/* High score sound */
#define YEAH_SAMPLE_LENGTH	(0x360C+0x80)
int yeah_smp_length = YEAH_SAMPLE_LENGTH;
int yeah_smp_rate = 0x82;
int yeah_sample[YEAH_SAMPLE_LENGTH / 2] = {
0x3242,0x4954,0x5945,0x4148,0x0000,0x002D,0x0000,0x0008,
0xFFFF,0x0000,0xFFFF,0xFF00,0x30E5,0x0000,0x360C,0x0000,
0x0000,0x0000,0x360C,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x5354,0x4552,0x454F,0x2052,0x4550,0x4C41,0x5900,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x00FF,0xFF00,0xFFFF,0xFF00,0xFFFF,0xFCFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFF00,0xFF00,0x0000,
0x0101,0x0101,0x0001,0x0101,0x0001,0x0106,0x0101,0x0100,
0x0600,0x0100,0x0001,0x00FF,0x0000,0xFF00,0x00FF,0x0000,
0x0000,0xFF00,0x0000,0x00FF,0x0000,0xFF00,0x00FF,0xFFFF,
0xFF00,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0x00FF,0xFFFF,0x00FF,0xFF00,0x0000,
0x0000,0x0100,0x0101,0x0101,0x0104,0x0404,0x0400,0x0900,
0x0904,0x0400,0xFC04,0x0000,0x0000,0x0400,0x0000,0x00FC,
0x0004,0x0000,0x0004,0x0400,0x0000,0x0000,0x0000,0x0000,
0x0000,0x00FC,0x0000,0x0000,0x0000,0xFCFC,0x0000,0xFCFC,
0xFC00,0xFCFC,0xFCFC,0xFC00,0x0000,0xFC00,0x0000,0x0000,
0x0004,0x0004,0x0400,0x0404,0x0400,0x0404,0x0400,0x0404,
0x0004,0x0400,0x00FC,0x0400,0xFC00,0x0400,0xFC04,0x00FC,
0x0000,0x00FC,0xFC00,0x00FC,0xFCFC,0xFC00,0xFCFC,0xFCF3,
0xF3FC,0xFCFC,0xF3FC,0xFCF3,0xFCF3,0xFCF3,0xFCFC,0xFCF3,
0xF3FC,0xFCFC,0xFCFC,0xFAFA,0xFA00,0xFAFA,0x0000,0x0006,
0x0606,0x0606,0x0606,0x0606,0x0606,0x060D,0x0606,0x0D06,
0x0D00,0x0D06,0x0000,0x0600,0xFA00,0x0606,0xFA00,0x06FA,
0xFA06,0x00FA,0xFA00,0x0600,0xFAFA,0xFA00,0xFAFA,0xFAFA,
0xFAFA,0xFAFA,0xF1FA,0xFAFA,0xFAFA,0xFAFA,0xFAFA,0xFAFA,
0xFA00,0xFAFA,0x0000,0x00FA,0x0000,0x0000,0x0606,0x0606,
0x060F,0x0606,0x0F06,0x0F0F,0x0F0F,0x0618,0x0F0F,0x0F06,
0x0F06,0x0606,0x0600,0x1806,0xFAFA,0x0F06,0xFA00,0x0FFA,
0xFA00,0x0600,0xFA06,0x0600,0xFAFA,0x0000,0xFAFA,0x00FA,
0xF1FA,0xFAFA,0xF1FA,0x00F1,0xF1F1,0xFAF1,0xF1FA,0xF1F1,
0xF1FA,0xFAF1,0xFAFA,0xFAFA,0xFAFA,0xF100,0x0000,0x0000,
0x0006,0x0606,0x0606,0x0606,0x0F06,0x0606,0x0F0F,0x0006,
0x0FFA,0x1800,0x0018,0x06FA,0xFA06,0x0F06,0xFA06,0x0FFA,
0x0006,0x00FA,0xFA0F,0x00FA,0xFA00,0x0600,0xFA00,0x00FA,
0xFA00,0x00F1,0xFA00,0xFAF1,0xFAFA,0xF1F1,0xFAFA,0xF1F1,
0xFAFA,0xF1FA,0xFAFA,0xFAFA,0x00FA,0x0000,0x0600,0x0006,
0x0606,0x0606,0x0F06,0x060F,0x0F06,0x0F06,0x2100,0x0F0F,
0x0606,0x000F,0x0F06,0xFA06,0x18FA,0xFA06,0x0FF1,0x000F,
0xFAFA,0xFA06,0x06FA,0xFA00,0x0600,0xFA06,0x00FA,0xFA00,
0x00F1,0xFA00,0xFAF1,0xFAFA,0xFAF1,0xFAFA,0xF1F1,0xFAFA,
0xF1F1,0xFAF1,0xF1FA,0xFAFA,0xFAFA,0x06FA,0xFA00,0x0006,
0x0006,0x0606,0x0F06,0x0F00,0x0F0F,0x060F,0x0618,0x0606,
0x0006,0x18FA,0xFA06,0x0F06,0xF106,0x06FA,0x0006,0x06FA,
0x0006,0x0600,0xFA06,0x0600,0xFA00,0x06FA,0xFA00,0x00F1,
0xF106,0xFAF1,0xFAFA,0xFAF1,0xF1FA,0xE8F1,0xF1FA,0xF1E8,
0xFAFA,0xF1FA,0xF1FA,0xFAFA,0x00FA,0xFA00,0x0600,0x0006,
0x060F,0x000F,0x0F06,0x0F18,0x0606,0x1806,0x0F00,0x0F21,
0x0000,0x0018,0x06F1,0x0006,0xFAFA,0x0600,0xFAFA,0x000F,
0xFAFA,0xFA06,0x06FA,0x0006,0xFAFA,0x0000,0xFAF1,0x0000,
0xF1F1,0xFAF1,0xFAF1,0xFAF1,0xE8FA,0xFAF1,0xF1F1,0xFAFA,
0xF1FA,0xFAF1,0xFA00,0xFA00,0xFA06,0x0000,0x0606,0x0606,
0x0F0F,0x000F,0x0F18,0x0F06,0x180F,0x0006,0x2106,0x0000,
0x0F0F,0xFAFA,0x1806,0xFA00,0x0600,0xFAFA,0x0F00,0xFAFA,
0xFA06,0xFAF1,0x0600,0xFAFA,0x0600,0xF1FA,0x06FA,0xF1FA,
0xFAFA,0xFAFA,0xFAF1,0xF1FA,0xF1FA,0xF100,0xFAFA,0xFAFA,
0xFAFA,0xFA00,0xFAFA,0x0000,0x0000,0x0006,0x0006,0x0F0F,
0x0606,0x0F06,0x0F06,0x0F00,0x0F21,0xFA00,0x0618,0x06FA,
0x0F06,0xFA06,0x0F06,0xFA00,0x0F06,0xFA00,0x0606,0x00FA,
0x0000,0xFA00,0xFA00,0xF1FA,0x06FA,0xFAF1,0x00F1,0xFAFA,
0xFAF1,0xF1FA,0xFAF1,0xF1FA,0xF1FA,0xFAFA,0xFAF1,0xFA00,
0xFAFA,0x0000,0x00FA,0x0606,0x0000,0x0F06,0x0F00,0x1806,
0x060F,0x0018,0x1800,0x000F,0x0F06,0xFA0F,0x0FFA,0x0618,
0x06FA,0xFA0F,0x0FFA,0x0000,0x0600,0xFA06,0x00F1,0x0006,
0x00F1,0xF106,0xFAF1,0xFAFA,0xFAF1,0xFAFA,0xE8F1,0xF1FA,
0xF1F1,0xFAFA,0xF1F1,0xFAFA,0xFAFA,0x00FA,0xFA00,0x06FA,
0x0000,0x0F00,0x0000,0x0F00,0x0F06,0x1800,0x0F28,0xFA00,
0x0F18,0x06FA,0x0F18,0x0006,0x0F18,0x0000,0x0F18,0x0000,
0x0606,0x0FFA,0x0606,0xFA00,0x0000,0xFAF1,0x0000,0xF1FA,
0xF1FA,0xF1F1,0xFAE8,0xF1F1,0xFAF1,0xE8FA,0xFAF1,0xF1FA,
0xFAF1,0xFAFA,0x00FA,0x0000,0x00FA,0x0000,0x0600,0x060F,
0x000F,0x06FA,0x0F21,0x0000,0x180F,0x0FFA,0x0F21,0xFA0F,
0x180F,0x00FA,0x2118,0x0006,0x0F0F,0x06FA,0x060F,0xFA00,
0x0606,0xFAF1,0x0000,0xE8F1,0xF1F1,0xF1F1,0xF1E8,0xDFF1,
0xF1E8,0xDFF1,0xF1F1,0xE8F1,0xF1F1,0xFA00,0xFAF1,0x0000,
0x00FA,0x000F,0x0006,0x1806,0x0F00,0x0021,0x18FA,0x0018,
0x1818,0xFA18,0x18F1,0x0F06,0x1800,0xFA18,0x1800,0x0000,
0x0F06,0xFA0F,0x06FA,0x0000,0x06F1,0xE8FA,0x00F1,0xFAF1,
0xF1F1,0xE8FA,0xE8E8,0xF1F1,0xF1E8,0xE8FA,0xF1E8,0xF1F1,
0xFAF1,0xFAFA,0xFA00,0x0000,0x06FA,0x0F06,0x060F,0x0600,
0x0F31,0x0006,0x180F,0x1800,0x2121,0x000F,0x2121,0x0606,
0x1821,0x0606,0x0F0F,0x0F00,0x0F21,0xFA06,0x0606,0x00F1,
0xFA06,0xE8FA,0xFAF1,0xF1F1,0xFAF1,0xE8F1,0xFAF1,0xF1F1,
0xFAE8,0xF1F1,0xF1FA,0xE800,0xFAFA,0xFAF1,0x0FFA,0x0600,
0x0606,0x0606,0x0F3A,0xFA00,0x210F,0x21F1,0x2128,0xFA0F,
0x2128,0x06FA,0x2128,0x0600,0x0F18,0x1800,0x0621,0xF100,
0x000F,0xFAE8,0x0006,0xE8F1,0xF1F1,0xE8E8,0xF1E8,0xD8E8,
0xE8F1,0xD8E8,0xE8F1,0xDFE8,0xF1F1,0xE8F1,0x00F1,0xF100,
0x0006,0xFA06,0xFAFA,0x0F28,0xFA00,0x0F0F,0x21FA,0x2118,
0xFA18,0x2128,0x0606,0x2128,0x0F18,0x0F0F,0x2100,0x1818,
0xF10F,0xFA18,0xFAE8,0x0000,0xF1F1,0xE8E8,0xE8E8,0xE8E8,
0xCFDF,0xE8E8,0xDFD8,0xE8E8,0xE8DF,0xE8E8,0xDFFA,0xE800,
0xF100,0x0006,0xFA00,0x0631,0xFAFA,0x2121,0x21FA,0x213A,
0x0606,0x2843,0x1806,0x2149,0x2106,0x2821,0x2800,0x0F3A,
0x0000,0xFA28,0x06E8,0xF10F,0xF1DF,0xF1F1,0xE8D8,0xE8F1,
0xCFCF,0xE8E8,0xD8CF,0xDFD8,0xDFCF,0xF1E8,0xD8E8,0xE8FA,
0xF1E8,0xDF00,0xFA31,0xFAF1,0x060F,0x21F1,0x1831,0x0606,
0x313A,0x1818,0x2152,0x3128,0x3121,0x4321,0x2143,0x0F06,
0x0F28,0x18FA,0xF10F,0xFAE8,0xF1F1,0xE8D8,0xDFE8,0xD8C6,
0xCFDF,0xD8C6,0xCFDF,0xCFCF,0xDFD8,0xD8D8,0xE8E8,0xDFCF,
0x0018,0xE8D8,0x0618,0x0FE8,0x0F43,0x0000,0x2143,0x2806,
0x215B,0x3121,0x2843,0x3A18,0x2164,0x210F,0x0F3A,0x28FA,
0xFA31,0x00F1,0xFAFA,0xFAD8,0xE800,0xE8C6,0xDFFA,0xD8C6,
0xD8D8,0xD8C6,0xE8D8,0xE8C6,0xF1BD,0xFA0F,0xC6C6,0xFA0F,
0x06CF,0x1828,0xF1FA,0x3149,0x21FA,0x316C,0x2131,0x2849,
0x4318,0x3A5B,0x1818,0x1849,0x3A00,0xFA43,0x00FA,0xF1FA,
0xFACF,0xF100,0xCFCF,0xCFF1,0xDFC6,0xCFDF,0xE8C6,0xE8DF,
0xB7AE,0x06E8,0xC6AE,0xFA18,0xE8CF,0x3106,0xE8F1,0x2143,
0x0FFA,0x3143,0x3A28,0x2152,0x3118,0x4349,0x3106,0x0649,
0x31E8,0x0018,0x00FA,0xE806,0xDFC6,0xFAFA,0xDFBD,0xCFE8,
0xF1BD,0xFAD8,0xE8DF,0xA5F1,0x31DF,0xA5C6,0x1821,0xB7D8,
0x4900,0xC600,0x5B49,0xE8FA,0x6464,0x2106,0x4364,0x210F,
0x6C49,0x0FE8,0x2852,0x06C6,0x060F,0xFAB7,0xDF00,0xBDAE,
0xE8F1,0xBD94,0xCFDF,0xCFA5,0xDFDF,0x9CFA,0xF1E8,0xA5C6,
0x2118,0xBD0F,0x21F1,0xE821,0x6449,0xFA21,0x5B49,0x6C3A,
0x3A5B,0x4349,0x523A,0x3A00,0x0F49,0x06E8,0xDFF1,0x00CF,
0xC6D8,0xB7B7,0xBDCF,0xB7A5,0xAED8,0xCFA5,0x9400,0x00B7,
0x8BCF,0x21DF,0xA500,0x3A00,0xD80F,0x6C43,0xF128,0x7575,
0x4921,0x757E,0x433A,0x5275,0x3A00,0x3152,0x18F1,0xE818,
0x06C6,0xDFF1,0xDFBD,0xC6E8,0xE8BD,0xCFCF,0xB7CF,0x00F1,
0xAE9C,0xF118,0xCFC6,0x0F18,0xD8DF,0x315B,0x18FA,0x435B,
0x6C31,0x2852,0x5B43,0x3A43,0x520F,0xF128,0x3A0F,0xD8DF,
0x1800,0xCFDF,0xF1DF,0xD8CF,0xFAF1,0xBD9C,0xDF21,0xFAA5,
0xB70F,0x0FBD,0xDF21,0x18CF,0xE83A,0x520F,0xE818,0x525B,
0x280F,0x3A3A,0x180F,0x3A3A,0xF1CF,0x0028,0x06BD,0xC600,
0xE8D8,0xCFDF,0xDFCF,0xBD00,0xA5AE,0x0606,0xCF94,0xD831,
0xE8A5,0xFA3A,0x00CF,0x0052,0x31E8,0x0631,0x5B49,0x0618,
0x3128,0x2106,0x3118,0xCFE8,0x0618,0xDFB7,0xDF0F,0xE8D8,
0xE8F1,0xFADF,0xC69C,0xFA21,0xFA94,0xBD21,0x21AE,0xC606,
0x28DF,0xCF31,0x5B06,0xDF00,0x3A75,0x2800,0x000F,0x4918,
0x06FA,0xE8E8,0x0000,0x0FD8,0xC6F1,0xF106,0xDFE8,0x06B7,
0x9C06,0x3A06,0x9CB7,0x2131,0xCFE8,0xFA28,0xDFE8,0x5264,
0x180F,0xFA3A,0x7E52,0x0F00,0x0652,0x2106,0x0000,0xF1F1,
0x0018,0x00E8,0xD800,0x1818,0x0FAE,0xAE06,0x3A00,0xAECF,
0x310F,0xBD00,0x2831,0xDFE8,0x3A5B,0x2128,0xF118,0x4943,
0x0FDF,0x0618,0x06D8,0xF100,0xE8C6,0xD80F,0xFAF1,0xD8DF,
0x1806,0xE8AE,0xF128,0x21C6,0xBD06,0x3AF1,0xD806,0x4318,
0xFA28,0x5243,0x3A21,0x0F43,0x4328,0xFAF1,0x1818,0xDFE8,
0xF1F1,0xE8CF,0xFAE8,0xF1DF,0xD80F,0xE8B7,0xAE00,0x21F1,
0x9CC6,0x0606,0xD8DF,0x1806,0xFAFA,0x283A,0x4921,0x0006,
0x4343,0x0FF1,0xFA18,0xFAF1,0x00FA,0xF1F1,0xFA0F,0xFAFA,
0xF100,0xC6B7,0x2121,0x06A5,0xBD0F,0x21E8,0x00FA,0x0F18,
0x003A,0x5B43,0x4906,0x0049,0x3118,0xF1D8,0x06DF,0xDFFA,
0xDFD8,0xD8E8,0xF1F1,0x00D8,0x00BD,0x9C00,0x1800,0x9CAE,
0x0628,0xD806,0x0006,0x0FF1,0x3164,0x2864,0x06F1,0x1828,
0x490F,0xFAFA,0xFAFA,0x3A18,0xFA00,0xFA0F,0xFA0F,0xFABD,
0x9CF1,0x2106,0x94A5,0x000F,0xBD06,0x3A21,0xFAFA,0x1852,
0x3A64,0x00D8,0x0000,0x1800,0xF1E8,0xBDDF,0x3128,0x0000,
0x0F0F,0x0F31,0x0FB7,0xBD28,0x3ADF,0x94CF,0x28F1,0xDFFA,
0x180F,0x1806,0x2828,0x753A,0xE8D8,0x0021,0x00CF,0xF1CF,
0xC606,0x28FA,0x18F1,0xE8F1,0x00B7,0xB721,0x0FD8,0x8BC6,
0x180F,0x06E8,0x000F,0x3118,0x3143,0x5221,0x00D8,0xF131,
0x18FA,0xD8DF,0xFA21,0x21F1,0xFAF1,0xFAF1,0x00D8,0x9CCF,
0x0F18,0xC6A5,0xFA43,0x18FA,0x1849,0x4906,0x215B,0x2849,
0x18E8,0xCFDF,0x3100,0xDFC6,0xD8E8,0x18FA,0x1806,0xFA28,
0x2800,0xAEB7,0x2831,0xDF8B,0xB70F,0x0FDF,0xF128,0x0600,
0x063A,0x316C,0x3ADF,0xBDFA,0x4928,0xD8B7,0xDFF1,0x213A,
0xFAF1,0xDFF1,0xAE9C,0x1818,0x068B,0x94CF,0x1831,0x18F1,
0x0006,0x1821,0x5B5B,0x31F1,0xB7DF,0x313A,0xF1B7,0xDF00,
0x3A28,0xDFDF,0xE8F1,0x8BC6,0xDF21,0xC68B,0xAEE8,0x3149,
0x0606,0x0F43,0x4952,0x6C28,0x3ADF,0xD821,0x4343,0xE8FA,
0x0F3A,0x3A0F,0x0600,0x18A5,0xA5E8,0x21FA,0xA59C,0xDF0F,
0x3A21,0x2121,0x2106,0x3164,0x0628,0xCFBD,0xE80F,0x28FA,
0xCFF1,0xF100,0x2100,0x06FA,0x0FDF,0xC6B7,0xFA43,0x21BD,
0xC618,0x5252,0x2128,0x3A28,0x3118,0x2849,0x00CF,0xAEDF,
0x2121,0xF1C6,0xE821,0x3118,0x0FE8,0xCFCF,0x80AE,0x0600,
0xAE80,0x9CE8,0x0F43,0x0F21,0x0621,0x2852,0x6C28,0xF1B7,
0xBD00,0x310F,0xCFF1,0x2821,0x21DF,0xE8CF,0xAE00,0xB7D8,
0xCFB7,0xBDD8,0x060F,0x2821,0x0F43,0x2864,0x5206,0x06D8,
0x0F21,0x21F1,0x0628,0x2821,0x00E8,0xDFD8,0xA5BD,0xC6E8,
0xD89C,0xBD00,0x3131,0xFA18,0x185B,0x213A,0x3106,0x06BD,
0xDF06,0x3A18,0xF121,0x3143,0x2806,0x0F06,0xB7A5,0xF1FA,
0x00A5,0xAEDF,0xFA43,0x5228,0x0F0F,0x1852,0x5B0F,0x06BD,
0xC6D8,0x000F,0x00C6,0xE8E8,0x0631,0x3100,0xE89C,0xC631,
0x31F1,0xA5BD,0xFA00,0x3A43,0x3121,0x0FFA,0x316C,0x4306,
0xC6C6,0xF121,0x31E8,0xDF21,0x280F,0xE8C6,0xDF82,0xCFD8,
0xCFB7,0x94BD,0xD80F,0x430F,0x3A21,0x213A,0x525B,0x28CF,
0xE8D8,0x0021,0x060F,0x2131,0x06DF,0xFACF,0xB718,0xCFCF,
0x94C6,0x0000,0x0F18,0x183A,0x2828,0x4364,0x2106,0xCFFA,
0x003A,0x0FF1,0x2128,0x3AF1,0xE8F1,0xCFAE,0xF1C6,0xE8BD,
0xAEDF,0x1849,0x0618,0x1849,0x3A49,0x4306,0xFACF,0xFAF1,
0x280F,0xDF00,0x183A,0x2118,0xF1E8,0x94E8,0x06E8,0xD894,
0xC600,0x183A,0xFA43,0x180F,0x3A49,0x3A06,0xCFF1,0xDF00,
0x28F1,0xE800,0x2106,0x060F,0xFAAE,0x94FA,0x06E8,0xA5AE,
0xE8FA,0x283A,0x0F28,0x3A0F,0x4343,0x52FA,0xCFF1,0xFA0F,
0x3A0F,0x1806,0x3AE8,0xD8F1,0x9CC6,0xE8D8,0xBD94,0xDF06,
0xDF0F,0x1828,0x0F28,0x2131,0x4906,0xC6F1,0xF118,0x0618,
0x433A,0x3106,0xD806,0xB7FA,0x00BD,0xCFAE,0xCF06,0x0043,
0x0021,0x2131,0x3A5B,0x310F,0xBDE8,0x0618,0x28F1,0xFA43,
0x3A06,0xC6F1,0xCFAE,0xFAB7,0xE8AE,0xB7F1,0xFA21,0x2821,
0x1818,0x4943,0x3121,0xD8D8,0x0FF1,0x0F00,0xFA3A,0x0FF1,
0xF1D8,0xFA9C,0xBDF1,0xD8BD,0xB7DF,0x00FA,0x3A18,0x0F28,
0x2843,0x3A06,0x28D8,0x0618,0xFA28,0x0021,0x0F18,0x180F,
0x00FA,0x94B7,0x000F,0xD89C,0xBDFA,0x063A,0x2106,0x1828,
0x0F18,0x3128,0xD8D8,0x00F1,0x183A,0x28F1,0x0006,0x06F1,
0x9CAE,0x00F1,0xD89C,0xCF18,0x2131,0x0F18,0x3131,0x3118,
0x280F,0xBDE8,0x1800,0x0006,0x430F,0x28FA,0xF1B7,0xA506,
0x06C6,0xBDA5,0xE806,0x4352,0x1828,0x0031,0x4343,0x3ACF,
0xC600,0x0621,0x2131,0x3121,0xFAF1,0xDFAE,0xE800,0xAEC6,
0xA5CF,0x0606,0x4900,0x2121,0x315B,0x3131,0xFABD,0xFA06,
0x0F18,0xFA49,0x310F,0xF1DF,0xFAAE,0x00D8,0xBDC6,0xBDF1,
0xE821,0x3A0F,0x2818,0x4949,0x0031,0xCFDF,0x0F06,0xFA18,
0x2128,0xFA18,0x1800,0xDFBD,0x94DF,0x000F,0xD8B7,0xF121,
0x3152,0x2821,0x2118,0x28F1,0x21D8,0xD8E8,0xE800,0x2131,
0x0F00,0xFA21,0xFAF1,0x8BB7,0xFAFA,0xCFB7,0xE831,0x0F31,
0x2818,0x493A,0x0F00,0x0F00,0xBDC6,0x000F,0x0028,0x3A0F,
0xDFD8,0xD88B,0xE818,0xBD9C,0xA500,0x2121,0x4318,0x0F21,
0x4943,0x2818,0xDFBD,0xDF31,0x1800,0x2831,0x06CF,0xD8D8,
0xA506,0xD8B7,0x9CB7,0x00FA,0x2843,0x3121,0x185B,0x5218,
0x0FD8,0xDF06,0x0600,0x0F49,0x490F,0xD8F1,0xE8A5,0xE8D8,
0xB7A5,0xBDD8,0x0621,0x5218,0x0021,0x6C64,0x2106,0xDFDF,
0xFA21,0xF1FA,0x1831,0x0F00,0x0643,0xE8AE,0xCFFA,0xE8DF,
0xBDC6,0xF10F,0x490F,0x0F3A,0x5B28,0xFA06,0x00F1,0xE8FA,
0xF1E8,0x3131,0x00E8,0x2106,0xD894,0xCF21,0xFABD,0xAECF,
0x0621,0x4306,0xF121,0x3128,0x0018,0xF1CF,0xC618,0x1800,
0x0F0F,0x0FE8,0x00E8,0x94D8,0x28E8,0xA5AE,0xDF18,0x0F49,
0x3A0F,0x1852,0x490F,0x0006,0xBDBD,0x0018,0xFA21,0x2818,
0xCFD8,0xE8A5,0x00F1,0xCFAE,0xB7F1,0x2121,0x4321,0x2100,
0x4964,0x2818,0xD8D8,0xF121,0x0618,0x3143,0x0FE8,0xFAF1,
0xB7F1,0xD8BD,0xBDC6,0xFA0F,0x1864,0x3118,0x3A52,0x6418,
0x0FE8,0xDFDF,0x180F,0xFA00,0x3131,0xFADF,0x0FC6,0xA5FA,
0xCFC6,0xB7C6,0xF1FA,0x2831,0x210F,0x3A75,0x3A06,0x00E8,
0xDF0F,0x1806,0xFA21,0x21E8,0xFA0F,0x28C6,0x9CE8,0x00DF,
0xF1CF,0xC6F1,0x315B,0x280F,0x3152,0x18FA,0x0606,0xF1DF,
0xFA0F,0xFA31,0x06F1,0xF1F1,0x0FAE,0x94E8,0x0FE8,0xC6AE,
0x000F,0x435B,0x1800,0x433A,0x28FA,0xE818,0xD8C6,0x0621,
0x210F,0x0FFA,0xE8D8,0xC6A5,0x0FF1,0xBDB7,0xC6FA,0x283A,
0x4306,0x0649,0x6C43,0x00FA,0x06C6,0xDF21,0x2821,0x1831,
0xFADF,0xE8C6,0xC606,0xC6C6,0xAEC6,0xFA18,0x5221,0x2128,
0x1864,0x4318,0xFAD8,0xCFFA,0x0F18,0x0F3A,0x1800,0xDFFA,
0xD8A5,0xFAD8,0xBDA5,0xC6DF,0x0F18,0x4931,0x0F31,0x7564,
0x0FFA,0xE8F1,0xE800,0x18FA,0xFA21,0x28FA,0xFA00,0xCF94,
0xCFF1,0xDFCF,0xBDCF,0xF106,0x433A,0x2821,0x5249,0x0F21,
0x0000,0xDF00,0x0FFA,0x0621,0x00F1,0xFA0F,0xDF94,0xD8FA,
0xDFCF,0xCFC6,0x0618,0x5228,0x0021,0x3A21,0x1800,0xFAFA,
0xC6FA,0x1800,0x0631,0xFAE8,0xDFD8,0x8BCF,0x00CF,0x9CA5,
0xD806,0x0F49,0x2106,0x1843,0x5B18,0xFA00,0xF1BD,0xF131,
0x2121,0x3121,0xDFE8,0xF1B7,0xDFFA,0xC6AE,0xB7C6,0x1818,
0x4921,0x0618,0x495B,0x3A0F,0x00E8,0xCF0F,0x2821,0x0631,
0x28FA,0xDF00,0xCFB7,0x00CF,0xB7AE,0xC6FA,0x2131,0x2828,
0x2831,0x6C49,0x06FA,0xE8D8,0xFA28,0x2100,0x283A,0x0FFA,
0x0F00,0xAED8,0xDFCF,0xB7BD,0xCFFA,0x003A,0x2121,0x2849,
0x6421,0x0000,0xFADF,0x0018,0x0600,0x2118,0xFA06,0x06E8,
0xAEC6,0x0FCF,0xCFCF,0xD800,0x063A,0x310F,0x2143,0x5228,
0xFA0F,0xE8D8,0xF121,0x0FFA,0x2106,0x00FA,0xFADF,0x94D8,
0xFAC6,0xC6C6,0xD80F,0x0F52,0x3A18,0x283A,0x4318,0x0600,
0x00CF,0x0021,0x060F,0x2800,0xF1DF,0xD89C,0xCF00,0xC69C,
0xAEBD,0x060F,0x4328,0x0F18,0x435B,0x3A00,0xF1FA,0xD8FA,
0x2121,0x0F31,0x3106,0xF1FA,0xCFC6,0xF1CF,0xAEB7,0xB7E8,
0x1818,0x2828,0x1828,0x5B52,0x18F1,0xE8D8,0xE806,0x0F00,
0x2128,0x06E8,0xF1E8,0xBDDF,0xD8C6,0xB7C6,0xDFFA,0x0F43,
0x1828,0x2849,0x643A,0x00F1,0xF1E8,0x0618,0x0FFA,0x2131,
0x0606,0x00D8,0xC6BD,0xF1D8,0xB7C6,0xCF06,0x0043,0x3121,
0x2849,0x5249,0x0000,0x00E8,0xE821,0x060F,0x0F0F,0xFA06,
0x06DF,0xA5CF,0xE8D8,0xC6BD,0xD800,0xFA43,0x280F,0x1831,
0x4321,0xFA00,0x00D8,0xFA28,0x0F06,0x2128,0x06DF,0xE8AE,
0xC60F,0xCFAE,0xB7CF,0x1806,0x3A31,0x0F31,0x2152,0x4900,
0xF100,0xC6D8,0x1821,0x0018,0x210F,0xF1E8,0xD8BD,0xFACF,
0xB7B7,0xCFE8,0x0618,0x2821,0x1821,0x6C52,0x310F,0xF1F1,
0xDF00,0x2806,0x2131,0x0FE8,0xDFFA,0xAEF1,0xD8CF,0xAEC6,
0xCF06,0x1831,0x2821,0x1828,0x4949,0x00DF,0xE8DF,0xFA21,
0x0F0F,0x2131,0x0F00,0xFADF,0xB7E8,0xCFBD,0xBDC6,0xDF00,
0x0F28,0x2828,0x283A,0x4928,0x06FA,0xF1DF,0xF118,0x1806,
0x2121,0x1800,0x000F,0xCFFA,0xDFF1,0xDFD8,0xF121,0x0F49,
0x3A28,0x2831,0x4321,0x00F1,0xFACF,0xF121,0x0F00,0x180F,
0x00F1,0xF1AE,0x9CE8,0xBDBD,0xAEB7,0xE806,0x2143,0x2818,
0x1843,0x5218,0x00DF,0xF1C6,0xFA18,0x0600,0x280F,0x06E8,
0xF1A5,0xBDDF,0xBD9C,0xAEBD,0x06FA,0x2831,0x2821,0x3152,
0x5218,0xF1FA,0xE8E8,0x180F,0x0021,0x3128,0xF1E8,0xE8AE,
0x00C6,0xB7BD,0xB7DF,0x0F0F,0x3121,0x2118,0x435B,0x3100,
0xF1E8,0xD800,0x0F18,0x0621,0x210F,0x0006,0xC6B7,0xFAC6,
0xB7BD,0xAEFA,0x0018,0x2831,0x2821,0x5B5B,0x1800,0xE8E8,
0xDFFA,0x0F06,0x0F18,0x310F,0xF1FA,0xDFB7,0xFABD,0xCFC6,
0xC6F1,0x0F0F,0x283A,0x2828,0x5B49,0x3106,0xFAFA,0xD800,
0x0618,0x0F21,0x2800,0x0606,0xCFAE,0xE8C6,0xC6C6,0xCFFA,
0x0F06,0x4928,0x1828,0x3A52,0x21F1,0x00F1,0xCFE8,0x1806,
0x0621,0x210F,0x00F1,0xB7B7,0x00E8,0xC6B7,0xBD00,0x0031,
0x4331,0x1818,0x5B5B,0x1800,0xF1DF,0xCF00,0x1806,0x0F31,
0x3106,0xF1F1,0xAEDF,0xFADF,0xAEAE,0xD80F,0x0031,0x3121,
0x1821,0x6449,0x06FA,0xE8C6,0xD8FA,0x1800,0x1831,0x2100,
0xF1FA,0xB7D8,0xF1D8,0xAEB7,0xCF06,0x003A,0x3128,0x1821,
0x6C49,0x18FA,0xE8C6,0xD8FA,0x06FA,0x0621,0x31FA,0xFA00,
0xBDCF,0xFAD8,0xC6B7,0xC606,0xFA3A,0x3131,0x280F,0x5B49,
0x0F00,0xF1CF,0xD8FA,0x0000,0x0618,0x31FA,0x06F1,0xC6AE,
0xF1D8,0xBDBD,0xCFF1,0xFA0F,0x4331,0x2121,0x4949,0x31FA,
0xF1E8,0xCFDF,0xFA00,0x0F21,0x3106,0x00F1,0xE8AE,0xF1F1,
0xCFBD,0xBDDF,0x000F,0x4931,0x2818,0x3A64,0x4306,0xFAF1,
0xC6D8,0x000F,0x0621,0x1831,0x00F1,0xF1BD,0xDF00,0xC6C6,
0xBDCF,0x0F06,0x433A,0x2821,0x2864,0x520F,0x00F1,0xC6D8,
0x0018,0x0621,0x2131,0x06FA,0xFABD,0xD800,0xC6BD,0xC6B7,
0x0606,0x3A31,0x3A21,0x1864,0x4918,0x06DF,0xC6CF,0xFA06,
0x0F00,0x2128,0x0FE8,0xFAD8,0xBDFA,0xC6C6,0xBDAE,0xF106,
0x1831,0x2821,0x0F43,0x5B31,0x00E8,0xCFCF,0xF100,0x1800,
0x0F18,0x2800,0x00E8,0xBDD8,0xF1D8,0xBDBD,0xD806,0x0F43,
0x3A3A,0x1821,0x6443,0x06F1,0xCFCF,0xDFFA,0x0000,0x1818,
0x3A06,0xFAE8,0xD8BD,0xFAD8,0xB7CF,0xBDE8,0x0028,0x493A,
0x180F,0x4949,0x1800,0xDFCF,0xCFE8,0xFA0F,0x0021,0x3121,
0xFAE8,0xF1B7,0xF1D8,0xC6C6,0xB7CF,0x000F,0x4331,0x1818,
0x2852,0x4306,0xFADF,0xD8DF,0xF10F,0x0F21,0x283A,0x0FFA,
0xE8C6,0xD806,0xD8C6,0xC6C6,0x0006,0x3A3A,0x2821,0x0F49,
0x4918,0x00DF,0xCFD8,0xF106,0x2106,0x2828,0x28FA,0xE8E8,
0xBD00,0xD8C6,0xC6B7,0xDF06,0x1843,0x3A28,0x0F28,0x493A,
0x0FF1,0xCFC6,0xDFFA,0x0000,0x0F21,0x2800,0xF1F1,0xCFCF,
0xF1CF,0xCFC6,0xC6FA,0x063A,0x313A,0x1806,0x5249,0x2106,
0xDFC6,0xDF00,0x0618,0x0018,0x2128,0xFAFA,0xDFAE,0x00DF,
0xCFC6,0xBDDF,0x000F,0x3121,0x2100,0x1849,0x3100,0xFACF,
0xD8F1,0xFAFA,0x0606,0x2143,0x1800,0xDFE8,0xC618,0xE8D8,
0xBDBD,0xF10F,0x1828,0x2828,0x0631,0x5228,0x00FA,0xD8DF,
0xF100,0x0F06,0x0628,0x3A0F,0xFAF1,0xCFCF,0x06F1,0xC6BD,
0xCFFA,0x0021,0x2828,0x1806,0x4352,0x1806,0xFAC6,0xD8FA,
0x0606,0x060F,0x2828,0x06DF,0xE8BD,0xD8FA,0xD8BD,0xC6C6,
0xFAFA,0x2828,0x2118,0x0649,0x4321,0x06E8,0xCFDF,0xFA06,
0x0F06,0x1828,0x3100,0xF1F1,0xBD00,0xDFD8,0xC6C6,0xCFF1,
0x0031,0x2128,0x060F,0x523A,0x1818,0xDFCF,0xE8FA,0x060F,
0x0028,0x3128,0x00F1,0xFABD,0x00E8,0xD8BD,0xC6CF,0xFA00,
0x3118,0x1806,0x0F49,0x3A0F,0x06D8,0xCFE8,0x0006,0x0006,
0x1831,0x3A00,0x00E8,0xBD00,0xDFDF,0xC6C6,0xC6F1,0x0F31,
0x2821,0x060F,0x5231,0x1818,0xD8CF,0xF1F1,0x0F06,0x000F,
0x3A31,0x0FF1,0xFAB7,0x06DF,0xDFBD,0xBDCF,0xFA00,0x3128,
0x310F,0x0652,0x3A21,0x18F1,0xCFE8,0x000F,0x0006,0x0631,
0x3A0F,0x00E8,0xBDDF,0x00E8,0xBDB7,0xBDF1,0xFA31,0x3118,
0x0600,0x4949,0x2818,0xF1CF,0xDFFA,0x0606,0xFA06,0x2143,
0x2100,0xF1C6,0xC60F,0xDFBD,0xB7AE,0xCFFA,0x2128,0x1818,
0x0031,0x5228,0x210F,0xD8D8,0xF1FA,0x0006,0x0028,0x3A3A,
0x06F1,0xFABD,0x06DF,0xD8BD,0xBDC6,0xFA00,0x2118,0x210F,
0x0F52,0x4328,0x18FA,0xCFDF,0xFA0F,0x0600,0x0628,0x2806,
0xFA00,0xC6CF,0xF1F1,0xBDC6,0xB7E8,0xDF18,0x2121,0x0F00,
0x315B,0x3121,0x00D8,0xD8E8,0x0600,0x06FA,0x2128,0x3100,
0xF1E8,0xAEF1,0xE8D8,0xC6B7,0xBDF1,0xFA3A,0x2818,0x060F,
0x5243,0x2118,0xF1CF,0xE800,0x0600,0xFA06,0x2843,0x18FA,
0xDFC6,0xD80F,0xE8BD,0xAEAE,0xDFFA,0x2128,0x2118,0x0F31,
0x643A,0x280F,0xD8D8,0xF106,0x0000,0xFA21,0x3131,0x0000,
0xE8C6,0x00E8,0xD8BD,0xAEBD,0xF100,0x2821,0x1806,0x0F5B,
0x4931,0x21F1,0xCFE8,0x0000,0x00E8,0x0028,0x3128,0x06E8,
0xD8CF,0x06F1,0xC6BD,0xB7D8,0xE818,0x2818,0x180F,0x315B,
0x4331,0x06DF,0xD8F1,0x06FA,0xFAFA,0x063A,0x3A06,0x00E8,
0xB7D8,0xF1E8,0xBDB7,0xAEE8,0xFA21,0x3A21,0x0F06,0x4964,
0x3A21,0x00D8,0xDFF1,0x0000,0xE8FA,0x183A,0x3100,0xFAE8,
0xBDF1,0xE8D8,0xBDAE,0xAEE8,0xF131,0x3118,0x1818,0x4964,
0x3A28,0x00D8,0xE8E8,0x0006,0xF106,0x1843,0x2800,0x00DF,
0xB7FA,0xDFD8,0xAEA5,0xB7F1,0xF128,0x2821,0x0F18,0x6449,
0x280F,0xF1D8,0xE8F1,0x00FA,0xFA00,0x2143,0x1806,0x00D8,
0xAE00,0xDFCF,0xB7AE,0xBDF1,0x0028,0x2828,0x1828,0x5243,
0x2821,0xF1CF,0xDFFA,0x00F1,0xF100,0x2143,0x2106,0x00D8,
0xBD00,0xF1D8,0xBDB7,0xBDFA,0xFA31,0x3A28,0x0F21,0x5264,
0x3A18,0xFAD8,0xDFFA,0xFAFA,0xF1F1,0x0F3A,0x2106,0x00DF,
0xB7DF,0x00E8,0xBDAE,0xA5E8,0xFA28,0x2821,0x0F18,0x4364,
0x3A28,0x00D8,0xDFF1,0x00FA,0xE8DF,0x0F3A,0x310F,0x00F1,
0xBDCF,0x18E8,0xBDB7,0xAEDF,0xFA21,0x3118,0x1818,0x495B,
0x4328,0x00DF,0xE8F1,0xF1F1,0xE8DF,0x0631,0x4918,0x06FA,
0xD8BD,0x06F1,0xDFAE,0xA5CF,0x0000,0x3121,0x180F,0x3152,
0x4328,0x18F1,0xCFDF,0xE8FA,0xF1F1,0xF121,0x4331,0x0006,
0xF1C6,0xDF00,0xE8C6,0xAEB7,0xFAFA,0x2828,0x1818,0x1849,
0x4928,0x18FA,0xD8D8,0xE8FA,0xF1F1,0xE80F,0x3149,0x180F,
0xFAD8,0xCF18,0xFACF,0xB7AE,0xF1FA,0x1828,0x1818,0x183A,
0x493A,0x2106,0xE8DF,0xDFF1,0xFAE8,0xE8FA,0x183A,0x280F,
0x06E8,0xC6E8,0x00F1,0xC6B7,0xC6F1,0xFA21,0x210F,0x1821,
0x433A,0x2818,0xFAE8,0xF1F1,0xFAF1,0xF1FA,0x0F28,0x280F,
0x0600,0xDFCF,0x00E8,0xDFC6,0xBDD8,0xFA00,0x2818,0x180F,
0x283A,0x3121,0x0FF1,0xF1F1,0xF1FA,0xFAFA,0xFA21,0x3121,
0x0F0F,0xE8CF,0xDF00,0xF1CF,0xB7BD,0xF1FA,0x2121,0x180F,
0x183A,0x313A,0x2800,0xE8E8,0xF100,0xFAF1,0xFA00,0x213A,
0x2106,0x00E8,0xBDDF,0x00F1,0xC6B7,0xBDFA,0xFA21,0x210F,
0x0F18,0x4943,0x2818,0x06E8,0xE8F1,0xFAFA,0xE8E8,0x0031,
0x3118,0x06FA,0xDFBD,0xF1E8,0xF1B7,0xAEBD,0xFAF1,0x1821,
0x060F,0x2843,0x4331,0x0F00,0xF1E8,0xF106,0x00E8,0xE818,
0x3A31,0x180F,0xFADF,0xB700,0xE8DF,0xB7AE,0xC6FA,0x0028,
0x1800,0x0F43,0x4931,0x4318,0x00E8,0xE8F1,0x06F1,0xDFE8,
0x0F31,0x3118,0x06F1,0xDFB7,0xFADF,0xDFB7,0xB7CF,0xFAFA,
0x2828,0x0F06,0x3A5B,0x4331,0x1800,0xF1F1,0xFA00,0xFAD8,
0xFA31,0x3A3A,0x0F06,0xE8CF,0xBD06,0xE8D8,0xA5A5,0xD8FA,
0x1821,0x1800,0x1849,0x493A,0x2806,0xFAF1,0xF1FA,0xFAE8,
0xE800,0x2831,0x3100,0x06E8,0xD8BD,0xFADF,0xC6AE,0xAED8,
0x0006,0x2818,0x0F0F,0x4349,0x3A21,0x06F1,0xF1FA,0xFA00,
0xF1E8,0xF128,0x3128,0x0F06,0xF1CF,0xBD06,0xF1DF,0xB7B7,
0xDF00,0x0F21,0x2106,0x1849,0x433A,0x310F,0x00F1,0xE8F1,
0xFAE8,0xDFE8,0x2131,0x1806,0xFAFA,0xCFBD,0x00DF,0xE8B7,
0xB7D8,0xF106,0x1821,0x0618,0x4943,0x3143,0x0F00,0xF1E8,
0xF1FA,0xE8DF,0xF118,0x2821,0x060F,0xF1E8,0xB7FA,0xFAF1,
0xB7AE,0xC6FA,0x0028,0x280F,0x1831,0x493A,0x3A21,0xFAE8,
0xE8E8,0xFAE8,0xDFF1,0x0621,0x3106,0x1800,0xE8B7,0xCF00,
0xF1B7,0xA5BD,0xF1FA,0x2128,0x0006,0x315B,0x4331,0x1806,
0xF1DF,0xE8FA,0xE8DF,0xF106,0x283A,0x1818,0x00FA,0xCFC6,
0x06F1,0xC6B7,0xB7E8,0x0021,0x3118,0x0F21,0x5243,0x3A21,
0x06F1,0xE8E8,0x00FA,0xF1E8,0x0028,0x3A28,0x1806,0xE8DF,
0xC618,0xFAD8,0xAEB7,0xDF00,0x2128,0x0F06,0x0649,0x4321,
0x2800,0xFAF1,0xE800,0xFADF,0xE8F1,0x2131,0x2806,0x0006,
0xE8BD,0xF1FA,0xF1C6,0xBDD8,0xFA00,0x2121,0x0006,0x2849,
0x313A,0x210F,0xFAF1,0xE8FA,0xF1DF,0xE800,0x2831,0x0600,
0x06FA,0xD8C6,0x1800,0xC6B7,0xB7E8,0xFA06,0x1806,0xFA0F,
0x5249,0x2831,0x0F06,0xF1F1,0xFAFA,0xDFD8,0xF118,0x2128,
0x0F00,0x18E8,0xCFE8,0x06FA,0xBDAE,0xC6F1,0xF118,0x2806,
0x0631,0x643A,0x3128,0x0F00,0xF1F1,0x06DF,0xDFF1,0xF121,
0x2128,0x0606,0x00DF,0xBD00,0xFACF,0xAEA5,0xD8FA,0x0F21,
0x0F06,0x0F52,0x4931,0x3A18,0x06FA,0xDFF1,0xFAE8,0xDFF1,
0x0F28,0x3118,0x0F06,0xFACF,0xCF06,0xF1BD,0xAEB7,0xF1FA,
0x2121,0x0606,0x3164,0x4328,0x310F,0xFAE8,0xDFFA,0xE8D8,
0xE8E8,0x2121,0x2806,0x0606,0xF1BD,0xF1E8,0xF1B7,0xAEBD,
0xFAFA,0x1821,0x0006,0x4352,0x3A28,0x1800,0xF1E8,0xF1F1,
0xDFD8,0xDF06,0x2828,0x1806,0x0600,0xE8C6,0x0FF1,0xD8B7,
0xBDDF,0x000F,0x2118,0x0621,0x6443,0x2128,0x1806,0xF1DF,
0xF1E8,0xD8DF,0xFA06,0x0F3A,0x0F0F,0x0F00,0xD8C6,0x0FFA,
0xD8AE,0xB7DF,0xFA0F,0x280F,0x0621,0x5B43,0x2128,0x06FA,
0xE8D8,0xFADF,0xCFDF,0xF118,0x213A,0x210F,0x2106,0xDFCF,
0x06E8,0xD8B7,0xAEDF,0xFA0F,0x210F,0x0621,0x6443,0x2831,
0x18FA,0xE8D8,0xFAE8,0xCFDF,0xF118,0x283A,0x2118,0x0606,
0xDFC6,0x00E8,0xD8AE,0xAED8,0xFA0F,0x1806,0x0628,0x523A,
0x1828,0x0F00,0x00D8,0xFAF1,0xD8DF,0xF121,0x2843,0x180F,
0x0F18,0xDFC6,0xFADF,0xE8B7,0xAECF,0xFA06,0x0F06,0xFA0F,
0x4949,0x2131,0x1800,0xFADF,0x06FA,0xDFD8,0xF10F,0x3A3A,
0x3106,0x0606,0xFAC6,0xD8F1,0xE8B7,0xAEBD,0xF1FA,0x1818,
0xFA06,0x435B,0x3121,0x310F,0xFAE8,0xE800,0xE8DF,0xF1FA,
0x1843,0x2818,0x000F,0x06D8,0xC6F1,0xFAC6,0xAEB7,0xE8F1,
0x1818,0x0F00,0x3175,0x4928,0x3118,0x06FA,0xE800,0xFAD8,
0xE8E8,0x2131,0x3121,0x000F,0x18FA,0xC6E8,0xDFE8,0xBDB7,
0xC6FA,0xFA0F,0x1800,0x2149,0x5B28,0x2128,0x0FFA,0xE8F1,
0xFADF,0xD8DF,0xF10F,0x2821,0x0600,0x0F06,0xDFBD,0xFAFA,
0xC6AE,0xB7D8,0xF10F,0x1806,0x003A,0x6443,0x2131,0x2106,
0xE8D8,0x00E8,0xD8DF,0xDF06,0x2831,0x210F,0x0F18,0xFAC6,
0xD8E8,0xFAB7,0xAEB7,0xF1FA,0x1821,0x0006,0x4364,0x3121,
0x2806,0xF1DF,0xE8FA,0xDFD8,0xE8F1,0x2143,0x3128,0x0021,
0x00F1,0xB7D8,0xE8E8,0xB7AE,0xCF00,0x0F18,0x18FA,0x2143,
0x4921,0x2128,0x00F1,0xF1FA,0x06E8,0xE8F1,0xFA21,0x3A28,
0x06FA,0x2106,0xE8B7,0xF1E8,0xDFBD,0xBDD8,0xFA06,0x0606,
0xF118,0x493A,0x1828,0x280F,0xFAE8,0x06FA,0xE8DF,0xF1FA,
0x0F28,0x1806,0x0F21,0x06D8,0xBD00,0x00D8,0xBDAE,0xCFF1,
0x060F,0x00FA,0x285B,0x3A28,0x3A28,0x0FFA,0xE800,0xFADF,
0xDFDF,0xFA0F,0x2821,0x060F,0x21FA,0xCFC6,0x0F06,0xC6A5,
0xAED8,0xF10F,0x18FA,0xFA31,0x643A,0x283A,0x2100,0xF1E8,
0x06F1,0xDFCF,0xDFFA,0x2128,0x1800,0x0F28,0x06D8,0xC606,
0x00C6,0xAEAE,0xDFF1,0x0F21,0xFA00,0x3164,0x3A28,0x3A28,
0x00FA,0xDF00,0xF1CF,0xCFDF,0xFA28,0x180F,0x0021,0x2818,
0xDFBD,0x0600,0xCFAE,0xA5CF,0xFA0F,0x1806,0x003A,0x6449,
0x283A,0x3100,0xFADF,0xFAF1,0xDFCF,0xDFFA,0x2821,0x2806,
0x1821,0x18F1,0xBD00,0xF1D8,0xB7AE,0xCFFA,0x0618,0x0F06,
0x285B,0x4921,0x3131,0x06FA,0xD8FA,0xFAD8,0xDFE8,0x0021,
0x2821,0x060F,0x310F,0xE8AE,0x00FA,0xD8AE,0xAECF,0x0006,
0x180F,0x0018,0x5249,0x2128,0x3100,0xF1E8,0x00FA,0xD8DF,
0xE8FA,0x1828,0x2806,0x0621,0x18F1,0xB7DF,0xFA00,0xBDB7,
0xB7FA,0xFA0F,0x21FA,0x0643,0x5221,0x2131,0x18F1,0xF1F1,
0x06DF,0xDFE8,0xE8FA,0x2131,0x0FFA,0x1828,0x06CF,0xB706,
0xFACF,0xA5A5,0xC6E8,0x0F21,0x00F1,0x2152,0x3121,0x3A31,
0xFAE8,0xDF0F,0xF1CF,0xD8DF,0xE818,0x2821,0x0600,0x3121,
0x00BD,0xDFF1,0xF1BD,0xB7B7,0xFAFA,0x0F18,0xFA0F,0x4952,
0x2828,0x4321,0x00F1,0x0006,0xDFDF,0xE8E8,0x0628,0x280F,
0xFA18,0x310F,0xCFBD,0x06FA,0xDFB7,0xB7CF,0xF10F,0x2100,
0xF121,0x5231,0x213A,0x3106,0x00FA,0x06FA,0xD8DF,0xDFF1,
0x0F28,0x1800,0x063A,0x310F,0xC6CF,0x0F06,0xD8B7,0xA5DF,
0xF106,0x2800,0xFA31,0x5B43,0x3A43,0x3A00,0xF1E8,0x00F1,
0xD8CF,0xD8F1,0x0F28,0x1806,0x0631,0x210F,0xBDBD,0x0000,
0xC6A5,0xA5D8,0xF10F,0x2106,0x0631,0x523A,0x313A,0x2100,
0xE8DF,0x00F1,0xCFCF,0xD8F1,0x0F21,0x210F,0x0F31,0x210F,
0xCFBD,0x0000,0xCFAE,0xAEDF,0xF100,0x2806,0x0031,0x523A,
0x3131,0x2800,0xFAE8,0xFAE8,0xCFD8,0xDFE8,0x0628,0x2818,
0x1831,0x2118,0xE8BD,0xE8DF,0xE8BD,0xAEB7,0xFAFA,0x1818,
0x0021,0x4343,0x2831,0x3A18,0xF1F1,0xFAF1,0xDFDF,0xDFE8,
0x000F,0x3118,0x1828,0x2821,0x00D8,0xC6FA,0xFADF,0xB7A5,
0xD8F1,0x0F18,0x0600,0x2149,0x433A,0x3128,0x06FA,0xF106,
0xFAD8,0xCFD8,0xF100,0x2121,0x0F21,0x2128,0x18FA,0xCFBD,
0xFAF1,0xCFA5,0xA5CF,0xF10F,0x210F,0x0621,0x5249,0x3A3A,
0x2806,0xFAFA,0x06FA,0xD8CF,0xE8F1,0x0618,0x2118,0x2131,
0x310F,0xE8CF,0xBDF1,0xF1D8,0xB7AE,0xC6FA,0x0F0F,0x06FA,
0x0F43,0x4931,0x3128,0x0600,0x000F,0x00DF,0xD8E8,0xF106,
0x0F18,0x0006,0x2128,0x21FA,0xDFBD,0xCFFA,0xF1B7,0xAEB7,
0xE8F1,0x0006,0xFAFA,0x2852,0x433A,0x3128,0x0F06,0x180F,
0xE8D8,0xDFE8,0xFA00,0x0600,0x0618,0x3121,0x00DF,0xCFCF,
0x06FA,0xC6A5,0xAED8,0xF10F,0x0600,0xFA18,0x5B52,0x4343,
0x280F,0x0F18,0x18F1,0xD8CF,0xD8E8,0xFAFA,0xFAF1,0x0621,
0x2106,0xFAE8,0xCFE8,0xF1F1,0xBDAE,0xC6F1,0xFA06,0x0F00,
0x0F3A,0x5B49,0x433A,0x310F,0x060F,0x06DF,0xCFD8,0xDFE8,
0xF1FA,0xFA00,0x1831,0x210F,0xF1DF,0xD806,0x00CF,0xAEB7,
0xD8FA,0x0F0F,0x0600,0x285B,0x4943,0x3A28,0x0600,0x0006,
0xE8CF,0xC6CF,0xDFF1,0xFA06,0x0018,0x2828,0x2100,0xF1CF,
0xDF00,0x00C6,0xAEB7,0xF100,0x1818,0x0000,0x3164,0x433A,
0x2821,0x0600,0x0000,0xDFBD,0xC6D8,0xE800,0x0000,0x0021,
0x3A31,0x2100,0xE8C6,0xDF06,0xFAC6,0xA5AE,0xE800,0x180F,
0xFAFA,0x315B,0x433A,0x310F,0x00FA,0x0600,0xDFCF,0xCFDF,
0xE800,0x0600,0x0028,0x3131,0x2106,0xF1D8,0xFA06,0xFAC6,
0xAEB7,0xF100,0x0606,0xFA00,0x3152,0x4343,0x3A18,0x0000,
0x0F00,0xDFC6,0xC6D8,0xF100,0x00FA,0x0028,0x3A31,0x280F,
0xF1DF,0xDF06,0xFABD,0xA5A5,0xD8F1,0x0F0F,0xFAF1,0x2152,
0x4343,0x3121,0x0000,0x0F06,0xDFCF,0xD8DF,0xE800,0x0606,
0x0018,0x4331,0x280F,0x00D8,0xD806,0x00CF,0xA5A5,0xCFF1,
0x0006,0xFAF1,0x0652,0x493A,0x3131,0x1806,0x0F18,0xFACF,
0xC6D8,0xE8FA,0x0006,0xFA0F,0x3A43,0x2818,0x06E8,0xC6FA,
0xFAD8,0xAE9C,0xB7E8,0xFA06,0x00F1,0x0649,0x6449,0x433A,
0x280F,0x060F,0xFAD8,0xC6CF,0xE8F1,0x0006,0x0006,0x3A49,
0x3118,0x06F1,0xCFCF,0xFAF1,0xBD9C,0xA5D8,0xFA0F,0x2100,
0xFA31,0x6449,0x3A28,0x2106,0x0606,0x06E8,0xCFD8,0xDFF1,
0xFA0F,0x00FA,0x0631,0x3A21,0x00FA,0xD8C6,0xFA00,0xDFBD,
0xAEBD,0xF100,0x0F0F,0xF1FA,0x3A49,0x3A31,0x2818,0x000F,
0x2100,0xDFD8,0xDFE8,0xE8FA,0x00F1,0xF121,0x3A31,0x180F,
0x06D8,0xD806,0xFAD8,0xAEA5,0xC6E8,0xFA06,0xF1DF,0x0652,
0x523A,0x3131,0x210F,0x1818,0xFAD8,0xCFCF,0xDFE8,0xFAFA,
0xE8FA,0x283A,0x3121,0x0F00,0xDFCF,0x00F1,0xD8AE,0x9CB7,
0xE800,0x0F00,0xE806,0x525B,0x433A,0x2828,0x180F,0x0FF1,
0xD8D8,0xCFDF,0xDFF1,0x06F1,0x0028,0x3A3A,0x2818,0x0FF1,
0xCFE8,0xFADF,0xBD9C,0xAEDF,0xFA18,0x0FFA,0x0043,0x6C52,
0x3A28,0x2818,0x180F,0xFAD8,0xD8D8,0xDFDF,0xF106,0xFA00,
0x0F31,0x4331,0x2118,0x06D8,0xD8FA,0xF1D8,0xA5A5,0xBDE8,
0x0F0F,0xFAF1,0x0F5B,0x5B43,0x3131,0x2106,0x0F06,0xF1D8,
0xC6CF,0xD8D8,0xFA00,0xFAFA,0x2143,0x3A28,0x2118,0xF1D8,
0xDF00,0xDFB7,0x94A5,0xC6E8,0x0F06,0xF1FA,0x3164,0x493A,
0x3131,0x0F06,0x06FA,0xD8CF,0xCFCF,0xD8E8,0x0600,0xFA0F,
0x3A49,0x3A28,0x210F,0xF1CF,0xE8FA,0xD8B7,0x8BA5,0xD8FA,
0x1806,0xFA00,0x4364,0x523A,0x3128,0x180F,0x06FA,0xD8CF,
0xC6CF,0xD8F1,0x0600,0xFA18,0x3A49,0x3A21,0x280F,0xF1CF,
0xD8F1,0xD8BD,0x8B9C,0xC6FA,0x2106,0xFA06,0x4964,0x523A,
0x3131,0x180F,0x06FA,0xDFD8,0xD8D8,0xDFF1,0x0F06,0x0018,
0x4343,0x4328,0x2821,0x00CF,0xCFE8,0xDFD8,0xA59C,0xBDF1,
0x2118,0x00FA,0x2864,0x523A,0x2828,0x0F06,0x0600,0xDFD8,
0xD8D8,0xDFE8,0x0006,0xF1FA,0x2831,0x2821,0x180F,0x00DF,
0xBDC6,0xE8F1,0xBD94,0xA5DF,0x0018,0x0FFA,0x003A,0x6449,
0x3A28,0x2818,0x0F18,0x00E8,0xD8CF,0xCFD8,0xE8FA,0xF1F1,
0x0628,0x3A31,0x3118,0x180F,0xF1BD,0xD8F1,0xD8B7,0x94A5,
0xD8FA,0x0606,0x0006,0x526C,0x5243,0x3128,0x1806,0x06F1,
0xCFBD,0xC6CF,0xD8DF,0x06FA,0xFA18,0x3A3A,0x3128,0x2118,
0x00DF,0xB7C6,0xE8DF,0xB79C,0xA5DF,0x0621,0x2106,0x1852,
0x6449,0x4328,0x2106,0x0000,0xF1DF,0xCFCF,0xCFD8,0xFA0F,
0x00FA,0x1831,0x3A28,0x2118,0x180F,0xF1BD,0xC6F1,0xE8C6,
0x9CA5,0xD800,0x1818,0x0000,0x3A6C,0x493A,0x2831,0x1806,
0x06FA,0xD8D8,0xCFCF,0xCFDF,0x0600,0xFA0F,0x283A,0x3A28,
0x2821,0x1800,0xCFAE,0xDFE8,0xD8AE,0x9CC6,0xFA0F,0x2818,
0x0028,0x6C5B,0x433A,0x310F,0x0000,0x00DF,0xCFC6,0xC6D8,
0xDF00,0x06FA,0x0028,0x3A31,0x2828,0x2118,0x0FF1,0xB7BD,
0xDFF1,0xCF9C,0x9CCF,0xFA21,0x280F,0x0031,0x6452,0x3128,
0x280F,0xFAFA,0xE8D8,0xCFCF,0xC6CF,0xE806,0x0600,0x0621,
0x3131,0x2821,0x180F,0x0FFA,0xBDB7,0xDFE8,0xD8A5,0xA5CF,
0xFA21,0x2818,0x0028,0x5B52,0x3128,0x1806,0x00FA,0xF1D8,
0xD8D8,0xD8D8,0xF100,0x0F00,0x1828,0x3A31,0x2821,0x2118,
0x1800,0xCFA5,0xCFFA,0xF1BD,0xA5AE,0xDF0F,0x3A21,0x000F,
0x495B,0x4943,0x2818,0xFA00,0x00F1,0xD8D8,0xCFD8,0xD800,
0x1806,0x000F,0x2828,0x3128,0x180F,0x0F06,0xFAC6,0xA5CF,
0xFAD8,0xAEA5,0xB7E8,0x2131,0x2100,0x285B,0x5B43,0x4331,
0x0FFA,0x0000,0xDFD8,0xCFC6,0xC6D8,0xFA06,0xFA00,0x1831,
0x3131,0x3118,0x1821,0x0FF1,0xC69C,0xBDE8,0xDFBD,0x9CAE,
0xE80F,0x4331,0x0F18,0x5264,0x5249,0x2100,0xF1F1,0xFADF,
0xBDBD,0xB7C6,0xDF00,0x0F00,0x0628,0x3A43,0x3A21,0x0F0F,
0x180F,0xF1D8,0xA5A5,0xC6E8,0xE8B7,0xAECF,0x063A,0x5231,
0x0F21,0x5B5B,0x4328,0x0FFA,0xE8FA,0xF1D8,0xC6C6,0xC6D8,
0xE80F,0x0F00,0x0621,0x4331,0x2118,0x060F,0x180F,0xF1DF,
0xAEAE,0xDFFA,0xE8B7,0xAED8,0x0643,0x4921,0x0021,0x5252,
0x3118,0x00E8,0xDF00,0xF1C6,0xCFC6,0xC6D8,0xFA18,0x0600,
0x0F31,0x4943,0x3118,0x0F18,0x210F,0xFADF,0xBDA5,0xC6E8,
0x00CF,0xAEBD,0xFA21,0x523A,0x0606,0x3A5B,0x4331,0x0FFA,
0xDFDF,0x00F1,0xD8C6,0xC6CF,0xF118,0x2106,0x0018,0x3A43,
0x3121,0x0000,0x180F,0xFAE8,0xD8AE,0xA5D8,0xF100,0xCFB7,
0xC6FA,0x3A52,0x31FA,0x0F52,0x5B31,0x2806,0xF1D8,0xF100,
0xDFCF,0xCFC6,0xDFFA,0x2821,0x0000,0x3143,0x3A28,0x0F00,
0x0018,0x0FF1,0xDFDF,0xB7AE,0xCFFA,0x00CF,0xBDDF,0x0F43,
0x5228,0xFA0F,0x525B,0x3118,0x00E8,0xDF00,0x06E8,0xD8CF,
0xCFE8,0x0028,0x18FA,0x0021,0x3A31,0x2106,0xFA00,0x210F,
0xFAE8,0xDFB7,0xAECF,0x0000,0xCFB7,0xCF0F,0x3A52,0x2800,
0x0F52,0x6443,0x2100,0xFAE8,0xFA00,0xDFCF,0xC6CF,0xDFF1,
0x1821,0x0000,0x2143,0x3A28,0x0FFA,0x0018,0x0FFA,0xDFD8,
0xBDA5,0xBDFA,0x06DF,0xB7CF,0x0031,0x5231,0x0600,0x3152,
0x3A18,0xFAF1,0xDFF1,0x00F1,0xD8D8,0xD8DF,0xF121,0x21FA,
0xF118,0x3131,0x280F,0xFAF1,0x1818,0x00F1,0xE8DF,0xB7BD,
0xF106,0xFAC6,0xC6E8,0x1852,0x4918,0xFA18,0x5249,0x1806,
0x00E8,0xE800,0xF1CF,0xD8DF,0xD8DF,0xFA21,0x06FA,0x0621,
0x2828,0x1800,0xFA06,0x1806,0xF1F1,0xE8CF,0xB7D8,0x000F,
0xE8BD,0xC600,0x3152,0x2100,0x003A,0x4931,0x18FA,0xFAF1,
0xFAFA,0xDFD8,0xDFCF,0xD8E8,0x0F0F,0xFAFA,0x1828,0x2821,
0x0FFA,0x0021,0x0FFA,0xF1F1,0xE8CF,0xAEDF,0x0006,0xDFCF,
0xDF06,0x4349,0x21FA,0x0F3A,0x4321,0x0FFA,0xF1DF,0xFAFA,
0xDFE8,0xDFDF,0xDF00,0x2121,0x0000,0x1831,0x3121,0x0600,
0x0621,0x1800,0xFAFA,0xF1CF,0xC6F1,0x0000,0xD8C6,0xDF06,
0x4331,0x0FF1,0x0643,0x4321,0x06FA,0xF1F1,0x06FA,0xDFE8,
0xDFCF,0xE800,0x210F,0xFA00,0x2131,0x3128,0x0600,0x0F21,
0x06FA,0xF1F1,0xE8CF,0xAED8,0xFA00,0xD8BD,0xCF06,0x3A43,
0x0FF1,0x0643,0x4321,0x0FFA,0xF1E8,0x06FA,0xDFE8,0xDFDF,
0xE8FA,0x2118,0x0000,0x1831,0x3121,0x0F00,0x000F,0x06FA,
0xF1E8,0xE8D8,0xB7BD,0xFA06,0xF1C6,0xC600,0x2849,0x2100,
0xFA28,0x4328,0x18FA,0xFAE8,0xFA00,0xF1E8,0xE8DF,0xE8FA,
0x1821,0x0600,0x0F21,0x2828,0x0FFA,0x0018,0x06FA,0xF1F1,
0xF1F1,0xD8BD,0xE8FA,0x0FE8,0xCFDF,0x183A,0x3A0F,0xFA06,
0x3A3A,0x180F,0xFAFA,0xFA0F,0xFADF,0xF1F1,0xF1F1,0xFA18,
0x0F00,0x060F,0x2128,0x2106,0x0006,0x1806,0xFAFA,0xFAF1,
0xF1CF,0xBDE8,0x0006,0xD8C6,0xE818,0x3A31,0x0FFA,0x0F43,
0x3A18,0x0606,0xFAF1,0x06F1,0xE8F1,0xF1E8,0xE800,0x1806,
0x0000,0x0F21,0x2121,0x06FA,0x060F,0x00FA,0xFAF1,0xE8DF,
0xC6AE,0xCF00,0x0FD8,0xBDD8,0x1831,0x3A0F,0xFA06,0x4343,
0x280F,0x00FA,0xFA00,0xFAE8,0xE8E8,0xE8E8,0x0018,0x0600,
0x0618,0x2128,0x2106,0xF100,0x0600,0xF1E8,0xF1E8,0xF1DF,
0xBDC6,0xFA18,0xFACF,0xD806,0x2843,0x18FA,0x0028,0x3A21,
0x0600,0x00F1,0x0000,0xFAF1,0xF1F1,0xE8E8,0x0F0F,0x0000,
0x0006,0x2128,0x0FFA,0xFA0F,0x0F00,0xFA00,0xFAFA,0xF1D8,
0xBDDF,0x060F,0xD8C6,0xE818,0x3A3A,0x0FFA,0x0F3A,0x3A0F,
0x0600,0xFAF1,0x0600,0xE8FA,0xF1F1,0xE800,0x2118,0x0000,
0x0F18,0x1818,0x00F1,0x000F,0x00F1,0xFAFA,0xFAFA,0xFADF,
0xC6DF,0x0606,0xDFC6,0xD806,0x2131,0x06FA,0x0631,0x3118,
0x180F,0x00F1,0x0606,0xF1E8,0xE8E8,0xE8FA,0x0606,0xFA00,
0x0F18,0x2121,0x06FA,0x060F,0x00FA,0xFAF1,0xF1F1,0xF1E8,
0xBDC6,0xFA00,0xF1D8,0xD8FA,0x183A,0x280F,0x0018,0x3121,
0x0F0F,0x00E8,0xFA06,0xF1F1,0xF1F1,0xF1F1,0x0618,0x0606,
0x0606,0x0F21,0x0F00,0xFAFA,0x00FA,0x00FA,0xF1FA,0xFAFA,
0xDFC6,0xDF00,0x0FFA,0xBDCF,0xFA21,0x3106,0xFA00,0x2831,
0x2821,0x0600,0xFA18,0x06F1,0xFAFA,0xE8F1,0xFA0F,0x06FA,
0xFA00,0x0618,0x2106,0xFA00,0x0F06,0x0600,0xFAF1,0x0000,
0xFADF,0xB7C6,0xF106,0xF1CF,0xC6F1,0x1843,0x280F,0x0628,
0x3A31,0x2818,0x06FA,0x00FA,0xF1F1,0xF1DF,0xDFE8,0x060F,
0x0606,0x060F,0x2128,0x1800,0x0606,0x00FA,0xFAF1,0xF1FA,
0xF1F1,0xE8C6,0xBDDF,0x060F,0xF1D8,0xE818,0x3A43,0x2100,
0x0F31,0x3121,0x0F00,0xF1F1,0x06FA,0xF1FA,0xF1F1,0xF10F,
0x180F,0x060F,0x060F,0x1818,0x06FA,0x0000,0xFAFA,0xFAF1,
0xF1FA,0x00FA,0xF1D8,0xC6E8,0x0F0F,0xE8D8,0xE80F,0x3128,
0x0FFA,0x0628,0x3118,0x0F00,0xFAFA,0x0600,0xFAFA,0xF1F1,
0xF106,0x0F06,0x0000,0x000F,0x0F0F,0x00FA,0x0006,0x0000,
0xFAFA,0xFAFA,0xFAFA,0xF1DF,0xB7C6,0xFA0F,0xF1C6,0xC6F1,
0x1831,0x2106,0x0018,0x3131,0x2121,0x06FA,0x0006,0x00FA,
0xF1F1,0xE8F1,0x0F06,0xFAFA,0x0000,0x0F18,0x0FFA,0xFA06,
0x06FA,0xFAFA,0xE8E8,0xF1FA,0xF1DF,0xCFBD,0xC600,0x18FA,
0xCFD8,0x0028,0x4928,0x0606,0x2843,0x3128,0x0F00,0xF1FA,
0x06FA,0xFAF1,0xE8E8,0xFA18,0x0F00,0x0606,0x0618,0x310F,
0xFAF1,0x0000,0x0000,0xF1DF,0xE8FA,0x00FA,0xF1D8,0xBDC6,
0x0628,0xFAD8,0xCFF1,0x1849,0x2800,0xFA0F,0x3128,0x2118,
0x00E8,0xFA0F,0x06FA,0xFAF1,0xE8F1,0x1818,0x0000,0x0000,
0x0F21,0x0FFA,0xFA00,0x0600,0x00F1,0xE8F1,0xFAFA,0xF1F1,
0xE8C6,0xBDE8,0x0F06,0xDFCF,0xE806,0x3A3A,0x18FA,0x0628,
0x3121,0x1806,0xF1FA,0x0F00,0x0000,0xF1F1,0xF106,0x0F00,
0x0000,0x0006,0x180F,0xFAF1,0x0000,0xFA00,0xFAF1,0xF1FA,
0x00FA,0xF1FA,0xDFC6,0xC600,0x0FF1,0xD8CF,0xF10F,0x4928,
0x0600,0x2143,0x3A3A,0x2106,0xFA0F,0x0FFA,0xFAF1,0xE8DF,
0xE806,0x00FA,0xFAFA,0x0006,0x2106,0xFA00,0x0600,0x0000,
0xFAF1,0xF1FA,0xF1E8,0xF1E8,0xCFB7,0xCF00,0x0FF1,0xDFDF,
0x063A,0x4928,0x0606,0x3143,0x3121,0x06FA,0xF106,0x00F1,
0xFAF1,0xE8E8,0x000F,0x0600,0x0000,0x0F21,0x1800,0xFA00,
0x0606,0x00FA,0xF1F1,0xFAFA,0xFAF1,0xFAFA,0xE8C6,0xCF06,
0x2100,0xDFD8,0x0028,0x4921,0x0000,0x1831,0x2821,0x0FFA,
0xF106,0x0000,0x00FA,0xE8F1,0x0006,0x0F00,0xFAFA,0x0018,
0x1806,0xFAFA,0x0000,0x0000,0xF1F1,0xFAF1,0xFAFA,0xFAF1,
0xE8CF,0xBDD8,0x000F,0xF1D8,0xDF00,0x3A43,0x2106,0x0631,
0x4331,0x2106,0xFAFA,0x0600,0xFAFA,0xF1E8,0xDF00,0x0F06,
0x0000,0xFA00,0x1818,0x06FA,0xF1FA,0xFA00,0xFAE8,0xE8F1,
0xF1F1,0xF1F1,0xF1F1,0xDFBD,0xD80F,0x18FA,0xD8DF,0x0F3A,
0x4321,0x0006,0x3143,0x2821,0x06FA,0xF106,0x00F1,0xFAF1,
0xE8DF,0xFA0F,0x0F06,0x0000,0x0018,0x2100,0xF1FA,0xFAFA,
0xFAF1,0xE8E8,0xFAFA,0x00FA,0xFAFA,0xFAF1,0xC6CF,0x0621,
0x00D8,0xCFFA,0x2843,0x2100,0xFA18,0x3A28,0x210F,0xFAFA,
0x0F06,0x0000,0xFAF1,0xE8FA,0x0F0F,0x0600,0xFA00,0x0F21,
0x06FA,0xF100,0x0006,0xFAE8,0xF1FA,0x0000,0xFAFA,0xFAFA,
0xFAE8,0xBDD8,0x0618,0xF1CF,0xD8FA,0x2843,0x2100,0x0631,
0x4931,0x280F,0x0000,0x1800,0xFA00,0xF1E8,0xDFFA,0x0606,
0x00FA,0x0000,0x2121,0x00F1,0x0006,0x0000,0xF1E8,0xF1FA,
0xFAF1,0xF1FA,0xFAF1,0xFAF1,0xC6D8,0x0028,0xFAE8,0xDFFA,
0x2149,0x2806,0x0021,0x3A28,0x280F,0x00FA,0x0F00,0xFAFA,
0xF1FA,0xE8FA,0x0606,0x0006,0x0000,0x0618,0x06FA,0xFAFA,
0xFA00,0x00F1,0xF1E8,0xF1FA,0xFA00,0xFAF1,0xF100,0xD8C6,
0xFA18,0x0FE8,0xCFE8,0x0643,0x310F,0xFA0F,0x3A31,0x1818,
0x0600,0x0606,0xF1FA,0xFAFA,0xE8DF,0xFA00,0x0006,0x00FA,
0x0021,0x1800,0x0000,0xFAFA,0x00FA,0xE8E8,0xF1F1,0xF1FA,
0xFAF1,0xF100,0x00D8,0xC600,0x280F,0xF1DF,0xE806,0x4931,
0x00FA,0x0F31,0x2821,0x1800,0xFA06,0x06F1,0x00FA,0xFAE8,
0xF10F,0x0F0F,0x0600,0xFA06,0x180F,0xFAF1,0xF1F1,0xFA00,
0xFAF1,0xF1FA,0xFAFA,0x0606,0xFAFA,0x00F1,0xC6C6,0x0021,
0x00D8,0xCFE8,0x0652,0x3A06,0xFA21,0x433A,0x3121,0x06FA,
0x0F06,0xFAFA,0x00F1,0xDFDF,0x0606,0x0000,0xFAFA,0x0021,
0x0FFA,0xFA00,0xFAFA,0x00FA,0xE8E8,0xFAFA,0xF1FA,0xFAF1,
0xF100,0x00DF,0xC6E8,0x1821,0xFAD8,0xD800,0x3A43,0x18FA,
0x0021,0x3121,0x2106,0xFAFA,0x06FA,0xFA00,0xF1E8,0xE800,
0x0F06,0x0600,0xFA00,0x0F0F,0x00F1,0xFAF1,0xFA00,0xFAF1,
0xF1F1,0xFAFA,0xFA06,0xFAF1,0x0000,0xFAD8,0xBDE8,0x180F,
0xE8CF,0xDFFA,0x3A3A,0x0F00,0x0631,0x3128,0x2106,0xFA06,
0x06FA,0xFA00,0xFAF1,0xDFFA,0xFA00,0x0F06,0xFAFA,0x1818,
0x0600,0x00F1,0xFA00,0xFAFA,0xF1F1,0xF1F1,0xFA00,0x00FA,
0x0600,0x06FA,0xCFD8,0x0F31,0x00E8,0xDFFA,0x2152,0x2800,
0x0628,0x4328,0x2118,0x0000,0x06FA,0xE8F1,0x00FA,0xDFDF,
0x0006,0x0F0F,0x00F1,0x0621,0x0FFA,0xFAF1,0xF1FA,0xFAF1,
0xDFF1,0xF1F1,0xF1FA,0x00FA,0x0000,0x0006,0x0FD8,0xC6E8,
0x2818,0xE8CF,0xDF00,0x4343,0x0FFA,0x0031,0x2821,0x2806,
0xF100,0x06FA,0xF100,0xFAE8,0xDF00,0x0606,0x0F06,0xFAFA,
0x180F,0x00F1,0xF1F1,0xF1FA,0xFAE8,0xE8F1,0xFAFA,0xFA00,
0xFAF1,0x0000,0x000F,0x0FF1,0xBDCF,0x0631,0x06DF,0xCFE8,
0x0F52,0x3100,0xFA18,0x3128,0x2818,0xFAF1,0x00FA,0xDFE8,
0x00F1,0xDFDF,0xFA06,0x0F18,0x00F1,0x0021,0x0FFA,0xFAF1,
0xF1F1,0x00FA,0xF1F1,0xF1FA,0x0006,0x0600,0x0006,0x0006,
0x0F0F,0x00D8,0xB7D8,0x1828,0xF1CF,0xD8F1,0x3152,0x2800,
0x0028,0x3121,0x1806,0xF1E8,0xF1E8,0xDFF1,0x00F1,0xD8F1,
0x0618,0x1818,0x00FA,0x0618,0x0FFA,0xFAF1,0xE8E8,0x00FA,
0xF1F1,0xFAF1,0xFA06,0x06FA,0xFA00,0x0000,0x0F06,0x06DF,
0xBDC6,0x183A,0x00CF,0xD8FA,0x285B,0x3106,0x0028,0x3A21,
0x2106,0xFAF1,0xFAFA,0xE8F1,0x06FA,0xE8F1,0x0618,0x2118,
0x06F1,0x0021,0x06FA,0xF1E8,0xF1F1,0x00FA,0xE8F1,0xFAFA,
0xFA00,0x0000,0xFA06,0xFAFA,0x0606,0x0600,0xE8BD,0xD818,
0x3A00,0xD8DF,0x0028,0x5231,0x00FA,0x2128,0x1818,0x06F1,
0xE8FA,0xFAE8,0xF106,0x06E8,0xF10F,0x1818,0x1806,0xF1FA,
0x1806,0xF1E8,0xE8E8,0xE800,0xFADF,0xDFFA,0xFA00,0x0000,
0xFAFA,0x0F00,0xFAFA,0x0000,0x06E8,0xBDC6,0x0F43,0x06CF,
0xE806,0x285B,0x3A06,0xF118,0x310F,0x0606,0xF1E8,0xF1FA,
0xE8E8,0x1818,0xF1FA,0x0621,0x180F,0x0FFA,0xF10F,0x00E8,
0xDFF1,0xFAF1,0xF1FA,0xE8FA,0x0F06,0xFAFA,0x0606,0x0600,
0xFAFA,0x0006,0x0000,0xFAC6,0xB7FA,0x4321,0xDFD8,0x0018,
0x4949,0x21FA,0x0031,0x1806,0x06FA,0xE8E8,0xFAFA,0xE800,
0x2100,0xE8FA,0x1821,0x0F06,0xFAE8,0xFA06,0x00E8,0xE8F1,
0xFAF1,0xFAFA,0xF100,0x0600,0xFAFA,0x0600,0xFAFA,0xF1FA,
0x0606,0x06F1,0xCFCF,0x0643,0x21E8,0xE806,0x2843,0x4318,
0xFA06,0x2118,0x0006,0x00F1,0xF1FA,0xFAF1,0x060F,0xFADF,
0xF10F,0x0F00,0x00F1,0xE8F1,0x0600,0xF1F1,0xFAFA,0xFAFA,
0x00FA,0x0000,0xFAF1,0xFA00,0x06FA,0xF1F1,0x000F,0x1818,
0xE8C6,0xDF31,0x490F,0xDFE8,0x0F3A,0x4931,0x00E8,0x0628,
0x06FA,0x00FA,0xF1F1,0x00FA,0xF118,0x2100,0xE8FA,0x210F,
0x0600,0xF1DF,0xE80F,0x00E8,0xF1FA,0xF1E8,0x0006,0xFA00,
0xFAFA,0xF106,0x0F00,0xF1F1,0xFAFA,0x060F,0xDFB7,0xC621,
0x490F,0xDFD8,0x003A,0x493A,0x06F1,0x0021,0x0FFA,0xF1FA,
0xFAE8,0xF1FA,0xF106,0x2106,0xE8E8,0x1828,0x0F00,0xFAE8,
0xDF0F,0x0FF1,0xDFFA,0xF1E8,0xF106,0x00FA,0xFA00,0xFAFA,
0x0F0F,0xFAF1,0x060F,0x0FC6,0xAEE8,0x433A,0xE8CF,0xE818,
0x4352,0x28FA,0xF121,0x3100,0xF1FA,0xF1E8,0xDFFA,0xE8E8,
0x2121,0xE8D8,0x0031,0x210F,0x06F1,0xDF06,0x2100,0xDFE8,
0xFAFA,0xF100,0xFAFA,0x0000,0x00FA,0x0618,0x06FA,0x0006,
0xF1BD,0xC606,0x4921,0xDFD8,0x063A,0x5252,0x28FA,0x0031,
0x2806,0x00FA,0xE8DF,0xE8F1,0xDFFA,0x210F,0xE8E8,0x2131,
0x180F,0x00F1,0xE800,0x06F1,0xD8E8,0xE8D8,0xE8FA,0x00F1,
0x0000,0x0000,0x0F0F,0x0F00,0xE8B7,0xBD06,0x4318,0xCFCF,
0xFA21,0x5252,0x21FA,0x003A,0x2100,0x0000,0xFAE8,0xE8E8,
0xDFFA,0x1800,0xE8FA,0x1821,0x180F,0x06FA,0xF100,0xFAE8,
0xDFE8,0xF1DF,0xDFE8,0xF1F1,0xFA00,0x00FA,0x0F0F,0xFAC6,
0xBDFA,0x3A21,0xE8CF,0xDF18,0x3A52,0x31FA,0x0031,0x3A18,
0x0606,0x06FA,0xFAF1,0xE8E8,0x000F,0xFAFA,0x060F,0x1818,
0x1800,0xF100,0x00F1,0xE8E8,0xFAE8,0xE8F1,0xE8E8,0xFA00,
0x0000,0xE8C6,0xC6FA,0x3A28,0x06E8,0xF118,0x3A5B,0x310F,
0x0F18,0x180F,0x1818,0x0606,0xFAE8,0xDF06,0x3121,0x06FA,
0x000F,0x2828,0x00E8,0xDFF1,0xE8DF,0xE8F1,0xDFE8,0xDFDF,
0xDFFA,0x00E8,0xC6BD,0xDF0F,0x18FA,0xFAF1,0x1831,0x3A31,
0x1821,0x2818,0x0F0F,0x0F18,0x00E8,0xCFDF,0x0F28,0x2106,
0x0006,0x1828,0x18FA,0xF1FA,0xF1E8,0xE8E8,0xE8F1,0xE8E8,
0xDFF1,0xFAFA,0xD8D8,0xE800,0x18FA,0xFAFA,0x183A,0x2821,
0x1818,0x2821,0x0F06,0x0006,0x0606,0xF1F1,0x000F,0x180F,
0x0000,0x0000,0xFAFA,0xFAF1,0xDFD8,0xD8DF,0xE8F1,0xE8F1,
0xFAFA,0xE8C6,0xD8FA,0x060F,0xFAF1,0xE8E8,0x213A,0x3A21,
0x0618,0x2131,0x3A31,0x1800,0xF1FA,0x0F18,0x0F00,0x00FA,
0xFA00,0x0600,0xFAF1,0xE8DF,0xDFF1,0xF1E8,0xE8F1,0xF1F1,
0xFAFA,0xFA06,0x0F00,0x00FA,0x0621,0x2118,0x06F1,0xE8E8,
0x0031,0x3A21,0x060F,0x2852,0x433A,0x2106,0x0606,0x000F,
0x0F06,0xF1DF,0xDFD8,0xE8F1,0xE8CF,0xCFCF,0xDFFA,0x00F1,
0xD8C6,0xCFE8,0xF1FA,0xFAFA,0x00F1,0xE8FA,0x063A,0x3121,
0x2128,0x3A43,0x3A3A,0x210F,0x0F0F,0x1818,0x0600,0xFAF1,
0xE8E8,0xFAFA,0xE8D8,0xD8E8,0xF1F1,0xF1E8,0xF1FA,0x0600,
0x00FA,0x060F,0x2106,0x0006,0x180F,0x00FA,0xFAFA,0xFAF1,
0xFAF1,0xFAFA,0xFAFA,0xE8FA,0x1818,0x0600,0x0F21,0x1818,
0x0F0F,0x1806,0x1818,0x0606,0x0F00,0xFAFA,0x0000,0xF1E8,
0xF1E8,0xDFDF,0xF1FA,0xE8E8,0xE8FA,0x0006,0x0000,0x0000,
0x0618,0x0606,0x0F18,0x180F,0x0606,0x0600,0x0600,0xFA00,
0xFAF1,0xF1FA,0x00FA,0xF1FA,0xFAFA,0x0006,0x0006,0x0F0F,
0x0606,0x0606,0x0F0F,0x0600,0x0006,0x0606,0x0000,0x0606,
0x0600,0xFAFA,0x0000,0x00FA,0xFAFA,0xFAFA,0xFAFA,0xFAFA,
0xFAFA,0x00FA,0xFAFA,0x00FA,0x0000,0xFAFA,0x0000,0x0000,
0x00FA,0xF1F1,0xFAFA,0xFAF1,0xF1FA,0xFA00,0x0606,0x0000,
0x0006,0x0606,0x0000,0x06FA,0xFA00,0x0000,0xFAFA,0xFA00,
0x0006,0x0000,0x0000,0x0000,0x0000,0x0000,0xFAFA,0x0006,
0x00FA,0xFA00,0x0606,0x0000,0x0F0F,0x00FA,0x000F,0x0600,
0xFAFA,0x0606,0x00FA,0xFA00,0x0F00,0xF1FA,0x060F,0x00F1,
0xFA00,0x06FA,0xF1F1,0x060F,0x00E8,0xE800,0x06FA,0xF1E8,
0xFAFA,0xF1E8,0xFA06,0x00FA,0xF100,0x0F06,0xFA00,0x0006,
0x0600,0x000F,0x0600,0x0006,0x0600,0x00FA,0x0000,0x0000,
0x0000,0x00FA,0xFA00,0x0F00,0xF1F1,0xFA00,0x0000,0xFAFA,
0x0000,0xFAFA,0xFA00,0xFAF1,0xF100,0x06FA,0xF1F1,0x0000,
0xFAFA,0xFA06,0x06FA,0xFA00,0x0F06,0xFAFA,0x0F0F,0x0F00,
0xFA0F,0x0F0F,0x0006,0x1818,0x0600,0x0F0F,0x0600,0x060F,
0x0006,0xFA06,0x0600,0x0006,0x1806,0x0000,0x0F0F,0x06FA,
0xFA0F,0x0600,0xFA00,0x0F06,0xFAFA,0x000F,0x0600,0xFA00,
0x0600,0xFAF1,0x0006,0x00FA,0xF100,0x06FA,0xE8E8,0x060F,
0xFAF1,0xE800,0x0600,0xF1FA,0x0F06,0x00FA,0x060F,0x0600,
0x000F,0x0006,0xFA06,0x0600,0x00FA,0x0F00,0x0600,0x0606,
0xFAFA,0xFA06,0xFAFA,0xFAFA,0x06F1,0xFAFA,0x0000,0xF1F1,
0xFA00,0xFAF1,0xF1FA,0x00FA,0xFAFA,0x0006,0xFAFA,0xFA06,
0x06FA,0xFA00,0x0606,0xFAFA,0xFA06,0x06FA,0xFA06,0x0F00,
0x00FA,0x060F,0x0000,0xFA0F,0x0F00,0xFA00,0x0F06,0x0000,
0x1806,0x06FA,0x000F,0x0606,0xFA00,0x0000,0xFAFA,0x0F00,
0xFAFA,0xFA0F,0x00FA,0xF106,0x0600,0xFAFA,0x0600,0x00FA,
0xFA06,0x0000,0xFA00,0x0600,0xFAF1,0x0F06,0x00F1,0xF10F,
0x06F1,0xE8E8,0x0F06,0xFAE8,0xE806,0x06FA,0xE8F1,0x0600,
0xF1F1,0x000F,0x00FA,0xF106,0x0F00,0xFAF1,0x0F06,0x00FA,
0x0618,0x0606,0x0018,0x0F00,0x0000,0x1806,0x06FA,0x0F06,
0x00FA,0xFA18,0x0600,0xFAFA,0x0600,0xFAF1,0x0000,0xFAF1,
0xF106,0x0600,0xF1FA,0x0F00,0xFAF1,0x0006,0x00F1,0xE8FA,
0x0600,0xFAF1,0xFA06,0x00FA,0xFA06,0x0F00,0xFAFA,0x0F0F,
0x06FA,0x000F,0x0600,0x000F,0x0F00,0x0000,0x1806,0x0006,
0x060F,0x00FA,0x000F,0x06FA,0xFAFA,0x0F06,0x00FA,0x0006,
0x0000,0xFA00,0x0600,0xFAF1,0xFA00,0xFAFA,0xF1FA,0xFAFA,
0xFAFA,0x0600,0xFAFA,0xFA0F,0x0600,0xFAFA,0x0600,0xFAFA,
0xFA06,0xFAF1,0xF106,0x0600,0xFAF1,0x0600,0xFAFA,0x000F,
0xFAFA,0xFA00,0x06FA,0xFA00,0x0F00,0x00FA,0x000F,0x00FA,
0xFA06,0x00FA,0xFAFA,0x0F00,0x00FA,0x0006,0xFA00,0xFA06,
0x0600,0x00FA,0x0606,0x06FA,0xFA0F,0x0606,0xFA06,0x0F06,
0xFAFA,0x060F,0x00FA,0xFA06,0x0F06,0xFAFA,0x060F,0x00FA,
0xF106,0x0600,0xFA00,0x1800,0x00FA,0x0618,0x00FA,0xFA06,
0x0600,0xFAFA,0x0F06,0xFAFA,0x000F,0x0000,0xFA00,0x0F00,
0x00FA,0x0600,0xFAFA,0xFA0F,0x00FA,0xFAF1,0x0600,0x00FA,
0x0006,0x00FA,0xFA06,0x06FA,0xFAFA,0x0600,0x00FA,0xF106,
0x06FA,0xF1FA,0x060F,0xFAF1,0xFA00,0x0F00,0xF1FA,0x060F,
0xFAF1,0x000F,0x0000,0xFA00,0x0F00,0xFAFA,0x060F,0x00FA,
0xFA06,0x0600,0xFA00,0x0600,0x00FA,0x000F,0x0600,0xFA00,
0x060F,0x00F1,0x0006,0x00F1,0xFA06,0x06FA,0xFAF1,0x0006,
0xFAFA,0xF100,0x0FFA,0xF1FA,0x0000,0xFAF1,0xFA06,0x00FA,
0xF1F1,0x0600,0xFAFA,0xFA06,0x06FA,0xF100,0x0F06,0xFAFA,
0x0F0F,0x06FA,0xFA06,0x0F06,0x0000,0x0606,0x00FA,0x0006,
0x0000,0xFA00,0x0606,0xFAFA,0xFA00,0xFAFA,0xFA06,0x0000,
0xFAFA,0x0606,0x00FA,0xFA06,0x0F00,0xFAFA,0x0606,0x00FA,
0x000F,0x0F00,0x0000,0x0606,0x0000,0x0006,0x0606,0x0000,
0x060F,0x0000,0x0006,0x0606,0xFA00,0x0606,0x00FA,0x0006,
0x00FA,0xFAFA,0x00FA,0xFAFA,0x0000,0xF1FA,0xFA00,0x00FA,
0xFAFA,0xFAFA,0x00FA,0xFA00,0xFAF1,0xFAFA,0x0000,0x00FA,
0xFA00,0x0600,0xFAFA,0x0006,0x00FA,0xFA06,0x0600,0xF100,
0x0606,0x00FA,0x0018,0x0F00,0xFA00,0x0F06,0x00FA,0x000F,
0x0600,0xFA00,0x0F06,0xFAF1,0xFA06,0x0600,0xFAFA,0x0000,
0xFAFA,0xFA06,0x06FA,0xFAFA,0x0F0F,0x00FA,0xFA06,0x0F00,
0xFAFA,0x0F06,0xFAF1,0xFA06,0x0000,0xF1FA,0x0606,0xFAF1,
0xFA00,0x0600,0xF1FA,0x0600,0xFAFA,0xFA00,0x06FA,0xFAFA,
0x0000,0xFAFA,0xFAFA,0x00FA,0xFAFA,0xFA00,0x00FA,0xFA00,
0x0600,0xFAFA,0x060F,0x06FA,0xFAFA,0x0F0F,0xFAFA,0x000F,
0x0600,0xFA00,0x180F,0x00FA,0x0018,0x0F00,0xFA00,0x0F0F,
0x00FA,0x000F,0x0F00,0xF100,0x0F0F,0x00FA,0x000F,0x0F06,
0xFAFA,0x0F0F,0x00FA,0xFA06,0x0600,0x00FA,0xFA06,0x06FA,
0xFA00,0x0606,0xFAFA,0xFA06,0x0F00,0xFAFA,0x000F,0x06FA,
0xF100,0x0F00,0xFAFA,0x0006,0x00F1,0xF1FA,0x0600,0xF1F1,
0xF100,0x06F1,0xF1F1,0x0000,0xFAF1,0xFA00,0x06FA,0xF1F1,
0x0006,0xFAFA,0xFAFA,0x0600,0xFAF1,0xFA00,0x00FA,0xFAFA,
0x0006,0x00FA,0xFA00,0x0606,0xFAF1,0x000F,0x0600,0xFA00,
0x060F,0x00FA,0xFA00,0x0F00,0xFAFA,0x000F,0x0600,0xFA00,
0x0F0F,0x00FA,0x000F,0x0F00,0xFA00,0x0618,0x00F1,0xFA06,
0x1806,0xFAF1,0x0018,0x1800,0xF1FA,0x0F18,0x00F1,0xFA06,
0x0F00,0xF1F1,0x000F,0x06FA,0xF100,0x060F,0xFAF1,0xFA00,
0x0F06,0xFAF1,0x000F,0x06FA,0xF1FA,0x060F,0xFAF1,0xF106,
0x0F00,0xF1F1,0x0006,0x06FA,0xFAFA,0x0006,0x00FA,0xFAFA,
0x0000,0xFAFA,0x0006,0x0000,0xFAFA,0x0606,0x00FA,0xFA00,
0x0600,0x00FA,0x0006,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FA,0xFA00,0x0000,0xFAFA,0x0006,0x00FA,0xFA06,0x0606,
0x0000,0x000F,0x0F00,0xFA00,0x0F06,0x06FA,0x0006,0x0F0F,
0xFAFA,0xFA06,0x0F06,0xFAFA,0x0006,0x0600,0xF1FA,0x0606,
0x00FA,0x0006,0x0600,0x00FA,0x0006,0x00FA,0xFA00,0x06FA,
0xF1FA,0xFAFA,0xFAFA,0xFA00,0x00FA,0xF1F1,0x0000,0x00FA,
0xF1FA,0x0000,0xFAF1,0xF1FA,0x0600,0xFAF1,0xF106,0x0600,
0xF1F1,0xFA00,0x00FA,0xF1F1,0x0000,0x06FA,0xFAFA,0x0006,
0x0000,0xFA00,0x0606,0x00FA,0x0000,0x0606,0x0000,0x0000,
0x0606,0x0606,0x0006,0x060F,0x0606,0x0006,0x0F0F,0x0F00,
0x0606,0x0F0F,0x0606,0x060F,0x0606,0x0000,0x0606,0x0600,
0x0000,0x0006,0x0600,0x0006,0x0600,0x0000,0x0606,0x0000,
0x0000,0x0606,0x00FA,0xFA06,0x06FA,0xF1FA,0x0006,0x00FA,
0xFAFA,0xFA00,0x00FA,0xF1F1,0xFA00,0x00FA,0xF1FA,0xFA00,
0x00FA,0xFAFA,0xFA00,0xFA00,0xFAFA,0xFAFA,0xFAFA,0xFAFA,
0xFAFA,0xFAFA,0xFAFA,0xFA00,0x00FA,0xFAFA,0xFAFA,0xFA00,
0xFA00,0xFAFA,0xFA00,0x06FA,0xFAF3,0xFA06,0x0600,0xFAFA,
0x0006,0x0600,0xFA00,0x060D,0x0600,0x0006,0x060D,0x0606,
0x0606,0x0006,0x0606,0x0606,0xFA00,0x0004,0x0400,0xFC00,
0x0004,0x0400,0x0000,0xFC00,0x0004,0x00FC,0xFC00,0x0004,
0x0000,0xFCFC,0x0000,0x04FC,0xFCFC,0xFCFC,0xFC00,0x00FC,
0xFCFC,0x0000,0x00FC,0xFCFC,0xFC00,0x0000,0xFCFC,0xFC00,
0x0000,0xFCFC,0xF6FC,0x0000,0x00FC,0xFCFC,0xFCFC,0x0000,
0xFCFC,0xFC00,0xFC00,0xFCF6,0xFCFC,0x0000,0xFCFC,0xFC00,
0x0000,0x0000,0x0000,0x0000,0x0404,0x0000,0x0000,0x0404,
0x0404,0x0004,0x0004,0x0404,0x0404,0x0000,0x0404,0x0404,
0x0404,0x0409,0x0904,0x0404,0x0401,0x0109,0x0100,0x0000,
0x0101,0x0101,0x0000,0x0001,0x0000,0x0000,0x0001,0x00FF,
0x0000,0x0000,0x00FF,0xFF00,0x0000,0x0000,0xFFFF,0xFFFF,
0x00FF,0xFF00,0xFFFF,0xFFFF,0xFF00,0xFFFF,0xFFFF,0xFFFF,
0xFF00,0xFFFF,0xFFFF,0xFF00,0xFFFF,0x0000,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0x00FF,0xFFFF,0xFF00,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0100,0x0000,0x0001,0x0101,0x0000,
0x0101,0x0100,0x0101,0x0101,0x0100,0x0101,0x0100,0x0001,
0x0000,0x0000,0x0100,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000
};

