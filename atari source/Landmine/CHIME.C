/* Clear area sound */
#define CLEAR_SAMPLE_LENGTH	(0x2238+0x80)
int clear_smp_length = CLEAR_SAMPLE_LENGTH;
int clear_smp_rate = 0x82;
int clear_sample[CLEAR_SAMPLE_LENGTH / 2] = {
0x3242,0x4954,0x4348,0x494D,0x4500,0x002D,0x0000,0x0008,
0xFFFF,0x0000,0xFFFF,0xFF00,0x30E5,0x0000,0x2237,0x0000,
0x0000,0x0000,0x2237,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x5354,0x4552,0x454F,0x2052,0x4550,0x4C41,0x5900,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x00FF,0xFDFA,0xF800,
0x0804,0x00F8,0xEFF3,0xF704,0x110B,0x04F8,0xEBF1,0xF706,
0x1511,0x0DFC,0xEBEF,0xF304,0x1511,0x0DFC,0xEBEF,0xF304,
0x1514,0x1200,0xEFEE,0xEE00,0x1112,0x1200,0xEFEE,0xEE00,
0x1112,0x12FF,0xEBEC,0xEE00,0x110F,0x0DFA,0xE6EA,0xEE01,
0x1511,0x0DFA,0xE6EC,0xF304,0x1511,0x0DFA,0xE6EC,0xF304,
0x1511,0x0DFA,0xE6EA,0xEE01,0x1514,0x12FF,0xEBEC,0xEE00,
0x1112,0x12FF,0xEBEA,0xEAFE,0x1112,0x12FF,0xEBEA,0xEAFC,
0x0C0F,0x1100,0xEFEE,0xEEFE,0x0C0F,0x1100,0xEFEE,0xEE00,
0x110F,0x0DFE,0xEFF1,0xF300,0x0C0D,0x0DFE,0xEFF1,0xF300,
0x0C0D,0x0D00,0xF4F3,0xF300,0x0C0B,0x09FF,0xF4F3,0xF3FE,
0x0809,0x09FF,0xF4F3,0xF3FE,0x0809,0x09FF,0xF4F3,0xF3FE,
0x080A,0x0C02,0xF8F7,0xF700,0x0809,0x0900,0xF8F7,0xF700,
0x0809,0x0900,0xF8F7,0xF700,0x0809,0x0900,0xF8F7,0xF700,
0x0809,0x09FF,0xF4F8,0xFC02,0x0809,0x0900,0xF8F7,0xF700,
0x0809,0x0900,0xF8F7,0xF700,0x0809,0x0900,0xF8F7,0xF700,
0x0809,0x0900,0xF8F7,0xF700,0x0809,0x0900,0xF8F7,0xF700,
0x0809,0x0900,0xF8F7,0xF700,0x0809,0x0900,0xF8F7,0xF700,
0x0806,0x04FE,0xF8F7,0xF700,0x0806,0x04FE,0xF8FA,0xFC02,
0x0806,0x04FE,0xF8FA,0xFC02,0x0809,0x0900,0xF8FA,0xFC02,
0x0806,0x04FE,0xF8FA,0xFC02,0x0806,0x04FC,0xF4F8,0xFC02,
0x0806,0x04FC,0xF4F8,0xFC02,0x0806,0x04FE,0xF8FA,0xFC02,
0x0806,0x04FE,0xF8FA,0xFC02,0x0806,0x04FE,0xF8FA,0xFC02,
0x0806,0x04FE,0xF8FA,0xFC02,0x0806,0x04FC,0xF4F8,0xFC02,
0x0806,0x04FE,0xF8FA,0xFC02,0x0806,0x04FC,0xF4F8,0xFC02,
0x0806,0x04FE,0xF8FA,0xFC02,0x0806,0x04FE,0xF8FC,0x0004,
0x0806,0x04FC,0xF4FA,0x0004,0x0806,0x04FC,0xF4F8,0xFC02,
0x0806,0x04FC,0xF4F8,0xFC02,0x0806,0x04FC,0xF4FA,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FA,0xF4FA,0x0004,
0x0806,0x04FC,0xF4FA,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FA,0xF4FA,0x0006,0x0C06,0x00FA,0xF4FA,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FA,0xF4FA,0x0004,
0x0806,0x04FE,0xF8FC,0x0004,0x0806,0x04FE,0xF8FC,0x0006,
0x0C06,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0006,
0x0C06,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0006,
0x0C06,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FF,0xFDFE,0x0001,0x0302,0x00FC,0xF8FC,0x0001,
0x0302,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FF,0xFDFE,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0004,0x0804,0x00FC,0xF8FC,0x0004,
0x0804,0x00FC,0xF8FC,0x0001,0x0302,0x00FF,0xFDFE,0x0001,
0x0302,0x00FF,0xFDFE,0x0001,0x0302,0x00FF,0xFDFE,0x0004,
0x08FF,0xF4F1,0xEFF9,0x030A,0x110B,0x04F6,0xE7EE,0xF701,
0x0C0F,0x1107,0xFDF8,0xF4F8,0xFCFC,0xFCFE,0x0008,0x110D,
0x09FD,0xEFEA,0xE6F6,0x0715,0x2315,0x05F6,0xE7E8,0xEAF9,
0x070D,0x110B,0x0400,0xFDFA,0xF8F6,0xF4FA,0x0008,0x110F,
0x0DFF,0xF0EA,0xE6F4,0x0210,0x1D12,0x05F8,0xEBEC,0xEEF9,
0x0308,0x0C07,0x00FC,0xF8F7,0xF7F7,0xF7FD,0x030C,0x1510,
0x09FB,0xECE8,0xE6F6,0x0713,0x1E12,0x05F6,0xE7EA,0xEEF9,
0x030A,0x1109,0x00FF,0xFDF8,0xF4F5,0xF7FD,0x030C,0x1510,
0x09FB,0xECE8,0xE6F4,0x0210,0x1D14,0x09FB,0xECEA,0xEAF6,
0x0208,0x0C08,0x0402,0x00FC,0xF8F6,0xF4F9,0x000A,0x1510,
0x09FD,0xF0EA,0xE6F2,0xFF0C,0x1912,0x09FD,0xF0EE,0xEEF7,
0x0005,0x0C08,0x0402,0x00FC,0xF8F6,0xF4F9,0x0008,0x110D,
0x09FF,0xF4EF,0xEBF6,0x020C,0x1510,0x09FD,0xF0F1,0xF3F9,
0x0001,0x0302,0x0000,0x00FF,0xFDFA,0xF8FC,0x0008,0x110D,
0x09FF,0xF4EF,0xEBF5,0x000A,0x150D,0x04FD,0xF4F5,0xF7FC,
0x0001,0x0304,0x0402,0x00FF,0xFDFA,0xF8FC,0x0005,0x0C0B,
0x09FF,0xF5F1,0xEFF8,0x020A,0x110B,0x04FD,0xF4F5,0xF7FC,
0x0001,0x0304,0x0402,0x00FF,0xFDFA,0xF8FC,0x0005,0x0C0B,
0x0900,0xF5F1,0xEFF8,0x020A,0x110B,0x04FD,0xF4F5,0xF7FC,
0x0001,0x0304,0x0402,0x00FF,0xFDFA,0xF8FC,0x0005,0x0C0B,
0x0900,0xF5F1,0xEFF8,0x020A,0x110B,0x04FD,0xF4F5,0xF7FC,
0x0001,0x0304,0x0402,0x00FF,0xFDFA,0xF8FC,0x0008,0x110D,
0x0900,0xF5F1,0xEFF8,0x020A,0x1109,0x00FB,0xF4F5,0xF7FC,
0x0001,0x0302,0x0000,0x00FF,0xFDFA,0xF8FA,0xFC05,0x100D,
0x0900,0xF5EF,0xEBF6,0x020C,0x150D,0x04FD,0xF4F5,0xF7FC,
0x0000,0x0001,0x0302,0x00FF,0xFDF8,0xF4F8,0xFC05,0x100D,
0x0900,0xF5F1,0xEFF8,0x020A,0x1109,0x00FB,0xF4F5,0xF7FC,
0x0001,0x0304,0x0402,0x00FF,0xFDF8,0xF4F9,0x0008,0x110D,
0x09FD,0xF0EE,0xEEF8,0x020A,0x1109,0x00FB,0xF4F5,0xF7FD,
0x0302,0x0001,0x0302,0x00FF,0xFDF8,0xF4F9,0x0008,0x110D,
0x09FD,0xF0EE,0xEEF8,0x020A,0x1109,0x00FB,0xF4F5,0xF7FC,
0x0000,0x0001,0x0302,0x00FF,0xFDF8,0xF4F9,0x0008,0x110E,
0x0900,0xF5F1,0xEFF8,0x020A,0x110A,0x01FD,0xF8F7,0xF7FB,
0x0000,0x0001,0x0302,0x00FD,0xF8F6,0xF4F9,0x0009,0x1410,
0x09FE,0xF0EE,0xEEFA,0x070C,0x110A,0x01FB,0xF4F7,0xFCFE,
0x0000,0x0001,0x0302,0x00FD,0xF8F6,0xF4F9,0x0009,0x140E,
0x05FB,0xF0EE,0xEEFA,0x070C,0x110A,0x01FB,0xF4F5,0xF7FB,
0x0000,0x0001,0x0302,0x00FD,0xF8F6,0xF4FB,0x020B,0x140E,
0x05F9,0xECEC,0xEEFA,0x070C,0x110A,0x01FB,0xF4F7,0xFCFE,
0x0000,0x0001,0x0304,0x04FF,0xF8F7,0xF7FA,0xFCF9,0xF406,
0x1C0F,0xFFF6,0xEF01,0x180B,0xFAEE,0xE3F3,0x060E,0x1510,
0x090C,0x11FB,0xE0E3,0xEAF4,0xFF07,0x1013,0x151C,0x2306,
0xE6D0,0xBBD6,0xF815,0x3233,0x311F,0x0BF0,0xD3C9,0xC2E1,
0x0418,0x2A2A,0x2822,0x1BFC,0xD8C4,0xB2D7,0x0322,0x3F37,
0x2912,0xFBE4,0xCDD1,0xD8F4,0x121D,0x261A,0x0A05,0x00F3,
0xE3DA,0xD1E9,0x051C,0x3322,0x0BFE,0xF0E9,0xE2E5,0xEAFA,
0x0A13,0x1A13,0x0A0A,0x0C00,0xF1DF,0xCDE2,0xFD13,0x2A25,
0x1C0F,0x01F5,0xE7E0,0xD9E8,0xFA0D,0x2124,0x2420,0x1B00,
0xE1C7,0xAFCC,0xF21B,0x4644,0x3B1F,0x00E7,0xCEC7,0xC2DD,
0xFC19,0x3634,0x2D1B,0x06EE,0xD3C2,0xB2D3,0xFB24,0x4F41,
0x2B0B,0xEADC,0xD1D3,0xD8EF,0x091A,0x2A21,0x130A,0x01F5,
0xE7DC,0xD1E5,0xFD19,0x3628,0x1402,0xF1ED,0xEBEA,0xEAF2,
0xFB07,0x1414,0x1212,0x1206,0xF9E6,0xD2DD,0xEC09,0x2826,
0x1F11,0x02FB,0xF4EC,0xE3E5,0xEAFC,0x0F1B,0x2622,0x1B05,
0xEED7,0xC1D3,0xEB0C,0x3033,0x3118,0xFCEC,0xDEDC,0xDCEA,
0xFA0E,0x242A,0x2C19,0x03EF,0xDBD2,0xCBE2,0xFD1C,0x3E35,
0x2607,0xE6DE,0xD9E4,0xF2FD,0x0712,0x1D19,0x1206,0xF9F0,
0xE7E5,0xE5F3,0x0115,0x2A1F,0x0FFC,0xE8EB,0xF2F9,0x0000,
0x0003,0x080C,0x110C,0x0500,0xFDF1,0xE3E7,0xEE01,0x171B,
0x1B0D,0xFFFA,0xF8F6,0xF4F1,0xEFFA,0x0714,0x221C,0x1300,
0xEDDD,0xCDDA,0xEC08,0x282D,0x2D14,0xF8EA,0xDEE0,0xE5EF,
0xFB0A,0x1C22,0x2716,0x02EF,0xDBD6,0xD4E8,0x001D,0x3A31,
0x2102,0xE2DB,0xD9E8,0xFA01,0x080E,0x1514,0x1206,0xFAF0,
0xE7E9,0xEEFA,0x0616,0x251A,0x0BF9,0xE5E9,0xF2FD,0x0705,
0x0000,0x0005,0x0C09,0x04FD,0xF5EE,0xE7EB,0xF203,0x171B,
0x1B0B,0xFAF7,0xF7F7,0xF7F2,0xECF5,0x0113,0x251E,0x13FF,
0xE9DC,0xD1DF,0xF10D,0x2C2F,0x2D14,0xF8E8,0xDBE2,0xEDF4,
0xFB0A,0x1C24,0x2B1A,0x03EC,0xD3D3,0xD8EF,0x081F,0x362C,
0x1DFF,0xDED6,0xD4E8,0x0007,0x0C10,0x1514,0x1204,0xF6EA,
0xDEE8,0xF500,0x0B16,0x2218,0x0BF9,0xE5E7,0xEDFC,0x0A07,
0x01FF,0xFD03,0x0B0B,0x09FE,0xF1EE,0xEEF4,0xFB06,0x1316,
0x160B,0xFFF9,0xF4F7,0xFCF7,0xF0F8,0x0215,0x2921,0x14FA,
0xDDD6,0xD4E5,0xF912,0x2C2F,0x2D12,0xF4E2,0xD2DF,0xF1F9,
0xFF0C,0x1C24,0x2B18,0x00E4,0xC6CD,0xDAF5,0x1125,0x372A,
0x18FB,0xD9D2,0xD0E6,0x000D,0x1917,0x1212,0x1205,0xF6E6,
0xD6E5,0xF908,0x181E,0x2316,0x06F4,0xE0E2,0xE9FB,0x0E0E,
0x0903,0xFE03,0x0B09,0x04F8,0xE8E9,0xEEF8,0x0209,0x1012,
0x1208,0xFEF7,0xF0F6,0xFFFD,0xF8FB,0x0010,0x241C,0x0FF8,
0xDDD6,0xD4E8,0x0015,0x2929,0x240F,0xF8E6,0xD6DF,0xECF8,
0x020D,0x1922,0x2B1A,0x03E6,0xC7CF,0xDFFB,0x192A,0x372B,
0x19FD,0xDED5,0xD0E4,0xFC0B,0x1817,0x1212,0x1205,0xF6E3,
0xCEDD,0xF409,0x2024,0x2415,0x03F4,0xE4E5,0xEAF9,0x090B,
0x0905,0x0005,0x0B09,0x04F6,0xE5E9,0xF2FE,0x0A0F,0x110E,
0x0901,0xF9F2,0xECF2,0xFBFC,0xFC00,0x0311,0x211A,0x0FF6,
0xD9D6,0xD8ED,0x0417,0x2927,0x200C,0xF7E5,0xD3DC,0xECFA,
0x0612,0x1D22,0x2715,0x00E1,0xBFC9,0xDEFF,0x212F,0x3827,
0x11F6,0xD9D0,0xCBE1,0xFC0E,0x2020,0x1B13,0x0AFD,0xEDDC,
0xCADD,0xF811,0x2C29,0x200E,0xFBEC,0xDFE0,0xE5F6,0x090F,
0x110A,0x0101,0x0302,0x00F4,0xE4EA,0xF503,0x1314,0x120A,
0x01FF,0xFDF7,0xF0F2,0xF7FB,0x0003,0x0811,0x1C16,0x0BF2,
0xD5D3,0xD8F2,0x101F,0x2A22,0x1403,0xF2E4,0xD6DE,0xECFD,
0x0E19,0x2221,0x1F0E,0xFBDC,0xBBC3,0xD510,0x5535,0xFEEE,
0xE7E8,0xEADE,0xCEF1,0x1F26,0x2430,0x4011,0xD6D5,0xE3C3,
0x99CA,0x112B,0x3B54,0x6F39,0xF0E9,0xF2CF,0xA2C5,0xFAFE,
0xF503,0x1713,0x0A24,0x4524,0xF4F7,0x06FB,0xE9ED,0xF6E2,
0xC7E0,0x0507,0x0124,0x513E,0x1C19,0x1E03,0xE3E2,0xE9C4,
0x95B5,0xE90A,0x274E,0x775B,0x301B,0x0CDE,0xA8AA,0xBAC3,
0xC9F4,0x2631,0x313D,0x4D20,0xE4E7,0xF9FE,0x0003,0x08E7,
0xBDC5,0xD9E2,0xE917,0x4F56,0x5142,0x3003,0xD1BA,0xAA98,
0x86B7,0xF82B,0x5D70,0x7C4D,0x10F3,0xDDC6,0xB0B8,0xC7D5,
0xE3F8,0x0D1E,0x2D3F,0x513B,0x1C09,0xFBED,0xDFD4,0xC9BF,
0xB6D3,0xF919,0x384D,0x5F52,0x3E22,0x05E9,0xCCB6,0xA29A,
0x95B5,0xDD1E,0x6678,0x7D69,0x4D1B,0xE4B8,0x9085,0x81A2,
0xCBF9,0x274C,0x6E66,0x5432,0x0BF1,0xD8E2,0xF4E6,0xCFBE,
0xAFB4,0xBFED,0x2246,0x6573,0x7D5A,0x2DF8,0xC0A0,0x8683,
0x87B2,0xE82A,0x707F,0x7F61,0x3D07,0xCEC1,0xC1B0,0x99B3,
0xDAE9,0xF212,0x3A44,0x474D,0x532F,0x00F6,0xF4CE,0x9E9E,
0xA9B8,0xC703,0x4B56,0x515D,0x6C45,0x0FF8,0xE9BE,0x8B8E,
0x9FAD,0xBB09,0x6A7F,0x7F73,0x6524,0xD7BF,0xB6A0,0x86AC,
0xE3FD,0x0E3C,0x725C,0x3128,0x2804,0xD9EC,0x0EF3,0xC7C1,
0xC6B5,0x9EE2,0x3D52,0x5465,0x7A52,0x19F2,0xCEAB,0x8893,
0xABC5,0xE021,0x6E7E,0x7E65,0x4500,0xAFB3,0xCEB4,0x8BB2,
0xEFF7,0xF01B,0x564D,0x3242,0x5D2D,0xEBE9,0xF9CC,0x8E96,
0xB2B7,0xB503,0x686D,0x5965,0x7A48,0x02EC,0xE3BB,0x8B95,
0xAFBC,0xC50E,0x6A7F,0x7F79,0x7127,0xCCBA,0xBDA6,0x87AF,
0xEB00,0x0A39,0x725B,0x2D2E,0x3C13,0xDCEA,0x0AE8,0xB2B5,
0xC7B7,0x9FE6,0x485E,0x5E6A,0x7B4D,0x0DEA,0xCDAB,0x8895,
0xAFCB,0xE826,0x6F7E,0x7E61,0x3DF7,0xA6AF,0xD1BB,0x94B8,
0xF0F9,0xF41E,0x564A,0x2A33,0x4722,0xEDEA,0xF5CD,0x989F,
0xB8BF,0xC108,0x646B,0x595A,0x6135,0xFCE4,0xD7B3,0x8A98,
0xB7CB,0xDD1E,0x6D7E,0x7E6A,0x510B,0xB9AC,0xB3A0,0x86AF,
0xEA06,0x1A43,0x7357,0x261C,0x1E03,0xE1EB,0x03E9,0xBEB6,
0xB8B0,0xA5EB,0x4864,0x6D75,0x7D4C,0x0ADF,0xB89D,0x8695,
0xAFDA,0x0A3E,0x737B,0x7652,0x25E9,0xA8AC,0xC5BF,0xAFC5,
0xE7F4,0xFB1C,0x4743,0x3137,0x4428,0x00EF,0xE4C2,0x9A99,
0xA4B8,0xCE0F,0x5D70,0x7064,0x542E,0x01E1,0xC4A6,0x8893,
0xAAD2,0xFF36,0x717F,0x7F61,0x3A01,0xC3AC,0xA09C,0x9AB7,
0xDD02,0x2844,0x5D4A,0x2B1B,0x0F06,0xFEF6,0xEDDD,0xCBBA,
0xAAB3,0xC3FA,0x3C5F,0x7974,0x663E,0x0FDA,0xA28D,0x838F,
0xA2E4,0x345D,0x787F,0x7F4E,0x0EE3,0xBDB3,0xB0BD,0xCFD9,
0xE0FB,0x1C2C,0x373D,0x4137,0x271E,0x17F6,0xCCB7,0xAAA3,
0x9FC3,0xF525,0x576D,0x7B5D,0x3217,0x01D7,0xA593,0x8A92,
0x9FDC,0x2750,0x6D78,0x7D53,0x1AF6,0xD7B2,0x8C97,0xB2C3,
0xD002,0x4152,0x5450,0x4925,0xF9F9,0x05F2,0xD2D0,0xD7C1,
0xA1BD,0xEC12,0x3657,0x7764,0x4228,0x12D8,0x9280,0x808A,
0x96EB,0x5575,0x7D7F,0x7F41,0xF0D1,0xC1AB,0x92AF,0xDFE2,
0xD6FA,0x2D35,0x2E3A,0x4C32,0x090B,0x1BF2,0xB5AA,0xAEA2,
0x90C3,0x0C31,0x4A62,0x7955,0x1F06,0xF7C8,0x8F88,0x9298,
0x9CE5,0x4260,0x6973,0x7C4A,0x04E7,0xD7B4,0x8BA0,0xC9D2,
0xD000,0x404B,0x4446,0x4A25,0xF2F6,0x0CF4,0xCCC7,0xCEB8,
0x98BB,0xF315,0x3253,0x7663,0x3F21,0x06D1,0x9180,0x808D,
0x9EF5,0x627E,0x7E7C,0x7939,0xE5C9,0xC0A9,0x8EB1,0xE9ED,
0xE0FC,0x262C,0x2536,0x4E36,0x0E0F,0x1FF5,0xB6A6,0xA69B,
0x8BC2,0x1038,0x5367,0x7A56,0x1F01,0xEBC0,0x8D8D,0x9EA7,
0xAEF6,0x536D,0x6F71,0x743D,0xF4DE,0xDAB8,0x8CA5,0xD5DE,
0xDA03,0x3D45,0x3C42,0x4E2A,0xF8F9,0x0CF0,0xC1BB,0xC4B6,
0x9FCB,0x0D29,0x3653,0x765D,0x2F13,0xFDCB,0x9086,0x8E9B,
0xA8FA,0x627E,0x7E78,0x7134,0xE4CE,0xCBB0,0x8CAC,0xE5ED,
0xE403,0x3233,0x2331,0x4A33,0x0A09,0x17ED,0xAEA4,0xADA6,
0x98D2,0x2442,0x4D61,0x7853,0x18FC,0xEAC0,0x8E94,0xAEB8,
0xBCFE,0x5568,0x6466,0x6A36,0xEFDE,0xE1BE,0x8DA4,0xD5DE,
0xDA04,0x4145,0x353C,0x4C2B,0xF8F7,0x08EB,0xBCB8,0xC3B6,
0x9FD0,0x1935,0x4059,0x7758,0x2307,0xF4C6,0x8F8D,0x9EAC,
0xBA03,0x647A,0x766C,0x6126,0xDBCD,0xD6C0,0x9EB9,0xEAEE,
0xE0FD,0x292C,0x1E32,0x5139,0x0C09,0x17EF,0xB3A7,0xAEA9,
0xA0DA,0x2C49,0x5264,0x7952,0x14FB,0xEEC4,0x8F97,0xB5BD,
0xBDF8,0x485E,0x5E5F,0x6233,0xF3E3,0xE5C5,0x98A9,0xD2DC,
0xDC03,0x393C,0x2C35,0x472B,0x00FD,0x09ED,0xC1B9,0xC0B3,
0x9FCF,0x1835,0x4058,0x765A,0x2807,0xEDC1,0x8E8E,0xA1B5,
0xCA0C,0x6174,0x6D60,0x501B,0xD9CE,0xD9C7,0xAAC0,0xE8EE,
0xE700,0x2627,0x192B,0x4835,0x0E09,0x10EA,0xB2A7,0xAEAC,
0xA8DF,0x2D49,0x5263,0x7851,0x14F8,0xE6BE,0x8E98,0xB8C8,
0xD107,0x4F61,0x5E59,0x5225,0xE9DC,0xE0C6,0x9FB0,0xD7E5,
0xE90B,0x3A3B,0x292F,0x3E27,0x01FB,0xFFE7,0xC3BE,0xC5BE,
0xB3DE,0x1E3A,0x485C,0x7255,0x2302,0xE9BF,0x8E90,0xA5BF,
0xDA16,0x6071,0x6D5D,0x4817,0xDCCE,0xD2C5,0xB1C2,0xE2EC,
0xEE07,0x2B2D,0x222B,0x3D2E,0x1107,0x04E3,0xB4A8,0xABB0,
0xB7EC,0x3351,0x5F64,0x6642,0x0EF0,0xDAB6,0x8C96,0xB5CE,
0xE412,0x4A5A,0x5A51,0x461F,0xEFDE,0xDAC5,0xAAB4,0xCCDD,
0xEB0E,0x3B41,0x3837,0x3922,0x00F6,0xF4DE,0xC1BC,0xC0C0,
0xBEE7,0x203D,0x4F5D,0x684A,0x1AFB,0xE0B9,0x8D91,0xA9C8,
0xEA1E,0x5A6A,0x6757,0x4012,0xDBCF,0xD6CD,0xBDCA,0xE3EA,
0xEA00,0x1E24,0x2035,0x545C,0x5A1F,0xCDA2,0x8880,0x8088,
0x92DB,0x3D67,0x796E,0x5734,0x0BFF,0xFDE1,0xBBB6,0xBFCE,
0xE01B,0x677A,0x7655,0x28F1,0xB4AF,0xC1C0,0xB7A8,0x96A2,
0xBAF7,0x435D,0x6151,0x3821,0x0A18,0x3627,0x05E8,0xCAC1,
0xC1FC,0x4E6F,0x7B5E,0x3101,0xD0B7,0xA797,0x8680,0x809C,
0xC40C,0x647A,0x765B,0x3712,0xEDF7,0x151D,0x1B0E,0xFDFB,
0xFF1C,0x444F,0x4C35,0x16FB,0xE0D5,0xD1B4,0x8C80,0x8086,
0x8ED6,0x3763,0x786B,0x5033,0x150E,0x1107,0xF8EB,0xE0F4,
0x1440,0x7078,0x6E47,0x13E4,0xB5AD,0xB6AB,0x978B,0x8393,
0xADE3,0x2543,0x5042,0x2720,0x232A,0x3324,0x0BF8,0xE7EB,
0xF829,0x6A7E,0x7E5F,0x3107,0xE0C2,0xAA97,0x8680,0x8099,
0xBCFA,0x435E,0x6549,0x1E08,0xFC03,0x1516,0x0F08,0x010A,
0x1A3B,0x6368,0x5D39,0x0AF6,0xEDDC,0xC8AB,0x8A80,0x808E,
0xA1DC,0x274F,0x685B,0x3E29,0x1712,0x1205,0xF4EA,0xE402,
0x3357,0x7575,0x6739,0xFDD8,0xBDB1,0xAD9D,0x8982,0x8197,
0xB7EB,0x273D,0x4135,0x2125,0x3536,0x3220,0x07F1,0xDAEE,
0x133E,0x6B72,0x6943,0x10EB,0xCBB1,0x988B,0x8380,0x80A3,
0xD60D,0x475D,0x6148,0x221A,0x2125,0x2721,0x180E,0x0312,
0x2D48,0x6359,0x3E18,0xEFDB,0xD2C3,0xB19D,0x8780,0x8098,
0xBBF0,0x2B4E,0x645C,0x463F,0x3F3A,0x3320,0x07FC,0xF613,
0x4260,0x7665,0x410F,0xD8BF,0xB3A5,0x958B,0x8380,0x809D,
0xC6F1,0x1A2B,0x2F2C,0x2634,0x4D55,0x553C,0x1802,0xF306,
0x2A48,0x6361,0x512A,0xFADB,0xC5A9,0x8A80,0x8080,0x80A5,
0xDA09,0x3843,0x3C29,0x1018,0x2E37,0x3936,0x3227,0x1A2A,
0x4755,0x5B4B,0x300F,0xEDDE,0xDAC6,0xAB97,0x8680,0x8098,
0xBBE8,0x1834,0x463F,0x2D2F,0x3B34,0x2417,0x0C09,0x092D,
0x6378,0x7D64,0x3D0E,0xDBC6,0xC0AE,0x988B,0x8380,0x809E,
0xCAE9,0x010F,0x1814,0x0B21,0x454A,0x412C,0x1105,0x011F,
0x4E68,0x786E,0x5831,0x02E7,0xD5B5,0x8D80,0x8080,0x80A9,
0xE409,0x2428,0x2113,0x010C,0x242B,0x2824,0x201F,0x1F3A,
0x626B,0x6553,0x3D1A,0xF3E7,0xEAD2,0xAE97,0x8680,0x80A1,
0xD2F6,0x1422,0x2620,0x151C,0x2B24,0x1209,0x0507,0x0B33,
0x6C7E,0x7E64,0x3D10,0xE0D1,0xD3BE,0x9F8E,0x8480,0x80A7,
0xE0FB,0x050D,0x130F,0x061C,0x403E,0x2A19,0x0902,0x0023,
0x596C,0x6C5B,0x4220,0xFBE9,0xE0BE,0x9080,0x8081,0x82AF,
0xF310,0x1B1C,0x170E,0x0313,0x3031,0x231A,0x1414,0x1934,
0x5A5C,0x4D3A,0x250D,0xF3ED,0xF2D7,0xAC94,0x8580,0x80AA,
0xE806,0x151D,0x221F,0x1821,0x3329,0x1106,0x0108,0x163B,
0x6D75,0x674C,0x2A04,0xDDD4,0xDAC6,0xA592,0x8688,0x91B5,
0xE7FA,0xFF04,0x0A0F,0x1427,0x423D,0x2616,0x0804,0x0426,
0x5A67,0x6050,0x3C1E,0xFBE9,0xE0BE,0x9080,0x8087,0x91BC,
0xF90F,0x1414,0x120A,0x000F,0x2C2D,0x1F1B,0x1B1D,0x223B,
0x5F5E,0x4A35,0x210C,0xF6EE,0xEED3,0xA891,0x8580,0x80A7,
0xE300,0x0D17,0x201F,0x1820,0x3024,0x0901,0x030F,0x2144,
0x6F70,0x5C43,0x2809,0xE8DC,0xDCC7,0xA594,0x8B8F,0x9ABC,
0xECFC,0xFC00,0x060E,0x1729,0x4036,0x1B0D,0x0608,0x0F2D,
0x585F,0x5445,0x331A,0xFEEC,0xE1BF,0x9282,0x818D,0xA0C7,
0xF809,0x090A,0x0C0B,0x0914,0x2622,0x1211,0x1820,0x293E,
0x5952,0x3928,0x1A0D,0x00FA,0xF5D6,0xA991,0x8589,0x95BA,
0xEB00,0x0610,0x1B1F,0x1F23,0x2A1B,0x00FC,0x0112,0x2946,
0x6864,0x4B33,0x1A03,0xEDE3,0xDEC7,0xA599,0x99A3,0xB3CE,
0xF0FC,0xFC01,0x0914,0x1F2C,0x3A2D,0x1207,0x040B,0x162D,
0x4A4C,0x3E31,0x2313,0x02F2,0xE2C1,0x9787,0x879A,0xB7DA,
0x0008,0x0202,0x070B,0x1019,0x241F,0x110E,0x1119,0x2433,
0x453C,0x2315,0x0C06,0x01FB,0xF2D6,0xB09D,0x949C,0xAECC,
0xF0FF,0x0209,0x121A,0x2125,0x2719,0x03FE,0x000F,0x283F,
0x554F,0x3924,0x10FE,0xECE1,0xDBC7,0xACA4,0xA6B2,0xC4DC,
0xF7FE,0xF9FC,0x010F,0x212D,0x362A,0x1107,0x040B,0x1627,
0x3B3C,0x3125,0x1A0C,0xFDEC,0xDABD,0x998E,0x93A8,0xC8E6,
0x0208,0x0202,0x070D,0x131A,0x211C,0x1111,0x1821,0x2C36,
0x3F34,0x1E10,0x0700,0xFAF2,0xE9CF,0xAB9C,0x9AA6,0xBAD5,
0xF502,0x070F,0x1A21,0x2626,0x2418,0x0601,0x0313,0x2C3F,
0x4F46,0x301C,0x0AFB,0xEBDF,0xD4C1,0xABA7,0xADBC,0xD1E5,
0xF9FE,0xF9FD,0x0514,0x262E,0x3022,0x0C05,0x0812,0x222F,
0x3A37,0x2C21,0x1609,0xFDE9,0xD3B8,0x9B96,0x9FB6,0xD6EE,
0x0106,0x0102,0x070D,0x1317,0x1A15,0x0C0F,0x1A24,0x2D33,
0x382D,0x190D,0x0601,0xFEF3,0xE3C8,0xA69B,0x9DAD,0xC6DF,
0xF701,0x030C,0x1920,0x231F,0x180D,0x0001,0x091B,0x313C,
0x4136,0x2212,0x05FB,0xF2E3,0xD1C1,0xB1B2,0xBDCB,0xDBE8,
0xF3F7,0xF7FE,0x0816,0x262B,0x281B,0x0702,0x0712,0x222A,
0x2F2B,0x221A,0x140B,0x00EC,0xD1B9,0xA2A2,0xAFC6,0xE3F5,
0x0002,0x0002,0x070F,0x1A1C,0x1711,0x0B0E,0x1720,0x292D,
0x2D24,0x170D,0x0602,0x00F4,0xE0C8,0xADA7,0xADBD,0xD4E8,
0xFA01,0x030B,0x161D,0x221C,0x1107,0x0002,0x0D1D,0x2F37,
0x392E,0x1C0F,0x04FB,0xF2E5,0xD5C6,0xB6B7,0xC2D0,0xE0EB,
0xF4F9,0xFC03,0x101D,0x2828,0x2115,0x0502,0x0712,0x2129,
0x2C2A,0x251C,0x1106,0xFCE9,0xD0BD,0xADAF,0xBCD1,0xEAF7,
0xFE01,0x0306,0x0B11,0x1818,0x130F,0x0A0E,0x1720,0x2928,
0x211B,0x140D,0x0602,0x00F2,0xD9C6,0xB6B2,0xB7C6,0xDDEE,
0xFB02,0x070E,0x171C,0x1E18,0x0D06,0x0106,0x111E,0x2B2F,
0x2D26,0x1A0F,0x04FD,0xF6E7,0xD3C5,0xBCBE,0xC7D5,0xE7F0,
0xF3F9,0x0009,0x121B,0x2421,0x160D,0x0605,0x0812,0x2128,
0x2825,0x2019,0x1006,0xFCE6,0xC9B9,0xB2B8,0xC5D8,0xEFFA,
0xFF01,0x0308,0x0F15,0x1C19,0x100B,0x090E,0x171E,0x2522,
0x1914,0x120F,0x0A05,0xFFED,0xD4C4,0xB9B8,0xBFCF,0xE6F4,
0xFD02,0x070F,0x1A1F,0x1F16,0x0902,0x0006,0x111C,0x2828,
0x211B,0x140C,0x03FD,0xF6E7,0xD3C8,0xC3C7,0xD0DD,0xEDF3,
0xF3F9,0x0009,0x121A,0x211D,0x110A,0x0505,0x0711,0x1E21,
0x1C1B,0x1B15,0x0C03,0xFBE7,0xCCBF,0xBAC1,0xCEDE,0xF0FA,
0xFF00,0x0003,0x0A0F,0x1412,0x0B09,0x090C,0x1318,0x1D1B,
0x1412,0x120F,0x0A05,0xFFEE,0xD5C8,0xC3C6,0xCDDA,0xECF6,
0xFB01,0x0911,0x1819,0x170F,0x0400,0x0005,0x0E18,0x2324,
0x1D16,0x0F09,0x02FD,0xF6E9,0xD7CE,0xCCCF,0xD6E0,0xEEF3,
0xF3F9,0x0009,0x1218,0x1D17,0x0904,0x0405,0x070E,0x1719,
0x1716,0x1610,0x07FF,0xF7E6,0xD0C6,0xC6CD,0xD8E6,0xF6FE,
0x0002,0x070B,0x1013,0x1510,0x0705,0x070B,0x1014,0x1916,
0x0F0D,0x0D0A,0x0500,0xFAEC,0xD8CE,0xCCCF,0xD6E2,0xF1FA,
0xFF03,0x0A11,0x1819,0x170F,0x0401,0x0308,0x0F15,0x1C1B,
0x1410,0x0E09,0x02FD,0xF6E9,0xD7CF,0xCFD3,0xDAE4,0xF2F9,
0xFB00,0x060E,0x171B,0x1B14,0x0802,0x0002,0x070C,0x1314,
0x1212,0x120C,0x03FB,0xF2E4,0xD2CA,0xCAD1,0xDDE9,0xF7FE,
0x0001,0x0308,0x0F13,0x1510,0x0706,0x0B0E,0x1013,0x1513,
0x0E0D,0x0D0A,0x0500,0xFAEC,0xD8CE,0xCCCF,0xD6E1,0xF1FA,
0xFF03,0x0A0F,0x1416,0x160F,0x0401,0x0309,0x1218,0x1D1B,
0x140F,0x0A06,0x01FD,0xF6EA,0xDAD2,0xD0D3,0xDAE3,0xEFF6,
0xFB00,0x060E,0x171B,0x1B15,0x0C07,0x0505,0x070E,0x1719,
0x1714,0x120C,0x03FB,0xF2E3,0xCFC6,0xC6CD,0xD8E6,0xF6FE,
0x0002,0x070A,0x0C0F,0x1412,0x0B0A,0x0C0E,0x1013,0x1513,
0x0E0D,0x0D0A,0x0500,0xFAEC,0xD8CD,0xC8CA,0xD1DF,0xF4FE,
0x0005,0x0E13,0x1516,0x160F,0x0401,0x0309,0x1219,0x201E,
0x150F,0x0A05,0xFFF9,0xF2E4,0xD2CA,0xCAD0,0xD9E4,0xF2F9,
0xFB00,0x060E,0x171C,0x1E17,0x0904,0x0406,0x0B12,0x1B1C,
0x1714,0x120C,0x03FA,0xEFDF,0xCAC3,0xC5CD,0xD8E7,0xF900,
0x0003,0x0A0E,0x1013,0x1510,0x0706,0x0B0F,0x1417,0x1917,
0x100B,0x0906,0x01FB,0xF2E3,0xCFC5,0xC3C8,0xD3E3,0xF5FE,
0x0005,0x0E14,0x1919,0x170F,0x0402,0x070E,0x171D,0x221E,
0x150F,0x0A05,0xFFF7,0xEEDF,0xCBC3,0xC5CD,0xD8E5,0xF5FC,
0xFC00,0x0910,0x171B,0x1B13,0x0503,0x0A0F,0x1418,0x1D1B,
0x1410,0x0E09,0x02F9,0xEBD9,0xC2BC,0xC3CE,0xDCEA,0xFA00,
0x0002,0x070C,0x1317,0x1915,0x0C0C,0x1317,0x191C,0x1E18,
0x0D0A,0x0C09,0x02FA,0xEFDE,0xC7BF,0xC1C9,0xD6E6,0xF800,
0x0004,0x0D13,0x1514,0x120D,0x0403,0x0A11,0x1A21,0x2520,
0x130B,0x0906,0x02FA,0xEFDF,0xCBC4,0xC8D1,0xDCE9,0xF6FE,
0x0004,0x0D13,0x1516,0x160F,0x0401,0x0307,0x0E16,0x1F20,
0x1914,0x120D,0x04F9,0xECDC,0xCAC5,0xCCD7,0xE4F1,0xFC00,
0x0002,0x060A,0x0C0E,0x100D,0x0403,0x0A0F,0x1318,0x1C1B,
0x1410,0x0E09,0x02FA,0xEFDE,0xC8C0,0xC4CE,0xDBEA,0xF901,
0x0307,0x0E12,0x120F,0x0B06,0x0202,0x060F,0x1A21,0x2521,
0x160F,0x0B04,0xFCF3,0xEADC,0xCAC5,0xCCD5,0xE0ED,0xFA00,
0x0004,0x0D13,0x1514,0x120D,0x0402,0x060C,0x131A,0x2323,
0x1A14,0x120D,0x04F7,0xE5D2,0xBEBA,0xC5D4,0xE6F3,0xFC00,
0x0003,0x0A0D,0x0D0D,0x0D09,0x0203,0x0A10,0x171C,0x1E1B,
0x1410,0x0E09,0x02F9,0xECD9,0xC3BB,0xBFCB,0xDDED,0xFA01,
0x0307,0x0E12,0x120E,0x0701,0xFE01,0x0C17,0x2228,0x2822,
0x170E,0x0702,0x00F7,0xE5D5,0xC8C4,0xC8D3,0xE3EF,0xF8FE,
0x0004,0x0D14,0x1817,0x1009,0x0302,0x060E,0x1920,0x2220,
0x1913,0x0F09,0x03F6,0xE2D0,0xC0BD,0xC6D4,0xE6F3,0xFC00,
0x0002,0x060B,0x0F0F,0x0B07,0x0507,0x0E16,0x1F21,0x1D17,
0x100D,0x0D0A,0x06FB,0xEAD8,0xC6BF,0xC1CC,0xE1F0,0xFB01,
0x0307,0x0E12,0x120D,0x04FF,0xFD00,0x0914,0x2125,0x211B,
0x150E,0x0702,0x00F9,0xECDD,0xCEC9,0xCDD9,0xEBF6,0xFAFE,
0x0003,0x0910,0x1716,0x0D06,0x0200,0x0008,0x171D,0x1B19,
0x1712,0x0C06,0x02F6,0xE2D1,0xC4C2,0xCBDA,0xEEFA,0xFE01,
0x0305,0x070B,0x0F0E,0x0702,0x0002,0x0610,0x1D1F,0x1612,
0x120F,0x0B07,0x05F9,0xE3D2,0xC7C3,0xC5D3,0xECFA,0xFE02,
0x060B,0x0F13,0x1510,0x05FF,0xFD00,0x0510,0x1D21,0x1D18,
0x140E,0x0702,0x00F6,0xE2D4,0xCBC9,0xCDDA,0xEEFA,0xFE01,
0x0307,0x0E14,0x1813,0x0600,0x0001,0x030C,0x1C20,0x1916,
0x1612,0x0C06,0x02F4,0xDBCB,0xC2C3,0xCEDE,0xF3FE,0x0001,
0x0306,0x0A0F,0x1310,0x0500,0x0003,0x0911,0x1A1B,0x1510,
0x0E0E,0x100E,0x07F8,0xDFCE,0xC3C2,0xCBDA,0xEEFA,0xFE02,
0x060B,0x0F13,0x150F,0x02FE,0x0004,0x0D17,0x2222,0x170F,
0x0B07,0x0502,0x00F6,0xE2D4,0xCBCA,0xD0DC,0xECF5,0xF7FB,
0x0008,0x1119,0x201A,0x0800,0x0002,0x060E,0x191C,0x1814,
0x1210,0x0E09,0x03F4,0xDBCC,0xC5C8,0xD6E6,0xF800,0x0000,
0x0002,0x060A,0x0C09,0x0300,0x0003,0x0910,0x1716,0x0D09,
0x090B,0x0F0F,0x0BFE,0xE8D7,0xCCCA,0xD0DE,0xF2FE,0x0003,
0x090E,0x1010,0x0E06,0xFAF6,0xFA00,0x0813,0x2122,0x170F,
0x0B07,0x0502,0x00F9,0xE9DD,0xD4D3,0xD9E3,0xF1F9,0xFBFF,
0x0207,0x0E13,0x150F,0x02FB,0xF9FB,0x0009,0x151B,0x1B19,
0x1714,0x120C,0x01F2,0xDED1,0xCDD1,0xDFEC,0xFA00,0x0000,
0x0003,0x090D,0x0D08,0x00FE,0x0003,0x0910,0x1717,0x100D,
0x0D0D,0x0D09,0x03F6,0xE2D4,0xCBCB,0xD4E2,0xF4FD,0xFF03,
0x090F,0x1311,0x0800,0xF8F6,0xFA01,0x0C16,0x1F1F,0x160F,
0x0B07,0x0502,0xFFF4,0xE2D6,0xD2D5,0xE0EB,0xF7FD,0xFF02,
0x060D,0x1618,0x140C,0x01FC,0xFC00,0x050D,0x1619,0x1715,
0x130F,0x0B04,0xFCEE,0xDACE,0xCCD2,0xE2F0,0xFB00,0x0000,
0x0207,0x0E10,0x0E08,0x00FD,0xFF04,0x0D12,0x1412,0x0C09,
0x0909,0x0B08,0x00F2,0xDED1,0xCDD0,0xDCE8,0xF6FD,0xFF03,
0x090F,0x1312,0x0C04,0xFCFA,0xFE05,0x1018,0x1C19,0x0E09,
0x0909,0x0904,0xFCEF,0xDDD3,0xD1D6,0xE4EF,0xF8FC,0xFCFE,
0x0109,0x1518,0x140C,0x01FC,0xFC00,0x050D,0x1618,0x1410,
0x0E0C,0x0A05,0x00F2,0xDED3,0xD1D7,0xE7F3,0xFC00,0x0002,
0x0609,0x0B0A,0x0600,0xFBFA,0xFE03,0x090F,0x1312,0x0C09,
0x0B0D,0x0D08,0x00F4,0xE2D7,0xD5D8,0xE1EC,0xFA00,0x0206,
0x0A0E,0x100E,0x0700,0xF8F6,0xFA00,0x0810,0x1717,0x100D,
0x0D0A,0x0602,0xFFF5,0xE5DC,0xDCE0,0xE7F0,0xFB00,0x0002,
0x060C,0x1213,0x0F07,0xFDF9,0xFBFE,0x0108,0x1115,0x1312,
0x1412,0x0C04,0xFCEF,0xDDD3,0xD3DA,0xE7F3,0xFC00,0x0205,
0x0709,0x0B0A,0x0600,0xFBFA,0xFE03,0x090F,0x1313,0x0F0D,
0x0D0C,0x0A05,0x00F4,0xE2D7,0xD5D8,0xE1EB,0xF7FD,0xFF04,
0x0D12,0x1412,0x0C02,0xF6F2,0xF900,0x050E,0x191B,0x1510,
0x0E09,0x03FE,0xFAEE,0xDAD2,0xD6DE,0xE9F3,0xFC00,0x0003,
0x090F,0x1313,0x0F07,0xFDFA,0xFE00,0x0208,0x1112,0x0C0C,
0x1212,0x0C05,0x00F2,0xDBD0,0xD2D9,0xE4F0,0xFB00,0x0003,
0x090D,0x0D0C,0x0A05,0x00FD,0xFF03,0x090F,0x1311,0x0806,
0x0A0C,0x0A06,0x02F7,0xE3D8,0xD8DC,0xE2EB,0xF6FD,0xFF04,
0x0D12,0x1412,0x0C02,0xF6F2,0xF900,0x050E,0x191B,0x1510,
0x0E09,0x03FE,0xFAF1,0xE4DF,0xE3E9,0xF0F7,0xFD00,0x0000,
0x0205,0x0707,0x0500,0xFBFA,0xFE00,0x0208,0x1113,0x0F0F,
0x1313,0x0F09,0x03F6,0xE0D6,0xDAE1,0xEAF3,0xFC00,0x0002,
0x0609,0x0905,0x00F9,0xF2F3,0xFC03,0x090F,0x1313,0x0F0D,
0x0D0D,0x0D09,0x03F8,0xE6DE,0xE0E5,0xEBF3,0xFC00,0x0002,
0x0609,0x0B09,0x03FC,0xF3F2,0xF900,0x050D,0x1618,0x1412,
0x120F,0x0B04,0xFCF1,0xE4DE,0xE0E7,0xF2FA,0xFE00,0x0000,
0x0204,0x0403,0x01FE,0xF7F6,0xFD02,0x060B,0x0F10,0x0E0E,
0x1012,0x120D,0x04F8,0xE6DC,0xDCE2,0xEDF7,0x0004,0x0406,
0x0A0C,0x0A06,0x00F8,0xEFF0,0xFB04,0x0D14,0x1816,0x0D09,
0x0B0C,0x0A04,0xFCF0,0xE1DB,0xDFE6,0xEFF6,0xFD00,0x0002,
0x0609,0x0906,0x00F8,0xEFEF,0xF801,0x0C14,0x1B1A,0x110D,
0x0D0C,0x0A04,0xFCF0,0xE1DB,0xDFE6,0xF1FA,0x0003,0x0100,
0x0204,0x0402,0xFFFA,0xF6F6,0xFD04,0x0D12,0x1413,0x0F0D,
0x0D0D,0x0D08,0xFEF1,0xE1D8,0xD8DF,0xEFFA,0xFE00,0x0000,
0x0204,0x0402,0xFFF9,0xF2F3,0xFC06,0x131B,0x1B17,0x100C,
0x0A09,0x0B08,0xFEF1,0xE4DC,0xDCE4,0xF4FD,0xFF00,0x0000,
0x0203,0x01FE,0xFAF5,0xEEEF,0xF800,0x0B14,0x1818,0x1410,
0x0E0D,0x0D09,0x00F5,0xE5DF,0xE3EB,0xF6FD,0xFF00,0x0000,
0x0000,0x00FE,0xFAF3,0xEAE9,0xF2FC,0x0610,0x1719,0x1412,
0x1414,0x0F08,0xFEF2,0xE4DE,0xE3EB,0xF6FE,0x0103,0x0100,
0x0000,0x00FE,0xF7F0,0xE9EB,0xF600,0x0B13,0x1819,0x1412,
0x1210,0x0B05,0xFDF3,0xE8E2,0xE4EB,0xF6FE,0x0103,0x0101,
0x0607,0x0500,0xF5EC,0xE5E6,0xF1FE,0x0D17,0x1C1E,0x1C19,
0x140E,0x0700,0xF8EE,0xE3E0,0xE7EF,0xFA00,0x0000,0x0000,
0x0204,0x0400,0xF8F0,0xE9E9,0xF2FD,0x0A13,0x1819,0x1716,
0x1613,0x0C03,0xF6E9,0xDBD9,0xE4F0,0xFD05,0x0707,0x0504,
0x0403,0x01FD,0xF4EC,0xE5E8,0xF805,0x131B,0x1D1C,0x1510,
0x0E0C,0x0A04,0xFAEF,0xE3DE,0xE3EA,0xF6FE,0x0104,0x0405,
0x0A0B,0x06FE,0xEEE3,0xDCE0,0xF203,0x1520,0x2524,0x1B14,
0x0F0B,0x0600,0xF5EA,0xDFDD,0xE8F2,0xFB00,0x0000,0x0000,
0x0204,0x0400,0xF8F0,0xE7E7,0xF501,0x0E17,0x1C1E,0x1C1B,
0x1B17,0x0E03,0xF6EA,0xDFDB,0xE2EB,0xF901,0x0607,0x0503,
0x0100,0xFEF9,0xF0E8,0xE1E3,0xF302,0x121B,0x1B19,0x1716,
0x1614,0x0F09,0x00F7,0xE9E3,0xE8EE,0xF7FE,0x0103,0x0101,
0x0607,0x02FB,0xEDE2,0xD9DB,0xEDFF,0x101E,0x2729,0x2019,
0x140F,0x0800,0xF8F0,0xE7E5,0xEEF7,0x0004,0x0403,0x0100,
0x0000,0x00FC,0xF1E9,0xE4E6,0xF1FD,0x0A14,0x1B1F,0x1F1E,
0x1C18,0x1107,0xFBEE,0xE0DC,0xE5F0,0xFD05,0x0707,0x0503,
0x01FF,0xFAF3,0xE8E0,0xDEE3,0xF302,0x111C,0x2122,0x201D,
0x1813,0x0C03,0xF6EC,0xE5E4,0xEBF2,0xFB00,0x0204,0x0403,
0x0100,0x00FA,0xEBE0,0xDEE3,0xF302,0x111D,0x2427,0x2521,
0x1A11,0x06FD,0xF4ED,0xE8E7,0xECF3,0xFE03,0x0100,0x0000,
0x0000,0x00FA,0xEBE0,0xDEE2,0xF0FF,0x101C,0x2122,0x201D,
0x1813,0x0C03,0xF6EC,0xE5E4,0xEBF3,0xFE03,0x0100,0x0000,
0x0000,0xFEF6,0xE6DC,0xDCE3,0xF302,0x111B,0x1D1E,0x1C1B,
0x1B18,0x1107,0xFBF0,0xE7E5,0xEEF6,0xFD00,0x0000,0x0000,
0x0000,0xFEF6,0xE6DE,0xE0E7,0xF502,0x111B,0x1B1B,0x1D1E,
0x1C17,0x0E04,0xFAF2,0xEDED,0xF4F9,0xFE00,0x0000,0x0000,
0x00FF,0xFAF2,0xE5DE,0xE0E7,0xF401,0x0E17,0x191B,0x1B1B,
0x1B18,0x1108,0xFEF6,0xF1F2,0xFB00,0x0000,0x0000,0x0000,
0x00FF,0xFAF2,0xE5DC,0xDCE3,0xF300,0x0B13,0x181B,0x1B1B,
0x1B17,0x0E05,0xFDF7,0xF5F5,0xFAFE,0x0103,0x0100,0x0000,
0x00FF,0xFAF3,0xE8E1,0xE1E6,0xF1FC,0x060E,0x1317,0x1C1E,
0x1C17,0x0E06,0x00FA,0xF3F1,0xF8FE,0x0103,0x0100,0x0000,
0xFEFB,0xF6EF,0xE3DF,0xE6EE,0xF700,0x070D,0x1013,0x181B,
0x1B18,0x1108,0xFEF7,0xF5F6,0xFD00,0x0000,0xFEFD,0xFF00,
0x00FE,0xF7EF,0xE3DE,0xE3EA,0xF600,0x0B12,0x1417,0x1C1E,
0x1C17,0x0E06,0x00FC,0xFCFD,0xFF00,0x0000,0xFEFD,0xFF00,
0x00FE,0xF7F0,0xE7E2,0xE4EA,0xF6FF,0x050A,0x0F14,0x1B1F,
0x1F1A,0x0F06,0x00FB,0xF6F6,0xFD00,0x0000,0xFEFC,0xFCFD,
0xFFFD,0xF4EB,0xE2DE,0xE3EB,0xF802,0x090D,0x1012,0x1416,
0x1918,0x1109,0x01FC,0xFCFD,0xFF00,0x0000,0xFEFC,0xFCFD,
0xFFFE,0xF7EF,0xE4DE,0xE3EB,0xF801,0x060A,0x0F12,0x1416,
0x1917,0x0E07,0x0200,0xFEFD,0xFF00,0x0000,0xFEFC,0xFCFD,
0xFFFE,0xF7F0,0xE7E2,0xE4EA,0xF5FD,0xFF02,0x090D,0x1014,
0x1B1B,0x120A,0x0400,0x0000,0x0203,0x0100,0x0000,0xFEFD,
0xFFFE,0xF8F0,0xE7E1,0xE1E7,0xF700,0x0204,0x0709,0x0B0E,
0x1314,0x0F0A,0x0400,0x0000,0x0203,0x0100,0x0000,0x0000,
0x00FE,0xF8F0,0xE7E1,0xE1E7,0xF4FE,0x0105,0x0A0D,0x1012,
0x1412,0x0903,0x0100,0x0001,0x0607,0x0200,0x0000,0xFEFD,
0xFFFE,0xF8F1,0xEAE6,0xE9EE,0xF7FD,0xFF01,0x0609,0x0B0E,
0x1314,0x0F0A,0x0400,0xFEFE,0x0104,0x0403,0x0100,0xFEFC,
0xFCFA,0xF3ED,0xE8E7,0xECF2,0xFB00,0x0204,0x0709,0x090B,
0x1115,0x130E,0x0500,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFEFA,0xF3EC,0xE6E4,0xEAF2,0xFB01,0x0608,0x0505,0x0A0D,
0x1010,0x0B07,0x0200,0x0204,0x0403,0x0100,0xFEFC,0xFCFD,
0xFFFE,0xF8EF,0xE4E0,0xE9F2,0xFB00,0x0204,0x0709,0x0B0D,
0x1010,0x0B07,0x0200,0x0001,0x0608,0x0502,0xFFFC,0xFCFC,
0xF9F6,0xF1ED,0xE8E8,0xEFF6,0xFC00,0x0203,0x0102,0x080E,
0x1314,0x0F0A,0x0400,0x0000,0x0203,0x0100,0x0000,0x0000,
0xFEFA,0xF3EC,0xE6E6,0xF1FA,0x0004,0x0403,0x0101,0x0609,
0x0B0C,0x0A07,0x0200,0x0204,0x0403,0x0100,0x0000,0x0000,
0xFEFB,0xF6F0,0xE7E4,0xEAF2,0xFB00,0x0000,0x0205,0x0A0D,
0x0D0C,0x0A07,0x0200,0x0205,0x0A0B,0x0602,0xFFFD,0xFF00,
0xFEFB,0xF6F2,0xEDEC,0xF1F5,0xFAFD,0xFF00,0x0002,0x080D,
0x1010,0x0B07,0x0200,0x0204,0x0708,0x0503,0x0100,0x00FF,
0xFAF6,0xF1ED,0xE8EA,0xF5FD,0xFF00,0x0000,0x0001,0x0609,
0x0B0C,0x0A07,0x0200,0x0203,0x0100,0x0000,0xFEFD,0xFF00,
0xFEFB,0xF6F1,0xEAE9,0xF2F9,0xFE00,0x0000,0x0002,0x080C,
0x0A07,0x0200,0x0001,0x0609,0x0907,0x0200,0xFEFD,0xFF00,
0xFEFB,0xF6F3,0xF0F1,0xF8FC,0xFCFD,0xFF00,0x0002,0x080D,
0x0D0B,0x0603,0x0100,0x0204,0x0403,0x0100,0xFEFD,0xFFFF,
0xFAF7,0xF5F3,0xF0F2,0xFB00,0x0000,0x0000,0x0001,0x0609,
0x0B0C,0x0A07,0x0200,0x0203,0x0100,0x0000,0x0000,0x00FF,
0xFAF7,0xF5F2,0xEDEE,0xF7FD,0xFF00,0x0203,0x0102,0x080C,
0x0A07,0x0200,0x0000,0x0204,0x0403,0x0100,0xFEFD,0xFF00,
0xFEFC,0xF9F6,0xF1F1,0xF8FD,0xFF00,0x0000,0x0001,0x0609,
0x0B0C,0x0A07,0x0200,0x0204,0x0403,0x0100,0xFEFD,0xFFFF,
0xFAF7,0xF7F6,0xF1F1,0xF8FD,0xFF00,0x0000,0x0001,0x0609,
0x0909,0x0907,0x0200,0x0204,0x0403,0x0100,0x0000,0x0000,
0xFEFB,0xF6F3,0xF0F1,0xF8FD,0xFF00,0x0000,0x0000,0x0204,
0x0403,0x0100,0x0000,0x0204,0x0403,0x0100,0xFEFD,0xFFFF,
0xFAF7,0xF7F7,0xF5F6,0xFC00,0x0000,0x0000,0x0001,0x0609,
0x0908,0x0503,0x0100,0x0204,0x0403,0x0100,0x0000,0x00FF,
0xFAF7,0xF7F7,0xF5F6,0xFC00,0x0000,0x0000,0x0000,0x0204,
0x0403,0x0100,0x0000,0x0204,0x0403,0x0100,0xFEFD,0xFF00,
0xFEFC,0xF9F7,0xF5F5,0xF9FD,0xFF00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0204,0x0403,0x0100,0x0000,0x0000,
0xFEFC,0xFCFC,0xFCFD,0xFF00,0x0000,0x0000,0x0000,0x0204,
0x0403,0x0100,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FF,0xFBF7,0xF7F9,0xFD00,0x0203,0x0100,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FF,0xFBF7,0xF7F9,0xFD00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0204,0x0403,0x0100,0x0000,0x0000,
0xFEFC,0xFCFD,0xFF00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0203,0x0100,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFEFC,0xF9F8,0xFBFD,0xFF00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFEFC,0xFCFD,0xFF00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFEFC,0xFCFD,0xFF00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0xFFFF
};

