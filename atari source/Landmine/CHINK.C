/* Mark sound */
#define MARK_SAMPLE_LENGTH		(0x2888+0x80)
int mark_smp_rate = 0x0082;
int mark_smp_length = MARK_SAMPLE_LENGTH;
int mark_sample[MARK_SAMPLE_LENGTH / 2] = {
0x3242,0x4954,0x4348,0x494E,0x4B00,0x002D,0x0000,0x0008,
0xFFFF,0x0000,0xFF4E,0xFF00,0x30E5,0x0000,0x2887,0x0000,
0x0000,0x0000,0x2887,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x436F,0x7079,0x7269,0x6768,0x7420,0xBD20,0x3139,0x3931,
0x2062,0x7920,0x5072,0x656D,0x6965,0x7220,0x4D75,0x7369,
0x6320,0x5365,0x7276,0x6963,0x6573,0x204C,0x7464,0x2E00,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FF,0xFEFE,0xFEFF,0x0000,0x00FF,0xFF00,0x0102,0x0202,
0x0202,0x0202,0x0100,0x0000,0x0101,0x0100,0x0000,0x0001,
0x0100,0x00FD,0xFBFC,0xFDFE,0xFF00,0x0000,0x00FC,0xF8F8,
0xF9FE,0x0204,0x0500,0xFBFC,0xFE00,0x0000,0x0000,0x0000,
0x0200,0xFFFE,0xFEFF,0x00FF,0xFDFF,0x0000,0xFF00,0x01FF,
0xFCFD,0xFEFF,0x0000,0xFF00,0x0102,0x03FD,0xF5FE,0x0605,
0x0400,0xFCFE,0x00FE,0xFBFF,0x0201,0x00FC,0xF8FB,0xFF00,
0x0201,0x0000,0x00F9,0xF3FA,0x0105,0x0904,0xFFF9,0xF4F9,
0xFEFE,0xFE01,0x0600,0xFBF9,0xF7FA,0xFD07,0x12FF,0xEA00,
0x15FD,0xE3FF,0x1A11,0x07F8,0xE9F8,0x060A,0x0DFD,0xEC01,
0x17FE,0xE3F0,0xFD08,0x1304,0xF6F5,0xF4F1,0xEF05,0x1D10,
0x03F4,0xE5F3,0x000A,0x1302,0xF200,0x10F5,0xD8E9,0xFB14,
0x2D0E,0xF0E6,0xDCFF,0x2300,0xDB00,0x250E,0xF7E4,0xD1FF,
0x2D1A,0x06E7,0xC700,0x3C04,0xCAEA,0x0B24,0x3CF5,0xABD9,
0x0917,0x24F8,0xCAF5,0x2107,0xEDEC,0xEB04,0x1F02,0xE4F7,
0x0AF3,0xDAF3,0x0B11,0x17F0,0xC7E9,0x0C15,0x1EF1,0xC1F8,
0x3011,0xF1E1,0xD210,0x500E,0xCBCE,0xD216,0x5C0F,0xC0E8,
0x111C,0x27EB,0xADF3,0x3C2A,0x16E8,0xB8F9,0x3C1B,0xF8F1,
0xEB0A,0x2BFC,0xCAEB,0x0E14,0x1AF8,0xD3FB,0x2401,0xDCF3,
0x0A1D,0x30FA,0xC2F0,0x1F12,0x04F3,0xE10D,0x3B05,0xCEDC,
0xEC20,0x5500,0xA8D9,0x0C1E,0x2EF4,0xB7F8,0x3B18,0xF4D2,
0xB1FC,0x4916,0xE1DF,0xDF09,0x34FE,0xC4F7,0x2B17,0x01E5,
0xC8F5,0x2312,0x00ED,0xDA01,0x2A00,0xD3EF,0x0D0E,0x0EF5,
0xDAFB,0x1CFF,0xDEED,0xFD16,0x30F4,0xB5DF,0x0A16,0x20F1,
0xBEFE,0x4113,0xE2D8,0xCF09,0x4713,0xDDDD,0xDE12,0x4903,
0xBAEC,0x211B,0x13ED,0xC6FF,0x3A1E,0x00F0,0xDE01,0x2607,
0xE6FA,0x1012,0x1300,0xEB03,0x1D0B,0xF9FA,0xFB12,0x2AF9,
0xC4F5,0x291C,0x0CEE,0xCF00,0x3513,0xF0EF,0xEF17,0x4005,
0xC8E6,0x0625,0x4401,0xBAF0,0x2920,0x14F0,0xCA06,0x4720,
0xF6E5,0xD50D,0x4814,0xDCEE,0x0212,0x2307,0xEAFF,0x1513,
0x1100,0xF0FE,0x0D01,0xF501,0x0F06,0xFEFF,0x000C,0x1803,
0xEEFC,0x0B18,0x24FB,0xCEF5,0x1E22,0x25F7,0xC6F7,0x2B21,
0x14EE,0xC5FF,0x3C1E,0xFEDB,0xB9FC,0x431B,0xEFE3,0xD803,
0x3108,0xDDF1,0x0713,0x1FF5,0xC7EF,0x1A14,0x0DF5,0xDCFB,
0x1B01,0xE5F0,0xFE09,0x1600,0xE9F7,0x07FE,0xF3F5,0xF713,
0x30F9,0xBCE7,0x1621,0x2AF1,0xB4F1,0x331C,0x01E1,0xC0FD,
0x3D10,0xDFD7,0xD10A,0x4703,0xBBDF,0x071B,0x2EF7,0xBCED,
0x2316,0x05ED,0xD401,0x320B,0xE1ED,0xFD0C,0x1CFC,0xD8FD,
0x240A,0xEFED,0xED0A,0x2800,0xD3EB,0x0511,0x1CF4,0xC8FC,
0x3411,0xEBDF,0xD407,0x3E07,0xCCE2,0xFC17,0x33F7,0xB5E2,
0x1520,0x28F3,0xBAF5,0x341C,0x00EB,0xD706,0x3B13,0xE8EB,
0xF00F,0x300C,0xE6FC,0x1510,0x0AFB,0xEB04,0x210B,0xF3FB,
0x040C,0x14F9,0xDA00,0x2910,0xF4F3,0xF40D,0x2701,0xD8E9,
0xFD11,0x26F8,0xC5F3,0x251A,0x0BEF,0xD102,0x3919,0xF5E9,
0xDE0F,0x4415,0xE2EC,0xF91A,0x3D09,0xD2EF,0x111D,0x2901,
0xD8F8,0x1B17,0x10FE,0xEB03,0x2010,0xFEFE,0x0007,0x0F02,
0xF503,0x1308,0xFDFE,0xFF0B,0x1902,0xEBF9,0x090A,0x0AF9,
0xE700,0x1E0E,0xFDEE,0xE002,0x280B,0xEAEF,0xF60C,0x2400,
0xD6F1,0x0F15,0x19FB,0xD9F8,0x1A10,0x03F0,0xDB00,0x2808,
0xE4EC,0xF809,0x1C00,0xE2F5,0x090C,0x0EF5,0xD8F9,0x1D0B,
0xF7F2,0xEF03,0x1900,0xE3F2,0x030C,0x13F8,0xDAF3,0x0F08,
0x00EF,0xDEFA,0x1901,0xE5EA,0xF103,0x17F6,0xD0EA,0x070B,
0x0DF6,0xDCF4,0x0F00,0xEFE7,0xE0FE,0x1E05,0xE8EA,0xEEFE,
0x0DF4,0xD6EF,0x0B02,0xF7E8,0xD9F3,0x1000,0xEEEA,0xE7FC,
0x12F8,0xDAF3,0x0F0A,0x02EC,0xD4F1,0x1003,0xF3ED,0xE800,
0x1AFB,0xD7E5,0xF603,0x11F4,0xD4ED,0x0908,0x04F4,0xE2F3,
0x05FC,0xEFEF,0xF001,0x13FF,0xE6F1,0xFEFE,0xFEF4,0xE8FC,
0x1103,0xF4EE,0xEAFE,0x13F9,0xDAED,0x0307,0x0AF8,0xE2F8,
0x1005,0xF9EC,0xDFFC,0x1A07,0xF0F3,0xF703,0x11F8,0xDAEE,
0x060B,0x0EFD,0xEAFB,0x0F07,0xFEF2,0xE5FA,0x1107,0xFBFC,
0xFE07,0x1100,0xEDF3,0xFB00,0x0707,0x0705,0x0400,0xFC00,
0x06FE,0xF3FA,0x0107,0x0D03,0xF9FE,0x0407,0x0AFA,0xE7F9,
0x0E12,0x1502,0xEE00,0x1509,0xFCF5,0xEE03,0x1C15,0x0C00,
0xF2FF,0x0E06,0xFCFA,0xF902,0x0E0A,0x0601,0xFD07,0x130B,
0x01F3,0xE4FE,0x1B19,0x1501,0xECF9,0x0806,0x03F8,0xEC0B,
0x2F12,0xF1EF,0xF00B,0x2A0F,0xEFF0,0xF30F,0x2E10,0xEDF8,
0x050A,0x0DFA,0xE4F6,0x0A15,0x1F0E,0xFCFA,0xFAF5,0xF0FD,
0x0A03,0xFB02,0x0B05,0xFFF2,0xE5FB,0x1406,0xF5F4,0xF40A,
0x230A,0xEDE9,0xE8FF,0x17F8,0xD2F1,0x151C,0x1FFC,0xD4ED,
0x0C12,0x15F8,0xD7FF,0x2C17,0xFBF8,0xF808,0x1C00,0xE0ED,
0xFF0A,0x1510,0x0804,0x00F3,0xE5EE,0xF901,0x0909,0x0908,
0x07F8,0xE8ED,0xF503,0x12F7,0xD7F3,0x1410,0x08F6,0xE2F2,
0x0502,0xFDF5,0xEC0B,0x2E14,0xF5E8,0xDEF5,0x0E00,0xEDFE,
0x110E,0x09FD,0xF0F5,0xFC04,0x0EFD,0xE9F6,0x060A,0x0C0A,
0x08F9,0xE8F1,0xFCFD,0xFC02,0x0A0F,0x1500,0xE8E5,0xE5FC,
0x1409,0xFCFC,0xFD05,0x0E00,0xF0F4,0xFBFF,0x02FC,0xF400,
0x0F14,0x1800,0xE5EC,0xF601,0x0D05,0xFC01,0x0A0C,0x0EFD,
0xE8F5,0x0608,0x09FF,0xF3FF,0x0E0F,0x0FFF,0xEDF4,0xFD01,
0x0504,0x020F,0x1E0A,0xF4EC,0xE6F4,0x0309,0x0F08,0x00FF,
0xFEFD,0xFDFD,0xFDFD,0xFD01,0x0603,0x0004,0x0806,0x03F5,
0xE5F2,0x0108,0x0F0F,0x0F00,0xF1F7,0xFFF5,0xEA01,0x1E10,
0xFEFD,0xFD01,0x0602,0xFEF8,0xF1F8,0x0003,0x060B,0x100C,
0x08F2,0xD8EC,0x0505,0x030A,0x1308,0xFDF3,0xE9F0,0xFA03,
0x0D00,0xEFF9,0x0506,0x05FF,0xF800,0x08F7,0xE2F3,0x0711,
0x190D,0xFFF2,0xE6F3,0x0300,0xF908,0x1B0F,0xFFF9,0xF4FB,
0x0303,0x02FD,0xF6FD,0x0408,0x0B0A,0x0800,0xF7EF,0xE6F6,
0x070B,0x0D0E,0x0FFB,0xE2E8,0xF1FD,0x080C,0x0E02,0xF400,
0x0E01,0xF1F6,0xFD02,0x08FD,0xEF00,0x1312,0x0EFA,0xE3F0,
0x0103,0x0301,0x0010,0x2308,0xE7EE,0xF905,0x1107,0xFCFE,
0x0009,0x1305,0xF5FD,0x06FE,0xF3F9,0x010B,0x150F,0x0604,
0x03FB,0xF2F6,0xFD09,0x170D,0x00FE,0xFE04,0x0DF9,0xE1F4,
0x0B07,0x0000,0x0009,0x1405,0xF3EC,0xE6FE,0x180C,0xFB01,
0x0B09,0x05F5,0xE2F4,0x0A0A,0x0800,0xF902,0x1005,0xF7F6,
0xF600,0x09FE,0xEEFD,0x0F0B,0x03FC,0xF4F5,0xF7FD,0x0300,
0xFD07,0x1505,0xF3F7,0xFFFC,0xF9FA,0xFB02,0x0A07,0x02FD,
0xF7FA,0xFEFB,0xF8F7,0xF706,0x1702,0xE8F7,0x0B02,0xF6F5,
0xF6FD,0x0304,0x04FF,0xF800,0x09FA,0xE7EE,0xF905,0x1207,
0xF900,0x0AFF,0xF0F2,0xF500,0x0A06,0x00FB,0xF503,0x1502,
0xEBF5,0x0401,0xFCFD,0xFE08,0x130E,0x06F3,0xDDEF,0x0605,
0x0006,0x0D07,0x00F9,0xF0F8,0x0201,0x0003,0x0805,0x02FB,
0xF3FE,0x0C0A,0x05F1,0xD9F8,0x1F13,0xFFFE,0x0000,0x00F7,
0xECF1,0xF90F,0x290A,0xE4F4,0x0C08,0x00F9,0xF1FD,0x0B09,
0x0400,0xFB03,0x0E02,0xF3F1,0xF2FF,0x0C08,0x0208,0x10FD,
0xE5EF,0xFEFE,0xFC00,0x0606,0x0604,0x03F3,0xE0FA,0x1903,
0xE6F2,0x030D,0x1603,0xEDF0,0xF700,0x0AFA,0xE4F8,0x110E,
0x07F7,0xE4F2,0x05FF,0xF3F5,0xF801,0x0C09,0x03F9,0xECF3,
0xFCFD,0xFD00,0x0200,0xFF02,0x08FD,0xEEF3,0xFC00,0x01F9,
0xEFFC,0x0B10,0x12FA,0xDCE7,0xFA03,0x0B00,0xF200,0x1407,
0xF5ED,0xE6F9,0x0F0A,0x00F3,0xE500,0x210D,0xF2EF,0xF0F4,
0xF900,0x0904,0xFE08,0x1702,0xE8EB,0xF3FE,0x0809,0x0900,
0xF6FF,0x0A06,0x00F5,0xE7F8,0x0D04,0xF7FA,0x0008,0x1200,
0xE8E5,0xE502,0x250F,0xF2F4,0xFB04,0x0E00,0xECF3,0xFF05,
0x0BFE,0xEDFE,0x130F,0x07F9,0xE9EC,0xF200,0x0F0D,0x0801,
0xFAF7,0xF5F9,0xFEFF,0x0004,0x0A00,0xF2F6,0xFD09,0x1705,
0xEDEA,0xEBFD,0x1010,0x0D05,0xFDFB,0xFBF1,0xE5FB,0x1514,
0x0DFF,0xEEF2,0xFA02,0x0B01,0xF4F8,0xFF00,0x0105,0x0909,
0x08FC,0xEEEF,0xF4FE,0x090C,0x0D06,0xFEF9,0xF4F8,0xFD00,
0x0301,0xFE02,0x0806,0x0200,0xFCFF,0x03FC,0xF3F9,0x000D,
0x1A0B,0xF9F6,0xF5FD,0x0602,0xFC02,0x0B0E,0x0FFE,0xE8F9,
0x100A,0x00FB,0xF701,0x0E09,0x0101,0x0201,0x00FA,0xF3FE,
0x0B10,0x1306,0xF6FE,0x09FE,0xEEF9,0x0909,0x0705,0x0301,
0x0001,0x04FD,0xF2FC,0x0905,0xFF00,0x0409,0x0FFE,0xE8F5,
0x0805,0xFE00,0x0305,0x0608,0x09FE,0xF0FB,0x0906,0x0004,
0x0B09,0x0401,0xFFFE,0xFE00,0x0302,0x0003,0x0705,0x0305,
0x0702,0xFCF6,0xF1FF,0x0F0D,0x0702,0xFDFA,0xF8FB,0xFF00,
0x0007,0x1004,0xF4F7,0xFD03,0x0A02,0xF8F6,0xF600,0x0E07,
0xFCFF,0x0303,0x03F6,0xE6F6,0x0B11,0x1307,0xF8F9,0xFEFD,
0xFBFB,0xFB03,0x0D07,0x00FD,0xFCFE,0x00FE,0xFBFF,0x04FC,
0xF0FE,0x0F0C,0x05FC,0xF2F6,0xFCFC,0xFBFF,0x030D,0x1803,
0xEAED,0xF502,0x1100,0xE8F8,0x0F0B,0x01F7,0xEBF7,0x0705,
0x00F0,0xDEF9,0x1B0D,0xF6F9,0x0000,0xFFF7,0xEEF7,0x020B,
0x1209,0xFEF9,0xF5F5,0xF6FB,0x0006,0x0C01,0xF2FA,0x06FC,
0xECF8,0x0903,0xF8F5,0xF4FF,0x0C10,0x11F7,0xD6EB,0x0B04,
0xF7F9,0xFE0A,0x1803,0xE8E8,0xEDFE,0x1005,0xF4F4,0xF801,
0x0DFE,0xE8F3,0x0400,0xF5F4,0xF4FE,0x090B,0x0BFB,0xE8EF,
0xFCFA,0xF500,0x0C06,0xFDFF,0x02FA,0xEFF2,0xF7FE,0x0403,
0x00FA,0xF200,0x1105,0xF3EC,0xE8FB,0x1206,0xF4FA,0x050C,
0x12FA,0xDBE6,0xFA0B,0x1C01,0xDEF1,0x100B,0xFFF2,0xE6F4,
0x0707,0x03F8,0xEB00,0x1B0B,0xF2F1,0xF5FA,0x00FF,0xFD01,
0x0708,0x0701,0xFCF9,0xF7F5,0xF302,0x160D,0xFFFA,0xF700,
0x0CF9,0xDEEF,0x0912,0x1802,0xE7F0,0x0008,0x0DF5,0xD7F3,
0x1A11,0xFDF7,0xF306,0x1E03,0xDEE0,0xEA05,0x2510,0xF0F8,
0x0803,0xFBF0,0xE5F8,0x120E,0x03FC,0xF5FD,0x0801,0xF7FB,
0x02FF,0xF9F7,0xF706,0x190A,0xF5F3,0xF6FB,0x00FA,0xF101,
0x1814,0x09F3,0xD9F2,0x160D,0xFAF6,0xF604,0x1507,0xF2F7,
0x010A,0x11FF,0xE6F3,0x080E,0x1205,0xF5FC,0x0803,0xFAF8,
0xF804,0x1409,0xF9FA,0xFF04,0x09FE,0xEDFA,0x0D07,0xFCFE,
0x0307,0x0900,0xF3F5,0xFA02,0x0B01,0xF400,0x130F,0x05F9,
0xEAF8,0x0B05,0xFBFF,0x060A,0x0E03,0xF6F6,0xF804,0x1404,
0xEFFA,0x0D09,0x0000,0x0000,0x00FF,0xFDFC,0xFC05,0x1109,
0xFCFF,0x04FB,0xECF5,0x020D,0x1808,0xF2F6,0x0006,0x0B01,
0xF6FC,0x0507,0x07FC,0xEC01,0x2010,0xF4EF,0xEFFE,0x100F,
0x0900,0xF700,0x0BFE,0xE9F5,0x0912,0x1703,0xEAF2,0x0007,
0x0B02,0xF7F8,0xFD00,0x0302,0x0006,0x0F03,0xF4F6,0xFCFF,
0x0009,0x150C,0xFFF8,0xF2F9,0x0206,0x0901,0xF7FF,0x0B03,
0xF8FB,0x0107,0x0DFD,0xE5EF,0x000C,0x180C,0xFBF7,0xF7FC,
0x01FB,0xF000,0x1712,0x05F7,0xE8F5,0x080A,0x07FE,0xF3FA,
0x0603,0xFDFD,0x0006,0x0E01,0xF0F0,0xF502,0x120E,0x04FF,
0xF9F7,0xF7FB,0x0004,0x0908,0x05FF,0xF7F5,0xF5FF,0x0B06,
0xFEFC,0xFBFC,0xFD02,0x0803,0xFBFF,0x05FD,0xF0F7,0x020B,
0x1309,0xFCF5,0xEFFA,0x0806,0x0000,0x0104,0x08FC,0xECF7,
0x080B,0x0B00,0xF1F6,0xFF06,0x0F02,0xF0F9,0x0702,0xF9F7,
0xF702,0x100D,0x06F7,0xE5F5,0x0C07,0xFDFA,0xFA02,0x0D04,
0xF6F6,0xFBFF,0x0300,0xFCFB,0xFB04,0x1007,0xFAFB,0xFFFE,
0xFB00,0x0804,0xFE03,0x0C06,0xFDFB,0xFB01,0x0A09,0x05FE,
0xF400,0x130C,0xFEF8,0xF4FF,0x0C06,0xFBFA,0xFC06,0x1406,
0xF1EF,0xF300,0x1204,0xEFF7,0x0608,0x06FF,0xF6F7,0xFB04,
0x1101,0xEAF7,0x0E0C,0x03FF,0xFBFB,0xFB00,0x0800,0xF5FD,
0x0A08,0x00FB,0xF5F6,0xF900,0x0805,0x00FD,0xFC00,0x04FF,
0xF6F8,0xFD01,0x0601,0xFBFB,0xFD05,0x0FFF,0xE5ED,0xFF05,
0x0A00,0xF2F7,0x0105,0x08F7,0xDFF0,0x0C0E,0x08FB,0xEBF6,
0x0706,0x00F7,0xEEFA,0x0A06,0xFEFA,0xF901,0x0D03,0xF3F3,
0xF7FD,0x0205,0x0803,0xFCFB,0xFBFD,0x00FE,0xFBFD,0x0002,
0x05FC,0xEFF6,0x0106,0x0AFB,0xE5F2,0x070A,0x09FD,0xECF6,
0x0705,0xFFF5,0xE9FB,0x1510,0x02F5,0xE8F8,0x0F07,0xF6F5,
0xF801,0x0E07,0xFCFA,0xFA00,0x0600,0xF6F7,0xFB00,0x0603,
0xFFFA,0xF6F8,0xFD00,0x01FF,0xFAFC,0x0001,0x01FA,0xF0F8,
0x0404,0x01F7,0xEAFA,0x110C,0x00F3,0xE6F5,0x0D08,0xFCF6,
0xF200,0x1307,0xF2F0,0xF303,0x1805,0xE7ED,0xFD08,0x1207,
0xF7F8,0xFE00,0x01FB,0xF1FB,0x0B0B,0x07FC,0xEDF2,0xFE02,
0x0504,0x03FD,0xF5FD,0x0903,0xF9FC,0x0203,0x02FC,0xF4F6,
0xFA08,0x1A0A,0xF1ED,0xF1FF,0x0F06,0xF6FA,0x0306,0x06F9,
0xE7F6,0x0F13,0x0FFB,0xE1EE,0x070C,0x0B02,0xF8FD,0x0601,
0xF9F3,0xEE01,0x1E10,0xF7F0,0xF0F9,0x0407,0x07FF,0xF3F9,
0x0400,0xF7FA,0x0104,0x0500,0xFAF5,0xF1FA,0x070B,0x0CFD,
0xE8F3,0x0706,0xFFFD,0xFC00,0x0705,0x00F9,0xF002,0x1F0E,
0xF1ED,0xF201,0x150D,0xFDF8,0xF702,0x1203,0xEBF5,0x0910,
0x1402,0xEBF2,0x020B,0x1205,0xF2F8,0x0407,0x0701,0xFA01,
0x0D08,0xFEFA,0xF8FF,0x070B,0x0D04,0xF9FA,0xFE04,0x0C08,
0x00FE,0xFB00,0x0803,0xFB00,0x0C0E,0x0EFD,0xE7F2,0x0611,
0x190A,0xF6F8,0x0204,0x03FD,0xF403,0x1C11,0xFDF1,0xE8FD,
0x1A15,0x04FA,0xF1F8,0x0305,0x0204,0x080B,0x0EFB,0xE1EB,
0x000D,0x1810,0x01F7,0xEEF5,0x0003,0x0203,0x0500,0xF7F7,
0xFAFF,0x050A,0x0E03,0xF4EB,0xE3F8,0x1617,0x0F00,0xEFEF,
0xF6FB,0xFF00,0x000B,0x1803,0xE4EA,0xFB0A,0x1A09,0xEEEE,
0xF600,0x0C04,0xF800,0x1006,0xF4E8,0xDEF5,0x1617,0x0C00,
0xF5F5,0xF9FA,0xF9FF,0x0707,0x03FC,0xF3F8,0x0104,0x0402,
0x01F9,0xEDF2,0xFD07,0x130F,0x06FA,0xECF1,0xFDFB,0xF501,
0x1512,0x07F7,0xE4F0,0x0406,0x02FC,0xF5FB,0x0505,0x0200,
0xFC00,0x08FC,0xE8EF,0x0006,0x0A09,0x0500,0xF8F5,0xF2F6,
0xFD02,0x0908,0x0400,0xFDFC,0xFCFC,0xFB00,0x06FF,0xF2FD,
0x100D,0x0200,0x00FB,0xF5F9,0x0002,0x030B,0x160B,0xFAF6,
0xF6FA,0xFF00,0x0103,0x0604,0x0000,0x00FE,0xF9FA,0xFEFC,
0xF8FF,0x0809,0x0604,0x01F8,0xECF1,0xFD00,0x0002,0x0604,
0x01FE,0xFAF6,0xF2F7,0xFEFF,0xFE00,0x0305,0x0601,0xFAF3,
0xECF3,0xFE00,0x0001,0x0201,0xFFFB,0xF7F3,0xEFF5,0xFF01,
0x0100,0x0001,0x02FE,0xF6F1,0xEDF3,0xFE03,0x0706,0x0301,
0x00F9,0xF1EF,0xF0FB,0x0808,0x0300,0xFCFD,0x00FD,0xF6F4,
0xF3F8,0x0002,0x0403,0x0000,0x01F9,0xEBEE,0xF700,0x0808,
0x0500,0xFCFA,0xFAF8,0xF7F9,0xFD00,0x0302,0x0001,0x0403,
0x02FC,0xF3EE,0xEBFB,0x1012,0x0D05,0xFCF8,0xF7F5,0xF4F8,
0xFF08,0x130C,0xFEFC,0xFF00,0x00FB,0xF2F5,0xFD04,0x0B09,
0x0404,0x06FF,0xF4EF,0xEDF9,0x0A0F,0x0F09,0x00FB,0xF8FA,
0xFEFD,0xF9FC,0x0003,0x0505,0x0501,0xFDFB,0xFBF4,0xE9F2,
0x020E,0x180F,0xFFF9,0xF6F5,0xF5F5,0xF600,0x0C0C,0x08FE,
0xF1F7,0x0202,0xFDF9,0xF5FB,0x0308,0x0B07,0x0000,0x00F9,
0xEEF2,0xFB04,0x0F0F,0x0B02,0xF8F7,0xFBFB,0xFBFD,0x0004,
0x0B09,0x0500,0xFAFC,0x00FF,0xFAF7,0xF601,0x1212,0x0B01,
0xF6F6,0xFCFC,0xFBFC,0xFF09,0x170F,0xFFF9,0xF7FA,0x0000,
0xFDFF,0x0108,0x100A,0xFEFD,0x0000,0xFEFC,0xFA00,0x070C,
0x0F08,0xFFFB,0xFAFC,0x0000,0xFD00,0x0408,0x0C08,0x01FC,
0xF6FA,0x0000,0xFD00,0x070A,0x0D04,0xF8F7,0xFB00,0x0503,
0xFF01,0x0709,0x0902,0xF9FB,0x0001,0x00FE,0xFA01,0x0F0E,
0x0700,0xF9FA,0xFF00,0x0101,0x0003,0x0907,0x0300,0xFDFD,
0xFEFF,0x00FF,0xFD00,0x0709,0x0900,0xF5F7,0xFE01,0x0403,
0x0003,0x0907,0x01FB,0xF4FA,0x0505,0x01FE,0xFB02,0x0F0A,
0xFFFA,0xF8FE,0x0504,0x0000,0x0004,0x0A04,0xFBFA,0xFD00,
0x0402,0xFDFD,0x0002,0x0605,0x01FD,0xF7FA,0x0002,0x0203,
0x0405,0x0500,0xFAF8,0xF700,0x100C,0x01FD,0xFBFF,0x0503,
0xFDFD,0x0002,0x0500,0xF7FC,0x050B,0x0F01,0xEDF1,0xFF04,
0x0604,0x0102,0x0300,0xFDF8,0xF4FD,0x0C0C,0x06FF,0xF6FA,
0x0204,0x0404,0x0400,0xF8FC,0x0403,0xFE00,0x0705,0x00FA,
0xF3F8,0x0009,0x1206,0xF3F5,0x0003,0x03FF,0xF8FE,0x0A06,
0xFCF8,0xF800,0x0C06,0xFAF6,0xF6FC,0x0403,0xFEFF,0x0201,
0xFEF9,0xF3F9,0x0204,0x0401,0xFFFE,0xFEFD,0xFBFE,0x0200,
0xFCFE,0x0302,0x00FE,0xFEFE,0xFDFC,0xFCFB,0xFB00,0x0704,
0xFCFA,0xFAFC,0xFEFB,0xF5FB,0x0406,0x03FE,0xF6F8,0xFFFF,
0xFEFA,0xF6FD,0x0906,0xFDFA,0xFAFD,0x00FD,0xF7F8,0xFB00,
0x0501,0xF9F9,0xFCFD,0xFDFB,0xF8FB,0xFF00,0x00FF,0xFEFC,
0xFAFC,0xFFFC,0xF5F9,0x0001,0x01FF,0xFCF9,0xF8FB,0x00FD,
0xF4FA,0x0506,0x03FD,0xF5F8,0x0001,0x00FD,0xF7FB,0x0104,
0x04FF,0xF6F9,0x00FF,0xF9F7,0xF8FF,0x0707,0x04FA,0xEDF2,
0x0000,0xFBFB,0xFC00,0x0300,0xFAF7,0xF6FF,0x0B03,0xF3F2,
0xF801,0x0B09,0x00FC,0xF9FA,0xFDFB,0xF5FC,0x080B,0x0B00,
0xF0F0,0xF900,0x0905,0xFCFA,0xFBFF,0x0300,0xFBFD,0x0302,
0xFDF8,0xF3F9,0x020A,0x1005,0xF3F2,0xF8FD,0x0002,0x0203,
0x0402,0x00F8,0xEEF8,0x0A0B,0x04FD,0xF4F7,0x0004,0x0702,
0xFAFC,0x0200,0xF8F7,0xFA02,0x0E08,0xFAF5,0xF5F9,0x0003,
0x0602,0xFCFD,0x02FF,0xF6FC,0x0808,0x02FE,0xFBF9,0xF900,
0x0C0B,0x04FF,0xFAF9,0xFAFF,0x0405,0x0504,0x04FF,0xF8F7,
0xFA01,0x0C09,0x00FC,0xFAFE,0x0303,0x0000,0x0000,0x00FC,
0xF7FD,0x0809,0x0600,0xF9F9,0xFD01,0x0505,0x0202,0x0200,
0xFCFC,0xFF01,0x0504,0x0100,0x0000,0x0001,0x0302,0x0000,
0xFFFF,0xFF00,0x0101,0x00FF,0xFEFC,0xFAFC,0x0003,0x0603,
0xFEFD,0xFEFE,0xFD00,0x0504,0x00FF,0xFFFF,0xFF00,0x0301,
0xFFFF,0x0000,0x0000,0x0201,0x00FE,0xFBFC,0xFF00,0x0302,
0x0000,0xFFFE,0xFEFE,0xFF00,0x0200,0xFCFC,0xFDFF,0x0001,
0x01FF,0xFBFA,0xFBFE,0x0001,0x0101,0x0100,0xFDFA,0xF7FC,
0x0304,0x01FD,0xF7FA,0x0000,0x00FD,0xFAFD,0x0200,0xFAF9,
0xFB00,0x0602,0xF9F5,0xF4FB,0x0405,0x0100,0xFFFE,0xFEFC,
0xF9FB,0x0003,0x0604,0xFEFB,0xFAFE,0x0503,0xFEFD,0x0001,
0x0101,0x0100,0xFE00,0x0702,0xF7F8,0xFF05,0x0B08,0x00FC,
0xFCFF,0x0401,0xFAFC,0x0307,0x0900,0xF0F5,0x0307,0x0400,
0xF8F9,0xFF03,0x0803,0xFAFD,0x0604,0xFCF9,0xFAFF,0x0508,
0x0800,0xF6F8,0x0003,0x0302,0x0000,0x0504,0x01FF,0xFCFF,
0x0406,0x05FF,0xF4FB,0x090B,0x0501,0xFFFF,0x0102,0x02FE,
0xF600,0x1211,0x05FF,0xF9FD,0x0606,0x0100,0x0003,0x0906,
0xFFFC,0xFC02,0x0D08,0xFDFC,0x0103,0x0504,0x0200,0xFF00,
0x0201,0xFF00,0x0405,0x0402,0x00FE,0xFBFD,0x0204,0x0400,
0xFBFC,0x0102,0x00FD,0xFAFD,0x0202,0xFFFB,0xF7FE,0x0B08,
0xFDF9,0xF7FC,0x0404,0xFFFD,0xFD01,0x0802,0xF6F6,0xFE01,
0x0402,0xFDFD,0x0001,0x01FF,0xFBFB,0xFE00,0x0000,0xFFFE,
0xFCFD,0x0000,0x00FE,0xFBFD,0x0202,0xFFFD,0xFC00,0x0805,
0xFDF8,0xF5FC,0x0908,0x00FB,0xF8FC,0x0300,0xF7F8,0xFE05,
0x0D03,0xF0F1,0xFF06,0x0C02,0xF2F3,0xFD01,0x0300,0xFAFF,
0x0905,0xFBF4,0xF1F9,0x0609,0x05FE,0xF4F6,0xFE00,0x0202,
0x0200,0xFEFE,0x00FF,0xFC00,0x0808,0x04FB,0xEEF4,0x020B,
0x1106,0xF3F2,0xFA00,0x0400,0xF9FE,0x0A06,0xF9F3,0xF0FD,
0x100F,0x03F7,0xEBF5,0x0A0A,0x00FD,0xFF00,0x03FD,0xF2F5,
0xFF06,0x0E06,0xF6F1,0xF4FD,0x0A0A,0x01FD,0xFAFC,0xFF00,
0x00FF,0xFDFF,0x03FF,0xF4F5,0xFC03,0x0C07,0xFBF3,0xEEF8,
0x090A,0x01FD,0xFAFD,0x02FE,0xF3F7,0x0108,0x0D01,0xEDED,
0xF904,0x110A,0xF8F5,0xFBFF,0x0200,0xF8FE,0x0A09,0x00F7,
0xEDF3,0x0209,0x0C01,0xF1F2,0xFD01,0x0100,0xFDFE,0x0000,
0xFEFA,0xF5FC,0x090B,0x06FA,0xEAEF,0x0107,0x0500,0xFBFB,
0xFEFF,0xFFFB,0xF4FC,0x0C09,0xFCF6,0xF4F9,0x0105,0x05FF,
0xF3F7,0x0303,0xFEFB,0xF9FF,0x0906,0xFCF5,0xF1FA,0x090A,
0x02FC,0xF5F9,0x0303,0xFDFA,0xF8FF,0x0A06,0xF9F4,0xF600,
0x0F0B,0xFCF6,0xF4FB,0x0705,0xFCFC,0x0003,0x06FD,0xECF1,
0x020A,0x0C05,0xFBF6,0xF6FD,0x0706,0xFEFD,0x0001,0x00FE,
0xFBFD,0x0206,0x0901,0xF4F1,0xF501,0x120F,0x00FB,0xFBFE,
0x0100,0xFAFD,0x050A,0x0D00,0xEBF0,0x040E,0x1106,0xF5F5,
0x0005,0x0702,0xFB00,0x0E09,0xFAF4,0xF2FE,0x1011,0x06FF,
0xF8F9,0xFF01,0x0304,0x0603,0xFFFD,0xFDFE,0x0003,0x0605,
0x01FB,0xF1F5,0x0008,0x0E07,0xF8F5,0xFAFD,0x0000,0xFD00,
0x0905,0xFBF5,0xF2FC,0x0D0C,0x01F8,0xF0F6,0x0507,0x0000,
0x0505,0x00FB,0xF3F7,0x0007,0x0D07,0xFBF8,0xFAFE,0x0204,
0x0503,0xFFFD,0xFCFE,0x0204,0x0406,0x0A01,0xF2F0,0xF802,
0x0F0F,0x0700,0xF6F9,0x0201,0xFBFE,0x0708,0x03FE,0xF8FB,
0x0207,0x0904,0xFCF8,0xF8FD,0x0406,0x0606,0x0601,0xF8F6,
0xF9FE,0x0308,0x0D06,0xFAF8,0xFC00,0x0203,0x0100,0xFDFE,
0x0200,0xFC00,0x0A0A,0x03FA,0xEFF3,0x0008,0x0D0A,0x02FF,
0xFFFD,0xFAFB,0x0006,0x0F0B,0x00FC,0xFCFE,0x0003,0x0603,
0xFDFC,0xFF00,0x0204,0x0706,0x01FE,0xFBF9,0xF9FE,0x050A,
0x0C03,0xF5F4,0xFC00,0x0100,0xFF00,0x0100,0xFEFB,0xF8FF,
0x0B07,0xFAF4,0xF4FC,0x0708,0x0301,0x0100,0xFDF9,0xF4F9,
0x050A,0x0A03,0xFAF9,0xFEFF,0xFF00,0x0201,0xFFFF,0x0000,
0x0001,0x0402,0x00FE,0xFCFB,0xF900,0x0D0C,0x00FC,0xFCFE,
0x0000,0xFE00,0x0205,0x0804,0xFDFD,0x0003,0x0601,0xF6F9,
0x0406,0x0101,0x0303,0x0100,0xFEFC,0xF900,0x0C0B,0x0300,
0x0100,0xFF00,0x0203,0x0202,0x0402,0xFFFF,0x0002,0x0502,
0xFEFB,0xFBFD,0x0004,0x0905,0xFEFC,0xFEFD,0xFAFB,0x0001,
0x0101,0x00FD,0xF7F9,0x0001,0xFEFB,0xF8FA,0xFD01,0x0602,
0xFBF9,0xFBFA,0xF8F8,0xFA00,0x0704,0xFBF5,0xF3F7,0xFF01,
0x00FC,0xF5F8,0x0000,0xFAFA,0xFFFF,0xFCF9,0xF7F9,0xFE01,
0x0402,0xFDF9,0xF6F7,0xFCFF,0x0000,0xFDFA,0xF7FA,0x00FF,
0xF7F8,0x0000,0xF9F5,0xF2F9,0x0608,0x03F9,0xEAEF,0x0003,
0xFFFB,0xF9FD,0x0601,0xF1EF,0xF700,0x0904,0xF7F4,0xF9FD,
0x0100,0xF9F9,0xFEFF,0xFDFA,0xF8FC,0x0405,0x00FC,0xF8F8,
0xFAFD,0x0103,0x0300,0xFBFB,0xFF00,0x00FE,0xF9FC,0x0302,
0xFCF9,0xF8FF,0x0C08,0xF9F2,0xF2FC,0x0B08,0xF9F8,0x0004,
0x06FD,0xECF1,0x030D,0x0F04,0xF0F2,0x0307,0x01FD,0xF8FB,
0x0404,0x00FC,0xFAFF,0x0806,0xFCF8,0xFAFC,0xFE00,0x0203,
0x03FF,0xF6F7,0xFEFF,0xFDFD,0xFE00,0x0500,0xF4F2,0xF700,
0x0D05,0xEEEC,0xFA03,0x0A03,0xF3F6,0x0407,0x00F6,0xE8F2,
0x0E12,0x06FB,0xEDF3,0x0708,0xFDFA,0xFD02,0x0A04,0xF5F5,
0x0008,0x0D06,0xF8F6,0xFD00,0x0204,0x0604,0x01FD,0xF7F9,
0x0103,0x0100,0x0205,0x0A01,0xF1F4,0x050E,0x1004,0xF0F3,
0x070D,0x0A01,0xF5FB,0x0E0D,0xFDF5,0xF300,0x1A16,0xFDF4,
0xF700,0x0E0C,0xFDFC,0x040A,0x0D06,0xF8FA,0x070C,0x0A05,
0xFE00,0x080A,0x0705,0x0403,0x0201,0x0003,0x090B,0x0907,
0x0505,0x0503,0xFF03,0x1011,0x0A03,0xFD00,0x0B0C,0x0600,
0xFC01,0x110D,0xFDFA,0x020A,0x1109,0xF7F5,0xFE06,0x0F09,
0xFAFA,0x0406,0x03FC,0xF1F7,0x090B,0x01FC,0xF9FD,0x0505,
0x00FC,0xF7F8,0xFFFE,0xF8FB,0x0302,0xFAF7,0xF8F8,0xF8F9,
0xFBFD,0x0000,0xFBF6,0xF2F6,0x00FF,0xF4F1,0xF5FC,0x0400,
0xF4F4,0xFDFF,0xFCF5,0xECF2,0x0307,0x02FA,0xEEF1,0x0001,
0xF8F5,0xF7FB,0x0100,0xF7F5,0xFAFF,0x03FF,0xF1F0,0xF7FE,
0x0202,0xFFFE,0xFEFD,0xF9F7,0xF7FA,0x0002,0x00FE,0xFEFD,
0xFCFE,0x0100,0xFDFB,0xFBFF,0x0305,0x0501,0xFCFB,0xFF00,
0xFEFF,0x0004,0x0B08,0xFDF9,0xFD01,0x0605,0xFFFD,0xFF02,
0x0806,0xFF00,0x0605,0xFEF9,0xF7FE,0x0A0E,0x0A04,0xFDFD,
0x0203,0x0000,0x0104,0x0604,0x0000,0x0304,0x0301,0xFFFE,
0x0001,0x0406,0x0604,0x00FE,0xFDFF,0x0202,0x0001,0x0404,
0x0200,0xFCFE,0x0403,0xFFFB,0xF9FD,0x0507,0x02FF,0xFCFC,
0xFEFD,0xF8FA,0x0005,0x0702,0xFAF8,0xFDFE,0xFDFD,0xFD00,
0x0302,0xFEFC,0xFEFE,0xFEFD,0xFBFA,0xFAFC,0xFE00,0x0101,
0x00FD,0xF6F6,0xFDFE,0xFCFD,0xFF00,0x00FF,0xFAF8,0xF8FC,
0x0000,0xF9F9,0xFE00,0x01FF,0xF8F9,0x0100,0xFAF8,0xFC00,
0x0405,0x0300,0xFCFB,0xFDFD,0xFD00,0x0607,0x0300,0xFEFD,
0xFF00,0x0000,0x0001,0x0202,0x0102,0x0404,0x02FF,0xFBFD,
0x0305,0x0304,0x0807,0x02FF,0xFDFD,0x0005,0x0B08,0x00FF,
0x0506,0x0403,0x0302,0x0000,0xFF00,0x0307,0x0B09,0x0400,
0xFDFE,0x0103,0x0508,0x0C09,0x00FE,0x0000,0x0001,0x0404,
0x0202,0x0202,0x0204,0x0704,0xFEFC,0x0002,0x0506,0x0505,
0x0704,0xFFFC,0xFBFE,0x0407,0x0603,0x0000,0x0201,0xFCFC,
0x0102,0x00FF,0xFF00,0x0001,0x0300,0xFAF9,0xFDFD,0xFBFD,
0x0003,0x0300,0xFCF9,0xF8F9,0xFBFE,0x0001,0x0100,0xFDFA,
0xF8FA,0xFEFF,0xFBFB,0xFDFE,0xFDFE,0x0000,0xFEFC,0xFAF8,
0xF8FB,0x0000,0xFDFC,0xFDFC,0xFAF9,0xF8F9,0xFDFD,0xFBFB,
0xFBFD,0xFFFE,0xF9F7,0xF9FB,0xFDFC,0xFAFC,0x0101,0xFDFA,
0xF8FA,0xFEFE,0xFCFB,0xFCFF,0x0302,0xFDFA,0xF9F8,0xF8FA,
0xFCFF,0x0202,0x00FD,0xFBFB,0xFBFC,0xFDFF,0x0000,0xFEFE,
0x0001,0x0300,0xFBFA,0xFEFF,0xFFFF,0xFF01,0x0706,0x00FB,
0xF7FB,0x0305,0x0100,0x0203,0x0502,0xFCFB,0x0003,0x0503,
0xFDFD,0x0206,0x0804,0xFDFC,0x0000,0xFFFF,0x0003,0x0908,
0x01FD,0xFBFC,0x0002,0x0303,0x0301,0x00FF,0xFF00,0x0101,
0x0000,0x0000,0xFCFD,0x0206,0x0803,0xF9F5,0xF9FE,0x0303,
0xFEFF,0x0505,0xFFF8,0xF2F6,0x0408,0x01FC,0xF8F9,0x0000,
0xFCF9,0xF9FC,0x01FE,0xF2F2,0xFD03,0x0501,0xFAF5,0xF4F7,
0xFD00,0xFEFE,0x00FF,0xFDFB,0xF9F9,0xFAFD,0x0000,0xFEFA,
0xF6F9,0x0203,0xFEFA,0xF6F8,0xFF00,0xFEFC,0xFBFF,0x0703,
0xF5F1,0xF900,0x0806,0xFCF8,0xFBFF,0x0400,0xF4F4,0xFF04,
0x0400,0xF7F9,0x0307,0x0300,0xFAFA,0xFE00,0x00FE,0xFAFD,
0x0506,0x00FC,0xFCFC,0xFD00,0x0403,0xFEFD,0x0001,0x00FF,
0xFEFF,0x0002,0x0401,0xF8F8,0x0005,0x0903,0xF5F5,0x0005,
0x0502,0xFF00,0x0506,0x02FC,0xF4FA,0x0C0F,0x03FC,0xF8FC,
0x0607,0x00FC,0xFE01,0x0704,0xF9F7,0x0006,0x0906,0xFFFC,
0xFE00,0x0404,0x0201,0x0100,0x0000,0x0101,0x0001,0x0303,
0x01FE,0xF8FC,0x0709,0x03FF,0xF9FB,0x0204,0x0200,0xFE00,
0x0603,0xF8F6,0xFE04,0x0A06,0xFAF6,0xFA00,0x0503,0xFBFB,
0x0203,0x00FC,0xF9FB,0x0103,0x01FF,0xFBFC,0x0102,0xFFFE,
0x0000,0xFFFE,0xFCFE,0x0202,0xFEFE,0x0101,0xFEFC,0xFCFE,
0x0203,0x01FE,0xF9FB,0x0404,0xFBF9,0xFD00,0x0401,0xF8F7,
0xFE02,0x0400,0xF7F7,0xFF02,0x0200,0xFCFE,0x0404,0xFFFC,
0xFCFF,0x0404,0xFFFE,0x0001,0x0100,0xFE00,0x0302,0xFCFC,
0x0104,0x0200,0xFDFE,0x0203,0x00FE,0xFAFF,0x0C0A,0xFBF6,
0xFC01,0x0906,0xFBF8,0x0004,0x0805,0xFCFC,0x0507,0x03FE,
0xF6FA,0x070A,0x02FF,0xFF00,0x0202,0x0000,0x0103,0x0502,
0xFDFD,0x0203,0x00FF,0x0201,0xFEFC,0xFC00,0x0807,0x00FB,
0xF7FB,0x0405,0xFEFD,0x0005,0x0903,0xF5F5,0x040A,0x06FF,
0xF3F4,0x0208,0x0702,0xFAFB,0x0404,0xF9F6,0xFC02,0x0A09,
0xFEF8,0xF9FC,0x0002,0x0000,0x00FF,0xFCFC,0xFE00,0x0402,
0xFBF8,0xFAFA,0xFAFC,0x0104,0x0601,0xF4F0,0xF6FE,0x0706,
0xFBF8,0xFE00,0xFEFB,0xF7FB,0x0708,0xFFF6,0xEEF4,0x070C,
0x04FE,0xF9F8,0xFCFC,0xF6F8,0x0208,0x0800,0xF3F0,0xF900,
0x0303,0xFFFD,0xFFFE,0xFBFC,0x0103,0x0200,0xFAF8,0xFBFD,
0xFF01,0x0506,0x02FC,0xF2F2,0xFC02,0x0805,0xFAF8,0x0002,
0xFEFB,0xFAFF,0x0807,0xFAF5,0xF800,0x0B0B,0x00FA,0xFBFE,
0x0302,0xFBFE,0x0A0D,0x05FF,0xF7F8,0x0106,0x0503,0x0000,
0x0303,0xFFFF,0x0304,0x02FF,0xFBFB,0x0003,0x0102,0x0404,
0x00FD,0xF7FA,0x0308,0x0601,0xFCFD,0x0505,0xFCF9,0xFF03,
0x0603,0xFAFA,0x0308,0x0903,0xF6F5,0x0005,0x0300,0xFF00,
0x0807,0xFEFA,0xFD00,0x0605,0x00FD,0xFF00,0x0202,0xFFFF,
0x0302,0xFCFB,0xFF01,0x0302,0x00FF,0xFFFE,0xFDFC,0xFBFF,
0x0606,0xFDF9,0xFD00,0x0301,0xFAF9,0x0002,0x00FE,0xFCFE,
0x0507,0x01FB,0xF5F7,0x0206,0x00FF,0x0203,0x01FE,0xF8F8,
0xFE02,0x0402,0xFBF9,0xFF01,0x00FF,0xFFFF,0xFFFD,0xF9FA,
0x0004,0x0401,0xFDFB,0xFDFD,0xFBFD,0x0104,0x0602,0xF9F7,
0xFD01,0x0302,0xFEFD,0xFF00,0xFEFD,0xFF01,0x0603,0xF9F6,
0xFB00,0x0405,0x0200,0x0000,0xFEFC,0xFAFE,0x0607,0x00FD,
0xFBFD,0x0204,0x0100,0x0000,0xFEFC,0xFC00,0x0607,0x03FF,
0xF9F9,0x0002,0x0102,0x0504,0xFFFC,0xFAFD,0x0407,0x0501,
0xFCFB,0x0002,0x0001,0x0303,0x00FC,0xF6F9,0x0309,0x0804,
0xFFFB,0xFBFC,0xFF01,0x0407,0x0904,0xF8F5,0xFF05,0x0807,
0x01FE,0xFEFE,0xFE00,0x0306,0x0805,0xFDF8,0xF9FE,0x0609,
0x0301,0x0100,0xFAF9,0xFE02,0x0707,0x01FE,0xFAFB,0x0103,
0x0100,0x0100,0xFDFB,0xFC00,0x0606,0x00FB,0xFAFB,0xFF00,
0x0000,0x0202,0x00FC,0xF7F9,0x0306,0x01FE,0xFBFB,0xFEFF,
0xFFFF,0x0001,0x02FF,0xF6F5,0x0005,0x0502,0xFDFB,0xFF00,
0xFEFE,0x0000,0x0200,0xFBF9,0xFCFF,0x0202,0xFFFF,0x0201,
0xFDFC,0xFF01,0x0302,0xFCFA,0xFCFF,0x0000,0xFDFD,0x0101,
0xFDFA,0xFAFD,0x0304,0xFDFA,0xFE00,0x0201,0xFCFC,0x0001,
0x00FE,0xFAFC,0x0406,0x00FC,0xFCFE,0x0101,0xFEFD,0x0001,
0x01FF,0xFBFC,0x0204,0x00FF,0xFDFE,0x0102,0xFFFE,0x0000,
0xFEFC,0xFAFC,0x0204,0x01FE,0xF9FA,0x0001,0xFCFB,0x0002,
0x02FF,0xF8F8,0x0003,0x01FF,0xFCFC,0x0000,0xFEFD,0xFF00,
0x0300,0xF8F6,0xFE02,0x0200,0xFCFB,0xFFFF,0xFDFD,0xFF01,
0x0502,0xFAF7,0xFBFF,0x0201,0xFBFA,0x0001,0xFCFA,0xFC00,
0x0403,0xFDF8,0xF8FB,0x0102,0xFEFD,0x0000,0xFCF9,0xF7F9,
0x0002,0xFFFC,0xFAFB,0xFF00,0xFEFD,0xFF00,0xFFFC,0xF7F9,
0x0204,0xFEFB,0xFDFE,0xFDFC,0xFBFC,0x0002,0x0400,0xF5F4,
0x0005,0xFFFB,0xFBFE,0x0201,0xFBF8,0xFC00,0x0300,0xF8F6,
0xFD01,0x0300,0xF8F7,0x0104,0xFDFA,0xFE00,0x0000,0xFDFC,
0xFCFE,0x0201,0xFBFA,0x0000,0xFCFB,0xFF01,0x0503,0xFDFB,
0xFE00,0x0000,0xFE00,0x0505,0xFFFB,0xFBFF,0x0606,0xFCF9,
0xFE01,0x0301,0xFDFD,0x0103,0x01FE,0xF7F9,0x0408,0x03FF,
0xFDFD,0x0000,0xFCFC,0x0002,0x01FF,0xFAFA,0xFF01,0x00FF,
0xFCFC,0xFF00,0xFEFF,0x0304,0x00FC,0xFAFB,0x0000,0xFFFE,
0x0000,0x00FE,0xF7F7,0xFE01,0x0200,0xF7F6,0xFF03,0x0200,
0xFBFA,0xFF00,0xFBFA,0xFC00,0x0504,0xFCF7,0xF8FB,0x0001,
0xFEFC,0xFEFF,0xFFFE,0xFCFD,0xFF00,0x00FE,0xFAFA,0xFE00,
0x0000,0x00FF,0xFAF9,0xFCFF,0x0000,0xFDFC,0xFF00,0x00FF,
0xFDFE,0x0203,0xFFFB,0xF9FC,0x0608,0x00FA,0xFAFD,0x0102,
0xFDFC,0x0004,0x0501,0xF9F7,0x0005,0x0502,0xFAF9,0x0106,
0x0401,0x00FF,0x0000,0xFEFD,0xFF01,0x0606,0x01FE,0xFEFE,
0x0001,0x0202,0x0000,0x0001,0x0304,0x0200,0xFFFF,0x0000,
0xFF00,0x0609,0x0702,0xF9F7,0xFF04,0x0706,0x00FF,0x0304,
0x01FF,0xFE00,0x0607,0x00FC,0xFC00,0x090B,0x03FF,0xFEFF,
0x0000,0xFF00,0x0608,0x0502,0xFEFD,0xFF01,0x0404,0x0000,
0x0102,0x0000,0x0202,0x00FE,0x0000,0x0001,0x0102,0x0505,
0x00FC,0xFCFE,0x0204,0x0200,0xFF00,0x0505,0xFEFB,0xFF01,
0x0301,0xFDFD,0x0105,0x0704,0xFCFA,0x0003,0x0100,0x0001,
0x0707,0x00FC,0xFBFD,0x0305,0x0200,0x0000,0x0101,0x0000,
0x0202,0x00FF,0x0000,0x0001,0x0304,0x0301,0xFFFC,0xFC00,
0x0608,0x0200,0x0203,0x01FF,0xFDFE,0x0407,0x02FF,0xFDFF,
0x0709,0x02FE,0xFEFF,0x0303,0xFFFF,0x060A,0x0803,0xFCF9,
0xFD00,0x0405,0x0100,0x0302,0xFEFD,0x0002,0x0201,0x0000,
0xFEFF,0x0305,0x0503,0x00FE,0xFBFC,0x0206,0x0606,0x0402,
0x0100,0xFEFF,0x0306,0x0806,0x00FF,0x0104,0x0605,0x0100,
0x0000,0x0000,0x0305,0x0705,0x00FD,0xFBFC,0x0104,0x0201,
0x0302,0x00FE,0x0000,0xFEFE,0x0000,0xFEFE,0x0000,0x0101,
0x00FF,0xFBFA,0xFD00,0x0000,0x00FF,0xFFFD,0xFAF9,0xFBFC,
0xFDFD,0xFDFC,0xFCFE,0x0000,0xFBF9,0xFBFB,0xFBFC,0xFF00,
0xFFFE,0xFEFD,0xF8F7,0xFBFE,0xFFFF,0xFFFE,0xFDFD,0xFEFE,
0xFEFD,0xFDFD,0xFCFC,0xFCFE,0x0001,0xFEFB,0xFBFA,0xFAFB,
0xFEFF,0xFFFF,0xFFFE,0xFBFA,0xFCFD,0xFCFC,0xFDFD,0xFDFD,
0xFFFF,0xFDFB,0xFBFB,0xFBFC,0xFEFE,0xFEFE,0xFEFE,0xFCFB,
0xFBFD,0xFFFF,0xFDFC,0xFF00,0xFFFE,0xFEFD,0xFDFD,0xFFFE,
0xFCFC,0x0001,0xFFFD,0xFCFC,0xFDFE,0xFFFF,0xFF00,0x0100,
0xFEFD,0xFEFF,0xFFFF,0xFEFE,0x0000,0x0000,0xFEFD,0xFDFE,
0xFFFF,0xFEFE,0xFF00,0x0000,0xFFFE,0xFEFD,0xFDFC,0xFCFD,
0x0001,0x0100,0xFDFA,0xF8F9,0xFE00,0xFEFD,0xFFFF,0xFEFD,
0xFCFC,0xFE00,0x0100,0xFBF9,0xFE00,0x0000,0xFDFC,0xFCFC,
0xFCFD,0xFEFF,0x0101,0xFEFB,0xF9F9,0xFE00,0xFEFE,0x00FF,
0xFCFB,0xFDFD,0xFDFD,0xFEFD,0xF9F8,0xFD00,0xFDFD,0x0000,
0xF9F6,0xFAFD,0xFFFF,0xFFFE,0xFEFD,0xFCFB,0xF9FA,0xFDFF,
0x00FF,0xFBFB,0x0102,0xFDFA,0xFCFC,0xFCFC,0xFDFE,0xFF00,
0x00FF,0xF9F7,0xFBFE,0xFFFF,0xFF00,0x0000,0xFEFD,0xFEFF,
0x0000,0xFDFB,0xFE00,0x0100,0xFEFE,0x0000,0xFCFB,0xFE00,
0x0202,0xFFFD,0xFF00,0x0201,0xFDFC,0x0003,0x0100,0xFF00,
0x0203,0xFFFC,0xFCFE,0x0102,0x00FF,0x0000,0x00FF,0xFCFC,
0x0003,0x0100,0x0000,0x0101,0x0000,0x0000,0x0000,0xFEFF,
0x0304,0x0100,0x0000,0x0201,0xFEFD,0x0104,0x0301,0xFDFC,
0x0104,0x0100,0xFDFE,0x0305,0xFFFC,0xFF01,0x0404,0xFDFA,
0xFF01,0x0403,0xFEFC,0x0003,0x0100,0xFDFE,0x0407,0x02FF,
0xFDFE,0x0204,0x0100,0xFEFE,0x0001,0xFDFC,0x0001,0x0000,
0xFEFE,0xFEFF,0xFFFF,0xFFFF,0xFFFE,0xFDFD,0x0000,0x0000,
0x0000,0x0100,0xFBFA,0x0004,0x0200,0xFEFD,0x0103,0x0200,
0xFCFD,0x0608,0xFFFB,0xFE02,0x0808,0x00FB,0xFE00,0x0506,
0xFFFD,0x0307,0x0501,0xFAFA,0x0409,0x0400,0xFEFF,0x0306,
0x0402,0x0001,0x0403,0xFEFD,0x0408,0x0503,0x0100,0x0000,
0x0000,0x0202,0x0100,0xFBFB,0x0205,0x0200,0xFF00,0x0202,
0xFDFC,0x0105,0x0501,0xF8F5,0x0006,0x0806,0xFFFD,0x0407,
0x00FC,0xFE01,0x090B,0x03FE,0xFE00,0x0709,0x01FF,0x0102,
0x0000,0x0000,0x0507,0x0401,0xFEFD,0x0002,0x0000,0x0505,
0x00FC,0xFE00,0x0304,0x00FE,0x0000,0x0000,0xFDFE,0x0305,
0x01FD,0xF7F8,0x0208,0x0300,0x0000,0x0100,0xFCFA,0xFD00,
0x0505,0xFEFA,0xFF01,0x0100,0xFDFD,0x0000,0xFFFE,0xFCFD,
0x0103,0x00FF,0xFDFC,0xFDFE,0xFF00,0x0202,0xFFFC,0xFCFD,
0xFF00,0xFFFF,0x0102,0x00FF,0xFCFC,0x0104,0x0200,0xFDFC,
0xFF00,0x0000,0x0000,0x0200,0xFBF8,0xFD01,0x0405,0x00FD,
0xFDFE,0x0000,0xFF00,0x0406,0x01FE,0xFDFE,0x0002,0x0100,
0x0000,0xFEFE,0x0001,0x0405,0x00FD,0xFDFD,0x0000,0xFF00,
0x0203,0x00FE,0xFBFB,0x0004,0x01FF,0xFCFC,0x0001,0xFFFD,
0xFF00,0x0000,0xFDFC,0xFF01,0x0201,0xFEFC,0xFEFF,0xFFFF,
0x0000,0x0000,0x0000,0x0000,0xFEFE,0x0000,0x0000,0xFEFE,
0x0002,0x00FF,0xFAFA,0x0003,0x00FF,0xFDFE,0x0102,0xFFFC,
0xFAFB,0x0002,0xFDFA,0xFDFF,0x00FF,0xFAF8,0xFBFD,0xFFFF,
0xFCFB,0xFDFF,0xFFFF,0xFDFC,0xFDFE,0xFEFE,0xFEFE,0xFCFC,
0xFF00,0xFEFD,0xFBFB,0xFF00,0x00FF,0xFCFC,0x0001,0xFFFD,
0xFDFF,0x0102,0xFEFC,0xFDFF,0x0101,0xFDFB,0xFE00,0x0000,
0xFEFD,0x0000,0x00FE,0xFBFB,0xFE00,0x0000,0xFEFD,0xFDFE,
0xFEFF,0xFFFF,0xFDFD,0xFFFF,0xFFFE,0xFEFE,0x0000,0xFEFD,
0xFBFC,0x0103,0x00FD,0xFDFE,0x0102,0x00FE,0x0000,0x0202,
0xFDFB,0x0002,0x0200,0xFDFC,0xFF00,0x0202,0x00FF,0x0000,
0x00FF,0xFF00,0x0203,0x0000,0x0000,0x0001,0x0101,0x0000,
0x0000,0x0001,0x0202,0x00FF,0x0000,0x0000,0x0001,0x0405,
0x00FD,0xFF01,0x0506,0x0200,0x0000,0x0202,0x00FF,0x0304,
0x0100,0xFDFD,0x0103,0x0100,0xFEFD,0xFF00,0xFEFE,0xFF00,
0x0100,0xFDFC,0xFF01,0x0101,0x00FF,0xFFFE,0xFEFE,0x0102,
0x0200,0xFCFB,0xFE00,0x0101,0x00FF,0x0000,0xFEFC,0xFF00,
0x0303,0xFEFA,0xFCFE,0x0000,0x0000,0x0000,0xFDFB,0xFCFF,
0x0305,0x00FC,0xFBFC,0xFF01,0x0101,0x0000,0xFDFB,0xFCFE,
0x0104,0x0100,0xFDFC,0xFDFF,0x0000,0x0303,0x00FC,0xFBFB,
0x0004,0x0100,0xFEFD,0xFEFF,0xFF00,0x0204,0x01FF,0xF9F7,
0xFE02,0x0304,0x01FF,0xFEFC,0xFCFE,0x0003,0x0302,0xFDFA,
0xFDFF,0x0102,0x0201,0xFFFD,0xFCFD,0x0003,0x0302,0xFFFC,
0xFCFC,0xFF00,0x0203,0x0200,0xFCFA,0xFD00,0x0304,0x00FE,
0xFEFE,0xFEFF,0x0000,0x0303,0xFFFB,0xFBFC,0x0105,0x0401,
0xFFFD,0xFDFE,0xFEFF,0x0103,0x0100,0xFDFB,0xFE00,0x0102,
0x00FD,0xFCFC,0xFF00,0x0102,0x00FD,0xFDFD,0xFDFE,0xFF00,
0x0100,0xFEFC,0xFCFE,0x0103,0x0200,0xFDFB,0xFE00,0x0000,
0x0000,0xFFFE,0xFCFB,0xFE00,0x0303,0xFFFC,0xFCFD,0x0000,
0x0000,0x0000,0xFFFD,0xFDFE,0x0000,0x0000,0xFDFB,0xFE00,
0x0000,0x0000,0xFEFD,0xFE00,0x0000,0x0000,0xFFFE,0xFEFF,
0x0000,0x0000,0x00FF,0xFEFE,0x0002,0x00FF,0xFFFF,0xFEFD,
0xFE00,0x0001,0x00FF,0xFBFA,0xFE00,0x0000,0x0000,0x0000,
0xFEFE,0x0002,0x0100,0xFEFD,0xFF00,0x0203,0x0100,0x0000,
0xFDFD,0x0002,0x0201,0x00FF,0xFF00,0x0000,0x0001,0x0100,
0xFFFE,0xFF00,0x0202,0x00FE,0xFFFF,0xFEFE,0x0001,0x0101,
0xFFFC,0xFCFD,0x0002,0x0000,0x0000,0xFFFE,0xFEFF,0x0102,
0x00FD,0xFDFE,0x0000,0x0000,0x00FF,0xFEFD,0xFDFE,0x0103,
0x00FF,0xFEFD,0xFEFF,0xFF00,0x0000,0xFFFE,0xFDFC,0xFF00,
0x0000,0xFDFC,0xFEFF,0xFEFE,0x0000,0x0000,0xFDFC,0xFDFF,
0x0000,0x00FF,0x0000,0xFFFE,0xFEFF,0x0000,0xFFFE,0xFEFF,
0x0000,0xFFFF,0xFFFF,0xFEFD,0xFDFE,0x0000,0xFEFD,0xFEFF,
0xFFFE,0xFEFF,0x0000,0xFFFE,0xFEFE,0x0000,0x00FF,0xFFFF,
0x0000,0xFFFF,0x0000,0x00FF,0xFFFE,0xFEFF,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0001,
0x0000,0x0000,0x0000,0x0101,0x0000,0x0000,0x0001,0x0100,
0x0000,0x0000,0x0000,0x0001,0x0100,0x00FF,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0102,0x00FE,0xFF00,0x0001,
0x0100,0x00FF,0x0000,0x0000,0x0001,0x00FE,0xFEFF,0x0000,
0x0000,0x00FF,0xFFFF,0xFF00,0x0102,0x00FF,0xFEFD,0xFE00,
0x0000,0x0000,0x00FF,0xFEFD,0x0001,0x0100,0xFFFE,0xFF00,
0x0000,0x0000,0x0000,0xFFFE,0xFF00,0x0000,0x00FF,0xFFFF,
0xFF00,0x0000,0x0000,0x00FF,0xFF00,0x0000,0x0000,0x0000,
0xFFFF,0x0000,0x0101,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFFFF,0x0102,0x0100,0x0000,0x0000,0x0000,0x0000,
0x0001,0x0000,0x0000,0x0000,0x0000,0x0001,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0101,0x0000,0x0101,0x0101,0x0100,
0x0000,0x0000,0x0101,0x0100,0x0000,0x0000,0x0000,0x0001,
0x0100,0x0000,0x0000,0x0101,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0102,0x0100,0xFFFE,0xFF00,0x0000,
0x0000,0x0000,0xFFFF,0x0000,0x0000,0xFFFF,0xFF00,0x0000,
0x0000,0x00FE,0xFEFF,0x0000,0x0000,0x0000,0x00FF,0xFF00,
0x0000,0x0000,0xFFFE,0x0000,0x0000,0x00FF,0xFFFF,0xFFFF,
0xFF00,0x0102,0x00FD,0xFDFE,0xFF00,0x00FF,0xFF00,0x0000,
0xFEFD,0xFF00,0xFFFE,0xFDFC,0xFF00,0x0000,0xFFFE,0xFEFE,
0xFEFF,0xFF00,0x0000,0xFEFD,0xFEFE,0xFEFF,0x0000,0xFFFE,
0xFEFF,0x0000,0x0000,0xFFFD,0xFDFE,0xFEFF,0x0000,0x0000,
0xFDFB,0xFDFF,0x0000,0xFFFF,0xFFFF,0xFEFE,0xFEFF,0x0000,
0xFFFD,0xFDFE,0xFF00,0x0000,0x0000,0xFFFE,0xFEFF,0x0001,
0x00FF,0xFEFE,0xFFFF,0xFF00,0x0000,0x00FF,0xFEFE,0x0000,
0x0000,0xFFFF,0x0000,0x0000,0x0000,0x0000,0xFEFD,0xFF00,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFFFE,0xFF00,
0x0000,0x0000,0x00FF,0xFFFF,0x0001,0x0100,0xFEFD,0xFF00,
0x0000,0xFFFF,0x0000,0xFFFE,0xFF00,0x0101,0xFEFC,0xFDFF,
0x0000,0x0000,0x0000,0xFFFE,0xFEFE,0x0000,0x00FF,0xFEFE,
0xFF00,0x00FF,0xFFFF,0xFFFE,0xFEFF,0x0000,0x00FF,0xFFFF,
0xFEFE,0xFF00,0x0000,0x00FE,0xFEFE,0x0000,0x00FF,0xFF00,
0x0000,0xFEFD,0x0000,0x00FF,0xFCFB,0xFE00,0x0000,0xFFFE,
0xFF00,0xFEFD,0xFEFF,0x0000,0xFFFE,0xFEFF,0x0000,0xFFFE,
0xFFFF,0xFFFF,0xFF00,0x0000,0x00FF,0xFF00,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0xFFFF,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x00FF,0x0000,0x0101,0xFFFE,
0xFF00,0x0000,0x0000,0x0001,0x0100,0x0000,0x0102,0x0100,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0101,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0001,0x0100,0x00FF,0x0001,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0102,0x00FF,0x0000,0x0101,
0x0000,0x0000,0x0000,0x0000,0x0001,0x00FE,0xFEFF,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x00FF,0xFF00,0x0001,
0x0000,0x0000,0x00FF,0xFF00,0x0000,0x0000,0xFFFE,0x0000,
0x00FF,0x0000,0x0000,0xFFFF,0x0000,0x0000,0xFFFF,0x0000,
0x0000,0x0101,0x0000,0xFFFE,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0101,0xFFFD,0xFF00,0x0000,0x00FF,0x0000,
0x00FF,0xFF00,0x0102,0x00FF,0xFF00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0001,0x00FF,0xFF00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0001,0x0000,0xFFFE,0x0001,0x0000,0x0001,
0x0100,0x00FF,0x0001,0x0100,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFFFE,0xFF00,0x0000,0x0000,0x0000,0x00FF,0xFF00,
0x0000,0x00FF,0x0000,0x0000,0x0000,0x0000,0x00FF,0xFF00,
0x0000,0x00FF,0xFF00,0x0000,0x0000,0x0000,0x00FF,0xFF00,
0x0000,0x00FF,0xFF00,0x0000,0x0000,0x0000,0x00FF,0xFFFF,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFFFF,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0xFFFF,0xFF00,0x0000,0x00FF,
0xFFFF,0x0000,0x0000,0x0000,0xFFFE,0xFEFF,0x0000,0x0000,
0xFFFF,0x0000,0xFFFF,0x0000,0x00FF,0xFFFF,0x0000,0x0000,
0xFFFF,0xFFFF,0xFFFF,0xFF00,0x0000,0xFFFE,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFF00,0x0000,0xFFFE,0xFEFF,0xFF00,
0x0000,0x00FF,0xFFFF,0xFF00,0x0000,0xFFFF,0x0000,0x0000,
0x0000,0x0000,0xFFFF,0xFF00,0x0000,0x00FF,0xFFFF,0xFFFF,
0xFF00,0x0000,0x0000,0xFFFF,0x0000,0x00FF,0xFF00,0x0000,
0x0000,0x0000,0x0000,0xFFFF,0xFF00,0x0000,0x0000,0x00FF,
0xFF00,0x0000,0x0000,0x0000,0x00FF,0xFF00,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FF,0xFF00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0xFFFF,0xFF00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFFFF,0x0000,
0x0000,0x0000,0x0000,0x0000,0xFFFF,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x00FF,0xFF00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x00FF,0xFF00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0xFFFF
};

