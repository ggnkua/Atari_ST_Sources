/* Explosion sound */
#define AHH_SAMPLE_LENGTH	(0x3136+0x80)
int ahh_smp_rate = 0x0081;
int ahh_smp_length = AHH_SAMPLE_LENGTH;
int ahh_sample[AHH_SAMPLE_LENGTH / 2] = {
0x3242,0x4954,0x4558,0x504C,0x4F44,0x4532,0x0000,0x0008,
0xFFFF,0x0000,0xFFFF,0xFF00,0x30E5,0x0000,0x3135,0x0000,
0x0000,0x0000,0x3135,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x5354,0x4552,0x454F,0x2052,0x4550,0x4C41,0x5900,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFFFE,0xFEFE,0xFEFC,0xFBFA,0xF9F8,0xF8F9,0xFBFF,
0x0305,0x0300,0xFCFD,0x0208,0x0B0A,0x0908,0x0502,0xFEFA,
0xF6F3,0xF3F4,0xF4F4,0xF4F4,0xF2F1,0xF2F6,0xFBFE,0x0000,
0x0206,0x0808,0x0504,0x01FE,0xF7EF,0xEBE8,0xE6E4,0xE1DB,
0xD4CD,0xCBCD,0xCECF,0xD1D4,0xD9E0,0xEAF3,0xFD05,0x0F18,
0x2027,0x2D2F,0x312E,0x2D2D,0x2F31,0x302A,0x221C,0x1817,
0x1511,0x0A05,0x00FE,0xFAF6,0xF2EC,0xE6DF,0xDBDA,0xDCE1,
0xE6E8,0xECEC,0xEBE9,0xE7E7,0xE9EC,0xEFEF,0xEEEB,0xE9EA,
0xF1F8,0xFE00,0x0002,0x0405,0x0608,0x090C,0x1625,0x2E2C,
0x2926,0x1F19,0x181C,0x1F1E,0x1C18,0x1614,0x1210,0x0F0D,
0x0B07,0x00F7,0xF3F7,0xFE03,0x0A0D,0x0801,0xFDF5,0xF1F3,
0xF5F5,0xF7F9,0xFCFD,0x0003,0x090C,0x0C09,0x0602,0x00FC,
0xF9F6,0xF4F1,0xEFEB,0xE8E7,0xE7E5,0xE2DD,0xDADA,0xDDE2,
0xE6E9,0xECEE,0xF0F3,0xF6F8,0xFAFE,0x0106,0x0A0D,0x1014,
0x191F,0x2730,0x373A,0x3835,0x3231,0x2E2B,0x251F,0x1A14,
0x0E09,0x0401,0x0000,0x00F3,0xDFCF,0xC8CC,0xD2D4,0xD4DA,
0xE2EA,0xEEF0,0xF700,0x0A11,0x1518,0x1B1E,0x1C18,0x1821,
0x2D32,0x2D27,0x221E,0x1913,0x0B00,0xF2E4,0xDCD6,0xD3D1,
0xD3D7,0xDCE0,0xE3E4,0xE4E8,0xF0FC,0x0A13,0x110D,0x09FE,
0xF0F2,0xF8F9,0xF8F9,0xFBFD,0x000A,0x171C,0x1910,0x0702,
0x0001,0x00F9,0xEDE5,0xDFD8,0xD1CA,0xC7CB,0xD4E1,0xECF7,
0xFDFE,0xFE00,0x0207,0x0C12,0x191F,0x2425,0x211D,0x1710,
0x0D10,0x171A,0x1E1E,0x150B,0x02FC,0xFCFF,0xFDFA,0xF4F1,
0xF1F4,0xF9FC,0xFCFA,0xF7F4,0xEEE9,0xEAEF,0xF4F6,0xF5F2,
0xF0F3,0xF6F7,0xF6F5,0xF7F9,0xFD00,0x0205,0x0709,0x0B0A,
0x0906,0x0403,0x0509,0x0D0E,0x1115,0x1E29,0x3637,0x3231,
0x2E26,0x230D,0xFAF0,0xEBEA,0xE7EA,0xF400,0x131E,0x1504,
0xF3EB,0xF2F9,0xFEFB,0xF4ED,0xE4DA,0xD5D3,0xD6DA,0xE5F4,
0x0414,0x1915,0x1104,0xF8FD,0x080B,0x110F,0x0F15,0x191A,
0x1814,0x0D04,0xFEFB,0xFDFE,0xFEFC,0xFCFF,0x00FE,0xF6ED,
0xE8E9,0xECF3,0xFD05,0x0707,0x0706,0x0400,0xF8F1,0xF0FD,
0x1527,0x2316,0x02EE,0xF910,0x1DFF,0xE4F1,0x0106,0xEADF,
0xECFB,0xFE00,0x1224,0x2520,0x2027,0x2F30,0x2921,0x1301,
0xF4E6,0xDDD8,0xD4CF,0xCCCB,0xCDD1,0xE0F4,0xF7F2,0xEBEA,
0xF5F6,0xF3EE,0xEFF0,0xE6DC,0xDADD,0xE3E8,0xEFF5,0xFC00,
0x060C,0x131A,0x1D21,0x2931,0x363B,0x3832,0x271D,0x1817,
0x1812,0x0B04,0xFFF7,0xECE1,0xD9D3,0xD0D3,0xD9E1,0xE8EE,
0xF4F9,0xFD01,0x040B,0x1929,0x312E,0x2D31,0x3530,0x271E,
0x1A16,0x1311,0x0D09,0x04FF,0xF5E4,0xD2C2,0xBDC2,0xCCD5,
0xDEEA,0xFC0B,0x151F,0x282B,0x2B26,0x2524,0x1708,0xFCF3,
0xEAE5,0xE0DE,0xDDDB,0xDCE4,0xEAE9,0xE4DE,0xD8CC,0xBCB7,
0xBCC3,0xCACE,0xD6E7,0xFE11,0x1718,0x1405,0x0221,0x3221,
0x1329,0x4551,0x463C,0x4853,0x5042,0x3431,0x2D20,0x1003,
0xFDF4,0xEAEA,0xF600,0x0100,0x0104,0x0908,0x00FD,0xF8F1,
0xE8DE,0xD6D4,0xD3D1,0xD0D1,0xD5DE,0xE5EC,0xF5FD,0x040D,
0x1118,0x273C,0x433A,0x353A,0x3A36,0x3128,0x13FF,0x0C23,
0x271D,0x0DF7,0xEAF1,0xF4F5,0xF6F7,0xF4EA,0xDFD9,0xD6CA,
0xBCB8,0xBDC6,0xD2D5,0xD8DC,0xDEDB,0xD7DB,0xE4E7,0xE5E9,
0xF0EE,0xE1D3,0xCFCE,0xCCD0,0xDFF4,0x050C,0x0B06,0xFD00,
0x1229,0x3C44,0x423B,0x3126,0x1B14,0x1C29,0x373F,0x3527,
0x1601,0x0511,0x1E2B,0x261C,0x1104,0xF9EF,0xE4D7,0xD0CD,
0xCBCD,0xCCC8,0xC9CE,0xD5DA,0xE0E8,0xF402,0x0E17,0x1917,
0x1C2A,0x3835,0x3637,0x2F2E,0x2A2B,0x3031,0x2B16,0xFCED,
0xEDF0,0xFC07,0x0A0B,0x0706,0x03FF,0xF9F2,0xE9DF,0xD5CE,
0xCDCE,0xD2DB,0xE7F3,0x0316,0x2325,0x201B,0x1712,0x0C0A,
0x0B0A,0x0D17,0x1A14,0x0900,0xFCFB,0xFCFD,0xFEFC,0xF5E9,
0xDCD1,0xC9C6,0xC7CB,0xCED2,0xD5DB,0xE0E5,0xEAEE,0xF1F7,
0xFE07,0x111C,0x2224,0x2527,0x3142,0x4E4D,0x443C,0x352E,
0x323B,0x3730,0x251F,0x1E11,0x01FA,0xFC13,0x2424,0x1B0C,
0x0103,0xFDF2,0xDDCA,0xBEBC,0xB8B8,0xBFCF,0xE1EA,0xE7E1,
0xDCD5,0xD6E4,0xFC08,0x1222,0x2B25,0x1A15,0x1524,0x2209,
0xFD03,0x00F7,0xF0EF,0xECE6,0xD9CE,0xE2F5,0xF7F7,0xF5E5,
0xE609,0x0DFA,0xE8F6,0x1008,0xFDEE,0xFA13,0x10F6,0xE5EE,
0xFA06,0x0D12,0x1311,0x0C06,0x00FB,0xF1E2,0xD6D5,0xDFE6,
0xE1DD,0xD6CA,0xC9D7,0xE7F4,0xE9E3,0xF50B,0x1F25,0x1B18,
0x2437,0x3E3B,0x343A,0x454D,0x4D48,0x433E,0x3B38,0x342C,
0x2520,0x1A15,0x0F07,0x0100,0x00FA,0xF1EE,0xF5FC,0xFCF9,
0x000D,0x0E05,0xF4E2,0xDDDB,0xCCBE,0xAFA8,0xA49C,0x9590,
0x9098,0x9EA8,0xB3BA,0xBCC3,0xD8F1,0x0410,0x1518,0x1F1E,
0x252E,0x3843,0x473C,0x2C24,0x272C,0x281F,0x1D23,0x2D2A,
0x1F16,0x07F5,0xE3D7,0xCDBF,0xB7B6,0xB7B9,0xC1D3,0xE3DE,
0xDBF1,0x2245,0x3E2E,0x1D0E,0x132B,0x3A4B,0x5655,0x5352,
0x493B,0x2F1C,0x0F16,0x0C04,0x0103,0x02F8,0xEBDD,0xD2D7,
0xE6FE,0x04FA,0xF6FF,0x1026,0x2813,0x1C2D,0x1E00,0xFEFC,
0xF5F3,0x0009,0xF4EB,0xECCC,0xACA8,0xB0C1,0xD2C3,0xB1B1,
0xCAEB,0x0602,0xF2EC,0xFE15,0x343A,0x3737,0x3318,0x0114,
0x3A4E,0x4255,0x6974,0x6441,0x2407,0x0516,0x1503,0xE1E1,
0x0001,0x0100,0x0306,0x06F7,0xE5E1,0xDBD5,0xD8E8,0xF4F6,
0xE9E1,0xEFF5,0xF1F1,0xF1ED,0xDCDE,0xF4F6,0xE1E6,0xF704,
0xFBED,0xEF02,0x0A07,0x060A,0x1412,0x0903,0x030B,0x1014,
0x191C,0x170B,0x0707,0x0A08,0x0303,0x080D,0x0900,0xF4F0,
0xFA00,0xFCF6,0xF4F7,0xF3E1,0xCFCC,0xCDDF,0xF7F8,0xEBD5,
0xBEC6,0xDEF5,0xF9E7,0xF71A,0x3937,0x1505,0x02F7,0x0005,
0x0000,0xF20C,0x1D0A,0xFFEC,0xD7D5,0xD7DF,0xF50A,0x0D07,
0x0203,0x0708,0x0805,0xFDFD,0x0209,0x0403,0xF9F1,0xF4F1,
0xEBE3,0xE0DF,0xD7CD,0xCED9,0xE3E9,0xEDF3,0xF8FB,0xFF02,
0x0A15,0x2430,0x3B42,0x4544,0x4442,0x392D,0x1F12,0x0F0D,
0x0A06,0x00FC,0xFF01,0x02F8,0xE7DD,0xDAE2,0xF2FE,0xFEFC,
0xFF06,0x0E11,0x1416,0x1A22,0x2C31,0x2C22,0x1F22,0x2522,
0x1C14,0x1111,0x0F06,0xFDF3,0xECE5,0xDCD2,0xC8BC,0xAC9E,
0xA0A7,0xABB5,0xC7D9,0xECFB,0x050E,0x1111,0x0E0D,0x1518,
0x160F,0x00F3,0xECEA,0xE3D7,0xD8E2,0xEDFF,0x0F16,0x1816,
0x1414,0x1008,0x090E,0x1112,0x1111,0x1827,0x3334,0x2A1B,
0x03E4,0xE904,0x06ED,0xE3F5,0x0C13,0x04FB,0x051C,0x2C2F,
0x2419,0x1812,0x04FE,0x020C,0x0E08,0x05FF,0xF8FC,0x040F,
0x03FE,0x0F25,0x2920,0x2323,0x1301,0xF7FD,0x09FF,0xFC07,
0x0A04,0x030F,0x1616,0x0E01,0xF2ED,0xF608,0x1515,0x0A0A,
0x141C,0x1C1E,0x230F,0xF0EF,0x1221,0x1204,0xF9E1,0xD5DE,
0xDBD9,0xD5D2,0xD4D2,0xD3DA,0xE3F0,0xFE07,0x0503,0x0A16,
0x1200,0xF9FC,0x0000,0xFBFE,0xE8C2,0xBCC3,0xCBCC,0xCBCE,
0xD4E4,0xF2FB,0xFD04,0x0A08,0x0506,0xFBE2,0xCCD4,0xEDF2,
0xEAE0,0xE3FB,0x0601,0xFDFD,0x051E,0x2B23,0x0DFA,0xF205,
0x1A26,0x221E,0x1D22,0x292A,0x2110,0x03FC,0xF0F8,0x1610,
0xF1D4,0xCBDA,0xE9EE,0xF2E6,0xD5D1,0xD3DD,0xE7EB,0xEEEF,
0xF90C,0x2332,0x373C,0x3E3B,0x3733,0x3232,0x3337,0x352C,
0x2B1A,0xFCE6,0xD0C5,0xDFFF,0x18FE,0xD6CE,0xDEFB,0x01FC,
0xF4E4,0xD6CD,0xD1EC,0x0A18,0x1917,0x1C23,0x2420,0x1807,
0xFEFB,0xF0E2,0xDDDB,0xDDDE,0xD1BF,0xBCBE,0xC6CF,0xD9EA,
0xF9FE,0x0103,0x0A14,0x1510,0x0C17,0x2930,0x3637,0x342E,
0x3C4A,0x4136,0x333A,0x392B,0x2018,0x130E,0x02F2,0xEDE4,
0xD6D8,0xE6ED,0xE8E1,0xDED3,0xD0D7,0xDBDC,0xD5CE,0xC6C8,
0xD3DB,0xE2E0,0xE0E3,0xE6E9,0xECF1,0xFD08,0x141E,0x1D19,
0x100A,0x1720,0x2222,0x1D22,0x2729,0x343B,0x3426,0x221B,
0x171D,0x1008,0x0604,0x0BFC,0xD0BE,0xBFC2,0xCDE1,0xFD1A,
0x220C,0xF0E8,0xE9E7,0xF104,0xFCE0,0xF92C,0x21F8,0xF713,
0x2E1B,0xFC0D,0x3248,0x3712,0x0412,0x2020,0x1E24,0x374B,
0x3E1A,0xF7D8,0xC7BF,0xDDEE,0xD8C6,0xC4E8,0xFDFE,0x0100,
0x0722,0x3A38,0x1902,0x1129,0x3419,0xEDE3,0xF602,0x0AFA,
0xDDCC,0xD0E3,0xF2F8,0xF3F1,0xEFF3,0x1635,0x362B,0x1D1F,
0x2928,0x1A0B,0x0502,0x0400,0xECD8,0xCDD3,0xE0EC,0xEEE9,
0xEDF0,0xF800,0xFF0B,0x150D,0x0907,0x00F8,0xEDE9,0xF40E,
0x190A,0xFDF0,0xEBE8,0xF0FC,0xFFF9,0xF601,0x0502,0x0513,
0x1806,0xF6ED,0xEBF3,0xF8F4,0xEADD,0xD0C5,0xBEB9,0xB2AD,
0xAFB6,0xC5DB,0xEAEF,0xF3F9,0xFAF6,0xF3FA,0x0407,0x0402,
0x040C,0x0B01,0xFF08,0x151D,0x1E28,0x312C,0x2524,0x2935,
0x4247,0x4A50,0x534A,0x3F30,0x1C14,0x121F,0x1E16,0x180B,
0x0D1B,0x0BF0,0xE3DF,0xEAF7,0xF3ED,0xE7F4,0x0B1A,0xFDDF,
0xDDED,0xE3D2,0xD6D5,0xD4D5,0xDDE6,0xD4CE,0xEAF2,0xE7E8,
0xF805,0x1D26,0x13FC,0xEEFA,0x0A1B,0x1307,0xFAFF,0x000D,
0x1819,0x1B1A,0x10FB,0xE8F1,0xF8E6,0xC1C5,0xDCFC,0x211E,
0x0BF8,0xFC08,0x1108,0xFFF0,0xFA0A,0xEDD3,0xC0C4,0xD6EA,
0xEEEA,0xE2E6,0xF50A,0x1A21,0x231B,0x01FD,0x1A2F,0x3F44,
0x3C33,0x2013,0x212D,0x19FE,0xFD04,0x0F06,0xF8F7,0x070F,
0x0900,0xFCFE,0x0206,0x0C12,0x1719,0x160F,0x0701,0x00FD,
0xF9F7,0xEDE2,0xDFE2,0xE8E2,0xD5CC,0xC9CE,0xD9E0,0xDCD5,
0xD1D4,0xDBE2,0xE7EE,0xF0E7,0xE0E9,0xF601,0x0A0E,0x1116,
0x1B20,0x282B,0x2B2B,0x2D36,0x404A,0x4628,0x0C07,0xF6F2,
0xF1F5,0x182C,0x1F19,0x02DA,0xC5C3,0xC1CE,0xE5F0,0xF706,
0x0F0C,0x00F6,0xEEEA,0xEBEE,0xF9F3,0xDCCE,0xD6DD,0xE6F3,
0xF8F1,0xE4D8,0xCFCC,0xE300,0x131A,0x1F1B,0x0906,0x1E2D,
0x332E,0x223C,0x5250,0x4A3A,0x3A51,0x583F,0x1908,0x0F24,
0x2D23,0x242F,0x3530,0x2725,0x2A2F,0x332A,0x1604,0xFAF6,
0xF7F8,0xF8F1,0xE6DC,0xD2CD,0xCCCF,0xD2D8,0xDFE3,0xE3E6,
0xEEF9,0xFBFB,0xF8FA,0xFFFD,0xF7F4,0xF2EA,0xE4E2,0xE0E4,
0xECF4,0xFAF4,0xE9F3,0x0415,0x201A,0x0E0B,0x0F0D,0x00F0,
0xEAF2,0xF904,0x06FD,0xF3E9,0xE2E8,0xEFF3,0xF7F3,0xEBE3,
0xE3EA,0xFA04,0x0500,0xFBF9,0xF7F5,0xF5F4,0xF2F2,0xEFED,
0xEDF1,0xF5FA,0xFF0A,0x161A,0x1E29,0x3132,0x302E,0x2B26,
0x1D10,0x06FD,0xECD8,0xD6E1,0xF1F7,0xF2E9,0xE4E6,0xEFF8,
0xF9F8,0xFAF4,0xDBBC,0xB1CF,0xF5FE,0xEAC2,0xB8D1,0xF401,
0x0106,0x0C04,0xF7F5,0xFAFC,0xE8C7,0xC1E2,0x0F22,0x221A,
0x181C,0x11FB,0xDCD5,0x0131,0x2F19,0xFBDD,0xDAF5,0x131B,
0x0BF6,0xD8C4,0xD500,0x1A1C,0x06F9,0xEDF1,0xF9F8,0xFE10,
0x200F,0x0F1F,0x2B2F,0x2F39,0x4E58,0x5359,0x593D,0x1901,
0xF702,0x1F27,0x19F8,0xE4ED,0xF90E,0x04FA,0xEBE6,0xEE03,
0x2737,0x3835,0x2E23,0x1910,0x1F31,0x21EB,0xD4DE,0xFD2E,
0x392A,0x1D0B,0x101D,0x1C13,0x212E,0x312C,0x212B,0x2A0F,
0xFE03,0x150C,0xEFDA,0xDEE7,0xF203,0x110E,0x0C09,0x0403,
0x0814,0x08EA,0xD3BB,0xA1A3,0xB6B9,0xA48B,0x94AC,0xCAD1,
0xBAA7,0xBADD,0xE7E5,0xE5E5,0xEF09,0x1E1A,0x12FF,0xE7DD,
0xDEE4,0xF700,0x0712,0x0BF1,0xDCDC,0xDFE2,0xE5EF,0xEADA,
0xD0C6,0xD0E7,0xF702,0x1419,0x0A0F,0x2739,0x4740,0x1E00,
0xF5FD,0x0B0E,0x0E15,0x0D04,0x0A15,0x2327,0x201F,0x2219,
0x06FC,0xEBD6,0xC8C5,0xE002,0x0AEB,0xD0E8,0xF5F9,0xF6DD,
0xCFC7,0xD1ED,0xFC06,0x0C01,0xFB00,0x091C,0x1D04,0x1028,
0x4955,0x4F4D,0x493E,0x311B,0x0407,0x1320,0x292F,0x3345,
0x5141,0x3233,0x4047,0x3C2F,0x2416,0x0C0A,0xFAE7,0xE7EE,
0xFAFA,0xF1E5,0xD0CB,0xDDD9,0xB5A3,0xB7C2,0xC6D6,0xE3E4,
0xD6C6,0xC5C9,0xC2C3,0xC0C4,0xD2C1,0xBEE0,0xF2F4,0x0612,
0x1B16,0x0816,0x2B29,0x2217,0x1E34,0x3139,0x5D78,0x6C4E,
0x19E7,0xECF5,0x092D,0x3E3E,0x3D2F,0x1D1B,0x1724,0x2322,
0xFEE8,0xF7F1,0xF1FC,0xF710,0x1E1C,0x0AED,0xE4E3,0xE1EC,
0xEEF1,0x0B04,0xE3CF,0xCFDF,0xE1C2,0xBEE8,0x1215,0x02EE,
0xEEFC,0x0A0C,0x0DFE,0xEAE7,0xE6E3,0xE4E6,0xEBEB,0xF002,
0x0A04,0x0710,0x0F03,0xF2F1,0xFAF1,0xE3EA,0xFAFF,0xECD8,
0xDBF6,0x141C,0x13DF,0xEAE3,0xDDD9,0xD3D2,0xDDE8,0xF1FB,
0x0003,0x111C,0x13F9,0xD1C2,0xD6F5,0x0A09,0x01F2,0xD7D0,
0xE9EE,0xE0DB,0xE1F5,0x1013,0x0D00,0x0726,0x2812,0x01FE,
0x0000,0xFEFE,0xFD00,0x0F1E,0x2521,0x1815,0x04EE,0xF601,
0xFCF3,0xF6FF,0x0809,0x0000,0x0305,0x0507,0x0B0B,0x04FE,
0x0004,0x090E,0x1517,0x110D,0x1116,0x1510,0x0B0A,0x0D0D,
0x0D0D,0x0A0B,0x1B2B,0x3130,0x2306,0xEFF3,0x0411,0x1B18,
0x09FC,0xE3E2,0xF90C,0x06F2,0xD3CA,0xE303,0x1C0D,0xFBF6,
0x0830,0x3719,0x041B,0x2F2C,0x1B05,0x00FD,0xF8F9,0xFBFA,
0xF4F8,0xF9EF,0xEAF2,0xFD09,0x181D,0x1812,0x06FE,0xFBFC,
0xFBF4,0xEAE5,0xE4E1,0xD9D1,0xC6BF,0xC1D7,0xEAF5,0xFE0B,
0x1420,0x2B31,0x3434,0x2B20,0x1D20,0x251F,0x1104,0x0207,
0xFFEF,0xF2F8,0xF5E6,0xDBE0,0xE7EB,0xECE5,0xE5EA,0xE5DF,
0xE3E3,0xDCD3,0xD3E0,0xE9F3,0xFBFD,0x0003,0x0307,0x1321,
0x2213,0x01FA,0xF9FC,0x020F,0x1409,0xF8EC,0xE6E1,0xE2EC,
0xFC00,0xF2F5,0x0004,0x0604,0x040E,0x1E27,0x2B22,0x1B0D,
0xFA0C,0x1A14,0x0701,0xFDFF,0x0F12,0x08EE,0xE2E3,0xDDD9,
0xD6DC,0xD9C6,0xC1DA,0xFA12,0x0BF0,0xEBF5,0x0A0C,0x0303,
0x0205,0xFF00,0x0F18,0x1512,0x0C05,0x0811,0x1914,0x0D09,
0xFEEA,0xE6EE,0xF5F6,0xF3F3,0xFD04,0x050A,0x0E08,0x050E,
0x1619,0x1917,0x1114,0x2A47,0x565C,0x5641,0x270F,0x0100,
0x0201,0xF2E4,0xE2EA,0xFBFB,0xEBDF,0xD9E6,0xFF0A,0x0E02,
0xE8DF,0xEEFF,0x0002,0x0206,0x0509,0x0703,0x0203,0xF5EB,
0xF0FD,0x0913,0x1E26,0x1D16,0x160C,0x03FC,0xEFE5,0xE7F6,
0x0902,0xE6DF,0x001E,0x2727,0x1C0F,0x02F5,0x0414,0xFEED,
0xF0F8,0x00F3,0xE3F1,0x0007,0x0702,0xF6E7,0xD4C8,0xCBCB,
0xCAD7,0xE0D9,0xCACB,0xD6E5,0x0013,0x1712,0x0800,0xF7EE,
0xE8E9,0xEAF1,0xF5EF,0xEAF6,0x0A24,0x4251,0x4C39,0x2420,
0x241C,0x1516,0x1F30,0x3D41,0x3E25,0x0C1D,0x3526,0xF7D1,
0xC9DD,0xE4D2,0xD8F6,0xFAE9,0xD7DF,0xF700,0xF0DE,0xD6D1,
0xE300,0x0A04,0xF9F9,0xFBFC,0xF6E9,0xDEE5,0xF5F4,0xE1D1,
0xCED7,0xE4F2,0xFCFE,0xF7F1,0xEFF7,0xFF08,0x0E07,0x0304,
0x070C,0x06F5,0xECF2,0xF904,0x0D0C,0x0A00,0xFAFD,0x040D,
0x100D,0x0E10,0x0C07,0x01FE,0x0206,0x0A10,0x1313,0x0F05,
0xFCF9,0xFBFE,0xFF07,0x0C02,0x0509,0x0C0E,0x1109,0xFFFF,
0x0A16,0x2029,0x2C29,0x2522,0x2327,0x2726,0x2521,0x1812,
0x0E14,0x1F1F,0x1107,0x0710,0x1A18,0x0E04,0x020B,0x1205,
0xFAF3,0xF4F3,0xEDEC,0xF1F6,0xF6F8,0xF7F3,0xF3F4,0xECDF,
0xD4D6,0xDAD9,0xCDC3,0xBDC9,0xEBFD,0xEAD6,0xD9E5,0xEFEF,
0xEEF3,0xEDE7,0xE9ED,0xF3F1,0xE7F0,0x0812,0x04EB,0xE2E1,
0xF001,0x00E9,0xDAD8,0xE0ED,0x0010,0x0C00,0xFAF7,0x021B,
0x2E44,0x5558,0x431D,0xF9ED,0xF900,0x0305,0x0706,0x151D,
0x253A,0x4337,0x281D,0x10F8,0xDACF,0xE50A,0x231F,0x232D,
0x3218,0x0513,0x241C,0x0E16,0x2422,0x10FB,0xFB16,0x292C,
0x220F,0xF5D9,0xD8E0,0xDCD5,0xD5DD,0xEAFD,0x0924,0x4144,
0x2813,0x1A08,0xF606,0xFBD9,0xD6D4,0xD8E7,0xE3DC,0xE9F4,
0x0000,0xF6EE,0xE6D8,0xE1F1,0xF7E3,0xD2D8,0xEBE7,0xD5CC,
0xD0E5,0xF4FA,0xFAFD,0x0208,0x0A0E,0x151C,0x170A,0x00FF,
0x050E,0x0D00,0xF5F6,0xFDFE,0xF5EE,0xEBE6,0xDACF,0xD2D9,
0xDFDF,0xDCDB,0xDCDD,0xDBE0,0xF101,0x01F2,0xE6E1,0xE2E5,
0xE2DE,0xEC07,0x324F,0x4A3B,0x2617,0x232F,0x311B,0x0E1F,
0x241E,0x1B1A,0x1915,0x0A02,0x0001,0x0A19,0x2420,0x100D,
0x191C,0x150C,0x02FE,0xFCF9,0xFF00,0xF9F7,0x000A,0x04F4,
0xE3DD,0xDEE9,0xFE12,0x1B17,0x09F6,0xE0D9,0xE4ED,0xF6F6,
0xF001,0x1524,0x1D07,0xF2EF,0xFA07,0x0808,0x0E19,0x1605,
0xF3FA,0x0E06,0xF2E7,0xEBF4,0xF7F6,0xF7F6,0xF7FB,0xFE05,
0x1A25,0x0902,0x121C,0x2D3B,0x3934,0x281C,0x1716,0x150B,
0x090B,0x121A,0x1B19,0x1715,0x1310,0x121A,0x1F1C,0x160E,
0x0707,0x0C0A,0x03FC,0xF7F9,0xFD01,0x0202,0xFCF3,0xEEEC,
0xECE9,0xDFD1,0xC9CC,0xCCC7,0xBFBA,0xB7BA,0xC2CE,0xD8DD,
0xDEDF,0xE1E7,0xEFF4,0xF2EE,0xEBE4,0xE3ED,0xFC0B,0x110F,
0x05F6,0xE9E8,0xF3F7,0xFCFC,0xF5F7,0xFAFF,0x03FF,0xEFD5,
0xC7D0,0xDCE1,0xE6EE,0xF802,0x0D18,0x14FB,0xF706,0x1823,
0x1E16,0x0C02,0xFBFB,0x030E,0x1409,0xFBFD,0x030F,0x1A21,
0x2529,0x2F3B,0x4A52,0x5247,0x2F1F,0x364C,0x514A,0x3B39,
0x3B3D,0x3F3C,0x3427,0x1608,0x04FC,0xF3F2,0xF1E8,0xD4C0,
0xB7B5,0xBCC1,0xC3CB,0xCCCB,0xD9EF,0xF6EF,0xED04,0x2B39,
0x2622,0x222A,0x2D2A,0x3138,0x3A35,0x2719,0x1B27,0x2109,
0xE8D0,0xCED8,0xE2EA,0xE9DE,0xD6D1,0xC4C3,0xD4D5,0xD0D1,
0xD7DA,0xD8DB,0xE8FC,0x0C11,0x0DFC,0xE6DB,0xE0EC,0xEFF4,
0xF6EE,0xE2DE,0xE6F8,0x0D22,0x2112,0x01EE,0xE8FB,0x091A,
0x2817,0x0003,0x0A09,0x00FA,0x000B,0x1E1F,0x0F07,0x120A,
0xE5C9,0xD7EB,0xE7E1,0xD7D1,0xD0D1,0xDCF3,0xFFE7,0xDDE3,
0xF810,0x04F0,0xFA0A,0x253F,0x3F33,0x1F1E,0x262A,0x2C35,
0x403E,0x302B,0x2624,0x2217,0x02F4,0xE5DB,0xDCF0,0x010A,
0x161E,0x2018,0x0A00,0xFD00,0x01F9,0xEFEA,0xDFCE,0xC4C2,
0xC4C7,0xCACE,0xD4DC,0xE0DD,0xE0E8,0xEF00,0x131C,0x1A0E,
0x00FC,0xFFFF,0xFB01,0x1321,0x2627,0x2D38,0x3A29,0x1006,
0x0903,0xF0EF,0x000F,0x01F2,0xFD03,0xE8D0,0xC9D7,0xEE07,
0xF5D6,0xD9EB,0x0619,0x2724,0x1E1F,0x1809,0xFF06,0x2122,
0x0B00,0xF4F0,0xEDE8,0xE0DD,0xE0E9,0xFE15,0x2327,0x2512,
0x0010,0x1F1C,0x1726,0x313A,0x3F32,0x1C19,0x2930,0x2D27,
0x231F,0x11FE,0xEEDD,0xC4AE,0xA6AE,0xBED0,0xDDDC,0xECFA,
0xF0E1,0xDDFC,0x1F1E,0x01F0,0xF509,0x1911,0x0409,0x1409,
0xE7CD,0xC7D5,0xF411,0x2D2D,0x1B1A,0x2328,0x2521,0x1714,
0x140D,0x0602,0xFDED,0xDDD5,0xD3D2,0xCFCF,0xD6E7,0xF9FA,
0xEEE7,0xE9EE,0xF6FF,0x0F29,0x332D,0x2212,0x0C12,0x202D,
0x2C2A,0x2D2E,0x3133,0x302D,0x261C,0x1205,0xFAEE,0xE1DC,
0xEBEC,0xE0D6,0xCDC8,0xC8D0,0xDBE5,0xEAED,0xF1FE,0x121D,
0x2009,0xE7E2,0xF404,0x0E10,0x08FF,0xEDE3,0xEDE8,0xD6CE,
0xD6E2,0xF4FC,0xF5E8,0xD6D8,0xE3E3,0xE0E0,0xE5EC,0xF4FC,
0x081A,0x221E,0x1E2B,0x3A3B,0x3D30,0x1B08,0x0304,0xFAE4,
0xDCEC,0xFCFE,0xF0ED,0xF702,0x00F3,0xE7E3,0xEC00,0x1611,
0xF1CD,0xC8CE,0xDAF4,0x1110,0x151F,0x10FA,0xF2FD,0x03FE,
0xFBFE,0xFFF4,0xE5DB,0xEAFF,0x0607,0xF9EA,0xEB05,0x3D56,
0x413C,0x423A,0x2D20,0x1C1E,0x2D23,0x0A03,0xF500,0x281F,
0x00F0,0xF605,0x03F8,0xF7F7,0xF900,0x0705,0xFAEE,0xE5EC,
0x113A,0x493D,0x2C16,0x0209,0x1500,0xDBDE,0x021F,0x241D,
0x212F,0x3B30,0x0DEF,0xDFDE,0xF301,0x01FB,0xEFEB,0xE3E7,
0xF6FC,0x00FE,0xF7F9,0x0D1B,0x151A,0x2224,0x1908,0x070B,
0x03E5,0xB7C3,0xEDFF,0xF3DE,0xDBE2,0xD4CD,0xDFF2,0xF3EF,
0xF000,0x0C07,0xE9C8,0xC9F8,0x1D2C,0x1A07,0xFD00,0x02F9,
0xE3E2,0xEEEC,0xE2E4,0xEDFC,0x0603,0xFBEF,0xE4F8,0x120C,
0x04FF,0xFAF8,0xEADC,0xDEDF,0xE4ED,0xEFF1,0xFAF1,0xDEDC,
0xDFD3,0xD3FF,0x2D3B,0x2709,0xFCF9,0xF0FD,0x1633,0x403E,
0x3B29,0x1C22,0x17FF,0xEAE2,0xE9F5,0xF9EF,0xE5EB,0xF905,
0x00EF,0xFD20,0x220E,0x0C09,0x04FE,0xF902,0x0B11,0x1319,
0x242F,0x3122,0x0AF5,0xE5E8,0xEDED,0xE3DA,0xDEDF,0xD2CF,
0xCECA,0xC9D7,0xF51E,0x2505,0xF5FB,0x0E23,0x211D,0x191F,
0x2A2C,0x2624,0x1A08,0xF7EF,0xF1F4,0xF5F3,0xF0FC,0x0F18,
0x0E03,0x020F,0x191B,0x0E03,0x0102,0x0912,0x1103,0x0008,
0x09FF,0xE9DE,0xE5EA,0xE5E8,0xF0FD,0x00F0,0xDDD5,0xD3DC,
0xE8F7,0x0808,0xFC09,0x3051,0x4B37,0x2422,0x3039,0x3936,
0x302A,0x333A,0x3521,0x2332,0x342F,0x312B,0x1702,0xF603,
0x0CFD,0xEEF7,0x040D,0x07F3,0xF301,0x03F9,0xECE2,0xDFE1,
0xD7C3,0xB6AA,0xA3AD,0xBEC2,0xB8B4,0xBFCC,0xD3E2,0xF3EB,
0xE4F8,0x0816,0x1103,0x01F5,0xDDD8,0xE8FD,0x100A,0x051E,
0x2A22,0x2414,0x02FA,0xF0F5,0x0B12,0x1918,0x1100,0xE5D3,
0xCCC5,0xD5E8,0xECDA,0xD4F3,0x0806,0xFBE9,0xF210,0x1C0D,
0xF3E0,0xF0FC,0x0011,0x2526,0x240E,0xFAF9,0xFAFD,0xFD00,
0x0E27,0x3627,0x2034,0x4E5B,0x523B,0x2505,0xFB12,0x170B,
0xFCF8,0xF9FA,0xF8F8,0xEDCA,0xB8BE,0xC9DE,0xEAD5,0xBEBE,
0xC9D7,0xD9DA,0xE6F9,0x1832,0x3834,0x2926,0x2F2B,0x2935,
0x3C3C,0x322A,0x313C,0x3D3E,0x3E40,0x4543,0x382E,0x2620,
0x12FF,0xF802,0x03FD,0xFAF4,0xF3ED,0xDECF,0xC2B2,0xB3C2,
0xDEE4,0xCBC2,0xB7B3,0xA9A0,0xA8B6,0xBFC6,0xD9F6,0x0B0C,
0x0301,0x01FE,0x030E,0x171C,0x242F,0x372A,0x1400,0xEBEA,
0xEBEA,0xE4DB,0xDEE1,0xE2F2,0x0608,0xF6F1,0xF3F9,0xFEFC,
0xEEE9,0x0518,0x1222,0x1F17,0x2632,0x250C,0x0F1D,0x3549,
0x3A20,0x1706,0xF80C,0x2737,0x3406,0xDAE0,0xE0D1,0xBCBA,
0xD9EF,0xD1C8,0xCFD8,0xF00E,0x0B01,0xFFF4,0xFAFC,0xF6F8,
0x0319,0x221C,0x202F,0x3937,0x2B20,0x1D1C,0x0E00,0xF8FE,
0x1224,0x13FD,0x0610,0x1415,0x0E05,0xFCED,0xDFCC,0xC1C7,
0xD8DD,0xD0D5,0xE1EA,0xE0D6,0xD8ED,0x0507,0x041A,0x2623,
0x0EFC,0xFD0B,0x1A2E,0x3626,0x13FB,0xF100,0x09FC,0xEBE4,
0xEBF9,0xFAE7,0xE8F7,0xFEFE,0xFBF8,0xFDFD,0x030C,0x0000,
0x0C07,0x0606,0xFAFC,0x1822,0x120C,0x1622,0x2926,0x1807,
0xF1D9,0xEF09,0xFEE9,0xE2CC,0xC1C0,0xC1C8,0xC6D5,0xF006,
0x0E0D,0x1126,0x332D,0x210F,0x0B1A,0x3131,0x2825,0x1D21,
0x292C,0x2D22,0x1F29,0x322B,0x2523,0x242B,0x1E06,0xF6F2,
0xF6ED,0xD8D1,0xD7D2,0xC6C2,0xCDDF,0xE9EA,0xEAEB,0xF0FD,
0x080F,0x02F5,0xE8E6,0xE9E5,0xE4E4,0xE9FD,0x0500,0xF7FE,
0x0C0E,0x0B03,0x0A0D,0x06FC,0xF9FB,0x0E17,0x1312,0x0E09,
0x01F0,0xF818,0x1E05,0xF6F8,0xFFFF,0xF7EE,0xEEEA,0xEAF6,
0xFAEE,0xD8CC,0xD2DF,0xEBE7,0xCAB0,0xC5EA,0x0103,0xF9EF,
0xEFEF,0xF0F5,0x0313,0x1416,0x04FB,0x090E,0x0D1F,0x3A54,
0x5949,0x3021,0x190A,0xFE01,0x0314,0x261C,0x0CF4,0xE3EA,
0xEFF1,0xF807,0xFEF0,0x071F,0x2F4B,0x5B54,0x4B36,0x2728,
0x2830,0x2113,0x1D24,0x2114,0x0507,0xFCE6,0xD7D1,0xCCCA,
0xDCEA,0xF2F2,0xD5CE,0xD7C8,0xBDBD,0xC6D3,0xD0CB,0xDADF,
0xE0EE,0xF8EF,0xE5F3,0x0613,0x221D,0x1010,0xFDF7,0x0100,
0xFCEF,0xDDDC,0xE3F1,0xF8F7,0xF601,0x0A18,0x1E1B,0x160F,
0x0B03,0x00FF,0xF3F3,0xF4E9,0xE3E3,0xE7FA,0x1019,0x1A15,
0x191F,0x0D00,0x0E15,0x14FE,0xD7C1,0xCBE4,0xFAF8,0xF1F8,
0xF9F8,0xE6E7,0x021E,0x3331,0x221E,0x1500,0x0019,0x3C4E,
0x3F28,0x0FFF,0xF9F1,0xE8EF,0xF700,0x01FA,0x0918,0xFDED,
0xFE0D,0x271A,0xFFE2,0xD5E4,0x000F,0x170A,0xFAEE,0xEA03,
0x0E03,0xFD02,0x0A09,0x0000,0x00F9,0xF9F9,0xFD04,0x050D,
0x0912,0x1C16,0x1315,0x1101,0xF6FC,0x161E,0x1405,0x0512,
0x190E,0x00F8,0xF2EF,0xF3F5,0xFBFD,0xF8F7,0xFCFB,0xF2ED,
0xECF2,0xEBF0,0xEDE4,0xE6F0,0xF8F6,0xF805,0x01FA,0xF6F5,
0xF0E5,0xE9E3,0xD7D4,0xD6D4,0xC8C1,0xC1CD,0xD8DE,0xEAFC,
0x0A1A,0x1E21,0x2214,0x0B27,0x484A,0x423A,0x291F,0x1210,
0x191F,0x140F,0x171E,0x231B,0x08FC,0xFAFE,0x090C,0x050C,
0x292E,0x13F7,0xFE0D,0x1210,0x0AFB,0xEBDD,0xDEEF,0x050D,
0xF5EB,0xF1EE,0xF4F6,0xF0FC,0x1D38,0x422D,0x0EFC,0xEDF1,
0xF9FD,0xFAF8,0xF3F0,0xF4F6,0xF0E8,0xD1B2,0xAAB7,0xC2C6,
0xCCC4,0xCBDC,0xED03,0x1619,0x2825,0x2A46,0x4C44,0x3D32,
0x1F10,0x0E13,0x06F7,0xE3DC,0xD2C4,0xCFE9,0xDDC4,0xD1EC,
0xEDEB,0xF400,0x1414,0x03F0,0xE2FB,0x171F,0x0D00,0x0615,
0x1E1B,0x1E34,0x423A,0x251A,0x1C19,0x0D06,0x0808,0x0602,
0x070C,0x03FD,0xE9D0,0xCEE2,0x0001,0xF2F3,0x010A,0x0400,
0xFB00,0x080A,0x01F5,0xEBF8,0xF9E8,0xE0DE,0xE3E8,0xDDD3,
0xDCEC,0xEFE7,0xEBFA,0x0306,0x0812,0x1309,0x0D12,0x1821,
0x2420,0x1511,0x1406,0xF1F2,0x0706,0x010F,0x2A30,0x0DD7,
0xC0D4,0xF80D,0xF4DC,0xDBD3,0xD3D4,0xDF0A,0x1CF9,0xE2E3,
0xFA15,0x1FFE,0xE60F,0x3E3C,0x3727,0x0703,0x1027,0x1F0D,
0xFAEE,0xE3D8,0xD3D1,0xCFD6,0xEB04,0x1D3B,0x4333,0x2123,
0x3040,0x3318,0xFCEA,0xECEC,0xF4FB,0x00F8,0xE6EB,0xFF17,
0x281C,0x1C2B,0x220C,0x0503,0xF6EA,0xE7EE,0xF300,0x1820,
0x1E1D,0x281E,0xF4ED,0x0018,0x2117,0xFEEF,0xE9F1,0xFFFD,
0xEEE4,0xE4EF,0xF5ED,0xE4EA,0xE9E3,0xDAC9,0xCBCC,0xC9D1,
0xDAD8,0xD8E6,0x0113,0x100B,0x0908,0x131E,0x2228,0x2D2B,
0x2E35,0x3B2D,0x181D,0x2C26,0x2E3B,0x423B,0x2517,0x191A,
0x130B,0x04FE,0xF7EE,0xECEB,0xE5DC,0xDDDA,0xD5D2,0xCEC7,
0xBEB7,0xB3B9,0xCAD6,0xD4D2,0xD6E8,0xFA09,0x0D06,0x040F,
0x1D1E,0x1200,0xF4FB,0x0605,0xFB02,0x0505,0x0911,0x2229,
0x3845,0x4542,0x3F2E,0x251D,0x08FD,0xF5F0,0xE8DA,0xC0AC,
0xB2C3,0xC6BF,0xBFC4,0xCEDA,0xEFE7,0xD9DC,0xEB01,0x110F,
0x0605,0x100E,0x0D14,0x06F5,0xF2F4,0x0010,0x1404,0xFAFB,
0x010C,0x0902,0xFD03,0x1423,0x1A09,0x0308,0x0F15,0x1D1E,
0x1411,0x141D,0x1F1C,0x1A15,0x1920,0x1905,0xFCFC,0xF2ED,
0xF402,0x141A,0x06F1,0xF0F6,0xF6F5,0xEEF1,0xFBF8,0xF2F4,
0xFE07,0x131A,0x1407,0x090E,0x1309,0xFC07,0x191F,0x1907,
0xEEEC,0x0308,0xF2E7,0xE8E1,0xD6C5,0xC6D4,0xDBE1,0xE4D7,
0xCAD9,0xF9FF,0xF7EB,0xEAEE,0xF5EE,0xE6EE,0x0011,0x1D16,
0x1520,0x2633,0x403B,0x2112,0x1819,0xF9E0,0xDCD2,0xE0FA,
0x050F,0x151F,0x2D3A,0x443F,0x1AF6,0xE6E7,0xEFEF,0xE7E3,
0xE7F6,0x00FE,0x0B23,0x2F3D,0x4B4C,0x3405,0xEBFF,0x0FFC,
0xE9F3,0x00FE,0x0304,0x0925,0x322F,0x2C35,0x3C3D,0x3421,
0x07F1,0xF100,0xFFE6,0xDBDF,0xD4CF,0xDAE4,0xD7D3,0xDFF4,
0x0307,0x05FF,0xFE01,0xFF02,0x0702,0xFAF6,0xFB03,0x00F6,
0xEEE3,0xD3CD,0xD8E3,0xE0DE,0xDCE5,0xEBF3,0xF4EC,0xE5E1,
0xE6F3,0x0104,0xFDFE,0x050C,0x1112,0x0C04,0xF2F0,0x0004,
0x0606,0x0706,0x0406,0x1117,0x1418,0x1510,0x0F0B,0x0501,
0x0100,0xFCF3,0xECE1,0xD8D9,0xDDE1,0xE5DE,0xD2C9,0xCCD8,
0xE5EB,0xE8E9,0xF2F8,0xFD04,0x0B0D,0x0D12,0x1D23,0x2421,
0x1C17,0x1B26,0x2833,0x3937,0x3835,0x2B23,0x2224,0x2728,
0x2922,0x1008,0x0302,0x0A12,0x140D,0x02FC,0x000C,0x1210,
0x1108,0xF5DE,0xC8CA,0xDFED,0xEBE3,0xD1C1,0xCADD,0xE0C9,
0xBCC0,0xCADD,0xF2F8,0xF1E2,0xD6D8,0xE9F6,0xFBF6,0xFB04,
0xF6F2,0xF9FC,0x0B24,0x261E,0x2F41,0x31FD,0xE0FF,0x2618,
0xE9D0,0xD7F1,0x1026,0x2210,0xFFF5,0xF4FB,0x0512,0x1415,
0x13FB,0xFA1F,0x3738,0x3431,0x372A,0x1917,0x263A,0x3421,
0x0BFC,0xEBEE,0xFF0C,0x02ED,0xD9DB,0xF4F5,0xDBD0,0xD6E0,
0xE1DD,0xF40F,0x120D,0x0405,0x1829,0x2E22,0x1D17,0x0502,
0x1327,0x3530,0x251D,0x1F1D,0x08F5,0xEDEC,0xE6E5,0xEAF2,
0xFBED,0xDEDD,0xDFDD,0xDCE2,0xEEF2,0xF2F3,0xEFE5,0xDED8,
0xE3F8,0xF6E2,0xD8E4,0xF3F5,0xEBE1,0xDCDE,0xE7F5,0x0A1F,
0x2217,0x141F,0x1F0C,0xF1DC,0xD8DC,0xDFE4,0xE3E5,0xE7E9,
0xEFF9,0x000B,0x1318,0x2327,0x3244,0x483F,0x3128,0x2420,
0x2335,0x3E38,0x2619,0x140D,0xFFFB,0xFEFC,0xF4F6,0xF0E8,
0xF1FF,0x1022,0x1A00,0xDDDE,0x0917,0x1110,0x110A,0xFAEF,
0xECDE,0xD3D6,0xDBE8,0xFD0D,0x07F8,0xD9C1,0xCADD,0xDFE1,
0xE4CF,0xC8E3,0xF9E9,0xC8CD,0xDFF2,0x06FE,0xE4DE,0xEBF4,
0xFE05,0x010C,0x191D,0x1D2D,0x2E19,0xFDEA,0xFF0E,0xF1DB,
0xDADC,0xD1D1,0xE9FA,0xFE00,0xFDFF,0x050A,0x0B11,0x1911,
0x1232,0x5262,0x5947,0x2D10,0x03FC,0xF8FA,0x0519,0x394A,
0x4224,0x00E8,0xF20A,0x0B0A,0x100E,0x0503,0x0F11,0x0300,
0x0C0B,0xFEFB,0xF2DA,0xD5DC,0xEE04,0x1314,0x00EA,0xE6E9,
0xFA08,0xFBEC,0xF60F,0x1C05,0xE1D7,0xE4ED,0xEBE7,0xEDF4,
0xFF04,0x0402,0xFE00,0x01FB,0xFDF3,0xDCD6,0xE0F8,0x0B16,
0x211B,0x1206,0xEACC,0xC0C0,0xCBDF,0xF609,0x1825,0x2D20,
0x0802,0xFF00,0x06FC,0xFC08,0x0917,0x2108,0xE9D2,0xC6D0,
0xEA02,0x0F0A,0x182A,0x3233,0x3D4E,0x5752,0x4533,0x2820,
0x231E,0x0C06,0x131F,0x1809,0xF9EB,0xECED,0xE7E7,0xF2FE,
0x00F4,0xEAEC,0xF6F0,0xDFD4,0xD3D5,0xD2C8,0xAFAC,0xC0D6,
0xE3E2,0xE6EF,0xFA06,0x0E15,0x1E19,0x1525,0x2A14,0x080A,
0x1B2D,0x3130,0x2721,0x2938,0x4441,0x3B3A,0x3834,0x2A18,
0x0C05,0xF7E7,0xC7B0,0xB6D3,0xF5F8,0xD3C1,0xCCDE,0xE8DF,
0xD4D7,0xE0ED,0xF0E5,0xDCE4,0xF0FD,0x0100,0xFBF7,0xEFDD,
0xCFD0,0xD1CD,0xC0C5,0xD8E9,0xF100,0x0301,0xFBFE,0x0308,
0x1218,0x1827,0x4051,0x5B51,0x3D31,0x1908,0x120E,0xFFF5,
0xDED9,0xDBDA,0xDCDC,0xD7D4,0xDAEE,0xFCF7,0xF0ED,0xFC10,
0x1A14,0xF9E3,0xEEF9,0xFDF4,0xE6DE,0xDEE1,0xEF00,0x0311,
0x2A3A,0x3214,0x082D,0x4E59,0x4522,0x0AF7,0x0320,0x1F07,
0xFEF5,0xFDF5,0xE0DD,0xE1E6,0xF4FD,0x0610,0x1218,0x1610,
0x0B00,0xEFE5,0xEF0D,0x0CF7,0xFBFC,0xF4F9,0xEFEC,0xF703,
0x1724,0x383E,0x2607,0xFE0F,0x2D3A,0x2A1E,0x1209,0x1118,
0x221E,0x1C23,0x1E0E,0x00EF,0xF407,0x151E,0x1E13,0x0A09,
0x03F3,0xE7EB,0xFB0B,0x100C,0x0802,0xF9EB,0xD5C1,0xC6D8,
0xE9F2,0xF3F6,0x0001,0xFDF7,0xECEF,0xEEDF,0xD4D6,0xE1EE,
0xF1EB,0xE6F1,0xFF00,0xFDED,0xD2C1,0xD0E2,0xEDEF,0xE6D9,
0xD0E0,0xFF0E,0x0E14,0x1813,0x0E0A,0x0705,0x0C15,0x1719,
0x1B21,0x2013,0x0D0F,0x1314,0x0A06,0x0D09,0xF2E8,0xF50E,
0x110C,0x00F8,0x051C,0x1911,0x0F0A,0x0A0D,0x0E15,0x1E2A,
0x332D,0x231C,0x1311,0x1005,0xFCF2,0xE3D7,0xCAC4,0xC3C2,
0xC1C2,0xCDDC,0xCFCD,0xDCE6,0xDCD1,0xE0F4,0x0006,0x07FF,
0xF2E5,0xD9D4,0xD8DE,0xEBF7,0x0000,0xFDF4,0xECF3,0xF8FC,
0x0B1D,0x282C,0x313C,0x3326,0x1F1E,0x324B,0x4B43,0x3427,
0x2F22,0x1817,0x0EF9,0xECF1,0xEBF0,0x090B,0xF9E7,0xE3F1,
0xF6EF,0xEBF6,0x0005,0x0F1E,0x2826,0x1C14,0x0E0D,0x0C0B,
0x1016,0x100E,0x0C00,0xFAFA,0xF8FE,0xFDFA,0x050B,0x0701,
0x0302,0x01F3,0xDFD2,0xC8D0,0xF501,0xEBE8,0x030F,0x0B02,
0xEED1,0xC7D0,0xD7D7,0xD9DE,0xE2E7,0xF3FE,0x0205,0x0606,
0xFFF8,0x0924,0x1E05,0xEED5,0xC3D7,0xF1FA,0xFA00,0x0109,
0x1305,0xEEDF,0xEF04,0x0900,0xF1E2,0xECFB,0x0404,0x00F7,
0xEEF7,0x142C,0x2A26,0x2C48,0x5E57,0x3A19,0x0711,0x293C,
0x321A,0x121A,0x1A08,0xF5F2,0x0001,0xF8EB,0xEAFA,0xFEFC,
0xFBFC,0xF9F8,0xFF0C,0x181A,0x1B1C,0x1B21,0x2622,0x1608,
0xFFFB,0xFAF8,0xF1EA,0xEDFA,0x0400,0xECD8,0xD8E9,0xFBFE,
0xF9F9,0xFF07,0x100C,0x0103,0x0C14,0x140D,0xFFF4,0xF1F4,
0xF5F9,0x0412,0x180F,0x0401,0xFDF3,0xE3D6,0xDAE4,0xE6E6,
0xDDD1,0xC3B7,0xB2AF,0xAFAC,0xA4A7,0xB2BD,0xD1D6,0xC8C8,
0xD5EF,0x0D21,0x1F1D,0x2126,0x2C3D,0x5154,0x5048,0x372B,
0x2B2E,0x3131,0x2813,0x0C02,0x030F,0x181D,0x1C1F,0x2220,
0x0FF5,0xDDD3,0xD7E2,0xECF9,0x060C,0x04FD,0xFCF9,0xEDE6,
0xEBFF,0xFDE9,0xEDF2,0xF5F2,0xF4FD,0x040F,0x1007,0xFCF8,
0xF702,0x0B1D,0x2916,0x0C03,0xF3E9,0xE6EA,0xFB11,0x1717,
0x1103,0x010D,0x1E22,0x2931,0x2A15,0xFFE6,0xCFDB,0xF600,
0x060F,0x111D,0x2318,0xFEDF,0xE3F9,0xF7FC,0x0F20,0x1C02,
0xDDC4,0xC6D4,0xE903,0x1016,0x3243,0x4438,0x1E06,0x030A,
0x100C,0x0B09,0x06FD,0xF3E7,0xD7CF,0xDCF1,0xFBF8,0xEFE9,
0xE5DD,0xDEE4,0xE9EF,0xEADC,0xCFC5,0xC0C6,0xDCF2,0xFBF2,
0xE9E6,0xEAF1,0xFBF1,0xCDC3,0xCFD9,0xE0F0,0x0018,0x2928,
0x2110,0x0B17,0x2A32,0x2D2A,0x313B,0x371E,0x0D08,0x0B0E,
0x07FC,0xF906,0x141F,0x2823,0x1F1B,0x0F00,0xF8FA,0x0003,
0x06FD,0xF4EB,0xD4C3,0xCCDB,0xE6ED,0xF1FD,0x0402,0x0201,
0xFBF9,0x0B24,0x343C,0x4048,0x4A40,0x3121,0x1511,0x1A17,
0x09F8,0xECE6,0xE6E6,0xD7C5,0xC4DB,0xF806,0x01FF,0x090D,
0xF9EB,0xFA1D,0x3E48,0x453D,0x321F,0x1307,0x03FA,0xF4F2,
0xF2F6,0xF7EF,0xF3EE,0xE2EA,0xF3F4,0xEEF5,0x0911,0x080A,
0x2233,0x2B1E,0x04DF,0xCBD5,0xE6E1,0xC9C1,0xC4D1,0xEAEE,
0xD7D3,0xE6EE,0xECF7,0x0310,0x150C,0x0001,0x0F15,0x170D,
0x0812,0x241B,0xF9E5,0xDDE5,0xF6FC,0x00FE,0xF6E9,0xDED8,
0xDCE6,0xF0F8,0xFBFB,0x000E,0x1817,0x1D2F,0x382E,0x1F1A,
0x1610,0x0800,0xF8F4,0xF5F8,0xEDDA,0xD2D8,0xE0EB,0xF5FB,
0x0613,0x1916,0x0BFD,0xF6FA,0xF8F7,0xF0E7,0xE5E8,0xE8E3,
0xE2E7,0xF502,0x0907,0x0303,0x0705,0xF9EA,0xEC00,0x1415,
0x03FA,0xF3E1,0xD6DB,0xE7F0,0xEDF3,0x0009,0x0F17,0x0BFC,
0xFC06,0x0A06,0x0A17,0x212B,0x302D,0x2D2F,0x3127,0x1803,
0xF3F4,0x0000,0xF0E9,0xEFF4,0xFD11,0x293A,0x4C54,0x4A39,
0x17EE,0xE6FC,0x1313,0x05EB,0xD1BD,0xB4C1,0xDAE1,0xEDEF,
0xEDF3,0x0413,0x01EC,0xEE01,0x151A,0x130A,0x0717,0x3234,
0x1E0D,0x0304,0x0F21,0x3138,0x2D1C,0x1B22,0x232A,0x343C,
0x3F2F,0x1B0D,0x1010,0x0D09,0x0908,0xFEF0,0xE8DF,0xE8EA,
0xDCD8,0xD5D1,0xE1E6,0xD6D1,0xCDBD,0xADAC,0xB8C7,0xDEF0,
0xE2DF,0xEFFB,0x0E1A,0x05E5,0xC9DA,0x082E,0x271D,0x1A18,
0x1D15,0xFDEC,0xF0F2,0xE3CB,0xCBE1,0xEAE6,0xE2E6,0xEDF8,
0x061B,0x2929,0x1B0C,0x1628,0x1B0C,0x1828,0x2818,0x08F4,
0xE0DF,0xE9E6,0xDDDA,0xD6DE,0xF40D,0x221C,0x0F0E,0x1210,
0x0B02,0xFBFD,0x010E,0x1B10,0xFEF1,0xFA0C,0x110F,0x0B09,
0xFFF3,0xEDF2,0xECE2,0xE1E9,0xE6D2,0xD1E9,0xFF14,0x1F15,
0xF8E2,0xE8FE,0xFEF0,0xEDEE,0xF5FA,0xF4F1,0xF6F8,0xFAFA,
0xFE0F,0x222A,0x2622,0x262D,0x2E2C,0x251C,0x1923,0x3137,
0x3936,0x2A16,0xFFF0,0xE6D7,0xCFD9,0xEDFF,0xF8E4,0xDEDB,
0xD5C8,0xC0C4,0xCED4,0xE0E8,0xF1F9,0xF7FA,0x0208,0x0F0C,
0x0500,0x020A,0x0F13,0x1209,0x030D,0x2126,0x2326,0x2A26,
0x2524,0x2523,0x1908,0x00F6,0xE9E6,0xF0FC,0x01FF,0x0301,
0xFE04,0x0C16,0x140D,0x1416,0x0B00,0xFA07,0x1003,0xFE03,
0x090E,0x1216,0x1F1B,0x0F01,0xF3E0,0xCCC2,0xC3CB,0xD0D9,
0xDFEA,0xEEE9,0xE9F2,0xF6EC,0xECF8,0x0309,0x1219,0x1A11,
0x0C15,0x1A18,0x1205,0xFAF0,0xF714,0x3139,0x2F1E,0x1104,
0xF6F9,0xF5E1,0xD7E6,0xF3E9,0xDFDD,0xDFD8,0xD4DE,0xECEE,
0xF1FA,0xFAFC,0x0506,0x0208,0x192B,0x291F,0x2526,0x1F0B,
0x0114,0x2B32,0x1E0A,0x0B1A,0x251E,0x1408,0xF5EB,0xEBEF,
0xF4FE,0x090B,0x0602,0x0305,0x0D19,0x1F18,0xFFE1,0xE5FC,
0x0205,0x040B,0x1B17,0x00E9,0xDDD5,0xD2CF,0xD1D5,0xD9E1,
0xEAF2,0xF500,0x05FC,0xF4F7,0x020A,0x100E,0x0A09,0x0C16,
0x1704,0xF7EB,0xE3E3,0xEAEF,0xE9E4,0xE8EF,0xF9FC,0xF6F6,
0xFDFE,0xFF05,0x0906,0x0300,0xF9F4,0xEBE0,0xE3F7,0x080A,
0x05F8,0xECEE,0xF2EE,0xE5E3,0xE8EF,0xF7FA,0xFBFB,0xFAFF,
0xFFF0,0xDFDE,0xF00E,0x323F,0x2B22,0x2931,0x3728,0x0E06,
0x101C,0x1F12,0xFDF6,0x0002,0x00F3,0xDECF,0xCBD7,0xEFFD,
0x0B2D,0x3E2E,0x130A,0x090D,0x1116,0x1F2A,0x2E2F,0x343B,
0x3E3C,0x3631,0x2A1F,0x0BFD,0xF4E9,0xD7C9,0xCEDA,0xDBD9,
0xE7FB,0x0106,0x0C0D,0x0602,0x0507,0x00FE,0x0204,0x0001,
0xFDF1,0xE0DA,0xD1C0,0xB8C0,0xCEDE,0xE4D9,0xCED1,0xDDF6,
0x0501,0xF3E2,0xE3F2,0xF7F2,0xE4D3,0xDAED,0x040B,0x00FD,
0xF8FB,0x00F9,0xFB0D,0x1F24,0x1A0E,0x0E14,0x1C20,0x2031,
0x4952,0x4F45,0x2E20,0x2B32,0x3431,0x2B22,0x2022,0x2623,
0x190F,0x0E0E,0x06FF,0xFAFD,0x080A,0xFBE6,0xD5DC,0xEAE9,
0xE9ED,0xEBF4,0xF8F7,0xEEE9,0xF2F2,0xEBED,0xF6F7,0xF0DD,
0xCCC2,0xC7CF,0xD6E1,0xEFFB,0xF9EB,0xDBD2,0xD1D0,0xD1D6,
0xE6F4,0xF6FB,0xFCFF,0x0500,0x0002,0xFFF4,0xEEE6,0xEBFB,
0xFB00,0x0A13,0x0904,0x0711,0x1F20,0x2027,0x2720,0x1F14,
0x0B02,0xFD0A,0x181C,0x1102,0xFCFD,0x0508,0x0A1A,0x302C,
0x09F6,0x0318,0x1802,0xFD0D,0x1F1F,0x1616,0x1918,0x1D26,
0x2B27,0x2423,0x303C,0x3719,0x00EE,0xE3DD,0xE4E9,0xE3DB,
0xE600,0x1100,0xE8D2,0xC8C5,0xD0E8,0xFF18,0x2824,0x1502,
0xFBFB,0x0C1B,0x1517,0x2831,0x1807,0x0308,0x03F9,0xF7F8,
0xF6ED,0xF604,0x030B,0x1314,0x0400,0x1226,0x3121,0x02E8,
0xD0DA,0xE9E7,0xE2EA,0x0219,0x11FE,0xE9D9,0xD9D5,0xD1D0,
0xD8EB,0xFBF8,0xEBE1,0xDEDF,0xE7EB,0xECE2,0xD1D3,0xDFE8,
0xE2D8,0xD3DB,0xE4E1,0xE4F6,0x0E19,0x02E3,0xD4DD,0xE700,
0x150D,0x02FD,0xFE02,0xFFF4,0xEBE6,0xE8E8,0xE5F0,0xFF01,
0xFDF4,0xF7F9,0x0412,0x2028,0x2A23,0x1400,0xFDFF,0x000D,
0x2338,0x3927,0x0A05,0x1823,0x251D,0x0D07,0x0911,0x2132,
0x3D34,0x2623,0x262C,0x2F30,0x3330,0x2116,0x0800,0xFC00,
0x00F2,0xE7E0,0xD2C8,0xC9D3,0xDEDF,0xDEE2,0xE3E2,0xE8F0,
0xF6FB,0x00FC,0xF7F5,0xFB00,0x030B,0x0F1A,0x2B31,0x3223,
0x131D,0x262A,0x210F,0x0A07,0x0500,0xFBFC,0x00F8,0xEADD,
0xDBE2,0xE9E9,0xEBEC,0xECEC,0xEBE9,0xE4E0,0xE9F6,0x0108,
0x00EB,0xE3EE,0xFD02,0x00FA,0xF6FB,0x0002,0x0D12,0x0600,
0x0919,0x3546,0x3319,0xF6CD,0xCFD9,0xEEF1,0xE6F7,0x040A,
0x10F5,0xDFEA,0xF800,0x0802,0x1022,0x180E,0x08FE,0x0209,
0x0A10,0x02FA,0x00FC,0x020B,0x0508,0x05FF,0x0102,0x0F22,
0x2326,0x251B,0x1C15,0x0A09,0x00FE,0x04F9,0xE9EB,0xECEC,
0xE8E3,0xEBED,0xD4CD,0xDEF6,0x0C10,0x171C,0x1B26,0x2D30,
0x3B33,0x3035,0x2929,0x3331,0x3126,0x1304,0xE9D8,0xD4D0,
0xD4D2,0xC6C6,0xC2B5,0xA39A,0xA3B8,0xCBE2,0xF4E4,0xE2F3,
0x0011,0x1D27,0x3224,0x1A0F,0xF9E6,0xE6F0,0x0B1E,0x1D1E,
0x1613,0x0F0B,0x111B,0x1D1E,0x14FE,0xF2E9,0xE6E6,0xE3EA,
0xF3EE,0xF0F5,0xF7F8,0xFA00,0x0903,0xFAFA,0xF4FA,0x0004,
0x0E15,0x1924,0x282B,0x2B18,0x1014,0x1921,0x1E0C,0x0500,
0xFEF8,0xE3DA,0xD7CA,0xC4C4,0xC1C8,0xD3E7,0xFF01,0x00FD,
0xF9F4,0xF4FB,0x0305,0x0304,0x050C,0x171E,0x1F20,0x1C19,
0x170B,0x0608,0x0C16,0x1B22,0x261B,0x0F06,0xFFFA,0xF5EC,
0xDFD7,0xDAE2,0xDED7,0xD7DA,0xDADE,0xE2E5,0xF200,0x0B20,
0x1C02,0xFB00,0x0407,0x0914,0x2233,0x3834,0x383C,0x3C36,
0x250D,0xF5E5,0xE4E9,0xF3F3,0xEAEA,0xE7E0,0xE1E9,0xF805,
0x0F1A,0x1E0D,0xFCF6,0xF904,0x151E,0x1805,0xEBD5,0xD9E7,
0xFC00,0xEBE2,0xE8F8,0x0C1C,0x2324,0x241F,0x1607,0xFE00,
0x0A13,0x1512,0x0600,0x060D,0x04FB,0xF2E5,0xE8F8,0x0300,
0xF5F2,0x000F,0x1615,0x0D0C,0x181D,0x1607,0xFDF7,0xE6D2,
0xC6C0,0xC5D9,0xEF03,0x120D,0xFCE3,0xD9DE,0xE4EE,0xFBF9,
0xF5F8,0xFB00,0x0604,0x04F8,0xE5E9,0xF500,0x0300,0xFAF5,
0xF0E7,0xE1DA,0xD9DA,0xDFEC,0xF6F7,0xF5F5,0xFBFF,0x0412,
0x232F,0x373D,0x3E3A,0x3837,0x362E,0x2316,0x0B08,0x0702,
0xFDF5,0xF3F4,0xFD09,0x0C07,0x0814,0x1F21,0x1A11,0x0C11,
0x1613,0x1108,0x040B,0x05FF,0xFAF8,0xF4EE,0xE8F9,0x00F6,
0xECE4,0xDFE4,0xEBFA,0x0300,0xFCF4,0xEDEC,0xEFFA,0xFDFC,
0xFD00,0x0B0E,0x01EE,0xE5EB,0xF2F4,0xF4F6,0xF4EF,0xEAEA,
0xF400,0x0100,0x0000,0xFEF4,0xF2FC,0x0001,0x00FD,0x030C,
0x111A,0x2129,0x2515,0x0700,0x0003,0x0A12,0x1613,0x1418,
0x1711,0x00ED,0xE9F6,0x0709,0xF9F6,0x0C21,0x2824,0x1810,
0x0A0E,0x161B,0x1E15,0x0400,0x050A,0x0B08,0x02FD,0xF7EE,
0xE0D6,0xD7DE,0xDED1,0xC8C8,0xD0DF,0xEFFB,0x0000,0x0101,
0xF9EF,0xEFFD,0x0D18,0x1509,0x0A11,0x181C,0x1307,0x00FA,
0xF800,0x0C14,0x0B01,0xFDF8,0xF4F4,0xF4F4,0x0114,0x1406,
0x020D,0x1C27,0x2619,0x0A00,0x0009,0x120D,0x03FF,0xF8F3,
0xECE4,0xD8D5,0xDEEC,0xFA01,0x0403,0xFBE7,0xDADC,0xE1EA,
0xEDEB,0xEDED,0xEAE9,0xE2DE,0xE7EB,0xF0FA,0xFAFA,0xF9F0,
0xEDF9,0xFE03,0x03FD,0xFD06,0x1420,0x1E07,0xF6F5,0x000B,
0x0907,0x090E,0x0C06,0x0602,0xFAEE,0xEDF9,0x0000,0x0209,
0x0600,0xF7EB,0xEBFC,0x1429,0x3935,0x2118,0x191E,0x2324,
0x2423,0x1504,0xFBFC,0x0309,0x0500,0xFDFD,0xFAF3,0xF703,
0x1318,0x0CFE,0xEBEA,0xFF00,0xEEE5,0xEFF8,0xF2E6,0xDEE3,
0xEEF9,0x0008,0x0800,0xF0EE,0xF2F2,0xF5FB,0x020B,0x0701,
0x0100,0xFCF8,0xF8FB,0xFF04,0x0810,0x1C25,0x271C,0x0AFD,
0xFBFC,0x000F,0x1F19,0xFFE3,0xE4F3,0xF8FA,0x0112,0x1F28,
0x3333,0x2207,0x0009,0x0F10,0x0D07,0xFFF4,0xF3FB,0x0308,
0x070A,0x0F0D,0x0602,0x0912,0x1418,0x1708,0xF1E2,0xE4EB,
0xFB0A,0xFCDB,0xC2C2,0xD5EC,0xF9FC,0xFE02,0x02F2,0xE4E9,
0xF50A,0x1B0C,0xF9E7,0xDBDD,0xE8F6,0xF900,0x00F9,0xF9FE,
0xFEFE,0x0509,0x03F9,0xF4FE,0x0A06,0xFDFC,0x050F,0x140F,
0x0C04,0xFF07,0x1316,0x0E07,0x0D16,0x1310,0x1010,0x1110,
0x0702,0x00FC,0xFDFC,0xF4ED,0xEFF2,0xF2F7,0xFD00,0x0402,
0xFEF7,0xF2F4,0xF9F9,0xF5F4,0xF7FE,0x0202,0x0607,0xFEFB,
0x0005,0x0500,0xFE00,0xFEF9,0xF4F1,0xF7FE,0x0002,0x0404,
0x0400,0xFAF4,0xF1F2,0xF7FD,0xFFFE,0xFEFD,0xF5EA,0xE7F2,
0x0715,0x1102,0xFAF9,0xF8F3,0xE9E2,0xE9F8,0x01FE,0xF3F0,
0xF2EF,0xE8EE,0xFE0C,0x0F06,0xF8EF,0xF602,0x0B09,0x01F7,
0xF1F3,0xFAFF,0x00FA,0xF6FC,0x050B,0x0D0F,0x1925,0x2E30,
0x2C2A,0x2416,0x0A08,0x0400,0xFBF3,0xEDEE,0xF2EF,0xE7E3,
0xE3E9,0xFA0B,0x161A,0x1B19,0x1D26,0x2D2A,0x1F15,0x1011,
0x1B24,0x2319,0x1411,0x0E13,0x191C,0x1B16,0x0B00,0x0001,
0x0206,0x0D11,0x0C08,0x0A0A,0x06F8,0xEADC,0xCAC8,0xD5E6,
0xEAE5,0xEBF6,0xF3EB,0xECEE,0xF1FE,0x1016,0x0B04,0xFFF2,
0xE6DE,0xD9DA,0xDCEC,0xFB02,0x0402,0x0410,0x1C13,0x02FA,
0xF0F3,0x030F,0x0800,0x0000,0xF9EF,0xF100,0x0607,0x08FF,
0xEBE5,0xEBFB,0x0305,0xFFEE,0xDFDC,0xDCE1,0xEBF3,0xF3EF,
0xF0F3,0xF6FE,0x020B,0x1A24,0x2924,0x252A,0x2A25,0x1A0F,
0x0805,0x0A05,0xF8F3,0x000C,0x09FD,0xF2F3,0xFD09,0x1617,
0x0D0B,0x1011,0x1217,0x1710,0xFFEF,0xF2F4,0xF0F1,0xF3F2,
0xF4EE,0xE9E8,0xE9F3,0xFD05,0x0605,0x0508,0x0803,0x00FD,
0xF8F1,0xEBED,0xF3F5,0xFD0B,0x1206,0xFAF9,0x000D,0x1C2C,
0x2B1C,0x0F06,0xFCF7,0x0010,0x1C0B,0xF6EC,0xF300,0x0300,
0x0203,0xFF00,0xFFF3,0xECEE,0xFC09,0x1117,0x1B14,0x00E6,
0xE3F0,0xFD01,0x0808,0xFEF9,0xF7F5,0xF3F3,0xF1EA,0xE4E4,
0xECFA,0x0808,0x01FA,0xFB00,0xFFF7,0xF1E7,0xE4ED,0xFBFA,
0xF6FE,0x00FA,0xF0F0,0xF3FC,0x0A16,0x1C17,0x1414,0x1718,
0x1408,0xFF00,0x0607,0x0606,0x0603,0xF8F4,0x000B,0x0E08,
0x00FC,0xFF03,0x01FC,0xF5F3,0xFA00,0x0303,0x01FD,0xF4EC,
0xEEF6,0xF6F1,0xF1FA,0xFFF9,0xF5FD,0x0003,0x070C,0x0E07,
0x060B,0x0E0A,0x02FD,0xFA00,0x0F14,0x1212,0x0E03,0xFCF9,
0xF6EE,0xF1FF,0xFCF2,0xECF2,0xF4F4,0xFD02,0x01FD,0xFAFB,
0xFCFD,0x050E,0x04F1,0xF0FC,0x040C,0x1314,0x161D,0x1E1C,
0x1306,0xFBF5,0xF8F8,0xF6F9,0xFE04,0x101D,0x2521,0x1C1D,
0x1E14,0x080C,0x1E28,0x2218,0x0A00,0x00FE,0xF5EC,0xEEF8,
0xFDF6,0xEFEC,0xEBE6,0xDEDC,0xE1EB,0xF5FC,0x040E,0x1212,
0x1413,0x0B05,0x0701,0xFEFC,0xFE00,0xFDFC,0xFDFF,0xFFF7,
0xEFEA,0xE7E5,0xE3E8,0xF1F3,0xEDE9,0xEAE8,0xE2E3,0xEFFB,
0xFFFC,0xFCFD,0xFCFB,0x020C,0x110D,0x0407,0x100C,0x05FF,
0xFD07,0x1618,0x1518,0x1B17,0x0D08,0x0B0E,0x0D08,0x00FA,
0xF2EE,0xF3FF,0xFEF3,0xEEF6,0x0004,0xFFF7,0xF4F2,0xEEEE,
0xF2F6,0xFD03,0x0F13,0x0B07,0x101B,0x1F1D,0x1A14,0x0D0E,
0x1417,0x170F,0x0A0C,0x0706,0x02FD,0xF5E8,0xE4EA,0xE8E3,
0xE1DE,0xDCDB,0xDDE4,0xEDF1,0xF2F2,0xEFEF,0xF3F7,0xFD05,
0x0D14,0x1C1F,0x1E1C,0x1711,0x1215,0x0E0A,0x0905,0x02FA,
0xF0E6,0xE8F5,0xFAF9,0xFC00,0x0403,0x0304,0xFFFA,0xF8F9,
0xF8F8,0xF7FA,0x0003,0x0503,0xFEF2,0xE5E8,0xEFF6,0xFE06,
0x0E0F,0x1317,0x1415,0x160F,0x01F7,0xECE3,0xE3ED,0xFF08,
0x0B0B,0x0901,0xF7ED,0xF400,0x0207,0x0904,0xF9F0,0xE9E9,
0xEBF1,0xF9FD,0xFEFF,0xFEFC,0x091B,0x2425,0x201C,0x1510,
0x110E,0x0B09,0x0600,0x030F,0x1610,0x0600,0xFF01,0x0101,
0x0305,0x0202,0x02FF,0xFAF6,0xF4F5,0xF7F8,0xFBFE,0x060B,
0x0C0D,0x0D0C,0x0704,0x070D,0x0D06,0xFDF2,0xE9E7,0xEBEF,
0xF4F6,0xF6F4,0xF3F7,0xFE04,0x0505,0x0507,0x0A11,0x171A,
0x1611,0x1111,0x110B,0x03FB,0xF1EC,0xEFF4,0xF8FA,0xF5EC,
0xE6E7,0xECF1,0xF3F1,0xF0F0,0xEDEF,0xF5F6,0xF9FA,0xFBFC,
0xFCFB,0xFE05,0x0C0E,0x0904,0x00FE,0xFCFD,0x0105,0x0608,
0x0C0D,0x0E11,0x1518,0x1919,0x1B1B,0x1917,0x1513,0x110A,
0xFEF6,0xF6F8,0xFBFB,0xF8F8,0xF8F6,0xF5F6,0xF4EC,0xE6E6,
0xEBEE,0xEEED,0xEEEE,0xECEC,0xF1F8,0xFDFE,0xFCF6,0xF2F6,
0xFF06,0x0500,0xF6EC,0xEAF1,0xF1EE,0xF0F4,0xFC02,0x070A,
0x0D0A,0x080B,0x0F14,0x1205,0xFEFB,0xFAFD,0x020B,0x161D,
0x1B15,0x0A03,0x0409,0x0F10,0x0F0D,0x0E17,0x1C16,0x100B,
0x0604,0x0606,0x01FD,0xFC00,0x0302,0xFEFD,0x020C,0x120B,
0x0907,0x0400,0xFCFD,0xFDF8,0xF8FA,0xFBFC,0xFBF8,0xFB05,
0x0F11,0x0904,0x0100,0x030C,0x0E07,0xFDFC,0x0002,0x00FD,
0xF3E6,0xDBD9,0xDCE1,0xEFFB,0xFDFE,0xFAF4,0xF8FE,0x00FC,
0xFBFF,0x0001,0x01FC,0xF8F7,0xFA00,0x0000,0xFDFE,0xFEFB,
0xF7F4,0xF4F5,0xF6F7,0xF8F9,0xFBFE,0xFEF9,0xF3F3,0xF9FF,
0x0000,0xFCFB,0xFCFE,0xFDFC,0xFDFF,0xFF00,0x0002,0x080E,
0x1011,0x1414,0x100F,0x0F0F,0x0D0E,0x1318,0x1B19,0x1206,
0x0105,0x0502,0x0102,0xFBED,0xE6E7,0xE9EF,0xFB03,0x0A08,
0x0100,0x0105,0x0705,0x00F8,0xF1F0,0xF4F6,0xF6F5,0xF1EA,
0xE7EA,0xF1F8,0x0002,0x0102,0x0507,0x0501,0x0206,0x0C0F,
0x0B04,0x030A,0x1215,0x1212,0x0D01,0xFE00,0x070B,0x0807,
0x0808,0x0707,0x090D,0x0C0B,0x0D0B,0x0606,0x0808,0x0503,
0x0504,0xFEF3,0xECEB,0xEEF3,0xFB02,0x0910,0x1108,0xFFFF,
0x0508,0x0500,0xFD00,0x0808,0x0000,0x00FB,0xF2ED,0xECEB,
0xE7E6,0xE9EB,0xEBEB,0xEAEC,0xF3F8,0xF5F1,0xF4FD,0x080F,
0x1009,0x0403,0x060B,0x0D06,0xFDF7,0xFC05,0x0B09,0x0301,
0x0407,0x090A,0x0601,0x00FF,0xFDF9,0xF900,0x070C,0x0E0C,
0x0601,0x0002,0x0305,0x0300,0xFEFA,0xF6F3,0xEEEB,0xEBEE,
0xF2F7,0xFBFA,0xF7F5,0xF5F6,0xF6F8,0xFAFC,0xFF02,0x0507,
0x0A0B,0x0A08,0x0507,0x0E12,0x1413,0x1210,0x0D09,0x0706,
0x0504,0x0301,0x00FE,0xFBFA,0xFAFA,0xFBFB,0xFD00,0x0100,
0x0001,0x0100,0xFFFD,0xFCFE,0xFEFC,0xF6F3,0xF3F5,0xF5F5,
0xF5F5,0xF8FC,0xFEFE,0x0005,0x0709,0x0D0F,0x110F,0x0D0C,
0x0C0C,0x0C09,0x0403,0x0506,0x0402,0x0200,0xF8F6,0xFBFE,
0xFDFD,0xFFFD,0xFAFA,0xFE00,0xFFFC,0xFAF9,0xF7F8,0xF7F9,
0xFEFE,0xF9FB,0x00FF,0xFDF9,0xFA00,0x0304,0x0305,0x0806,
0x00FD,0xFF03,0x0709,0x0808,0x0D12,0x0E09,0x0501,0x0000,
0x0001,0x0101,0x0000,0x0000,0xFFFB,0xF5F5,0xF9FC,0xFCFC,
0xFDFB,0xF6F2,0xF7FD,0x0106,0x01F4,0xF1FA,0x0405,0xFFFA,
0xFF04,0x090C,0x0B08,0x0709,0x0B08,0x00FD,0x000A,0x0B04,
0xFCF1,0xECF2,0xFA01,0x0301,0x00FF,0xFDF9,0xF9FB,0xFC00,
0x0509,0x0C0B,0x0907,0x0600,0xFDFB,0x0008,0x0E0E,0x0905,
0x060B,0x100C,0x00F9,0xF5F8,0xFCFF,0x0307,0x0400,0xFDFA,
0xF2EF,0xF4FB,0x0005,0x0600,0xF8F2,0xF2FA,0xFF02,0x0300,
0xF8F0,0xF1F9,0xFDFC,0xFAFD,0x050D,0x0E0A,0x02FB,0xF9FE,
0x0305,0x00F9,0xF5F3,0xF2EF,0xF1FB,0x0107,0x0A09,0x0705,
0x0301,0x00FE,0xFEFD,0xF7F1,0xF0F6,0xFDFD,0xF6F3,0xF5F7,
0xFA00,0x00FD,0x0001,0x0104,0x0405,0x0607,0x0A0D,0x0904,
0x0509,0x0907,0x01FD,0xFBFF,0x050C,0x1211,0x0D09,0x0608,
0x0B0A,0x0600,0xFCF9,0xFAFB,0xF9FC,0xFCFD,0xFE00,0x0103,
0x0507,0x0601,0xFEFE,0xFEFC,0xFCFA,0xF7F8,0xF9F9,0xFAFE,
0x0005,0x0A0C,0x0B07,0x0202,0x0402,0x0205,0x0B0D,0x0800,
0xFAFB,0x0107,0x0B0D,0x0C0A,0x0604,0x0607,0x0709,0x0A04,
0x0000,0xFEFD,0xFDFC,0xFBFC,0xFDFA,0xF6F3,0xF3F4,0xF7F6,
0xF6F6,0xF0E9,0xE8ED,0xF5FE,0x070D,0x0C08,0x0808,0x0605,
0x070A,0x0C0B,0x0805,0x03FF,0xFBFC,0xFEFC,0xFBF9,0xF9FB,
0xFAF6,0xF8FF,0x0302,0x0101,0x0205,0x0604,0x0101,0x0404,
0x0303,0x070A,0x0701,0xFFFF,0xFFF9,0xF5F7,0xF9FA,0xFBFD,
0xFDFB,0xF9FC,0x0000,0xFEFD,0xFF01,0x0401,0x0000,0x00FD,
0xFAFA,0xFAFA,0xFEFE,0xFD00,0x0100,0xFCFA,0xFDFC,0xFB00,
0x0403,0x00FB,0xFBFE,0x0000,0xFEFD,0xFDFB,0xFBFE,0x0002,
0x0300,0xFF01,0x090E,0x0B03,0x0004,0x0807,0x0200,0x0008,
0x0D0D,0x0A07,0x02FF,0xFDFD,0x0000,0xFCF7,0xF1ED,0xE9E9,
0xECF1,0xF6FA,0xFCFD,0x0000,0x040C,0x100E,0x0B09,0x0809,
0x0B0B,0x0D0B,0x0702,0xFDF9,0xF9FE,0x0302,0x0000,0x0206,
0x0600,0xFCFD,0xFEFF,0x0004,0x0704,0x0204,0x0707,0x070C,
0x1012,0x1414,0x1008,0x00FF,0x0300,0xFDFA,0xF4F0,0xF3FB,
0x0200,0xF9F5,0xF7FA,0x0003,0x01FD,0xF5EE,0xEBEC,0xEFEF,
0xEFF2,0xF5F9,0xFCFD,0xFE00,0x0405,0x0508,0x0A0B,0x0C09,
0x0706,0x0505,0x0809,0x0807,0x0502,0xFFF9,0xF7F6,0xF5F7,
0xF7F6,0xF7FB,0x0003,0x0405,0x0403,0x0304,0x0302,0x0303,
0x0100,0xFEFB,0xFBFE,0x0001,0x0206,0x0804,0x0100,0xFFFE,
0xFDFC,0xFBFB,0xFEFF,0x0002,0x0606,0x0403,0x0305,0x0704,
0x00FE,0xFCFA,0xFBFF,0x00FD,0xFBF9,0xF8F7,0xF8F8,0xF7F8,
0xFD02,0x0200,0xFEFB,0xF8F5,0xF5FB,0x0000,0x0101,0x0101,
0x0307,0x0A0F,0x1313,0x120F,0x0B09,0x0909,0x0706,0x0605,
0x0301,0x0000,0x0203,0x0300,0x0000,0xFFFD,0xFAF7,0xF8FA,
0xFCFC,0xFAF9,0xF7F5,0xF6F8,0xFC01,0x070C,0x0C08,0x02FE,
0xFAFA,0xFD00,0x0202,0x0000,0xFFFF,0xFFFE,0xFCFD,0xFEFA,
0xF6F7,0xFBFF,0x0101,0x0003,0x0608,0x0705,0x0200,0xFEFF,
0x0102,0x00FC,0xF6F1,0xEDEF,0xF2F7,0xF9F9,0xF9FB,0xFE00,
0x0307,0x0808,0x0806,0x0300,0xFE00,0x0407,0x0806,0x0200,
0x0001,0x0102,0x0609,0x0C0A,0x0502,0x0102,0x0204,0x0506,
0x080A,0x0903,0x00FD,0xFD00,0x0000,0xFEFC,0xFAF9,0xF8F9,
0xFBFE,0x0000,0x00FD,0xFBFB,0x0001,0x0203,0x0404,0x0505,
0x0505,0x0403,0x0303,0x0201,0x0001,0x0101,0x0000,0xFFFD,
0xF9F7,0xF7F9,0xFBFD,0xFEFE,0xFD00,0x0202,0x01FC,0xF7F7,
0xF9FC,0xFE00,0x0101,0xFFFD,0xFBFA,0xF9F9,0xFAFD,0xFF00,
0xFFFF,0xFEFE,0xFEFE,0xFF00,0x0307,0x0806,0x0200,0xFEFE,
0x0005,0x0604,0x0100,0xFF01,0x0302,0x0201,0x0204,0x0404,
0x0406,0x0809,0x0908,0x0604,0x0303,0x01FF,0xFE00,0x0103,
0x0303,0x0100,0x0103,0x0606,0x0605,0x0301,0x0101,0x0102,
0x0302,0x0000,0xFFFB,0xF7F4,0xF5F8,0xFAFA,0xF7F5,0xF5F6,
0xF7F8,0xF9FA,0xFBFD,0xFEFF,0xFFFF,0xFFFF,0x0001,0x0201,
0x0000,0x0104,0x0607,0x0707,0x0A0B,0x0804,0x0100,0xFFFF,
0x0000,0xFEFB,0xF7F6,0xF7FA,0xF9F5,0xF3F5,0xF8FA,0xFCFF,
0x0000,0x0000,0x0002,0x0406,0x0603,0x0100,0x0000,0xFFFF,
0x0004,0x0504,0x0101,0x0204,0x0606,0x0607,0x0603,0x0201,
0x0001,0x00FF,0xFF00,0x0001,0x0000,0xFDFB,0xFDFF,0x0000,
0xFFFD,0xFCFA,0xFCFC,0xFBFA,0xFAFC,0xFF02,0x0302,0x0202,
0x0303,0x0506,0x0402,0x0204,0x0504,0x0508,0x0907,0x02FE,
0xFCFE,0x0002,0x0000,0x0000,0x0000,0x0000,0xFFFC,0xFBFB,
0xFBFB,0xFE00,0x0000,0xFEFD,0xFDFE,0xFEFE,0xFCFA,0xF9FA,
0xFCFF,0x0002,0x0201,0x0101,0x0202,0x0405,0x0606,0x0504,
0x0404,0x0505,0x0504,0x0100,0xFFFF,0xFF00,0x0000,0xFFFF,
0xFFFF,0xFEFE,0xFDFC,0xFEFF,0xFFFE,0xFEFD,0xFDFD,0xFDFD,
0xFCFC,0xFE00,0x0101,0x0000,0x0101,0x0100,0x0000,0x0000,
0x0101,0x0000,0x0001,0x0202,0x0101,0x0203,0x0405,0x0504,
0x0302,0x0100,0x00FF,0xFF00,0x0002,0x0303,0x0100,0x0000,
0x00FF,0xFEFC,0xFBFA,0xF9FA,0xFCFE,0x0000,0x0001,0x0202,
0x0201,0x0000,0xFDFC,0xFCFD,0xFEFF,0x0000,0x00FF,0xFF00,
0x0203,0x0302,0x0000,0xFFFF,0x0000,0x0101,0x0000,0x00FE,
0xFDFD,0xFF00,0xFFFE,0xFDFE,0xFEFF,0xFF00,0x0002,0x0304,
0x0404,0x0403,0x0202,0x0201,0x00FF,0xFDFD,0xFE00,0x0000,
0x0203,0x0200,0xFFFE,0xFDFE,0xFF00,0x0102,0x0201,0x0000,
0x0000,0x0000,0x0000,0xFFFE,0xFFFF,0xFF00,0x0000,0x0203,
0x0201,0x0001,0x0100,0x0000,0x0000,0x0000,0x0000,0xFF00,
0x0000,0x0101,0x0000,0xFFFF,0x0001,0x0202,0x0100,0xFF00,
0x0000,0x0000,0x00FF,0xFDFB,0xFCFD,0xFEFD,0xFEFE,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0101,0x0101,0x0101,
0x0101,0x0000,0x0000,0x0001,0x0101,0x0101,0x0000,0x00FF,
0xFFFF,0xFFFE,0xFEFF,0xFFFE,0xFEFE,0xFEFE,0xFEFE,0xFEFF,
0x0001,0x0102,0x0101,0x0000,0xFFFF,0xFF00,0x0000,0x0000,
0x0000,0x0101,0x0000,0x0000,0x0000,0x0202,0x0100,0x0000,
0x0002,0x0303,0x0303,0x0201,0x0101,0x0100,0x0001,0x0304,
0x0302,0x0100,0x0000,0x0000,0x0000,0x0000,0x00FF,0xFEFD,
0xFDFE,0xFFFF,0xFEFE,0xFEFF,0x0000,0x0000,0x0000,0x0102,
0x0303,0x0201,0x0202,0x0101,0x0101,0x0000,0xFFFE,0xFEFE,
0xFEFE,0xFEFE,0xFFFF,0xFFFF,0x00FF,0xFF00,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0001,0x0101,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0101,0x0202,0x0101,0x0000,0xFEFD,0xFEFE,
0x0000,0x0000,0x0000,0x0000,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFE,0xFEFE,0xFEFF,0x0000,0x0000,0x0000,0x0000,0x0101,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0001,0x0202,0x0303,0x0202,0x0101,0x0000,0x0000,0x0100,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0101,0x0100,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0100,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x00FF,0xFF00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0xFFFF
};

