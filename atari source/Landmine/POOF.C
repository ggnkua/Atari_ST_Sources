/* Clear area sound */
#define STEP_SAMPLE_LENGTH	(0x10D0+0x80)
int step_smp_length = STEP_SAMPLE_LENGTH;
int step_smp_rate = 0x82;
int step_sample[STEP_SAMPLE_LENGTH / 2] = {
0x3242,0x4954,0x504F,0x4F46,0x0000,0x002D,0x0000,0x0008,
0xFFFF,0x0000,0xFFFF,0xFF00,0x30E5,0x0000,0x10D0,0x0000,
0x0000,0x0000,0x10D0,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x5354,0x4552,0x454F,0x2052,0x4550,0x4C41,0x5900,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0303,0x0E11,0x0700,0xFDFD,0x0007,0x0707,0x0300,0x03FD,
0xF90A,0x11FD,0xF9FD,0xFD03,0x0703,0xF9F9,0x030E,0x0300,
0x00F9,0x0011,0x0E00,0x0300,0x030A,0x0000,0x1511,0x0307,
0x0707,0x0000,0xFD03,0x03FD,0xFDFD,0xFDFD,0xF6F2,0xF6FD,
0x07F9,0xEFEF,0xEBF9,0xF9EB,0xEFF6,0xF2EF,0xEFEF,0xF2F2,
0xF2EB,0xF6FD,0x00F2,0xF6F2,0xF6FD,0xF9F9,0x03F9,0xF903,
0x0707,0x0703,0x07FD,0x0007,0x0E07,0x030A,0x110E,0x1515,
0x0E07,0x070A,0x0E11,0x1111,0x0E07,0x0307,0x0A07,0x0A0E,
0x0A0E,0x0A00,0x0007,0x070A,0x0E0A,0x0303,0x0000,0x0307,
0x110E,0x03FD,0x0003,0x0307,0x0700,0x030E,0x07FD,0xFDFD,
0x0003,0x0303,0x0700,0xFDFD,0xFDFD,0x0303,0xFDF9,0xF6FD,
0xFDF2,0xEBF6,0xFDF6,0xF2F6,0xF9F6,0xF2F2,0xF2F6,0x0000,
0xF6F2,0xF2F9,0xF9F6,0xF2F9,0xFDF9,0xF6F9,0xF9F9,0xFDFD,
0xFD03,0x03FD,0xFDF6,0xF903,0x0700,0x0000,0x0000,0x0303,
0x0307,0x0300,0x0000,0x0703,0x0000,0x030A,0x0A0A,0x03FD,
0xFD03,0x0307,0x070A,0x0700,0xFD00,0x0303,0x0707,0x070A,
0x0A00,0xF9FD,0x0303,0x0707,0x0300,0xFDFD,0xFD00,0x070E,
0x03F9,0xF900,0x0300,0x03FD,0xFD07,0x03FD,0xF9F9,0xF9FD,
0xFDFD,0x0300,0xFDFD,0x00FD,0x0307,0x00FD,0xFDFD,0x00FD,
0xF6F9,0x0000,0xFDFD,0xFDF9,0x00FD,0xF6F9,0x00F2,0x1FF6,
0x114A,0x151F,0xFD07,0x11D9,0xEBFD,0xF90A,0xFDE1,0x03E1,
0xEFF2,0xE8F9,0xEFF9,0x181C,0x1507,0x1527,0x272A,0x2A11,
0x0A11,0x07EB,0xEBEF,0xE1D9,0xD2DD,0xE8DD,0xE1D9,0xD6FD,
0xFDFD,0x0711,0x2E35,0x2E43,0x4A51,0x5F38,0x3F38,0x4A3C,
0x110A,0x03FD,0xF2D6,0xD2E8,0xD6B6,0xC1F2,0xF6EF,0xEBE4,
0xF2D6,0xCBC1,0xEBD9,0xB9E4,0xF2E8,0xD2CB,0x07F6,0x071F,
0xFDF2,0xE1E4,0xC4E4,0xCBE8,0x11B9,0xF911,0x3115,0xF20A,
0x0E0A,0xCB15,0x1511,0xF92A,0x3858,0x3C23,0x381F,0x15F9,
0x150E,0x0A18,0xE100,0x030A,0x1123,0x2355,0x7815,0xE13C,
0x0027,0xFD0A,0x436E,0x07D9,0x233F,0x0E03,0xB2FD,0xE4F6,
0xC1EB,0xEB03,0xC4EB,0xD218,0xE4E8,0xE8E4,0xE807,0x0303,
0x0EF6,0xE1D2,0xD9CF,0xB6CF,0xC1D6,0xE4CB,0xD2F2,0xE8E4,
0xD2FD,0xF6FD,0xFDD9,0xF60A,0xD2C8,0xD6F2,0xEFE8,0xCBE1,
0xEFEB,0x07F6,0x00F9,0xF600,0x0A18,0x234E,0x2727,0x1C1C,
0x381C,0x110E,0x1C51,0x274E,0x3843,0x552E,0x1838,0x3F27,
0x1F15,0x113F,0x150A,0x382A,0x1127,0x432E,0x18FD,0x0E2E,
0xFD11,0x1F15,0xF90A,0x070E,0x1503,0xF903,0xE8DD,0xF903,
0xD203,0x110A,0x0707,0xF911,0x11F6,0xF911,0xD6F2,0xDDDD,
0xD9D2,0xCFFD,0xD6D6,0xF6F6,0xD2D6,0xBDA8,0xB6CF,0x8FC8,
0xEFFD,0xDDE1,0xE1F9,0xF2FD,0xDDF6,0xF60A,0xD9E4,0xE8E1,
0xE1EF,0xE4F2,0xFDD9,0x0315,0xFD0A,0x0007,0x11EB,0x03F9,
0x0AF6,0x00DD,0xFDF6,0xDDE8,0xFDE1,0xD9E4,0xF907,0x270E,
0x1515,0x1F18,0x4A23,0x0E18,0x1C43,0x311F,0x182E,0x0A11,
0xFD1F,0x3118,0x150A,0x1F18,0x1511,0x0A1C,0x431F,0x1507,
0x2735,0x27FD,0x0A27,0x1815,0x2335,0x2A11,0xF611,0x1F23,
0xDDE8,0xF9F6,0xDDFD,0xE4E4,0xF2E1,0xE107,0x0A0E,0x111F,
0x151F,0x0A07,0x07F2,0xE1D9,0xD2C1,0xAFC1,0xB9C4,0xBDC4,
0xD6E8,0xEB00,0x1F3C,0x3C47,0x4A4E,0x4327,0x2E47,0x4331,
0x2A1C,0xEFFD,0xEFEB,0xF2DD,0xE1E4,0xCBC1,0xC4B6,0xB2A4,
0xABA4,0xB6BD,0xC8CB,0xE1EF,0x0011,0x1C31,0x2A43,0x3147,
0x5543,0x431C,0x1511,0x00EF,0xD6C8,0xA4A8,0xB9C4,0xB6F6,
0xB2D2,0xCB0A,0x0A0E,0xCB18,0xF600,0xE400,0xD6E1,0xD9EB,
0xF6D9,0xE1E4,0xE1EF,0xEF0A,0xF215,0xF215,0x00FD,0x231F,
0x1827,0x232A,0x1811,0x1C31,0x3F31,0x312A,0x0A31,0x3C4A,
0x5147,0x754A,0x3511,0x3511,0xFD18,0x1C0A,0x001C,0x180A,
0xF62A,0x1518,0x1518,0x072A,0x11FD,0x18E1,0xE4EF,0x03FD,
0xF6E1,0xEBD6,0xF200,0x0E0E,0xEBB6,0xDDE8,0xE803,0x1FF6,
0xEBEB,0xF6F2,0x07F2,0xF6D9,0xD2C8,0xCBAF,0xA4A1,0xA89D,
0xA8A4,0xAFB9,0xC1D9,0xEF03,0x112A,0x4355,0x5C6A,0x7163,
0x7C75,0x7F6A,0x7C6E,0x5847,0x3118,0x1C00,0xEF0E,0xF9EF,
0xF6FD,0xF903,0x070E,0x1F11,0x110E,0x150E,0x0E11,0x0EFD,
0xDDD6,0xD6C8,0xBDB2,0xB9AB,0xAFA1,0xB9CF,0xD2C8,0xE1CB,
0xFDF6,0x0A11,0x15FD,0x0A11,0x1518,0x0E07,0x11FD,0xF6F2,
0xF2E8,0xE8F6,0xE1D2,0xE1EF,0xE4E8,0xF2E1,0xEBF2,0x0EF2,
0xFDE8,0x11F6,0xFDFD,0xFDDD,0xE4F9,0x03EB,0x0315,0x0315,
0x0318,0xFD07,0xFD15,0x0007,0xF9FD,0xF2F6,0xF6F9,0xF9FD,
0xEF03,0xFDFD,0xF918,0x1115,0x1818,0x0307,0x1511,0x1515,
0x0A07,0x000E,0x182A,0x2E2E,0x2E2E,0x3C43,0x434E,0x3F27,
0x180A,0xF9F2,0xE1D2,0xC1B6,0xA4A1,0x9696,0xA8AB,0xAFB2,
0xB2CB,0xD2DD,0xEBFD,0x03FD,0x0A1F,0x2327,0x2E35,0x4343,
0x4E55,0x514E,0x474E,0x513F,0x4338,0x2E1F,0x180A,0x00FD,
0x0307,0x03F9,0xF6E4,0xDDD9,0xEB00,0xFDEF,0xEFE4,0xE1E1,
0xEBF2,0xF2F6,0xEFEF,0xF6FD,0x0703,0x0715,0x1C1F,0x1815,
0x1F18,0x1F1C,0x272A,0x3123,0x1F27,0x1C0E,0x152A,0x2311,
0xF9FD,0xFDF6,0xE4E1,0xE8E1,0xD9DD,0xE8E1,0xD9D6,0xE1E8,
0xEBF6,0xF2F2,0xE8EB,0xF2EF,0xF600,0x0A07,0x030A,0x0A03,
0x0A11,0x110A,0x00FD,0xFDF6,0xEFF6,0xFDFD,0xF6F2,0xF2F2,
0xF2EF,0xF2F9,0xF2E8,0xEBEF,0xEBE4,0xE4EF,0xEBEF,0xF6F6,
0xF9F2,0xEFF6,0x0000,0x0307,0x0300,0x0300,0xFD03,0x0703,
0xFDFD,0xF9F9,0xF2F2,0xF6F9,0xFDFD,0xF9F9,0xF2EF,0xF2F2,
0xF9FD,0xFDF6,0xF6FD,0x0300,0x0000,0x000A,0x0A07,0x0707,
0x070A,0x0707,0x0A0A,0x0303,0x0303,0x0007,0x00FD,0xF9F9,
0xFDF9,0xF6F9,0x0007,0x070E,0x150E,0x0707,0x0A11,0x1518,
0x1C15,0x1111,0x1515,0x1111,0x0E0E,0x0E11,0x0E0A,0x0E0E,
0x0E0E,0x0A07,0x0300,0xFDFD,0x0307,0x0000,0x0000,0x0303,
0x0707,0x0A07,0x0303,0x0A07,0x0707,0x0A0E,0x1111,0x110E,
0x0703,0x070A,0x0300,0xFDF9,0xF9F6,0xEFF6,0xFDFD,0xFDFD,
0xF9F6,0xF9F2,0xF603,0x0700,0xFD00,0xF2EF,0xF9F6,0xF900,
0x00F6,0xF6F9,0xF9FD,0xFDFD,0x0003,0x03FD,0x03FD,0xF2FD,
0x0000,0x0000,0xF6F6,0xF9F6,0xF900,0x00FD,0xFDF6,0xF6FD,
0xFDF6,0xFD03,0x0003,0x0300,0xFDF9,0xF9FD,0xFDFD,0x0300,
0xF9F6,0xFDFD,0xF9F9,0xF9FD,0x0003,0x07FD,0xFD07,0x070A,
0x0E0A,0x0300,0xFDFD,0x000A,0x0707,0xFDF9,0xFDF9,0xF9F6,
0xFDF9,0xF6F6,0xF6F9,0xF9FD,0xFDFD,0x030A,0x0A0A,0x0000,
0x070A,0x0707,0x0E0A,0x0307,0x0300,0x030A,0x070A,0x0A00,
0xFDFD,0xFD00,0x070A,0x0700,0xFDF6,0xF6F9,0xFD03,0x0A07,
0x00FD,0x0000,0x0000,0x00FD,0x0003,0x0300,0xF9FD,0x0300,
0x0303,0xFDFD,0x0303,0x0003,0x0A11,0x110A,0x0E15,0x110A,
0x0707,0x0A0A,0x0A03,0x00FD,0xF6F9,0xFD03,0x0307,0x00F9,
0xFD00,0xF9F2,0xF6FD,0xFD03,0x03FD,0xFD00,0x0300,0x0303,
0x0300,0xF6F2,0xF600,0x00F9,0xFDF6,0xF2F6,0xF2F6,0xFDFD,
0xF9F6,0xF9FD,0xFD00,0xFDF9,0x0003,0x00FD,0xFDF6,0xF6F6,
0xF2EF,0xF2F6,0xF6F9,0xF9F6,0xF9FD,0x0303,0x0707,0x0000,
0x0307,0x0E0E,0x0E0E,0x0A07,0x0707,0x0711,0x110A,0x0300,
0x0300,0xF9FD,0xFDF9,0xFDFD,0x00FD,0xF2F9,0x0303,0x070A,
0x0A03,0x070A,0x0A0E,0x1511,0x110A,0x030A,0x0E03,0x0003,
0x0A0A,0x0A0A,0x0E0A,0x0303,0x0707,0x070E,0x0A00,0x0007,
0x03F9,0xF6F9,0xFD00,0xFDF9,0xF6F6,0xF6F6,0xF6F9,0xFDF6,
0xF2F2,0xF2F9,0xFDFD,0xFDFD,0xFD00,0xFD00,0x030A,0x0703,
0x070A,0x0303,0x00FD,0x030E,0x0A07,0x0300,0xFD00,0x0303,
0x00FD,0xFD03,0x0000,0x0003,0x0307,0x0A03,0x0000,0x00FD,
0xFD03,0x03FD,0xF9F6,0xF6F6,0xF9FD,0x0300,0xFDF6,0xF9FD,
0xFDFD,0xFDFD,0xFD00,0x0300,0xFDFD,0x0000,0x0303,0x00FD,
0xFD00,0xFDF9,0xFD07,0x03FD,0xFD03,0x03FD,0xFD03,0x070A,
0x0E0E,0x0E0A,0x0703,0x030A,0x0707,0x00F9,0xF6FD,0xF9F2,
0xF2F6,0xFDFD,0x00FD,0xFD00,0x0003,0x070E,0x0E0A,0x0700,
0xFD03,0x0707,0x0300,0xFDFD,0xFDFD,0xFD03,0x0000,0x0000,
0x0003,0x0000,0x030A,0x0A0A,0x0300,0x0000,0x0303,0x00FD,
0xFDFD,0xF9F9,0xF9F9,0xFD03,0x0300,0xFDF6,0xF6F6,0xF9FD,
0xFDFD,0xF6F6,0xF9F6,0xF9FD,0xFD00,0x00F9,0xF900,0xFDFD,
0x0003,0x0307,0x0700,0xF6F9,0xFD00,0x0303,0x00FD,0xFD00,
0x00FD,0xFD07,0x0300,0x0000,0x03FD,0xF9F9,0xFD03,0x0000,
0x0000,0xFDF6,0xF9FD,0x000A,0x0700,0xFD00,0x00FD,0xFDFD,
0x0007,0x0A03,0x0303,0x0703,0x0711,0x0E0A,0x0A00,0xFD00,
0x0A0E,0x0703,0x0303,0x0700,0xFDFD,0x0300,0x0000,0x00FD,
0xFD00,0xFDFD,0x0303,0x03FD,0xFDFD,0xFD00,0xFDFD,0x0300,
0x0307,0x00FD,0x000A,0x0A0A,0x0A07,0x0000,0x0000,0x070A,
0x0303,0x00FD,0xF9FD,0x0303,0x03FD,0xF6F9,0xFDFD,0xFDF9,
0xFDFD,0x0000,0xFDF9,0xFDFD,0x0303,0x0303,0x0007,0x0E03,
0x030A,0x0E0A,0x0307,0x0A07,0x0300,0xFD03,0x0303,0x0707,
0x00FD,0x0003,0x0303,0x0700,0x0000,0x0300,0xF9F9,0xFD07,
0x0303,0x03FD,0xFDFD,0xFDFD,0x0303,0x00FD,0xF6F6,0xFD00,
0x0000,0xFDFD,0xFDFD,0xFDFD,0xFDFD,0xFD03,0x0000,0x03FD,
0xF6F6,0xFD03,0x00FD,0xF9F6,0xFD00,0x0000,0x0003,0x00F9,
0xF9F9,0xF9FD,0x0303,0x07FD,0xF6F9,0xFDFD,0x0307,0x0A00,
0xFDFD,0xF9FD,0x070A,0x0E0E,0x0300,0x0000,0x03FD,0xFDFD,
0xFD00,0xF9F9,0xFDFD,0x0303,0x0307,0x0000,0x0300,0xFD00,
0x00FD,0xFD00,0x00F9,0xF9F9,0xF6F9,0xFD00,0x0700,0x00FD,
0xFDFD,0x0007,0x0A0A,0x0303,0x0300,0x00FD,0xFD00,0x0000,
0xFDFD,0xFDFD,0xFDFD,0x030A,0x03FD,0xFDFD,0xFDFD,0x0007,
0x03FD,0xFD03,0xFDFD,0xFDFD,0xF9FD,0x00FD,0xFDFD,0xF6F6,
0xFD03,0x0707,0x00FD,0x0307,0x0300,0x0A0E,0x0A03,0x0707,
0x0000,0x0307,0x0A03,0x00FD,0xFDFD,0xFD00,0x0000,0xFDF9,
0xF9FD,0xFDFD,0x0300,0xF9FD,0x0003,0x0A03,0x0003,0x0A07,
0x0303,0x0000,0x0703,0x0003,0x0303,0x0303,0xFDFD,0x00FD,
0xFD03,0x0703,0x0700,0x0003,0x0303,0x0707,0x0000,0x0000,
0x0007,0x0300,0x0300,0xFD03,0x00F9,0xFDFD,0xFDFD,0x0703,
0x0307,0x0300,0x0707,0x0000,0xFDFD,0xFDFD,0xFD00,0xFDF9,
0xF9FD,0xF9F9,0xF9FD,0xF9F9,0xF9FD,0x0003,0x00FD,0x070A,
0x0A07,0x0703,0x0303,0x0303,0x0300,0x0000,0xFDFD,0xFDFD,
0x0303,0x0703,0xFDF9,0xFD03,0x0307,0x0E0A,0x03FD,0xFDFD,
0x0003,0x0A0A,0xFDF6,0xF9FD,0x00FD,0x0303,0x03FD,0xFDF9,
0xF6F9,0xFD00,0x0000,0x0300,0x030A,0x0A03,0x0303,0x0303,
0x00FD,0x00FD,0xF9F9,0xFD00,0x00FD,0xFDFD,0xF9FD,0xFD03,
0x0707,0x03FD,0xFD03,0x03FD,0xF9FD,0x00FD,0xFDFD,0xFDFD,
0xFDFD,0x0007,0x00FD,0xFDF9,0xF9FD,0x0300,0x0703,0xFDFD,
0x0300,0x0003,0x03FD,0xFD00,0x0003,0x00F9,0xFD03,0x0700,
0x00FD,0xF9FD,0xFD00,0x0007,0x00F9,0xFD03,0x00FD,0xFD07,
0x0700,0x00FD,0xF9FD,0xFDF9,0x000A,0x03FD,0xFDFD,0x00FD,
0x030A,0x0E00,0x0307,0x0A0A,0x0703,0x0307,0x00F9,0xF6F6,
0x0000,0x0003,0x0700,0xFDFD,0x0000,0xFD00,0x0007,0x03FD,
0xFD00,0x0003,0x0707,0x070A,0x0A00,0xFDFD,0xFDFD,0x0000,
0x0000,0xF9FD,0x00FD,0xF2F6,0xF9FD,0xFD03,0x0300,0xFDFD,
0xFD03,0x0000,0x0000,0x00FD,0xFD00,0x0000,0xFDFD,0x0307,
0x0707,0x0307,0x0703,0x0003,0x0700,0xFD03,0x0A0A,0x03FD,
0xFD00,0x0000,0x0000,0x00FD,0x00FD,0xF9F9,0xFDFD,0x0307,
0x03FD,0xFD00,0x0300,0x0003,0x0303,0xFD03,0x0707,0x070A,
0x07FD,0xFD00,0x00FD,0x0003,0xFD00,0x03FD,0xFDFD,0xFD03,
0x0300,0x030A,0x0300,0x0300,0xFDFD,0xFDFD,0xFDF9,0xF6F9,
0xF9FD,0xFDFD,0xFD03,0x0703,0x0000,0x030A,0x110E,0x0A07,
0xFDFD,0x0000,0xFDFD,0x03FD,0xFDFD,0xF9F9,0xFDFD,0xFD03,
0x03FD,0x00FD,0xFD00,0x00FD,0xFD00,0xFDFD,0x0303,0x0003,
0x00FD,0x0007,0x00FD,0xFDFD,0xFDFD,0xFD03,0x00FD,0xF9FD,
0x0307,0x0303,0x0300,0xFDFD,0x03FD,0xFD03,0x0707,0x00FD,
0xF9F9,0xFDFD,0xFD03,0x0700,0xFDFD,0x0007,0x0A0A,0x0700,
0xFDFD,0x0707,0x0707,0x0000,0x0303,0x00FD,0xFDFD,0xFDFD,
0x0000,0xFDFD,0x0000,0x0000,0x0000,0x0000,0x0003,0x0707,
0x0A07,0x030A,0x0E03,0xFD00,0x0303,0x0300,0x0000,0xFDF9,
0xFD00,0xFDF9,0x0303,0xFD03,0x00FD,0xFD03,0x0303,0x0703,
0x0000,0x0000,0x0000,0xFDF9,0xFD00,0xF9FD,0x0300,0xFDF9,
0xFD03,0x0703,0x0707,0x0003,0x0703,0x0000,0x00FD,0xFD00,
0x0300,0x0000,0x0303,0xFDF9,0xFDFD,0x0307,0x00F9,0xF9F9,
0xFDFD,0xFDFD,0x0300,0xF6F2,0xFD03,0x0303,0x0300,0xFDFD,
0xFDFD,0x0300,0xFDFD,0xFDFD,0xFDFD,0xFD03,0x0300,0x0000,
0xFDFD,0x0003,0x0303,0x0000,0x0707,0x0300,0x0300,0x0000,
0xFDFD,0x00FD,0xF9FD,0x0000,0x0307,0x0303,0x00FD,0xFDFD,
0xFDFD,0xFD03,0x0703,0x0300,0x0303,0x00FD,0x0300,0xF9F9,
0xFDFD,0xFDFD,0xFD00,0x0300,0x0007,0x0A07,0x0300,0x000A,
0x0A03,0x0000,0x00FD,0xFD00,0x0000,0xFDF6,0xF903,0x0303,
0x0303,0x0700,0x0307,0x0707,0x0307,0x07FD,0xFDFD,0x0000,
0xFDFD,0x0303,0xFDFD,0xFD00,0x0307,0x03FD,0xFD00,0x0000,
0x0003,0x00FD,0xFDFD,0xFDFD,0xFDFD,0xFDFD,0xFDFD,0xF9FD,
0x0707,0x0303,0x0703,0x0003,0x0300,0x00FD,0x0303,0xFDFD,
0x0703,0xFDF9,0xFD03,0x0707,0x03FD,0xFDFD,0x00FD,0x0003,
0x00FD,0xFDF9,0xFDFD,0xFDFD,0x0007,0x03FD,0xFDF9,0xFDFD,
0xFD00,0x0000,0x03FD,0xF6FD,0x0303,0x0000,0x0000,0x0300,
0xFD03,0x0003,0x0A07,0x0303,0x00F9,0xFD00,0x0303,0x0300,
0x0003,0x0300,0x0003,0x030A,0x07FD,0xFDFD,0xFD00,0x0003,
0x070A,0x00F9,0xFD00,0x0707,0x0300,0x00FD,0xFDFD,0x0003,
0x0003,0x0003,0x0300,0xFD00,0x0000,0x0000,0xFDFD,0x0000,
0x00FD,0xF6F9,0xFD00,0xFDF6,0xF6FD,0xFD00,0xFD03,0x0703,
0xFDF9,0xFD03,0x0303,0x0303,0x0303,0xFDFD,0x0300,0xFDFD,
0xFDFD,0xFDFD,0xFDFD,0x03FD,0xFD00,0x0000,0x030A,0x0A0A,
0x0A0A,0x0A07,0x00FD,0x0303,0x0000,0x0003,0x0703,0xFDF9,
0x0300,0x0007,0x0703,0x03FD,0xFD00,0x0703,0x0703,0x0000,
0x0303,0xFDFD,0xF9FD,0x0300,0xFDFD,0xF9FD,0xFDFD,0xFD03,
0x00F9,0xF6F9,0xFD03,0x0703,0x0303,0x0000,0x0307,0x0A03,
0x0000,0xFDFD,0xF9F6,0xFD00,0xFDFD,0xFDF9,0xFD00,0x00FD,
0xFDFD,0xFDFD,0x0000,0x0003,0x0300,0x00FD,0x0003,0x00F9,
0xF6FD,0xFDFD,0xFD00,0x00FD,0xFDFD,0x0007,0x0703,0x0A0A,
0x0307,0x0707,0x070A,0x0703,0x0300,0xFDFD,0xFD07,0x0700,
0xFDFD,0xFDFD,0xFD00,0x0303,0xFDFD,0x0007,0x0300,0x0303,
0x0003,0x00FD,0xFDFD,0xF9FD,0x0303,0x0000,0xFDFD,0xFD00,
0xFDFD,0xFD00,0x0300,0xFDF9,0xFDFD,0x0303,0x0003,0x0703,
0xFDFD,0xFD07,0x0300,0xFDFD,0x00FD,0xF9F9,0xFDFD,0xFDF9,
0xFDFD,0xFDF9,0xFD07,0x070A,0x0A00,0x0003,0x0A0E,0x0707,
0x0303,0x0300,0xFD00,0x0000,0xFDF9,0xF6FD,0xFDFD,0xF9FD,
0xFD00,0x070A,0x0707,0x0703,0x0000,0x0000,0x0303,0x00FD,
0xF9FD,0xFD00,0x0300,0xFDFD,0xF9F9,0xFD03,0x0307,0x0707,
0x03FD,0x0007,0x0707,0x0300,0xFD00,0x00F9,0xFD00,0xFDFD,
0xFDFD,0xFDFD,0xF9F9,0x0000,0xFDFD,0x0303,0x0307,0x0A03,
0x0000,0x0307,0x00FD,0xF9FD,0xFD00,0xFDFD,0x0303,0xFDF6,
0xF9FD,0x0303,0x0000,0x00FD,0xF6F2,0x0311,0x1503,0x0000,
0x00FD,0xFD00,0x0700,0xFDF6,0xF2FD,0x0303,0x00FD,0xFDFD,
0x0003,0x030A,0x0E0A,0x0A0E,0x0E07,0x03FD,0xF9F6,0xFDFD,
0xFD00,0x0300,0xFDFD,0xFD07,0x07FD,0xFD03,0x03F9,0xF9FD,
0x0003,0x0000,0x0000,0xFDFD,0xF9FD,0x070E,0x0703,0x0303,
0x0303,0x0303,0x07FD,0xF9FD,0x0000,0x0307,0x00FD,0x0303,
0x0000,0xFD00,0x0300,0xFDFD,0x0303,0x0307,0x0303,0x0303,
0x0707,0x0700,0xFDF9,0xFD07,0x0703,0x0703,0xFDF6,0xF6F9,
0xFD00,0xFDFD,0xF9F9,0xFDFD,0x0303,0x0707,0x0303,0x00FD,
0xF9FD,0x0000,0xFDFD,0xF6FD,0xFDFD,0xFD00,0x00FD,0xFD00,
0xFDF9,0xFD00,0x0303,0x0303,0x0703,0x00FD,0xFDFD,0x0000,
0x0000,0x0300,0xFDFD,0x0000,0xFD00,0x0707,0x00FD,0xFD00,
0x0303,0x0303,0x00FD,0x0003,0x0307,0x0703,0xFDFD,0xF9FD,
0xFD00,0x0703,0x00FD,0x0000,0xFDFD,0x00FD,0x0003,0x0000,
0x0003,0x0300,0x0000,0x0303,0x0703,0x0303,0x00F9,0xFDFD,
0x00FD,0xF9F9,0xFDFD,0xFDFD,0x0307,0x03FD,0xFD03,0x0707,
0x0700,0xFDFD,0xFDFD,0xFD00,0x0003,0x00FD,0x00FD,0xF9FD,
0x0000,0x0303,0x0000,0x0A0A,0x0A0A,0x0700,0x0703,0xFDFD,
0xFDFD,0x0000,0x0003,0x0A07,0xFDF9,0xFD00,0xFDFD,0x0000,
0xFDF9,0xFDFD,0xFDFD,0x0003,0x0703,0xFDFD,0x0000,0x0307,
0x0300,0xFD00,0x0307,0x0703,0x0300,0xFDFD,0xF9FD,0x0303,
0x0707,0x0A0A,0x0700,0x0003,0x03FD,0x0003,0x00FD,0xF9FD,
0xFDFD,0xF9FD,0x0000,0xF9F9,0xFD00,0x0300,0x0003,0x0700,
0xF9FD,0x0007,0x0000,0x0307,0x00FD,0xFD00,0x0707,0x0000,
0xFDFD,0xFD03,0x0000,0x0303,0x00FD,0x0003,0x0003,0x0303,
0x0707,0x0000,0x0307,0x0303,0x00FD,0xFDFD,0xF6F2,0xF9FD,
0x0000,0x0003,0x0700,0xFDFD,0x0003,0x0303,0x0703,0x0000,
0xFDFD,0xF9FD,0xFDFD,0x0000,0xFDF9,0xFDFD,0xFD00,0x00FD,
0xF9FD,0xFDFD,0x0003,0x0303,0x00FD,0xFDFD,0x0007,0x0707,
0x0303,0x0703,0x00FD,0x0000,0x0303,0x00FD,0xFDFD,0xFDFD,
0xFDFD,0x0003,0x0300,0x0003,0x0000,0x0307,0x0700,0xFDF9,
0xFD00,0x0003,0x0707,0x00FD,0xFDFD,0x0307,0x0300,0xFD00,
0x0000,0x0003,0x0307,0x0300,0x0000,0x0000,0x0000,0x0003,
0x0000,0x0007,0x0703,0x00FD,0x0003,0x00FD,0xFD00,0x00FD,
0x0003,0x0003,0xFDFD,0xFD00,0x0003,0x0303,0x0300,0xFD00,
0x0000,0xFD00,0x0000,0xFDFD,0x0000,0x0003,0x0300,0xFDFD,
0xFDFD,0x0003,0x0300,0x0000,0x0300,0x0000,0x0703,0x0000,
0x0000,0xFDFD,0x0000,0xFD03,0x0303,0x0000,0x00FD,0xFD00,
0x0300,0x0000,0x0000,0x0303,0x0303,0x0300,0x00FD,0xFD03,
0x00FD,0xFD00,0x00FD,0xFD00,0x0300,0x0003,0xFDFD,0xFDFD,
0xFDFD,0xFD00,0x0300,0x0000,0x00FD,0xF9FD,0xFD00,0x0000,
0x0003,0x0300,0xFDFD,0x0303,0xFDFD,0xFDFD,0x0000,0x00FD,
0xFDFD,0x0707,0x0A03,0x0303,0x0700,0xFDF9,0xFD03,0x0300,
0x00FD,0xFD00,0x0003,0x00FD,0xF9FD,0xFDFD,0x0303,0xFDFD,
0xFD03,0x0703,0x0300,0x0003,0x0A07,0x000E,0xFD0A,0xF90E,
0x03FD,0x0AFD,0xF6F2,0x0EEF,0xEB15,0x03F9,0x030A,0x07F6,
0xF9FD,0xF611,0x11F9,0x0303,0x0A03,0xF603,0x11E8,0xEB00
};

