* ShIcEd Form Definition Block  Shape Data

     swh:
	dc.w	$0008,$000F

     ssd:
	dc.w	$07F0,$07F0,$07F0,$07F0
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$180C,$180C,$1FFC,$180C
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$2002,$2002,$3FFE,$2002
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$4001,$4001,$7D5F,$4001
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$4001,$4001,$7D5F,$4001
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$8000,$8000,$FD5F,$8000
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$8000,$8000,$FD5F,$8000
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$8000,$8000,$FD5F,$8000
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$8000,$8000,$FD5F,$8000
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$8000,$8000,$FB6F,$8000
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$4001,$4001,$6773,$4001
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$4001,$4001,$7FFF,$4001
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$2002,$2002,$3FFE,$2002
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$180C,$180C,$1FFC,$180C
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$07F0,$07F0,$07F0,$07F0
	dc.w	$0000,$0000,$0000,$0000

* ShIcEd Form Definition Block  Mask Data

     msd:
	dc.w	$07F0,$07F0,$07F0,$07F0
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$1FFC,$1FFC,$1FFC,$1FFC
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$3FFE,$3FFE,$3FFE,$3FFE
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$7FFF,$7FFF,$7FFF,$7FFF
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$7FFF,$7FFF,$7FFF,$7FFF
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000
	dc.w	$7FFF,$7FFF,$7FFF,$7FFF
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$7FFF,$7FFF,$7FFF,$7FFF
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$3FFE,$3FFE,$3FFE,$3FFE
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$1FFC,$1FFC,$1FFC,$1FFC
	dc.w	$0000,$0000,$0000,$0000
	dc.w	$07F0,$07F0,$07F0,$07F0
	dc.w	$0000,$0000,$0000,$0000
