/* cards.h					01 apr 86  01 apr 86	*/

#define	TRUE	1
#define	FALSE	0

#define PRT	0
#define AUX	1
#define CON	2
#define DSK	3

/* Useful definitions for this program */

#define HIDE_MOUSE graf_mouse(256,0x0L)
#define SHOW_MOUSE graf_mouse(257,0x0L)

#define SHOW 1

