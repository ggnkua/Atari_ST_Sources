#define CARD 0  	/* TREE */
#define PRINT 9  	/* OBJECT in TREE #0 */
#define EXIT 10  	/* OBJECT in TREE #0 */
#define INDEXNO 1  	/* OBJECT in TREE #0 */
#define SUBJECT 8  	/* OBJECT in TREE #0 */
