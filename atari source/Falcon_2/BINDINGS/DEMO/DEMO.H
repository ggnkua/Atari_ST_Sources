#define MENUBAR 0  	/* TREE */
#define GTITLE 5  	/* OBJECT in TREE #0 */
#define ETITLE 6  	/* OBJECT in TREE #0 */
#define ABOUTX 9  	/* OBJECT in TREE #0 */
#define FQUIT 18  	/* OBJECT in TREE #0 */
#define STYLE 20  	/* OBJECT in TREE #0 */
#define POSITION 21  	/* OBJECT in TREE #0 */
#define FONTS1 23  	/* OBJECT in TREE #0 */
#define PHONE 25  	/* OBJECT in TREE #0 */
#define PATTERN1 26  	/* OBJECT in TREE #0 */
#define COLOR 27  	/* OBJECT in TREE #0 */
#define FONTTREE 1  	/* TREE */
#define PTREE 2  	/* TREE */
#define CTREE 3  	/* TREE */
#define POSTREE 4  	/* TREE */
#define STREE 5  	/* TREE */
#define MTREE 6  	/* TREE */
#define M1BUTTON 2  	/* OBJECT in TREE #6 */
#define M2BUTTON 4  	/* OBJECT in TREE #6 */
#define M3BUTTON 6  	/* OBJECT in TREE #6 */
#define M4BUTTON 8  	/* OBJECT in TREE #6 */
#define M5BUTTON 10  	/* OBJECT in TREE #6 */
#define M6BUTTON 12  	/* OBJECT in TREE #6 */
#define MOK 13  	/* OBJECT in TREE #6 */
#define BAUDRATE 7  	/* TREE */
#define PARTREE 8  	/* TREE */
#define BITTREE 9  	/* TREE */
#define STOPTREE 10  	/* TREE */
#define PORTTREE 11  	/* TREE */
#define FLOWTREE 12  	/* TREE */
#define ATREE 13  	/* TREE */
#define AEXIT 1  	/* OBJECT in TREE #13 */
#define M1TITLE 1  	/* OBJECT in TREE #6 */
#define M2TITLE 3  	/* OBJECT in TREE #6 */
#define M3TITLE 5  	/* OBJECT in TREE #6 */
#define M4TITLE 7  	/* OBJECT in TREE #6 */
#define M5TITLE 9  	/* OBJECT in TREE #6 */
#define M6TITLE 11  	/* OBJECT in TREE #6 */
#define P1 1  	/* OBJECT in TREE #2 */
#define P2 2  	/* OBJECT in TREE #2 */
#define P3 3  	/* OBJECT in TREE #2 */
#define P4 4  	/* OBJECT in TREE #2 */
#define P5 5  	/* OBJECT in TREE #2 */
#define P6 6  	/* OBJECT in TREE #2 */
#define P7 7  	/* OBJECT in TREE #2 */
#define P8 8  	/* OBJECT in TREE #2 */
