
int bgmed1[0x0304] = 
{ 0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x80DF, 0xFFF4, 0xFD80, 0x4000, 
  0x80DF, 0xFFF4, 0x0580, 0x4000, 
  0x80D8, 0x3E14, 0x0580, 0x4000, 
  0x80D8, 0xE314, 0x0580, 0x4000, 
  0x80DF, 0x8D14, 0x0580, 0x4000, 
  0x80DC, 0xFB14, 0x0580, 0x4000, 
  0x80DF, 0x9D14, 0x0580, 0x4000, 
  0x80D8, 0x0D14, 0x0580, 0x4000, 
  0x80D8, 0x0714, 0x0580, 0x4000, 
  0x80D8, 0xFE14, 0x0580, 0x4000, 
  0x80DB, 0xBE14, 0x0580, 0x4000, 
  0x80DB, 0x2317, 0x8580, 0x4000, 
  0x80DB, 0xDF76, 0xC580, 0x4000, 
  0x80D8, 0xF5F7, 0x2580, 0x4000, 
  0x80FF, 0x3DB6, 0xC580, 0x4000, 
  0x8100, 0xCF56, 0x8580, 0x4000, 
  0x811F, 0xA3F7, 0x8580, 0x4000, 
  0x8111, 0xE0F4, 0x0580, 0x4000, 
  0x8088, 0xC074, 0x0580, 0x4000, 
  0x80E6, 0x07F4, 0x0580, 0x4000, 
  0x80FF, 0x7C14, 0x0580, 0x4000, 
  0x80FF, 0x8014, 0x0780, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x80FF, 0xFFF4, 0xFD80, 0x4000, 
  0x80DF, 0xFFF4, 0x0580, 0x4000, 
  0x80D8, 0x0014, 0x0580, 0x4000, 
  0x80D8, 0x0014, 0x0580, 0x4000, 
  0x80D8, 0x0414, 0x0580, 0x4000, 
  0x80D8, 0x0E14, 0x0580, 0x4000, 
  0x80D8, 0x1D14, 0x0580, 0x4000, 
  0x80D8, 0x3894, 0x0580, 0x4000, 
  0x80DB, 0xF054, 0x0580, 0x4000, 
  0x80FC, 0x3034, 0x0580, 0x4000, 
  0x83C0, 0x0C14, 0x0580, 0x4000, 
  0x8380, 0x7E17, 0x8580, 0x4000, 
  0x83FF, 0x8216, 0xC580, 0x4000, 
  0x83F0, 0x0217, 0x2580, 0x4000, 
  0x83F8, 0x0FF6, 0xC580, 0x4000, 
  0x8398, 0x3816, 0x8580, 0x4000, 
  0x80D9, 0xE017, 0x8580, 0x4000, 
  0x80FF, 0xE014, 0x0580, 0x4000, 
  0x80D8, 0xE014, 0x0580, 0x4000, 
  0x87FF, 0xE014, 0x0580, 0x4000, 
  0x9E00, 0xF014, 0x0580, 0x4000, 
  0x9E00, 0xDC14, 0x0780, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x83FF, 0xFFFF, 0xFFE0, 0x4000, 
  0x8FFF, 0xFFFF, 0xFFF8, 0x4000, 
  0x9800, 0x0000, 0x0006, 0x4000, 
  0x90FF, 0xFFFF, 0xFFC2, 0x4000, 
  0x9127, 0x2740, 0x0022, 0x4000, 
  0x9172, 0x7740, 0x0022, 0x4000, 
  0x9152, 0x5540, 0x0022, 0x4000, 
  0x9100, 0x0000, 0x0022, 0x4000, 
  0x913E, 0x87A8, 0xB622, 0x4000, 
  0x912A, 0x4450, 0x5022, 0x4000, 
  0x913D, 0x4600, 0xE822, 0x4000, 
  0x9114, 0x4440, 0xA022, 0x4000, 
  0x9136, 0x06F8, 0xD022, 0x4000, 
  0x9129, 0x4500, 0x0022, 0x4000, 
  0x9137, 0x45B0, 0x0022, 0x4000, 
  0x9120, 0x0518, 0x0022, 0x4000, 
  0x9138, 0x07D0, 0xC022, 0x4000, 
  0x9122, 0x0500, 0xB522, 0x4000, 
  0x9180, 0x0000, 0x0062, 0x4000, 
  0x90FF, 0xFFFF, 0xFFC2, 0x4000, 
  0x9000, 0x0003, 0x9CE2, 0x4000, 
  0x9555, 0x5555, 0x5556, 0x4000, 
  0x8FFF, 0xFFFF, 0xFFFC, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xE73F, 0xFFFF, 0xFFFE, 0xC000, 
  0xD567, 0xE037, 0x1C72, 0xC000, 
  0xD567, 0xA01F, 0x1C72, 0xC000, 
  0xD566, 0xD807, 0x9C72, 0xC000, 
  0xD56F, 0xF603, 0xDC72, 0xC000, 
  0xD56B, 0xFDC3, 0xDC72, 0xC000, 
  0xD569, 0xFFB9, 0xDC72, 0xC000, 
  0xD564, 0x7FF7, 0xDC72, 0xC000, 
  0xD56E, 0x1FFF, 0xFC72, 0xC000, 
  0xD571, 0x81FF, 0x1E72, 0xC000, 
  0xD681, 0x7FFA, 0x19F2, 0xC000, 
  0xD481, 0x04E2, 0x1872, 0xC000, 
  0xD881, 0x05D2, 0x182E, 0xC000, 
  0xF881, 0x0762, 0x1866, 0xC000, 
  0xE881, 0x0636, 0x1FFA, 0xC000, 
  0xC881, 0x0C1E, 0x1FFF, 0xC000, 
  0xFFFF, 0xF80F, 0xFFFF, 0xC000, 
  0xC000, 0x3007, 0xFFF9, 0xC000, 
  0xE000, 0x6007, 0xFF03, 0xC000, 
  0xFE00, 0x6003, 0xF01F, 0xC000, 
  0xFFFC, 0x1FFF, 0x0FFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x387F, 0x2208, 0x4000, 
  0x8000, 0x07FD, 0xFC10, 0x4000, 
  0x8000, 0x7F87, 0xE7C0, 0x4000, 
  0x8000, 0xFFFE, 0x1F20, 0x4000, 
  0x8001, 0xFFFF, 0xF880, 0x4000, 
  0x8003, 0xFFFF, 0xFC00, 0x4000, 
  0x8007, 0xFFFF, 0xF400, 0x4000, 
  0x800F, 0xFFFF, 0xE800, 0x4000, 
  0x801F, 0xFFFF, 0xD000, 0x4000, 
  0x801F, 0xFFFF, 0xA000, 0x4000, 
  0x800F, 0xFFFF, 0x4000, 0x4000, 
  0x8000, 0x7FFE, 0x8000, 0x4000, 
  0x8000, 0x01FF, 0x0000, 0x4000, 
  0x81FF, 0xFFFF, 0xF800, 0x4000, 
  0x8EDD, 0x0000, 0x07C0, 0x4000, 
  0xB57B, 0x8EB9, 0xB030, 0x4000, 
  0xBEAD, 0x5346, 0x63F0, 0x4000, 
  0x9BFF, 0x3D69, 0xFDE0, 0x4000, 
  0x917D, 0xFFFF, 0xBEE0, 0x4000, 
  0x9B43, 0x9039, 0x0460, 0x4000, 
  0x9141, 0x0810, 0x84E0, 0x4000, 
  0x9B43, 0x0830, 0x8460, 0x4000, 
  0xF5F9, 0xFF9F, 0xF6BF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x801F, 0xFFFF, 0xFC00, 0x4000, 
  0x8021, 0xFFFF, 0xFA00, 0x4000, 
  0x802F, 0x5555, 0x5200, 0x4000, 
  0x83CF, 0xFD55, 0xFDE0, 0x4000, 
  0x8C00, 0x07FF, 0x0018, 0x4000, 
  0x9FFF, 0xFFD5, 0x5554, 0x4000, 
  0xA000, 0x003F, 0xFFFA, 0x4000, 
  0xBFFF, 0xFFFF, 0xFFFE, 0x4000, 
  0xA000, 0x0000, 0x0002, 0x4000, 
  0xA000, 0x1AAA, 0xAAA2, 0x4000, 
  0xA000, 0x1FFF, 0xFFE2, 0x4000, 
  0xA000, 0x2000, 0x0012, 0x4000, 
  0xA000, 0x7FFF, 0xFFFA, 0x4000, 
  0xA000, 0x0CCC, 0xCCC2, 0x4000, 
  0xA000, 0x0EEE, 0xEEC2, 0x4000, 
  0xAAAA, 0xB555, 0x554A, 0x4000, 
  0x9AAA, 0xAAAA, 0xAAAC, 0x4000, 
  0x8800, 0x0000, 0x0008, 0x4000, 
  0x87FF, 0xFFFF, 0xFFF0, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xA222, 0x2222, 0x2222, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x9010, 0x1010, 0x1010, 0x4000, 
  0x9010, 0x1010, 0x1010, 0x4000, 
  0x9010, 0x1010, 0x1010, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x9012, 0x1010, 0x1010, 0x4000, 
  0x9092, 0x1810, 0x1010, 0x4000, 
  0x9062, 0x3010, 0x1010, 0x4000, 
  0xFF90, 0x4FFF, 0xFFFF, 0xC000, 
  0x95DF, 0xFD10, 0x1010, 0x4000, 
  0x905E, 0xC810, 0x1010, 0x4000, 
  0x90F7, 0x7010, 0x1010, 0x4000, 
  0xFF9D, 0xCFFF, 0xFFFF, 0xC000, 
  0x9331, 0xF810, 0x1010, 0x4000, 
  0x92CB, 0x0810, 0x1010, 0x4000, 
  0x9706, 0x3C10, 0x1010, 0x4000, 
  0xFE1F, 0x67FF, 0xFFFF, 0xC000, 
  0x947D, 0xFB10, 0x1010, 0x4000, 
  0x9407, 0xAD10, 0x1010, 0x4000, 
  0xFC0C, 0x7210, 0x1010, 0x4000, 
  0x8718, 0x3FFF, 0xFFFF, 0xC000, 
  0x81E1, 0xF010, 0x1010, 0x4000, 
  0xC0FF, 0x1010, 0x1010, 0x4000, 
  0xF3B8, 0x1010, 0x1010, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000
};


int bgmed2[0x0304] = 
{ 0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x807F, 0xFFFF, 0xFFC0, 0x4000, 
  0x806F, 0xFFFF, 0xFEC0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0FBE, 0x02C0, 0x4000, 
  0x8068, 0x38A3, 0x82C0, 0x4000, 
  0x8068, 0x5EAF, 0x42C0, 0x4000, 
  0x8068, 0x87BC, 0x22C0, 0x4000, 
  0x8068, 0xFC47, 0xE2C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x806B, 0x8000, 0x02C0, 0x4000, 
  0x806B, 0x8000, 0x02C0, 0x4000, 
  0x8069, 0x8000, 0x02C0, 0x4000, 
  0x806B, 0xC000, 0x02C0, 0x4000, 
  0x806B, 0xC000, 0x02C0, 0x4000, 
  0x806B, 0xC000, 0x02C0, 0x4000, 
  0x806A, 0x4000, 0x02C0, 0x4000, 
  0x8069, 0x8000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x807F, 0xFFFF, 0xFFC0, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x807F, 0xFFFF, 0xFC00, 0x4000, 
  0x807F, 0xFFFF, 0xFF00, 0x4000, 
  0x8070, 0x0000, 0x0F80, 0x4000, 
  0x8077, 0xFFFF, 0xF380, 0x4000, 
  0x8077, 0xFFFF, 0xFB80, 0x4000, 
  0x8077, 0xFFFF, 0xFB80, 0x4000, 
  0x8077, 0xFFFF, 0xFB80, 0x4000, 
  0x8077, 0xFFFF, 0xFB80, 0x4000, 
  0x8077, 0xFFFF, 0xFB80, 0x4000, 
  0x8077, 0xFFFF, 0xFB80, 0x4000, 
  0x8077, 0xFFFF, 0xE780, 0x4000, 
  0x8077, 0xFFFF, 0x9F80, 0x4000, 
  0x8077, 0x0000, 0x7E00, 0x4000, 
  0x8076, 0xFFFF, 0xF800, 0x4000, 
  0x8075, 0xFFFF, 0xE000, 0x4000, 
  0x8075, 0xC000, 0x0000, 0x4000, 
  0x8071, 0xC000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8001, 0xFFFF, 0x8000, 0x4000, 
  0x800F, 0x0000, 0xF800, 0x4000, 
  0x8038, 0x0000, 0x0E00, 0x4000, 
  0x80E0, 0x0000, 0x0380, 0x4000, 
  0x8380, 0x0000, 0x00E0, 0x4000, 
  0x8600, 0x0000, 0x0030, 0x4000, 
  0x8C00, 0x0000, 0x0018, 0x4000, 
  0x8800, 0x0000, 0x000C, 0x4000, 
  0x9800, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9800, 0x0000, 0x000C, 0x4000, 
  0x8800, 0x0000, 0x0018, 0x4000, 
  0x8C00, 0x0000, 0x0030, 0x4000, 
  0x8700, 0x0000, 0x0060, 0x4000, 
  0x81C0, 0x0000, 0x01C0, 0x4000, 
  0x8070, 0x0000, 0x0700, 0x4000, 
  0x801E, 0x0000, 0x1C00, 0x4000, 
  0x8003, 0xF003, 0xF000, 0x4000, 
  0x8000, 0x1FFE, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8001, 0xFFFF, 0xF800, 0x4000, 
  0x807F, 0x0000, 0x0FC0, 0x4000, 
  0x81C0, 0x0000, 0x0070, 0x4000, 
  0x8100, 0x0000, 0x0010, 0x4000, 
  0x8100, 0x0000, 0x0010, 0x4000, 
  0x8180, 0x0000, 0x0030, 0x4000, 
  0x80C0, 0x0000, 0x0060, 0x4000, 
  0x807E, 0x0000, 0x0FC0, 0x4000, 
  0x8003, 0xFFFF, 0xF800, 0x4000, 
  0x8000, 0x0000, 0x3FE0, 0x4000, 
  0x8000, 0x0000, 0xE038, 0x4000, 
  0x803E, 0x0001, 0x800C, 0x4000, 
  0x81E3, 0xC003, 0x0006, 0x4000, 
  0x8300, 0x6002, 0x0002, 0x4000, 
  0x8200, 0x2002, 0x0002, 0x4000, 
  0x8600, 0x3002, 0x0002, 0x4000, 
  0x8400, 0x1002, 0x0002, 0x4000, 
  0x8600, 0x3003, 0x0006, 0x4000, 
  0x8300, 0x6001, 0x800C, 0x4000, 
  0x8180, 0xC000, 0xC018, 0x4000, 
  0x80FF, 0x8000, 0x78F0, 0x4000, 
  0x8000, 0x0000, 0x0F80, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8001, 0xFF03, 0xE000, 0x4000, 
  0x801F, 0xFF00, 0x3E00, 0x4000, 
  0x81FF, 0xFF00, 0x03C0, 0x4000, 
  0x811F, 0xFF00, 0x07C0, 0x4000, 
  0x81E1, 0xFF00, 0x7C40, 0x4000, 
  0x81FE, 0x1F07, 0xC040, 0x4000, 
  0x81FF, 0xE0FC, 0x0040, 0x4000, 
  0x81FF, 0xFF80, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x0040, 0x4000, 
  0x81FF, 0xFF00, 0x00C0, 0x4000, 
  0x807F, 0xFF00, 0x0F80, 0x4000, 
  0x8007, 0xFF00, 0xF800, 0x4000, 
  0x8000, 0x7F0F, 0x8000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x83FF, 0xFFE0, 0x0000, 0x4000, 
  0x87FF, 0xFFF8, 0x0000, 0x4000, 
  0x8700, 0x0078, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0xFFFF, 0xFFFC, 0x4000, 
  0x8700, 0xFFFF, 0xFFFE, 0x4000, 
  0x8700, 0x0000, 0x007E, 0x4000, 
  0x87C0, 0x0000, 0x01F8, 0x4000, 
  0x83F0, 0x0000, 0x07E0, 0x4000, 
  0x80FC, 0x0000, 0x1F80, 0x4000, 
  0x803F, 0x0000, 0x7E00, 0x4000, 
  0x800F, 0xC001, 0xF800, 0x4000, 
  0x8003, 0xF007, 0xE000, 0x4000, 
  0x8000, 0xFC1F, 0x8000, 0x4000, 
  0x8000, 0x3FFE, 0x0000, 0x4000, 
  0x8000, 0x0FF8, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x81FF, 0xFFFF, 0xFFE0, 0x4000, 
  0x8200, 0x0000, 0x0010, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8200, 0x0000, 0x0010, 0x4000, 
  0x81FF, 0xFFFF, 0xFFE0, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xB7FF, 0xFFFF, 0xFFFB, 0x4000, 
  0xB600, 0x0000, 0x001B, 0x4000, 
  0xB600, 0x3FC0, 0x001B, 0x4000, 
  0xB7FD, 0xC03F, 0xFFFB, 0x4000, 
  0xB7FF, 0xA007, 0xFFFB, 0x4000, 
  0xB60F, 0xD002, 0x001B, 0x4000, 
  0xB617, 0xEC01, 0x001B, 0x4000, 
  0xB613, 0xFB01, 0x001B, 0x4000, 
  0xB611, 0xFEE1, 0x001B, 0x4000, 
  0xB7F8, 0x7F9F, 0xFFFB, 0x4000, 
  0xB7FC, 0x1FFF, 0xFFFB, 0x4000, 
  0xB7FF, 0x07FF, 0xFFFB, 0x4000, 
  0xB600, 0xFFF0, 0x001B, 0x4000, 
  0xB7FF, 0xFFFF, 0xFFFB, 0x4000, 
  0xB600, 0x07DF, 0x001B, 0x4000, 
  0xEFFF, 0xFF7F, 0xFFFD, 0xC000, 
  0x8000, 0x1E3F, 0x8000, 0x4000, 
  0x8000, 0x3C1F, 0xC000, 0x4000, 
  0x8000, 0x780F, 0xE000, 0x4000, 
  0x8000, 0xF007, 0xF000, 0x4000, 
  0xFFFF, 0xE003, 0xFFFF, 0xC000, 
  0x8001, 0xE00F, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000
};
