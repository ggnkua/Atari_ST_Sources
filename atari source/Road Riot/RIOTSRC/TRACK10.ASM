
* File name = track10.intel

* Previously loaded at $9180

	DC.B	$00,$00,$00,$08,$00,$08,$00,$08,$00,$0E,$00,$0E,$00,$0E,$00,$11
	DC.B	$00,$00,$FF,$ED,$FF,$ED,$FF,$EC,$FF,$EC,$FF,$E9,$FF,$F2,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$17,$00,$17,$00,$17,$00,$17,$00,$17
	DC.B	$00,$17,$00,$19,$00,$17,$00,$18,$00,$09,$00,$04,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$EC,$FF,$E7,$FF,$E7,$FF,$E7
	DC.B	$FF,$E7,$FF,$E9,$FF,$F5,$00,$00,$00,$1A,$00,$1A,$00,$1A,$00,$1A
	DC.B	$00,$03,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$08,$00,$08,$00,$10,$00,$10,$00,$14,$00,$16,$00,$16,$00,$16
	DC.B	$00,$16,$00,$16,$00,$14,$00,$10,$00,$10,$00,$10,$00,$00,$00,$00
	DC.B	$FF,$EC,$FF,$EB,$FF,$EB,$FF,$EB,$FF,$EA,$FF,$EB,$FF,$EC,$FF,$F0
	DC.B	$00,$08,$00,$11,$00,$14,$00,$14,$00,$14,$00,$14,$00,$10,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$FF,$F0,$FF,$D0,$FF,$A0,$FF,$C0,$FF,$E0,$FF,$F0,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$C8,$FF,$58,$FE,$D0,$FF,$88
	DC.B	$FF,$D0,$FF,$F8,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$40
	DC.B	$FE,$88,$FE,$70,$00,$80,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$E8,$01,$A0,$02,$58,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$38,$00,$10,$FE,$C0,$FF,$E0
	DC.B	$FE,$E8,$00,$B0,$01,$70,$01,$B0,$01,$C0,$00,$80,$00,$80,$00,$D0
	DC.B	$FF,$B0,$FF,$E0,$00,$40,$00,$70,$00,$90,$FF,$D0,$FF,$E0,$FF,$F0
	DC.B	$FF,$F0,$FF,$08,$FF,$38,$FF,$48,$FF,$48,$FF,$48,$FF,$78,$FF,$A8
	DC.B	$FF,$D8,$00,$00,$00,$00,$FF,$B0,$FE,$98,$FE,$C0,$FF,$00,$FF,$28
	DC.B	$FF,$50,$FF,$80,$FF,$A0,$FF,$A0,$FF,$C0,$FF,$C0,$FF,$E0,$00,$00
