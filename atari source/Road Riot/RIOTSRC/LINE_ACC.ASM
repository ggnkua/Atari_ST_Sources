*
*	Line Acceleration Values
*	Fractional value: 36
*

lacc_tbl:
	DC.W	$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001
	DC.W	$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0001,$0002,$0002,$0002,$0002,$0002,$0002
	DC.W	$0002,$0002,$0002,$0002,$0002,$0002,$0002,$0002,$0002,$0003,$0003,$0003,$0003,$0003,$0003,$0003
	DC.W	$0003,$0003,$0003,$0004,$0004,$0004,$0004,$0004,$0004,$0004,$0004,$0005,$0005,$0005,$0005,$0005
	DC.W	$0005,$0005,$0006,$0006,$0006,$0006,$0006,$0006,$0007,$0007,$0007,$0007,$0008,$0008,$0008,$0008
	DC.W	$0008,$0009,$0009,$0009,$0009,$000a,$000a,$000a,$000b,$000b,$000b,$000c,$000c,$000c,$000d,$000d
	DC.W	$000d,$000e,$000e,$000f,$000f,$000f,$0010,$0010,$0011,$0011,$0012,$0012,$0013,$0013,$0014,$0014
	DC.W	$0015,$0016,$0016,$0017,$0018,$0018,$0019,$001a,$001a,$001b,$001c,$001d,$001d,$001e,$001f,$0020
	DC.W	$0021,$0022,$0023,$0024,$0025,$0026,$0027,$0028,$0029,$002a,$002b,$002d,$002e,$002f,$0030,$0032
	DC.W	$0033,$0035,$0036,$0038,$0039,$003b,$003c,$003e,$0040,$0042,$0043,$0045,$0047,$0049,$004b,$004d
	DC.W	$0050,$0052,$0054,$0057,$0059,$005b,$005e,$0061,$0063,$0066,$0069,$006c,$006f,$0072,$0075,$0078
	DC.W	$007c,$007f,$0083,$0086,$008a,$008e,$0092,$0096,$009a,$009e,$00a3,$00a7,$00ac,$00b1,$00b6,$00bb
	DC.W	$00c0,$00c5,$00cb,$00d1,$00d6,$00dc,$00e3,$00e9,$00ef,$00f6,$00fd,$0104,$010b,$0113,$011a,$0122
	DC.W	$012a,$0132,$013b,$0144,$014d,$0156,$015f,$0169,$0173,$017e,$0188,$0193,$019e,$01aa,$01b6,$01c2
	DC.W	$01ce,$01db,$01e8,$01f6,$0204,$0212,$0221,$0230,$0240,$0250,$0260,$0271,$0283,$0294,$02a7,$02ba
	DC.W	$02cd,$02e1,$02f5,$030a,$0320,$0336,$034d,$0365,$037d,$0396,$03af,$03c9,$03e4,$0400,$041c,$043a
