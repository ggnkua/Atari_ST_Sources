
* File name = list2.intel

* Previously loaded at $A800

	DC.B	$00,$6E,$FF,$68,$4A,$70,$09,$FF,$FF,$FF,$0B,$FF,$FF,$FF,$FF,$0C
	DC.B	$FF,$FF,$FF,$04,$FF,$FF,$51,$FF,$FF,$FF,$FF,$06,$FF,$17,$16,$FF
	DC.B	$FF,$FF,$FF,$FF,$50,$FF,$FF,$FF,$FF,$FF,$FF,$19,$1A,$1C,$1D,$1E
	DC.B	$1F,$20,$22,$23,$24,$25,$26,$FF,$FF,$FF,$52,$FF,$FF,$FF,$6A,$71
	DC.B	$FF,$FF,$FF,$49,$FF,$61,$FF,$62,$72,$FF,$FF,$FF,$FF,$53,$55,$56
	DC.B	$57,$58,$59,$FF,$5A,$5C,$5D,$5E,$5F,$FF,$FF,$FF,$08,$FF,$05,$48
	DC.B	$FF,$FF,$FF,$0E,$FF,$FF,$0F,$60,$10,$12,$FF,$15,$13,$27,$28,$29
	DC.B	$2A,$2F,$33,$37,$3B,$3F,$43,$47,$FF,$FF,$66,$67,$4C,$69,$4F,$73
	DC.B	$00,$74,$00,$18,$F5,$00,$0C,$02,$00,$00,$01,$58,$10,$42,$00,$00
	DC.B	$00,$00,$00,$58,$10,$40,$04,$00,$00,$00,$80,$57,$10,$40,$0C,$00
	DC.B	$00,$00,$C0,$05,$09,$40,$00,$00,$00,$00,$80,$05,$F1,$20,$00,$00
	DC.B	$00,$00,$00,$05,$EE,$30,$00,$00,$00,$00,$80,$5E,$CA,$42,$0E,$BE
	DC.B	$00,$00,$81,$31,$16,$C0,$00,$00,$00,$10,$01,$31,$13,$02,$00,$00
	DC.B	$00,$90,$C1,$38,$EE,$52,$0F,$F0,$00,$00,$81,$66,$0C,$D0,$00,$00
	DC.B	$00,$B8,$01,$66,$12,$A4,$0A,$E0,$00,$82,$80,$6D,$1D,$BC,$05,$2C
	DC.B	$00,$3E,$80,$4D,$30,$3C,$00,$00,$00,$00,$80,$32,$3F,$94,$09,$C0
	DC.B	$00,$00,$00,$5F,$19,$B6,$00,$00,$00,$40,$80,$5F,$18,$30,$02,$18
	DC.B	$00,$4C,$80,$4D,$83,$34,$00,$00,$00,$A0,$00,$4D,$E4,$42,$00,$00
	DC.B	$00,$00,$80,$0A,$05,$E0,$00,$00,$00,$00,$80,$49,$1D,$6C,$00,$00
	DC.B	$00,$00,$80,$05,$BB,$D2,$00,$00,$00,$00,$40,$05,$D6,$22,$09,$86
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$49,$20,$80,$00,$00
	DC.B	$00,$10,$00,$49,$20,$80,$00,$00,$00,$00,$80,$0A,$F9,$52,$00,$00
	DC.B	$00,$00,$80,$49,$20,$80,$00,$00,$00,$30,$80,$49,$20,$80,$00,$00
	DC.B	$FF,$B0,$80,$49,$20,$80,$00,$00,$00,$28,$80,$49,$20,$80,$00,$00
	DC.B	$00,$10,$00,$49,$20,$80,$00,$00,$FF,$88,$80,$0A,$05,$FC,$00,$00
	DC.B	$00,$00,$80,$49,$20,$80,$00,$00,$FF,$C0,$80,$49,$20,$80,$00,$00
	DC.B	$00,$48,$80,$49,$20,$80,$00,$00,$00,$00,$80,$49,$20,$80,$00,$00
	DC.B	$00,$20,$80,$49,$20,$80,$00,$00,$00,$B0,$80,$49,$1E,$1C,$00,$00
	DC.B	$00,$00,$80,$49,$1E,$1C,$00,$00,$00,$00,$80,$49,$1E,$1C,$00,$00
	DC.B	$00,$00,$00,$49,$1E,$1C,$00,$00,$00,$00,$41,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$40,$46,$F1,$50,$04,$00,$00,$06,$40,$46,$F1,$50,$08,$00
	DC.B	$00,$04,$C0,$46,$F1,$50,$0C,$00,$00,$02,$40,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$40,$46,$F1,$50,$04,$00,$00,$00,$40,$46,$F1,$50,$08,$00
	DC.B	$00,$00,$C0,$46,$F1,$50,$0C,$00,$00,$00,$40,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$40,$46,$F1,$50,$04,$00,$00,$00,$40,$46,$F1,$50,$08,$00
	DC.B	$00,$00,$C0,$46,$F1,$50,$0C,$00,$00,$00,$40,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$40,$46,$F1,$50,$04,$00,$00,$00,$40,$46,$F1,$50,$08,$00
	DC.B	$00,$00,$C0,$46,$F1,$50,$0C,$00,$00,$00,$40,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$40,$46,$F1,$50,$04,$00,$00,$00,$40,$46,$F1,$50,$08,$00
	DC.B	$00,$00,$C0,$46,$F1,$50,$0C,$00,$00,$00,$40,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$40,$46,$F1,$50,$04,$00,$00,$00,$40,$46,$F1,$50,$08,$00
	DC.B	$00,$00,$C0,$46,$F1,$50,$0C,$00,$00,$00,$40,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$40,$46,$F1,$50,$04,$00,$00,$00,$40,$46,$F1,$50,$08,$00
	DC.B	$00,$00,$C0,$46,$F1,$50,$0C,$00,$00,$00,$C2,$46,$F1,$50,$00,$00
	DC.B	$00,$00,$C0,$6B,$B8,$10,$0F,$F0,$00,$00,$81,$59,$13,$38,$0F,$F0
	DC.B	$01,$06,$00,$78,$0D,$50,$00,$00,$00,$38,$81,$3D,$E5,$EA,$00,$00
	DC.B	$00,$38,$40,$5F,$EB,$12,$00,$00,$00,$00,$01,$36,$25,$08,$00,$00
	DC.B	$00,$00,$80,$1E,$D8,$C8,$00,$00,$00,$00,$80,$5F,$15,$BC,$00,$00
	DC.B	$00,$00,$81,$31,$1C,$40,$00,$00,$00,$00,$81,$66,$11,$F6,$00,$00
	DC.B	$00,$00,$81,$66,$14,$00,$00,$00,$00,$00,$00,$2C,$00,$D8,$00,$00
	DC.B	$00,$00,$80,$49,$20,$76,$00,$00,$00,$00,$80,$49,$20,$76,$00,$00
	DC.B	$00,$00,$80,$49,$20,$76,$00,$00,$00,$00,$80,$49,$20,$76,$00,$00
	DC.B	$00,$00,$80,$49,$20,$76,$00,$00,$00,$00,$80,$49,$20,$76,$00,$00
	DC.B	$00,$00,$00,$49,$20,$BC,$00,$00,$00,$00,$80,$2C,$FF,$20,$00,$00
	DC.B	$00,$00,$80,$49,$20,$BC,$00,$00,$00,$00,$80,$49,$20,$BC,$00,$00
	DC.B	$00,$00,$80,$49,$20,$BC,$00,$00,$00,$00,$80,$49,$20,$BC,$00,$00
	DC.B	$00,$00,$81,$3C,$1F,$88,$0B,$00,$00,$2C,$80,$2C,$FD,$10,$00,$00
	DC.B	$00,$00,$00,$6D,$1E,$00,$00,$00,$00,$00,$01,$45,$12,$0A,$06,$D6
	DC.B	$00,$00,$00,$45,$12,$0A,$0A,$D6,$00,$00,$80,$45,$12,$0A,$0E,$D6
	DC.B	$00,$00,$80,$0A,$FA,$E0,$00,$00,$00,$00,$80,$0B,$FE,$B4,$00,$00
	DC.B	$00,$00,$80,$0B,$FE,$68,$00,$00,$00,$00,$80,$0B,$00,$00,$00,$00
	DC.B	$00,$00,$00,$6D,$1F,$82,$00,$00,$00,$00,$01,$45,$13,$32,$06,$66
	DC.B	$00,$00,$00,$45,$13,$32,$0A,$66,$FF,$74,$80,$45,$13,$32,$0E,$66
	DC.B	$FF,$7C,$00,$58,$10,$40,$00,$00,$00,$00,$82,$57,$10,$40,$04,$00
	DC.B	$00,$00,$C0,$5F,$ED,$C4,$0E,$AE,$00,$84,$82,$45,$13,$32,$02,$66
	DC.B	$FF,$89,$82,$45,$12,$0A,$02,$D6,$00,$00,$80,$78,$0D,$40,$00,$00
	DC.B	$00,$00,$80,$6D,$1D,$7E,$00,$00,$00,$00,$80,$6D,$1D,$7E,$00,$00
	DC.B	$00,$00,$80,$6D,$1D,$7E,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$80,$1C,$86,$00,$00,$00
	DC.B	$00,$00,$80,$1C,$86,$00,$00,$00,$00,$00,$FF,$7F,$FF,$FF,$FF,$D3
	DC.B	$00,$00,$00,$00,$00,$00,$80,$00,$FF,$FF,$BF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$55,$FF,$FD,$FB,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FB,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$C4,$10,$83,$00,$CF,$04,$C6,$FF,$E8,$FF,$02,$FF,$3C,$FF,$0F
	DC.B	$00,$00,$00,$00,$00,$4B,$01,$04,$FF,$FF,$FF,$7F,$FF,$BB,$BF,$5E
	DC.B	$00,$00,$00,$00,$00,$00,$81,$00,$FF,$FF,$FF,$FF,$FF,$F7,$FF,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$F7,$FF,$FF,$FE,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$40,$00,$80,$40,$FF,$FF,$FB,$7F,$FF,$DE,$FF,$FF
	DC.B	$00,$E0,$00,$A9,$00,$6B,$00,$4D,$FF,$0D,$FF,$47,$FF,$91,$FF,$11
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FD,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$80,$00,$00,$00,$08,$01,$00,$FF,$FF,$FF,$FF,$FB,$FF,$7D,$FD
	DC.B	$08,$00,$00,$00,$80,$00,$08,$00,$FD,$FF,$FC,$FF,$F7,$FF,$7B,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$EF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$40,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FE,$FF
	DC.B	$00,$00,$00,$40,$00,$60,$00,$00,$FF,$E7,$FD,$5E,$FF,$F9,$FF,$F6
	DC.B	$00,$00,$00,$00,$00,$00,$00,$10,$FF,$FF,$FF,$FF,$FF,$FB,$FF,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$55,$FF,$FF,$FF,$FF,$FE
	DC.B	$00,$00,$00,$00,$40,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$2A,$00,$3C,$00,$BF,$02,$C7,$FF,$08,$3F,$81,$BF,$E7,$EF,$80
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$E7,$FE,$FF,$FF,$9F,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FE,$FF,$FF,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$08,$00,$FF,$EF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$80,$00,$00,$FF,$FF,$EF,$FF,$FF,$FB,$7F,$FF
	DC.B	$00,$A0,$00,$80,$00,$B5,$00,$E8,$FF,$C6,$FF,$D7,$FF,$25,$FF,$0B
	DC.B	$00,$00,$00,$00,$04,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$01,$04,$00,$41,$FF,$EF,$FF,$FF,$FF,$FF,$FF,$F7
	DC.B	$00,$00,$84,$00,$02,$00,$00,$00,$BF,$FF,$FE,$FF,$FD,$FF,$B7,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$80,$00,$FF,$FF,$FF,$FF,$7F,$FF,$F7,$FF
	DC.B	$00,$00,$00,$00,$80,$00,$00,$88,$FF,$FF,$FF,$FF,$EF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$10,$00,$66,$00,$08,$FF,$FB,$FF,$FF,$FE,$FE,$FF,$FB
	DC.B	$00,$00,$00,$00,$00,$20,$80,$00,$FF,$FF,$FF,$FF,$7F,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$55,$FF,$FF,$FF,$FF,$FD
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$1E,$00,$7E,$00,$BF,$00,$E7,$FF,$84,$FF,$D0,$FF,$40,$FF,$10
	DC.B	$00,$00,$00,$40,$00,$40,$10,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$BF,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$90,$00,$10,$00,$38,$FF,$4F,$FF,$AB,$FF,$FF,$FF,$65
	DC.B	$00,$00,$00,$00,$20,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$10,$00,$00,$FF,$FF,$FF,$FF,$FF,$BF,$FF,$3F
	DC.B	$00,$00,$00,$00,$24,$00,$00,$00,$F5,$FF,$7F,$FF,$FF,$FF,$CF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$80,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$BF,$FF
