* ROM/PROM data file created 25-SEP-1989 14:08:01

* File name = EE$USERDISK:[speed.PROG]LASER_OFFSET.ASM;

* Previously loaded at $0002F8BE

 DC.B $02,$0E,$01,$EC,$01,$E0,$01,$CC,$01,$B0,$01,$8A,$01,$84,$01,$70
 DC.B $01,$50,$01,$2E,$01,$0A,$00,$DA,$00,$BC,$00,$A0,$00,$7C,$00,$56
 DC.B $00,$56,$00,$34,$00,$0C,$FF,$E4,$FF,$CA,$FF,$9C,$FF,$84,$FF,$5C
 DC.B $FF,$28,$FF,$0A,$FE,$F0,$FE,$D4,$FE,$B6,$FE,$94,$FE,$6A,$FE,$5C
 DC.B $01,$80,$01,$80,$01,$98,$01,$98,$01,$B2,$01,$B2,$01,$E0,$01,$E0
 DC.B $01,$F0,$01,$F0,$01,$F0,$01,$F0,$02,$16,$02,$16,$02,$16,$02,$16
 DC.B $02,$16,$02,$16,$02,$16,$02,$16,$02,$16,$02,$16,$02,$16,$02,$16
 DC.B $02,$16,$02,$16,$02,$00,$02,$00,$01,$DE,$01,$DE,$01,$DE,$01,$CA
