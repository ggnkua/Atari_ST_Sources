
* File name = map4.intel

* Previously loaded at $6180

	DC.B	$09,$60,$1A,$E0,$0A,$20,$1A,$80,$0A,$C0,$1A,$20,$0B,$80,$19,$A0
	DC.B	$0B,$C0,$19,$60,$0C,$20,$19,$60,$0C,$60,$19,$20,$0C,$C0,$18,$E0
	DC.B	$0D,$80,$18,$80,$0E,$20,$18,$40,$0E,$80,$18,$00,$0E,$E0,$17,$E0
	DC.B	$0F,$40,$17,$80,$0F,$A0,$17,$00,$0F,$C0,$16,$60,$0F,$E0,$15,$C0
	DC.B	$0F,$E0,$15,$40,$0F,$E0,$14,$C0,$0F,$80,$14,$40,$0F,$A0,$13,$E0
	DC.B	$0F,$60,$13,$80,$0F,$60,$13,$00,$0E,$E0,$12,$C0,$0E,$40,$12,$80
	DC.B	$0D,$80,$12,$60,$0D,$20,$12,$40,$0C,$C0,$12,$20,$0C,$40,$12,$60
	DC.B	$0C,$00,$12,$40,$0B,$C0,$12,$A0,$0B,$20,$13,$20,$0A,$80,$14,$20
	DC.B	$0A,$40,$15,$20,$0A,$00,$16,$00,$09,$C0,$16,$60,$09,$60,$16,$C0
	DC.B	$08,$E0,$16,$E0,$08,$60,$16,$C0,$08,$20,$16,$E0,$07,$E0,$16,$E0
	DC.B	$07,$80,$16,$80,$07,$60,$16,$40,$06,$E0,$16,$20,$06,$80,$15,$80
	DC.B	$06,$A0,$15,$20,$06,$A0,$14,$C0,$06,$80,$14,$40,$06,$E0,$13,$E0
	DC.B	$07,$20,$13,$60,$07,$A0,$12,$40,$07,$80,$11,$C0,$07,$E0,$11,$20
	DC.B	$07,$E0,$10,$60,$07,$C0,$10,$20,$07,$C0,$0F,$C0,$07,$A0,$0F,$A0
	DC.B	$07,$00,$0F,$20,$06,$00,$0E,$A0,$05,$20,$0E,$80,$04,$80,$0E,$80
	DC.B	$04,$20,$0F,$00,$03,$A0,$0F,$C0,$03,$40,$10,$E0,$03,$40,$11,$60
	DC.B	$03,$40,$12,$20,$03,$40,$12,$E0,$03,$40,$13,$80,$03,$40,$13,$E0
	DC.B	$03,$40,$14,$60,$03,$40,$14,$C0,$03,$40,$15,$20,$03,$40,$15,$80
	DC.B	$03,$40,$16,$40,$03,$40,$16,$C0,$03,$40,$17,$40,$03,$40,$18,$00
	DC.B	$03,$40,$18,$A0,$03,$40,$18,$E0,$03,$40,$19,$60,$03,$40,$19,$E0
	DC.B	$03,$40,$1A,$80,$03,$40,$1B,$60,$03,$40,$1B,$E0,$03,$20,$1C,$60
	DC.B	$03,$00,$1C,$E0,$03,$00,$1D,$20,$03,$00,$1D,$80,$03,$20,$1E,$00
	DC.B	$03,$20,$1E,$C0,$03,$00,$1F,$E0,$03,$60,$20,$40,$03,$80,$20,$E0
	DC.B	$03,$A0,$21,$20,$03,$80,$21,$80,$03,$80,$21,$E0,$03,$C0,$22,$60
	DC.B	$04,$40,$22,$E0,$04,$80,$23,$60,$04,$E0,$23,$A0,$05,$40,$24,$20
	DC.B	$05,$A0,$24,$20,$06,$00,$24,$40,$06,$80,$24,$40,$07,$20,$24,$20
	DC.B	$07,$A0,$24,$00,$07,$E0,$23,$A0,$08,$40,$23,$80,$08,$60,$23,$60
	DC.B	$08,$A0,$22,$E0,$08,$A0,$22,$60,$08,$A0,$21,$A0,$08,$A0,$21,$00
	DC.B	$08,$20,$20,$A0,$08,$00,$20,$00,$07,$40,$1F,$80,$07,$00,$1F,$20
	DC.B	$06,$C0,$1E,$E0,$06,$80,$1E,$80,$06,$60,$1E,$40,$06,$20,$1D,$E0
	DC.B	$06,$20,$1D,$60,$06,$40,$1C,$A0,$06,$40,$1C,$00,$07,$40,$1B,$60
	DC.B	$07,$E0,$1B,$60,$08,$40,$1B,$20,$08,$A0,$1B,$00,$09,$00,$1A,$E0
