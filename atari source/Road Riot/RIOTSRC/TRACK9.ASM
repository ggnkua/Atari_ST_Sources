
* File name = track9.intel

* Previously loaded at $8F80

	DC.B	$00,$00,$00,$00,$00,$00,$00,$0D,$00,$0C,$00,$0D,$FF,$FD,$FF,$F4
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$10,$00,$13,$00,$16,$00,$1A,$00,$1C,$00,$1D,$00,$1D
	DC.B	$00,$1E,$00,$1E,$00,$1E,$00,$1E,$00,$0A,$00,$00,$00,$00,$00,$00
	DC.B	$00,$01,$00,$01,$00,$01,$00,$01,$00,$01,$00,$01,$00,$01,$00,$01
	DC.B	$00,$01,$00,$01,$00,$01,$00,$03,$00,$03,$00,$03,$00,$03,$00,$03
	DC.B	$00,$03,$00,$00,$00,$02,$00,$02,$00,$02,$00,$00,$00,$00,$00,$00
	DC.B	$00,$02,$00,$02,$00,$00,$00,$02,$00,$00,$00,$01,$00,$02,$00,$02
	DC.B	$00,$02,$00,$00,$00,$01,$00,$01,$00,$02,$00,$02,$00,$02,$00,$02
	DC.B	$00,$01,$00,$01,$00,$02,$00,$02,$00,$02,$00,$02,$00,$01,$00,$01
	DC.B	$00,$01,$00,$02,$00,$0C,$00,$11,$00,$15,$00,$1A,$00,$1B,$00,$1D
	DC.B	$00,$1E,$00,$1E,$00,$1E,$00,$1E,$00,$1E,$00,$1E,$00,$10,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$FF,$D0,$FF,$A0,$FF,$10,$00,$00,$00,$48,$FF,$B8,$00,$00,$FF,$70
	DC.B	$FE,$D0,$FF,$C0,$00,$00,$00,$00,$FF,$88,$FF,$20,$FF,$B8,$00,$00
	DC.B	$00,$00,$FF,$A0,$FF,$00,$FF,$A8,$00,$00,$00,$00,$FF,$D0,$FF,$40
	DC.B	$FE,$98,$FF,$18,$FF,$F8,$FE,$A8,$FF,$98,$FF,$D8,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$A0,$FF,$00
	DC.B	$FF,$00,$FF,$00,$00,$08,$00,$00,$00,$A0,$FF,$08,$FE,$18,$FD,$00
	DC.B	$FC,$28,$FD,$08,$FE,$78,$FF,$58,$FF,$D8,$00,$00,$00,$00,$00,$00
	DC.B	$00,$90,$FF,$28,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$00,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$A0,$FF,$00,$FF,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$A0,$FF,$00,$FF,$00,$00,$00,$00,$00,$00,$00,$00,$A0
	DC.B	$FF,$00,$FF,$00,$00,$00,$00,$00,$00,$00,$00,$B0,$FF,$00,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
