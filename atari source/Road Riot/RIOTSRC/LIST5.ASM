
* File name = list5.intel

* Previously loaded at $C000

	DC.B	$00,$66,$67,$4F,$FF,$FF,$01,$50,$FF,$51,$FF,$52,$43,$9C,$FF,$9A
	DC.B	$9D,$72,$9E,$FF,$A1,$FF,$94,$64,$8E,$FF,$FF,$08,$99,$09,$4D,$FF
	DC.B	$FF,$02,$0D,$0F,$04,$FF,$90,$0A,$7D,$81,$85,$89,$8D,$6A,$95,$12
	DC.B	$13,$17,$1B,$1F,$23,$27,$2B,$2F,$FF,$FF,$6C,$6D,$FF,$FF,$73,$A2
	DC.B	$FF,$FF,$FF,$91,$FF,$92,$FF,$97,$33,$37,$3B,$3F,$FF,$FF,$93,$76
	DC.B	$FF,$FF,$FF,$77,$FF,$46,$47,$48,$49,$4A,$4B,$4C,$FF,$FF,$79,$FF
	DC.B	$FF,$FF,$7A,$FF,$FF,$FF,$70,$6E,$FF,$FF,$FF,$7B,$FF,$FF,$FF,$FF
	DC.B	$98,$FF,$FF,$8F,$53,$5B,$55,$5D,$57,$5F,$58,$60,$59,$61,$5A,$62
	DC.B	$00,$A3,$80,$43,$F5,$00,$0C,$00,$00,$0C,$80,$52,$28,$00,$0B,$8A
	DC.B	$00,$00,$01,$2F,$0E,$00,$00,$00,$00,$20,$80,$63,$23,$92,$0F,$F0
	DC.B	$00,$20,$00,$4C,$29,$C0,$00,$00,$00,$30,$3F,$2F,$0E,$00,$00,$00
	DC.B	$00,$A0,$02,$2F,$0E,$00,$08,$00,$00,$F4,$80,$62,$29,$A6,$0C,$0C
	DC.B	$01,$1E,$C0,$64,$26,$30,$0C,$60,$00,$00,$80,$19,$0E,$98,$00,$00
	DC.B	$00,$C8,$41,$12,$F0,$26,$08,$00,$00,$30,$40,$12,$F0,$26,$0C,$00
	DC.B	$00,$30,$80,$67,$21,$BC,$0A,$C0,$00,$30,$3F,$2F,$0E,$00,$00,$00
	DC.B	$00,$20,$80,$2D,$0E,$00,$08,$00,$00,$30,$3F,$2F,$0E,$00,$00,$00
	DC.B	$00,$40,$3F,$2F,$0E,$00,$08,$00,$00,$70,$80,$63,$27,$B6,$03,$B4
	DC.B	$00,$56,$81,$12,$0F,$80,$0C,$00,$00,$30,$00,$12,$0F,$80,$00,$00
	DC.B	$00,$30,$00,$12,$0F,$80,$04,$00,$00,$30,$00,$12,$0F,$80,$08,$00
	DC.B	$00,$30,$80,$12,$0F,$80,$0C,$00,$00,$30,$00,$12,$0F,$80,$00,$00
	DC.B	$00,$30,$00,$12,$0F,$80,$04,$00,$00,$30,$00,$12,$0F,$80,$08,$00
	DC.B	$00,$30,$80,$12,$0F,$80,$0C,$00,$00,$30,$00,$12,$0F,$80,$00,$00
	DC.B	$00,$30,$00,$12,$0F,$80,$04,$00,$00,$30,$00,$12,$0F,$80,$08,$00
	DC.B	$00,$30,$80,$12,$0F,$80,$0C,$00,$00,$30,$00,$12,$0F,$80,$00,$00
	DC.B	$00,$30,$00,$12,$0F,$80,$04,$00,$00,$34,$00,$12,$0F,$80,$08,$00
	DC.B	$00,$38,$80,$12,$0F,$80,$0C,$00,$00,$3C,$00,$12,$0F,$80,$00,$00
	DC.B	$00,$40,$00,$12,$0F,$80,$04,$00,$00,$48,$00,$12,$0F,$80,$08,$00
	DC.B	$00,$50,$80,$12,$0F,$80,$0C,$00,$00,$58,$00,$12,$0F,$80,$00,$00
	DC.B	$00,$60,$00,$12,$0F,$80,$04,$00,$00,$80,$00,$12,$0F,$80,$08,$00
	DC.B	$00,$A0,$80,$12,$0F,$80,$0C,$00,$00,$C0,$00,$12,$0F,$80,$00,$00
	DC.B	$00,$E0,$00,$12,$0F,$80,$04,$00,$00,$FA,$00,$12,$0F,$80,$08,$00
	DC.B	$01,$14,$80,$12,$0F,$80,$0C,$00,$01,$2E,$00,$12,$0F,$80,$00,$00
	DC.B	$01,$48,$00,$12,$0F,$80,$04,$00,$01,$62,$00,$12,$0F,$80,$08,$00
	DC.B	$01,$7C,$82,$12,$0F,$80,$0C,$00,$01,$96,$01,$12,$0F,$00,$00,$00
	DC.B	$00,$00,$00,$12,$0F,$00,$04,$00,$FF,$42,$00,$12,$0F,$00,$08,$00
	DC.B	$FF,$5C,$80,$12,$0F,$00,$0C,$00,$FF,$76,$00,$12,$0F,$00,$00,$00
	DC.B	$FF,$90,$00,$12,$0F,$00,$04,$00,$FF,$AA,$00,$12,$0F,$00,$08,$00
	DC.B	$FF,$C4,$80,$12,$0F,$00,$0C,$00,$FF,$DE,$00,$12,$0F,$00,$00,$00
	DC.B	$FF,$F8,$00,$12,$0F,$00,$04,$00,$00,$18,$00,$12,$0F,$00,$08,$00
	DC.B	$00,$38,$80,$12,$0F,$00,$0C,$00,$00,$58,$00,$12,$0F,$00,$00,$00
	DC.B	$00,$78,$00,$12,$0F,$00,$04,$00,$00,$A2,$00,$12,$0F,$00,$08,$00
	DC.B	$00,$CC,$82,$12,$0F,$00,$0C,$00,$00,$F6,$00,$52,$29,$30,$0F,$F0
	DC.B	$00,$C7,$01,$37,$1E,$C2,$0E,$64,$00,$BB,$C0,$76,$F0,$00,$04,$30
	DC.B	$00,$6D,$81,$59,$12,$AC,$00,$00,$00,$40,$81,$59,$11,$D2,$00,$00
	DC.B	$00,$88,$81,$59,$12,$8C,$00,$00,$01,$18,$81,$59,$12,$9E,$00,$00
	DC.B	$00,$F0,$81,$59,$13,$70,$00,$00,$00,$A0,$81,$59,$12,$26,$00,$00
	DC.B	$00,$00,$81,$59,$12,$BA,$00,$00,$00,$00,$00,$52,$28,$92,$0C,$E0
	DC.B	$00,$59,$C0,$76,$F8,$C0,$07,$EA,$00,$4F,$80,$63,$1F,$86,$0B,$48
	DC.B	$01,$D8,$80,$63,$1F,$86,$0A,$A8,$FF,$DD,$80,$64,$22,$74,$0A,$A8
	DC.B	$00,$00,$C0,$63,$DF,$B2,$0A,$A8,$00,$3A,$00,$6F,$2D,$76,$00,$00
	DC.B	$00,$00,$80,$2E,$0E,$C8,$00,$00,$00,$00,$00,$4E,$29,$74,$00,$00
	DC.B	$00,$00,$80,$2E,$0E,$C8,$00,$00,$00,$00,$80,$63,$29,$48,$00,$00
	DC.B	$00,$00,$80,$63,$2B,$70,$00,$00,$00,$00,$C0,$63,$DE,$7E,$00,$00
	DC.B	$00,$00,$C0,$63,$E1,$54,$00,$00,$00,$00,$00,$64,$29,$34,$00,$00
	DC.B	$00,$00,$80,$2E,$0E,$C8,$00,$00,$00,$00,$40,$64,$DE,$12,$00,$00
	DC.B	$00,$00,$82,$2E,$0E,$C8,$00,$00,$00,$00,$C0,$64,$D8,$CE,$00,$00
	DC.B	$00,$00,$80,$64,$21,$C4,$00,$00,$00,$00,$80,$64,$21,$C4,$00,$00
	DC.B	$FF,$C0,$00,$63,$21,$06,$06,$92,$00,$00,$C0,$5F,$EB,$EA,$0F,$F0
	DC.B	$00,$00,$00,$52,$29,$74,$0F,$F0,$00,$10,$81,$70,$E1,$F8,$0E,$1A
	DC.B	$00,$1D,$80,$52,$29,$52,$0C,$48,$00,$65,$00,$79,$0D,$50,$05,$F2
	DC.B	$00,$C7,$40,$78,$F1,$E2,$07,$AE,$00,$DC,$80,$64,$21,$7C,$0D,$1E
	DC.B	$01,$1D,$00,$52,$29,$A4,$0B,$E2,$00,$30,$80,$76,$1F,$7E,$08,$02
	DC.B	$00,$30,$80,$76,$0C,$F0,$04,$90,$00,$00,$81,$68,$1C,$9E,$0F,$F0
	DC.B	$00,$00,$00,$52,$2C,$3A,$0C,$D4,$00,$00,$80,$76,$0C,$FE,$07,$DC
	DC.B	$00,$00,$00,$6B,$35,$38,$00,$00,$00,$00,$81,$66,$13,$F8,$09,$3E
	DC.B	$00,$00,$80,$64,$23,$3E,$0F,$F0,$02,$47,$00,$47,$30,$40,$00,$00
	DC.B	$01,$98,$00,$5F,$15,$4E,$05,$A2,$01,$BF,$80,$78,$10,$D6,$06,$36
	DC.B	$01,$C3,$80,$47,$34,$1E,$09,$38,$00,$33,$00,$6D,$1E,$2A,$00,$00
	DC.B	$00,$00,$80,$79,$0D,$9C,$0B,$B4,$00,$00,$C0,$6B,$C9,$26,$0E,$7E
	DC.B	$00,$00,$80,$47,$35,$60,$00,$00,$00,$00,$00,$6A,$13,$58,$00,$00
	DC.B	$00,$00,$80,$62,$D3,$00,$00,$00,$00,$00,$40,$12,$F0,$26,$00,$00
	DC.B	$00,$30,$40,$12,$F0,$26,$04,$00,$00,$30,$40,$12,$F0,$26,$08,$00
	DC.B	$00,$30,$C0,$12,$F0,$26,$0C,$00,$00,$30,$40,$12,$F0,$26,$00,$00
	DC.B	$00,$30,$40,$12,$F0,$26,$04,$00,$00,$30,$40,$12,$F0,$26,$08,$00
	DC.B	$00,$30,$C0,$12,$F0,$26,$0C,$00,$00,$30,$40,$12,$F0,$26,$00,$00
	DC.B	$00,$30,$40,$12,$F0,$26,$04,$00,$00,$30,$40,$12,$F0,$26,$08,$00
	DC.B	$00,$30,$C0,$12,$F0,$26,$0C,$00,$00,$30,$40,$12,$F0,$26,$00,$00
	DC.B	$00,$30,$40,$12,$F0,$26,$04,$00,$00,$30,$40,$12,$F0,$26,$08,$00
	DC.B	$00,$30,$C0,$12,$F0,$26,$0C,$00,$00,$30,$C2,$12,$F0,$26,$00,$00
	DC.B	$00,$30,$80,$5F,$0E,$E0,$0F,$F0,$00,$00,$81,$2E,$0E,$C8,$00,$00
	DC.B	$00,$00,$80,$76,$19,$20,$09,$8E,$00,$30,$C0,$6B,$D1,$60,$00,$00
	DC.B	$00,$C0,$C0,$76,$D5,$80,$07,$8E,$00,$00,$C0,$76,$E7,$C4,$05,$7E
	DC.B	$00,$10,$80,$63,$1E,$D0,$0A,$90,$00,$B2,$40,$4F,$E0,$1C,$0F,$F0
	DC.B	$00,$30,$80,$79,$0F,$70,$09,$C8,$00,$30,$80,$14,$32,$4E,$00,$00
	DC.B	$00,$00,$80,$14,$30,$A6,$00,$00,$00,$00,$81,$66,$13,$B4,$0B,$E2
	DC.B	$00,$88,$00,$6B,$27,$46,$05,$BE,$01,$3D,$81,$31,$EE,$38,$03,$5C
	DC.B	$01,$14,$C0,$63,$E0,$12,$0F,$F0,$01,$1F,$80,$79,$0E,$20,$00,$00
	DC.B	$01,$F8,$40,$78,$F0,$60,$07,$3A,$02,$9A,$00,$5F,$17,$40,$04,$82
	DC.B	$02,$7C,$81,$66,$13,$70,$0D,$EA,$02,$E1,$81,$66,$11,$40,$03,$BE
	DC.B	$02,$7D,$81,$31,$10,$80,$00,$00,$02,$08,$FF,$5F,$FF,$38,$FF,$70
	DC.B	$00,$00,$00,$00,$00,$00,$20,$00,$FF,$FF,$FD,$FF,$BF,$FF,$FF,$F7
	DC.B	$00,$00,$00,$00,$00,$90,$04,$00,$FF,$FE,$FF,$FF,$FB,$F5,$39,$77
	DC.B	$00,$00,$20,$00,$40,$00,$00,$00,$7F,$FF,$FF,$FF,$F7,$FF,$F7,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$EF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FD,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$02,$04,$00,$08,$FF,$FF,$FF,$FF,$DE,$FF,$FF,$FF
	DC.B	$00,$14,$00,$48,$04,$05,$01,$10,$FF,$7F,$FF,$DF,$FF,$FC,$FD,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$01,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$5D,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$6E,$00,$CE,$00,$A9,$40,$F7,$FF,$44,$EF,$01,$FF,$04,$FF,$48
	DC.B	$00,$00,$00,$00,$00,$00,$00,$01,$FF,$DF,$FF,$7F,$FF,$F7,$FF,$37
	DC.B	$00,$00,$00,$00,$00,$00,$20,$00,$FF,$FF,$FF,$FF,$FF,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$EF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$DF,$FF,$FF,$FF
	DC.B	$00,$90,$00,$A9,$04,$C6,$00,$B0,$FF,$EB,$FF,$7E,$FF,$8E,$FF,$60
	DC.B	$00,$10,$00,$00,$00,$00,$00,$00,$FF,$FF,$DF,$FF,$F7,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FD,$FF,$7D
	DC.B	$00,$00,$01,$00,$C8,$00,$39,$00,$DF,$FF,$FF,$FF,$DD,$FF,$7A,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FE
	DC.B	$00,$00,$00,$00,$08,$00,$00,$00,$FF,$FF,$DF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$80,$00,$00,$00,$FF,$FF,$BF,$FF,$FF,$FF,$BF,$FF
	DC.B	$00,$00,$00,$28,$00,$03,$10,$00,$FF,$DF,$FF,$FE,$F7,$FF,$BF,$FB
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FB,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$55,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$F7,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$20,$FE,$00,$FD,$00,$FF,$00,$FB,$EF,$02,$FF,$00,$FF,$71,$FF,$08
	DC.B	$00,$00,$00,$00,$00,$00,$00,$10,$FF,$F7,$FF,$FF,$FF,$5E,$BF,$FE
	DC.B	$00,$00,$00,$00,$40,$00,$04,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$40,$00,$00,$FF,$FF,$FF,$FF,$FB,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FD,$FF,$FF,$FF,$FF,$FF,$F7,$FF
	DC.B	$00,$04,$00,$08,$00,$86,$00,$A1,$FF,$CD,$FF,$9A,$FD,$BB,$FF,$6D
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$EF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$10,$00,$80,$02,$FB,$FB,$FF,$FF,$FF,$FF,$5F,$7F
	DC.B	$00,$00,$80,$00,$00,$00,$88,$00,$7D,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$7F,$FF,$FF,$FF
	DC.B	$00,$01,$00,$00,$00,$00,$00,$40,$FF,$FF,$7F,$FF,$FF,$FF,$FF,$FF
