* ROM/PROM data file created 31-OCT-1990 11:11:21

* File name = EE$USERDISK:[SPEED.PROG]DUST_TBL.ASM;

* Previously loaded at $5714    

 DC.B $FE,$8A,$FE,$EC,$FE,$EC,$FF,$8E,$FF,$8E,$FF,$8E,$00,$E8,$00,$E8
 DC.B $00,$E8,$01,$42,$01,$42,$01,$42,$01,$86,$01,$86,$01,$86,$01,$BC
 DC.B $01,$BC,$01,$BC,$02,$10,$02,$10,$02,$10,$02,$94,$02,$94,$02,$94
 DC.B $02,$94,$02,$94,$02,$94,$02,$DC,$02,$DC,$02,$DC,$02,$AC,$02,$AC
 DC.B $02,$AC,$02,$AC,$02,$AC,$02,$AC,$02,$AC,$02,$A2,$02,$64,$02,$64
 DC.B $02,$7A,$02,$64,$02,$4E,$02,$38,$02,$10,$01,$E2,$01,$CA,$01,$B8
 DC.B $01,$D0,$01,$B2,$01,$92,$01,$56,$01,$22,$00,$CA,$00,$7A,$00,$3A
 DC.B $FF,$F6,$FF,$AA,$FF,$4A,$FF,$04,$FF,$04,$FE,$74,$FE,$74,$FE,$08
 DC.B $FE,$08,$FE,$08,$FD,$D8,$FD,$D8,$FD,$D8,$FD,$88,$FD,$88,$FD,$88
 DC.B $FD,$38,$FD,$38,$FD,$38,$FD,$12,$FD,$12,$FD,$12,$FD,$12,$FD,$12
 DC.B $FD,$12,$FC,$F6,$FC,$F6,$FC,$F6,$FD,$2E,$FD,$2E,$FD,$2E,$FD,$94
 DC.B $FD,$94,$FD,$94,$FD,$DE,$FD,$DE,$FD,$DE,$FE,$52,$FE,$52,$FE,$7E
 DC.B $01,$72,$01,$72,$01,$72,$01,$72,$01,$72,$01,$72,$01,$98,$01,$98
 DC.B $01,$98,$01,$BA,$01,$BA,$01,$BA,$02,$40,$02,$40,$02,$40,$02,$12
 DC.B $02,$12,$02,$12,$02,$1A,$02,$1A,$02,$1A,$02,$18,$02,$18,$02,$18
 DC.B $02,$08,$02,$08,$02,$08,$01,$44,$01,$44,$01,$44,$00,$CE,$00,$CE
 DC.B $00,$CE,$00,$92,$00,$92,$00,$92,$00,$92,$00,$42,$00,$26,$00,$26
 DC.B $00,$14,$00,$14,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 DC.B $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 DC.B $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 DC.B $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$20,$00,$20,$00,$20
 DC.B $00,$60,$00,$60,$00,$60,$00,$9A,$00,$9A,$00,$9A,$00,$D0,$00,$D0
 DC.B $00,$D0,$01,$2C,$01,$2C,$01,$2C,$01,$40,$01,$40,$01,$40,$01,$6E
 DC.B $01,$6E,$01,$6E,$01,$6E,$01,$6E,$01,$6E,$01,$64,$01,$64,$01,$72
