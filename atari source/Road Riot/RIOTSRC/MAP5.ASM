
* File name = map5.intel

* Previously loaded at $6380

	DC.B	$09,$80,$23,$60,$0A,$00,$22,$E0,$0A,$40,$22,$A0,$0A,$80,$22,$20
	DC.B	$0A,$C0,$21,$80,$0A,$C0,$21,$60,$0A,$C0,$21,$20,$0B,$00,$20,$C0
	DC.B	$0B,$00,$20,$A0,$0B,$00,$20,$60,$0B,$40,$20,$20,$0B,$40,$1F,$C0
	DC.B	$0B,$40,$1F,$40,$0B,$80,$1F,$20,$0B,$80,$1E,$80,$0B,$C0,$1E,$20
	DC.B	$0C,$00,$1D,$80,$0C,$20,$1D,$40,$0C,$40,$1C,$E0,$0C,$60,$1C,$80
	DC.B	$0C,$60,$1C,$60,$0C,$80,$1C,$20,$0C,$A0,$1B,$C0,$0C,$E0,$1B,$60
	DC.B	$0D,$20,$1A,$E0,$0D,$40,$1A,$20,$0D,$80,$19,$E0,$0D,$80,$19,$60
	DC.B	$0D,$C0,$18,$E0,$0D,$C0,$18,$A0,$0E,$00,$18,$00,$0E,$00,$17,$80
	DC.B	$0E,$00,$16,$E0,$0E,$00,$16,$40,$0E,$00,$15,$C0,$0D,$C0,$15,$60
	DC.B	$0D,$C0,$14,$C0,$0D,$00,$14,$60,$0C,$A0,$14,$00,$0B,$E0,$13,$E0
	DC.B	$0B,$40,$13,$C0,$0B,$00,$13,$60,$0A,$E0,$13,$00,$0A,$E0,$12,$C0
	DC.B	$0A,$C0,$12,$60,$0A,$E0,$12,$20,$0B,$80,$11,$40,$0C,$C0,$11,$40
	DC.B	$0D,$A0,$11,$20,$0E,$20,$10,$C0,$0E,$A0,$10,$80,$0E,$A0,$0F,$E0
	DC.B	$0E,$A0,$0F,$60,$0E,$40,$0F,$00,$0D,$C0,$0E,$E0,$0D,$40,$0E,$E0
	DC.B	$0C,$C0,$0E,$E0,$0C,$20,$0E,$C0,$0B,$60,$0F,$00,$0B,$20,$0F,$60
	DC.B	$0A,$80,$0F,$60,$0A,$20,$0F,$A0,$09,$E0,$0F,$80,$09,$A0,$0F,$C0
	DC.B	$09,$00,$10,$00,$08,$80,$10,$20,$07,$80,$10,$40,$07,$40,$10,$40
	DC.B	$06,$C0,$10,$60,$06,$A0,$10,$60,$06,$60,$10,$40,$06,$20,$10,$60
	DC.B	$05,$80,$10,$40,$05,$00,$10,$40,$04,$60,$11,$20,$04,$20,$11,$80
	DC.B	$04,$20,$12,$80,$04,$60,$13,$00,$04,$60,$13,$60,$04,$80,$13,$E0
	DC.B	$04,$C0,$14,$40,$05,$60,$15,$00,$05,$80,$15,$A0,$05,$C0,$15,$C0
	DC.B	$05,$E0,$16,$40,$06,$00,$16,$80,$06,$40,$17,$20,$06,$C0,$17,$A0
	DC.B	$07,$00,$18,$00,$07,$00,$18,$A0,$06,$C0,$19,$00,$06,$60,$19,$A0
	DC.B	$05,$E0,$19,$E0,$05,$E0,$1A,$20,$05,$C0,$1A,$60,$06,$00,$1A,$C0
	DC.B	$06,$40,$1B,$40,$06,$C0,$1B,$C0,$07,$60,$1C,$00,$07,$C0,$1C,$A0
	DC.B	$07,$80,$1C,$E0,$07,$A0,$1D,$20,$07,$A0,$1D,$00,$07,$60,$1D,$80
	DC.B	$07,$20,$1E,$00,$06,$E0,$1E,$20,$06,$40,$1E,$80,$05,$C0,$1E,$E0
	DC.B	$05,$60,$1F,$00,$05,$00,$1F,$60,$05,$20,$1F,$C0,$05,$00,$20,$00
	DC.B	$04,$C0,$20,$60,$05,$00,$21,$20,$04,$C0,$21,$A0,$04,$C0,$22,$00
	DC.B	$05,$00,$22,$80,$05,$40,$22,$E0,$05,$80,$23,$20,$05,$C0,$23,$40
	DC.B	$06,$00,$23,$A0,$06,$C0,$23,$C0,$07,$80,$24,$20,$08,$00,$24,$00
	DC.B	$08,$80,$23,$E0,$08,$E0,$23,$C0,$09,$20,$23,$C0,$09,$80,$23,$A0
