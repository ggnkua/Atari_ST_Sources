/*	std.h		*/

#define	LOCAL	static

#define TRUE	1
#define FALSE	0
#define NULL	0

#define	uint	unsigned int
#define	ulong	unsigned long
#define	ushort	unsigned short
#define	uchar	unsigned char

#define	BYTE		uchar
#define	SBYTE		char
#define	WORD		ushort
#define	SWORD		short
#define	LWORD		unsigned long
#define	SLWORD		long

typedef char		S8;
typedef unsigned char	U8;
typedef short		S16;
typedef unsigned short	U16;
typedef unsigned long	U32;
typedef long		S32;

typedef	int (*PFI)();
