
* File name = track4.intel

* Previously loaded at $8580

	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$0A,$00,$0B,$00,$0D,$00,$10
	DC.B	$00,$10,$00,$10,$00,$10,$00,$10,$00,$0F,$00,$0C,$00,$0C,$00,$0C
	DC.B	$00,$0C,$00,$0C,$00,$0C,$00,$0C,$00,$0C,$00,$0C,$00,$0C,$00,$0C
	DC.B	$00,$0A,$00,$08,$00,$04,$00,$00,$FF,$F8,$FF,$F6,$FF,$F6,$FF,$EE
	DC.B	$FF,$EE,$FF,$EE,$FF,$EE,$FF,$EE,$FF,$EE,$FF,$F6,$00,$00,$00,$00
	DC.B	$00,$08,$00,$10,$00,$16,$00,$16,$00,$16,$00,$16,$00,$16,$00,$16
	DC.B	$00,$16,$00,$16,$00,$16,$00,$16,$00,$16,$00,$08,$00,$04,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$05,$00,$08,$00,$08,$00,$08,$00,$0A,$00,$14,$00,$14,$00,$14
	DC.B	$00,$14,$00,$14,$00,$14,$00,$13,$00,$13,$00,$13,$00,$13,$00,$05
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$ED
	DC.B	$FF,$ED,$FF,$ED,$FF,$EF,$FF,$EF,$FF,$EF,$FF,$EF,$FF,$F6,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$A0,$00,$00,$00,$00
	DC.B	$00,$C0,$00,$00,$FF,$E0,$FF,$A0,$FF,$80,$FF,$60,$FF,$40,$FF,$80
	DC.B	$FF,$A0,$FF,$E0,$00,$00,$00,$40,$00,$80,$01,$20,$01,$90,$01,$F0
	DC.B	$02,$68,$02,$98,$02,$80,$02,$10,$01,$60,$00,$90,$00,$00,$FF,$80
	DC.B	$FE,$F8,$FE,$C0,$FF,$00,$FF,$C0,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$FF,$E0,$FF,$C0,$FF,$A0,$FF,$A0,$FF,$80,$FF,$B0,$FF,$E0
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$10,$00,$20,$00,$30,$00,$40
	DC.B	$00,$50,$00,$40,$00,$30,$00,$20,$00,$10,$00,$00,$FF,$C0,$FF,$80
	DC.B	$00,$00,$00,$00,$00,$00,$01,$30,$00,$00,$FF,$78,$FF,$78,$00,$00
	DC.B	$01,$30,$00,$00,$FF,$78,$FF,$78,$00,$00,$01,$30,$00,$08,$FF,$78
	DC.B	$FF,$78,$00,$00,$01,$20,$00,$00,$FF,$78,$FF,$78,$00,$00,$01,$20
	DC.B	$00,$08,$00,$68,$00,$00,$00,$00,$FF,$78,$FF,$18,$FF,$00,$FE,$E0
	DC.B	$00,$50,$00,$48,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$E0,$FF,$70
	DC.B	$FF,$10,$FE,$B8,$00,$00,$FF,$00,$FE,$98,$FF,$00,$FF,$80,$FF,$20
	DC.B	$FF,$28,$FF,$48,$FF,$60,$FF,$30,$FF,$30,$FF,$80,$FF,$B0,$FF,$E0
