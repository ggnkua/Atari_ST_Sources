* Elastic collision table
* Force constant: 8

	DC.W	$fd00,$00f8,$00f0,$00e8,$00e0,$00d8,$00d0,$00c8,$00c0,$00b8,$00b0,$00a8,$00a0,$0098,$0090,$0088
	DC.W	$0000,$00ad,$00d4,$00da,$00d8,$00d3,$00cc,$00c5,$00be,$00b6,$00ae,$00a6,$009f,$0097,$008f,$0087
	DC.W	$0000,$006a,$00a5,$00bd,$00c4,$00c5,$00c2,$00be,$00b8,$00b1,$00ab,$00a3,$009c,$0095,$008d,$0085
	DC.W	$0000,$0048,$007e,$009d,$00ac,$00b3,$00b4,$00b3,$00af,$00aa,$00a5,$009e,$0098,$0091,$008a,$0083
	DC.W	$0000,$0036,$0062,$0081,$0095,$009f,$00a5,$00a6,$00a4,$00a1,$009d,$0098,$0092,$008c,$0086,$007f
	DC.W	$0000,$002a,$004f,$006b,$007f,$008d,$0094,$0098,$0099,$0097,$0094,$0091,$008c,$0086,$0081,$007a
	DC.W	$0000,$0022,$0040,$005a,$006e,$007b,$0085,$008a,$008c,$008d,$008b,$0088,$0084,$0080,$007b,$0000
	DC.W	$0000,$001c,$0036,$004c,$005f,$006c,$0076,$007d,$0080,$0082,$0081,$007f,$007d,$0079,$0074,$0000
	DC.W	$0000,$0017,$002e,$0041,$0052,$005f,$0069,$0070,$0075,$0077,$0077,$0077,$0075,$0072,$0000,$0000
	DC.W	$0000,$0014,$0027,$0038,$0047,$0054,$005e,$0065,$006a,$006d,$006e,$006e,$006c,$006a,$0000,$0000
	DC.W	$0000,$0011,$0022,$0031,$003f,$004a,$0053,$005a,$005f,$0063,$0065,$0065,$0064,$0000,$0000,$0000
	DC.W	$0000,$000f,$001d,$002b,$0037,$0041,$004a,$0051,$0056,$005a,$005c,$005d,$0000,$0000,$0000,$0000
	DC.W	$0000,$000d,$001a,$0026,$0030,$003a,$0042,$0048,$004e,$0051,$0053,$0000,$0000,$0000,$0000,$0000
	DC.W	$0000,$000b,$0016,$0021,$002b,$0033,$003b,$0041,$0046,$0049,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W	$0000,$000a,$0014,$001d,$0026,$002e,$0034,$003a,$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W	$0000,$0009,$0011,$001a,$0021,$0028,$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
