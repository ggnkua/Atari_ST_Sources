
* File name = map11.intel

* Previously loaded at $6F80

	DC.B	$07,$20,$1F,$E0,$07,$A0,$1F,$E0,$08,$00,$1F,$E0,$08,$60,$1F,$E0
	DC.B	$08,$80,$1F,$E0,$09,$00,$1F,$E0,$09,$40,$1F,$A0,$09,$A0,$1F,$A0
	DC.B	$0A,$00,$1F,$A0,$0A,$60,$1F,$A0,$0A,$C0,$1F,$40,$0B,$60,$1F,$40
	DC.B	$0B,$A0,$1F,$40,$0C,$00,$1F,$40,$0C,$40,$1F,$00,$0C,$80,$1E,$C0
	DC.B	$0C,$C0,$1E,$80,$0C,$C0,$1E,$20,$0C,$C0,$1D,$60,$0C,$80,$1D,$20
	DC.B	$0C,$40,$1C,$E0,$0C,$20,$1C,$40,$0B,$C0,$1C,$00,$0B,$80,$1B,$C0
	DC.B	$0B,$20,$1B,$80,$0A,$C0,$1B,$60,$0A,$A0,$1B,$00,$0A,$60,$1B,$00
	DC.B	$0A,$20,$1A,$C0,$09,$C0,$1A,$80,$09,$80,$1A,$00,$09,$80,$19,$A0
	DC.B	$09,$80,$19,$20,$09,$E0,$18,$80,$0A,$40,$18,$40,$0A,$C0,$18,$20
	DC.B	$0B,$00,$18,$20,$0B,$40,$18,$20,$0B,$A0,$18,$60,$0C,$00,$18,$E0
	DC.B	$0C,$60,$19,$00,$0C,$C0,$19,$A0,$0D,$20,$19,$A0,$0D,$60,$19,$E0
	DC.B	$0D,$E0,$19,$E0,$0E,$40,$19,$E0,$0E,$80,$19,$E0,$0E,$C0,$19,$A0
	DC.B	$0F,$60,$19,$60,$0F,$60,$19,$00,$0F,$60,$18,$A0,$0F,$60,$18,$40
	DC.B	$0F,$40,$17,$E0,$0F,$00,$17,$40,$0F,$00,$16,$C0,$0F,$00,$16,$00
	DC.B	$0F,$80,$15,$A0,$0F,$E0,$15,$A0,$10,$20,$15,$A0,$10,$80,$15,$A0
	DC.B	$10,$E0,$15,$C0,$11,$60,$15,$C0,$11,$C0,$15,$C0,$12,$00,$15,$80
	DC.B	$12,$40,$15,$60,$12,$80,$14,$E0,$12,$80,$14,$20,$12,$80,$13,$A0
	DC.B	$12,$40,$12,$E0,$11,$E0,$12,$A0,$11,$20,$12,$A0,$10,$A0,$12,$A0
	DC.B	$0F,$E0,$12,$E0,$0F,$80,$12,$E0,$0F,$20,$12,$E0,$0E,$C0,$12,$E0
	DC.B	$0E,$60,$12,$E0,$0E,$00,$12,$E0,$0D,$60,$12,$E0,$0D,$00,$12,$E0
	DC.B	$0C,$E0,$12,$80,$0C,$A0,$12,$40,$0C,$00,$12,$00,$0B,$C0,$11,$A0
	DC.B	$0B,$80,$11,$A0,$0B,$40,$11,$40,$0B,$00,$10,$C0,$0B,$00,$10,$80
	DC.B	$0A,$E0,$10,$20,$0A,$A0,$0F,$C0,$0A,$20,$0F,$40,$09,$C0,$0F,$20
	DC.B	$09,$80,$0E,$E0,$09,$40,$0E,$E0,$08,$C0,$0E,$E0,$08,$80,$0E,$A0
	DC.B	$08,$20,$0E,$A0,$07,$E0,$0E,$E0,$07,$40,$0F,$20,$07,$00,$0F,$00
	DC.B	$06,$A0,$0F,$A0,$06,$20,$10,$00,$05,$C0,$10,$80,$05,$E0,$10,$C0
	DC.B	$05,$A0,$11,$20,$05,$60,$11,$60,$05,$00,$11,$80,$05,$00,$11,$C0
	DC.B	$04,$E0,$12,$00,$04,$A0,$12,$A0,$04,$60,$12,$E0,$04,$40,$13,$20
	DC.B	$04,$00,$13,$60,$03,$C0,$13,$A0,$03,$80,$14,$00,$03,$40,$14,$60
	DC.B	$02,$E0,$14,$E0,$02,$80,$15,$40,$02,$80,$15,$E0,$02,$80,$16,$40
	DC.B	$02,$80,$16,$C0,$02,$80,$17,$40,$02,$80,$17,$80,$02,$80,$17,$E0
	DC.B	$02,$C0,$18,$40,$02,$C0,$18,$C0,$03,$60,$19,$60,$03,$A0,$19,$E0
	DC.B	$04,$00,$1A,$40,$04,$60,$1A,$A0,$04,$C0,$1B,$40,$05,$00,$1B,$E0
	DC.B	$05,$00,$1C,$60,$05,$00,$1C,$C0,$05,$40,$1D,$20,$05,$40,$1D,$80
	DC.B	$05,$40,$1D,$C0,$05,$40,$1E,$20,$05,$A0,$1E,$80,$05,$A0,$1E,$E0
	DC.B	$05,$E0,$1F,$20,$06,$20,$1F,$A0,$06,$80,$1F,$E0,$06,$E0,$1F,$E0
