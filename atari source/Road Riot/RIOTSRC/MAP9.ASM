
* File name = map9.intel

* Previously loaded at $6B80

	DC.B	$09,$A0,$22,$00,$0A,$00,$21,$C0,$0A,$A0,$21,$40,$0A,$C0,$20,$C0
	DC.B	$0B,$00,$20,$A0,$0B,$A0,$20,$20,$0B,$A0,$1F,$80,$0B,$A0,$1F,$20
	DC.B	$0B,$40,$1E,$40,$0B,$40,$1D,$C0,$0B,$00,$1D,$60,$0B,$00,$1D,$00
	DC.B	$0B,$00,$1C,$A0,$0B,$40,$1C,$40,$0B,$40,$1B,$E0,$0B,$40,$1B,$40
	DC.B	$0B,$40,$1A,$E0,$0B,$40,$1A,$00,$0B,$40,$19,$C0,$0B,$40,$19,$60
	DC.B	$0B,$40,$19,$20,$0B,$40,$18,$E0,$0B,$40,$18,$80,$0B,$80,$18,$20
	DC.B	$0B,$80,$17,$E0,$0B,$80,$17,$40,$0B,$80,$16,$E0,$0B,$80,$16,$80
	DC.B	$0B,$80,$16,$20,$0B,$80,$15,$80,$0B,$80,$15,$40,$0B,$C0,$14,$E0
	DC.B	$0B,$C0,$14,$60,$0B,$C0,$13,$C0,$0B,$C0,$13,$60,$0B,$C0,$12,$C0
	DC.B	$0B,$E0,$12,$40,$0B,$E0,$12,$00,$0C,$20,$11,$80,$0C,$20,$11,$20
	DC.B	$0C,$20,$10,$A0,$0B,$C0,$0F,$E0,$0B,$80,$0F,$60,$0B,$20,$0E,$80
	DC.B	$0A,$A0,$0E,$40,$0A,$60,$0E,$20,$09,$C0,$0E,$00,$09,$20,$0D,$C0
	DC.B	$08,$A0,$0E,$20,$08,$00,$0E,$40,$07,$60,$0E,$C0,$07,$20,$0F,$60
	DC.B	$07,$20,$0F,$E0,$07,$20,$10,$00,$06,$E0,$10,$80,$06,$E0,$11,$20
	DC.B	$06,$A0,$11,$A0,$06,$A0,$12,$00,$06,$A0,$12,$80,$06,$60,$13,$00
	DC.B	$06,$60,$13,$40,$06,$60,$13,$A0,$06,$60,$14,$20,$06,$60,$14,$80
	DC.B	$06,$00,$15,$20,$06,$00,$15,$80,$06,$00,$15,$C0,$06,$00,$16,$40
	DC.B	$06,$00,$16,$A0,$06,$00,$16,$C0,$06,$00,$17,$60,$05,$C0,$17,$A0
	DC.B	$05,$C0,$18,$20,$05,$C0,$18,$80,$05,$80,$19,$00,$05,$80,$19,$60
	DC.B	$05,$80,$19,$E0,$05,$80,$1A,$20,$05,$80,$1A,$A0,$05,$40,$1A,$C0
	DC.B	$05,$60,$1B,$40,$05,$40,$1B,$C0,$05,$40,$1C,$60,$05,$40,$1C,$A0
	DC.B	$05,$40,$1C,$E0,$05,$00,$1D,$20,$05,$00,$1D,$80,$05,$00,$1E,$00
	DC.B	$05,$00,$1E,$A0,$04,$E0,$1F,$20,$04,$C0,$1F,$A0,$04,$C0,$1F,$E0
	DC.B	$04,$C0,$20,$40,$04,$C0,$20,$80,$04,$C0,$20,$E0,$04,$C0,$21,$20
	DC.B	$04,$80,$21,$80,$04,$80,$22,$40,$04,$80,$22,$80,$04,$40,$23,$00
	DC.B	$04,$40,$23,$60,$04,$00,$23,$C0,$04,$00,$24,$20,$04,$00,$24,$80
	DC.B	$04,$40,$25,$20,$04,$60,$25,$80,$04,$80,$26,$00,$04,$80,$26,$40
	DC.B	$04,$E0,$26,$C0,$05,$60,$27,$00,$05,$A0,$27,$00,$05,$C0,$27,$00
	DC.B	$06,$20,$27,$00,$06,$C0,$27,$00,$07,$20,$26,$E0,$07,$80,$26,$80
	DC.B	$07,$C0,$26,$00,$08,$20,$25,$80,$08,$20,$25,$60,$08,$00,$25,$00
	DC.B	$08,$60,$24,$80,$08,$40,$24,$20,$08,$60,$23,$C0,$08,$80,$23,$80
	DC.B	$08,$A0,$23,$60,$08,$C0,$23,$20,$09,$00,$22,$E0,$09,$20,$22,$A0
