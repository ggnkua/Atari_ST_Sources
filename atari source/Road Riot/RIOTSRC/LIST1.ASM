
* File name = list1.intel

* Previously loaded at $A000

	DC.B	$00,$65,$66,$FF,$62,$5B,$04,$55,$64,$FF,$FF,$67,$05,$06,$07,$09
	DC.B	$0C,$0D,$0E,$0F,$10,$12,$13,$FF,$16,$18,$19,$1A,$1B,$1D,$69,$1E
	DC.B	$20,$21,$22,$23,$25,$FF,$56,$6A,$FF,$FF,$FF,$28,$FF,$FF,$58,$FF
	DC.B	$29,$5E,$60,$FF,$2A,$FF,$2B,$2C,$2E,$2F,$31,$32,$34,$35,$37,$38
	DC.B	$3A,$3B,$3C,$3D,$3F,$40,$41,$43,$44,$46,$47,$48,$49,$4A,$4B,$4C
	DC.B	$4D,$4F,$50,$52,$52,$52,$53,$54,$68,$63,$61,$5D,$FF,$FF,$FF,$FF
	DC.B	$00,$6B,$00,$18,$F5,$00,$0C,$00,$00,$00,$40,$5F,$E8,$40,$00,$00
	DC.B	$00,$00,$00,$5F,$13,$10,$00,$00,$00,$00,$80,$79,$0E,$A4,$0E,$C4
	DC.B	$00,$00,$80,$5A,$13,$86,$00,$00,$00,$00,$80,$10,$0E,$EE,$00,$00
	DC.B	$00,$00,$80,$10,$0E,$EE,$00,$00,$00,$00,$00,$1F,$0E,$EE,$00,$00
	DC.B	$00,$00,$80,$31,$43,$E8,$00,$00,$00,$00,$00,$10,$0E,$EE,$00,$00
	DC.B	$00,$00,$40,$78,$F1,$42,$00,$00,$00,$00,$81,$3C,$EB,$76,$0D,$DE
	DC.B	$00,$00,$80,$11,$0E,$EE,$00,$00,$00,$00,$80,$1F,$0E,$EE,$00,$00
	DC.B	$00,$00,$80,$10,$0E,$EE,$00,$00,$00,$00,$80,$1F,$0E,$EE,$00,$00
	DC.B	$00,$00,$00,$1F,$0E,$EE,$00,$00,$00,$00,$80,$14,$34,$C0,$00,$00
	DC.B	$00,$00,$80,$11,$0E,$EE,$00,$00,$00,$00,$00,$11,$0E,$EE,$00,$00
	DC.B	$00,$00,$00,$11,$0F,$AA,$0F,$F0,$00,$00,$C0,$79,$EF,$C0,$0C,$74
	DC.B	$00,$00,$00,$10,$0E,$EE,$00,$00,$00,$00,$80,$30,$4F,$C0,$00,$00
	DC.B	$00,$00,$80,$1F,$0E,$EE,$00,$00,$00,$00,$80,$11,$0E,$EE,$00,$00
	DC.B	$00,$00,$80,$1F,$0E,$EE,$00,$00,$00,$00,$00,$11,$0E,$EE,$00,$00
	DC.B	$00,$00,$80,$31,$DB,$40,$00,$00,$00,$00,$80,$11,$0E,$EE,$00,$00
	DC.B	$00,$00,$00,$1F,$0D,$EE,$00,$00,$00,$00,$80,$31,$3A,$9E,$00,$00
	DC.B	$00,$00,$80,$11,$0D,$A0,$00,$00,$00,$00,$80,$10,$0E,$EE,$00,$00
	DC.B	$00,$00,$80,$11,$0E,$EE,$00,$00,$00,$00,$00,$11,$0E,$EE,$00,$00
	DC.B	$00,$00,$80,$14,$32,$B4,$00,$00,$00,$00,$02,$11,$0E,$EE,$00,$00
	DC.B	$00,$00,$01,$31,$E7,$80,$00,$00,$00,$00,$C0,$5F,$EC,$80,$02,$C0
	DC.B	$00,$00,$81,$59,$12,$6A,$00,$00,$00,$A0,$81,$59,$12,$F8,$00,$01
	DC.B	$00,$DF,$C0,$5A,$15,$48,$00,$00,$00,$00,$C1,$11,$F1,$8E,$00,$00
	DC.B	$00,$00,$40,$1F,$F1,$7C,$00,$00,$00,$00,$80,$32,$1D,$C0,$00,$00
	DC.B	$00,$00,$C0,$11,$F1,$E0,$00,$00,$00,$00,$40,$11,$F3,$08,$00,$00
	DC.B	$00,$00,$80,$1C,$A3,$C0,$0F,$F0,$00,$00,$C0,$11,$F2,$32,$00,$00
	DC.B	$00,$00,$40,$11,$F2,$F2,$00,$00,$00,$00,$80,$32,$7E,$3E,$00,$00
	DC.B	$00,$00,$C0,$11,$F2,$44,$00,$00,$00,$00,$40,$11,$F2,$A8,$00,$00
	DC.B	$00,$00,$80,$32,$1C,$60,$0B,$78,$00,$00,$C0,$11,$F2,$E4,$00,$00
	DC.B	$00,$00,$40,$11,$F3,$80,$00,$00,$00,$00,$80,$14,$2D,$C0,$0F,$F0
	DC.B	$00,$00,$C0,$11,$F2,$00,$00,$00,$00,$00,$C0,$10,$F2,$32,$00,$00
	DC.B	$00,$00,$C0,$11,$F1,$BC,$00,$00,$00,$00,$40,$1F,$F1,$C0,$00,$00
	DC.B	$00,$00,$80,$4D,$B1,$40,$00,$00,$00,$00,$C0,$11,$F2,$48,$00,$00
	DC.B	$00,$00,$C0,$1F,$F1,$FC,$00,$00,$00,$00,$40,$11,$F1,$BC,$00,$00
	DC.B	$00,$00,$80,$4D,$BA,$9A,$00,$00,$00,$00,$C0,$11,$F2,$28,$00,$00
	DC.B	$00,$00,$40,$10,$F1,$70,$00,$00,$00,$00,$81,$31,$17,$80,$00,$00
	DC.B	$00,$00,$C0,$11,$F3,$B0,$00,$00,$00,$00,$C0,$1F,$EF,$FE,$00,$00
	DC.B	$00,$00,$C0,$11,$F1,$C0,$00,$00,$00,$00,$C0,$11,$F1,$C0,$00,$00
	DC.B	$00,$00,$C0,$11,$F2,$1E,$00,$00,$00,$00,$C0,$10,$F1,$B4,$00,$00
	DC.B	$00,$00,$C0,$11,$F3,$10,$00,$00,$00,$00,$40,$1F,$F2,$56,$00,$00
	DC.B	$00,$00,$80,$14,$2A,$40,$00,$00,$00,$00,$C0,$11,$F3,$A8,$00,$00
	DC.B	$00,$00,$40,$11,$F2,$B0,$00,$00,$00,$00,$80,$30,$17,$00,$00,$00
	DC.B	$00,$00,$80,$1F,$F2,$68,$00,$00,$00,$00,$C0,$10,$F1,$BE,$00,$00
	DC.B	$00,$00,$C2,$1F,$F1,$FA,$00,$00,$00,$00,$80,$32,$35,$40,$00,$00
	DC.B	$00,$00,$01,$31,$12,$E2,$00,$00,$00,$00,$81,$3A,$11,$AE,$0F,$F0
	DC.B	$00,$00,$01,$3E,$1A,$98,$0F,$F0,$00,$00,$00,$78,$0F,$02,$01,$4A
	DC.B	$00,$00,$C0,$5F,$E3,$80,$04,$FE,$00,$00,$00,$31,$B4,$90,$00,$00
	DC.B	$00,$00,$C0,$79,$F1,$A6,$00,$00,$00,$00,$80,$5F,$14,$24,$0F,$F0
	DC.B	$00,$00,$40,$30,$D0,$DE,$0B,$E0,$00,$00,$80,$30,$35,$96,$0F,$3E
	DC.B	$00,$00,$81,$59,$11,$C0,$00,$00,$00,$00,$81,$66,$12,$FE,$0E,$28
	DC.B	$00,$00,$81,$36,$DD,$EC,$00,$00,$00,$00,$80,$5F,$14,$80,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$C0,$5F,$EE,$90,$00,$00
	DC.B	$00,$00,$80,$78,$0D,$E8,$00,$00,$00,$00,$81,$10,$0E,$EE,$00,$00
	DC.B	$00,$00,$C1,$36,$DE,$3C,$0E,$B6,$00,$00,$80,$1F,$0E,$80,$00,$00
	DC.B	$00,$00,$C0,$79,$F1,$00,$00,$00,$00,$00,$C0,$79,$F1,$00,$00,$00
	DC.B	$00,$00,$80,$5F,$13,$10,$00,$00,$00,$00,$80,$5F,$13,$10,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$52,$28,$50,$00,$00,$00,$00,$80,$52,$28,$50,$00,$00
	DC.B	$00,$00,$80,$47,$30,$40,$00,$00,$00,$00,$80,$47,$30,$40,$00,$00
	DC.B	$00,$00,$80,$00,$00,$00,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$36,$E1,$80,$00,$00
	DC.B	$00,$00,$80,$36,$E1,$80,$00,$00,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$1C,$C1,$00,$0F,$F0,$00,$00,$80,$1C,$C1,$00,$0F,$F0
	DC.B	$00,$00,$80,$49,$1F,$C8,$00,$00,$00,$00,$FE,$FF,$FF,$FF,$DF,$FF
	DC.B	$6F,$40,$BA,$00,$FF,$04,$FF,$80,$00,$FF,$00,$FB,$40,$FF,$00,$BF
	DC.B	$00,$FB,$40,$FF,$FF,$FF,$F1,$FF,$24,$00,$04,$00,$04,$00,$09,$00
	DC.B	$9C,$00,$9C,$00,$FF,$00,$7F,$00,$40,$FF,$00,$FF,$2A,$FF,$02,$FF
	DC.B	$5D,$6C,$03,$4B,$FE,$FF,$FF,$FF,$80,$00,$80,$00,$01,$00,$40,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$EF,$FF,$D7,$FF,$FF,$FF,$FB
	DC.B	$00,$60,$00,$00,$00,$00,$00,$80,$FF,$7D,$FF,$9F,$FF,$FF,$FF,$FF
	DC.B	$00,$9C,$A0,$89,$CF,$FD,$FD,$FF,$00,$00,$02,$00,$49,$48,$50,$08
