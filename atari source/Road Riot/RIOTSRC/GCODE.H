#define	G_ATTRACT	0
#define	G_PREDIT	1
#define	G_PLAY1		2
#define	G_DEMO		4
#define	G_MOED		5
#define	G_LWAIT		6
#define	G_ACCEPT	7
#define	G_PAUSE		8
#define	G_PAUSE1	9
#define	G_PAUSE2	10
#define	G_ENDWAVE	11
#define	G_HISCORE	14
#define G_GOTTO		15
#define G_JOIN1    	16
#define G_START		17	
#define G_CONT		18
#define G_WON		19
#define G_OVER		20
#define	G_WAIT		21
#define	G_FWAIT1	22
#define	G_FWAIT2	23
#define G_TITLE		24
#define G_JOIN2     25
#define G_CHOOSE    26
#define	G_DONE		27
#define	G_HIS1		28
#define G_SELECT    29
#define G_TALLY1	30
#define G_TALLY2	31
#define G_CRAMTST   32
#define G_AWARD1	33
#define G_DIFFTST   34
#define G_GETSYNC   35
#define G_RANKWAVE  36

#define A_TITLE 0
#define A_COUNT 1
#define A_PLAY  2
#define A_QUIT  3
#define A_EXIT	4
#define A_CREDS	5
#define A_LOGO	6
#define A_HISCORE	7
#define A_TESTRAM 8
#define A_GETSYNC 9

