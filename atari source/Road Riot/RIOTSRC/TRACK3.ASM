
* File name = track3.intel

* Previously loaded at $8380

	DC.B	$00,$00,$00,$00,$00,$00,$00,$04,$00,$04,$00,$04,$00,$04,$00,$04
	DC.B	$00,$08,$00,$0A,$00,$00,$00,$00,$00,$01,$00,$00,$00,$00,$00,$00
	DC.B	$FF,$F6,$FF,$F0,$FF,$EC,$FF,$EA,$FF,$E8,$FF,$EC,$FF,$EF,$FF,$F2
	DC.B	$00,$00,$00,$0F,$00,$13,$00,$14,$00,$14,$00,$14,$00,$0F,$00,$0A
	DC.B	$FF,$F4,$FF,$EB,$FF,$E9,$FF,$E7,$FF,$E5,$FF,$E5,$FF,$E5,$FF,$E5
	DC.B	$FF,$E5,$FF,$EB,$FF,$EE,$FF,$EE,$FF,$EE,$00,$00,$00,$0C,$00,$13
	DC.B	$00,$15,$00,$17,$00,$17,$00,$16,$00,$16,$00,$16,$00,$16,$00,$16
	DC.B	$00,$16,$00,$12,$00,$12,$00,$0A,$00,$08,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$02,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FE
	DC.B	$00,$00,$00,$00,$00,$10,$00,$07,$00,$00,$00,$00,$00,$00,$00,$0B
	DC.B	$00,$10,$00,$10,$00,$14,$00,$15,$FF,$F5,$FF,$F6,$FF,$F6,$FF,$FD
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$FF,$EE,$FF,$F5,$00,$08,$00,$0A,$00,$0A,$00,$0A,$00,$0A,$00,$00
	DC.B	$00,$00,$FF,$C0,$FF,$40,$FE,$50,$FE,$B0,$FF,$48,$FF,$A8,$FF,$D0
	DC.B	$00,$20,$00,$50,$00,$58,$00,$20,$FF,$E0,$FF,$80,$FF,$28,$FE,$E0
	DC.B	$FE,$98,$FE,$60,$FE,$68,$FE,$F0,$FF,$50,$FF,$80,$FF,$B0,$00,$00
	DC.B	$00,$40,$00,$80,$00,$C0,$00,$F0,$01,$00,$00,$E8,$00,$C0,$00,$90
	DC.B	$00,$60,$00,$30,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$FF,$C0,$FF,$80,$FF,$28,$FE,$C0,$FE,$90,$FF,$88
	DC.B	$00,$58,$00,$B0,$00,$78,$00,$28,$FF,$B8,$FF,$28,$FE,$C0,$FE,$88
	DC.B	$FF,$80,$00,$70,$01,$40,$02,$50,$FF,$90,$FF,$90,$02,$00,$01,$80
	DC.B	$01,$00,$00,$80,$00,$40,$00,$00,$01,$38,$00,$00,$00,$40,$01,$80
	DC.B	$00,$B0,$01,$10,$01,$B8,$00,$F8,$00,$50,$00,$A8,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$FF,$78,$FE,$F0,$FE,$F0,$00,$10,$01,$00,$02,$50,$00,$00
	DC.B	$FF,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
