
* File name = track11.intel

* Previously loaded at $9380

	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$04,$00,$00,$00,$08,$00,$10,$00,$12
	DC.B	$00,$15,$00,$15,$00,$15,$00,$15,$00,$15,$00,$01,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$F2,$FF,$EE,$FF,$ED
	DC.B	$FF,$EC,$FF,$EB,$FF,$EB,$FF,$EE,$FF,$EF,$FF,$F2,$00,$05,$00,$03
	DC.B	$00,$00,$00,$03,$00,$02,$00,$02,$00,$06,$00,$06,$00,$0A,$00,$10
	DC.B	$00,$11,$00,$12,$00,$10,$00,$00,$00,$00,$FF,$F0,$FF,$EB,$FF,$EA
	DC.B	$FF,$EA,$FF,$EA,$FF,$EA,$FF,$EA,$FF,$FD,$00,$00,$00,$0A,$00,$13
	DC.B	$00,$15,$00,$16,$00,$18,$00,$18,$00,$19,$00,$1A,$00,$1A,$00,$14
	DC.B	$00,$02,$00,$03,$FF,$FC,$FF,$FA,$FF,$F9,$FF,$F8,$FF,$F8,$FF,$F8
	DC.B	$FF,$F7,$FF,$F9,$FF,$FD,$FF,$FA,$FF,$F8,$FF,$F5,$FF,$FA,$FF,$FC
	DC.B	$FF,$F9,$00,$00,$00,$04,$00,$04,$00,$04,$00,$04,$00,$08,$00,$0E
	DC.B	$00,$0E,$00,$0E,$00,$08,$00,$02,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$FF,$FE,$FF,$FD,$00,$0D,$00,$10,$00,$10,$00,$08
	DC.B	$00,$07,$00,$06,$00,$05,$00,$04,$00,$03,$00,$03,$00,$03,$00,$03
	DC.B	$00,$03,$00,$00,$00,$01,$FF,$FE,$FF,$FD,$FF,$FC,$FF,$FB,$FF,$FA
	DC.B	$FF,$F7,$00,$00,$00,$00,$00,$04,$00,$08,$00,$0E,$00,$10,$00,$0F
	DC.B	$00,$00,$00,$00,$00,$00,$FE,$48,$FE,$50,$FE,$50,$FD,$10,$FD,$10
	DC.B	$FD,$10,$FC,$20,$FC,$20,$FC,$20,$FC,$90,$FD,$C0,$FE,$80,$FF,$00
	DC.B	$FF,$80,$00,$00,$00,$80,$01,$60,$02,$00,$02,$60,$02,$60,$02,$00
	DC.B	$01,$80,$00,$E8,$00,$20,$FF,$68,$FE,$A8,$FE,$10,$FD,$D8,$FD,$D0
	DC.B	$FD,$E0,$FD,$E0,$FE,$20,$FE,$50,$FE,$E0,$00,$30,$00,$A0,$01,$00
	DC.B	$FF,$58,$FF,$88,$00,$08,$00,$40,$FF,$90,$FF,$80,$00,$38,$00,$48
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$18,$00,$50,$FF,$30,$FF,$78
	DC.B	$FF,$C0,$FF,$E0,$00,$00,$00,$00,$00,$18,$FF,$48,$FF,$78,$FF,$B8
	DC.B	$FF,$E0,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$C0,$FF,$50,$FE,$A0,$FD,$D0
	DC.B	$FE,$A8,$FE,$D0,$FE,$D0,$FF,$A0,$00,$00,$00,$00,$FF,$F8,$FE,$B8
	DC.B	$FF,$80,$FF,$80,$FD,$C0,$FE,$80,$FF,$00,$FF,$80,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$80,$FD,$00,$FD,$80,$00,$00
	DC.B	$00,$00,$00,$48,$00,$28,$FF,$78,$FE,$88,$FF,$D8,$00,$80,$00,$68
	DC.B	$00,$60,$FF,$98,$FE,$68,$FF,$60,$00,$48,$00,$30,$00,$00,$00,$00
	DC.B	$00,$00,$FF,$20,$FF,$30,$00,$18,$00,$D0,$00,$D0,$00,$58,$FF,$68
	DC.B	$FE,$E0,$FF,$E0,$00,$38,$FF,$F8,$FF,$00,$FF,$C8,$00,$50,$FF,$D8
	DC.B	$FE,$C8,$FF,$48,$FF,$B8,$FF,$F0,$00,$00,$00,$50,$00,$00,$00,$00
