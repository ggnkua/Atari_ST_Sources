 	TTL	'Animation Scripts'

SYSID	EQU	1	* VMS = 0	ARIUM = 1

	IFEQ	SYSID
	INCLUDE	'inc:mobmac.asm'
	INCLUDE	'[speed.grafix]mobs.equ'
	ENDC

	IFNE	SYSID
	INCLUDE	prog/inc/mobmac.asm
	INCLUDE	grafix/mobs.equ
	ENDC

	SECTION	13

	XDEF	wheels
wheels:	DC.L	whl,whll,whlr
	DC.L	wup6,wup6l,wup6r
	DC.L	wup12,wup12l,wup12r
	DC.L	wdn6,wdn6l,wdn6r
	DC.L	wdn12,wdn12l,wdn12r

	XDEF	bodys
bodys:	DC.L	body,body,body
	DC.L	bup6,bup6,bup6
	DC.L	bup12,bup12,bup12
	DC.L	bdn6,bdn6,bdn6
	DC.L	bdn12,bdn12,bdn12

whl:	DCPB	RATF052,RATF051,RATF051,RATF050,RATF050,RATF050
	DCPB	RATF049,RATF049,RATF049,RATF048,RATF048,RATF048
	DCPB	RATF047,RATF047,RATF047,RATF046,RATF046,RATF046
	DCPB	RATF045,RATF045,RATF045,RATF044,RATF044,RATF044
	DCPB	RATF043,RATF043,RATF043,RATF042,RATF042,RATF042
	DCPB	RATF040,RATF040,RATF040,RATF037,RATF037,RATF034
	DCPB	RATF034,RATF031,RATF028,RATF025,RATF022,RATF019
	DCPB	RATF016,RATF013,RATF010,RATF007,RATF004,RATF001

	DCPB	RAT001,RAT004,RAT007,RAT010,RAT013,RAT016
	DCPB	RAT019,RAT022,RAT025,RAT028,RAT031,RAT034
	DCPB	RAT034,RAT037,RAT037,RAT040,RAT040,RAT040
	DCPB	RAT042,RAT042,RAT042,RAT043,RAT043,RAT043
	DCPB	RAT044,RAT044,RAT044,RAT045,RAT045,RAT045
	DCPB	RAT046,RAT046,RAT046,RAT047,RAT047,RAT047
	DCPB	RAT048,RAT048,RAT048,RAT049,RAT049,RAT049
	DCPB	RAT050,RAT050,RAT050,RAT051,RAT051,RAT052

whll:	DCPB	RATF052,RATF051,RATF051,RATF050,RATF050,RATF050
	DCPB	RATF049,RATF049,RATF049,RATF048,RATF048,RATF048
	DCPB	RATF047,RATF047,RATF047,RATF046,RATF046,RATF046
	DCPB	RATF045,RATF045,RATF045,RATF044,RATF044,RATF044
	DCPB	RATF043,RATF043,RATF043,RATF042,RATF042,RATF042
	DCPB	RATF041,RATF041,RATF041,RATF038,RATF038,RATF035
	DCPB	RATF035,RATF032,RATF029,RATF026,RATF023,RATF020
	DCPB	RATF017,RATF014,RATF011,RATF008,RATF005,RATF002

	DCPB	RAT000,RAT003,RAT006,RAT009,RAT012,RAT015
	DCPB	RAT018,RAT021,RAT024,RAT027,RAT030,RAT033
	DCPB	RAT033,RAT036,RAT036,RAT039,RAT039,RAT039
	DCPB	RAT042,RAT042,RAT042,RAT043,RAT043,RAT043
	DCPB	RAT044,RAT044,RAT044,RAT045,RAT045,RAT045
	DCPB	RAT046,RAT046,RAT046,RAT047,RAT047,RAT047
	DCPB	RAT048,RAT048,RAT048,RAT049,RAT049,RAT049
	DCPB	RAT050,RAT050,RAT050,RAT051,RAT051,RAT052

whlr:	DCPB	RATF052,RATF051,RATF051,RATF050,RATF050,RATF050
	DCPB	RATF049,RATF049,RATF049,RATF048,RATF048,RATF048
	DCPB	RATF047,RATF047,RATF047,RATF046,RATF046,RATF046
	DCPB	RATF045,RATF045,RATF045,RATF044,RATF044,RATF044
	DCPB	RATF043,RATF043,RATF043,RATF042,RATF042,RATF042
	DCPB	RATF039,RATF039,RATF039,RATF036,RATF036,RATF033
	DCPB	RATF033,RATF030,RATF027,RATF024,RATF021,RATF018
	DCPB	RATF015,RATF012,RATF009,RATF006,RATF003,RATF000

	DCPB	RAT002,RAT005,RAT008,RAT011,RAT014,RAT017
	DCPB	RAT020,RAT023,RAT026,RAT029,RAT032,RAT035
	DCPB	RAT035,RAT038,RAT038,RAT041,RAT041,RAT041
	DCPB	RAT042,RAT042,RAT042,RAT043,RAT043,RAT043
	DCPB	RAT044,RAT044,RAT044,RAT045,RAT045,RAT045
	DCPB	RAT046,RAT046,RAT046,RAT047,RAT047,RAT047
	DCPB	RAT048,RAT048,RAT048,RAT049,RAT049,RAT049
	DCPB	RAT050,RAT050,RAT050,RAT051,RAT051,RAT052

wup6:	DCPB	R6UF052,R6UF051,R6UF051,R6UF050,R6UF050,R6UF050
	DCPB	R6UF049,R6UF049,R6UF049,R6UF048,R6UF048,R6UF048
	DCPB	R6UF047,R6UF047,R6UF047,R6UF046,R6UF046,R6UF046
	DCPB	R6UF045,R6UF045,R6UF045,R6UF044,R6UF044,R6UF044
	DCPB	R6UF043,R6UF043,R6UF043,R6UF042,R6UF042,R6UF042
	DCPB	R6UF040,R6UF040,R6UF040,R6UF037,R6UF037,R6UF034
	DCPB	R6UF034,R6UF031,R6UF028,R6UF025,R6UF022,R6UF019
	DCPB	R6UF016,R6UF013,R6UF010,R6UF007,R6UF004,R6UF001

	DCPB	R6U001,R6U004,R6U007,R6U010,R6U013,R6U016
	DCPB	R6U019,R6U022,R6U025,R6U028,R6U031,R6U034
	DCPB	R6U034,R6U037,R6U037,R6U040,R6U040,R6U040
	DCPB	R6U042,R6U042,R6U042,R6U043,R6U043,R6U043
	DCPB	R6U044,R6U044,R6U044,R6U045,R6U045,R6U045
	DCPB	R6U046,R6U046,R6U046,R6U047,R6U047,R6U047
	DCPB	R6U048,R6U048,R6U048,R6U049,R6U049,R6U049
	DCPB	R6U050,R6U050,R6U050,R6U051,R6U051,R6U052

wup6l:	DCPB	R6UF052,R6UF051,R6UF051,R6UF050,R6UF050,R6UF050
	DCPB	R6UF049,R6UF049,R6UF049,R6UF048,R6UF048,R6UF048
	DCPB	R6UF047,R6UF047,R6UF047,R6UF046,R6UF046,R6UF046
	DCPB	R6UF045,R6UF045,R6UF045,R6UF044,R6UF044,R6UF044
	DCPB	R6UF043,R6UF043,R6UF043,R6UF042,R6UF042,R6UF042
	DCPB	R6UF041,R6UF041,R6UF041,R6UF038,R6UF038,R6UF035
	DCPB	R6UF035,R6UF032,R6UF029,R6UF026,R6UF023,R6UF020
	DCPB	R6UF017,R6UF014,R6UF011,R6UF008,R6UF005,R6UF002

	DCPB	R6U000,R6U003,R6U006,R6U009,R6U012,R6U015
	DCPB	R6U018,R6U021,R6U024,R6U027,R6U030,R6U033
	DCPB	R6U033,R6U036,R6U036,R6U039,R6U039,R6U039
	DCPB	R6U042,R6U042,R6U042,R6U043,R6U043,R6U043
	DCPB	R6U044,R6U044,R6U044,R6U045,R6U045,R6U045
	DCPB	R6U046,R6U046,R6U046,R6U047,R6U047,R6U047
	DCPB	R6U048,R6U048,R6U048,R6U049,R6U049,R6U049
	DCPB	R6U050,R6U050,R6U050,R6U051,R6U051,R6U052

wup6r:	DCPB	R6UF052,R6UF051,R6UF051,R6UF050,R6UF050,R6UF050
	DCPB	R6UF049,R6UF049,R6UF049,R6UF048,R6UF048,R6UF048
	DCPB	R6UF047,R6UF047,R6UF047,R6UF046,R6UF046,R6UF046
	DCPB	R6UF045,R6UF045,R6UF045,R6UF044,R6UF044,R6UF044
	DCPB	R6UF043,R6UF043,R6UF043,R6UF042,R6UF042,R6UF042
	DCPB	R6UF039,R6UF039,R6UF039,R6UF036,R6UF036,R6UF033
	DCPB	R6UF033,R6UF030,R6UF027,R6UF024,R6UF021,R6UF018
	DCPB	R6UF015,R6UF012,R6UF009,R6UF006,R6UF003,R6UF000

	DCPB	R6U002,R6U005,R6U008,R6U011,R6U014,R6U017
	DCPB	R6U020,R6U023,R6U026,R6U029,R6U032,R6U035
	DCPB	R6U035,R6U038,R6U038,R6U041,R6U041,R6U041
	DCPB	R6U042,R6U042,R6U042,R6U043,R6U043,R6U043
	DCPB	R6U044,R6U044,R6U044,R6U045,R6U045,R6U045
	DCPB	R6U046,R6U046,R6U046,R6U047,R6U047,R6U047
	DCPB	R6U048,R6U048,R6U048,R6U049,R6U049,R6U049
	DCPB	R6U050,R6U050,R6U050,R6U051,R6U051,R6U052

wup12:	DCPB	R12UF052,R12UF051,R12UF051,R12UF050,R12UF050,R12UF050
	DCPB	R12UF049,R12UF049,R12UF049,R12UF048,R12UF048,R12UF048
	DCPB	R12UF047,R12UF047,R12UF047,R12UF046,R12UF046,R12UF046
	DCPB	R12UF045,R12UF045,R12UF045,R12UF044,R12UF044,R12UF044
	DCPB	R12UF043,R12UF043,R12UF043,R12UF042,R12UF042,R12UF042
	DCPB	R12UF040,R12UF040,R12UF040,R12UF037,R12UF037,R12UF034
	DCPB	R12UF034,R12UF031,R12UF028,R12UF025,R12UF022,R12UF019
	DCPB	R12UF016,R12UF013,R12UF010,R12UF007,R12UF004,R12UF001

	DCPB	R12U001,R12U004,R12U007,R12U010,R12U013,R12U016
	DCPB	R12U019,R12U022,R12U025,R12U028,R12U031,R12U034
	DCPB	R12U034,R12U037,R12U037,R12U040,R12U040,R12U040
	DCPB	R12U042,R12U042,R12U042,R12U043,R12U043,R12U043
	DCPB	R12U044,R12U044,R12U044,R12U045,R12U045,R12U045
	DCPB	R12U046,R12U046,R12U046,R12U047,R12U047,R12U047
	DCPB	R12U048,R12U048,R12U048,R12U049,R12U049,R12U049
	DCPB	R12U050,R12U050,R12U050,R12U051,R12U051,R12U052

wup12l:	DCPB	R12UF052,R12UF051,R12UF051,R12UF050,R12UF050,R12UF050
	DCPB	R12UF049,R12UF049,R12UF049,R12UF048,R12UF048,R12UF048
	DCPB	R12UF047,R12UF047,R12UF047,R12UF046,R12UF046,R12UF046
	DCPB	R12UF045,R12UF045,R12UF045,R12UF044,R12UF044,R12UF044
	DCPB	R12UF043,R12UF043,R12UF043,R12UF042,R12UF042,R12UF042
	DCPB	R12UF040,R12UF040,R12UF040,R12UF037,R12UF037,R12UF034
	DCPB	R12UF034,R12UF031,R12UF028,R12UF025,R12UF022,R12UF019
	DCPB	R12UF016,R12UF013,R12UF010,R12UF007,R12UF004,R12UF001

	DCPB	R12U000,R12U003,R12U006,R12U009,R12U012,R12U015
	DCPB	R12U018,R12U021,R12U024,R12U027,R12U030,R12U033
	DCPB	R12U033,R12U036,R12U036,R12U039,R12U039,R12U039
	DCPB	R12U042,R12U042,R12U042,R12U043,R12U043,R12U043
	DCPB	R12U044,R12U044,R12U044,R12U045,R12U045,R12U045
	DCPB	R12U046,R12U046,R12U046,R12U047,R12U047,R12U047
	DCPB	R12U048,R12U048,R12U048,R12U049,R12U049,R12U049
	DCPB	R12U050,R12U050,R12U050,R12U051,R12U051,R12U052

wup12r:	DCPB	R12UF052,R12UF051,R12UF051,R12UF050,R12UF050,R12UF050
	DCPB	R12UF049,R12UF049,R12UF049,R12UF048,R12UF048,R12UF048
	DCPB	R12UF047,R12UF047,R12UF047,R12UF046,R12UF046,R12UF046
	DCPB	R12UF045,R12UF045,R12UF045,R12UF044,R12UF044,R12UF044
	DCPB	R12UF043,R12UF043,R12UF043,R12UF042,R12UF042,R12UF042
	DCPB	R12UF041,R12UF041,R12UF041,R12UF038,R12UF038,R12UF035
	DCPB	R12UF035,R12UF032,R12UF029,R12UF026,R12UF023,R12UF020
	DCPB	R12UF017,R12UF014,R12UF011,R12UF008,R12UF005,R12UF002

	DCPB	R12U002,R12U005,R12U008,R12U011,R12U014,R12U017
	DCPB	R12U020,R12U023,R12U026,R12U029,R12U032,R12U035
	DCPB	R12U035,R12U038,R12U038,R12U041,R12U041,R12U041
	DCPB	R12U042,R12U042,R12U042,R12U043,R12U043,R12U043
	DCPB	R12U044,R12U044,R12U044,R12U045,R12U045,R12U045
	DCPB	R12U046,R12U046,R12U046,R12U047,R12U047,R12U047
	DCPB	R12U048,R12U048,R12U048,R12U049,R12U049,R12U049
	DCPB	R12U050,R12U050,R12U050,R12U051,R12U051,R12U052

wdn6:	DCPB	R6DF052,R6DF051,R6DF051,R6DF050,R6DF050,R6DF050
	DCPB	R6DF049,R6DF049,R6DF049,R6DF048,R6DF048,R6DF048
	DCPB	R6DF047,R6DF047,R6DF047,R6DF046,R6DF046,R6DF046
	DCPB	R6DF045,R6DF045,R6DF045,R6DF044,R6DF044,R6DF044
	DCPB	R6DF043,R6DF043,R6DF043,R6DF042,R6DF042,R6DF042
	DCPB	R6DF040,R6DF040,R6DF040,R6DF037,R6DF037,R6DF034
	DCPB	R6DF034,R6DF031,R6DF028,R6DF025,R6DF022,R6DF019
	DCPB	R6DF016,R6DF013,R6DF010,R6DF007,R6DF004,R6DF001

	DCPB	R6D001,R6D004,R6D007,R6D010,R6D013,R6D016
	DCPB	R6D019,R6D022,R6D025,R6D028,R6D031,R6D034
	DCPB	R6D034,R6D037,R6D037,R6D040,R6D040,R6D040
	DCPB	R6D042,R6D042,R6D042,R6D043,R6D043,R6D043
	DCPB	R6D044,R6D044,R6D044,R6D045,R6D045,R6D045
	DCPB	R6D046,R6D046,R6D046,R6D047,R6D047,R6D047
	DCPB	R6D048,R6D048,R6D048,R6D049,R6D049,R6D049
	DCPB	R6D050,R6D050,R6D050,R6D051,R6D051,R6D052

wdn6l:	DCPB	R6DF052,R6DF051,R6DF051,R6DF050,R6DF050,R6DF050
	DCPB	R6DF049,R6DF049,R6DF049,R6DF048,R6DF048,R6DF048
	DCPB	R6DF047,R6DF047,R6DF047,R6DF046,R6DF046,R6DF046
	DCPB	R6DF045,R6DF045,R6DF045,R6DF044,R6DF044,R6DF044
	DCPB	R6DF043,R6DF043,R6DF043,R6DF042,R6DF042,R6DF042
	DCPB	R6DF041,R6DF041,R6DF041,R6DF038,R6DF038,R6DF035
	DCPB	R6DF035,R6DF032,R6DF029,R6DF026,R6DF023,R6DF020
	DCPB	R6DF017,R6DF014,R6DF011,R6DF008,R6DF005,R6DF002

	DCPB	R6D000,R6D003,R6D006,R6D009,R6D012,R6D015
	DCPB	R6D018,R6D021,R6D024,R6D027,R6D030,R6D033
	DCPB	R6D033,R6D036,R6D036,R6D039,R6D039,R6D039
	DCPB	R6D042,R6D042,R6D042,R6D043,R6D043,R6D043
	DCPB	R6D044,R6D044,R6D044,R6D045,R6D045,R6D045
	DCPB	R6D046,R6D046,R6D046,R6D047,R6D047,R6D047
	DCPB	R6D048,R6D048,R6D048,R6D049,R6D049,R6D049
	DCPB	R6D050,R6D050,R6D050,R6D051,R6D051,R6D052

wdn6r:	DCPB	R6DF052,R6DF051,R6DF051,R6DF050,R6DF050,R6DF050
	DCPB	R6DF049,R6DF049,R6DF049,R6DF048,R6DF048,R6DF048
	DCPB	R6DF047,R6DF047,R6DF047,R6DF046,R6DF046,R6DF046
	DCPB	R6DF045,R6DF045,R6DF045,R6DF044,R6DF044,R6DF044
	DCPB	R6DF043,R6DF043,R6DF043,R6DF042,R6DF042,R6DF042
	DCPB	R6DF039,R6DF039,R6DF039,R6DF036,R6DF036,R6DF033
	DCPB	R6DF033,R6DF030,R6DF027,R6DF024,R6DF021,R6DF018
	DCPB	R6DF015,R6DF012,R6DF009,R6DF006,R6DF003,R6DF000

	DCPB	R6D002,R6D005,R6D008,R6D011,R6D014,R6D017
	DCPB	R6D020,R6D023,R6D026,R6D029,R6D032,R6D035
	DCPB	R6D035,R6D038,R6D038,R6D041,R6D041,R6D041
	DCPB	R6D042,R6D042,R6D042,R6D043,R6D043,R6D043
	DCPB	R6D044,R6D044,R6D044,R6D045,R6D045,R6D045
	DCPB	R6D046,R6D046,R6D046,R6D047,R6D047,R6D047
	DCPB	R6D048,R6D048,R6D048,R6D049,R6D049,R6D049
	DCPB	R6D050,R6D050,R6D050,R6D051,R6D051,R6D052


wdn12:	DCPB	R12DF052,R12DF051,R12DF051,R12DF050,R12DF050,R12DF050
	DCPB	R12DF049,R12DF049,R12DF049,R12DF048,R12DF048,R12DF048
	DCPB	R12DF047,R12DF047,R12DF047,R12DF046,R12DF046,R12DF046
	DCPB	R12DF045,R12DF045,R12DF045,R12DF044,R12DF044,R12DF044
	DCPB	R12DF043,R12DF043,R12DF043,R12DF042,R12DF042,R12DF042
	DCPB	R12DF040,R12DF040,R12DF040,R12DF037,R12DF037,R12DF034
	DCPB	R12DF034,R12DF031,R12DF028,R12DF025,R12DF022,R12DF019
	DCPB	R12DF016,R12DF013,R12DF010,R12DF007,R12DF004,R12DF001

	DCPB	R12D001,R12D004,R12D007,R12D010,R12D013,R12D016
	DCPB	R12D019,R12D022,R12D025,R12D028,R12D031,R12D034
	DCPB	R12D034,R12D037,R12D037,R12D040,R12D040,R12D040
	DCPB	R12D042,R12D042,R12D042,R12D043,R12D043,R12D043
	DCPB	R12D044,R12D044,R12D044,R12D045,R12D045,R12D045
	DCPB	R12D046,R12D046,R12D046,R12D047,R12D047,R12D047
	DCPB	R12D048,R12D048,R12D048,R12D049,R12D049,R12D049
	DCPB	R12D050,R12D050,R12D050,R12D051,R12D051,R12D052

wdn12l:	DCPB	R12DF052,R12DF051,R12DF051,R12DF050,R12DF050,R12DF050
	DCPB	R12DF049,R12DF049,R12DF049,R12DF048,R12DF048,R12DF048
	DCPB	R12DF047,R12DF047,R12DF047,R12DF046,R12DF046,R12DF046
	DCPB	R12DF045,R12DF045,R12DF045,R12DF044,R12DF044,R12DF044
	DCPB	R12DF043,R12DF043,R12DF043,R12DF042,R12DF042,R12DF042
	DCPB	R12DF041,R12DF041,R12DF041,R12DF038,R12DF038,R12DF035
	DCPB	R12DF035,R12DF032,R12DF029,R12DF026,R12DF023,R12DF020
	DCPB	R12DF017,R12DF014,R12DF011,R12DF008,R12DF005,R12DF002

	DCPB	R12D000,R12D003,R12D006,R12D009,R12D012,R12D015
	DCPB	R12D018,R12D021,R12D024,R12D027,R12D030,R12D033
	DCPB	R12D033,R12D036,R12D036,R12D039,R12D039,R12D039
	DCPB	R12D042,R12D042,R12D042,R12D043,R12D043,R12D043
	DCPB	R12D044,R12D044,R12D044,R12D045,R12D045,R12D045
	DCPB	R12D046,R12D046,R12D046,R12D047,R12D047,R12D047
	DCPB	R12D048,R12D048,R12D048,R12D049,R12D049,R12D049
	DCPB	R12D050,R12D050,R12D050,R12D051,R12D051,R12D052

wdn12r:	DCPB	R12DF052,R12DF051,R12DF051,R12DF050,R12DF050,R12DF050
	DCPB	R12DF049,R12DF049,R12DF049,R12DF048,R12DF048,R12DF048
	DCPB	R12DF047,R12DF047,R12DF047,R12DF046,R12DF046,R12DF046
	DCPB	R12DF045,R12DF045,R12DF045,R12DF044,R12DF044,R12DF044
	DCPB	R12DF043,R12DF043,R12DF043,R12DF042,R12DF042,R12DF042
	DCPB	R12DF039,R12DF039,R12DF039,R12DF036,R12DF036,R12DF033
	DCPB	R12DF033,R12DF030,R12DF027,R12DF024,R12DF021,R12DF018
	DCPB	R12DF015,R12DF012,R12DF009,R12DF006,R12DF003,R12DF000

	DCPB	R12D002,R12D005,R12D008,R12D011,R12D014,R12D017
	DCPB	R12D020,R12D023,R12D026,R12D029,R12D032,R12D035
	DCPB	R12D035,R12D038,R12D038,R12D041,R12D041,R12D041
	DCPB	R12D042,R12D042,R12D042,R12D043,R12D043,R12D043
	DCPB	R12D044,R12D044,R12D044,R12D045,R12D045,R12D045
	DCPB	R12D046,R12D046,R12D046,R12D047,R12D047,R12D047
	DCPB	R12D048,R12D048,R12D048,R12D049,R12D049,R12D049
	DCPB	R12D050,R12D050,R12D050,R12D051,R12D051,R12D052

	PAGE
*
*	Car Bodys
*
body:	DCPB	BODF024,BODF023,BODF023,BODF022,BODF022,BODF022
	DCPB	BODF021,BODF021,BODF021,BODF020,BODF020,BODF020
	DCPB	BODF019,BODF019,BODF019,BODF018,BODF018,BODF018
	DCPB	BODF017,BODF017,BODF017,BODF016,BODF016,BODF016
	DCPB	BODF015,BODF015,BODF015,BODF014,BODF014,BODF014
	DCPB	BODF013,BODF013,BODF013,BODF012,BODF012,BODF011
	DCPB	BODF011,BODF010,BODF009,BODF008,BODF007,BODF006
	DCPB	BODF005,BODF004,BODF003,BODF002,BODF001,BODF000

	DCPB	BOD000,BOD001,BOD002,BOD003,BOD004,BOD005
	DCPB	BOD006,BOD007,BOD008,BOD009,BOD010,BOD011
	DCPB	BOD011,BOD012,BOD012,BOD013,BOD013,BOD013
	DCPB	BOD014,BOD014,BOD014,BOD015,BOD015,BOD015
	DCPB	BOD016,BOD016,BOD016,BOD017,BOD017,BOD017
	DCPB	BOD018,BOD018,BOD018,BOD019,BOD019,BOD019
	DCPB	BOD020,BOD020,BOD020,BOD021,BOD021,BOD021
	DCPB	BOD022,BOD022,BOD022,BOD023,BOD023,BOD024

bup6:	DCPB	B6UF024,B6UF023,B6UF023,B6UF022,B6UF022,B6UF022
	DCPB	B6UF021,B6UF021,B6UF021,B6UF020,B6UF020,B6UF020
	DCPB	B6UF019,B6UF019,B6UF019,B6UF018,B6UF018,B6UF018
	DCPB	B6UF017,B6UF017,B6UF017,B6UF016,B6UF016,B6UF016
	DCPB	B6UF015,B6UF015,B6UF015,B6UF014,B6UF014,B6UF014
	DCPB	B6UF013,B6UF013,B6UF013,B6UF012,B6UF012,B6UF011
	DCPB	B6UF011,B6UF010,B6UF009,B6UF008,B6UF007,B6UF006
	DCPB	B6UF005,B6UF004,B6UF003,B6UF002,B6UF001,B6UF000

	DCPB	B6U000,B6U001,B6U002,B6U003,B6U004,B6U005
	DCPB	B6U006,B6U007,B6U008,B6U009,B6U010,B6U011
	DCPB	B6U011,B6U012,B6U012,B6U013,B6U013,B6U013
	DCPB	B6U014,B6U014,B6U014,B6U015,B6U015,B6U015
	DCPB	B6U016,B6U016,B6U016,B6U017,B6U017,B6U017
	DCPB	B6U018,B6U018,B6U018,B6U019,B6U019,B6U019
	DCPB	B6U020,B6U020,B6U020,B6U021,B6U021,B6U021
	DCPB	B6U022,B6U022,B6U022,B6U023,B6U023,B6U024

bup12:	DCPB	B12UF024,B12UF023,B12UF023,B12UF022,B12UF022,B12UF022
	DCPB	B12UF021,B12UF021,B12UF021,B12UF020,B12UF020,B12UF020
	DCPB	B12UF019,B12UF019,B12UF019,B12UF018,B12UF018,B12UF018
	DCPB	B12UF017,B12UF017,B12UF017,B12UF016,B12UF016,B12UF016
	DCPB	B12UF015,B12UF015,B12UF015,B12UF014,B12UF014,B12UF014
	DCPB	B12UF013,B12UF013,B12UF013,B12UF012,B12UF012,B12UF011
	DCPB	B12UF011,B12UF010,B12UF009,B12UF008,B12UF007,B12UF006
	DCPB	B12UF005,B12UF004,B12UF003,B12UF002,B12UF001,B12UF000

	DCPB	B12U000,B12U001,B12U002,B12U003,B12U004,B12U005
	DCPB	B12U006,B12U007,B12U008,B12U009,B12U010,B12U011
	DCPB	B12U011,B12U012,B12U012,B12U013,B12U013,B12U013
	DCPB	B12U014,B12U014,B12U014,B12U015,B12U015,B12U015
	DCPB	B12U016,B12U016,B12U016,B12U017,B12U017,B12U017
	DCPB	B12U018,B12U018,B12U018,B12U019,B12U019,B12U019
	DCPB	B12U020,B12U020,B12U020,B12U021,B12U021,B12U021
	DCPB	B12U022,B12U022,B12U022,B12U023,B12U023,B12U024

bdn6:	DCPB	B6DF024,B6DF023,B6DF023,B6DF022,B6DF022,B6DF022
	DCPB	B6DF021,B6DF021,B6DF021,B6DF020,B6DF020,B6DF020
	DCPB	B6DF019,B6DF019,B6DF019,B6DF018,B6DF018,B6DF018
	DCPB	B6DF017,B6DF017,B6DF017,B6DF016,B6DF016,B6DF016
	DCPB	B6DF015,B6DF015,B6DF015,B6DF014,B6DF014,B6DF014
	DCPB	B6DF013,B6DF013,B6DF013,B6DF012,B6DF012,B6DF011
	DCPB	B6DF011,B6DF010,B6DF009,B6DF008,B6DF007,B6DF006
	DCPB	B6DF005,B6DF004,B6DF003,B6DF002,B6DF001,B6DF000

	DCPB	B6D000,B6D001,B6D002,B6D003,B6D004,B6D005
	DCPB	B6D006,B6D007,B6D008,B6D009,B6D010,B6D011
	DCPB	B6D011,B6D012,B6D012,B6D013,B6D013,B6D013
	DCPB	B6D014,B6D014,B6D014,B6D015,B6D015,B6D015
	DCPB	B6D016,B6D016,B6D016,B6D017,B6D017,B6D017
	DCPB	B6D018,B6D018,B6D018,B6D019,B6D019,B6D019
	DCPB	B6D020,B6D020,B6D020,B6D021,B6D021,B6D021
	DCPB	B6D022,B6D022,B6D022,B6D023,B6D023,B6D024

bdn12:	DCPB	B12DF024,B12DF023,B12DF023,B12DF022,B12DF022,B12DF022
	DCPB	B12DF021,B12DF021,B12DF021,B12DF020,B12DF020,B12DF020
	DCPB	B12DF019,B12DF019,B12DF019,B12DF018,B12DF018,B12DF018
	DCPB	B12DF017,B12DF017,B12DF017,B12DF016,B12DF016,B12DF016
	DCPB	B12DF015,B12DF015,B12DF015,B12DF014,B12DF014,B12DF014
	DCPB	B12DF013,B12DF013,B12DF013,B12DF012,B12DF012,B12DF011
	DCPB	B12DF011,B12DF010,B12DF009,B12DF008,B12DF007,B12DF006
	DCPB	B12DF005,B12DF004,B12DF003,B12DF002,B12DF001,B12DF000

	DCPB	B12D000,B12D001,B12D002,B12D003,B12D004,B12D005
	DCPB	B12D006,B12D007,B12D008,B12D009,B12D010,B12D011
	DCPB	B12D011,B12D012,B12D012,B12D013,B12D013,B12D013
	DCPB	B12D014,B12D014,B12D014,B12D015,B12D015,B12D015
	DCPB	B12D016,B12D016,B12D016,B12D017,B12D017,B12D017
	DCPB	B12D018,B12D018,B12D018,B12D019,B12D019,B12D019
	DCPB	B12D020,B12D020,B12D020,B12D021,B12D021,B12D021
	DCPB	B12D022,B12D022,B12D022,B12D023,B12D023,B12D024

	PAGE
*
*	Car Shadows
*
	XDEF	shds
shds:	DCPB	SHDF124,SHDF123,SHDF123,SHDF122,SHDF122,SHDF122
	DCPB	SHDF121,SHDF121,SHDF121,SHDF120,SHDF120,SHDF120
	DCPB	SHDF119,SHDF119,SHDF119,SHDF118,SHDF118,SHDF118
	DCPB	SHDF117,SHDF117,SHDF117,SHDF116,SHDF116,SHDF116
	DCPB	SHDF115,SHDF115,SHDF115,SHDF114,SHDF114,SHDF114
	DCPB	SHDF113,SHDF113,SHDF113,SHDF112,SHDF112,SHDF111
	DCPB	SHDF111,SHDF110,SHDF109,SHDF108,SHDF107,SHDF106
	DCPB	SHDF105,SHDF104,SHDF103,SHDF102,SHDF101,SHDF100

	DCPB	SHD100,SHD101,SHD102,SHD103,SHD104,SHD105
	DCPB	SHD106,SHD107,SHD108,SHD109,SHD110,SHD111
	DCPB	SHD111,SHD112,SHD112,SHD113,SHD113,SHD113
	DCPB	SHD114,SHD114,SHD114,SHD115,SHD115,SHD115
	DCPB	SHD116,SHD116,SHD116,SHD117,SHD117,SHD117
	DCPB	SHD118,SHD118,SHD118,SHD119,SHD119,SHD119
	DCPB	SHD120,SHD120,SHD120,SHD121,SHD121,SHD121
	DCPB	SHD122,SHD122,SHD122,SHD123,SHD123,SHD124

	PAGE
*
*	Rear view Drones
*
	XDEF	drn_tbl
drn_tbl:
	DCPB	LDRNF006,LDRNF006,LDRNF006,LDRNF005,LDRNF005,LDRNF005
	DCPB	LDRNF005,LDRNF005,LDRNF005,LDRNF004,LDRNF004,LDRNF004
	DCPB	LDRNF004,LDRNF004,LDRNF004,LDRNF004,LDRNF004,LDRNF004
	DCPB	LDRNF003,LDRNF003,LDRNF003,LDRNF003,LDRNF003,LDRNF003
	DCPB	LDRNF003,LDRNF003,LDRNF003,LDRNF002,LDRNF002,LDRNF002
	DCPB	LDRNF002,LDRNF002,LDRNF002,LDRNF002,LDRNF002,LDRNF001
	DCPB	LDRNF001,LDRNF001,LDRNF001,LDRNF001,LDRNF001,LDRNF000
	DCPB	LDRNF000,LDRNF000,LDRNF000,LDRNF000,LDRNF000,LDRNF000

	DCPB	LDRN000,LDRN000,LDRN000,LDRN000,LDRN000,LDRN000
	DCPB	LDRN000,LDRN001,LDRN001,LDRN001,LDRN001,LDRN001
	DCPB	LDRN001,LDRN002,LDRN002,LDRN002,LDRN002,LDRN002
	DCPB	LDRN002,LDRN002,LDRN002,LDRN003,LDRN003,LDRN003
	DCPB	LDRN003,LDRN003,LDRN003,LDRN003,LDRN003,LDRN003
	DCPB	LDRN004,LDRN004,LDRN004,LDRN004,LDRN004,LDRN004
	DCPB	LDRN004,LDRN004,LDRN004,LDRN005,LDRN005,LDRN005
	DCPB	LDRN005,LDRN005,LDRN005,LDRN006,LDRN006,LDRN006


	END
