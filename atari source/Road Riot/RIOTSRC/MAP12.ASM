
* File name = map12.intel

* Previously loaded at $71C0

	DC.B	$04,$A0,$22,$A0,$05,$40,$22,$A0,$05,$C0,$22,$A0,$06,$40,$22,$A0
	DC.B	$07,$00,$22,$A0,$07,$80,$22,$A0,$08,$00,$22,$A0,$08,$C0,$22,$60
	DC.B	$09,$80,$22,$20,$0A,$20,$21,$C0,$0A,$C0,$21,$60,$0B,$60,$21,$60
	DC.B	$0B,$C0,$21,$20,$0C,$00,$20,$C0,$0C,$40,$20,$40,$0C,$A0,$1F,$E0
	DC.B	$0C,$A0,$1F,$00,$0C,$A0,$1E,$60,$0C,$E0,$1D,$C0,$0C,$E0,$1D,$A0
	DC.B	$0D,$60,$1D,$20,$0D,$C0,$1C,$A0,$0E,$20,$1C,$A0,$0E,$80,$1C,$A0
	DC.B	$0F,$40,$1C,$A0,$0F,$A0,$1D,$20,$0F,$A0,$1D,$80,$0F,$A0,$1E,$00
	DC.B	$0F,$A0,$1E,$C0,$0F,$A0,$1F,$40,$0F,$A0,$1F,$C0,$0F,$E0,$20,$80
	DC.B	$10,$20,$21,$20,$10,$80,$21,$40,$10,$E0,$21,$A0,$11,$60,$21,$A0
	DC.B	$11,$C0,$21,$60,$12,$40,$21,$20,$12,$80,$20,$C0,$12,$80,$20,$80
	DC.B	$12,$E0,$1F,$E0,$12,$E0,$1F,$A0,$12,$E0,$1E,$E0,$12,$E0,$1E,$A0
	DC.B	$12,$E0,$1D,$E0,$12,$E0,$1D,$80,$12,$E0,$1D,$20,$12,$E0,$1C,$A0
	DC.B	$12,$E0,$1B,$E0,$12,$E0,$1B,$60,$12,$E0,$1A,$E0,$12,$E0,$1A,$60
	DC.B	$12,$E0,$19,$80,$12,$E0,$19,$00,$12,$E0,$18,$A0,$12,$E0,$18,$00
	DC.B	$12,$80,$17,$60,$12,$80,$16,$C0,$12,$80,$16,$00,$12,$60,$15,$80
	DC.B	$12,$00,$14,$E0,$12,$00,$14,$60,$11,$C0,$13,$E0,$11,$80,$13,$00
	DC.B	$11,$A0,$12,$40,$11,$40,$11,$C0,$11,$00,$11,$60,$10,$E0,$10,$C0
	DC.B	$10,$80,$10,$80,$10,$60,$10,$20,$10,$40,$0F,$C0,$0F,$C0,$0F,$40
	DC.B	$0F,$40,$0E,$C0,$0E,$E0,$0E,$A0,$0E,$60,$0E,$00,$0D,$C0,$0E,$00
	DC.B	$0D,$00,$0E,$00,$0C,$60,$0E,$40,$0B,$E0,$0E,$C0,$0B,$40,$0F,$60
	DC.B	$0B,$20,$10,$20,$0A,$E0,$10,$A0,$0A,$E0,$11,$00,$0B,$20,$11,$80
	DC.B	$0B,$80,$12,$40,$0C,$20,$12,$A0,$0C,$80,$12,$E0,$0D,$60,$12,$E0
	DC.B	$0E,$00,$13,$40,$0E,$E0,$13,$C0,$0F,$20,$14,$80,$0F,$20,$15,$00
	DC.B	$0F,$20,$15,$40,$0F,$20,$15,$C0,$0E,$C0,$16,$20,$0E,$80,$16,$A0
	DC.B	$0E,$40,$17,$00,$0D,$E0,$17,$A0,$0D,$40,$18,$20,$0C,$E0,$18,$80
	DC.B	$0C,$20,$19,$00,$0B,$C0,$19,$40,$0B,$40,$19,$C0,$0B,$40,$1A,$40
	DC.B	$0B,$40,$1A,$E0,$0B,$00,$1B,$60,$0A,$C0,$1B,$C0,$0A,$C0,$1C,$40
	DC.B	$0A,$80,$1D,$20,$0A,$60,$1D,$80,$0A,$20,$1E,$20,$09,$E0,$1E,$60
	DC.B	$09,$40,$1E,$80,$08,$E0,$1F,$20,$08,$40,$1F,$20,$07,$C0,$1F,$20
	DC.B	$07,$00,$1F,$20,$06,$A0,$1F,$20,$06,$20,$1E,$80,$05,$80,$1E,$40
	DC.B	$04,$C0,$1E,$40,$04,$20,$1E,$40,$03,$80,$1E,$E0,$03,$00,$1F,$80
	DC.B	$02,$C0,$20,$80,$02,$C0,$21,$20,$03,$00,$21,$C0,$03,$C0,$22,$60
