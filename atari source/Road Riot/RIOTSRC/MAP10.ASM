
* File name = map10.intel

* Previously loaded at $6D80

	DC.B	$0C,$00,$1C,$E0,$0C,$60,$1C,$A0,$0C,$E0,$1C,$00,$0D,$20,$1B,$C0
	DC.B	$0D,$60,$1B,$80,$0D,$C0,$1B,$20,$0E,$00,$1A,$C0,$0E,$00,$1A,$60
	DC.B	$0E,$00,$19,$C0,$0E,$20,$18,$80,$0D,$C0,$18,$20,$0D,$80,$17,$A0
	DC.B	$0D,$80,$17,$60,$0D,$80,$16,$C0,$0D,$C0,$16,$60,$0E,$20,$15,$E0
	DC.B	$0E,$40,$15,$60,$0E,$C0,$14,$C0,$0F,$60,$14,$60,$0F,$E0,$14,$20
	DC.B	$10,$40,$13,$A0,$10,$C0,$13,$20,$11,$00,$12,$E0,$11,$60,$12,$A0
	DC.B	$11,$80,$12,$40,$11,$C0,$12,$00,$12,$60,$11,$80,$12,$A0,$11,$20
	DC.B	$12,$A0,$10,$A0,$12,$A0,$10,$20,$12,$A0,$0F,$80,$12,$40,$0F,$20
	DC.B	$11,$E0,$0E,$60,$11,$00,$0D,$C0,$10,$40,$0D,$80,$10,$20,$0D,$A0
	DC.B	$0F,$E0,$0D,$80,$0F,$80,$0D,$A0,$0F,$20,$0D,$80,$0E,$C0,$0D,$E0
	DC.B	$0E,$60,$0E,$00,$0D,$C0,$0E,$A0,$0D,$80,$0F,$20,$0D,$40,$0F,$E0
	DC.B	$0D,$00,$10,$E0,$0D,$00,$11,$40,$0C,$C0,$11,$C0,$0C,$80,$12,$60
	DC.B	$0C,$80,$12,$C0,$0C,$40,$13,$60,$0C,$00,$13,$C0,$0B,$E0,$14,$40
	DC.B	$0B,$E0,$14,$80,$0B,$A0,$14,$E0,$0B,$A0,$15,$20,$0B,$40,$15,$A0
	DC.B	$0B,$20,$16,$00,$0A,$C0,$16,$C0,$0A,$A0,$17,$A0,$0A,$60,$18,$00
	DC.B	$0A,$60,$18,$80,$0A,$00,$18,$E0,$0A,$00,$19,$60,$09,$C0,$19,$80
	DC.B	$09,$C0,$1A,$00,$09,$40,$1A,$A0,$08,$E0,$1B,$20,$08,$A0,$1B,$00
	DC.B	$08,$60,$1B,$60,$08,$00,$1B,$60,$07,$C0,$1B,$20,$07,$40,$1A,$E0
	DC.B	$07,$40,$1A,$A0,$07,$20,$1A,$60,$07,$20,$1A,$20,$07,$00,$19,$C0
	DC.B	$06,$80,$19,$00,$05,$80,$18,$A0,$05,$20,$18,$E0,$04,$E0,$18,$C0
	DC.B	$04,$40,$19,$40,$04,$00,$1A,$40,$04,$00,$1B,$20,$04,$00,$1B,$80
	DC.B	$03,$C0,$1C,$20,$03,$C0,$1C,$80,$03,$C0,$1D,$00,$03,$80,$1D,$A0
	DC.B	$03,$A0,$1E,$00,$03,$60,$1E,$C0,$03,$00,$1F,$40,$03,$00,$1F,$C0
	DC.B	$02,$E0,$20,$00,$02,$E0,$20,$A0,$02,$E0,$21,$20,$02,$A0,$21,$80
	DC.B	$02,$A0,$22,$00,$02,$A0,$22,$A0,$02,$E0,$23,$00,$03,$00,$23,$60
	DC.B	$03,$40,$23,$E0,$03,$E0,$24,$60,$04,$20,$24,$60,$04,$C0,$24,$A0
	DC.B	$05,$A0,$24,$80,$06,$40,$24,$40,$06,$E0,$24,$00,$07,$40,$23,$60
	DC.B	$07,$80,$22,$E0,$07,$80,$22,$60,$07,$A0,$22,$00,$07,$80,$21,$A0
	DC.B	$07,$00,$20,$C0,$06,$80,$20,$00,$06,$E0,$1F,$C0,$06,$C0,$1F,$40
	DC.B	$06,$C0,$1E,$E0,$07,$60,$1E,$60,$07,$C0,$1E,$00,$08,$80,$1D,$E0
	DC.B	$09,$40,$1E,$20,$09,$E0,$1D,$C0,$0A,$40,$1D,$E0,$0A,$A0,$1D,$C0
	DC.B	$0B,$00,$1D,$A0,$0B,$80,$1D,$40,$0B,$C0,$1D,$60,$0C,$20,$1D,$00
