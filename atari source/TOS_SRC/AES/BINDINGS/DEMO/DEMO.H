/* Resource Datei Indizes f�r DEMO */

#define MENUBAR  0   /* Menuebaum */
#define GTITLE   5   /* TITLE in Baum MENUBAR */
#define ETITLE   6   /* TITLE in Baum MENUBAR */
#define ABOUTX   9   /* STRING in Baum MENUBAR */
#define FOPEN    18  /* STRING in Baum MENUBAR */
#define FCLOSE   19  /* STRING in Baum MENUBAR */
#define FQUIT    21  /* STRING in Baum MENUBAR */
#define STYLE    23  /* STRING in Baum MENUBAR */
#define POSITION 24  /* STRING in Baum MENUBAR */
#define FONTS1   26  /* STRING in Baum MENUBAR */
#define TABOUT   28  /* STRING in Baum MENUBAR */
#define TSUB     29  /* STRING in Baum MENUBAR */
#define TOOLFLAG 31  /* STRING in Baum MENUBAR */
#define SWITCH   32  /* STRING in Baum MENUBAR */
#define PHONE    34  /* STRING in Baum MENUBAR */
#define PATTERN1 35  /* STRING in Baum MENUBAR */
#define COLOR    36  /* STRING in Baum MENUBAR */
#define SLISTS   39  /* STRING in Baum MENUBAR */

#define FONTTREE 1   /* Formular/Dialog */

#define PTREE    2   /* Formular/Dialog */
#define P1       1   /* BOX in Baum PTREE */
#define P2       2   /* BOX in Baum PTREE */
#define P3       3   /* BOX in Baum PTREE */
#define P4       4   /* BOX in Baum PTREE */
#define P5       5   /* BOX in Baum PTREE */
#define P6       6   /* BOX in Baum PTREE */
#define P7       7   /* BOX in Baum PTREE */
#define P8       8   /* BOX in Baum PTREE */

#define CTREE    3   /* Formular/Dialog */

#define POSTREE  4   /* Formular/Dialog */

#define STREE    5   /* Formular/Dialog */

#define MTREE    6   /* Formular/Dialog */
#define M1TITLE  1   /* TEXT in Baum MTREE */
#define M1BUTTON 2   /* BOXTEXT in Baum MTREE */
#define M2TITLE  3   /* TEXT in Baum MTREE */
#define M2BUTTON 4   /* BOXTEXT in Baum MTREE */
#define M3TITLE  5   /* TEXT in Baum MTREE */
#define M3BUTTON 6   /* BOXTEXT in Baum MTREE */
#define M4TITLE  7   /* TEXT in Baum MTREE */
#define M4BUTTON 8   /* BOXTEXT in Baum MTREE */
#define M5TITLE  9   /* TEXT in Baum MTREE */
#define M5BUTTON 10  /* BOXTEXT in Baum MTREE */
#define M6TITLE  11  /* TEXT in Baum MTREE */
#define M6BUTTON 12  /* BOXTEXT in Baum MTREE */
#define MOK      13  /* BUTTON in Baum MTREE */

#define BAUDRATE 7   /* Formular/Dialog */

#define PARTREE  8   /* Formular/Dialog */

#define BITTREE  9   /* Formular/Dialog */

#define STOPTREE 10  /* Formular/Dialog */

#define PORTTREE 11  /* Formular/Dialog */

#define FLOWTREE 12  /* Formular/Dialog */

#define ATREE    13  /* Formular/Dialog */
#define AEXIT    1   /* BUTTON in Baum ATREE */

#define LTREE    14  /* Formular/Dialog */
#define LTITLE   3   /* TEXT in Baum LTREE */
#define LBUTTON  4   /* BOXTEXT in Baum LTREE */
#define LHOT     5   /* BOXCHAR in Baum LTREE */
#define LOK      6   /* BUTTON in Baum LTREE */

#define TOOLBOX  15  /* Formular/Dialog */
#define B1B1     1   /* BOX in Baum TOOLBOX */
#define B1B2     4   /* BOX in Baum TOOLBOX */
#define B1B3     7   /* BOX in Baum TOOLBOX */
#define B1B4     10  /* BOX in Baum TOOLBOX */
#define B1B5     13  /* BOX in Baum TOOLBOX */
#define T1B1     16  /* IBOX in Baum TOOLBOX */
#define T1B2     17  /* IBOX in Baum TOOLBOX */
#define T1B3     18  /* IBOX in Baum TOOLBOX */
#define T1B4     19  /* IBOX in Baum TOOLBOX */
#define T1B5     20  /* IBOX in Baum TOOLBOX */

#define BLANK    16  /* Formular/Dialog */

#define TOOLBOX2 17  /* Formular/Dialog */
#define T2B1     1   /* BOX in Baum TOOLBOX2 */
#define T2B2     4   /* BOX in Baum TOOLBOX2 */
#define T2B3     7   /* BOX in Baum TOOLBOX2 */
#define T2B4     10  /* BOX in Baum TOOLBOX2 */
#define T2B5     13  /* BOX in Baum TOOLBOX2 */
#define BASE1    16  /* BOX in Baum TOOLBOX2 */
#define BASE2    17  /* BOX in Baum TOOLBOX2 */
#define T2I1     19  /* IBOX in Baum TOOLBOX2 */
#define T2I2     20  /* IBOX in Baum TOOLBOX2 */
#define T2I3     21  /* IBOX in Baum TOOLBOX2 */
#define T2I4     22  /* IBOX in Baum TOOLBOX2 */
#define T2I5     23  /* IBOX in Baum TOOLBOX2 */

#define TOOLBAR  18  /* Formular/Dialog */
#define T3BASE1  1   /* BOX in Baum TOOLBAR */
#define T3BASE2  46  /* BOX in Baum TOOLBAR */
#define FBUTT1   55  /* BOXTEXT in Baum TOOLBAR */
#define FBUTT2   56  /* BOXCHAR in Baum TOOLBAR */

#define FONT2    19  /* Formular/Dialog */
#define F2MENU   1   /* BOX in Baum FONT2 */
