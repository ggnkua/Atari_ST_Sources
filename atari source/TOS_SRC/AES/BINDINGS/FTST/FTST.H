/* Resource Datei Indizes f�r FTST */

#define BOX      0   /* Formular/Dialog */
#define TEXT0    1   /* BOXTEXT in Baum BOX */
#define TEXT2    2   /* TEXT in Baum BOX */
#define TEXT1    3   /* TEXT in Baum BOX */
#define STRING   4   /* STRING in Baum BOX */
#define FTEXT1   5   /* FTEXT in Baum BOX */
#define FTEXT2   6   /* FBOXTEXT in Baum BOX */
#define FTEXT4   7   /* FTEXT in Baum BOX */
#define FTEXT3   8   /* FTEXT in Baum BOX */
#define TEXT4    9   /* TEXT in Baum BOX */
#define OKBUTTON 10  /* BUTTON in Baum BOX */
#define SMFTEXT  11  /* FTEXT in Baum BOX */
