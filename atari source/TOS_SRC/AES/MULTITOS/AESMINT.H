/*	AESMINT.H		7/15/91 - 9/10/91	D.Mui		*/

#ifndef _AESMINT_H_
#define _AESMINT_H_

EXTERN	LONG	trap();

#define	Syield()		trap(0xff)
#define Fpipe(ptr)		trap(0x100, ptr)
#define Fcntl(f, arg, cmd)	trap(0x104, f, arg, cmd)
#define Finstat(f)		trap(0x105, f)
#define Foutstat(f)		trap(0x106, f)
#define Fgetchar(f, mode)	trap(0x107, f, mode)
#define Fputchar(f, ch, mode)	trap(0x108, f, ch, mode)
#define Pwait()			trap(0x109)
#define Snice(delta)		trap(0x10a, delta)
#define Pgetpid()		trap(0x10b)
#define Pgetppid()		trap(0x10c)
#define Pgetpgrp()		trap(0x10d)
#define Psetpgrp(pid, grp)	trap(0x10e, pid, grp)
#define Pgetuid()		trap(0x10f)
#define Psetuid(id)		trap(0x110, id)
#define Pkill(pid, sig)		trap(0x111, pid, sig)
#define Psignal(sig, handler)	trap(0x112, sig, handler)
#define Pvfork()		trap(0x113)
#define Pgetgid()		trap(0x114)
#define Psetgid(id)		trap(0x115, id)
#define Psigblock(mask)		trap(0x116, mask)
#define Psigsetmask(mask)	trap(0x117, mask)
#define Pusrval(arg)		trap(0x118, arg)
#define Pdomain(arg)		trap(0x119, arg)
#define Psigreturn()		trap(0x11a)
#define Pfork()			trap(0x11b)
#define Pwait3(flag, rusage)	trap(0x11c, flag, rusage)
#define Fselect(time, rfd, wfd, xfd)	trap(0x11d, time, rfd, wfd, xfd)
#define Prusage(rsp)		trap(0x11e, rsp)
#define Psetlimit(i, val)	trap(0x11f, i, val)
#define Talarm(sec)		trap(0x120, sec)
#define Pause()			trap(0x121)
#define Sysconf(n)		trap(0x122, n)
#define Psigpending()		trap(0x123)
#define Dpathconf(name, which)	trap(0x124, name, which)
#define Pmsg(a,b,c)		trap(0x125,a,b,c)
#define Prenice(id,value)	trap(0x127,id,value)
#define Psemaphore(mode,id,timeout) trap(0x134,mode,id,timeout)
#define Dos_tab()		trap(-1)
#define Bios_tab()		bios(-1)
#define Xbios_tab()		xbios(-1)

#endif
