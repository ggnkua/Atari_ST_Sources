#define FRONT 0  	/* TREE */
#define DEVICE 1  	/* TREE */
#define FEXIT 19  	/* OBJECT in TREE #0 */
#define FSAVE 20  	/* OBJECT in TREE #0 */
#define FREMOVE 17  	/* OBJECT in TREE #0 */
#define FCONFIG 21  	/* OBJECT in TREE #0 */
#define FCUSTOM 18  	/* OBJECT in TREE #0 */
#define DMENU 83  	/* OBJECT in TREE #1 */
#define DADD 80  	/* OBJECT in TREE #1 */
#define DMODIFY 81  	/* OBJECT in TREE #1 */
#define DDELETE 82  	/* OBJECT in TREE #1 */
#define FQUALITY 23  	/* OBJECT in TREE #0 */
#define FPRINTER 2  	/* OBJECT in TREE #0 */
#define FDRAFT 24  	/* OBJECT in TREE #0 */
#define FFINAL 25  	/* OBJECT in TREE #0 */
#define SCAN 2  	/* TREE */
#define FUP 4  	/* OBJECT in TREE #0 */
#define FDOWN 5  	/* OBJECT in TREE #0 */
#define FBASE 6  	/* OBJECT in TREE #0 */
#define FSLIDER 7  	/* OBJECT in TREE #0 */
#define LINEBASE 8  	/* OBJECT in TREE #0 */
#define LINE0 9  	/* OBJECT in TREE #0 */
#define LINE1 10  	/* OBJECT in TREE #0 */
#define LINE2 11  	/* OBJECT in TREE #0 */
#define LINE3 12  	/* OBJECT in TREE #0 */
#define LINE4 13  	/* OBJECT in TREE #0 */
#define LINE5 14  	/* OBJECT in TREE #0 */
#define LINE6 15  	/* OBJECT in TREE #0 */
#define LINE7 16  	/* OBJECT in TREE #0 */
#define FTITLE 3  	/* OBJECT in TREE #0 */
#define FTITLE1 1  	/* OBJECT in TREE #0 */
#define FBOX1 22  	/* OBJECT in TREE #0 */
#define DRIVER 3  	/* TREE */
#define DOK 19  	/* OBJECT in TREE #3 */
#define DCANCEL 20  	/* OBJECT in TREE #3 */
#define DPRINT 3  	/* OBJECT in TREE #3 */
#define DPAGE 4  	/* OBJECT in TREE #3 */
#define DCOLOR 7  	/* OBJECT in TREE #3 */
#define DPORT 9  	/* OBJECT in TREE #3 */
#define DTRAY 11  	/* OBJECT in TREE #3 */
#define DDRIVER 1  	/* OBJECT in TREE #3 */
#define QTITLE 2  	/* OBJECT in TREE #3 */
#define STITLE 5  	/* OBJECT in TREE #3 */
#define CTITLE 6  	/* OBJECT in TREE #3 */
#define PTITLE 8  	/* OBJECT in TREE #3 */
#define TTITLE 10  	/* OBJECT in TREE #3 */
#define DHSIZE 13  	/* OBJECT in TREE #3 */
#define DVSIZE 15  	/* OBJECT in TREE #3 */
#define HTITLE 12  	/* OBJECT in TREE #3 */
#define VTITLE 14  	/* OBJECT in TREE #3 */
#define XYREZ 4  	/* TREE */
#define XYOK 6  	/* OBJECT in TREE #4 */
#define XYCANCEL 7  	/* OBJECT in TREE #4 */
#define SETX 4  	/* OBJECT in TREE #4 */
#define SETY 5  	/* OBJECT in TREE #4 */
#define XYUNITS 2  	/* OBJECT in TREE #4 */
#define DUP 76  	/* OBJECT in TREE #1 */
#define DBASE 77  	/* OBJECT in TREE #1 */
#define DSLIDE 78  	/* OBJECT in TREE #1 */
#define DDOWN 79  	/* OBJECT in TREE #1 */
#define DLINE 3  	/* OBJECT in TREE #1 */
#define DLINE0 4  	/* OBJECT in TREE #1 */
#define DLINE1 10  	/* OBJECT in TREE #1 */
#define DLINE2 16  	/* OBJECT in TREE #1 */
#define DLINE3 22  	/* OBJECT in TREE #1 */
#define DLINE4 28  	/* OBJECT in TREE #1 */
#define DLINE5 34  	/* OBJECT in TREE #1 */
#define DLINE6 40  	/* OBJECT in TREE #1 */
#define DLINE7 46  	/* OBJECT in TREE #1 */
#define DLINE8 52  	/* OBJECT in TREE #1 */
#define DLINE9 58  	/* OBJECT in TREE #1 */
#define DLINE10 64  	/* OBJECT in TREE #1 */
#define DLINE11 70  	/* OBJECT in TREE #1 */
#define DNUM0 5  	/* OBJECT in TREE #1 */
#define DNUM1 11  	/* OBJECT in TREE #1 */
#define DNUM2 17  	/* OBJECT in TREE #1 */
#define DNUM3 23  	/* OBJECT in TREE #1 */
#define DNUM4 29  	/* OBJECT in TREE #1 */
#define DNUM5 35  	/* OBJECT in TREE #1 */
#define DNUM6 41  	/* OBJECT in TREE #1 */
#define DNUM7 47  	/* OBJECT in TREE #1 */
#define DNUM8 53  	/* OBJECT in TREE #1 */
#define DNUM9 59  	/* OBJECT in TREE #1 */
#define DNUM10 65  	/* OBJECT in TREE #1 */
#define DNUM11 71  	/* OBJECT in TREE #1 */
#define DNAME0 6  	/* OBJECT in TREE #1 */
#define DNAME1 12  	/* OBJECT in TREE #1 */
#define DNAME2 18  	/* OBJECT in TREE #1 */
#define DNAME3 24  	/* OBJECT in TREE #1 */
#define DNAME4 30  	/* OBJECT in TREE #1 */
#define DNAME5 36  	/* OBJECT in TREE #1 */
#define DNAME6 42  	/* OBJECT in TREE #1 */
#define DNAME7 48  	/* OBJECT in TREE #1 */
#define DNAME8 54  	/* OBJECT in TREE #1 */
#define DNAME9 60  	/* OBJECT in TREE #1 */
#define DNAME10 66  	/* OBJECT in TREE #1 */
#define DNAME11 72  	/* OBJECT in TREE #1 */
#define DROM0 7  	/* OBJECT in TREE #1 */
#define DROM1 13  	/* OBJECT in TREE #1 */
#define DROM2 19  	/* OBJECT in TREE #1 */
#define DROM3 25  	/* OBJECT in TREE #1 */
#define DROM4 31  	/* OBJECT in TREE #1 */
#define DROM5 37  	/* OBJECT in TREE #1 */
#define DROM6 43  	/* OBJECT in TREE #1 */
#define DROM7 49  	/* OBJECT in TREE #1 */
#define DROM8 55  	/* OBJECT in TREE #1 */
#define DROM9 61  	/* OBJECT in TREE #1 */
#define DROM10 67  	/* OBJECT in TREE #1 */
#define DROM11 73  	/* OBJECT in TREE #1 */
#define DRES0 8  	/* OBJECT in TREE #1 */
#define DRES1 14  	/* OBJECT in TREE #1 */
#define DRES2 20  	/* OBJECT in TREE #1 */
#define DRES3 26  	/* OBJECT in TREE #1 */
#define DRES4 32  	/* OBJECT in TREE #1 */
#define DRES5 38  	/* OBJECT in TREE #1 */
#define DRES6 44  	/* OBJECT in TREE #1 */
#define DRES7 50  	/* OBJECT in TREE #1 */
#define DRES8 56  	/* OBJECT in TREE #1 */
#define DRES9 62  	/* OBJECT in TREE #1 */
#define DRES10 68  	/* OBJECT in TREE #1 */
#define DRES11 74  	/* OBJECT in TREE #1 */
#define DCOVER0 9  	/* OBJECT in TREE #1 */
#define DCOVER1 15  	/* OBJECT in TREE #1 */
#define DCOVER2 21  	/* OBJECT in TREE #1 */
#define DCOVER3 27  	/* OBJECT in TREE #1 */
#define DCOVER4 33  	/* OBJECT in TREE #1 */
#define DCOVER5 39  	/* OBJECT in TREE #1 */
#define DCOVER6 45  	/* OBJECT in TREE #1 */
#define DCOVER7 51  	/* OBJECT in TREE #1 */
#define DCOVER8 57  	/* OBJECT in TREE #1 */
#define DCOVER9 63  	/* OBJECT in TREE #1 */
#define DCOVER10 69  	/* OBJECT in TREE #1 */
#define DCOVER11 75  	/* OBJECT in TREE #1 */
#define FSETPATH 26  	/* OBJECT in TREE #0 */
#define FONTPATH 5  	/* TREE */
#define POK 9  	/* OBJECT in TREE #5 */
#define PCANCEL 10  	/* OBJECT in TREE #5 */
#define PLEFT 6  	/* OBJECT in TREE #5 */
#define PRIGHT 8  	/* OBJECT in TREE #5 */
#define PPATH 7  	/* OBJECT in TREE #5 */
#define MODIFY 6  	/* TREE */
#define MOK 18  	/* OBJECT in TREE #6 */
#define MCANCEL 19  	/* OBJECT in TREE #6 */
#define MUP 4  	/* OBJECT in TREE #6 */
#define MDOWN 5  	/* OBJECT in TREE #6 */
#define MEDIT 6  	/* OBJECT in TREE #6 */
#define MNAME 9  	/* OBJECT in TREE #6 */
#define MROMYES 16  	/* OBJECT in TREE #6 */
#define MROMNO 17  	/* OBJECT in TREE #6 */
#define MRESYES 12  	/* OBJECT in TREE #6 */
#define MRESNO 13  	/* OBJECT in TREE #6 */
#define ROMBASE 15  	/* OBJECT in TREE #6 */
#define RESBASE 11  	/* OBJECT in TREE #6 */
#define MTITLE 1  	/* OBJECT in TREE #6 */
#define ROMTITLE 14  	/* OBJECT in TREE #6 */
#define DTITLE 1  	/* OBJECT in TREE #1 */
#define DTITLE2 2  	/* OBJECT in TREE #1 */
#define PTITLE1 1  	/* OBJECT in TREE #5 */
#define PTITLE2 3  	/* OBJECT in TREE #5 */
#define PTITLE3 4  	/* OBJECT in TREE #5 */
#define AREAON 17  	/* OBJECT in TREE #3 */
#define AREAOFF 18  	/* OBJECT in TREE #3 */
