void	DoCache( void );
int	HandleCache( int button, WORD *msg );
void	Get_Default_Cache( void );
