int	parse_extend( int skip );
void	skipequal( void );
int     isdir( struct stat *s );
int	GetSYSPath( char *sysfile, char *path );


extern struct stat statbuf;

