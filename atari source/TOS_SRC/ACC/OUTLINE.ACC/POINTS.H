int	DoPoints( OBJECT *xtree, int obj );
int	HandlePoints( int button, WORD *msg );

void	DoAdd( void );
int	HandleAdd( int button, WORD *msg );
