void	DoCustom( void );
int	HandleCustom( int button, WORD *msg );

extern FON_PTR AList, IList;
