/* COUNTRY.H
 *==========================================================================
 * DATE: JULY 11, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */
#define TRUE	1
#define FALSE 	0
 
#define USA	TRUE	/* USA and UK USE THE SAME RSC BUT */
#define UK	FALSE	/* NEEDS SEPARATE RUNTIME CODE	   */
		
#define GERMAN	FALSE
#define FRENCH	FALSE
