/*==========================================================================
 * FILE: TEXT.H
 *==========================================================================
 * DATE: January 17, 1991
 *       September 11, 1991
 *	 June 7, 1993   Added SetTitle14[]
 *
 * DESCRIPTION: Country Specific Text Strings
 * COMPILER: TURBO C Version 2.0
 */
 
extern char menu_title[];
extern char alert13[];
extern char window_title[];
extern char alert4[];
extern char alert5[];
extern char etitle1[];

extern char *cache_text[];
extern char alert17[];
extern char alert18[];
extern char alert19[];
extern char alert21[];
extern char alert22[];




extern char driver_null[];


/* EDIT.C */
extern char alert1[];
extern char alert2[];

/* FSMIO.C */
extern char alert3[];
extern char alert6[];
extern char alert7[];
/*extern char alert8[];*/

extern char data_null[];
extern char *page_data[];
extern char rez_map[];
extern char rez_map2[];
extern char dpi_map[];


/* INACTIVE.C */
extern char alert10[];
extern char alert12[];


extern char head1[];
extern char head2[];
extern char head3[];

extern char alert50[];
extern char alert51[];
extern char alert52[];
extern char alert53[];
extern char alert54[];

extern char *print_text[];
extern char *size_text[];
extern char *rez_text[];
extern char *color_text[];
extern char *port_text[];
extern char *tray_text[];
extern char rez_width[];
extern char rez_height[];
extern char rez2_width[];
extern char rez2_height[];
extern char xy1_unit[];
extern char xy2_unit[];

extern char NoDrivers[];
extern char YesDrivers[];

extern char wider[];
extern char dtext[];
extern char modtext[];
extern char addtext[];
extern char alert55[];
extern char alert56[];
extern char alert57[];
extern char NonSpeedo[];
extern char alert58[];
extern char otitle1[];
extern char otitle2[];
extern char alertw3[];
extern char alerte11[];
extern char alertw16[];
extern char alertw4[];
extern char alertw5[];
extern char msg1[];
extern char alertp1[];
extern char alertc1[];
extern char alertc2[];
extern char alertf6[];
extern char pnt_title1[];
extern char pnt_title2[];
extern char pnt_title3[];
extern char pnt_title4[];
extern char pnt_title5[];
extern char pnt1[];
extern char alertdel[];
extern char alertpnt14[];
extern char alertpnt15[];
extern char alertpnt20[];
extern char alertpnt23[];
extern char point_invalid[];
extern char point_exists[];
extern char point_noroom[];
extern char alertc7[];
extern char nomore[];
extern char showall[];
extern char selall[];
extern char nosel[];
extern char nofile[];

extern char SetTitle00[];
extern char SetTitle01[];
extern char SetTitle02[];
extern char SetTitle11[];
extern char SetTitle12[];
extern char SetTitle13[];
extern char SetTitlexx[];
extern char SetTitle14[];
