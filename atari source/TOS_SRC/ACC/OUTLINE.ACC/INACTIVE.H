void	DoAvailable( void );
int	HandleAvailable( int button, WORD *msg );
void	SelectAllUnusedFonts( void );
void	MoveToInstalled( int flag );
void	CheckSelectAll( int draw );
