/* PROTOTYPES
 * ================================================================
 */
void initialize( void );
void DoInstall( void );
void DoInsert( char *ptr, char DriveNum );
void ProcessFile( char *full_path );
