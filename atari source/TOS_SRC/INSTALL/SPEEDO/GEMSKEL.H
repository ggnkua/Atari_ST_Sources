extern GRECT gl_full;
extern GRECT gl_screen;
extern int   num_pens;

extern GRECT gl_work;
extern GRECT gl_curr;
extern int   AES_Version;

void Gem_Exit( int num );

