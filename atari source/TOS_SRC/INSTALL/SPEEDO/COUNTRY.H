/* COUNTRY.H
 *==========================================================================
 * DATE: December 12, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */

#define USA		1
#define UK		0
#define GERMAN	0
#define FRENCH	0



