int	fonts_dialog( void );
