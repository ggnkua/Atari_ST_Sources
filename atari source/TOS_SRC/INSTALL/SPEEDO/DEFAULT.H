// Default.h
#define FSPACE	3000000L		/* 3 Megs for fonts */
#define DSPACE	1000000L		/* 1 Meg for drivers */

