#define COPY 0  	/* TREE - DIALOG */
#define INTRO 1  	/* TREE - DIALOG */
#define DPATH 2  	/* TREE - DIALOG */
#define EEXTEND 3  	/* TREE - DIALOG */
#define DRIVERS 4  	/* TREE - DIALOG */
#define FONTS 5  	/* TREE - DIALOG */
#define APPS 6  	/* TREE - DIALOG */
#define SUBMENU 7  	/* TREE - DIALOG */
#define INSERT 8  	/* TREE - DIALOG */
#define COMMENCE 9  	/* TREE - DIALOG */
#define EPATH 10  	/* TREE - DIALOG */
#define EASSIGN 11  	/* TREE - DIALOG */
#define COMPLETE 12  	/* TREE - DIALOG */
#define GDOSTST 13  	/* TREE - DIALOG */
#define CFNAME 2  	/* G_STRING in (#0) COPY */
#define XSETUP 5  	/* G_BUTTON in (#1) INTRO */
#define XEXIT 6  	/* G_BUTTON in (#1) INTRO */
#define PPATH 7  	/* G_FBOXTEXT in (#2) DPATH */
#define PSETUP 9  	/* G_BUTTON in (#2) DPATH */
#define PEXIT 10  	/* G_BUTTON in (#2) DPATH */
#define E1 7  	/* G_BOX in (#3) EEXTEND */
#define E2 8  	/* G_BOX in (#3) EEXTEND */
#define E3 9  	/* G_BOX in (#3) EEXTEND */
#define F3 10  	/* G_IBOX in (#3) EEXTEND */
#define F1 13  	/* G_IBOX in (#3) EEXTEND */
#define F2 15  	/* G_IBOX in (#3) EEXTEND */
#define EOK 16  	/* G_BUTTON in (#3) EEXTEND */
#define EEXIT 17  	/* G_BUTTON in (#3) EEXTEND */
#define PTITLE 5  	/* G_TEXT in (#4) DRIVERS */
#define PBUTTON 6  	/* G_BUTTON in (#4) DRIVERS */
#define DSETUP 7  	/* G_BUTTON in (#4) DRIVERS */
#define DEXIT 8  	/* G_BUTTON in (#4) DRIVERS */
#define FFSM 5  	/* G_STRING in (#5) FONTS */
#define FSCREEN 6  	/* G_STRING in (#5) FONTS */
#define FSCREEN2 7  	/* G_BOX in (#5) FONTS */
#define FNB 8  	/* G_STRING in (#5) FONTS */
#define FNB2 9  	/* G_BOX in (#5) FONTS */
#define FFSM2 10  	/* G_BOX in (#5) FONTS */
#define FSLM 11  	/* G_STRING in (#5) FONTS */
#define FFX 12  	/* G_STRING in (#5) FONTS */
#define FSLM2 13  	/* G_BOX in (#5) FONTS */
#define FFX2 14  	/* G_BOX in (#5) FONTS */
#define FSETUP 15  	/* G_BUTTON in (#5) FONTS */
#define FEXIT 16  	/* G_BUTTON in (#5) FONTS */
#define ACPX 5  	/* G_STRING in (#6) APPS */
#define ACPX2 6  	/* G_BOX in (#6) APPS */
#define AACC 7  	/* G_STRING in (#6) APPS */
#define AACC2 8  	/* G_BOX in (#6) APPS */
#define APAGE 9  	/* G_STRING in (#6) APPS */
#define APAGE2 10  	/* G_BOX in (#6) APPS */
#define ASETUP 11  	/* G_BUTTON in (#6) APPS */
#define AEXIT 12  	/* G_BUTTON in (#6) APPS */
#define SNONE 1  	/* G_STRING in (#7) SUBMENU */
#define SLAST 16  	/* G_STRING in (#7) SUBMENU */
#define ITITLE1 3  	/* G_STRING in (#8) INSERT */
#define ITITLE2 4  	/* G_STRING in (#8) INSERT */
#define IINSERT 5  	/* G_BUTTON in (#8) INSERT */
#define IEXIT 6  	/* G_BUTTON in (#8) INSERT */
#define ZSETUP 6  	/* G_BUTTON in (#9) COMMENCE */
#define ZEXIT 7  	/* G_BUTTON in (#9) COMMENCE */
#define EPATHS 7  	/* G_FBOXTEXT in (#10) EPATH */
#define EOK2 9  	/* G_BUTTON in (#10) EPATH */
#define EEXIT2 10  	/* G_BUTTON in (#10) EPATH */
#define A1 8  	/* G_BOX in (#11) EASSIGN */
#define A2 9  	/* G_BOX in (#11) EASSIGN */
#define A3 10  	/* G_BOX in (#11) EASSIGN */
#define B3 11  	/* G_IBOX in (#11) EASSIGN */
#define B1 13  	/* G_IBOX in (#11) EASSIGN */
#define B2 15  	/* G_IBOX in (#11) EASSIGN */
#define EASETUP 16  	/* G_BUTTON in (#11) EASSIGN */
#define EAEXIT 17  	/* G_BUTTON in (#11) EASSIGN */
#define CEXIT 1  	/* G_BUTTON in (#12) COMPLETE */
#define GEXIT 8  	/* G_BUTTON in (#13) GDOSTST */
