/* Resource File indices for FRANCE */

#define COPY     0   /* Dialog */
#define CFNAME   2   /* STRING in Tree COPY */

#define INTRO    1   /* Dialog */
#define XSETUP   5   /* BUTTON in Tree INTRO */
#define XEXIT    6   /* BUTTON in Tree INTRO */

#define DPATH    2   /* Dialog */
#define PPATH    7   /* FBOXTEXT in Tree DPATH */
#define PSETUP   9   /* BUTTON in Tree DPATH */
#define PEXIT    10  /* BUTTON in Tree DPATH */

#define EEXTEND  3   /* Dialog */
#define E1       8   /* BOX in Tree EEXTEND */
#define E2       9   /* BOX in Tree EEXTEND */
#define E3       10  /* BOX in Tree EEXTEND */
#define F1       11  /* IBOX in Tree EEXTEND */
#define F2       12  /* IBOX in Tree EEXTEND */
#define F3       13  /* IBOX in Tree EEXTEND */
#define EOK      15  /* BUTTON in Tree EEXTEND */
#define EEXIT    16  /* BUTTON in Tree EEXTEND */

#define DRIVERS  4   /* Dialog */
#define PTITLE   5   /* TEXT in Tree DRIVERS */
#define PBUTTON  6   /* BUTTON in Tree DRIVERS */
#define DSETUP   7   /* BUTTON in Tree DRIVERS */
#define DEXIT    8   /* BUTTON in Tree DRIVERS */

#define FONTS    5   /* Dialog */
#define FFSM     5   /* STRING in Tree FONTS */
#define FSCREEN  6   /* STRING in Tree FONTS */
#define FSCREEN2 7   /* BOX in Tree FONTS */
#define FNB      8   /* STRING in Tree FONTS */
#define FNB2     9   /* BOX in Tree FONTS */
#define FFSM2    10  /* BOX in Tree FONTS */
#define FSLM     11  /* STRING in Tree FONTS */
#define FFX      12  /* STRING in Tree FONTS */
#define FSLM2    13  /* BOX in Tree FONTS */
#define FFX2     14  /* BOX in Tree FONTS */
#define FSETUP   15  /* BUTTON in Tree FONTS */
#define FEXIT    16  /* BUTTON in Tree FONTS */

#define APPS     6   /* Dialog */
#define ACPX     5   /* STRING in Tree APPS */
#define ACPX2    6   /* BOX in Tree APPS */
#define AACC     7   /* STRING in Tree APPS */
#define AACC2    8   /* BOX in Tree APPS */
#define APAGE    9   /* STRING in Tree APPS */
#define APAGE2   10  /* BOX in Tree APPS */
#define ASETUP   11  /* BUTTON in Tree APPS */
#define AEXIT    12  /* BUTTON in Tree APPS */

#define SUBMENU  7   /* Dialog */
#define SNONE    1   /* STRING in Tree SUBMENU */
#define SLAST    16  /* STRING in Tree SUBMENU */

#define INSERT   8   /* Dialog */
#define ITITLE1  3   /* STRING in Tree INSERT */
#define ITITLE2  4   /* STRING in Tree INSERT */
#define IINSERT  5   /* BUTTON in Tree INSERT */
#define IEXIT    6   /* BUTTON in Tree INSERT */

#define COMMENCE 9   /* Dialog */
#define ZSETUP   6   /* BUTTON in Tree COMMENCE */
#define ZEXIT    7   /* BUTTON in Tree COMMENCE */

#define EPATH    10  /* Dialog */
#define EPATHS   7   /* FBOXTEXT in Tree EPATH */
#define EOK2     9   /* BUTTON in Tree EPATH */
#define EEXIT2   10  /* BUTTON in Tree EPATH */

#define EASSIGN  11  /* Dialog */
#define A1       8   /* BOX in Tree EASSIGN */
#define A2       9   /* BOX in Tree EASSIGN */
#define A3       10  /* BOX in Tree EASSIGN */
#define B1       11  /* IBOX in Tree EASSIGN */
#define B2       12  /* IBOX in Tree EASSIGN */
#define B3       13  /* IBOX in Tree EASSIGN */
#define EASETUP  15  /* BUTTON in Tree EASSIGN */
#define EAEXIT   16  /* BUTTON in Tree EASSIGN */

#define COMPLETE 12  /* Dialog */
#define CEXIT    1   /* BUTTON in Tree COMPLETE */

#define GDOSTST  13  /* Dialog */
#define GEXIT    8   /* BUTTON in Tree GDOSTST */
