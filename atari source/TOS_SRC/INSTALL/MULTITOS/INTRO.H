void	intro_dialog( void );
