int	path_dialog( void );
void	SetPathWindow( void );
int	path_handler( void );
