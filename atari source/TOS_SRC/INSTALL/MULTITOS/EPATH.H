int	epath_dialog( void );
void	SetEPathWindow( void );
int	epath_handler( void );
