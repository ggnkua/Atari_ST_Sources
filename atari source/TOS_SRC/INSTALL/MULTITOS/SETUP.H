/* FSM INSTALL.H
 *==========================================================================
 * DATE: December 12, 1990
 * DESCRIPTION: INCLUDE.H file from RESOURCE
 */
 
 
#if USA | UK
#include "resource\usa\usa.h" 
#endif

#if GERMAN
#include "resource\german\german.h" 
#endif

#if FRENCH
#include "resource\france\france.h" 
#endif


