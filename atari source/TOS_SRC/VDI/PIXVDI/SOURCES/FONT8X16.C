/*
********************************* fnt8x16 **************************************
*
* $Revision: 3.0 $	$Source: /u/lozben/projects/vdi/mtaskvdi/RCS/font8x16.c,v $
* ==============================================================================
* $Author: lozben $	$Date: 91/01/03 15:09:02 $     $Locker:  $
* ==============================================================================
*
* $Log:	font8x16.c,v $
* Revision 3.0  91/01/03  15:09:02  lozben
* New generation VDI
* 
* Revision 2.2  89/07/11  16:00:25  lozben
* Changed the header to point to ram16x32 header as the next font.
* 
* Revision 2.1  89/02/21  17:20:29  kbad
* *** TOS 1.4  FINAL RELEASE VERSION ***
* 
********************************************************************************
*/

#include "portab.h"
#include "fontdef.h"


EXTERN	UWORD	off_8x8[];

EXTERN	FONT_HEAD ram16x32[];

UWORD dat_8x16[2048] =

{	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x1104,
	0x0000,0x0000,0x1800,0x3800,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x4000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x003C,
	0x0600,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x6032,0x3200,0x0000,0x0000,0x00F1,
	0x00F6,0x0000,0x0000,0x0000,0x0000,0x0000,0x0060,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0018,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x05A0,
	0x7C00,0x7C7C,0x007C,0x7C7C,0x7C7C,0x0000,0x0000,0x0B28,
	0x0000,0x0000,0x1800,0x7C00,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x1000,
	0x6000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x000E,0x18E0,0x0000,
	0x0000,0x0618,0x0060,0x1C00,0x1800,0x6000,0x1860,0x6666,
	0x0C00,0x3E18,0x0060,0x1860,0x0066,0x6600,0x0E00,0x0000,
	0x0606,0x0606,0x3232,0x0000,0x0000,0x0060,0x6000,0x0000,
	0x3232,0x0100,0x0000,0x307A,0x7A66,0x0610,0x0000,0x005B,
	0x66F6,0x0000,0x0000,0x0000,0x0000,0x0000,0x0060,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x7C00,0x001E,0x0E00,0x0000,
	0x0000,0x0000,0x0018,0x0000,0x3838,0x0000,0x0000,0x00FE,
	0x0000,0x0030,0x0C7C,0xFEEE,0x0100,0x0008,0x7838,0x05A0,
	0xBA02,0x3A3A,0x82B8,0xB8BA,0xBABA,0x0078,0x0000,0x0DD8,
	0x0018,0x6666,0x3E66,0x6C18,0x0660,0x6600,0x0000,0x0006,
	0x3C18,0x3C7E,0x0C7E,0x1C7E,0x3C3C,0x0000,0x0000,0x003C,
	0x3818,0x7C3C,0x787E,0x7E3E,0x667E,0x06CC,0x60C6,0x663C,
	0x7C3C,0xF83E,0x7E66,0x66C6,0x6666,0x7E1E,0x6078,0x1000,
	0x7000,0x6000,0x0600,0x0E00,0x6018,0x0CC0,0x3800,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0018,0x1830,0x0000,
	0x3C66,0x0C3C,0x6630,0x3600,0x3C66,0x3066,0x3C30,0x663C,
	0x1800,0x7E3C,0x6630,0x3C30,0x6666,0x6618,0x1E66,0x180E,
	0x0C0C,0x0C0C,0x7A7A,0x0000,0x1800,0x0020,0x2000,0x0000,
	0x7A7A,0x3D00,0x007E,0x184C,0x4C66,0x0C7C,0x7A7C,0x7C5F,
	0x6666,0x667C,0x1E7E,0x7E38,0x1E7E,0x6E3C,0x3C7E,0x6C1C,
	0xFE36,0x7E6E,0x3E7C,0xD67E,0x387E,0x7E7E,0x6E1C,0x0000,
	0x0018,0xFE00,0xFE00,0x0000,0x103C,0x383E,0x1E10,0x3E7C,
	0x0000,0x6006,0x0E18,0x0000,0x6C7C,0x0000,0x3030,0x78FE,
	0x0018,0x3C38,0x1C38,0xFEC6,0x013C,0x000E,0x4040,0x05A0,
	0xC606,0x0606,0xC6C0,0xC0C6,0xC6C6,0x0040,0x0000,0x0628,
	0x0018,0x6666,0x7E66,0x6C18,0x0C30,0x6618,0x0000,0x0006,
	0x7E18,0x7E7E,0x0C7E,0x3C7E,0x7E7E,0x0000,0x0E00,0xE07E,
	0x7C3C,0x7E7E,0x7C7E,0x7E7E,0x667E,0x06CC,0x60C6,0x667E,
	0x7E7E,0xFC7E,0x7E66,0x66C6,0x6666,0x7E1E,0x6078,0x3800,
	0x3800,0x6000,0x0600,0x1E00,0x6018,0x0CC0,0x3800,0x0000,
	0x0000,0x0000,0x1800,0x0000,0x0000,0x0018,0x1830,0x0000,
	0x7E66,0x1866,0x6618,0x1C00,0x6666,0x1866,0x6618,0x1818,
	0x7E00,0xF866,0x6618,0x6618,0x6600,0x0018,0x3866,0x3C1E,
	0x1818,0x1818,0x4C4C,0x0000,0x1800,0x0020,0x2018,0x0000,
	0x4C4C,0x7E00,0x00FE,0x0000,0x0000,0x1810,0xCAC6,0xC655,
	0x0066,0x767C,0x1E7E,0x7E38,0x1E7E,0x6E3C,0x3E7E,0x6E1C,
	0xFE36,0x7E6E,0x3E7E,0xD67E,0x387E,0x3E7E,0x6E36,0x0000,
	0x003C,0x7E00,0xFE00,0x0002,0x107E,0x6C20,0x1010,0x7EFE,
	0x0018,0x700E,0x1918,0x1802,0x447C,0x0000,0x7848,0x1800,
	0x003C,0x242C,0x34BA,0xFED6,0x0366,0x180F,0x7040,0x05A0,
	0xC606,0x0606,0xC6C0,0xC0C6,0xC6C6,0x0070,0x0000,0x07D0,
	0x0018,0x66FF,0x606C,0x3818,0x1C38,0x3C18,0x0000,0x0006,
	0x6638,0x660C,0x1C60,0x7006,0x6666,0x1818,0x1C7E,0x7066,
	0xE67E,0x6666,0x6E60,0x6060,0x6618,0x06D8,0x60EE,0x6666,
	0x6666,0xCC60,0x1866,0x66C6,0x6666,0x0C18,0x6018,0x3800,
	0x1C00,0x6000,0x0600,0x1800,0x6000,0x00C0,0x1800,0x0000,
	0x0000,0x0000,0x1800,0x0000,0x0000,0x0018,0x1830,0x0000,
	0x6600,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x3C3C,
	0x7E00,0xD800,0x0000,0x0000,0x003C,0x663C,0x3066,0x6618,
	0x0000,0x0000,0x0000,0x3C3C,0x0000,0x0023,0x2318,0x0000,
	0x0000,0x6601,0x00D8,0x3C3C,0x3C00,0x0010,0xCA82,0x8251,
	0xE666,0x760C,0x060C,0x0618,0x0466,0x660C,0x0606,0x3E0C,
	0xFE36,0x6666,0x3E06,0xD666,0x1806,0x3666,0x6632,0x0066,
	0x6266,0x6202,0x601E,0x007E,0x7C66,0xC630,0x7C7C,0xE0C6,
	0x7E18,0x381C,0x1B18,0x183E,0x6C7C,0x0000,0x4818,0x3000,
	0x0066,0x24E6,0x6792,0xFC92,0x03C3,0x3C09,0x4040,0x0DB0,
	0xC606,0x0606,0xC6C0,0xC0C6,0xC6C6,0x7C40,0x0000,0x2E10,
	0x0018,0x66FF,0x600C,0x3818,0x1818,0x3C18,0x0000,0x000C,
	0x6638,0x660C,0x1C60,0x6006,0x6666,0x1818,0x387E,0x3866,
	0xC266,0x6666,0x6660,0x6060,0x6618,0x06D8,0x60EE,0x7666,
	0x6666,0xCC60,0x1866,0x66C6,0x3C66,0x0C18,0x3018,0x6C00,
	0x0C3C,0x7C3C,0x3E3C,0x183E,0x7C38,0x0CCC,0x186C,0x3C3C,
	0x7C3E,0x7C3E,0x7E66,0x66C6,0x6666,0x7E18,0x1830,0x6218,
	0x6666,0x3C3C,0x3C3C,0x3C3C,0x3C3C,0x3C38,0x3838,0x7E7E,
	0x6076,0xD83C,0x3C3C,0x6666,0x667E,0x667E,0x3066,0x6618,
	0x3C38,0x3C66,0x3C66,0x3E7E,0x1800,0x0026,0x2600,0x0000,
	0x3C3C,0x663D,0x7ED8,0x7E7E,0x7E00,0x0010,0xCABA,0xBA00,
	0x6666,0x3E0C,0x060C,0x6618,0x0C66,0x660C,0x0606,0x360C,
	0xC636,0x6636,0x0606,0xD666,0x1806,0x3666,0x7618,0x10F7,
	0xF666,0x607E,0x3038,0x66FC,0xC642,0xC618,0xD6D6,0xC0C6,
	0x7E18,0x1C38,0x1B18,0x007C,0x3838,0x001F,0x4830,0x1800,
	0x00C3,0x2483,0xC1D6,0xFCBA,0x0691,0x3C08,0x4038,0x0DB0,
	0x8202,0x3A3A,0xBAB8,0xB882,0xBABA,0x7E78,0x0000,0x39E0,
	0x0018,0x6666,0x7C18,0x7018,0x1818,0xFF7E,0x007E,0x000C,
	0x6618,0x0C18,0x3C7C,0x600C,0x3C7E,0x1818,0x7000,0x1C0C,
	0xDA66,0x7E60,0x667C,0x7C6E,0x7E18,0x06F0,0x60FE,0x7666,
	0x6666,0xCC70,0x1866,0x66C6,0x3C3C,0x1818,0x3018,0x6C00,
	0x043E,0x7E7C,0x7E7E,0x7E7E,0x7E38,0x0CDC,0x18FE,0x7E7E,
	0x7E7E,0x7E7E,0x7E66,0x66C6,0x6666,0x7E38,0x1838,0xF218,
	0x6066,0x7E3E,0x3E3E,0x3E7C,0x7E7E,0x7E38,0x3838,0x6666,
	0x607F,0xDE7E,0x7E7E,0x6666,0x6666,0x6666,0x307E,0x6618,
	0x3E38,0x7E66,0x7E66,0x0666,0x1800,0x002C,0x2C18,0x1AB0,
	0x3E7E,0x6E7E,0xFFDE,0x6666,0x6600,0x0010,0xCAA2,0xAA00,
	0x6666,0x3C0C,0x0E0C,0x6618,0x0C66,0x6600,0x0606,0x660C,
	0xC636,0x763E,0x0606,0xF666,0x1806,0x3676,0x3E3C,0x1099,
	0xDC66,0x60FC,0x186C,0x6690,0x8242,0xC63C,0x9292,0xC0C6,
	0x007E,0x0E70,0x1818,0x7E40,0x0000,0x0010,0x4860,0x4800,
	0x0081,0xE783,0xC1C6,0xF838,0x0691,0x3C08,0x0000,0x1DB8,
	0x0000,0x7C7C,0x7C7C,0x7C00,0x7C7C,0x0600,0x0000,0x3800,
	0x0018,0x6666,0x3E18,0x7018,0x1818,0xFF7E,0x007E,0x0018,
	0x6E18,0x0C18,0x3C7E,0x7C0C,0x3C3E,0x1818,0xE000,0x0E0C,
	0xD666,0x7C60,0x667C,0x7C6E,0x7E18,0x06F0,0x60D6,0x7E66,
	0x6666,0xFC38,0x1866,0x66D6,0x183C,0x1818,0x1818,0xC600,
	0x0006,0x6660,0x6666,0x7E66,0x6618,0x0CF8,0x18FE,0x6666,
	0x6666,0x6660,0x1866,0x66D6,0x3C66,0x0CF0,0x181E,0xBE3C,
	0x6066,0x6606,0x0606,0x0660,0x6666,0x6618,0x1818,0x6666,
	0x7C1B,0xDE66,0x6666,0x6666,0x6666,0x6660,0x303C,0x7C7E,
	0x0618,0x6666,0x6676,0x3E66,0x1800,0x0018,0x1818,0x36D8,
	0x0666,0x6E66,0xDBDE,0x6666,0x6600,0x0010,0xCAA2,0xB200,
	0x6666,0x3C0C,0x1E0C,0x6618,0x0C66,0x6600,0x060E,0x660C,
	0xC636,0x7618,0x3606,0xF666,0x1806,0x3676,0x0E66,0x3899,
	0x887C,0x60A8,0x0CC6,0x6630,0x827E,0xC666,0x9292,0xFCC6,
	0x7E7E,0x1C38,0x1818,0x7E02,0x0000,0x00D0,0x4878,0x3000,
	0x00E7,0x81E6,0x67D6,0xFABA,0x8C9D,0x3C78,0x1E1C,0x399C,
	0x8202,0xB83A,0x3A3A,0xBA02,0xBA3A,0x060E,0x07F0,0x0000,
	0x0018,0x00FF,0x0630,0xDE00,0x1818,0x3C18,0x0000,0x0018,
	0x7618,0x180C,0x6C06,0x7E18,0x6606,0x0000,0x707E,0x1C18,
	0xD67E,0x6660,0x6660,0x6066,0x6618,0x06D8,0x60D6,0x7E66,
	0x7E66,0xF81C,0x1866,0x66D6,0x1818,0x3018,0x1818,0xC600,
	0x003E,0x6660,0x6666,0x1866,0x6618,0x0CF0,0x18D6,0x6666,
	0x6666,0x6070,0x1866,0x66D6,0x3C66,0x18F0,0x181E,0x9C24,
	0x6066,0x663E,0x3E3E,0x3E60,0x6666,0x6618,0x1818,0x7E7E,
	0x7C7B,0xF866,0x6666,0x6666,0x6666,0x6660,0xFE18,0x6618,
	0x3E18,0x6666,0x667E,0x7E66,0x3000,0x0030,0x3218,0x6C6C,
	0x3E66,0x766E,0xDBD8,0x7E7E,0x6600,0x0000,0x7AA2,0xBA00,
	0x6666,0x6E0C,0x360C,0x6618,0x0C66,0x6600,0x061C,0x660C,
	0xC636,0x061C,0x3606,0xC666,0x1806,0x3606,0x0666,0x38EF,
	0x8866,0x6028,0x0CC6,0x6630,0x8242,0x6C42,0x9292,0xFCC6,
	0x7E18,0x381C,0x1818,0x003E,0x0000,0x00D0,0x0000,0x0000,
	0x0024,0xC32C,0x3492,0xF292,0x8C81,0x3CF8,0x1012,0x799E,
	0xC606,0xC006,0x0606,0xC606,0xC606,0x7E10,0x0FF8,0x0000,
	0x0018,0x00FF,0x0636,0xDE00,0x1818,0x3C18,0x0000,0x0030,
	0x6618,0x180C,0x6C06,0x6618,0x6606,0x0000,0x387E,0x3818,
	0xDC7E,0x6660,0x6660,0x6066,0x6618,0x06D8,0x60C6,0x6E66,
	0x7C66,0xD80E,0x1866,0x66FE,0x3C18,0x3018,0x0C18,0x0000,
	0x007E,0x6660,0x667E,0x1866,0x6618,0x0CF8,0x18D6,0x6666,
	0x6666,0x603C,0x1866,0x66FE,0x1866,0x1838,0x1838,0x0066,
	0x6066,0x7E7E,0x7E7E,0x7E60,0x7E7E,0x7E18,0x1818,0x7E7E,
	0x60FF,0xF866,0x6666,0x6666,0x6666,0x6666,0x307E,0x6618,
	0x7E18,0x6666,0x667E,0x6666,0x307E,0x7E6E,0x6618,0xD836,
	0x7E66,0x767E,0xDFD8,0x7E7E,0x6600,0x0000,0x0ABA,0xAA00,
	0x6666,0x6E0C,0x360C,0x6618,0x0C66,0x6600,0x0630,0x6E0C,
	0xC636,0x7E0E,0x3606,0xC666,0x1806,0x3606,0x063C,0x6C66,
	0xDC66,0x6028,0x18C6,0x6630,0x8242,0x2842,0x9292,0xC0C6,
	0x0018,0x700E,0x1818,0x187C,0x0000,0x1850,0x0000,0x0000,
	0x0024,0x6638,0x1CBA,0xF6D6,0xD8C3,0x7E70,0x1C1C,0x718E,
	0xC606,0xC006,0x0606,0xC606,0xC606,0x660C,0x1FEC,0x0000,
	0x0000,0x0066,0x7E66,0xCC00,0x1818,0x6618,0x1800,0x1830,
	0x6618,0x3066,0x7E06,0x6630,0x6606,0x1818,0x1C00,0x7018,
	0xC066,0x6666,0x6660,0x6066,0x6618,0x66CC,0x60C6,0x6E66,
	0x6066,0xCC06,0x1866,0x3CFE,0x3C18,0x6018,0x0C18,0x0000,
	0x0066,0x6660,0x6660,0x1866,0x6618,0x0CD8,0x18D6,0x6666,
	0x6666,0x600E,0x1866,0x3CFE,0x3C66,0x3018,0x1830,0x0042,
	0x6666,0x6066,0x6666,0x6660,0x6060,0x6018,0x1818,0x6666,
	0x60D8,0xD866,0x6666,0x6666,0x6666,0x667E,0x3018,0x6618,
	0x6618,0x6666,0x666E,0x6666,0x667E,0x7ED3,0xCE18,0x6C6C,
	0x6666,0x6676,0xD8D8,0x6666,0x6600,0x0000,0x0A82,0x8200,
	0x6666,0x667E,0x360C,0x6618,0x0C66,0x7E00,0x3E30,0x6E7C,
	0xFE7E,0x7E7E,0x3606,0xFEE6,0x1806,0x3E06,0x0618,0x6C00,
	0xF666,0x6028,0x30C6,0x6630,0xC666,0xAA66,0xD6D6,0xC0C6,
	0x7E18,0x6006,0x18D8,0x1840,0x0000,0x3C70,0x0000,0x0000,
	0x0024,0x3C30,0x0C38,0xE6C6,0x5866,0xFF00,0x1014,0x718E,
	0xC606,0xC006,0x0606,0xC606,0xC606,0x6602,0x1804,0x0000,
	0x0000,0x0066,0x7C66,0xCC00,0x1C38,0x6600,0x1800,0x1860,
	0x6618,0x3066,0x7E66,0x6630,0x660E,0x1818,0x0E00,0xE000,
	0xE266,0x6666,0x6E60,0x6066,0x6618,0x66CC,0x60C6,0x6666,
	0x606A,0xCC06,0x1866,0x3CEE,0x6618,0x6018,0x0618,0x0000,
	0x0066,0x6660,0x6660,0x187E,0x6618,0x0CCC,0x18C6,0x6666,
	0x6666,0x6006,0x1866,0x3CEE,0x3C7E,0x3018,0x1830,0x00C3,
	0x6666,0x6066,0x6666,0x6660,0x6060,0x6018,0x1818,0x6666,
	0x60D8,0xD866,0x6666,0x6666,0x7E66,0x663C,0x3018,0x7C18,
	0x6618,0x6666,0x6666,0x7E7E,0x6660,0x0606,0x1A18,0x36D8,
	0x6666,0x6666,0xD8D8,0x6666,0x6600,0x0000,0x0AC6,0xC600,
	0x66F6,0x627E,0x360C,0x6618,0x0466,0x7E00,0x3C30,0x6E7C,
	0x7C7E,0x7E7E,0x3606,0xFEE6,0x1806,0x3E06,0x064C,0xC600,
	0x627C,0x6028,0x606C,0x7F20,0x7C7E,0xEE7E,0x7C7C,0xE0C6,
	0x7E00,0x0000,0x18D8,0x0000,0x0000,0x3C20,0x0000,0x0000,
	0x003C,0x1800,0x007C,0xEEEE,0x703C,0x1000,0x1012,0x6186,
	0xBA02,0xB83A,0x023A,0xBA02,0xBA3A,0x7E1C,0x1804,0x0000,
	0x0018,0x0000,0x1800,0xFE00,0x0C30,0x0000,0x1800,0x1860,
	0x7E7E,0x7E7E,0x0C7E,0x7E30,0x7E3C,0x1818,0x0000,0x0018,
	0x7E66,0x7E7E,0x7C7E,0x607E,0x667E,0x7EC6,0x7EC6,0x667E,
	0x607C,0xC67E,0x187E,0x18C6,0x6618,0x7E1E,0x0678,0x00FE,
	0x007E,0x7E7E,0x7E7E,0x183E,0x663C,0x0CCE,0x3CC6,0x667E,
	0x7E7E,0x607E,0x1E7E,0x18C6,0x663E,0x7E18,0x1830,0x00FF,
	0x7E7E,0x7E7E,0x7E7E,0x7E7E,0x7E7E,0x7E3C,0x3C3C,0x6666,
	0x7EFF,0xDE7E,0x7E7E,0x7E7E,0x3E7E,0x7E18,0x7F18,0x6C18,
	0x7E3C,0x7E7E,0x6666,0x3E3C,0x7E60,0x060C,0x3218,0x1AB0,
	0x7E7E,0x7E7E,0xFFFE,0x6666,0x7E00,0x0000,0x0A7C,0x7C00,
	0xF6F6,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x3000,0x0000,0x1806,0x0006,0x066C,0xC600,
	0x006C,0x6000,0xFE38,0x5D00,0x103C,0x6C3C,0x1010,0x7EC6,
	0x007E,0x7E7E,0x1898,0x0000,0x0000,0x1800,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x3000,0x3800,0x0000,0x4182,
	0x7C00,0x7C7C,0x007C,0x7C00,0x7C7C,0x3C00,0x1004,0x0000,
	0x0018,0x0000,0x1800,0x7600,0x0660,0x0000,0x1800,0x1860,
	0x3C7E,0x7E3C,0x0C3C,0x3C30,0x3C38,0x1818,0x0000,0x0018,
	0x3C66,0x7C3C,0x787E,0x603C,0x667E,0x3CC6,0x7EC6,0x663C,
	0x6036,0xC67C,0x183C,0x1882,0x6618,0x7E1E,0x0678,0x00FE,
	0x003E,0x7C3E,0x3E3E,0x1806,0x663C,0x0CC6,0x3CC6,0x663C,
	0x7C3E,0x607C,0x0E3E,0x1882,0x6606,0x7E18,0x1830,0x0000,
	0x3C3E,0x3E3E,0x3E3E,0x3E3E,0x3E3E,0x3E3C,0x3C3C,0x6666,
	0x7E7F,0xDE3C,0x3C3C,0x3E3E,0x063C,0x3C18,0xFF18,0x6070,
	0x3E3C,0x3C3E,0x6666,0x0000,0x3C60,0x0618,0x3F18,0x0000,
	0x3E3C,0xBCBC,0x7F7E,0x6666,0x3C00,0x0000,0x0A00,0x0000,
	0x0E0E,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x3000,0x0000,0x1806,0x0006,0x0638,0x0000,
	0x0060,0xF000,0xFE00,0xC000,0x1000,0x0000,0xF010,0x3EC6,
	0x007E,0x7E7E,0x1870,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x2000,0x1000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x1E3C,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x3000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0030,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x007E,0x0000,0x7C00,0x0000,0x0000,
	0x6006,0x0000,0x0000,0x0000,0x007E,0x000E,0x18E0,0x0000,
	0x0C00,0x0000,0x0000,0x000C,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x7E00,0x0000,0x0000,0x4060,
	0x0000,0x0000,0x0000,0x7E7E,0x0000,0x001F,0x0218,0x0000,
	0x0000,0x8080,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x3C7C,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x3000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0040,0x0000,0x0000,0x8000,0x7C00,0x0000,0xE000,0x0000,
	0x0000,0x0000,0x1800,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x1754,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x2000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0020,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x007C,0x0000,0x7800,0x0000,0x0000,
	0x6006,0x0000,0x0000,0x0000,0x007C,0x0000,0x0000,0x0000,
	0x3800,0x0000,0x0000,0x0038,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x7C00,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x3878,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
	0x0000,0x0000,0x1800,0x0000,0x0000,0x0000,0x0000,0x0000
};



struct font_head f8x16 ={

    1,					/*   WORD  font_id	 	*/
    10,					/*   WORD  point	 	*/
   "8x16 system font",			/*   BYTE  name[32]	 	*/
    0,					/*   UWORD first_ade	 	*/
    255,				/*   UWORD last_ade	 	*/
    13,					/*   UWORD top		 	*/
    11,					/*   UWORD ascent	 	*/
    8,					/*   UWORD half		 	*/
    2,					/*   UWORD descent	 	*/
    2,					/*   UWORD bottom	 	*/
    7,					/*   UWORD max_char_width	*/
    8,					/*   UWORD max_cell_width	*/
    1,					/*   UWORD left_offset	 	*/
    7,					/*   UWORD right_offset	 	*/
    1,					/*   UWORD thicken	 	*/
    1,					/*   UWORD ul_size	 	*/
    0x5555,				/*   UWORD lighten	 	*/
    0x5555,				/*   UWORD skew		 	*/
    STDFORM | MONOSPACE,		/*   UWORD flags	 	*/
    0,					/*   UBYTE *hor_table	 	*/
    off_8x8,				/*   UWORD *off_table	 	*/
    dat_8x16,				/*   UWORD *dat_table	 	*/
    256,				/*   UWORD form_width	 	*/
    16,					/*   UWORD form_height	 	*/
    ram16x32,				/*   UWORD *next_font	 	*/
    0					/*   UWORD next_seg		*/

};
