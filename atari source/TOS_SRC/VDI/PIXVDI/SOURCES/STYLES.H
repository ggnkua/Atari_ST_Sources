/*
*********************************  styles.h  **********************************
*
* $Revision: 3.1 $	$Source: /u/lozben/projects/vdi/mtaskvdi/RCS/styles.h,v $
* =============================================================================
* $Author: lozben $	$Date: 91/07/30 14:15:12 $     $Locker:  $
* =============================================================================
*
* $Log:	styles.h,v $
* Revision 3.1  91/07/30  14:15:12  lozben
* Change spelling of MK to MSK.
* 
* Revision 3.0  91/01/03  15:19:07  lozben
* New generation VDI
* 
* Revision 2.2  89/06/30  17:19:59  lozben
* Adjusted the declaration LINE_STYLE[]. The name was spelled
* different in three different files (we lucked out because it
* wasn't the first 8 characters, which make up the symbol name).
* 
* Revision 2.1  89/02/21  17:28:14  kbad
* *** TOS 1.4  FINAL RELEASE VERSION ***
* 
*******************************************************************************
*/
#ifndef _STYLES_H_
#define _STYLES_H_

/* styles.h */

/* the six predefined line styles */

WORD LINE_STYLE[6] = {0xFFFF, 0xFFF0, 0xC0C0, 0xFF18, 0xFF00, 0xF191};

/* the storage for the user-defined fill pattern */

WORD UDPATMSK =0xF;

WORD ROM_UD_PATRN[16] = {
	0x0000,0x05A0,0x05A0,0x05A0,0x05A0,0x0DB0,0x0DB0,0x1DB8,
	0x399C,0x799E,0x718E,0x718E,0x6186,0x4182,0x0000,0x0000
};      /* fuji */

/*	0x07E0,0x0FF0,0x1FD8,0x1808,0x1808,0x1008,0x1E78,0x1348,
	0x1108,0x0810,0x0B70,0x0650,0x07A0,0x1E20,0x1BC0,0x1800};   bob     */

WORD OEMMSKPA = 7;
WORD OEMPAT[128] = {
						/* Brick */
0xFFFF, 0x8080, 0x8080, 0x8080, 0xFFFF, 0x0808, 0x0808, 0x0808,
						/* Diagonal Bricks */
0x2020, 0x4040, 0x8080, 0x4141, 0x2222, 0x1414, 0x0808, 0x1010,
						/* Grass */
0x0000, 0x0000, 0x1010, 0x2828, 0x0000, 0x0000, 0x0101, 0x8282,
						/* Trees */
0x0202, 0x0202, 0xAAAA, 0x5050, 0x2020, 0x2020, 0xAAAA, 0x0505,
						/* Dashed x's */
0x4040, 0x8080, 0x0000, 0x0808, 0x0404, 0x0202, 0x0000, 0x2020,
						/* Cobble Stones */
0x6606, 0xC6C6, 0xD8D8, 0x1818, 0x8181, 0x8DB1, 0x0C33, 0x6000,
						/* Sand */
0x0000, 0x0000, 0x0400, 0x0000, 0x0010, 0x0000, 0x8000, 0x0000,
						/* Rough Weave */
0xF8F8, 0x6C6C, 0xC6C6, 0x8F8F, 0x1F1F, 0x3636, 0x6363, 0xF1F1,
						/* Quilt */
0xAAAA, 0x0000, 0x8888, 0x1414, 0x2222, 0x4141, 0x8888, 0x0000,
						/* Paterned Cross */
0x0808, 0x0000, 0xAAAA, 0x0000, 0x0808, 0x0000, 0x8888, 0x0000,
						/* Balls */
0x7777, 0x9898, 0xF8F8, 0xF8F8, 0x7777, 0x8989, 0x8F8F, 0x8F8F,
						/* Verticle Scales */
0x8080, 0x8080, 0x4141, 0x3E3E, 0x0808, 0x0808, 0x1414, 0xE3E3,
						/* Diagonal scales */
0x8181, 0x4242, 0x2424, 0x1818, 0x0606, 0x0101, 0x8080, 0x8080,
						/* Checker Board */
0xF0F0, 0xF0F0, 0xF0F0, 0xF0F0, 0x0F0F, 0x0F0F, 0x0F0F, 0x0F0F,
						/* Filled Diamond */
0x0808, 0x1C1C, 0x3E3E, 0x7F7F, 0xFFFF, 0x7F7F, 0x3E3E, 0x1C1C,
						/* Herringbone */
0x1111, 0x2222, 0x4444, 0xFFFF, 0x8888, 0x4444, 0x2222, 0xFFFF
};

WORD DITHRMSK = 3; /* mask off all but four scans */
WORD DITHER[32] = {
   0x0000,0x4444,0x0000,0x1111, /* intensity level 2 */
   0x0000,0x5555,0x0000,0x5555, /* intensity level 4 */
   0x8888,0x5555,0x2222,0x5555, /* intensity level 6 */
   0xAAAA,0x5555,0xAAAA,0x5555, /* intensity level 8 */
   0xAAAA,0xDDDD,0xAAAA,0x7777, /* intensity level 10 */
   0xAAAA,0xFFFF,0xAAAA,0xFFFF, /* intensity level 12 */
   0xEEEE,0xFFFF,0xBBBB,0xFFFF, /* intensity level 14 */
   0xFFFF,0xFFFF,0xFFFF,0xFFFF  /* intensity level 16 */
};

WORD HAT_0_MSK = 7;
WORD HATCH0[48] = {
					/* narrow spaced + 45 */
0x0101, 0x0202, 0x0404, 0x0808, 0x1010, 0x2020, 0x4040, 0x8080,
					/* medium spaced thick 45 deg */
0x6060, 0xC0C0, 0x8181, 0x0303, 0x0606, 0x0C0C, 0x1818, 0x3030,
					/* medium +-45 deg */
0x4242, 0x8181, 0x8181, 0x4242, 0x2424, 0x1818, 0x1818, 0x2424,
					/* medium spaced vertical */
0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080,
					/* medium spaced horizontal */
0xFFFF, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
					/* medium spaced cross */
0xFFFF, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080
};

WORD HAT_1_MSK = 0xF;
WORD HATCH1[96] = {
				/* wide +45 deg */
0x0001, 0x0002, 0x0004, 0x0008, 0x0010, 0x0020, 0x0040, 0x0080,
0x0100, 0x0200, 0x0400, 0x0800, 0x1000, 0x2000, 0x4000, 0x8000,
				/* widely spaced thick 45 deg */
0x8003, 0x0007, 0x000E, 0x001C, 0x0038, 0x0070, 0x00E0, 0x01C0,
0x0380, 0x0700, 0x0E00, 0x1C00, 0x3800, 0x7000, 0x0E000, 0x0C001,
				/* widely +- 45 deg */
0x8001, 0x4002, 0x2004, 0x1008, 0x0810, 0x0420, 0x0240, 0x0180,
0x0180, 0x0240, 0x0420, 0x0810, 0x1008, 0x2004, 0x4002, 0x8001,
				/* widely spaced vertical */
0x8000, 0x8000, 0x8000, 0x8000, 0x8000, 0x8000, 0x8000, 0x8000,
0x8000, 0x8000, 0x8000, 0x8000, 0x8000, 0x8000, 0x8000, 0x8000,
				/* widely spaced horizontal */
0xFFFF, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
				/* widely spaced horizontal/vert cross */
0xFFFF, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080,
0xFFFF, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080, 0x8080
};

WORD HOLLOW = 0;
WORD SOLID = 0xFFFF;

#endif
