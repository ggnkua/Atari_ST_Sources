#define MAINTREE 0  	/* TREE */
#define XUP 12  	/* OBJECT in TREE #0 */
#define XDOWN 13  	/* OBJECT in TREE #0 */
#define XBASE 10  	/* OBJECT in TREE #0 */
#define XSLIDE 11  	/* OBJECT in TREE #0 */
#define TBASE 2  	/* OBJECT in TREE #0 */
#define EEXIT 18  	/* OBJECT in TREE #0 */
#define T1 3  	/* OBJECT in TREE #0 */
#define T2 4  	/* OBJECT in TREE #0 */
#define T3 5  	/* OBJECT in TREE #0 */
#define T4 6  	/* OBJECT in TREE #0 */
#define T5 7  	/* OBJECT in TREE #0 */
#define T6 8  	/* OBJECT in TREE #0 */
#define T7 9  	/* OBJECT in TREE #0 */
#define XADD 15  	/* OBJECT in TREE #0 */
#define XDELETE 16  	/* OBJECT in TREE #0 */
#define SUBTREE 1  	/* TREE */
#define ETEXT 2  	/* OBJECT in TREE #1 */
#define EOK 3  	/* OBJECT in TREE #1 */
#define ECANCEL 4  	/* OBJECT in TREE #1 */
#define ETITLE 1  	/* OBJECT in TREE #1 */
#define DUMMY1 19  	/* OBJECT in TREE #0 */
#define DUMMY2 14  	/* OBJECT in TREE #0 */
#define XSAVE 17  	/* OBJECT in TREE #0 */
