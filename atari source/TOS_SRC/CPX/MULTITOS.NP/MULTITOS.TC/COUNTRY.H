/* COUNTRY.H
 *==========================================================================
 * DATE: April 3, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */
#define TRUE	1
#define FALSE 	0
 
#define USA	TRUE	/* The USA and UK versions are identical */
#define UK	FALSE

#define GERMAN	FALSE
#define FRENCH	FALSE


