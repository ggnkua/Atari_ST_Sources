#define MAINTREE 0  	/* TREE */
#define BASE 3  	/* OBJECT in TREE #0 */
#define SEXIT 28  	/* OBJECT in TREE #0 */
#define BOX1 4  	/* OBJECT in TREE #0 */
#define BOX2 6  	/* OBJECT in TREE #0 */
#define BOX3 8  	/* OBJECT in TREE #0 */
#define BOX4 10  	/* OBJECT in TREE #0 */
#define BOX5 12  	/* OBJECT in TREE #0 */
#define BOX6 14  	/* OBJECT in TREE #0 */
#define BOX7 16  	/* OBJECT in TREE #0 */
#define BOX8 18  	/* OBJECT in TREE #0 */
#define ICON1 5  	/* OBJECT in TREE #0 */
#define ICON2 7  	/* OBJECT in TREE #0 */
#define ICON3 9  	/* OBJECT in TREE #0 */
#define ICON4 11  	/* OBJECT in TREE #0 */
#define ICON5 13  	/* OBJECT in TREE #0 */
#define ICON6 15  	/* OBJECT in TREE #0 */
#define ICON7 17  	/* OBJECT in TREE #0 */
#define ICON8 19  	/* OBJECT in TREE #0 */
#define COVER1 20  	/* OBJECT in TREE #0 */
#define COVER2 21  	/* OBJECT in TREE #0 */
#define COVER3 22  	/* OBJECT in TREE #0 */
#define COVER4 23  	/* OBJECT in TREE #0 */
#define COVER5 24  	/* OBJECT in TREE #0 */
#define COVER6 25  	/* OBJECT in TREE #0 */
#define COVER7 26  	/* OBJECT in TREE #0 */
#define COVER8 27  	/* OBJECT in TREE #0 */
