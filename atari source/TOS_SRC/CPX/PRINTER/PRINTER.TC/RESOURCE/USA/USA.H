#define PRINTER 0  	/* TREE */
#define PSAVE 21  	/* OBJECT in TREE #0 */
#define PTYPE 3  	/* OBJECT in TREE #0 */
#define COLOR 6  	/* OBJECT in TREE #0 */
#define PIXLINE 9  	/* OBJECT in TREE #0 */
#define QUALITY 12  	/* OBJECT in TREE #0 */
#define PAPER 18  	/* OBJECT in TREE #0 */
#define PORT 15  	/* OBJECT in TREE #0 */
#define POK 23  	/* OBJECT in TREE #0 */
#define PCANCEL 24  	/* OBJECT in TREE #0 */
#define BOX0 2  	/* OBJECT in TREE #0 */
#define BOX1 5  	/* OBJECT in TREE #0 */
#define BOX2 8  	/* OBJECT in TREE #0 */
#define BOX3 11  	/* OBJECT in TREE #0 */
#define BOX4 14  	/* OBJECT in TREE #0 */
#define BOX5 17  	/* OBJECT in TREE #0 */
#define BOX6 20  	/* OBJECT in TREE #0 */
#define BOX7 22  	/* OBJECT in TREE #0 */
