/* Prototypes of super.c for those who need it...*/
void Enter_Super( void );
void Exit_Super( void );
