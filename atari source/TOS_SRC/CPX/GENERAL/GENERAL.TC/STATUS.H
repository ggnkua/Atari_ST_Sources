/* STATUS.C prototypes for those who need it...*/


void do_status( void );
void clear_status( void );
int  stat_button( int button, WORD *msg );

extern int max_stat;
extern int min_stat;
extern int blit_inc;
extern int stat_value;
extern int status_flag;
