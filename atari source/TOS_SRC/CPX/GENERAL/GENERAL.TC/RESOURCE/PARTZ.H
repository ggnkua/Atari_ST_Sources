#define PARTZ 0  	/* TREE */
