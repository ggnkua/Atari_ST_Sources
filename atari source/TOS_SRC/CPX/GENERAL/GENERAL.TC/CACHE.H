void cacheon( void );
void cacheoff( void );
long cacheinq( void );
