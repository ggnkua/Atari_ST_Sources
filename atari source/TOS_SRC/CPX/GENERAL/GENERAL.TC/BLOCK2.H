/* BLOCK2.H
 *==========================================================================
 * Prototypes and external variables from BLOCK2.C
 */
 
 
 
 /* DEFINES
  *=========================================================================
  */

 /* PROTOTYPES
  *=========================================================================
  */
void	Init_Block2( void );
void	Set_Block2( void );
void	Get_Block2( void );
void	Block2_Update( void );
void	Do_Block2( void );
void	Block2_Redraw( void );


  
 /* EXTERNS
  *=========================================================================
  */
