/* XCONTROL.H
 *==========================================================================
 * DATE: April 3, 1990
 * DESCRIPTION: INCLUDE.H file from RESOURCE
 */
 
 
#if USA
 #include "resource\usa.rsc\usa.h" 
#endif

/* The UK Resource is the same as the USA version */
#if UK
 #include "resource\usa.rsc\usa.h" 
#endif

#if ITALY
 #include "resource\italy.rsc\italy.h" 
#endif

#if GERMAN
 #include "resource\german.rsc\german.h" 
#endif

#if FRENCH
 #include "resource\french.rsc\french.h" 
#endif

#if SPAIN
 #include "resource\spain.rsc\spain.h" 
#endif

#if SWEDEN
 #include "resource\sweden.rsc\sweden.h" 
#endif

