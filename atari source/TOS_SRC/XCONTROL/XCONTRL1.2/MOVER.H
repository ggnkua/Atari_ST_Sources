/*  .C - Prototypes functions and defines
 *==========================================================================
 *
 */


/*   PROTOTYPES
 *==========================================================================
 */
BOOLEAN do_mover( void );
BOOLEAN mover_button( int obj );
BOOLEAN mover_keys( void );
void	Delete_Fnodes( void );


/*  DEFINES
 *==========================================================================
 */


/*  EXTERNS
 *==========================================================================
 */   
