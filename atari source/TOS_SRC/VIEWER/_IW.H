/* Resource File indices for _IW */

#define ICONWIND 0   /* Dialog */
#define IWMOVER  1   /* IBOX in Tree ICONWIND */
#define IWCLOSER 2   /* BOX in Tree ICONWIND */
#define IWPOPUP  3   /* BOXTEXT in Tree ICONWIND */
#define IWICON   4   /* ICON in Tree ICONWIND */
#define IWNOTE   5   /* IMAGE in Tree ICONWIND */

#define NAMEWIND 1   /* Dialog */
#define NWMOVER  1   /* IBOX in Tree NAMEWIND */
#define NWCLOSER 2   /* BOX in Tree NAMEWIND */
#define NWPOPUP  3   /* BOXTEXT in Tree NAMEWIND */
#define NWNAME   4   /* TEXT in Tree NAMEWIND */
