#define RS232 0  	/* TREE */
#define BAUD 3  	/* OBJECT in TREE #0 */
#define PARITY 6  	/* OBJECT in TREE #0 */
#define BITSCHAR 9  	/* OBJECT in TREE #0 */
#define STOPX 12  	/* OBJECT in TREE #0 */
#define PORT 15  	/* OBJECT in TREE #0 */
#define FLOW 19  	/* OBJECT in TREE #0 */
#define RS232CAN 26  	/* OBJECT in TREE #0 */
#define RS232OK 25  	/* OBJECT in TREE #0 */
#define RBOX 2  	/* OBJECT in TREE #0 */
#define PBOX 5  	/* OBJECT in TREE #0 */
#define CBOX 8  	/* OBJECT in TREE #0 */
#define BBOX 11  	/* OBJECT in TREE #0 */
#define SBOX 14  	/* OBJECT in TREE #0 */
#define FBOX 18  	/* OBJECT in TREE #0 */
#define SAVEBOX 23  	/* OBJECT in TREE #0 */
#define OKBOX 22  	/* OBJECT in TREE #0 */
#define SAVE 24  	/* OBJECT in TREE #0 */
