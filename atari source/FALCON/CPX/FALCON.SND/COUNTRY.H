/* COUNTRY.H
 *==========================================================================
 * DATE: April 3, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */
#define TRUE	1
#define FALSE 	0
 
#define USA	FALSE
#define UK	FALSE   /* UK is the same as the USA version */

#define GERMAN	FALSE
#define FRENCH	FALSE

#define	SPAIN	FALSE
#define	SWEDEN	TRUE

#define ITALY	FALSE
