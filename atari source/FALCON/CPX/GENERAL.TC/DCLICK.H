/* DCLICK.H
 *==========================================================================
 * Prototypes and external variables from DCLICK.C
 */
 
 
 
 /* DEFINES
  *=========================================================================
  */

 /* PROTOTYPES
  *=========================================================================
  */
void	Set_Dclick( void );
void	Get_Dclick( void );
void	Dclick_Update( void );
void	Dclick_Select( int obj );
void	Dclick_Handle( BOOLEAN flag, int obj );
void	Dclick_Redraw( void );


  
 /* EXTERNS
  *=========================================================================
  */
