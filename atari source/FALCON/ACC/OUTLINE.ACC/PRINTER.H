void	DoPrinter( void );
int	HandlePrinter( int button, WORD *msg );
