void	DoOptions( void );
int	HandleOptions( int button, WORD *msg );
extern int  MakeWidthFlag;	/* Make or not width Tables.*/
