#define FRONT 0  	/* TREE */
#define FUP 18  	/* OBJECT in TREE #0 */
#define FDOWN 26  	/* OBJECT in TREE #0 */
#define FBASE 20  	/* OBJECT in TREE #0 */
#define FSLIDER 21  	/* OBJECT in TREE #0 */
#define LINEBASE 3  	/* OBJECT in TREE #0 */
#define LINE0 4  	/* OBJECT in TREE #0 */
#define LINE1 5  	/* OBJECT in TREE #0 */
#define LINE2 6  	/* OBJECT in TREE #0 */
#define LINE3 7  	/* OBJECT in TREE #0 */
#define LINE4 8  	/* OBJECT in TREE #0 */
#define LINE5 9  	/* OBJECT in TREE #0 */
#define LINE6 10  	/* OBJECT in TREE #0 */
#define LINE7 11  	/* OBJECT in TREE #0 */
#define FTITLE 1  	/* OBJECT in TREE #0 */
#define FSAVE 25  	/* OBJECT in TREE #0 */
#define FEXIT 27  	/* OBJECT in TREE #0 */
#define LINE8 12  	/* OBJECT in TREE #0 */
#define LINE9 13  	/* OBJECT in TREE #0 */
#define SCAN 1  	/* TREE */
#define FADD 23  	/* OBJECT in TREE #0 */
#define FREMOVE 19  	/* OBJECT in TREE #0 */
#define FCONFIG 22  	/* OBJECT in TREE #0 */
#define FOPTIONS 24  	/* OBJECT in TREE #0 */
#define UNUSED 2  	/* TREE */
#define IEXIT 23  	/* OBJECT in TREE #2 */
#define ICONFIG 21  	/* OBJECT in TREE #2 */
#define IINSTALL 2  	/* OBJECT in TREE #2 */
#define IUP 18  	/* OBJECT in TREE #2 */
#define IDOWN 22  	/* OBJECT in TREE #2 */
#define IBASE 19  	/* OBJECT in TREE #2 */
#define ISLIDER 20  	/* OBJECT in TREE #2 */
#define ILINE0 4  	/* OBJECT in TREE #2 */
#define ILINE1 5  	/* OBJECT in TREE #2 */
#define ILINE2 6  	/* OBJECT in TREE #2 */
#define ILINE3 7  	/* OBJECT in TREE #2 */
#define ILINE4 8  	/* OBJECT in TREE #2 */
#define ILINE5 9  	/* OBJECT in TREE #2 */
#define ILINE6 10  	/* OBJECT in TREE #2 */
#define ILINE7 11  	/* OBJECT in TREE #2 */
#define ILINE8 12  	/* OBJECT in TREE #2 */
#define ILINE9 13  	/* OBJECT in TREE #2 */
#define ILINE 3  	/* OBJECT in TREE #2 */
#define ILINE10 14  	/* OBJECT in TREE #2 */
#define ILINE11 15  	/* OBJECT in TREE #2 */
#define ILINE12 16  	/* OBJECT in TREE #2 */
#define OPTIONS 3  	/* TREE */
#define OOK 21  	/* OBJECT in TREE #3 */
#define OCACHE 6  	/* OBJECT in TREE #3 */
#define OPOINT 4  	/* OBJECT in TREE #3 */
#define OPATH 3  	/* OBJECT in TREE #3 */
#define LINE10 14  	/* OBJECT in TREE #0 */
#define LINE11 15  	/* OBJECT in TREE #0 */
#define LINE12 16  	/* OBJECT in TREE #0 */
#define LINE13 17  	/* OBJECT in TREE #0 */
#define ILINE13 17  	/* OBJECT in TREE #2 */
#define ONUM1 16  	/* OBJECT in TREE #3 */
#define OWIDTH 5  	/* OBJECT in TREE #3 */
#define PATHTREE 4  	/* TREE */
#define PEXIT 6  	/* OBJECT in TREE #4 */
#define PCANCEL 7  	/* OBJECT in TREE #4 */
#define PNTSIZE 5  	/* TREE */
#define POINTOK 33  	/* OBJECT in TREE #5 */
#define POINTCAN 34  	/* OBJECT in TREE #5 */
#define OLEFT 3  	/* OBJECT in TREE #4 */
#define OPATHS 4  	/* OBJECT in TREE #4 */
#define ORIGHT 5  	/* OBJECT in TREE #4 */
#define CACHE 6  	/* TREE */
#define COK 29  	/* OBJECT in TREE #6 */
#define CCANCEL 30  	/* OBJECT in TREE #6 */
#define OBASE 14  	/* OBJECT in TREE #3 */
#define TITLE2 2  	/* OBJECT in TREE #6 */
#define CBASE 16  	/* OBJECT in TREE #6 */
#define LCACHE 17  	/* OBJECT in TREE #6 */
#define MCACHE 18  	/* OBJECT in TREE #6 */
#define SCACHE 19  	/* OBJECT in TREE #6 */
#define CCACHE 20  	/* OBJECT in TREE #6 */
#define CUP 6  	/* OBJECT in TREE #6 */
#define CDOWN 7  	/* OBJECT in TREE #6 */
#define MUP 10  	/* OBJECT in TREE #6 */
#define MDOWN 11  	/* OBJECT in TREE #6 */
#define BUP 14  	/* OBJECT in TREE #6 */
#define BDOWN 15  	/* OBJECT in TREE #6 */
#define CACHEMIN 24  	/* OBJECT in TREE #6 */
#define CUNUSED 26  	/* OBJECT in TREE #6 */
#define MUNUSED 28  	/* OBJECT in TREE #6 */
#define CUTITLE 25  	/* OBJECT in TREE #6 */
#define MUTITLE 27  	/* OBJECT in TREE #6 */
#define CSIZE 5  	/* OBJECT in TREE #6 */
#define MSIZE 9  	/* OBJECT in TREE #6 */
#define BSIZE 13  	/* OBJECT in TREE #6 */
#define OBACK1 2  	/* OBJECT in TREE #3 */
#define WBACK 7  	/* OBJECT in TREE #3 */
#define WEXIT 22  	/* OBJECT in TREE #3 */
#define WCANCEL 23  	/* OBJECT in TREE #3 */
#define OTITLE 1  	/* OBJECT in TREE #3 */
#define WON 10  	/* OBJECT in TREE #3 */
#define WOFF 11  	/* OBJECT in TREE #3 */
#define WBUILD 12  	/* OBJECT in TREE #3 */
#define LOADING 7  	/* TREE */
#define MAKEWID 8  	/* TREE */
#define WIDNAME 2  	/* OBJECT in TREE #8 */
#define PTITLE2 3  	/* OBJECT in TREE #5 */
#define PTITLE3 5  	/* OBJECT in TREE #5 */
#define PTITLE1 1  	/* OBJECT in TREE #5 */
#define PFIELD1 4  	/* OBJECT in TREE #5 */
#define PFIELD2 6  	/* OBJECT in TREE #5 */
#define PNTADD 19  	/* OBJECT in TREE #5 */
#define PNTDEL 20  	/* OBJECT in TREE #5 */
#define PNTDEF 21  	/* OBJECT in TREE #5 */
#define P10 12  	/* OBJECT in TREE #5 */
#define P12 13  	/* OBJECT in TREE #5 */
#define P18 14  	/* OBJECT in TREE #5 */
#define P24 15  	/* OBJECT in TREE #5 */
#define P48 16  	/* OBJECT in TREE #5 */
#define PNTUP 29  	/* OBJECT in TREE #5 */
#define PNTDOWN 32  	/* OBJECT in TREE #5 */
#define PNTBASE 30  	/* OBJECT in TREE #5 */
#define PNTSLIDE 31  	/* OBJECT in TREE #5 */
#define PNTLINE 22  	/* OBJECT in TREE #5 */
#define PNTLINE0 23  	/* OBJECT in TREE #5 */
#define PNTLINE1 24  	/* OBJECT in TREE #5 */
#define PNTLINE2 25  	/* OBJECT in TREE #5 */
#define PNTLINE3 26  	/* OBJECT in TREE #5 */
#define PNTLINE4 27  	/* OBJECT in TREE #5 */
#define PNTLINE5 28  	/* OBJECT in TREE #5 */
#define ADD 9  	/* TREE */
#define ADDOK 9  	/* OBJECT in TREE #9 */
#define ADDCAN 10  	/* OBJECT in TREE #9 */
#define ADDNUM 6  	/* OBJECT in TREE #9 */
#define ADDUP 7  	/* OBJECT in TREE #9 */
#define ADDDOWN 8  	/* OBJECT in TREE #9 */
#define ADDNAME 5  	/* OBJECT in TREE #9 */
#define ADDBASE 4  	/* OBJECT in TREE #9 */
#define ITITLE 1  	/* OBJECT in TREE #2 */
#define OTITLE2 1  	/* OBJECT in TREE #4 */
#define PTITLE4 17  	/* OBJECT in TREE #5 */
#define CTITLE1 1  	/* OBJECT in TREE #6 */
#define CTITLE2 21  	/* OBJECT in TREE #6 */
#define ADDTITLE 1  	/* OBJECT in TREE #9 */
#define FINSTALL 2  	/* OBJECT in TREE #0 */
#define ISELECT 24  	/* OBJECT in TREE #2 */
#define OTITLE3 13  	/* OBJECT in TREE #3 */
#define ONUM2 18  	/* OBJECT in TREE #3 */
#define ONUM3 20  	/* OBJECT in TREE #3 */
#define PFBASE1 2  	/* OBJECT in TREE #5 */
#define PTITLE5 7  	/* OBJECT in TREE #5 */
#define PTITLE6 8  	/* OBJECT in TREE #5 */
#define PFIELD6 10  	/* OBJECT in TREE #5 */
#define PFIELD5 9  	/* OBJECT in TREE #5 */
#define PFBASE2 11  	/* OBJECT in TREE #5 */
