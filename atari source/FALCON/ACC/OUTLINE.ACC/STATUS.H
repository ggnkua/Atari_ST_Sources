void	CacheCheck( void );
long	GetCurUsage( void );
void	CachePrompt( void );
