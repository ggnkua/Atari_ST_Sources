void	DoPath( void );
int	HandlePath( int button, WORD *msg );
