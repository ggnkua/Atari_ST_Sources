/* from buildwd.c */
void	 Make_Width_Table( void );
