/* FSM.H
 *==========================================================================
 * DATE: July 11, 1990
 * DESCRIPTION: INCLUDE.H file from RESOURCE
 */
 
 
#if USA | UK
 #include "resource\usauk\usa.h" 
#endif

#if ITALY
 #include "resource\italy\italy.h" 
#endif

#if GERMAN
 #include "resource\german\german.h" 
#endif

#if FRENCH
 #include "resource\french\french.h" 
#endif

#if SPAIN
 #include "resource\spain\spain.h" 
#endif

#if SWEDEN
 #include "resource\sweden\sweden.h" 
#endif

