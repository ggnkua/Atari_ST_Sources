void	DoCustom( void );
int	handle_custom( int button, WORD *msg );
DEV_PTR FindSelectedDevice( void );
