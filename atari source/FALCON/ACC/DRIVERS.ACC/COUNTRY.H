/* COUNTRY.H
 *==========================================================================
 * DATE: JULY 11, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */
#define TRUE	1
#define FALSE 	0
 
#define USA	FALSE		/* USA and the UK are NOT the same.*/
#define UK	FALSE
		
#define GERMAN	FALSE
#define FRENCH	TRUE

