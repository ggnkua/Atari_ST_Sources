/*==========================================================================
 * FILE: TEXT.H
 *==========================================================================
 * DATE: January 17, 1991
 *       September 11, 1991
 *
 * DESCRIPTION: Country Specific Text Strings
 * COMPILER: TURBO C Version 2.0
 */
 
/* MAINSTUF.C */
extern char menu_title[];
extern char alert13[];
extern char driver_null[];

/* WINDOWS.C */
extern char window_title[];


/* EDIT.C */
extern char alert1[];
extern char alert2[];

/* FSMIO.C */
extern char alert3[];
extern char alert4[];
extern char alert5[];
extern char alert6[];
extern char alert7[];
/*extern char alert8[];*/

extern char data_null[];
extern char *page_data[];
extern char rez_map[];
extern char rez_map2[];
extern char dpi_map[];


/* INACTIVE.C */
extern char alert10[];
extern char alert12[];


extern char head1[];
extern char head2[];
extern char head3[];

extern char alert50[];
extern char alert51[];
extern char alert52[];
extern char alert53[];
extern char alert54[];

extern char *print_text[];
extern char *size_text[];
extern char *rez_text[];
extern char *color_text[];
extern char *port_text[];
extern char *tray_text[];
extern char rez_width[];
extern char rez_height[];
extern char rez2_width[];
extern char rez2_height[];
extern char xy1_unit[];
extern char xy2_unit[];

extern char NoDrivers[];
extern char YesDrivers[];

extern char wider[];
extern char dtext[];
extern char modtext[];
extern char addtext[];
extern char alert55[];
extern char alert56[];
extern char alert57[];
extern char NonSpeedo[];
