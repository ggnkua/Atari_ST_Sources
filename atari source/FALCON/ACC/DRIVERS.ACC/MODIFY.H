void	DoModify( int obj, DEV_PTR curptr );
int	Modify_Button( int button, WORD *msg );
