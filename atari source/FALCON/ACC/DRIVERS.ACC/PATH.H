void	DoFontPath( void );
int	Path_Button( int button, WORD *msg );
void 	wait_up( void );

