/* PROTOTYPES 
 * ===============================================================
 */
void	XDeselect( OBJECT *tree, int button );
void	XSelect( OBJECT *tree, int button );

/* EXTERNS
 * ===============================================================
 */
extern OBJECT *tree; 
extern OBJECT *ad_front;
extern OBJECT *ad_device;
extern OBJECT *ad_scan;
extern OBJECT *PrevTree;
extern OBJECT *drivetree;
extern OBJECT *xytree;
extern OBJECT *ad_path;
extern OBJECT *ad_modify;
