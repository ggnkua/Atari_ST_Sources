#define XCONTROL 0  	/* TREE */
#define TIME24 2  	/* OBJECT in TREE #0 */
#define XOPTIONS 6  	/* OBJECT in TREE #0 */
#define XINFO 1  	/* TREE */
#define XBASE 5  	/* OBJECT in TREE #0 */
#define TIMEBASE 1  	/* OBJECT in TREE #0 */
#define SLOTBASE 7  	/* OBJECT in TREE #0 */
#define SLOTB0 8  	/* OBJECT in TREE #0 */
#define XABOUT 2  	/* TREE */
#define CPXPATH 22  	/* OBJECT in TREE #1 */
#define CPXLEFT 23  	/* OBJECT in TREE #1 */
#define CPXRIGHT 24  	/* OBJECT in TREE #1 */
#define DATE 4  	/* OBJECT in TREE #0 */
#define SLOT3 23  	/* OBJECT in TREE #0 */
#define SLOTB1 12  	/* OBJECT in TREE #0 */
#define SLOT1 15  	/* OBJECT in TREE #0 */
#define SLOTB2 16  	/* OBJECT in TREE #0 */
#define SLOTB3 20  	/* OBJECT in TREE #0 */
#define SLOT0TXT 9  	/* OBJECT in TREE #0 */
#define SLOT1TXT 13  	/* OBJECT in TREE #0 */
#define SLOT2TXT 17  	/* OBJECT in TREE #0 */
#define SLOT3TXT 21  	/* OBJECT in TREE #0 */
#define SLOT2 19  	/* OBJECT in TREE #0 */
#define SLOT0 11  	/* OBJECT in TREE #0 */
#define ICON0 10  	/* OBJECT in TREE #0 */
#define ICON1 14  	/* OBJECT in TREE #0 */
#define ICON2 18  	/* OBJECT in TREE #0 */
#define ICON3 22  	/* OBJECT in TREE #0 */
#define RLDBASE 17  	/* OBJECT in TREE #1 */
#define BASE 24  	/* OBJECT in TREE #0 */
#define UARROW 26  	/* OBJECT in TREE #0 */
#define RELOAD 20  	/* OBJECT in TREE #1 */
#define SLIDER 25  	/* OBJECT in TREE #0 */
#define DARROW 27  	/* OBJECT in TREE #0 */
#define XSAVE 27  	/* OBJECT in TREE #1 */
#define OKOPTION 29  	/* OBJECT in TREE #1 */
#define CANOPT 30  	/* OBJECT in TREE #1 */
#define HOUR 11  	/* OBJECT in TREE #1 */
#define STATS 16  	/* OBJECT in TREE #1 */
#define STATBASE 13  	/* OBJECT in TREE #1 */
#define NODETEXT 8  	/* OBJECT in TREE #1 */
#define LEFTNODE 6  	/* OBJECT in TREE #1 */
#define RTNODE 5  	/* OBJECT in TREE #1 */
#define NBASE 7  	/* OBJECT in TREE #1 */
#define ABOUTOK 8  	/* OBJECT in TREE #2 */
#define CPXSTAT 3  	/* TREE */
#define XEXIT 11  	/* OBJECT in TREE #3 */
#define CFNAME 6  	/* OBJECT in TREE #3 */
#define CVERSION 9  	/* OBJECT in TREE #3 */
#define CRES 8  	/* OBJECT in TREE #3 */
#define CID 7  	/* OBJECT in TREE #3 */
#define TIMEBOX 10  	/* OBJECT in TREE #1 */
#define TIME12 3  	/* OBJECT in TREE #0 */
#define MOVECPX 4  	/* TREE */
#define ROK 23  	/* OBJECT in TREE #4 */
#define MOVETEXT 24  	/* OBJECT in TREE #4 */
#define A0 2  	/* OBJECT in TREE #4 */
#define A1 3  	/* OBJECT in TREE #4 */
#define A2 4  	/* OBJECT in TREE #4 */
#define A3 5  	/* OBJECT in TREE #4 */
#define A4 6  	/* OBJECT in TREE #4 */
#define AUP 8  	/* OBJECT in TREE #4 */
#define ASLIDER 11  	/* OBJECT in TREE #4 */
#define ABASE 10  	/* OBJECT in TREE #4 */
#define ADOWN 9  	/* OBJECT in TREE #4 */
#define ATEXT 1  	/* OBJECT in TREE #4 */
#define I0 13  	/* OBJECT in TREE #4 */
#define I1 14  	/* OBJECT in TREE #4 */
#define I2 15  	/* OBJECT in TREE #4 */
#define I3 16  	/* OBJECT in TREE #4 */
#define I4 17  	/* OBJECT in TREE #4 */
#define IUP 20  	/* OBJECT in TREE #4 */
#define ISLIDER 19  	/* OBJECT in TREE #4 */
#define IBASE 18  	/* OBJECT in TREE #4 */
#define IDOWN 21  	/* OBJECT in TREE #4 */
#define ITEXT 12  	/* OBJECT in TREE #4 */
#define CPXTITLE 25  	/* OBJECT in TREE #1 */
#define STITLE 2  	/* OBJECT in TREE #1 */
#define ICBASE1 14  	/* OBJECT in TREE #1 */
#define ICBASE2 18  	/* OBJECT in TREE #1 */
#define ABOUTBAS 1  	/* OBJECT in TREE #2 */
#define CPXBASE 1  	/* OBJECT in TREE #3 */
#define ITEMBASE 2  	/* OBJECT in TREE #3 */
#define TITLEA 7  	/* OBJECT in TREE #4 */
#define TITLEB 22  	/* OBJECT in TREE #4 */
#define B0 1  	/* OBJECT in TREE #1 */
#define B1 21  	/* OBJECT in TREE #1 */
#define B2 26  	/* OBJECT in TREE #1 */
#define B3 28  	/* OBJECT in TREE #1 */
