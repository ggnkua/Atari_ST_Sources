/*	These tables are created based on the MCS 501 keyboard layout	*/
/*	Any other layout will have another set of 2 tables to be	*/
/*	overlayed on these default ones.				*/

/*	PC INTernal to MCS Flash position table	*/
unsigned char ptsfpos[256] = {
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*00:07*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*08:0f*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*10:17*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*18:1f*/
/*   !   # $ % & ' */ 0xff, 0x57, 0xff, 0x73, 0x44, 0x5c, 0x54, 0x61, /*20:27*/
/* ( ) * + , - . / */ 0x56, 0x55, 0x49, 0x45, 0x37, 0x59, 0x36, 0x66, /*28:2f*/
/* 0 1 2 3 4 5 6 7 */ 0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x3d, 0x3e, 0x3f, /*30:37*/
/* 8 9 : ;   =   ? */ 0x40, 0x41, 0x43, 0x42, 0xff, 0x4f, 0xff, 0x47, /*38:3f*/
/* @ A B C D E F G */ 0x53, 0x2f, 0x2a, 0x25, 0x29, 0x27, 0x2d, 0x22, /*40:47*/
/* H I J K L M N O */ 0x1d, 0x23, 0x31, 0x34, 0x20, 0x1f, 0x1e, 0x1c, /*48:4f*/
/* P Q R S T U V W */ 0x24, 0x33, 0x21, 0x2b, 0x1b, 0x32, 0x26, 0x30, /*50:57*/
/* X Y Z [   ]   _ */ 0x2e, 0x2c, 0x28, 0x5e, 0xff, 0x5d, 0xff, 0x35, /*58:5f*/
/* ` a b c d e f g */ 0x62, 0x15, 0x10, 0x0b, 0x0f, 0x0d, 0x13, 0x08, /*60:67*/
/* h i j k l m n o */ 0x03, 0x09, 0x17, 0x1a, 0x06, 0x05, 0x04, 0x02, /*68:6f*/
/* p q r s t u v w */ 0x0a, 0x19, 0x07, 0x11, 0x01, 0x18, 0x0c, 0x16, /*70:77*/
/* x y z {   }     */ 0x14, 0x12, 0x0e, 0x68, 0xff, 0x69, 0xff, 0xff, /*78:7f*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*80:87*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*88:8f*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*90:97*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*98:9f*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*a0:a7*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*a8:af*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*b0:b7*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*b8:bf*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*c0:c7*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*c8:cf*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*d0:d7*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*d8:df*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*e0:e7*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, /*e8:ef*/
                      0x5a, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x48, /*f0:f7*/
                      0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff  /*f8:ff*/
};

/*	PC INTernal to MCS double Flash position table		*/
unsigned char mcsdbl[303] = {0};
