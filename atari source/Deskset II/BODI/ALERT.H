/*ALERT TEXT STRING EQUATES */

#define ALERT1   1	    /* Unable to Locate Resource	*/
#define ALERT2   2	    /* Preview Functions Disabled	*/
#define ALERT3   3	    /* Printing Functions Disabled	*/
#define ALERT4   4	    /* Delete All Regions?		*/
#define ALERT5   5	    /* This Region is Already Linked    */
#define ALERT6   6	    /* Delete Page?			*/
#define ALERT7   7	    /* Delete Region?		 	*/
#define ALERT8   8	    /* File Not Found!			*/
#define ALERT9   9	    /* Commence Printing		*/
#define ALERT10  10	    /* Unable to Open Scanner Workstation*/
#define ALERT11  11	    /* Unable to Open Preview Workstation*/
#define ALERT12  12	    /* Memory LMALLOC() Allocation Error*/
#define ALERT13  13	    /* Memory LCALLOC() Allocation Error*/
#define ALERT14  14	    /* Unable to Allocate Critical Buffers*/
#define ALERT15  15	    /* Memory Shortage...		*/
#define ALERT16  16	    /* Disk Error -  Cannot Open File   */
#define ALERT17  17	    /* Disk Read Error!			*/
#define ALERT18  18	    /* Disk Error -  Cannot Close File  */
#define ALERT19  19	    /* Disk Error - Unable to Create File */
#define ALERT20  20	    /* Disk Write Error!		*/
#define ALERT21  21	    /* Disk Error - Unable to Delete File*/
#define ALERT22  22	    /* File I/O Error - Unable to continue */
#define ALERT23  23	    /* Memory Shortage - Cancelling operation*/
#define ALERT24  24	    /* File not found ... Edit? */
#define ALERT25  25	    /* Close article before going into editor */
#define ALERT26  26	    /* Clipboard is already full	*/
#define ALERT27  27	    /* Delete Current Template?		*/
#define ALERT28  28	    /* Delete Both Templates?		*/
#define ALERT29  29         /* Not a Deskset file		*/
#define ALERT30  30	    /* Not enough memory for rulers     */
#define ALERT31  31	    /* Not enough memory to repel	*/
#define ALERT32  32	    /* Not enough memory to show image  */
#define ALERT33  33	    /* Not enough memory for dpi requested*/
#define ALERT34  34	    /* Save Current Parameters?		  */
#define ALERT35  35	    /* Deskset will not run in this resolution */
#define ALERT36  36	    /* GDOS Not Installed - Please Install GDOS*/
#define ALERT37  37	    /* File Already Exists! Overwrite File? */
#define ALERT38  38	    /* You must load picture from the default path */
#define ALERT39  39	    /* The File Is Empty!|Please Check Your File */
#define ALERT40  40	    /* Delete Primitive? */
#define ALERT41  41	    /* No Laser Printer Attached... */
#define ALERT42  42	    /* Not Enough Memory to Print...*/
#define ALERT43  43	    /* Wrong Paper Size for Landscape modes */
