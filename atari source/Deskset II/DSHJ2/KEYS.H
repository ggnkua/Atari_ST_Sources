/*
	Useful Keys	
*/
#define		ctl_C	0x03
#define		bs	0x08
#define		esc	0x1b

/*
	Cursor Keys
*/
#define 	right_char	0xc0
#define 	left_char	0xc1
#define 	up_char		0xc2
#define 	down_char	0xc3
#define 	bol_char	0xc4
#define 	eol_char	0xc5
#define 	pageup_char	0xc6
#define 	pagedown_char	0xc7
#define 	bof_char	0xc8
#define 	eof_char	0xc9
#define 	Ins_char	0xca
#define 	Del_char	0xcb
#define 	NextWord_char	0xcc
#define 	PrevWord_char	0xcd

/*
	Alternate Command Keys
*/
#define		ATA		0x0d0	/* Again	*/
#define		ATB		0x0d1	/* Buffer	*/
#define		ATC		0x0d2	/* Copy		*/
#define		ATD		0x0d3	/* Delete	*/
#define		ATF		0x0d4	/* Forward Find	*/
#define		ATG		0x0d5	/* Get Text	*/
#define		ATJ		0x0d6	/* Jump Marker	*/
#define		ATM		0x0d7	/* Set	Marker	*/
#define		ATR		0x0d8	/* Replace	*/
#define		ATS		0x0d9	/* Select Art.	*/
#define		ATT		0x0da	/* Insert G.Tag	*/
#define		ATV		0x0db	/* Reverse Find	*/
#define		ATX		0x0dc	/* Delete Tag	*/
#define		ATL		0x0de	/* Insert L.Tag	*/
#define		ATP		0x0df	/* Insert PiTag	*/
