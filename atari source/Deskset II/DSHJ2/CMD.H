/*
	CG slave codes
*/
#define		st_take		0
#define		ed_take		1	/* N.U.	*/
#define		rev_typ		3
#define		init_rev_ld	5
#define		pt_typ		7
#define		s_size		8
#define		ver_mov_for	9
#define		ver_mov_rev	10
#define		hor_pos		11
#define		rul_wid		12	/* N.U.	*/
#define		rul_dep		13	/* N.U.	*/
#define		ins_rul		14	/* N.U.	*/
#define		sla_mod		15
#define		rev_wind_top	16
#define		rev_wind_bot	17
#define		aux_char_set	20	/* N.U. 8600	*/
#define		hor_mov_dir	21	/* 8200	*/
#define		ty_face		22
#define		font_ident	25	/* N.U.	*/
#define		char_comp	26	/* N.U.	*/
#define		hor_movr	27
#define		hor_movl	28
#define		landscape	34	/* N.U. EP308	*/
#define		st_doc		40	/* N.U. EP308	*/
#define		end_doc		41	/* N.U. EP308	*/
#define		st_page		42	/* N.U. EP308	*/
#define		end_page	43	/* N.U. EP308	*/

/*
	GOG slave codes
*/
#define		next_pg		29	/* Next Page	*/
#define		graphic		30	/* Ins Graphic	*/
#define		ver_pos		31	/* Vert. Pos.	*/
#define 	SLVEOB		32	/* End of Block	*/
#define 	SLVEOD		33	/* End of Data	*/
#define 	USRPGN		44	/* User Page #	*/
