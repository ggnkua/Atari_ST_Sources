/* DEGAS Elite Icon Definition */
#define ICON_W 0x0180
#define ICON_H 0x002C
#define ICONSIZE 0x0420
int bookm[ICONSIZE] = 
{ 0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0030, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0038, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x1F00, 0x0000, 0x0000, 
  0x0000, 0x003C, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x1FC0, 0x0000, 0x0000, 
  0x0000, 0x003C, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x00C0, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x1FE0, 0x0000, 0x0000, 
  0x0000, 0x003E, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x00E0, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x3FF0, 0x0000, 0x0000, 
  0x0000, 0x003E, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x00F0, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x6000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x003E, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x01F0, 0x0000, 
  0x0000, 0x0000, 0x0001, 0xF000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x003F, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x01F8, 0x0000, 
  0x0000, 0x0000, 0x0007, 0xF000, 
  0x0003, 0xFF00, 0x007F, 0xC000, 
  0x0003, 0xFF00, 0x007F, 0xC000, 
  0x0003, 0xFFFC, 0x007F, 0xC000, 
  0x0003, 0xFF3F, 0x007F, 0xC000, 
  0x0003, 0xFF00, 0x03FF, 0xC000, 
  0x0003, 0xFF00, 0x007F, 0xF000, 
  0x003F, 0xFFE0, 0x03FF, 0xFC00, 
  0x003F, 0xFFE0, 0x03FF, 0xFC00, 
  0x003F, 0xFFFC, 0x03FF, 0xFC00, 
  0x003F, 0xFFFF, 0x03FF, 0xFC00, 
  0x003F, 0xFFE0, 0x0FFF, 0xFC00, 
  0x003F, 0xFFE0, 0x03FF, 0xFC00, 
  0x00FF, 0xFFF8, 0x0FFF, 0xFF00, 
  0x00FF, 0xFFF8, 0x0FFF, 0xFF00, 
  0x00FF, 0xFFFC, 0x0FFF, 0xFF00, 
  0x00FF, 0xFFFF, 0x8FFF, 0xFF00, 
  0x00FF, 0xFFF8, 0x3FFF, 0xFF00, 
  0x00FF, 0xFFF8, 0x0FFF, 0xFF00, 
  0x01FF, 0xFFFE, 0x3FFF, 0xFF80, 
  0x01FF, 0xFFFE, 0x3FFF, 0xFF80, 
  0x01FF, 0xFFFE, 0x3FFF, 0xFF80, 
  0x01FF, 0xFFFF, 0xBFFF, 0xFF80, 
  0x01FF, 0xFFFE, 0x7FFF, 0xFF80, 
  0x01FF, 0xFFFE, 0x3FFF, 0xFF80, 
  0x03FF, 0xFFFF, 0x7FFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0x7FFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0x7FFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0x7FFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x03FF, 0xFFFF, 0xFFFF, 0xFFC0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0xFFF0, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x1FFF, 0xFFFF, 0xFFFF, 0xFFF8, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFC, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x5555, 0x555F, 0xFD55, 0x5554, 
  0x5555, 0x555F, 0xFD55, 0x5554, 
  0x5555, 0x555F, 0xFD55, 0x5554, 
  0x5555, 0x555F, 0xFD55, 0x5554, 
  0x5555, 0x555F, 0xFD55, 0x5554, 
  0x5555, 0x555F, 0xFD55, 0x5554, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000
};
