#define HYLAN 0  	/* TREE */
#define ENG 1  	/* OBJECT in TREE #0 */
#define FRE 2  	/* OBJECT in TREE #0 */
#define ITA 3  	/* OBJECT in TREE #0 */
#define SPA 4  	/* OBJECT in TREE #0 */
#define PORT 5  	/* OBJECT in TREE #0 */
#define GER 6  	/* OBJECT in TREE #0 */
#define DUT 7  	/* OBJECT in TREE #0 */
#define NOR 8  	/* OBJECT in TREE #0 */
#define HYPARS 1  	/* TREE */
#define CHBHY 2  	/* OBJECT in TREE #1 */
#define CHAHY 3  	/* OBJECT in TREE #1 */
#define HYOK 4  	/* OBJECT in TREE #1 */
#define PWFILES 2  	/* TREE */
#define PWOK 1  	/* OBJECT in TREE #2 */
#define WORDSPC 3  	/* TREE */
#define SUHY 1  	/* OBJECT in TREE #1 */
#define LSPON 15  	/* OBJECT in TREE #3 */
#define LSPOFF 14  	/* OBJECT in TREE #3 */
#define CPPOS 16  	/* OBJECT in TREE #3 */
#define CPNEG 17  	/* OBJECT in TREE #3 */
#define CPMIN 7  	/* OBJECT in TREE #3 */
#define CPPRF 8  	/* OBJECT in TREE #3 */
#define CPMAX 9  	/* OBJECT in TREE #3 */
#define CPOK 1  	/* OBJECT in TREE #3 */
#define CPCAN 2  	/* OBJECT in TREE #3 */
#define PWCAN 2  	/* OBJECT in TREE #2 */
#define HPCAN 5  	/* OBJECT in TREE #1 */
#define FIN 9  	/* OBJECT in TREE #0 */
#define SWD 10  	/* OBJECT in TREE #0 */
#define DAN 11  	/* OBJECT in TREE #0 */
#define HLCAN 12  	/* OBJECT in TREE #0 */
#define HYLOK 13  	/* OBJECT in TREE #0 */
#define HMOFF 8  	/* OBJECT in TREE #1 */
#define HMON 9  	/* OBJECT in TREE #1 */
#define DICT 7  	/* OBJECT in TREE #2 */
#define DRESS 8  	/* OBJECT in TREE #2 */
#define LAYOUT 9  	/* OBJECT in TREE #2 */
#define FONTMAN 4  	/* TREE */
#define FID1 91  	/* OBJECT in TREE #4 */
#define FID2 92  	/* OBJECT in TREE #4 */
#define FID3 93  	/* OBJECT in TREE #4 */
#define FID4 94  	/* OBJECT in TREE #4 */
#define FID5 95  	/* OBJECT in TREE #4 */
#define FID6 96  	/* OBJECT in TREE #4 */
#define FID7 97  	/* OBJECT in TREE #4 */
#define FID8 98  	/* OBJECT in TREE #4 */
#define FID9 99  	/* OBJECT in TREE #4 */
#define FID10 100  	/* OBJECT in TREE #4 */
#define FID11 101  	/* OBJECT in TREE #4 */
#define FID12 102  	/* OBJECT in TREE #4 */
#define FID13 103  	/* OBJECT in TREE #4 */
#define FID14 104  	/* OBJECT in TREE #4 */
#define FID15 105  	/* OBJECT in TREE #4 */
#define FID16 106  	/* OBJECT in TREE #4 */
#define FCF1 10  	/* OBJECT in TREE #4 */
#define FCF2 11  	/* OBJECT in TREE #4 */
#define FCF3 12  	/* OBJECT in TREE #4 */
#define FCF4 13  	/* OBJECT in TREE #4 */
#define FCF5 14  	/* OBJECT in TREE #4 */
#define FCF6 15  	/* OBJECT in TREE #4 */
#define FCF7 16  	/* OBJECT in TREE #4 */
#define FCF8 17  	/* OBJECT in TREE #4 */
#define FCF9 18  	/* OBJECT in TREE #4 */
#define FCF10 19  	/* OBJECT in TREE #4 */
#define FCF11 20  	/* OBJECT in TREE #4 */
#define FCF12 21  	/* OBJECT in TREE #4 */
#define FCF13 22  	/* OBJECT in TREE #4 */
#define FCF14 23  	/* OBJECT in TREE #4 */
#define FCF15 24  	/* OBJECT in TREE #4 */
#define FCF16 25  	/* OBJECT in TREE #4 */
#define FTF1 26  	/* OBJECT in TREE #4 */
#define FTF2 27  	/* OBJECT in TREE #4 */
#define FTF3 28  	/* OBJECT in TREE #4 */
#define FTF4 29  	/* OBJECT in TREE #4 */
#define FTF5 30  	/* OBJECT in TREE #4 */
#define FTF6 31  	/* OBJECT in TREE #4 */
#define FTF7 32  	/* OBJECT in TREE #4 */
#define FTF8 33  	/* OBJECT in TREE #4 */
#define FTF9 34  	/* OBJECT in TREE #4 */
#define FTF10 35  	/* OBJECT in TREE #4 */
#define FTF11 36  	/* OBJECT in TREE #4 */
#define FTF12 37  	/* OBJECT in TREE #4 */
#define FTF13 38  	/* OBJECT in TREE #4 */
#define FTF14 39  	/* OBJECT in TREE #4 */
#define FTF15 40  	/* OBJECT in TREE #4 */
#define FTF16 41  	/* OBJECT in TREE #4 */
#define FCC1 42  	/* OBJECT in TREE #4 */
#define FCC2 43  	/* OBJECT in TREE #4 */
#define FCC3 44  	/* OBJECT in TREE #4 */
#define FCC4 45  	/* OBJECT in TREE #4 */
#define FCC5 46  	/* OBJECT in TREE #4 */
#define FCC6 47  	/* OBJECT in TREE #4 */
#define FCC7 48  	/* OBJECT in TREE #4 */
#define FCC8 49  	/* OBJECT in TREE #4 */
#define FCC9 50  	/* OBJECT in TREE #4 */
#define FCC10 51  	/* OBJECT in TREE #4 */
#define FCC11 52  	/* OBJECT in TREE #4 */
#define FCC12 53  	/* OBJECT in TREE #4 */
#define FCC13 54  	/* OBJECT in TREE #4 */
#define FCC14 55  	/* OBJECT in TREE #4 */
#define FCC15 56  	/* OBJECT in TREE #4 */
#define FCC16 57  	/* OBJECT in TREE #4 */
#define FKRN1 58  	/* OBJECT in TREE #4 */
#define FKRN2 59  	/* OBJECT in TREE #4 */
#define FKRN3 60  	/* OBJECT in TREE #4 */
#define FKRN4 61  	/* OBJECT in TREE #4 */
#define FKRN5 62  	/* OBJECT in TREE #4 */
#define FKRN6 63  	/* OBJECT in TREE #4 */
#define FKRN7 64  	/* OBJECT in TREE #4 */
#define FKRN8 65  	/* OBJECT in TREE #4 */
#define FKRN9 66  	/* OBJECT in TREE #4 */
#define FKRN10 67  	/* OBJECT in TREE #4 */
#define FKRN11 68  	/* OBJECT in TREE #4 */
#define FKRN12 69  	/* OBJECT in TREE #4 */
#define FKRN13 70  	/* OBJECT in TREE #4 */
#define FKRN14 71  	/* OBJECT in TREE #4 */
#define FKRN15 72  	/* OBJECT in TREE #4 */
#define FKRN16 73  	/* OBJECT in TREE #4 */
#define FUK1 74  	/* OBJECT in TREE #4 */
#define FUK2 75  	/* OBJECT in TREE #4 */
#define FUK3 76  	/* OBJECT in TREE #4 */
#define FUK4 77  	/* OBJECT in TREE #4 */
#define FUK5 78  	/* OBJECT in TREE #4 */
#define FUK6 79  	/* OBJECT in TREE #4 */
#define FUK7 80  	/* OBJECT in TREE #4 */
#define FUK8 81  	/* OBJECT in TREE #4 */
#define FUK9 82  	/* OBJECT in TREE #4 */
#define FUK10 83  	/* OBJECT in TREE #4 */
#define FUK11 84  	/* OBJECT in TREE #4 */
#define FUK12 85  	/* OBJECT in TREE #4 */
#define FUK13 86  	/* OBJECT in TREE #4 */
#define FUK14 87  	/* OBJECT in TREE #4 */
#define FUK15 88  	/* OBJECT in TREE #4 */
#define FUK16 89  	/* OBJECT in TREE #4 */
#define FTADD 114  	/* OBJECT in TREE #4 */
#define FTDEL 115  	/* OBJECT in TREE #4 */
#define FTNPA 116  	/* OBJECT in TREE #4 */
#define FTKMOD 110  	/* OBJECT in TREE #4 */
#define FTOK 1  	/* OBJECT in TREE #4 */
#define FTKCOP 109  	/* OBJECT in TREE #4 */
#define FTKDEL 111  	/* OBJECT in TREE #4 */
#define FTNID 117  	/* OBJECT in TREE #4 */
#define CHARCOMP 6  	/* TREE */
#define JUSTIFI 5  	/* TREE */
#define AUTOJUST 4  	/* OBJECT in TREE #5 */
#define AUTORIG 6  	/* OBJECT in TREE #5 */
#define AUTOCTR 7  	/* OBJECT in TREE #5 */
#define AUTOLEFT 5  	/* OBJECT in TREE #5 */
#define JUSTCAN 2  	/* OBJECT in TREE #5 */
#define JUSTOK 1  	/* OBJECT in TREE #5 */
#define MCCOFF 9  	/* OBJECT in TREE #6 */
#define MCCON 10  	/* OBJECT in TREE #6 */
#define MCCSETVL 4  	/* OBJECT in TREE #6 */
#define ACCSET1 20  	/* OBJECT in TREE #6 */
#define ACCSET2 21  	/* OBJECT in TREE #6 */
#define ACCSET3 22  	/* OBJECT in TREE #6 */
#define ACCOFF 17  	/* OBJECT in TREE #6 */
#define ACCON 18  	/* OBJECT in TREE #6 */
#define COMPCAN 2  	/* OBJECT in TREE #6 */
#define COMPOK 1  	/* OBJECT in TREE #6 */
#define BADINP 15  	/* STRING */
#define PMS0 16  	/* STRING */
#define LYTMS1 17  	/* STRING */
#define LYTMS2 18  	/* STRING */
#define NORULE 19  	/* STRING */
#define NFONT 20  	/* STRING */
#define FONTADD 7  	/* TREE */
#define FONTSAVE 21  	/* STRING */
#define FIDSAVE 22  	/* STRING */
#define FTPATH2 13  	/* OBJECT in TREE #7 */
#define FADDID 14  	/* OBJECT in TREE #7 */
#define FADDFC 17  	/* OBJECT in TREE #7 */
#define FADDFF 18  	/* OBJECT in TREE #7 */
#define FADDFN 19  	/* OBJECT in TREE #7 */
#define FADDCC 20  	/* OBJECT in TREE #7 */
#define FADDNK 21  	/* OBJECT in TREE #7 */
#define FADDSK 11  	/* OBJECT in TREE #7 */
#define FADDDK 12  	/* OBJECT in TREE #7 */
#define FADDNOK 2  	/* OBJECT in TREE #7 */
#define FADDOK 3  	/* OBJECT in TREE #7 */
#define KERNPAIR 12  	/* TREE */
#define KPFNM 6  	/* OBJECT in TREE #12 */
#define KPFID 7  	/* OBJECT in TREE #12 */
#define KPFKT 8  	/* OBJECT in TREE #12 */
#define KPOK 4  	/* OBJECT in TREE #12 */
#define KPPRV 5  	/* OBJECT in TREE #12 */
#define KPNXT 3  	/* OBJECT in TREE #12 */
#define FTCREAT 11  	/* TREE */
#define FTCFN 3  	/* OBJECT in TREE #11 */
#define FTCNOK 1  	/* OBJECT in TREE #11 */
#define FTCOK 2  	/* OBJECT in TREE #11 */
#define FNWPA 9  	/* TREE */
#define FNPAID 2  	/* OBJECT in TREE #9 */
#define FNPANOK 4  	/* OBJECT in TREE #9 */
#define FNPAOK 5  	/* OBJECT in TREE #9 */
#define FTPATH1 3  	/* OBJECT in TREE #9 */
#define SFNMS 23  	/* STRING */
#define KPN1 9  	/* OBJECT in TREE #12 */
#define KPN2 10  	/* OBJECT in TREE #12 */
#define KPN3 11  	/* OBJECT in TREE #12 */
#define KPN4 12  	/* OBJECT in TREE #12 */
#define KPN5 13  	/* OBJECT in TREE #12 */
#define KPN6 14  	/* OBJECT in TREE #12 */
#define KPN7 15  	/* OBJECT in TREE #12 */
#define KPN8 16  	/* OBJECT in TREE #12 */
#define KPN9 17  	/* OBJECT in TREE #12 */
#define KPN10 18  	/* OBJECT in TREE #12 */
#define KPN11 19  	/* OBJECT in TREE #12 */
#define KPN12 20  	/* OBJECT in TREE #12 */
#define KPN13 21  	/* OBJECT in TREE #12 */
#define KPN14 22  	/* OBJECT in TREE #12 */
#define KPN15 23  	/* OBJECT in TREE #12 */
#define KPN16 24  	/* OBJECT in TREE #12 */
#define KPN17 25  	/* OBJECT in TREE #12 */
#define KPN18 26  	/* OBJECT in TREE #12 */
#define KPN19 27  	/* OBJECT in TREE #12 */
#define KPN20 28  	/* OBJECT in TREE #12 */
#define KPN21 29  	/* OBJECT in TREE #12 */
#define KPN22 30  	/* OBJECT in TREE #12 */
#define KPN23 31  	/* OBJECT in TREE #12 */
#define KPN24 32  	/* OBJECT in TREE #12 */
#define KPN25 33  	/* OBJECT in TREE #12 */
#define KPN26 34  	/* OBJECT in TREE #12 */
#define KPN27 35  	/* OBJECT in TREE #12 */
#define KPN28 36  	/* OBJECT in TREE #12 */
#define KPN29 37  	/* OBJECT in TREE #12 */
#define KPN30 38  	/* OBJECT in TREE #12 */
#define KPN31 39  	/* OBJECT in TREE #12 */
#define KPN32 40  	/* OBJECT in TREE #12 */
#define KPN33 41  	/* OBJECT in TREE #12 */
#define KPN34 42  	/* OBJECT in TREE #12 */
#define KPN35 43  	/* OBJECT in TREE #12 */
#define KPN36 44  	/* OBJECT in TREE #12 */
#define KPN37 45  	/* OBJECT in TREE #12 */
#define KPN38 46  	/* OBJECT in TREE #12 */
#define KPN39 47  	/* OBJECT in TREE #12 */
#define KPN40 48  	/* OBJECT in TREE #12 */
#define KPN41 49  	/* OBJECT in TREE #12 */
#define KPN42 50  	/* OBJECT in TREE #12 */
#define KPN43 51  	/* OBJECT in TREE #12 */
#define KPN44 52  	/* OBJECT in TREE #12 */
#define KPN45 53  	/* OBJECT in TREE #12 */
#define KPN46 54  	/* OBJECT in TREE #12 */
#define KPN47 55  	/* OBJECT in TREE #12 */
#define KPN48 56  	/* OBJECT in TREE #12 */
#define KPN49 57  	/* OBJECT in TREE #12 */
#define KPN50 58  	/* OBJECT in TREE #12 */
#define KPN51 59  	/* OBJECT in TREE #12 */
#define KPN52 60  	/* OBJECT in TREE #12 */
#define KPN53 61  	/* OBJECT in TREE #12 */
#define KPN54 62  	/* OBJECT in TREE #12 */
#define KPN55 63  	/* OBJECT in TREE #12 */
#define KPN56 64  	/* OBJECT in TREE #12 */
#define KPN57 65  	/* OBJECT in TREE #12 */
#define KPN58 66  	/* OBJECT in TREE #12 */
#define KPN59 67  	/* OBJECT in TREE #12 */
#define KPN60 68  	/* OBJECT in TREE #12 */
#define KPN61 69  	/* OBJECT in TREE #12 */
#define KPN62 70  	/* OBJECT in TREE #12 */
#define KPN63 71  	/* OBJECT in TREE #12 */
#define KPN64 72  	/* OBJECT in TREE #12 */
#define KPR1 73  	/* OBJECT in TREE #12 */
#define KPR2 74  	/* OBJECT in TREE #12 */
#define KPR3 75  	/* OBJECT in TREE #12 */
#define KPR4 76  	/* OBJECT in TREE #12 */
#define KPR5 77  	/* OBJECT in TREE #12 */
#define KPR6 78  	/* OBJECT in TREE #12 */
#define KPR7 79  	/* OBJECT in TREE #12 */
#define KPR8 80  	/* OBJECT in TREE #12 */
#define KPR9 81  	/* OBJECT in TREE #12 */
#define KPR10 82  	/* OBJECT in TREE #12 */
#define KPR11 83  	/* OBJECT in TREE #12 */
#define KPR12 84  	/* OBJECT in TREE #12 */
#define KPR13 85  	/* OBJECT in TREE #12 */
#define KPR14 86  	/* OBJECT in TREE #12 */
#define KPR15 87  	/* OBJECT in TREE #12 */
#define KPR16 88  	/* OBJECT in TREE #12 */
#define KPR17 89  	/* OBJECT in TREE #12 */
#define KPR18 90  	/* OBJECT in TREE #12 */
#define KPR19 91  	/* OBJECT in TREE #12 */
#define KPR20 92  	/* OBJECT in TREE #12 */
#define KPR21 93  	/* OBJECT in TREE #12 */
#define KPR22 94  	/* OBJECT in TREE #12 */
#define KPR23 95  	/* OBJECT in TREE #12 */
#define KPR24 96  	/* OBJECT in TREE #12 */
#define KPR25 97  	/* OBJECT in TREE #12 */
#define KPR26 98  	/* OBJECT in TREE #12 */
#define KPR27 99  	/* OBJECT in TREE #12 */
#define KPR28 100  	/* OBJECT in TREE #12 */
#define KPR29 101  	/* OBJECT in TREE #12 */
#define KPR30 102  	/* OBJECT in TREE #12 */
#define KPR31 103  	/* OBJECT in TREE #12 */
#define KPR32 104  	/* OBJECT in TREE #12 */
#define KPR33 105  	/* OBJECT in TREE #12 */
#define KPR34 106  	/* OBJECT in TREE #12 */
#define KPR35 107  	/* OBJECT in TREE #12 */
#define KPR36 108  	/* OBJECT in TREE #12 */
#define KPR37 109  	/* OBJECT in TREE #12 */
#define KPR38 110  	/* OBJECT in TREE #12 */
#define KPR39 111  	/* OBJECT in TREE #12 */
#define KPR40 112  	/* OBJECT in TREE #12 */
#define KPR41 113  	/* OBJECT in TREE #12 */
#define KPR42 114  	/* OBJECT in TREE #12 */
#define KPR43 115  	/* OBJECT in TREE #12 */
#define KPR44 116  	/* OBJECT in TREE #12 */
#define KPR45 117  	/* OBJECT in TREE #12 */
#define KPR46 118  	/* OBJECT in TREE #12 */
#define KPR47 119  	/* OBJECT in TREE #12 */
#define KPR48 120  	/* OBJECT in TREE #12 */
#define KPR49 121  	/* OBJECT in TREE #12 */
#define KPR50 122  	/* OBJECT in TREE #12 */
#define KPR51 123  	/* OBJECT in TREE #12 */
#define KPR52 124  	/* OBJECT in TREE #12 */
#define KPR53 125  	/* OBJECT in TREE #12 */
#define KPR54 126  	/* OBJECT in TREE #12 */
#define KPR55 127  	/* OBJECT in TREE #12 */
#define KPR56 128  	/* OBJECT in TREE #12 */
#define KPR57 129  	/* OBJECT in TREE #12 */
#define KPR58 130  	/* OBJECT in TREE #12 */
#define KPR59 131  	/* OBJECT in TREE #12 */
#define KPR60 132  	/* OBJECT in TREE #12 */
#define KPR61 133  	/* OBJECT in TREE #12 */
#define KPR62 134  	/* OBJECT in TREE #12 */
#define KPR63 135  	/* OBJECT in TREE #12 */
#define KPR64 136  	/* OBJECT in TREE #12 */
#define KPNOK 137  	/* OBJECT in TREE #12 */
#define SNFMSG 13  	/* TREE */
#define SNFILE 2  	/* OBJECT in TREE #13 */
#define SNFMS 3  	/* OBJECT in TREE #13 */
#define DRLDERR 25  	/* STRING */
#define NFNTERR 24  	/* STRING */
#define MKRNERR 26  	/* STRING */
#define FIND 14  	/* TREE */
#define RFIND 15  	/* TREE */
#define RPLACE 16  	/* TREE */
#define RFST 1  	/* OBJECT in TREE #16 */
#define RRST 3  	/* OBJECT in TREE #16 */
#define FFST 1  	/* OBJECT in TREE #14 */
#define FDOK 2  	/* OBJECT in TREE #14 */
#define RVST 1  	/* OBJECT in TREE #15 */
#define RVFOK 2  	/* OBJECT in TREE #15 */
#define RPOK 2  	/* OBJECT in TREE #16 */
#define RPNOK 4  	/* OBJECT in TREE #16 */
#define RVFNOK 3  	/* OBJECT in TREE #15 */
#define FDNOK 3  	/* OBJECT in TREE #14 */
#define RPALL 5  	/* OBJECT in TREE #16 */
#define SETAG 18  	/* TREE */
#define JPTAG 17  	/* TREE */
#define STGNOK 6  	/* OBJECT in TREE #18 */
#define JTGNOK 6  	/* OBJECT in TREE #17 */
#define JTGA 1  	/* OBJECT in TREE #17 */
#define JTGB 2  	/* OBJECT in TREE #17 */
#define JTGC 3  	/* OBJECT in TREE #17 */
#define JTGD 4  	/* OBJECT in TREE #17 */
#define STGA 1  	/* OBJECT in TREE #18 */
#define STGB 2  	/* OBJECT in TREE #18 */
#define STGC 3  	/* OBJECT in TREE #18 */
#define STGD 4  	/* OBJECT in TREE #18 */
#define MERM0 27  	/* STRING */
#define DELOK 28  	/* STRING */
#define TBMS 29  	/* STRING */
#define BFERR1 30  	/* STRING */
#define BFERR3 32  	/* STRING */
#define FRNFD 33  	/* STRING */
#define FRBFE 34  	/* STRING */
#define CPBFE 35  	/* STRING */
#define BFERR2 31  	/* STRING */
#define KILLTAG 36  	/* STRING */
#define TAGERR2 38  	/* STRING */
#define TAGERR1 37  	/* STRING */
#define FDUL 5  	/* OBJECT in TREE #14 */
#define RVFUL 6  	/* OBJECT in TREE #15 */
#define RPUL 9  	/* OBJECT in TREE #16 */
#define FNWID 8  	/* TREE */
#define OFID 4  	/* OBJECT in TREE #8 */
#define NWID 5  	/* OBJECT in TREE #8 */
#define FNIDOK 6  	/* OBJECT in TREE #8 */
#define FNIDNOK 7  	/* OBJECT in TREE #8 */
#define FKCOPY 10  	/* TREE */
#define FKCPOID 4  	/* OBJECT in TREE #10 */
#define FKCPNID 5  	/* OBJECT in TREE #10 */
#define FKCPOK 6  	/* OBJECT in TREE #10 */
#define FKCPNOK 7  	/* OBJECT in TREE #10 */
#define MENU 19  	/* TREE */
#define ABOUT 14  	/* OBJECT in TREE #19 */
#define TDESK 3  	/* OBJECT in TREE #19 */
#define TFILE 4  	/* OBJECT in TREE #19 */
#define TREGION 7  	/* OBJECT in TREE #19 */
#define FNEW 23  	/* OBJECT in TREE #19 */
#define FQUIT 41  	/* OBJECT in TREE #19 */
#define RCREATE 75  	/* OBJECT in TREE #19 */
#define RCLOSE 78  	/* OBJECT in TREE #19 */
#define TOBJECTS 8  	/* OBJECT in TREE #19 */
#define OPOLYGON 94  	/* OBJECT in TREE #19 */
#define OCIRCLE 95  	/* OBJECT in TREE #19 */
#define OELLIPSE 96  	/* OBJECT in TREE #19 */
#define OBOX 97  	/* OBJECT in TREE #19 */
#define DESKSET 20  	/* TREE */
#define OK 6  	/* OBJECT in TREE #20 */
#define TPAGE 5  	/* OBJECT in TREE #19 */
#define PSIZE 43  	/* OBJECT in TREE #19 */
#define P50 44  	/* OBJECT in TREE #19 */
#define P75 45  	/* OBJECT in TREE #19 */
#define PACTUAL 46  	/* OBJECT in TREE #19 */
#define P200 47  	/* OBJECT in TREE #19 */
#define RTOGGLE 83  	/* OBJECT in TREE #19 */
#define BKGRND 21  	/* TREE */
#define BGICBOX 1  	/* OBJECT in TREE #21 */
#define RWRITE 86  	/* OBJECT in TREE #19 */
#define FPRINT 37  	/* OBJECT in TREE #19 */
#define FONTSIZE 22  	/* TREE */
#define FCANCEL 25  	/* OBJECT in TREE #22 */
#define FOK 24  	/* OBJECT in TREE #22 */
#define GOPAGE 23  	/* TREE */
#define GOTOPAGE 3  	/* OBJECT in TREE #23 */
#define GOOK 4  	/* OBJECT in TREE #23 */
#define GOCANCEL 5  	/* OBJECT in TREE #23 */
#define PGOTO 50  	/* OBJECT in TREE #19 */
#define OLINE 98  	/* OBJECT in TREE #19 */
#define PPREV 51  	/* OBJECT in TREE #19 */
#define PNEXT 52  	/* OBJECT in TREE #19 */
#define TARTICLE 6  	/* OBJECT in TREE #19 */
#define ACREATE 62  	/* OBJECT in TREE #19 */
#define ACLOSE 65  	/* OBJECT in TREE #19 */
#define ORBOX 99  	/* OBJECT in TREE #19 */
#define OIMAGE 100  	/* OBJECT in TREE #19 */
#define ROPENGR 76  	/* OBJECT in TREE #19 */
#define FNTSIZE 8  	/* OBJECT in TREE #22 */
#define SSETSIZE 11  	/* OBJECT in TREE #22 */
#define LINESPCE 14  	/* OBJECT in TREE #22 */
#define FONTNUM 6  	/* OBJECT in TREE #22 */
#define PICTYPE 25  	/* TREE */
#define IOK 11  	/* OBJECT in TREE #25 */
#define INEO 3  	/* OBJECT in TREE #25 */
#define IIMG 4  	/* OBJECT in TREE #25 */
#define IGEM 5  	/* OBJECT in TREE #25 */
#define GRATTR 26  	/* TREE */
#define FINDEXL 2  	/* OBJECT in TREE #26 */
#define FINDEXR 3  	/* OBJECT in TREE #26 */
#define FPATTERN 8  	/* OBJECT in TREE #26 */
#define FHATCH 9  	/* OBJECT in TREE #26 */
#define LSTYLEL 4  	/* OBJECT in TREE #26 */
#define LSTYLER 6  	/* OBJECT in TREE #26 */
#define FBOX 10  	/* OBJECT in TREE #26 */
#define LBOX 11  	/* OBJECT in TREE #26 */
#define RGRATTR 87  	/* OBJECT in TREE #19 */
#define GROK 12  	/* OBJECT in TREE #26 */
#define GRCANCEL 13  	/* OBJECT in TREE #26 */
#define RDIMAGES 84  	/* OBJECT in TREE #19 */
#define ARTSEL 27  	/* TREE */
#define DART1 10  	/* OBJECT in TREE #27 */
#define DART2 11  	/* OBJECT in TREE #27 */
#define DART3 12  	/* OBJECT in TREE #27 */
#define DART4 13  	/* OBJECT in TREE #27 */
#define DART5 14  	/* OBJECT in TREE #27 */
#define DART6 15  	/* OBJECT in TREE #27 */
#define DART7 16  	/* OBJECT in TREE #27 */
#define DART8 17  	/* OBJECT in TREE #27 */
#define DSLDER 7  	/* OBJECT in TREE #27 */
#define DSLDBOX 6  	/* OBJECT in TREE #27 */
#define DUP 5  	/* OBJECT in TREE #27 */
#define DDOWN 8  	/* OBJECT in TREE #27 */
#define DOK 19  	/* OBJECT in TREE #27 */
#define DCANCEL 20  	/* OBJECT in TREE #27 */
#define DARTROOT 9  	/* OBJECT in TREE #27 */
#define BOOKOBJ 11  	/* OBJECT in TREE #21 */
#define TSETUP 9  	/* OBJECT in TREE #19 */
#define PPOINT 118  	/* OBJECT in TREE #19 */
#define ASELECT 63  	/* OBJECT in TREE #19 */
#define FLOADDOC 25  	/* OBJECT in TREE #19 */
#define FSAVEDOC 26  	/* OBJECT in TREE #19 */
#define PDELETE 53  	/* OBJECT in TREE #19 */
#define ADELETE 69  	/* OBJECT in TREE #19 */
#define RDELETE 81  	/* OBJECT in TREE #19 */
#define PADJCNT 48  	/* OBJECT in TREE #19 */
#define MEASURE 28  	/* TREE */
#define MOK 7  	/* OBJECT in TREE #28 */
#define MCANCEL 8  	/* OBJECT in TREE #28 */
#define MINCHES 3  	/* OBJECT in TREE #28 */
#define MPICAS 4  	/* OBJECT in TREE #28 */
#define MCENT 5  	/* OBJECT in TREE #28 */
#define DPTDRS 111  	/* OBJECT in TREE #19 */
#define MDTDRS 112  	/* OBJECT in TREE #19 */
#define DICTMN 114  	/* OBJECT in TREE #19 */
#define HYLANMN 119  	/* OBJECT in TREE #19 */
#define PWUPFLMN 120  	/* OBJECT in TREE #19 */
#define CHARCPMN 121  	/* OBJECT in TREE #19 */
#define HYPARMN 122  	/* OBJECT in TREE #19 */
#define JUSTMN 123  	/* OBJECT in TREE #19 */
#define WSPMN 124  	/* OBJECT in TREE #19 */
#define RUNLINK 80  	/* OBJECT in TREE #19 */
#define GRTHRU 16  	/* OBJECT in TREE #26 */
#define GRSKIP 17  	/* OBJECT in TREE #26 */
#define GRAROUND 18  	/* OBJECT in TREE #26 */
#define GRBOFF 19  	/* OBJECT in TREE #26 */
#define ADEFER 73  	/* OBJECT in TREE #19 */
#define OGRIDSP 150  	/* OBJECT in TREE #19 */
#define OSHOWGR 151  	/* OBJECT in TREE #19 */
#define GRIDSP 31  	/* TREE */
#define GRIDOK 7  	/* OBJECT in TREE #31 */
#define GRIDCAN 8  	/* OBJECT in TREE #31 */
#define GRBUT1 3  	/* OBJECT in TREE #31 */
#define GRBUT2 4  	/* OBJECT in TREE #31 */
#define GRBUT3 5  	/* OBJECT in TREE #31 */
#define GRBUT4 6  	/* OBJECT in TREE #31 */
#define PAGESIZE 32  	/* TREE */
#define PSIZEOK 7  	/* OBJECT in TREE #32 */
#define PSCANCEL 8  	/* OBJECT in TREE #32 */
#define PA4 3  	/* OBJECT in TREE #32 */
#define PB5 4  	/* OBJECT in TREE #32 */
#define PLETTER 5  	/* OBJECT in TREE #32 */
#define PLEGAL 6  	/* OBJECT in TREE #32 */
#define PRULER 147  	/* OBJECT in TREE #19 */
#define PUNITS 148  	/* OBJECT in TREE #19 */
#define OSNAP 152  	/* OBJECT in TREE #19 */
#define SPDEF 125  	/* OBJECT in TREE #19 */
#define FLOADCLI 28  	/* OBJECT in TREE #19 */
#define FSAVECLI 29  	/* OBJECT in TREE #19 */
#define PCLTOP 56  	/* OBJECT in TREE #19 */
#define PPTOCL 57  	/* OBJECT in TREE #19 */
#define CLIPTREE 30  	/* TREE */
#define CLCUR 3  	/* OBJECT in TREE #30 */
#define CLALL 6  	/* OBJECT in TREE #30 */
#define CLODD 4  	/* OBJECT in TREE #30 */
#define CLEVEN 5  	/* OBJECT in TREE #30 */
#define CLFROM 7  	/* OBJECT in TREE #30 */
#define CLTO 8  	/* OBJECT in TREE #30 */
#define CLOK 9  	/* OBJECT in TREE #30 */
#define CLCANCEL 10  	/* OBJECT in TREE #30 */
#define CLIPOBJ 12  	/* OBJECT in TREE #21 */
#define PDELCLIP 58  	/* OBJECT in TREE #19 */
#define OUTPUT 33  	/* TREE */
#define OPRINT 13  	/* OBJECT in TREE #33 */
#define OCANCEL 14  	/* OBJECT in TREE #33 */
#define OCOPIES 4  	/* OBJECT in TREE #33 */
#define OFROMPAG 6  	/* OBJECT in TREE #33 */
#define OTOPAGE 8  	/* OBJECT in TREE #33 */
#define RSCANOFF 88  	/* OBJECT in TREE #19 */
#define SCANOFF 24  	/* TREE */
#define SSCANVAL 2  	/* OBJECT in TREE #24 */
#define SCANOK 5  	/* OBJECT in TREE #24 */
#define SCANCAN 6  	/* OBJECT in TREE #24 */
#define PINSERT 54  	/* OBJECT in TREE #19 */
#define REGCOORD 34  	/* TREE */
#define RUPLEFT 9  	/* OBJECT in TREE #34 */
#define RUPRIGHT 10  	/* OBJECT in TREE #34 */
#define REGWIDTH 11  	/* OBJECT in TREE #34 */
#define RHEIGHT 12  	/* OBJECT in TREE #34 */
#define RCANCEL 8  	/* OBJECT in TREE #34 */
#define ROK 7  	/* OBJECT in TREE #34 */
#define RCOORD 89  	/* OBJECT in TREE #19 */
#define REGUNITS 13  	/* OBJECT in TREE #34 */
#define ICBOX2 4  	/* OBJECT in TREE #21 */
#define ICBOX3 5  	/* OBJECT in TREE #21 */
#define ICBOX4 6  	/* OBJECT in TREE #21 */
#define ICBOX5 7  	/* OBJECT in TREE #21 */
#define ICBOX6 8  	/* OBJECT in TREE #21 */
#define ICBOX7 9  	/* OBJECT in TREE #21 */
#define OADDPRIM 102  	/* OBJECT in TREE #19 */
#define ODELPRIM 104  	/* OBJECT in TREE #19 */
#define ICBOX1 3  	/* OBJECT in TREE #21 */
#define ICBOX8 10  	/* OBJECT in TREE #21 */
#define PATHS 35  	/* TREE */
#define PATHTEXT 9  	/* OBJECT in TREE #35 */
#define PATHCLIP 10  	/* OBJECT in TREE #35 */
#define PATHGRAP 11  	/* OBJECT in TREE #35 */
#define PATHOK 15  	/* OBJECT in TREE #35 */
#define PATHCANC 16  	/* OBJECT in TREE #35 */
#define SPATHS 126  	/* OBJECT in TREE #19 */
#define PATHDOC 14  	/* OBJECT in TREE #35 */
#define IPI1 6  	/* OBJECT in TREE #25 */
#define RPLREG 22  	/* OBJECT in TREE #26 */
#define RPLIMG 23  	/* OBJECT in TREE #26 */
#define TEXT 10  	/* OBJECT in TREE #19 */
#define SELART 129  	/* OBJECT in TREE #19 */
#define GETXT 130  	/* OBJECT in TREE #19 */
#define DELTXT 132  	/* OBJECT in TREE #19 */
#define BUFTXT 133  	/* OBJECT in TREE #19 */
#define CPYTXT 134  	/* OBJECT in TREE #19 */
#define FORFIND 136  	/* OBJECT in TREE #19 */
#define REVFIND 137  	/* OBJECT in TREE #19 */
#define RPLC 138  	/* OBJECT in TREE #19 */
#define SETMARK 140  	/* OBJECT in TREE #19 */
#define JPMARK 141  	/* OBJECT in TREE #19 */
#define INSLTAG 144  	/* OBJECT in TREE #19 */
#define DELTAG 145  	/* OBJECT in TREE #19 */
#define OPCOORD 106  	/* OBJECT in TREE #19 */
#define PRMCOORD 36  	/* TREE */
#define PRIMUNIT 3  	/* OBJECT in TREE #36 */
#define PUPLEFT 5  	/* OBJECT in TREE #36 */
#define PUPRIGHT 7  	/* OBJECT in TREE #36 */
#define PWIDTH 9  	/* OBJECT in TREE #36 */
#define PHEIGHT 11  	/* OBJECT in TREE #36 */
#define PCANCEL 13  	/* OBJECT in TREE #36 */
#define POK 12  	/* OBJECT in TREE #36 */
#define BGICON 2  	/* OBJECT in TREE #21 */
#define FNTNME 3  	/* OBJECT in TREE #22 */
#define FNTBAK 2  	/* OBJECT in TREE #22 */
#define FNTFWD 4  	/* OBJECT in TREE #22 */
#define RMOVEFNT 91  	/* OBJECT in TREE #19 */
#define RMOVEBAK 92  	/* OBJECT in TREE #19 */
#define OMOVEFNT 108  	/* OBJECT in TREE #19 */
#define OMOVEBAK 109  	/* OBJECT in TREE #19 */
#define FKERNON 17  	/* OBJECT in TREE #22 */
#define FKERNOFF 18  	/* OBJECT in TREE #22 */
#define FREVON 21  	/* OBJECT in TREE #22 */
#define FREVOFF 22  	/* OBJECT in TREE #22 */
#define TOPTIONS 11  	/* OBJECT in TREE #19 */
#define SETTMPL 39  	/* TREE */
#define OEDITTMP 154  	/* OBJECT in TREE #19 */
#define ODISPTMP 155  	/* OBJECT in TREE #19 */
#define OTMPLOPT 156  	/* OBJECT in TREE #19 */
#define OERASETP 158  	/* OBJECT in TREE #19 */
#define SETTBOTH 7  	/* OBJECT in TREE #39 */
#define SETTLEFT 8  	/* OBJECT in TREE #39 */
#define SETTRITE 9  	/* OBJECT in TREE #39 */
#define SETTFRNT 15  	/* OBJECT in TREE #39 */
#define SETTBACK 14  	/* OBJECT in TREE #39 */
#define SETTCANC 17  	/* OBJECT in TREE #39 */
#define SETTOK 16  	/* OBJECT in TREE #39 */
#define FLOADTMP 31  	/* OBJECT in TREE #19 */
#define FSAVETMP 32  	/* OBJECT in TREE #19 */
#define ODELTMPL 160  	/* OBJECT in TREE #19 */
#define PPAGENUM 60  	/* OBJECT in TREE #19 */
#define SNF1 0		/* FREE STRING */
#define SNF2 1		/* FREE STRING */
#define SNF3 2		/* FREE STRING */
#define YSMS 3		/* FREE STRING */
#define NOMS 4		/* FREE STRING */
#define KDMS1 5		/* FREE STRING */
#define KDMS2 6		/* FREE STRING */
#define CMENU 7		/* FREE STRING */
#define GMENU 8		/* FREE STRING */
#define BMENU 10		/* FREE STRING */
#define INMS 11		/* FREE STRING */
#define OVMS 12		/* FREE STRING */
#define DMENU 9		/* FREE STRING */
#define IGTAG 13		/* FREE STRING */
#define TRANMN 116  	/* OBJECT in TREE #19 */
#define PAGENUMS 40  	/* TREE */
#define PLEFT 5  	/* OBJECT in TREE #40 */
#define PRIGHT 6  	/* OBJECT in TREE #40 */
#define PBOTH 7  	/* OBJECT in TREE #40 */
#define PTOP 33  	/* OBJECT in TREE #40 */
#define PBOTTOM 34  	/* OBJECT in TREE #40 */
#define PSTRING 54  	/* OBJECT in TREE #40 */
#define PTDIST 36  	/* OBJECT in TREE #40 */
#define PDIST 37  	/* OBJECT in TREE #40 */
#define PAGEUNIT 39  	/* OBJECT in TREE #40 */
#define PLARROW 21  	/* OBJECT in TREE #40 */
#define PRARROW 22  	/* OBJECT in TREE #40 */
#define PFNAME 20  	/* OBJECT in TREE #40 */
#define PFNUM 24  	/* OBJECT in TREE #40 */
#define PPOINTS 26  	/* OBJECT in TREE #40 */
#define PSETSIZE 28  	/* OBJECT in TREE #40 */
#define PDISPNUM 42  	/* OBJECT in TREE #40 */
#define PAGEOK 45  	/* OBJECT in TREE #40 */
#define PAGECANC 46  	/* OBJECT in TREE #40 */
#define PLJLEFT 13  	/* OBJECT in TREE #40 */
#define PLJCNTRE 14  	/* OBJECT in TREE #40 */
#define PLJRIGHT 15  	/* OBJECT in TREE #40 */
#define PRJLEFT 9  	/* OBJECT in TREE #40 */
#define PRJCNTRE 10  	/* OBJECT in TREE #40 */
#define PRJRIGHT 11  	/* OBJECT in TREE #40 */
#define PNUMFROM 50  	/* OBJECT in TREE #40 */
#define PNUMTO 52  	/* OBJECT in TREE #40 */
#define AAUTOFL 67  	/* OBJECT in TREE #19 */
#define ASAVEART 71  	/* OBJECT in TREE #19 */
#define AUTOFL 29  	/* TREE */
#define AFFROM 1  	/* OBJECT in TREE #29 */
#define AFTO 2  	/* OBJECT in TREE #29 */
#define AFOK 3  	/* OBJECT in TREE #29 */
#define AFCANCEL 4  	/* OBJECT in TREE #29 */
#define MCICERO 6  	/* OBJECT in TREE #28 */
#define ODPI 162  	/* OBJECT in TREE #19 */
#define DOTS 37  	/* TREE */
#define VDPIDAT 6  	/* OBJECT in TREE #37 */
#define HDPIDAT 4  	/* OBJECT in TREE #37 */
#define DOTCANC 8  	/* OBJECT in TREE #37 */
#define DOTOK 7  	/* OBJECT in TREE #37 */
#define INSTAG 143  	/* OBJECT in TREE #19 */
#define GLOBTAG 41  	/* TREE */
#define GTAG1 1  	/* OBJECT in TREE #41 */
#define GTAG2 2  	/* OBJECT in TREE #41 */
#define GTAG3 3  	/* OBJECT in TREE #41 */
#define GTAG4 4  	/* OBJECT in TREE #41 */
#define GTAG5 5  	/* OBJECT in TREE #41 */
#define GTAG6 6  	/* OBJECT in TREE #41 */
#define GTAG7 7  	/* OBJECT in TREE #41 */
#define GTAG8 8  	/* OBJECT in TREE #41 */
#define GTAG9 9  	/* OBJECT in TREE #41 */
#define GTAG10 10  	/* OBJECT in TREE #41 */
#define GTAG11 11  	/* OBJECT in TREE #41 */
#define GTAG12 12  	/* OBJECT in TREE #41 */
#define GTAG13 13  	/* OBJECT in TREE #41 */
#define GTAG14 14  	/* OBJECT in TREE #41 */
#define GTAG15 15  	/* OBJECT in TREE #41 */
#define GTAG16 16  	/* OBJECT in TREE #41 */
#define GTAGOK 18  	/* OBJECT in TREE #41 */
#define GTAGNOK 19  	/* OBJECT in TREE #41 */
#define GTAGMOD 20  	/* OBJECT in TREE #41 */
#define PERIMON 27  	/* OBJECT in TREE #26 */
#define PERIMOFF 28  	/* OBJECT in TREE #26 */
#define GRLWID 29  	/* OBJECT in TREE #26 */
#define GRPIXWID 33  	/* OBJECT in TREE #26 */
#define GRPTSWID 34  	/* OBJECT in TREE #26 */
#define SDEFPARM 127  	/* OBJECT in TREE #19 */
#define DTOUCH 1  	/* OBJECT in TREE #20 */
#define CREDITS 42  	/* TREE */
#define FDINFO 39  	/* OBJECT in TREE #19 */
#define OCACHE 163  	/* OBJECT in TREE #19 */
#define DOCINFO 43  	/* TREE */
#define DI1 8  	/* OBJECT in TREE #43 */
#define DI2 9  	/* OBJECT in TREE #43 */
#define DI3 10  	/* OBJECT in TREE #43 */
#define DI4 11  	/* OBJECT in TREE #43 */
#define DI5 12  	/* OBJECT in TREE #43 */
#define DI6 13  	/* OBJECT in TREE #43 */
#define DI7 14  	/* OBJECT in TREE #43 */
#define DI8 15  	/* OBJECT in TREE #43 */
#define DI9 16  	/* OBJECT in TREE #43 */
#define DI10 17  	/* OBJECT in TREE #43 */
#define DIDOC 30  	/* OBJECT in TREE #43 */
#define DITMPLTE 31  	/* OBJECT in TREE #43 */
#define DICLIP 32  	/* OBJECT in TREE #43 */
#define DITEXT 27  	/* OBJECT in TREE #43 */
#define DIGRAPH 28  	/* OBJECT in TREE #43 */
#define DIEXIT 25  	/* OBJECT in TREE #43 */
#define DISLIDE 22  	/* OBJECT in TREE #43 */
#define DIVERT 21  	/* OBJECT in TREE #43 */
#define DBOX 7  	/* OBJECT in TREE #43 */
#define DIUP 19  	/* OBJECT in TREE #43 */
#define DIDOWN 20  	/* OBJECT in TREE #43 */
#define ILTAG 14		/* FREE STRING */
#define DOCPAGE 5  	/* OBJECT in TREE #43 */
#define PICMD 44  	/* TREE */
#define PINUM 3  	/* OBJECT in TREE #44 */
#define PIOK 4  	/* OBJECT in TREE #44 */
#define PINOK 5  	/* OBJECT in TREE #44 */
#define FLOADTAG 34  	/* OBJECT in TREE #19 */
#define FSAVETAG 35  	/* OBJECT in TREE #19 */
#define OPRINTER 10  	/* OBJECT in TREE #33 */
#define OTDO 12  	/* OBJECT in TREE #33 */
#define TAGMENU 45  	/* TREE */
#define SETSZ 30  	/* OBJECT in TREE #45 */
#define PTSIZE 29  	/* OBJECT in TREE #45 */
#define FTNUM 32  	/* OBJECT in TREE #45 */
#define ADVLD 9  	/* OBJECT in TREE #45 */
#define REVLD 10  	/* OBJECT in TREE #45 */
#define HORMVR 13  	/* OBJECT in TREE #45 */
#define HORMVL 15  	/* OBJECT in TREE #45 */
#define AVCC 18  	/* OBJECT in TREE #45 */
#define MCC 24  	/* OBJECT in TREE #45 */
#define KERNON 41  	/* OBJECT in TREE #45 */
#define KERNOFF 42  	/* OBJECT in TREE #45 */
#define RVON 47  	/* OBJECT in TREE #45 */
#define RVOFF 48  	/* OBJECT in TREE #45 */
#define JUSTMD 53  	/* OBJECT in TREE #45 */
#define LEFTMD 54  	/* OBJECT in TREE #45 */
#define CENTERMD 56  	/* OBJECT in TREE #45 */
#define RIGHTMD 55  	/* OBJECT in TREE #45 */
#define POSLSPC 60  	/* OBJECT in TREE #45 */
#define NEGLSP 61  	/* OBJECT in TREE #45 */
#define MINSP 79  	/* OBJECT in TREE #45 */
#define PRFSP 80  	/* OBJECT in TREE #45 */
#define MAXSP 82  	/* OBJECT in TREE #45 */
#define INSCH 78  	/* OBJECT in TREE #45 */
#define SUCHYH 73  	/* OBJECT in TREE #45 */
#define BEFHYP 74  	/* OBJECT in TREE #45 */
#define AFTHYP 75  	/* OBJECT in TREE #45 */
#define TAGOK 76  	/* OBJECT in TREE #45 */
#define TAGCAN 81  	/* OBJECT in TREE #45 */
#define TAGLEFT 31  	/* OBJECT in TREE #45 */
#define TAGRIGHT 36  	/* OBJECT in TREE #45 */
#define FOFG 2  	/* OBJECT in TREE #45 */
#define FOFFFG 34  	/* OBJECT in TREE #45 */
#define SSCMD 4  	/* OBJECT in TREE #45 */
#define PSCMD 3  	/* OBJECT in TREE #45 */
#define FTCMD 5  	/* OBJECT in TREE #45 */
#define ALDCMD 7  	/* OBJECT in TREE #45 */
#define RLDCMD 8  	/* OBJECT in TREE #45 */
#define MVRCMD 12  	/* OBJECT in TREE #45 */
#define MVLCMD 14  	/* OBJECT in TREE #45 */
#define AVCCMD 17  	/* OBJECT in TREE #45 */
#define MCCMD 23  	/* OBJECT in TREE #45 */
#define KNCMD 38  	/* OBJECT in TREE #45 */
#define REVCMD 44  	/* OBJECT in TREE #45 */
#define JUSTCMD 50  	/* OBJECT in TREE #45 */
#define LSPCMD 58  	/* OBJECT in TREE #45 */
#define SPCCMD 65  	/* OBJECT in TREE #45 */
#define INCHCMD 66  	/* OBJECT in TREE #45 */
#define HYCMD 68  	/* OBJECT in TREE #45 */
#define MCON 26  	/* OBJECT in TREE #45 */
#define MCOFF 27  	/* OBJECT in TREE #45 */
#define LSPMDON 63  	/* OBJECT in TREE #45 */
#define LSPMDOFF 64  	/* OBJECT in TREE #45 */
#define HYON 71  	/* OBJECT in TREE #45 */
#define HYOFF 72  	/* OBJECT in TREE #45 */
#define AVCON 20  	/* OBJECT in TREE #45 */
#define AVCOFF 21  	/* OBJECT in TREE #45 */
#define TAGNUM 33  	/* OBJECT in TREE #45 */
#define MTAG 1  	/* OBJECT in TREE #45 */
#define ARLDBOX 6  	/* OBJECT in TREE #45 */
#define RLMVBOX 11  	/* OBJECT in TREE #45 */
#define AVCCBOX 16  	/* OBJECT in TREE #45 */
#define MCCBOX 22  	/* OBJECT in TREE #45 */
#define KRNBOX 37  	/* OBJECT in TREE #45 */
#define REVBOX 43  	/* OBJECT in TREE #45 */
#define LSPBOX 57  	/* OBJECT in TREE #45 */
#define JSTBOX 49  	/* OBJECT in TREE #45 */
#define HYPBOX 67  	/* OBJECT in TREE #45 */
#define FILEBUF 38  	/* TREE */
#define FBUFSIZE 4  	/* OBJECT in TREE #38 */
#define FBUFOK 1  	/* OBJECT in TREE #38 */
#define FBUFCANC 2  	/* OBJECT in TREE #38 */
#define PPORT 10  	/* OBJECT in TREE #32 */
#define PLAND 11  	/* OBJECT in TREE #32 */
