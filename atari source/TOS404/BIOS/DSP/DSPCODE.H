		 /* (24 * 8) + (9*6) = 192 + 54 = 246 bytes   */
		 /* = 82 dsp words for BOOTLDSIZE	      */
		 /* Note 192 is the size up until the body of */
		 /* code at $40 therefore it will not change  */

char bootld[] = {0x0a, 0xf0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x0b, 0xf0, 0x80, 0x00, 0x7f, 0x00, 0x0b, 0xf0,
		 0x80, 0x00, 0x7e, 0xef, 0x0b, 0xf0, 0x80, 0x00,
		 0x7e, 0xdc, 0x0b, 0xf0, 0x80, 0x00, 0x7f, 0x00,
		 
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 
		/************************************************/
		/* Body of code from $40 goes here		*/
		/************************************************/

		0x08, 0xF4, 0xA8,     0x00, 0x00, 0x04, 
		0x08, 0xF4, 0xBF,     0x00, 0x0C, 0x00, 
		0x00, 0xFE, 0xB8,     0x08, 0xF4, 0xA0, 
		0x00, 0x00, 0x01,     0x08, 0xF4, 0xBE, 
		0x00, 0x00, 0x00,     0x60, 0xF4, 0x00, 
		0x00, 0x7E, 0xA9,     0x31, 0x98, 0x00, 
		0x06, 0xD1, 0x00,     0x00, 0x00, 0x50, 
		0x0A, 0xA9, 0x80,     0x00, 0x00, 0x4E, 
		0x08, 0x58, 0x6B,     0x0C, 0x00, 0x51

		 };


char pload[] = {
		/* Program loader -153- */
		0x08, 0xF4, 0xA0,     0x00, 0x00, 0x01, 
		0x08, 0xF4, 0xBE,     0x00, 0x00, 0x00, 
		0x0A, 0xA9, 0x80,     0x00, 0x7E, 0xAD, 
		0x20, 0x00, 0x13,     0x08, 0x4C, 0x2B, 
		0x45, 0xF4, 0x00,     0x00, 0x00, 0x03, 
		0x20, 0x00, 0x65,     0x0E, 0xA0, 0x00, 
		0x0A, 0xA9, 0x80,     0x00, 0x7E, 0xB5, 
		0x08, 0x50, 0x2B,     0x0A, 0xA9, 0x80, 
		0x00, 0x7E, 0xB8,     0x08, 0x51, 0x2B, 
		0x45, 0xF4, 0x00,     0x00, 0x00, 0x01, 
		0x20, 0x00, 0x65,     0x0A, 0xF0, 0xAA, 
		0x00, 0x7E, 0xCE,     0x45, 0xF4, 0x00, 
		0x00, 0x00, 0x02,     0x20, 0x00, 0x65, 
		0x0A, 0xF0, 0xAA,     0x00, 0x7E, 0xD5, 
		0x0A, 0xF0, 0x80,     0x00, 0x7E, 0xC7, 
		0x06, 0xD1, 0x00,     0x00, 0x7E, 0xCB, 
		0x0A, 0xA9, 0x80,     0x00, 0x7E, 0xC9, 
		0x08, 0x58, 0x6B,     0x0A, 0xF0, 0x80, 
		0x00, 0x7E, 0xAD,     0x06, 0xD1, 0x00, 
		0x00, 0x7E, 0xD2,     0x0A, 0xA9, 0x80, 
		0x00, 0x7E, 0xD0,     0x08, 0x58, 0xAB, 
		0x0A, 0xF0, 0x80,     0x00, 0x7E, 0xAD, 
		0x06, 0xD1, 0x00,     0x00, 0x7E, 0xD9, 
		0x0A, 0xA9, 0x80,     0x00, 0x7E, 0xD7, 
		0x08, 0x58, 0xEB,     0x0A, 0xF0, 0x80, 
		0x00, 0x7E, 0xAD,     

		/* Block Mover -57- */
		0x08, 0xF4, 0xA0,     0x00, 0x00, 0x01, 
		0x08, 0xF4, 0xBE,     0x00, 0x00, 0x00, 
		0x0A, 0xA9, 0x80,     0x00, 0x7E, 0xE0, 
		0x08, 0x50, 0x2B,     0x0A, 0xA9, 0x80, 
		0x00, 0x7E, 0xE3,     0x08, 0x51, 0x2B, 
		0x0A, 0xA9, 0x80,     0x00, 0x7E, 0xE6, 
		0x08, 0x52, 0x2B,     0x06, 0xD2, 0x00, 
		0x00, 0x7E, 0xEC,     0x07, 0xD0, 0x8C, 
		0x07, 0x51, 0x8C,     0x00, 0x00, 0x00, 
		0x00, 0x00, 0x04,     

		/* Subroutine Loader -51- */ 
		0x08, 0xf4, 0xa0, 0x00, 0x00, 0x01, 0x08, 0xf4,
		0xbe, 0x00, 0x00, 0x00, 0x0a, 0xa9, 0x80, 0x00,
		0x7e, 0xf3, 0x08, 0x50, 0x2b, 0x0a, 0xa9, 0x80,
		0x00, 0x7e, 0xf6, 0x08, 0x51, 0x2b, 0x06, 0xd1,
		0x00, 0x00, 0x7e, 0xfd, 0x0a, 0xa9, 0x80, 0x00,
		0x7e, 0xfb, 0x08, 0x58, 0x6b, 0x00, 0x00, 0x00,
		0x00, 0x00, 0x04,

		/* Debug - Memory downloader    			*/
		/* Note - this is a temporary routine that resides in   */
		/* subroutine BSS	 old -57- new -195-		*/

		0x08, 0xF4, 0xA0,     0x00, 0x00, 0x01, 
		0x08, 0xF4, 0xBE,     0x00, 0x00, 0x00, 
		0x0A, 0xA9, 0x80,     0x00, 0x7F, 0x04, 
		0x20, 0x00, 0x13,     0x08, 0x4C, 0x2B, 
		0x45, 0xF4, 0x00,     0x00, 0x00, 0x01, 
		0x20, 0x00, 0x65,     0x0A, 0xF0, 0xAA, 
		0x00, 0x7F, 0x23,     0x45, 0xF4, 0x00, 
		0x00, 0x00, 0x02,     0x20, 0x00, 0x65, 
		0x0A, 0xF0, 0xAA,     0x00, 0x7F, 0x32, 
		0x0A, 0xF0, 0x80,     0x00, 0x7F, 0x14, 
		0x0A, 0xA9, 0x80,     0x00, 0x7F, 0x14, 
		0x08, 0x50, 0x2B,     0x0A, 0xA9, 0x80, 
		0x00, 0x7F, 0x17,     0x08, 0x51, 0x2B, 
		0x06, 0xD1, 0x00,     0x00, 0x7F, 0x20, 
		0x07, 0xD8, 0x8C,     0x0A, 0xA9, 0x81, 
		0x00, 0x7F, 0x1D,     0x54, 0x70, 0x00, 
		0x00, 0xFF, 0xEB,     0x00, 0x00, 0x00, 
		0x00, 0x00, 0x04,     0x0A, 0xA9, 0x80, 
		0x00, 0x7F, 0x23,     0x08, 0x50, 0x2B, 
		0x0A, 0xA9, 0x80,     0x00, 0x7F, 0x26, 
		0x08, 0x51, 0x2B,     0x06, 0xD1, 0x00, 
		0x00, 0x7F, 0x2F,     0x54, 0xD8, 0x00, 
		0x0A, 0xA9, 0x81,     0x00, 0x7F, 0x2C, 
		0x54, 0x70, 0x00,     0x00, 0xFF, 0xEB, 
		0x00, 0x00, 0x00,     0x00, 0x00, 0x04, 
		0x0A, 0xA9, 0x80,     0x00, 0x7F, 0x32, 
		0x08, 0x50, 0x2B,     0x0A, 0xA9, 0x80, 
		0x00, 0x7F, 0x35,     0x08, 0x51, 0x2B, 
		0x06, 0xD1, 0x00,     0x00, 0x7F, 0x3E, 
		0x5C, 0xD8, 0x00,     0x0A, 0xA9, 0x81, 
		0x00, 0x7F, 0x3B,     0x54, 0x70, 0x00, 
		0x00, 0xFF, 0xEB,     0x00, 0x00, 0x00, 
		0x00, 0x00, 0x04     
		};

		 /************************************************/
		 /*  This call simply jmps to the program loader */
		 /*  location. (Needs change if program loader   */
		 /*  changes position. Actual Dsp code not	 */
		 /*  maintained.  All changes to jump address    */
		 /*  patched in here				 */
		 /************************************************/

char bootjmp[] = {
		 0x0a, 0xf0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
		 
		 /* I'm not quite sure what the rest of this is  */
		 /* But the jump to the program loader is at the */
		 /* end						 */

		 0x08, 0xf4, 0xa8, 0x00, 0x00, 0x04, 0x08, 0xf4,
		 0xbf, 0x00, 0x0c, 0x00, 0x00, 0xfe, 0xb8, 0x0a,
		 0xf0, 0x80, 0x00, 0x7e, 0xa9
		 };

