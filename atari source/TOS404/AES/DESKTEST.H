#define STNOAPPL 92  	/* STRING */
#define STNOWIND 93  	/* STRING */
#define ADFILEIN 1  	/* TREE */
#define ADDISKIN 2  	/* TREE */
#define ADDINFO 3  	/* TREE */
#define ADOPENAP 4  	/* TREE */
#define ADINSDIS 5  	/* TREE */
#define ADMKDBOX 6  	/* TREE */
#define STFOEXIS 94  	/* STRING */
#define STDISKFU 95  	/* STRING */
#define STFO8DEE 96  	/* STRING */
#define STBADCOP 97  	/* STRING */
#define ADFORMAT 7  	/* TREE */
#define DRID 2  	/* OBJECT in TREE #5 */
#define DRLABEL 3  	/* OBJECT in TREE #5 */
#define DROK 14  	/* OBJECT in TREE #5 */
#define DRCNCL 15  	/* OBJECT in TREE #5 */
#define MKNAME 1  	/* OBJECT in TREE #6 */
#define MKOK 2  	/* OBJECT in TREE #6 */
#define FINAME 5  	/* OBJECT in TREE #1 */
#define FISIZE 6  	/* OBJECT in TREE #1 */
#define FIDATE 7  	/* OBJECT in TREE #1 */
#define FITIME 8  	/* OBJECT in TREE #1 */
#define FIATTRS 13  	/* OBJECT in TREE #1 */
#define FIOK 14  	/* OBJECT in TREE #1 */
#define FISKIP 15  	/* OBJECT in TREE #1 */
#define DIDRIVE 2  	/* OBJECT in TREE #2 */
#define DIVOLUME 3  	/* OBJECT in TREE #2 */
#define DINFOLDS 4  	/* OBJECT in TREE #2 */
#define DINFILES 5  	/* OBJECT in TREE #2 */
#define DIUSED 6  	/* OBJECT in TREE #2 */
#define DIAVAIL 7  	/* OBJECT in TREE #2 */
#define DIOK 8  	/* OBJECT in TREE #2 */
#define DEOK 9  	/* OBJECT in TREE #3 */
#define APPLNAME 1  	/* OBJECT in TREE #4 */
#define APPLPARM 3  	/* OBJECT in TREE #4 */
#define APPLOK 4  	/* OBJECT in TREE #4 */
#define APPLCNCL 5  	/* OBJECT in TREE #4 */
#define TRSINFO 98  	/* STRING */
#define FINFOLDS 9  	/* OBJECT in TREE #1 */
#define FINFILES 10  	/* OBJECT in TREE #1 */
#define FIRONLY 11  	/* OBJECT in TREE #1 */
#define FIRWRITE 12  	/* OBJECT in TREE #1 */
#define FCCOPY 7  	/* OBJECT in TREE #7 */
#define FCFORMAT 18  	/* OBJECT in TREE #7 */
#define FCSINGLE 16  	/* OBJECT in TREE #7 */
#define FCDOUBLE 15  	/* OBJECT in TREE #7 */
#define FCOK 23  	/* OBJECT in TREE #7 */
#define FCCNCL 24  	/* OBJECT in TREE #7 */
#define FCBARA 20  	/* OBJECT in TREE #7 */
#define FCNOMEM 99  	/* STRING */
#define FCFAIL 100  	/* STRING */
#define FCLABEL 13  	/* OBJECT in TREE #7 */
#define FCSIZE 101  	/* STRING */
#define FCNOTYPE 102  	/* STRING */
#define SIDEBOX 14  	/* OBJECT in TREE #7 */
#define SAVETOP 103  	/* STRING */
#define PRINTTOP 104  	/* STRING */
#define PRINTFIL 9  	/* TREE */
#define PFILE 1  	/* OBJECT in TREE #9 */
#define BDRIVE 12  	/* OBJECT in TREE #7 */
#define ADRIVE 11  	/* OBJECT in TREE #7 */
#define SRCDRA 4  	/* OBJECT in TREE #7 */
#define SRCDRB 5  	/* OBJECT in TREE #7 */
#define LINEBOX 8  	/* OBJECT in TREE #7 */
#define FCBOXF 9  	/* OBJECT in TREE #7 */
#define DRIVE 10  	/* OBJECT in TREE #7 */
#define FCBOX4 1  	/* OBJECT in TREE #7 */
#define FCBARB 22  	/* OBJECT in TREE #7 */
#define ABORTCON 105  	/* STRING */
#define INFTITLE 1  	/* OBJECT in TREE #1 */
#define NOICON 106  	/* STRING */
#define NOAPP 107  	/* STRING */
#define FCBOXC 2  	/* OBJECT in TREE #7 */
#define DESTDR 6  	/* OBJECT in TREE #7 */
#define ADMENU 0  	/* TREE */
#define ADICON 8  	/* TREE */
#define DESKMENU 3  	/* OBJECT in TREE #0 */
#define FILEMENU 4  	/* OBJECT in TREE #0 */
#define VIEWMENU 5  	/* OBJECT in TREE #0 */
#define OPTNMENU 6  	/* OBJECT in TREE #0 */
#define ABOUITEM 9  	/* OBJECT in TREE #0 */
#define OPENITEM 18  	/* OBJECT in TREE #0 */
#define SHOWITEM 19  	/* OBJECT in TREE #0 */
#define NEWFITEM 24  	/* OBJECT in TREE #0 */
#define CLSFITEM 25  	/* OBJECT in TREE #0 */
#define CLSWITEM 26  	/* OBJECT in TREE #0 */
#define FORMITEM 31  	/* OBJECT in TREE #0 */
#define ICONITEM 33  	/* OBJECT in TREE #0 */
#define TEXTITEM 34  	/* OBJECT in TREE #0 */
#define NAMEITEM 36  	/* OBJECT in TREE #0 */
#define DATEITEM 37  	/* OBJECT in TREE #0 */
#define SIZEITEM 38  	/* OBJECT in TREE #0 */
#define TYPEITEM 39  	/* OBJECT in TREE #0 */
#define IDSKITEM 46  	/* OBJECT in TREE #0 */
#define IAPPITEM 47  	/* OBJECT in TREE #0 */
#define PREFITEM 51  	/* OBJECT in TREE #0 */
#define SAVEITEM 56  	/* OBJECT in TREE #0 */
#define PRINTITE 57  	/* OBJECT in TREE #0 */
#define BITBLT 60  	/* OBJECT in TREE #0 */
#define L3ITEM 30  	/* OBJECT in TREE #0 */
#define L4ITEM 35  	/* OBJECT in TREE #0 */
#define L5ITEM 50  	/* OBJECT in TREE #0 */
#define L6ITEM 58  	/* OBJECT in TREE #0 */
#define BACKGROU 10  	/* TREE */
#define SSCREEN 11  	/* TREE */
#define PATTERN 18  	/* OBJECT in TREE #11 */
#define SOK 36  	/* OBJECT in TREE #11 */
#define SCANCEL 37  	/* OBJECT in TREE #11 */
#define PAT0 9  	/* OBJECT in TREE #11 */
#define PAT1 10  	/* OBJECT in TREE #11 */
#define PAT2 11  	/* OBJECT in TREE #11 */
#define PAT3 12  	/* OBJECT in TREE #11 */
#define PAT4 13  	/* OBJECT in TREE #11 */
#define PAT5 14  	/* OBJECT in TREE #11 */
#define PAT6 15  	/* OBJECT in TREE #11 */
#define PAT7 16  	/* OBJECT in TREE #11 */
#define COLOR0 20  	/* OBJECT in TREE #11 */
#define COLOR1 21  	/* OBJECT in TREE #11 */
#define COLOR2 22  	/* OBJECT in TREE #11 */
#define COLOR3 23  	/* OBJECT in TREE #11 */
#define COLOR4 24  	/* OBJECT in TREE #11 */
#define COLOR5 25  	/* OBJECT in TREE #11 */
#define COLOR6 26  	/* OBJECT in TREE #11 */
#define COLOR7 27  	/* OBJECT in TREE #11 */
#define COLOR8 28  	/* OBJECT in TREE #11 */
#define COLOR9 29  	/* OBJECT in TREE #11 */
#define COLOR10 30  	/* OBJECT in TREE #11 */
#define COLOR11 31  	/* OBJECT in TREE #11 */
#define COLOR12 32  	/* OBJECT in TREE #11 */
#define COLOR13 33  	/* OBJECT in TREE #11 */
#define COLOR14 34  	/* OBJECT in TREE #11 */
#define COLOR15 35  	/* OBJECT in TREE #11 */
#define FILEOPTI 12  	/* TREE */
#define DLAUNCH 13  	/* TREE */
#define OPTNAME 2  	/* OBJECT in TREE #12 */
#define OPTOK 3  	/* OBJECT in TREE #12 */
#define ICON0 1  	/* OBJECT in TREE #8 */
#define ICON1 2  	/* OBJECT in TREE #8 */
#define ICON2 3  	/* OBJECT in TREE #8 */
#define ICON3 4  	/* OBJECT in TREE #8 */
#define ICON4 5  	/* OBJECT in TREE #8 */
#define LAUNCHOK 7  	/* OBJECT in TREE #13 */
#define RUNNAME 2  	/* OBJECT in TREE #13 */
#define LGRAPHIC 5  	/* OBJECT in TREE #13 */
#define NOSORT 40  	/* OBJECT in TREE #0 */
#define TEXTLINE 14  	/* TREE */
#define TSTYLE 1  	/* OBJECT in TREE #14 */
#define NODRIVE 108  	/* STRING */
#define NOOUTPUT 109  	/* STRING */
#define DELMENU 22  	/* OBJECT in TREE #0 */
#define SIZEFIT 42  	/* OBJECT in TREE #0 */
#define BOTTOP 27  	/* OBJECT in TREE #0 */
#define IDRIVE 6  	/* OBJECT in TREE #5 */
#define ITRASH 7  	/* OBJECT in TREE #5 */
#define IPRINTER 8  	/* OBJECT in TREE #5 */
#define IBOX 9  	/* OBJECT in TREE #5 */
#define IUP 11  	/* OBJECT in TREE #5 */
#define IDOWN 13  	/* OBJECT in TREE #5 */
#define IICON 10  	/* OBJECT in TREE #5 */
#define CNTOPEN 110  	/* STRING */
#define CNTCRTDR 111  	/* STRING */
#define WRERROR 112  	/* STRING */
#define RDERROR 113  	/* STRING */
#define CNTCRTFL 114  	/* STRING */
#define SAMENAME 15  	/* TREE */
#define COPY 4  	/* OBJECT in TREE #15 */
#define SKIP 5  	/* OBJECT in TREE #15 */
#define QUIT 6  	/* OBJECT in TREE #15 */
#define EDFNAME 3  	/* OBJECT in TREE #15 */
#define CPBOX 16  	/* TREE */
#define FNAME 2  	/* OBJECT in TREE #15 */
#define OKCP 14  	/* OBJECT in TREE #16 */
#define CCANCEL 15  	/* OBJECT in TREE #16 */
#define CPDIR 8  	/* OBJECT in TREE #16 */
#define CPFILE 7  	/* OBJECT in TREE #16 */
#define HIDECBOX 6  	/* OBJECT in TREE #16 */
#define CNTDELF 115  	/* STRING */
#define CNTDELD 116  	/* STRING */
#define PRINTINF 117  	/* STRING */
#define RENAME 118  	/* STRING */
#define NOBUF 119  	/* STRING */
#define TITLE 1  	/* OBJECT in TREE #16 */
#define NUMDIR 2  	/* OBJECT in TREE #16 */
#define NUMFILE 3  	/* OBJECT in TREE #16 */
#define REMVICON 49  	/* OBJECT in TREE #0 */
#define INWICON 17  	/* TREE */
#define WBOX 5  	/* OBJECT in TREE #17 */
#define WICON 6  	/* OBJECT in TREE #17 */
#define WOK 14  	/* OBJECT in TREE #17 */
#define WNAME 3  	/* OBJECT in TREE #17 */
#define WUP 7  	/* OBJECT in TREE #17 */
#define WDOWN 8  	/* OBJECT in TREE #17 */
#define WREMOVE 13  	/* OBJECT in TREE #17 */
#define WNONE 11  	/* OBJECT in TREE #17 */
#define OUTBOX 17  	/* OBJECT in TREE #11 */
#define WFOLDER 10  	/* OBJECT in TREE #17 */
#define SNAME 1  	/* OBJECT in TREE #15 */
#define IBOX1 2  	/* OBJECT in TREE #17 */
#define DELDISK 120  	/* STRING */
#define NOTPRG 121  	/* STRING */
#define NOAUTO 123  	/* STRING */
#define NOSETDIR 122  	/* STRING */
#define NOWINMEM 124  	/* STRING */
#define NOTYPE 125  	/* STRING */
#define ICONTYPE 126  	/* STRING */
#define NODIRCOP 127  	/* STRING */
#define CSDRIVE 4  	/* OBJECT in TREE #16 */
#define CDDRIVE 5  	/* OBJECT in TREE #16 */
#define SELALL 28  	/* OBJECT in TREE #0 */
#define INSDISK 48  	/* OBJECT in TREE #0 */
#define READINF 53  	/* OBJECT in TREE #0 */
#define FICNCL 16  	/* OBJECT in TREE #1 */
#define DIQUIT 9  	/* OBJECT in TREE #2 */
#define DRQUIT 16  	/* OBJECT in TREE #5 */
#define STITLE 1  	/* OBJECT in TREE #11 */
#define PYES 11  	/* OBJECT in TREE #16 */
#define SCOLTYPE 43  	/* OBJECT in TREE #0 */
#define WQUIT 16  	/* OBJECT in TREE #17 */
#define HELP1 18  	/* TREE */
#define DATEBOX 9  	/* OBJECT in TREE #16 */
#define SEAFILE 20  	/* TREE */
#define SFILE 2  	/* OBJECT in TREE #20 */
#define SEAMENU 20  	/* OBJECT in TREE #0 */
#define CHBOX1 13  	/* OBJECT in TREE #16 */
#define NOINSTAL 128  	/* STRING */
#define NOMORE 129  	/* STRING */
#define NOID 130  	/* STRING */
#define MKCNCL 4  	/* OBJECT in TREE #6 */
#define SEAOK 3  	/* OBJECT in TREE #20 */
#define SEACNCL 4  	/* OBJECT in TREE #20 */
#define ILLMAT 131  	/* STRING */
#define NOCART 132  	/* STRING */
#define NOMATCH 133  	/* STRING */
#define DELITEM 134  	/* STRING */
#define MCFAIL 135  	/* STRING */
#define FNOTFIND 136  	/* STRING */
#define SNEXT 137  	/* STRING */
#define NOHELP 138  	/* STRING */
#define NOSEA 139  	/* STRING */
#define LNCNCL 8  	/* OBJECT in TREE #13 */
#define EXTMENU 29  	/* OBJECT in TREE #0 */
#define MEMMENU 54  	/* OBJECT in TREE #0 */
#define DESKPREF 4  	/* OBJECT in TREE #11 */
#define WINPREF 5  	/* OBJECT in TREE #11 */
#define KEYUSED 140  	/* STRING */
#define CARTNOSH 141  	/* STRING */
#define FCHIGH 17  	/* OBJECT in TREE #7 */
#define BADKEY 142  	/* STRING */
#define FIRIGHT 4  	/* OBJECT in TREE #1 */
#define FILEFT 3  	/* OBJECT in TREE #1 */
#define FIFILE 2  	/* OBJECT in TREE #1 */
#define XNFILE 143  	/* STRING */
#define HELP2 19  	/* TREE */
#define MOREHELP 14  	/* OBJECT in TREE #18 */
#define SUPERITE 59  	/* OBJECT in TREE #0 */
#define MORE 0		/* FREE STRING */
#define ENDFILE 1		/* FREE STRING */
#define CART 2		/* FREE STRING */
#define CPYSTR 3		/* FREE STRING */
#define DELSTR 4		/* FREE STRING */
#define FILEINFO 5		/* FREE STRING */
#define FOLDINFO 6		/* FREE STRING */
#define MOVESTR 7		/* FREE STRING */
#define READERRO 8		/* FREE STRING */
#define CANTOPEN 9		/* FREE STRING */
#define NOMEM 10		/* FREE STRING */
#define CACHETXT 11		/* FREE STRING */
#define BLTTXT 12		/* FREE STRING */
#define NCONFLIC 13		/* FREE STRING */
#define RNAME 14		/* FREE STRING */
#define CRENSTR 15		/* FREE STRING */
#define MRENSTR 16		/* FREE STRING */
#define ISTR 17		/* FREE STRING */
#define ISELS 18		/* FREE STRING */
#define ISEL 19		/* FREE STRING */
#define ISTRS 20		/* FREE STRING */
#define DEVICE 21		/* FREE STRING */
#define SINF 22		/* FREE STRING */
#define LITEM 23		/* FREE STRING */
#define OBJ0 24		/* FREE STRING */
#define OBJ1 25		/* FREE STRING */
#define OBJ2 26		/* FREE STRING */
#define OBJ3 27		/* FREE STRING */
#define OBJ4 28		/* FREE STRING */
#define OBJ5 29		/* FREE STRING */
#define OBJ6 30		/* FREE STRING */
#define OBJ7 31		/* FREE STRING */
#define OBJ8 32		/* FREE STRING */
#define OBJ9 33		/* FREE STRING */
#define OBJ10 34		/* FREE STRING */
#define OBJ11 35		/* FREE STRING */
#define OBJ12 36		/* FREE STRING */
#define OBJ13 37		/* FREE STRING */
#define OBJ14 38		/* FREE STRING */
#define OBJ15 39		/* FREE STRING */
#define OBJ16 40		/* FREE STRING */
#define OBJ17 41		/* FREE STRING */
#define OBJ18 42		/* FREE STRING */
#define OBJ19 43		/* FREE STRING */
#define OBJ20 44		/* FREE STRING */
#define OBJ21 45		/* FREE STRING */
#define OBJ22 46		/* FREE STRING */
#define OBJ23 47		/* FREE STRING */
#define MNINSAPP 21  	/* TREE */
#define MNSETPRE 22  	/* TREE */
#define MNSETVID 23  	/* TREE */
#define MNVIDEO 24  	/* TREE */
#define SVOK 10  	/* OBJECT in TREE #23 */
#define SVCANCEL 11  	/* OBJECT in TREE #23 */
#define SVTTOK 2  	/* OBJECT in TREE #24 */
#define SVTTCAN 3  	/* OBJECT in TREE #24 */
#define SVMODES 8  	/* OBJECT in TREE #23 */
#define SVSTLOW 13  	/* OBJECT in TREE #24 */
#define SVTTMED 16  	/* OBJECT in TREE #24 */
#define SVCTITLE 2  	/* OBJECT in TREE #23 */
#define IBASE 9  	/* OBJECT in TREE #23 */
#define MNMENU 25  	/* TREE */
#define MNSYSTEM 26  	/* TREE */
#define SPDBUTTN 4  	/* OBJECT in TREE #22 */
#define SPCBUTTN 6  	/* OBJECT in TREE #22 */
#define SPOBUTTN 8  	/* OBJECT in TREE #22 */
#define MNSPOK 9  	/* OBJECT in TREE #22 */
#define MNSPCAN 10  	/* OBJECT in TREE #22 */
#define SDBUTTON 3  	/* OBJECT in TREE #26 */
#define SIBUTTON 5  	/* OBJECT in TREE #26 */
#define MFKEY 11  	/* OBJECT in TREE #26 */
#define MFLEFT 8  	/* OBJECT in TREE #26 */
#define MFRIGHT 10  	/* OBJECT in TREE #26 */
#define MFFILE 9  	/* OBJECT in TREE #26 */
#define MFUP 12  	/* OBJECT in TREE #26 */
#define MFDOWN 13  	/* OBJECT in TREE #26 */
#define MKITEM 17  	/* OBJECT in TREE #26 */
#define MKKEYS 20  	/* OBJECT in TREE #26 */
#define MKUPS 18  	/* OBJECT in TREE #26 */
#define MKDOWNS 19  	/* OBJECT in TREE #26 */
#define MKCLEAR 21  	/* OBJECT in TREE #26 */
#define MKMEMORY 22  	/* OBJECT in TREE #26 */
#define MOK 23  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MPFNAME 2  	/* OBJECT in TREE #21 */
#define MPARGS 3  	/* OBJECT in TREE #21 */
#define MPDTYPE 4  	/* OBJECT in TREE #21 */
#define MPIBUTTN 6  	/* OBJECT in TREE #21 */
#define MPBBUTTN 8  	/* OBJECT in TREE #21 */
#define MPFBUTTN 10  	/* OBJECT in TREE #21 */
#define MPDBUTTN 12  	/* OBJECT in TREE #21 */
#define MPPBUTTN 14  	/* OBJECT in TREE #21 */
#define MPOK 15  	/* OBJECT in TREE #21 */
#define MPREMOVE 16  	/* OBJECT in TREE #21 */
#define MPCANCEL 17  	/* OBJECT in TREE #21 */
#define MPQUIT 18  	/* OBJECT in TREE #21 */
#define SVSTMED 14  	/* OBJECT in TREE #24 */
#define SVSTHIGH 15  	/* OBJECT in TREE #24 */
#define SVTTLOW 18  	/* OBJECT in TREE #24 */
#define MPIBASE 1  	/* OBJECT in TREE #25 */
#define MPINONE 2  	/* OBJECT in TREE #25 */
#define MPIF1 3  	/* OBJECT in TREE #25 */
#define MPIF2 4  	/* OBJECT in TREE #25 */
#define MPIF3 5  	/* OBJECT in TREE #25 */
#define MPIF4 6  	/* OBJECT in TREE #25 */
#define MPIF5 7  	/* OBJECT in TREE #25 */
#define MPIF6 8  	/* OBJECT in TREE #25 */
#define MPIF7 9  	/* OBJECT in TREE #25 */
#define MPIF8 10  	/* OBJECT in TREE #25 */
#define MPIF9 11  	/* OBJECT in TREE #25 */
#define MPIF10 12  	/* OBJECT in TREE #25 */
#define MPFI11 13  	/* OBJECT in TREE #25 */
#define MPIF12 14  	/* OBJECT in TREE #25 */
#define MPIF13 15  	/* OBJECT in TREE #25 */
#define MPIF14 16  	/* OBJECT in TREE #25 */
#define MPIF15 17  	/* OBJECT in TREE #25 */
#define MPIF16 18  	/* OBJECT in TREE #25 */
#define MPIF17 19  	/* OBJECT in TREE #25 */
#define MPIF18 20  	/* OBJECT in TREE #25 */
#define MPIF19 21  	/* OBJECT in TREE #25 */
#define MPIF20 22  	/* OBJECT in TREE #25 */
#define MPFBASE 23  	/* OBJECT in TREE #25 */
#define MPFTOS 24  	/* OBJECT in TREE #25 */
#define MPFTTP 25  	/* OBJECT in TREE #25 */
#define MPFGEM 26  	/* OBJECT in TREE #25 */
#define MPFGMTTP 27  	/* OBJECT in TREE #25 */
#define SDBASE 28  	/* OBJECT in TREE #25 */
#define SDAPP 29  	/* OBJECT in TREE #25 */
#define SDTOP 30  	/* OBJECT in TREE #25 */
#define SIBASE 31  	/* OBJECT in TREE #25 */
#define SIFULL 32  	/* OBJECT in TREE #25 */
#define SIFILE 33  	/* OBJECT in TREE #25 */
#define SVLBASE 49  	/* OBJECT in TREE #25 */
#define SVL40 50  	/* OBJECT in TREE #25 */
#define SVL80 51  	/* OBJECT in TREE #25 */
#define SPBASE 37  	/* OBJECT in TREE #25 */
#define SPYES 38  	/* OBJECT in TREE #25 */
#define SPNO 39  	/* OBJECT in TREE #25 */
#define VIDBASE 40  	/* OBJECT in TREE #25 */
#define VID2 41  	/* OBJECT in TREE #25 */
#define VID4 42  	/* OBJECT in TREE #25 */
#define VID16 43  	/* OBJECT in TREE #25 */
#define VID256 44  	/* OBJECT in TREE #25 */
#define VIDTRUE 45  	/* OBJECT in TREE #25 */
#define MPBBASE 34  	/* OBJECT in TREE #25 */
#define MPBAUTO 35  	/* OBJECT in TREE #25 */
#define MPBNORML 36  	/* OBJECT in TREE #25 */
#define SVIBASE 46  	/* OBJECT in TREE #25 */
#define SVION 47  	/* OBJECT in TREE #25 */
#define SVIOFF 48  	/* OBJECT in TREE #25 */
#define FSTOS 48		/* FREE STRING */
#define FSTOSTTP 49		/* FREE STRING */
#define FSGEM 50		/* FREE STRING */
#define FSGEMTTP 51		/* FREE STRING */
#define FSAPP 52		/* FREE STRING */
#define FSTOP 53		/* FREE STRING */
#define FSFULL 54		/* FREE STRING */
#define FSFILE 55		/* FREE STRING */
#define FS40 56		/* FREE STRING */
#define FS80 57		/* FREE STRING */
#define FSYES 58		/* FREE STRING */
#define FSNO 59		/* FREE STRING */
#define FS2C 60		/* FREE STRING */
#define FS4C 61		/* FREE STRING */
#define FS16C 62		/* FREE STRING */
#define FS256C 63		/* FREE STRING */
#define FSTRUEC 64		/* FREE STRING */
#define FSAUTO 65		/* FREE STRING */
#define FSNORMAL 66		/* FREE STRING */
#define FSON 67		/* FREE STRING */
#define FSOFF 68		/* FREE STRING */
#define FSNONE 69		/* FREE STRING */
#define FSF1 70		/* FREE STRING */
#define FSF2 71		/* FREE STRING */
#define FSF3 72		/* FREE STRING */
#define FSF4 73		/* FREE STRING */
#define FSF5 74		/* FREE STRING */
#define FSF6 75		/* FREE STRING */
#define FSF7 76		/* FREE STRING */
#define FSF8 77		/* FREE STRING */
#define FSF9 78		/* FREE STRING */
#define FSF10 79		/* FREE STRING */
#define FSF11 80		/* FREE STRING */
#define FSF12 81		/* FREE STRING */
#define FSF13 82		/* FREE STRING */
#define FSF14 83		/* FREE STRING */
#define FSF15 84		/* FREE STRING */
#define FSF16 85		/* FREE STRING */
#define FSF17 86		/* FREE STRING */
#define FSF18 87		/* FREE STRING */
#define FSF19 88		/* FREE STRING */
#define FSF20 89		/* FREE STRING */
#define SDTITLE 2  	/* OBJECT in TREE #26 */
#define SITITLE 4  	/* OBJECT in TREE #26 */
#define MPITITLE 5  	/* OBJECT in TREE #21 */
#define MPBTITLE 7  	/* OBJECT in TREE #21 */
#define MPFTITLE 9  	/* OBJECT in TREE #21 */
#define MPDTITLE 11  	/* OBJECT in TREE #21 */
#define MPPTITLE 13  	/* OBJECT in TREE #21 */
#define SPDTITLE 3  	/* OBJECT in TREE #22 */
#define SPCTITLE 5  	/* OBJECT in TREE #22 */
#define SPOTITLE 7  	/* OBJECT in TREE #22 */
#define SVCBUTTN 3  	/* OBJECT in TREE #23 */
#define SVLBUTTN 5  	/* OBJECT in TREE #23 */
#define SVDBUTTN 7  	/* OBJECT in TREE #23 */
#define SVTTHIGH 17  	/* OBJECT in TREE #24 */
#define SVLTITLE 4  	/* OBJECT in TREE #23 */
#define SVDTITLE 6  	/* OBJECT in TREE #23 */
#define DLTEXT 90		/* FREE STRING */
#define ITEXT 91		/* FREE STRING */
#define VIDITEM 52  	/* OBJECT in TREE #0 */
