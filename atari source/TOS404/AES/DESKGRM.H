#define ADMENU 0  	/* TREE */
#define DESKMENU 3  	/* OBJECT in TREE #0 */
#define FILEMENU 4  	/* OBJECT in TREE #0 */
#define VIEWMENU 5  	/* OBJECT in TREE #0 */
#define OPTNMENU 6  	/* OBJECT in TREE #0 */
#define ABOUITEM 9  	/* OBJECT in TREE #0 */
#define OPENITEM 18  	/* OBJECT in TREE #0 */
#define SHOWITEM 19  	/* OBJECT in TREE #0 */
#define SEAMENU 20  	/* OBJECT in TREE #0 */
#define DELMENU 22  	/* OBJECT in TREE #0 */
#define NEWFITEM 24  	/* OBJECT in TREE #0 */
#define CLSFITEM 25  	/* OBJECT in TREE #0 */
#define CLSWITEM 26  	/* OBJECT in TREE #0 */
#define BOTTOP 27  	/* OBJECT in TREE #0 */
#define SELALL 28  	/* OBJECT in TREE #0 */
#define EXTMENU 29  	/* OBJECT in TREE #0 */
#define L3ITEM 30  	/* OBJECT in TREE #0 */
#define FORMITEM 31  	/* OBJECT in TREE #0 */
#define ICONITEM 33  	/* OBJECT in TREE #0 */
#define TEXTITEM 34  	/* OBJECT in TREE #0 */
#define L4ITEM 35  	/* OBJECT in TREE #0 */
#define NAMEITEM 36  	/* OBJECT in TREE #0 */
#define DATEITEM 37  	/* OBJECT in TREE #0 */
#define SIZEITEM 38  	/* OBJECT in TREE #0 */
#define TYPEITEM 39  	/* OBJECT in TREE #0 */
#define NOSORT 40  	/* OBJECT in TREE #0 */
#define SIZEFIT 42  	/* OBJECT in TREE #0 */
#define SCOLTYPE 43  	/* OBJECT in TREE #0 */
#define IDSKITEM 46  	/* OBJECT in TREE #0 */
#define IAPPITEM 47  	/* OBJECT in TREE #0 */
#define INSDISK 48  	/* OBJECT in TREE #0 */
#define REMVICON 49  	/* OBJECT in TREE #0 */
#define L5ITEM 50  	/* OBJECT in TREE #0 */
#define PREFITEM 51  	/* OBJECT in TREE #0 */
#define VIDITEM 52  	/* OBJECT in TREE #0 */
#define READINF 53  	/* OBJECT in TREE #0 */
#define MEMMENU 54  	/* OBJECT in TREE #0 */
#define SAVEITEM 56  	/* OBJECT in TREE #0 */
#define ADFILEIN 1  	/* TREE */
#define INFTITLE 1  	/* OBJECT in TREE #1 */
#define FIFILE 2  	/* OBJECT in TREE #1 */
#define FILEFT 3  	/* OBJECT in TREE #1 */
#define FIRIGHT 4  	/* OBJECT in TREE #1 */
#define FINAME 5  	/* OBJECT in TREE #1 */
#define FISIZE 6  	/* OBJECT in TREE #1 */
#define FIDATE 7  	/* OBJECT in TREE #1 */
#define FITIME 8  	/* OBJECT in TREE #1 */
#define FINFOLDS 9  	/* OBJECT in TREE #1 */
#define FINFILES 10  	/* OBJECT in TREE #1 */
#define FIRONLY 11  	/* OBJECT in TREE #1 */
#define FIRWRITE 12  	/* OBJECT in TREE #1 */
#define FIATTRS 13  	/* OBJECT in TREE #1 */
#define FIOK 14  	/* OBJECT in TREE #1 */
#define FISKIP 15  	/* OBJECT in TREE #1 */
#define FICNCL 16  	/* OBJECT in TREE #1 */
#define ADDISKIN 2  	/* TREE */
#define DIDRIVE 2  	/* OBJECT in TREE #2 */
#define DIVOLUME 3  	/* OBJECT in TREE #2 */
#define DINFOLDS 4  	/* OBJECT in TREE #2 */
#define DINFILES 5  	/* OBJECT in TREE #2 */
#define DIUSED 6  	/* OBJECT in TREE #2 */
#define DIAVAIL 7  	/* OBJECT in TREE #2 */
#define DIOK 8  	/* OBJECT in TREE #2 */
#define DIQUIT 9  	/* OBJECT in TREE #2 */
#define ADDINFO 3  	/* TREE */
#define DEOK 9  	/* OBJECT in TREE #3 */
#define ADOPENAP 4  	/* TREE */
#define APPLNAME 1  	/* OBJECT in TREE #4 */
#define APPLPARM 3  	/* OBJECT in TREE #4 */
#define APPLOK 4  	/* OBJECT in TREE #4 */
#define APPLCNCL 5  	/* OBJECT in TREE #4 */
#define ADINSDIS 5  	/* TREE */
#define DRID 2  	/* OBJECT in TREE #5 */
#define DRLABEL 3  	/* OBJECT in TREE #5 */
#define IDRIVE 6  	/* OBJECT in TREE #5 */
#define ITRASH 7  	/* OBJECT in TREE #5 */
#define IPRINTER 8  	/* OBJECT in TREE #5 */
#define IBOX 9  	/* OBJECT in TREE #5 */
#define IICON 10  	/* OBJECT in TREE #5 */
#define IUP 11  	/* OBJECT in TREE #5 */
#define IDOWN 13  	/* OBJECT in TREE #5 */
#define DROK 14  	/* OBJECT in TREE #5 */
#define DRCNCL 15  	/* OBJECT in TREE #5 */
#define DRQUIT 16  	/* OBJECT in TREE #5 */
#define ADMKDBOX 6  	/* TREE */
#define MKNAME 1  	/* OBJECT in TREE #6 */
#define MKOK 2  	/* OBJECT in TREE #6 */
#define MKCNCL 4  	/* OBJECT in TREE #6 */
#define ADFORMAT 7  	/* TREE */
#define FCBOX4 1  	/* OBJECT in TREE #7 */
#define FCBOXC 2  	/* OBJECT in TREE #7 */
#define SRCDRA 4  	/* OBJECT in TREE #7 */
#define SRCDRB 5  	/* OBJECT in TREE #7 */
#define DESTDR 6  	/* OBJECT in TREE #7 */
#define FCCOPY 7  	/* OBJECT in TREE #7 */
#define LINEBOX 8  	/* OBJECT in TREE #7 */
#define FCBOXF 9  	/* OBJECT in TREE #7 */
#define DRIVE 10  	/* OBJECT in TREE #7 */
#define ADRIVE 11  	/* OBJECT in TREE #7 */
#define BDRIVE 12  	/* OBJECT in TREE #7 */
#define FCLABEL 13  	/* OBJECT in TREE #7 */
#define SIDEBOX 14  	/* OBJECT in TREE #7 */
#define FCDOUBLE 15  	/* OBJECT in TREE #7 */
#define FCSINGLE 16  	/* OBJECT in TREE #7 */
#define FCHIGH 17  	/* OBJECT in TREE #7 */
#define FCFORMAT 18  	/* OBJECT in TREE #7 */
#define FCBARA 20  	/* OBJECT in TREE #7 */
#define FCBARB 22  	/* OBJECT in TREE #7 */
#define FCOK 23  	/* OBJECT in TREE #7 */
#define FCCNCL 24  	/* OBJECT in TREE #7 */
#define ADICON 8  	/* TREE */
#define ICON0 1  	/* OBJECT in TREE #8 */
#define ICON1 2  	/* OBJECT in TREE #8 */
#define ICON2 3  	/* OBJECT in TREE #8 */
#define ICON3 4  	/* OBJECT in TREE #8 */
#define ICON4 5  	/* OBJECT in TREE #8 */
#define PRINTFIL 9  	/* TREE */
#define PFILE 1  	/* OBJECT in TREE #9 */
#define BACKGROU 10  	/* TREE */
#define SSCREEN 11  	/* TREE */
#define STITLE 1  	/* OBJECT in TREE #11 */
#define DESKPREF 4  	/* OBJECT in TREE #11 */
#define WINPREF 5  	/* OBJECT in TREE #11 */
#define PAT0 9  	/* OBJECT in TREE #11 */
#define PAT1 10  	/* OBJECT in TREE #11 */
#define PAT2 11  	/* OBJECT in TREE #11 */
#define PAT3 12  	/* OBJECT in TREE #11 */
#define PAT4 13  	/* OBJECT in TREE #11 */
#define PAT5 14  	/* OBJECT in TREE #11 */
#define PAT6 15  	/* OBJECT in TREE #11 */
#define PAT7 16  	/* OBJECT in TREE #11 */
#define OUTBOX 17  	/* OBJECT in TREE #11 */
#define PATTERN 18  	/* OBJECT in TREE #11 */
#define COLOR0 20  	/* OBJECT in TREE #11 */
#define COLOR1 21  	/* OBJECT in TREE #11 */
#define COLOR2 22  	/* OBJECT in TREE #11 */
#define COLOR3 23  	/* OBJECT in TREE #11 */
#define COLOR4 24  	/* OBJECT in TREE #11 */
#define COLOR5 25  	/* OBJECT in TREE #11 */
#define COLOR6 26  	/* OBJECT in TREE #11 */
#define COLOR7 27  	/* OBJECT in TREE #11 */
#define COLOR8 28  	/* OBJECT in TREE #11 */
#define COLOR9 29  	/* OBJECT in TREE #11 */
#define COLOR10 30  	/* OBJECT in TREE #11 */
#define COLOR11 31  	/* OBJECT in TREE #11 */
#define COLOR12 32  	/* OBJECT in TREE #11 */
#define COLOR13 33  	/* OBJECT in TREE #11 */
#define COLOR14 34  	/* OBJECT in TREE #11 */
#define COLOR15 35  	/* OBJECT in TREE #11 */
#define SOK 36  	/* OBJECT in TREE #11 */
#define SCANCEL 37  	/* OBJECT in TREE #11 */
#define FILEOPTI 12  	/* TREE */
#define OPTNAME 2  	/* OBJECT in TREE #12 */
#define OPTOK 3  	/* OBJECT in TREE #12 */
#define DLAUNCH 13  	/* TREE */
#define RUNNAME 2  	/* OBJECT in TREE #13 */
#define LTOS 4  	/* OBJECT in TREE #13 */
#define LGRAPHIC 5  	/* OBJECT in TREE #13 */
#define LAUNCHOK 7  	/* OBJECT in TREE #13 */
#define LNCNCL 8  	/* OBJECT in TREE #13 */
#define TEXTLINE 14  	/* TREE */
#define TSTYLE 1  	/* OBJECT in TREE #14 */
#define SAMENAME 15  	/* TREE */
#define SNAME 1  	/* OBJECT in TREE #15 */
#define FNAME 2  	/* OBJECT in TREE #15 */
#define EDFNAME 3  	/* OBJECT in TREE #15 */
#define COPY 4  	/* OBJECT in TREE #15 */
#define SKIP 5  	/* OBJECT in TREE #15 */
#define QUIT 6  	/* OBJECT in TREE #15 */
#define CPBOX 16  	/* TREE */
#define TITLE 1  	/* OBJECT in TREE #16 */
#define NUMDIR 2  	/* OBJECT in TREE #16 */
#define NUMFILE 3  	/* OBJECT in TREE #16 */
#define CSDRIVE 4  	/* OBJECT in TREE #16 */
#define CDDRIVE 5  	/* OBJECT in TREE #16 */
#define HIDECBOX 6  	/* OBJECT in TREE #16 */
#define CPFILE 7  	/* OBJECT in TREE #16 */
#define CPDIR 8  	/* OBJECT in TREE #16 */
#define DATEBOX 9  	/* OBJECT in TREE #16 */
#define PYES 11  	/* OBJECT in TREE #16 */
#define CHBOX1 13  	/* OBJECT in TREE #16 */
#define OKCP 14  	/* OBJECT in TREE #16 */
#define CCANCEL 15  	/* OBJECT in TREE #16 */
#define INWICON 17  	/* TREE */
#define IBOX1 2  	/* OBJECT in TREE #17 */
#define WNAME 3  	/* OBJECT in TREE #17 */
#define WBOX 5  	/* OBJECT in TREE #17 */
#define WICON 6  	/* OBJECT in TREE #17 */
#define WUP 7  	/* OBJECT in TREE #17 */
#define WDOWN 8  	/* OBJECT in TREE #17 */
#define WFOLDER 10  	/* OBJECT in TREE #17 */
#define WNONE 11  	/* OBJECT in TREE #17 */
#define WSKIP 12  	/* OBJECT in TREE #17 */
#define WREMOVE 13  	/* OBJECT in TREE #17 */
#define WOK 14  	/* OBJECT in TREE #17 */
#define WQUIT 16  	/* OBJECT in TREE #17 */
#define HELP1 18  	/* TREE */
#define MOREHELP 14  	/* OBJECT in TREE #18 */
#define HELP2 19  	/* TREE */
#define SEAFILE 20  	/* TREE */
#define SFILE 2  	/* OBJECT in TREE #20 */
#define SEAOK 3  	/* OBJECT in TREE #20 */
#define SEACNCL 4  	/* OBJECT in TREE #20 */
#define MNINSAPP 21  	/* TREE */
#define MPFNAME 2  	/* OBJECT in TREE #21 */
#define MPARGS 3  	/* OBJECT in TREE #21 */
#define MPDTYPE 4  	/* OBJECT in TREE #21 */
#define MPITITLE 5  	/* OBJECT in TREE #21 */
#define MPIBUTTN 6  	/* OBJECT in TREE #21 */
#define MPBTITLE 7  	/* OBJECT in TREE #21 */
#define MPBBUTTN 8  	/* OBJECT in TREE #21 */
#define MPFTITLE 9  	/* OBJECT in TREE #21 */
#define MPFBUTTN 10  	/* OBJECT in TREE #21 */
#define MPDTITLE 11  	/* OBJECT in TREE #21 */
#define MPDBUTTN 12  	/* OBJECT in TREE #21 */
#define MPPTITLE 13  	/* OBJECT in TREE #21 */
#define MPPBUTTN 14  	/* OBJECT in TREE #21 */
#define MPOK 15  	/* OBJECT in TREE #21 */
#define MPREMOVE 16  	/* OBJECT in TREE #21 */
#define MPCANCEL 17  	/* OBJECT in TREE #21 */
#define MPQUIT 18  	/* OBJECT in TREE #21 */
#define MNSETPRE 22  	/* TREE */
#define SPDTITLE 3  	/* OBJECT in TREE #22 */
#define SPDBUTTN 4  	/* OBJECT in TREE #22 */
#define SPCTITLE 5  	/* OBJECT in TREE #22 */
#define SPCBUTTN 6  	/* OBJECT in TREE #22 */
#define SPOTITLE 7  	/* OBJECT in TREE #22 */
#define SPOBUTTN 8  	/* OBJECT in TREE #22 */
#define MNSPOK 9  	/* OBJECT in TREE #22 */
#define MNSPCAN 10  	/* OBJECT in TREE #22 */
#define MNSETVID 23  	/* TREE */
#define SVCTITLE 2  	/* OBJECT in TREE #23 */
#define SVCBUTTN 3  	/* OBJECT in TREE #23 */
#define SVLTITLE 4  	/* OBJECT in TREE #23 */
#define SVLBUTTN 5  	/* OBJECT in TREE #23 */
#define SVDTITLE 6  	/* OBJECT in TREE #23 */
#define SVDBUTTN 7  	/* OBJECT in TREE #23 */
#define SVMODES 8  	/* OBJECT in TREE #23 */
#define IBASE 9  	/* OBJECT in TREE #23 */
#define SVOK 10  	/* OBJECT in TREE #23 */
#define SVCANCEL 11  	/* OBJECT in TREE #23 */
#define MNVIDEO 24  	/* TREE */
#define SVSTLOW 3  	/* OBJECT in TREE #24 */
#define SVSTMED 4  	/* OBJECT in TREE #24 */
#define SVSTHIGH 5  	/* OBJECT in TREE #24 */
#define SVTTOK 6  	/* OBJECT in TREE #24 */
#define SVTTCAN 7  	/* OBJECT in TREE #24 */
#define MNMENU 25  	/* TREE */
#define MPIBASE 1  	/* OBJECT in TREE #25 */
#define MPINONE 2  	/* OBJECT in TREE #25 */
#define MPIF1 3  	/* OBJECT in TREE #25 */
#define MPIF2 4  	/* OBJECT in TREE #25 */
#define MPIF3 5  	/* OBJECT in TREE #25 */
#define MPIF4 6  	/* OBJECT in TREE #25 */
#define MPIF5 7  	/* OBJECT in TREE #25 */
#define MPIF6 8  	/* OBJECT in TREE #25 */
#define MPIF7 9  	/* OBJECT in TREE #25 */
#define MPIF8 10  	/* OBJECT in TREE #25 */
#define MPIF9 11  	/* OBJECT in TREE #25 */
#define MPIF10 12  	/* OBJECT in TREE #25 */
#define MPFI11 13  	/* OBJECT in TREE #25 */
#define MPIF12 14  	/* OBJECT in TREE #25 */
#define MPIF13 15  	/* OBJECT in TREE #25 */
#define MPIF14 16  	/* OBJECT in TREE #25 */
#define MPIF15 17  	/* OBJECT in TREE #25 */
#define MPIF16 18  	/* OBJECT in TREE #25 */
#define MPIF17 19  	/* OBJECT in TREE #25 */
#define MPIF18 20  	/* OBJECT in TREE #25 */
#define MPIF19 21  	/* OBJECT in TREE #25 */
#define MPIF20 22  	/* OBJECT in TREE #25 */
#define MPFBASE 23  	/* OBJECT in TREE #25 */
#define MPFTOS 24  	/* OBJECT in TREE #25 */
#define MPFTTP 25  	/* OBJECT in TREE #25 */
#define MPFGEM 26  	/* OBJECT in TREE #25 */
#define MPFGMTTP 27  	/* OBJECT in TREE #25 */
#define SDBASE 28  	/* OBJECT in TREE #25 */
#define SDAPP 29  	/* OBJECT in TREE #25 */
#define SDTOP 30  	/* OBJECT in TREE #25 */
#define SIBASE 31  	/* OBJECT in TREE #25 */
#define SIFULL 32  	/* OBJECT in TREE #25 */
#define SIFILE 33  	/* OBJECT in TREE #25 */
#define MPBBASE 34  	/* OBJECT in TREE #25 */
#define MPBAUTO 35  	/* OBJECT in TREE #25 */
#define MPBNORML 36  	/* OBJECT in TREE #25 */
#define SPBASE 37  	/* OBJECT in TREE #25 */
#define SPYES 38  	/* OBJECT in TREE #25 */
#define SPNO 39  	/* OBJECT in TREE #25 */
#define VIDBASE 40  	/* OBJECT in TREE #25 */
#define VID2 41  	/* OBJECT in TREE #25 */
#define VID4 42  	/* OBJECT in TREE #25 */
#define VID16 43  	/* OBJECT in TREE #25 */
#define VID256 44  	/* OBJECT in TREE #25 */
#define VIDTRUE 45  	/* OBJECT in TREE #25 */
#define SVIBASE 46  	/* OBJECT in TREE #25 */
#define SVION 47  	/* OBJECT in TREE #25 */
#define SVIOFF 48  	/* OBJECT in TREE #25 */
#define SVLBASE 49  	/* OBJECT in TREE #25 */
#define SVL40 50  	/* OBJECT in TREE #25 */
#define SVL80 51  	/* OBJECT in TREE #25 */
#define MNSYSTEM 26  	/* TREE */
#define SDTITLE 2  	/* OBJECT in TREE #26 */
#define SDBUTTON 3  	/* OBJECT in TREE #26 */
#define SITITLE 4  	/* OBJECT in TREE #26 */
#define SIBUTTON 5  	/* OBJECT in TREE #26 */
#define MFBASE 7  	/* OBJECT in TREE #26 */
#define MFLEFT 8  	/* OBJECT in TREE #26 */
#define MFFILE 9  	/* OBJECT in TREE #26 */
#define MFRIGHT 10  	/* OBJECT in TREE #26 */
#define MFKEY 11  	/* OBJECT in TREE #26 */
#define MFUP 12  	/* OBJECT in TREE #26 */
#define MFDOWN 13  	/* OBJECT in TREE #26 */
#define MKITEM 17  	/* OBJECT in TREE #26 */
#define MKUPS 18  	/* OBJECT in TREE #26 */
#define MKDOWNS 19  	/* OBJECT in TREE #26 */
#define MKKEYS 20  	/* OBJECT in TREE #26 */
#define MKCLEAR 21  	/* OBJECT in TREE #26 */
#define MKMEMORY 22  	/* OBJECT in TREE #26 */
#define MOK 23  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define MCANCEL 24  	/* OBJECT in TREE #26 */
#define STNOAPPL 68  	/* STRING */
#define STNOWIND 69  	/* STRING */
#define STFOEXIS 70  	/* STRING */
#define STDISKFU 71  	/* STRING */
#define STFO8DEE 72  	/* STRING */
#define STBADCOP 73  	/* STRING */
#define TRSINFO 74  	/* STRING */
#define FCNOMEM 75  	/* STRING */
#define FCFAIL 76  	/* STRING */
#define FCSIZE 77  	/* STRING */
#define FCNOTYPE 78  	/* STRING */
#define SAVETOP 79  	/* STRING */
#define PRINTTOP 80  	/* STRING */
#define ABORTCON 81  	/* STRING */
#define NOICON 82  	/* STRING */
#define NOAPP 83  	/* STRING */
#define NODRIVE 84  	/* STRING */
#define NOOUTPUT 85  	/* STRING */
#define CNTOPEN 86  	/* STRING */
#define CNTCRTDR 87  	/* STRING */
#define WRERROR 88  	/* STRING */
#define RDERROR 89  	/* STRING */
#define CNTCRTFL 90  	/* STRING */
#define CNTDELF 91  	/* STRING */
#define CNTDELD 92  	/* STRING */
#define PRINTINF 93  	/* STRING */
#define RENAME 94  	/* STRING */
#define NOBUF 95  	/* STRING */
#define DELDISK 96  	/* STRING */
#define NOTPRG 97  	/* STRING */
#define NOSETDIR 98  	/* STRING */
#define NOAUTO 99  	/* STRING */
#define NOWINMEM 100  	/* STRING */
#define NOTYPE 101  	/* STRING */
#define ICONTYPE 102  	/* STRING */
#define NODIRCOP 103  	/* STRING */
#define NOINSTAL 104  	/* STRING */
#define NOMORE 105  	/* STRING */
#define NOID 106  	/* STRING */
#define ILLMAT 107  	/* STRING */
#define NOCART 108  	/* STRING */
#define NOMATCH 109  	/* STRING */
#define DELITEM 110  	/* STRING */
#define MCFAIL 111  	/* STRING */
#define FNOTFIND 112  	/* STRING */
#define SNEXT 113  	/* STRING */
#define NOHELP 114  	/* STRING */
#define NOSEA 115  	/* STRING */
#define KEYUSED 116  	/* STRING */
#define CARTNOSH 117  	/* STRING */
#define BADKEY 118  	/* STRING */
#define XNFILE 119  	/* STRING */
