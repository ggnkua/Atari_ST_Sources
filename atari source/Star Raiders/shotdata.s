*
*	SHOTDATA.S	ST Star-Raiders SHOT Image Data
*

*
*	PUBLIC SYMBOLS
*
	.globl	shtimg00
	.globl	shtimg10
	.globl	shtimg20
	.globl	shtimg30
	.globl	shtimg40
	.globl	shtimg50
	.globl	shtimg60
	.globl	shtimg70
	.globl	shtimg01
	.globl	shtimg11
	.globl	shtimg21
	.globl	shtimg31
	.globl	shtimg41
	.globl	shtimg51
	.globl	shtimg61
	.globl	shtimg71
	.globl	shtimg02
	.globl	shtimg12
	.globl	shtimg22
	.globl	shtimg32
	.globl	shtimg42
	.globl	shtimg52
	.globl	shtimg62
	.globl	shtimg72
	.globl	shtimg03
	.globl	shtimg13
	.globl	shtimg23
	.globl	shtimg33
	.globl	shtimg43
	.globl	shtimg53
	.globl	shtimg63
	.globl	shtimg73
	.globl	shtimg04
	.globl	shtimg14
	.globl	shtimg24
	.globl	shtimg34
	.globl	shtimg44
	.globl	shtimg54
	.globl	shtimg64
	.globl	shtimg74
	.globl	shtimg05
	.globl	shtimg15
	.globl	shtimg25
	.globl	shtimg35
	.globl	shtimg45
	.globl	shtimg55
	.globl	shtimg65
	.globl	shtimg75
	.globl	shtimg06
	.globl	shtimg16
	.globl	shtimg26
	.globl	shtimg36
	.globl	shtimg46
	.globl	shtimg56
	.globl	shtimg66
	.globl	shtimg76
	.globl	shtimg07
	.globl	shtimg17
	.globl	shtimg27
	.globl	shtimg37
	.globl	shtimg47
	.globl	shtimg57
	.globl	shtimg67
	.globl	shtimg77

	.globl	eshimg00
	.globl	eshimg10
	.globl	eshimg20
	.globl	eshimg30
	.globl	eshimg40
	.globl	eshimg50
	.globl	eshimg60
	.globl	eshimg70
	.globl	eshimg01
	.globl	eshimg11
	.globl	eshimg21
	.globl	eshimg31
	.globl	eshimg41
	.globl	eshimg51
	.globl	eshimg61
	.globl	eshimg71
	.globl	eshimg02
	.globl	eshimg12
	.globl	eshimg22
	.globl	eshimg32
	.globl	eshimg42
	.globl	eshimg52
	.globl	eshimg62
	.globl	eshimg72
	.globl	eshimg03
	.globl	eshimg13
	.globl	eshimg23
	.globl	eshimg33
	.globl	eshimg43
	.globl	eshimg53
	.globl	eshimg63
	.globl	eshimg73
	.globl	eshimg04
	.globl	eshimg14
	.globl	eshimg24
	.globl	eshimg34
	.globl	eshimg44
	.globl	eshimg54
	.globl	eshimg64
	.globl	eshimg74
	.globl	eshimg05
	.globl	eshimg15
	.globl	eshimg25
	.globl	eshimg35
	.globl	eshimg45
	.globl	eshimg55
	.globl	eshimg65
	.globl	eshimg75
	.globl	eshimg06
	.globl	eshimg16
	.globl	eshimg26
	.globl	eshimg36
	.globl	eshimg46
	.globl	eshimg56
	.globl	eshimg66
	.globl	eshimg76
	.globl	eshimg07
	.globl	eshimg17
	.globl	eshimg27
	.globl	eshimg37
	.globl	eshimg47
	.globl	eshimg57
	.globl	eshimg67
	.globl	eshimg77


*
*	MISSILE GRAPHICS (8 Perspectives - 8 Animations)
*
*
*	Image data
*		Xoffset,Yoffset (pixels)
*		Height (lines), Width (words)
*		Image_Data
*

	.data
	.even

shtimg00:		* Friendly Shot (Perspective:0 - Animation:0)
	.dc.w	14,14
	.dc.w	29,2
	.dc.w	$003F,$003F,$003F,$0000,$8000,$8000,$8000,$0000
	.dc.w	$01FF,$01E6,$01FF,$0019,$C000,$8000,$C000,$4000
	.dc.w	$03FF,$031F,$03FF,$00E0,$E800,$E800,$E800,$0000
	.dc.w	$07FF,$06FA,$07FF,$0105,$F000,$B400,$F400,$4000
	.dc.w	$0F8F,$0D8F,$0F8F,$0200,$F000,$D200,$F200,$2000
	.dc.w	$1FA7,$1B25,$1FA7,$0482,$7000,$7100,$7100,$0000
	.dc.w	$3E0F,$360F,$3E0F,$0800,$0080,$0080,$0080,$0000
	.dc.w	$3C00,$6C00,$7C00,$1000,$0040,$0040,$0040,$0000
	.dc.w	$7900,$5900,$7900,$2000,$0000,$0000,$0000,$0020
	.dc.w	$7000,$5000,$7000,$2000,$0000,$0000,$0000,$0020
	.dc.w	$7000,$D000,$F000,$2000,$0000,$0000,$0000,$0020
	.dc.w	$E000,$B000,$F000,$4000,$0000,$0000,$0000,$0010
	.dc.w	$E000,$A000,$E000,$4000,$0000,$0000,$0000,$0010
	.dc.w	$E000,$A000,$E000,$4000,$0010,$0000,$0000,$0010
	.dc.w	$E000,$A000,$E000,$4000,$0010,$0000,$0000,$0010
	.dc.w	$E000,$A000,$E000,$4000,$0010,$0000,$0000,$0010
	.dc.w	$E000,$A000,$E000,$4000,$0000,$0010,$0000,$0010
	.dc.w	$E000,$B000,$F000,$4000,$0000,$0010,$0000,$0010
	.dc.w	$7000,$D000,$F000,$2000,$0000,$0020,$0000,$0020
	.dc.w	$7000,$5000,$7000,$2000,$0020,$0070,$0070,$0000
	.dc.w	$7000,$5800,$7800,$2000,$0070,$00D0,$00F0,$0020
	.dc.w	$7C00,$6C00,$7C00,$1000,$00E0,$00B0,$00F0,$0040
	.dc.w	$3E00,$3600,$3E00,$0800,$0080,$03E0,$03E0,$0000
	.dc.w	$1F00,$1B00,$1F00,$0400,$0380,$0280,$0380,$0100
	.dc.w	$0F00,$0D80,$0F80,$0200,$0700,$0F80,$0F80,$0000
	.dc.w	$07C0,$06E0,$07E0,$0100,$3E00,$7A00,$7E00,$0400
	.dc.w	$03FF,$033F,$03FF,$00C0,$FC00,$C600,$FE00,$3800
	.dc.w	$00FF,$01E0,$01FF,$001F,$F800,$7C00,$FC00,$8000
	.dc.w	$001F,$003F,$003F,$0000,$8000,$C000,$C000,$0000
shtimg01:		* Friendly Shot (Perspective:0 - Animation:1)
	.dc.w	14,14
	.dc.w	29,2
	.dc.w	$000C,$000C,$000C,$0000,$8000,$8000,$8000,$0000
	.dc.w	$00FF,$00F2,$00F2,$0000,$D000,$5000,$5000,$0000
	.dc.w	$03FC,$039C,$039C,$0000,$B800,$8800,$8800,$0000
	.dc.w	$07E5,$06E5,$06E5,$0000,$E600,$6200,$6200,$0000
	.dc.w	$0F8F,$0D8B,$0D8B,$0000,$F700,$D500,$D500,$0000
	.dc.w	$1F04,$1B04,$1B04,$0000,$2700,$2600,$2600,$0000
	.dc.w	$3E00,$3600,$3600,$0000,$3F80,$2A00,$2A00,$0000
	.dc.w	$7C00,$6C00,$6C00,$0000,$4AC0,$4840,$4840,$0000
	.dc.w	$7800,$5800,$5800,$0000,$E5A0,$A4A0,$A4A0,$0000
	.dc.w	$7000,$5000,$5000,$0000,$4E20,$4A20,$4A20,$0000
	.dc.w	$7000,$5000,$5000,$0000,$0420,$0420,$0420,$0000
	.dc.w	$F000,$F000,$F000,$0000,$0010,$0010,$0010,$0000
	.dc.w	$E000,$A000,$A000,$0000,$0010,$0010,$0010,$0000
	.dc.w	$E000,$A000,$A000,$0000,$0010,$0010,$0010,$0000
	.dc.w	$E000,$A000,$A000,$0000,$0000,$0010,$0000,$0010
	.dc.w	$E000,$A000,$A000,$0000,$0000,$0000,$0000,$0010
	.dc.w	$E000,$E000,$E000,$0000,$0000,$0010,$0000,$0010
	.dc.w	$F000,$B000,$B000,$0000,$0000,$0000,$0000,$0010
	.dc.w	$F000,$D000,$D000,$0000,$0000,$0020,$0000,$0020
	.dc.w	$7000,$5000,$5000,$0000,$0000,$0000,$0000,$0020
	.dc.w	$7800,$5800,$5800,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7C00,$6C00,$6C00,$0000,$0000,$0040,$0000,$0040
	.dc.w	$3E00,$3600,$3600,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1E00,$1A00,$1A00,$0000,$0000,$0100,$0000,$0100
	.dc.w	$0F00,$0D00,$0D00,$0000,$0000,$0200,$0000,$0200
	.dc.w	$03C0,$03C0,$03C0,$0000,$0000,$0400,$0000,$0400
	.dc.w	$01F8,$0118,$0118,$0000,$0800,$3800,$0800,$3000
	.dc.w	$00FC,$00E7,$00E4,$0003,$4000,$C000,$4000,$8000
	.dc.w	$0018,$0018,$0018,$0000,$0000,$0000,$0000,$0000
shtimg02:		* Friendly Shot (Perspective:0 - Animation:2)
	.dc.w	14,14
	.dc.w	29,2
	.dc.w	$0000,$003F,$003F,$0000,$0000,$E000,$E000,$0000
	.dc.w	$0013,$01FF,$01EC,$0013,$4000,$F800,$B800,$4000
	.dc.w	$00A0,$03F7,$0357,$00A0,$2800,$FE00,$D600,$2800
	.dc.w	$0100,$07E0,$06E0,$0100,$0400,$7E00,$7A00,$0400
	.dc.w	$0200,$0780,$0580,$0200,$2000,$2F00,$0F00,$2000
	.dc.w	$0000,$1F00,$1F00,$0000,$0500,$0780,$0680,$0100
	.dc.w	$0800,$3C00,$3400,$0800,$0E00,$0FC0,$0BC0,$0400
	.dc.w	$1000,$7C00,$6C00,$1000,$0440,$04E0,$04A0,$0040
	.dc.w	$2000,$7800,$5800,$2000,$0100,$01C0,$01C0,$0000
	.dc.w	$2000,$7000,$5000,$2000,$02A0,$02F0,$00D0,$0220
	.dc.w	$2000,$F000,$D000,$2000,$09D0,$09F0,$0160,$0890
	.dc.w	$4000,$F000,$B000,$4000,$0280,$03D0,$03D0,$0000
	.dc.w	$4000,$E000,$A000,$4000,$0790,$07F8,$0568,$0290
	.dc.w	$0000,$E000,$E000,$0000,$0270,$03F8,$03A8,$0050
	.dc.w	$4000,$E000,$A000,$4000,$0000,$0158,$0158,$0000
	.dc.w	$4000,$E000,$A000,$4000,$0040,$00E8,$00A8,$0040
	.dc.w	$4000,$E000,$A000,$4000,$0000,$00B0,$00B0,$0000
	.dc.w	$4000,$E000,$A000,$4000,$0000,$0010,$0010,$0000
	.dc.w	$0000,$F000,$F000,$0000,$0000,$0020,$0020,$0000
	.dc.w	$2000,$7000,$5000,$2000,$0020,$0020,$0020,$0000
	.dc.w	$2000,$7800,$5800,$2000,$0000,$0020,$0020,$0000
	.dc.w	$1000,$7C00,$6C00,$1000,$0040,$0040,$0040,$0000
	.dc.w	$0800,$3C00,$3400,$0800,$0080,$0000,$0000,$0080
	.dc.w	$0000,$1C00,$1C00,$0000,$0100,$0000,$0000,$0100
	.dc.w	$0200,$0000,$0000,$0200,$0000,$0200,$0200,$0000
	.dc.w	$0000,$0180,$0180,$0000,$0000,$0C00,$0C00,$0000
	.dc.w	$0080,$01CA,$014A,$0080,$0800,$7C00,$7400,$0800
	.dc.w	$000A,$00DF,$00D5,$000A,$4000,$F800,$B800,$4000
	.dc.w	$0000,$000A,$000A,$0000,$0000,$4000,$4000,$0000
shtimg03:		* Friendly Shot (Perspective:0 - Animation:3)
	.dc.w	14,14
	.dc.w	28,2
	.dc.w	$0000,$001F,$001F,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0000,$00FF,$00E5,$001A,$0000,$F000,$3000,$C000
	.dc.w	$0000,$01FF,$015F,$00A0,$0000,$FC00,$CC00,$3000
	.dc.w	$0000,$03E0,$02E0,$0100,$0000,$3E00,$3A00,$0400
	.dc.w	$0000,$0780,$0580,$0200,$0000,$0F80,$0F80,$0000
	.dc.w	$0000,$0E00,$0A00,$0400,$0000,$0380,$0280,$0100
	.dc.w	$0000,$0800,$0800,$0000,$0000,$01E0,$01E0,$0000
	.dc.w	$0000,$3000,$3000,$0000,$0000,$00F0,$00B0,$0040
	.dc.w	$0000,$7000,$5000,$2000,$0000,$00F0,$00D0,$0020
	.dc.w	$0000,$7000,$5000,$2000,$0000,$0070,$0050,$0020
	.dc.w	$0000,$6000,$6000,$0000,$0000,$00B0,$0090,$0020
	.dc.w	$0000,$E000,$A000,$4000,$0000,$01F8,$0168,$0090
	.dc.w	$0000,$4000,$4000,$0000,$0000,$0098,$0098,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0080,$00B0,$00A0,$0010
	.dc.w	$0000,$0000,$0000,$4000,$0140,$01E8,$0168,$0080
	.dc.w	$0000,$E000,$E000,$0000,$0090,$01B0,$01B0,$0000
	.dc.w	$0000,$E000,$A000,$4000,$0130,$03B0,$03A0,$0010
	.dc.w	$0000,$6000,$6000,$0000,$0400,$0560,$0560,$0010
	.dc.w	$0000,$0000,$0000,$2000,$0A40,$0F50,$0A10,$0540
	.dc.w	$0000,$0000,$0000,$2000,$04A0,$07A0,$05A0,$0200
	.dc.w	$2000,$2000,$2000,$0000,$01D0,$03F0,$0370,$0080
	.dc.w	$0000,$0800,$0800,$1000,$0000,$03E0,$02A0,$0140
	.dc.w	$0000,$1400,$1400,$0800,$0000,$0140,$0140,$0000
	.dc.w	$0000,$0800,$0800,$0000,$0000,$0500,$0500,$0000
	.dc.w	$0000,$0000,$0000,$0200,$0000,$0000,$0000,$0200
	.dc.w	$0000,$0080,$0080,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0140,$0140,$0080,$1000,$1800,$1800,$0000
	.dc.w	$0000,$0081,$0081,$001A,$4000,$C000,$C000,$0000
shtimg04:		* Friendly Shot (Perspective:0 - Animation:4)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$001B,$0000,$0000,$001B,$8000,$0000,$0000,$8000
	.dc.w	$0040,$0000,$0000,$0040,$5000,$0000,$0000,$5000
	.dc.w	$0035,$0035,$0035,$0000,$0800,$0000,$0000,$0800
	.dc.w	$0440,$0040,$0040,$0400,$6400,$6000,$6000,$0400
	.dc.w	$0000,$0000,$0000,$0000,$0200,$0000,$0000,$0200
	.dc.w	$1600,$0600,$0600,$1000,$0C00,$0C00,$0C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0480,$0400,$0400,$0080
	.dc.w	$4800,$0800,$0800,$4000,$0040,$0000,$0000,$0040
	.dc.w	$1000,$1000,$1000,$0000,$0140,$0100,$0100,$0040
	.dc.w	$4000,$0000,$0000,$4000,$0140,$0100,$0100,$0040
	.dc.w	$8000,$0000,$0000,$8000,$0080,$0080,$0080,$0000
	.dc.w	$A000,$2000,$2000,$8000,$00A0,$0080,$0080,$0020
	.dc.w	$A000,$2000,$2000,$8000,$00A0,$0080,$0080,$0020
	.dc.w	$2000,$2000,$2000,$0000,$0020,$0000,$0000,$0020
	.dc.w	$A000,$2000,$2000,$8000,$0020,$0000,$0000,$00A0
	.dc.w	$8000,$0000,$0000,$8000,$0020,$0000,$0000,$0020
	.dc.w	$A000,$2000,$2000,$8000,$0020,$0000,$0000,$00A0
	.dc.w	$4000,$1000,$1000,$4000,$0040,$1000,$0000,$1140
	.dc.w	$1000,$1000,$1000,$0000,$0040,$0000,$0000,$0140
	.dc.w	$4800,$0800,$0800,$4000,$0240,$0A00,$0000,$4A40
	.dc.w	$2000,$0000,$0000,$2000,$0880,$0800,$0000,$1C80
	.dc.w	$1000,$0000,$0000,$1400,$0000,$8000,$0000,$8800
	.dc.w	$0100,$0100,$0100,$0004,$0200,$0000,$0000,$2200
	.dc.w	$0400,$0442,$0440,$0002,$0400,$2000,$0000,$7400
	.dc.w	$0011,$0216,$0210,$0007,$0800,$0000,$0000,$A800
	.dc.w	$0020,$00E2,$00E0,$0002,$7000,$2000,$2000,$5000
	.dc.w	$002B,$0029,$0029,$0002,$0000,$0000,$0000,$0000
shtimg05:		* Friendly Shot (Perspective:0 - Animation:5)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$0000,$0000,$0000,$001F,$0000,$0000,$0000,$8000
	.dc.w	$0000,$0000,$0000,$01C0,$0000,$0000,$0000,$6000
	.dc.w	$002F,$0000,$0000,$002F,$8000,$0000,$0000,$8800
	.dc.w	$00C0,$0000,$0000,$04C0,$2000,$0000,$0000,$2400
	.dc.w	$0000,$0000,$0000,$0800,$0000,$0000,$0000,$0200
	.dc.w	$0000,$0000,$0000,$1200,$0400,$0000,$0000,$0500
	.dc.w	$0400,$0400,$0400,$2000,$0400,$0000,$0000,$0480
	.dc.w	$0800,$0800,$0800,$4000,$0000,$0000,$0000,$0040
	.dc.w	$1000,$1000,$1000,$0000,$0100,$0000,$0000,$0140
	.dc.w	$0000,$1000,$1000,$4000,$0100,$0000,$0000,$0140
	.dc.w	$2000,$2000,$2000,$0000,$0080,$0000,$0000,$0080
	.dc.w	$2000,$2000,$2000,$8000,$0080,$0000,$0000,$00A0
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0020
	.dc.w	$2000,$2000,$2000,$0000,$0000,$0000,$0000,$0020
	.dc.w	$2000,$2000,$2000,$8000,$0080,$0000,$0000,$00A0
	.dc.w	$0000,$0000,$0000,$8200,$0080,$0000,$0000,$00A0
	.dc.w	$0000,$A000,$A000,$0700,$0080,$0000,$0000,$00A0
	.dc.w	$1000,$0000,$0000,$5200,$0100,$0000,$0000,$0100
	.dc.w	$1400,$0400,$0000,$7500,$0000,$0000,$0000,$0040
	.dc.w	$0800,$0000,$0000,$1A20,$0200,$0000,$0000,$0240
	.dc.w	$0000,$0000,$0000,$2880,$0400,$0000,$0000,$0480
	.dc.w	$0480,$0080,$0000,$05C2,$0400,$0000,$0000,$0500
	.dc.w	$0000,$0000,$0000,$0690,$0000,$0000,$0000,$0200
	.dc.w	$0000,$0000,$0000,$0600,$4000,$0000,$0000,$4400
	.dc.w	$002D,$0020,$0000,$002D,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0180,$0000,$0000,$0000,$7000
	.dc.w	$0000,$0000,$0000,$003B,$0000,$0000,$0000,$8000
shtimg06:		* Friendly Shot (Perspective:0 - Animation:6)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$001B,$001B,$001B,$0000,$8000,$8000,$8000,$0000
	.dc.w	$0140,$01C0,$01C0,$0000,$7000,$7000,$7000,$0000
	.dc.w	$022E,$022E,$022E,$0001,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0040,$0040,$0000,$0000,$0000,$0000,$6000
	.dc.w	$0100,$0900,$0900,$0000,$0200,$0200,$0200,$1000
	.dc.w	$0400,$1400,$1400,$0000,$0C00,$0000,$0000,$0C00
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0000,$0000,$0400
	.dc.w	$4000,$4800,$4800,$0000,$0200,$0000,$0000,$0200
	.dc.w	$0000,$2000,$2000,$0000,$0100,$0000,$0000,$0100
	.dc.w	$5000,$5000,$5000,$0000,$0040,$0040,$0040,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00A0,$0020,$0020,$0080
	.dc.w	$2000,$2000,$0000,$7000,$00A0,$0020,$0020,$0080
	.dc.w	$A000,$A000,$A000,$0800,$0020,$00A0,$0020,$0080
	.dc.w	$2000,$2200,$0200,$7400,$0020,$00A0,$0020,$0080
	.dc.w	$8000,$A800,$8000,$2800,$0020,$00A0,$0020,$0080
	.dc.w	$5000,$5400,$5400,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8400,$AE00,$8A00,$6400,$0020,$0020,$0020,$0000
	.dc.w	$4000,$5400,$5400,$0100,$0040,$0040,$0040,$0000
	.dc.w	$4500,$7900,$6900,$1400,$0040,$0140,$0040,$0100
	.dc.w	$4B80,$5A80,$5A80,$0100,$0040,$0240,$0040,$0200
	.dc.w	$2100,$2500,$2100,$0400,$0000,$0400,$0000,$0400
	.dc.w	$1200,$1200,$1200,$0000,$0100,$0100,$0100,$0000
	.dc.w	$0800,$0800,$0800,$0000,$0200,$0200,$0200,$0000
	.dc.w	$0400,$0480,$0400,$0080,$0000,$6000,$0000,$6000
	.dc.w	$0200,$023C,$0200,$003C,$0800,$0800,$0800,$0000
	.dc.w	$01C0,$01C0,$01C0,$0000,$5000,$5000,$5000,$0000
	.dc.w	$001A,$001A,$001A,$0000,$8000,$8000,$8000,$0000
shtimg07:		* Friendly Shot (Perspective:0 - Animation:7)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$0007,$000F,$000F,$0000,$8000,$8000,$8000,$0000
	.dc.w	$0080,$00D0,$00D0,$0000,$7000,$7000,$7000,$0000
	.dc.w	$0203,$0233,$0233,$00C0,$0800,$0800,$0800,$0000
	.dc.w	$0440,$0440,$0400,$0140,$4400,$4400,$4400,$0000
	.dc.w	$0300,$0100,$0000,$0780,$0200,$0200,$0200,$1000
	.dc.w	$1540,$1400,$1000,$0D40,$0000,$0000,$0000,$0100
	.dc.w	$02A0,$0A60,$0A60,$0080,$0080,$0080,$0080,$0400
	.dc.w	$4940,$5C00,$5400,$09C0,$0040,$0040,$0040,$0200
	.dc.w	$0280,$0A80,$0A80,$0000,$0040,$0040,$0040,$0100
	.dc.w	$4400,$4100,$4100,$0400,$0000,$0000,$0000,$0100
	.dc.w	$A000,$A280,$8280,$2100,$0020,$0020,$0020,$0080
	.dc.w	$8000,$A100,$A100,$0000,$00A0,$00A0,$00A0,$0000
	.dc.w	$A000,$F000,$D000,$2000,$00A0,$0020,$0020,$0080
	.dc.w	$8000,$A000,$A000,$0000,$00A0,$00A0,$00A0,$0000
	.dc.w	$8000,$8000,$8000,$0000,$0020,$00A0,$0020,$0080
	.dc.w	$A000,$A000,$8000,$2000,$00A0,$0020,$0020,$0080
	.dc.w	$A000,$B000,$9000,$2000,$00A0,$00A0,$0020,$0080
	.dc.w	$4000,$7800,$7800,$0000,$0140,$0140,$0040,$0100
	.dc.w	$5000,$5000,$4000,$1000,$0100,$0000,$0000,$0100
	.dc.w	$4800,$4800,$4000,$0800,$0040,$0040,$0040,$0000
	.dc.w	$2000,$2200,$2200,$0000,$0000,$0400,$0000,$0400
	.dc.w	$0200,$0700,$0500,$0200,$0800,$0000,$0000,$0800
	.dc.w	$0800,$0B00,$0A00,$0100,$0200,$1200,$0200,$1000
	.dc.w	$0000,$0040,$0000,$0040,$2000,$2000,$0000,$2000
	.dc.w	$0034,$0035,$0000,$0035,$0800,$8800,$0800,$8000
	.dc.w	$0180,$0180,$0180,$0000,$6000,$6000,$6000,$0000
	.dc.w	$002E,$002E,$002E,$0000,$0000,$0000,$0000,$0000
shtimg10:		* Friendly Shot (Perspective:1 - Animation:0)
	.dc.w	12,12
	.dc.w	25,2
	.dc.w	$0055,$00FF,$00FF,$0000,$0000,$8000,$8000,$0000
	.dc.w	$01FF,$03FF,$0398,$0067,$C000,$C000,$C000,$0000
	.dc.w	$07FF,$07FF,$06F5,$010A,$C000,$C000,$4000,$8000
	.dc.w	$0EBF,$1EBF,$1CAB,$0214,$6000,$E000,$E000,$0000
	.dc.w	$1F55,$1F5F,$175E,$0801,$0800,$0800,$0800,$0000
	.dc.w	$3CE0,$3CE0,$34A0,$0840,$0000,$0000,$0000,$0800
	.dc.w	$3840,$7CE0,$6CE0,$1000,$0000,$0000,$0000,$0000
	.dc.w	$7000,$7800,$5800,$2000,$0000,$0000,$0000,$0200
	.dc.w	$7000,$F000,$D000,$2000,$0000,$0000,$0000,$0000
	.dc.w	$E000,$F000,$B000,$4000,$0000,$0100,$0100,$0000
	.dc.w	$E000,$E000,$A000,$4000,$0100,$0280,$0280,$0100
	.dc.w	$E000,$E000,$E000,$0000,$0000,$0100,$0100,$0000
	.dc.w	$E000,$E000,$E000,$0000,$0100,$0000,$0000,$0100
	.dc.w	$E000,$E000,$A000,$4000,$0000,$0100,$0000,$0100
	.dc.w	$E000,$E000,$A000,$4000,$0000,$0380,$0280,$0100
	.dc.w	$E000,$F000,$B000,$4000,$0000,$0300,$0200,$0100
	.dc.w	$F000,$F000,$D000,$2000,$0000,$0700,$0500,$0200
	.dc.w	$7000,$7800,$5800,$2000,$0000,$0200,$0200,$0000
	.dc.w	$3800,$7800,$6800,$1000,$0800,$1C00,$1C00,$0000
	.dc.w	$3C00,$3E00,$3E00,$0000,$1C00,$3C00,$3400,$0800
	.dc.w	$1E00,$1E00,$1200,$0C00,$3C00,$3C00,$2400,$1800
	.dc.w	$0F00,$1F81,$1F81,$0000,$F800,$FC00,$FC00,$0000
	.dc.w	$03EF,$03FF,$02FF,$0100,$E000,$E000,$2000,$C000
	.dc.w	$01F7,$03FF,$038C,$0073,$C000,$E000,$E000,$0000
	.dc.w	$006F,$00FF,$00FF,$0000,$0000,$8000,$8000,$0000
shtimg11:		* Friendly Shot (Perspective:1 - Animation:1)
	.dc.w	12,12
	.dc.w	25,2
	.dc.w	$0000,$00FF,$00FF,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0100,$03FF,$0390,$006F,$0000,$8000,$8000,$0000
	.dc.w	$0220,$03FF,$027F,$0180,$8000,$F000,$F000,$0000
	.dc.w	$0905,$1FCF,$1FCF,$0000,$4000,$FC00,$5C00,$A000
	.dc.w	$140A,$1C0F,$140B,$0804,$8000,$FC00,$E400,$1800
	.dc.w	$0004,$1C0F,$140F,$0800,$0400,$FC00,$5400,$A800
	.dc.w	$0001,$7C01,$7C01,$0000,$0200,$FF00,$EF00,$1000
	.dc.w	$0000,$7000,$5000,$2000,$4200,$7F00,$5700,$2800
	.dc.w	$0000,$7000,$5000,$2000,$2500,$7F00,$6D00,$1200
	.dc.w	$0000,$F000,$F000,$0000,$1200,$3F00,$3F00,$0000
	.dc.w	$0000,$E000,$A000,$4000,$0000,$0000,$0000,$0000
	.dc.w	$A000,$E000,$A000,$4000,$0100,$0100,$0100,$0000
	.dc.w	$0000,$E000,$A000,$4000,$0100,$0100,$0100,$0000
	.dc.w	$0000,$E000,$A000,$4000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$0000,$0000,$0100
	.dc.w	$0000,$7000,$7000,$0000,$0000,$0000,$0000,$0100
	.dc.w	$0000,$7000,$5000,$2000,$0000,$0000,$0000,$0200
	.dc.w	$0000,$7800,$7800,$0000,$0000,$0000,$0000,$0200
	.dc.w	$0000,$3800,$2800,$1000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$3800,$3800,$0000,$0800,$0000,$0000,$0800
	.dc.w	$0000,$0700,$0700,$0000,$0800,$0000,$0000,$0800
	.dc.w	$0000,$0780,$0580,$0200,$2000,$0000,$0000,$2000
	.dc.w	$0000,$07FE,$06FE,$0100,$4000,$0000,$0000,$4000
	.dc.w	$0001,$03FE,$03A2,$005D,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00FE,$00FE,$0000,$0000,$0000,$0000,$0000
shtimg12:		* Friendly Shot (Perspective:1 - Animation:2)
	.dc.w	12,12
	.dc.w	24,2
	.dc.w	$0000,$00FF,$00FF,$0000,$0000,$8000,$8000,$0000
	.dc.w	$006B,$0394,$0394,$006B,$0000,$E000,$E000,$0000
	.dc.w	$0180,$067F,$067F,$0180,$4000,$B000,$B000,$4000
	.dc.w	$0200,$0DC0,$0DC0,$0200,$2000,$DC00,$DC00,$2000
	.dc.w	$0C00,$1300,$1300,$0C00,$1800,$6400,$6400,$1800
	.dc.w	$0800,$3600,$3600,$0800,$2800,$5400,$5400,$2800
	.dc.w	$1000,$6C00,$6C00,$1000,$0000,$7C00,$7C00,$0000
	.dc.w	$2000,$5800,$5800,$2000,$1000,$2E00,$2E00,$1000
	.dc.w	$0000,$F000,$F000,$0000,$0400,$3B80,$3B80,$0400
	.dc.w	$4000,$A000,$A000,$4000,$0100,$1E80,$1E80,$0100
	.dc.w	$0000,$E000,$E000,$0000,$0B00,$1480,$1480,$0B00
	.dc.w	$4000,$A000,$A000,$4000,$0500,$1A80,$1A80,$0500
	.dc.w	$4000,$A000,$A000,$4000,$0A00,$1580,$1580,$0A00
	.dc.w	$4000,$A000,$A000,$4000,$0500,$1A80,$1A80,$0500
	.dc.w	$4000,$A000,$A000,$4000,$0100,$0E80,$0E80,$0100
	.dc.w	$4000,$B000,$B000,$4000,$0000,$0380,$0380,$0000
	.dc.w	$2000,$D000,$D000,$2000,$0200,$0200,$0200,$0000
	.dc.w	$0000,$7800,$7800,$0000,$0200,$0200,$0200,$0000
	.dc.w	$1000,$2C00,$2C00,$1000,$0000,$0000,$0000,$0000
	.dc.w	$0800,$3400,$3400,$0800,$0800,$0800,$0800,$0000
	.dc.w	$0800,$1400,$1400,$0800,$1000,$1000,$1000,$0000
	.dc.w	$0000,$1C00,$1C00,$0200,$2000,$2000,$2000,$0000
	.dc.w	$0000,$0000,$0000,$0180,$8000,$8000,$8000,$0000
	.dc.w	$0001,$0001,$0001,$006E,$0000,$0000,$0000,$0000
shtimg13:		* Friendly Shot (Perspective:1 - Animation:3)
	.dc.w	12,12
	.dc.w	24,2
	.dc.w	$0000,$00FF,$00FF,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0392,$0392,$006D,$0000,$E000,$E000,$0000
	.dc.w	$0000,$02FF,$02FF,$0100,$0000,$3000,$3000,$C000
	.dc.w	$0000,$1F81,$1F81,$0000,$0000,$D000,$D000,$2000
	.dc.w	$0000,$1200,$1200,$0C00,$0000,$7C00,$7C00,$0000
	.dc.w	$0000,$3E00,$3E00,$0000,$0000,$1600,$1600,$0800
	.dc.w	$0000,$6800,$6800,$1000,$0000,$1A00,$1A00,$0400
	.dc.w	$0000,$5800,$5800,$2000,$0000,$0F00,$0F00,$0000
	.dc.w	$0000,$D000,$D000,$2000,$0000,$0580,$0580,$0200
	.dc.w	$0000,$B000,$B000,$4000,$0000,$0680,$0680,$0100
	.dc.w	$0000,$E000,$E000,$0000,$0000,$0200,$0200,$0100
	.dc.w	$0000,$E000,$E000,$0000,$0000,$0F80,$0F80,$0000
	.dc.w	$0000,$A000,$A000,$4000,$0000,$0A80,$0A80,$0500
	.dc.w	$0000,$A000,$A000,$4000,$0100,$1E00,$1E00,$0100
	.dc.w	$0000,$E000,$E000,$0000,$0000,$2F80,$2F80,$1000
	.dc.w	$0000,$B000,$B000,$4000,$0000,$3E80,$3A80,$0500
	.dc.w	$0000,$D000,$D000,$2000,$0200,$FD00,$ED00,$1200
	.dc.w	$0000,$7001,$7001,$0000,$0000,$5F00,$5F00,$A000
	.dc.w	$1000,$1001,$1001,$0000,$5000,$AA00,$AA00,$5400
	.dc.w	$0000,$0E01,$0E01,$0000,$0000,$6600,$4600,$A800
	.dc.w	$0000,$0A00,$0A00,$0400,$0000,$BC00,$B400,$4800
	.dc.w	$0000,$0F80,$0F80,$0000,$0000,$F800,$F800,$0000
	.dc.w	$0000,$0280,$0280,$0100,$C000,$C000,$C000,$0000
	.dc.w	$0067,$03E7,$03E7,$0000,$0000,$0000,$0000,$0000
shtimg14:		* Friendly Shot (Perspective:1 - Animation:4)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$00FE,$00FE,$00FE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0301,$0301,$0301,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0400,$0400,$007C,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0181,$3000,$3000,$3000,$0000
	.dc.w	$1000,$1000,$1000,$0600,$0000,$0000,$0000,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$2000
	.dc.w	$4000,$4000,$4000,$0800,$0400,$0400,$0400,$2000
	.dc.w	$4000,$4000,$4000,$0000,$0400,$0400,$0400,$0000
	.dc.w	$8000,$8000,$8000,$0000,$0200,$0200,$0200,$0000
	.dc.w	$A000,$A000,$A000,$0000,$0200,$0200,$0200,$0000
	.dc.w	$8000,$8000,$8000,$0000,$0200,$0200,$0200,$0800
	.dc.w	$8000,$8000,$8000,$0000,$0200,$0200,$0200,$0800
	.dc.w	$2000,$2000,$2000,$0000,$0200,$0200,$0200,$0800
	.dc.w	$A000,$A000,$A000,$0000,$0200,$0200,$0200,$0800
	.dc.w	$9000,$9000,$9000,$0000,$0200,$0200,$0200,$9000
	.dc.w	$4000,$4000,$4000,$0000,$0400,$0400,$0400,$0000
	.dc.w	$4800,$4800,$4800,$0000,$0400,$0400,$0400,$2000
	.dc.w	$2000,$2000,$2000,$000A,$0000,$0000,$0000,$2000
	.dc.w	$1200,$1200,$1200,$0010,$1000,$1000,$1000,$8000
	.dc.w	$0880,$0880,$0880,$002A,$3000,$3000,$3000,$0000
	.dc.w	$0400,$0400,$0400,$0065,$4000,$4000,$4000,$0000
	.dc.w	$0300,$0300,$0300,$002A,$0000,$0000,$0000,$0000
	.dc.w	$0076,$0076,$0076,$0000,$0000,$0000,$0000,$0000
shtimg15:		* Friendly Shot (Perspective:1 - Animation:5)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$00FE,$00FE,$00FE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0100,$0100,$0100,$0000,$8000,$8000,$8000,$0000
	.dc.w	$0400,$0400,$0400,$005C,$0000,$0000,$0000,$0000
	.dc.w	$0800,$0800,$0800,$0081,$3000,$3000,$3000,$0000
	.dc.w	$1000,$1000,$1000,$0600,$4000,$0000,$0000,$C000
	.dc.w	$2000,$2000,$2000,$0000,$2800,$0800,$0800,$2000
	.dc.w	$4800,$4800,$4800,$0000,$2000,$0000,$0000,$2000
	.dc.w	$1000,$1000,$1000,$0000,$0400,$0400,$0400,$0000
	.dc.w	$9000,$9000,$9000,$0000,$0200,$0200,$0200,$0000
	.dc.w	$8000,$8000,$8000,$0000,$0A00,$0200,$0200,$0800
	.dc.w	$A000,$A000,$A000,$0000,$0A00,$0200,$0200,$0800
	.dc.w	$A000,$A000,$A000,$0000,$0800,$0000,$0000,$0800
	.dc.w	$2000,$2000,$2000,$0000,$0A00,$0200,$0200,$0800
	.dc.w	$A000,$A000,$A000,$0000,$0200,$0200,$0200,$0000
	.dc.w	$9000,$8000,$8000,$1200,$1200,$0200,$0200,$1000
	.dc.w	$5000,$4000,$4000,$1400,$1400,$0400,$0400,$1000
	.dc.w	$4800,$4000,$4000,$0A20,$2400,$0400,$0400,$2000
	.dc.w	$0800,$0000,$0000,$0D00,$2800,$0800,$0800,$2000
	.dc.w	$1200,$1000,$1000,$0240,$D000,$1000,$1000,$C000
	.dc.w	$0980,$0800,$0800,$0180,$0000,$0000,$0000,$0000
	.dc.w	$0464,$0400,$0400,$0064,$4000,$4000,$4000,$0000
	.dc.w	$0301,$0301,$0301,$0000,$8000,$8000,$8000,$0000
	.dc.w	$00FC,$00FC,$00FC,$0000,$0000,$0000,$0000,$0000
shtimg16:		* Friendly Shot (Perspective:1 - Animation:6)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$005A,$005A,$005A,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0300,$0300,$0300,$0000,$8000,$8000,$8000,$0000
	.dc.w	$0420,$0420,$0420,$000C,$4000,$4000,$4000,$0000
	.dc.w	$1880,$1880,$1880,$0003,$3000,$3000,$3000,$0000
	.dc.w	$1400,$1400,$1400,$0000,$1000,$1000,$1000,$4000
	.dc.w	$2800,$2800,$2800,$0000,$0000,$0000,$0000,$2000
	.dc.w	$4800,$4800,$4800,$0000,$0400,$0400,$0400,$0000
	.dc.w	$4000,$5000,$4000,$1000,$1400,$0400,$0400,$1000
	.dc.w	$8000,$9000,$8000,$1400,$0200,$0200,$0200,$0000
	.dc.w	$8000,$A000,$8000,$3000,$0A00,$0200,$0200,$0800
	.dc.w	$8000,$A000,$8000,$2800,$0A00,$0200,$0200,$0800
	.dc.w	$8000,$8000,$8000,$1400,$0A00,$0200,$0200,$0800
	.dc.w	$8000,$A000,$8000,$2800,$0A00,$0200,$0200,$0800
	.dc.w	$8000,$A000,$8000,$2200,$0200,$0A00,$0200,$0800
	.dc.w	$0000,$1000,$0000,$1400,$0200,$1200,$0200,$1000
	.dc.w	$4000,$4000,$4000,$0000,$0400,$1400,$0400,$1000
	.dc.w	$0000,$0800,$0000,$0800,$0400,$2400,$0400,$2000
	.dc.w	$2000,$2000,$2000,$0000,$0800,$2800,$0800,$2000
	.dc.w	$1000,$1600,$1000,$0600,$1000,$5000,$1000,$4000
	.dc.w	$1000,$1103,$1000,$0103,$3000,$3000,$3000,$0000
	.dc.w	$0000,$005C,$0000,$005C,$4000,$4000,$4000,$0000
	.dc.w	$0301,$0301,$0301,$0000,$8000,$8000,$8000,$0000
	.dc.w	$00AE,$00AE,$00AE,$0000,$0000,$0000,$0000,$0000
shtimg17:		* Friendly Shot (Perspective:1 - Animation:7)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$00DE,$00DE,$00DE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0200,$0200,$0200,$00A4,$8000,$8000,$8000,$0000
	.dc.w	$0464,$0464,$0400,$006E,$4000,$4000,$4000,$0000
	.dc.w	$1803,$1803,$1801,$00AA,$3000,$3000,$3000,$0000
	.dc.w	$0000,$0000,$0000,$0154,$9000,$9000,$9000,$0000
	.dc.w	$0800,$0800,$0000,$0828,$2800,$2800,$2800,$0000
	.dc.w	$4000,$4000,$4000,$0000,$2400,$2400,$2400,$0000
	.dc.w	$1000,$1000,$0000,$1100,$1400,$1400,$1400,$0000
	.dc.w	$9000,$9000,$8000,$1000,$0200,$0200,$0200,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0A00,$0A00,$0A00,$0000
	.dc.w	$A000,$A000,$8000,$2000,$0000,$0000,$0000,$0800
	.dc.w	$A000,$A000,$8000,$2000,$0200,$0200,$0200,$0000
	.dc.w	$8000,$8000,$8000,$0000,$0200,$0200,$0200,$0800
	.dc.w	$A000,$A000,$8000,$2000,$0000,$0000,$0000,$0800
	.dc.w	$0000,$0000,$0000,$0000,$0200,$0200,$0200,$0000
	.dc.w	$4000,$4000,$4000,$0000,$0000,$0000,$0000,$1000
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0400,$0400,$0000
	.dc.w	$0800,$0800,$0000,$0800,$0800,$0800,$0800,$2000
	.dc.w	$1400,$1400,$1000,$0400,$1000,$1000,$1000,$4000
	.dc.w	$1180,$1180,$1000,$0181,$1000,$1000,$1000,$0000
	.dc.w	$045C,$045C,$0400,$005C,$4000,$4000,$4000,$0000
	.dc.w	$0301,$0301,$0301,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0032,$0032,$0032,$0000,$0000,$0000,$0000,$0000
shtimg20:		* Friendly Shot (Perspective:2 - Animation:0)
	.dc.w	10,10
	.dc.w	21,2
	.dc.w	$01FC,$01FC,$01FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$03FF,$03EF,$0347,$00A8,$0000,$0000,$0000,$0000
	.dc.w	$0FFF,$0FFD,$0EF9,$0104,$8000,$8000,$8000,$0000
	.dc.w	$1EAF,$1E87,$1286,$0C29,$C000,$C000,$4000,$8000
	.dc.w	$3C03,$3C00,$3C00,$0002,$C000,$C000,$C000,$0000
	.dc.w	$7809,$7801,$6801,$1008,$0000,$0000,$0000,$0000
	.dc.w	$7800,$7800,$5800,$2000,$0000,$3000,$3000,$0000
	.dc.w	$7000,$7000,$5000,$2000,$7000,$7000,$5000,$2000
	.dc.w	$F000,$F000,$F000,$0000,$5800,$5800,$4800,$1000
	.dc.w	$E000,$E000,$A000,$4000,$1000,$3000,$2000,$1000
	.dc.w	$E000,$E000,$E000,$0000,$1000,$1800,$0800,$1000
	.dc.w	$E000,$E000,$A000,$4000,$3000,$3000,$2000,$1000
	.dc.w	$F000,$F000,$B000,$4000,$3000,$3800,$2800,$1000
	.dc.w	$F000,$F000,$D000,$2000,$3000,$3000,$3000,$0000
	.dc.w	$7800,$7800,$7800,$0000,$6000,$6000,$6000,$0000
	.dc.w	$3800,$3800,$2800,$1000,$E000,$E000,$A000,$4000
	.dc.w	$3E00,$3E00,$3E00,$0000,$C000,$E000,$A000,$4000
	.dc.w	$1F03,$1F03,$1303,$0C00,$4000,$C000,$C000,$0000
	.dc.w	$1FFF,$1FFF,$1DFD,$0202,$0000,$0000,$0000,$0000
	.dc.w	$07FE,$07FE,$074E,$00B0,$0000,$0000,$0000,$0000
	.dc.w	$01F8,$01F8,$01F8,$0000,$0000,$0000,$0000,$0000
shtimg21:		* Friendly Shot (Perspective:2 - Animation:1)
	.dc.w	10,10
	.dc.w	21,2
	.dc.w	$0028,$01FC,$01FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$07FC,$0754,$00A8,$0000,$0000,$0000,$0000
	.dc.w	$00A9,$1FFF,$1CFF,$0300,$0000,$C000,$C000,$0000
	.dc.w	$0012,$3F93,$3782,$0811,$0000,$E000,$6000,$8000
	.dc.w	$0805,$3C07,$2C07,$1000,$0000,$E000,$A000,$4000
	.dc.w	$000F,$380F,$280A,$1005,$0000,$F000,$B000,$4000
	.dc.w	$0004,$7804,$7804,$0000,$5000,$F000,$D000,$2000
	.dc.w	$0001,$F001,$D000,$2001,$8000,$F800,$D800,$2000
	.dc.w	$0001,$F001,$B001,$4000,$C000,$F800,$6800,$9000
	.dc.w	$4000,$E000,$E000,$0000,$8000,$B800,$B800,$0000
	.dc.w	$0000,$E000,$A000,$4000,$0000,$3800,$2800,$1000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$3800,$2800,$1000
	.dc.w	$0000,$F000,$B000,$4000,$0000,$3800,$3800,$0000
	.dc.w	$0000,$F000,$D000,$2000,$0000,$7000,$7000,$0000
	.dc.w	$0000,$7800,$5800,$2000,$0000,$7000,$5000,$2000
	.dc.w	$1000,$7800,$7800,$0000,$0000,$7000,$7000,$0000
	.dc.w	$0000,$3E01,$3E01,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0000,$0F07,$0B07,$0400,$0000,$C000,$4000,$8000
	.dc.w	$0000,$0F7F,$0D7D,$0202,$0000,$C000,$C000,$0000
	.dc.w	$0000,$077F,$074F,$0030,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0078,$0078,$0000,$0000,$0000,$0000,$0000
shtimg22:		* Friendly Shot (Perspective:2 - Animation:2)
	.dc.w	10,10
	.dc.w	21,2
	.dc.w	$0000,$01FC,$01FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00D8,$0727,$0727,$00D8,$0000,$0000,$0000,$0000
	.dc.w	$0206,$0DF9,$0DF9,$0206,$0000,$C000,$C000,$0000
	.dc.w	$0401,$0B0E,$0B0E,$0401,$8000,$4000,$4000,$8000
	.dc.w	$0000,$3E03,$3E03,$0000,$0000,$E000,$E000,$0000
	.dc.w	$1000,$6801,$6800,$1001,$4000,$B000,$B000,$4000
	.dc.w	$2000,$5800,$5800,$2000,$2000,$D000,$D000,$2000
	.dc.w	$2000,$D002,$D000,$2002,$0000,$7800,$7800,$0000
	.dc.w	$4000,$B000,$B000,$4000,$1000,$A800,$2800,$9000
	.dc.w	$4000,$A000,$A000,$4000,$1000,$6800,$2800,$5000
	.dc.w	$4000,$A000,$A000,$4000,$0000,$B800,$3800,$8000
	.dc.w	$4000,$A000,$A000,$4000,$1000,$6800,$2800,$5000
	.dc.w	$0000,$E000,$E000,$0000,$1000,$2800,$2800,$1000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$7800,$7800,$0000
	.dc.w	$0000,$3800,$3800,$0000,$2000,$5000,$5000,$2000
	.dc.w	$1000,$2800,$2800,$1000,$0000,$F000,$F000,$0000
	.dc.w	$1000,$2C01,$2C01,$1000,$4000,$A000,$A000,$4000
	.dc.w	$0800,$370F,$370F,$0800,$8000,$6000,$6000,$8000
	.dc.w	$0206,$1D79,$1D79,$0206,$0000,$C000,$C000,$0000
	.dc.w	$0030,$074F,$074F,$0030,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0078,$0078,$0000,$0000,$0000,$0000,$0000
shtimg23:		* Friendly Shot (Perspective:2 - Animation:3)
	.dc.w	10,10
	.dc.w	21,2
	.dc.w	$0000,$00FC,$00FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07B7,$07B7,$0048,$0000,$0000,$0000,$0000
	.dc.w	$0000,$05F9,$05F9,$0206,$0000,$C000,$C000,$0000
	.dc.w	$0000,$3F0F,$3F0F,$0000,$0000,$6000,$6000,$8000
	.dc.w	$0000,$2801,$2801,$1000,$0000,$A000,$A000,$4000
	.dc.w	$0000,$2800,$2800,$1000,$0000,$F000,$F000,$0000
	.dc.w	$0000,$7800,$7800,$0000,$0000,$5000,$5000,$2000
	.dc.w	$0000,$D000,$D000,$2000,$0000,$5800,$5800,$2000
	.dc.w	$0000,$B000,$B000,$4000,$0000,$6800,$6800,$1000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$3800,$2800,$1000
	.dc.w	$0000,$A000,$A000,$4000,$4000,$3800,$3800,$4000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$2800,$2800,$1000
	.dc.w	$0000,$A000,$A000,$4000,$4000,$3800,$2800,$5000
	.dc.w	$0002,$E000,$E000,$0002,$8000,$7800,$7800,$8000
	.dc.w	$0001,$0000,$0000,$0001,$0000,$D000,$D000,$2000
	.dc.w	$0002,$3800,$3800,$0002,$0000,$B000,$3000,$C000
	.dc.w	$0000,$2E03,$2E03,$1000,$0000,$A000,$A000,$4000
	.dc.w	$0000,$3386,$3386,$0C01,$0000,$E000,$E000,$0000
	.dc.w	$0000,$1CFD,$1CFD,$0302,$0000,$8000,$8000,$0000
	.dc.w	$0000,$074F,$074F,$00B0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01F8,$01F8,$0000,$0000,$0000,$0000,$0000
shtimg24:		* Friendly Shot (Perspective:2 - Animation:4)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0190,$0190,$0190,$0000,$0000,$0000,$0000,$0000
	.dc.w	$040C,$040C,$040C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0803,$0803,$0803,$01E0,$0000,$0000,$0000,$0000
	.dc.w	$2000,$2000,$2000,$0604,$8000,$8000,$8000,$0000
	.dc.w	$2000,$2000,$2000,$0002,$8000,$8000,$8000,$0000
	.dc.w	$4000,$4000,$4000,$1000,$4000,$4000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4000,$4000,$4000,$0000
	.dc.w	$8000,$8000,$8000,$2000,$2000,$2000,$2000,$8000
	.dc.w	$8000,$8000,$8000,$0000,$0000,$0000,$0000,$8000
	.dc.w	$8000,$8000,$8000,$0000,$2000,$2000,$2000,$8000
	.dc.w	$0000,$0000,$0000,$2004,$2000,$2000,$2000,$8000
	.dc.w	$0000,$0000,$0000,$2000,$2000,$2000,$2000,$8000
	.dc.w	$0000,$0000,$0000,$1009,$4000,$4000,$4000,$0000
	.dc.w	$4000,$4000,$4000,$0005,$4000,$4000,$4000,$0000
	.dc.w	$2000,$2000,$2000,$0050,$8000,$8000,$8000,$0000
	.dc.w	$2000,$2000,$2000,$04A4,$8000,$8000,$8000,$0000
	.dc.w	$0001,$0001,$0001,$01D0,$0000,$0000,$0000,$0000
	.dc.w	$0408,$0408,$0408,$0020,$0000,$0000,$0000,$0000
	.dc.w	$01D0,$01D0,$01D0,$0000,$0000,$0000,$0000,$0000
shtimg25:		* Friendly Shot (Perspective:2 - Animation:5)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0170,$0170,$0170,$0000,$0000,$0000,$0000,$0000
	.dc.w	$020C,$020C,$020C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$11D1,$1001,$1001,$01D0,$0000,$0000,$0000,$0000
	.dc.w	$240C,$2000,$2000,$040C,$0000,$0000,$0000,$0000
	.dc.w	$0802,$0000,$0000,$0802,$0000,$0000,$0000,$0000
	.dc.w	$1000,$0000,$0000,$1000,$4000,$4000,$4000,$0000
	.dc.w	$4000,$4000,$4000,$0000,$4000,$4000,$4000,$0000
	.dc.w	$A000,$8000,$8000,$2000,$2000,$2000,$2000,$0000
	.dc.w	$8000,$8000,$8000,$0000,$A000,$2000,$2000,$8000
	.dc.w	$A000,$8000,$8000,$2000,$0000,$0000,$0000,$0000
	.dc.w	$A000,$8000,$8000,$2000,$8000,$0000,$0000,$8000
	.dc.w	$A000,$8000,$8000,$2000,$A000,$2000,$2000,$8000
	.dc.w	$5000,$4000,$4000,$1A00,$4000,$4000,$4000,$0000
	.dc.w	$5001,$4000,$4000,$1441,$4000,$4000,$4000,$0000
	.dc.w	$2002,$2000,$2000,$0A02,$8000,$8000,$8000,$0000
	.dc.w	$2404,$2000,$2000,$0504,$0000,$0000,$0000,$0000
	.dc.w	$0863,$0803,$0803,$0260,$0000,$0000,$0000,$0000
	.dc.w	$020C,$020C,$020C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01F0,$01F0,$01F0,$0000,$0000,$0000,$0000,$0000
shtimg26:		* Friendly Shot (Perspective:2 - Animation:6)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$00F0,$00F0,$00F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0604,$0604,$0604,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1802,$1862,$1802,$0060,$0000,$0000,$0000,$0000
	.dc.w	$2000,$2604,$2000,$0604,$8000,$8000,$8000,$0000
	.dc.w	$2000,$2800,$2000,$0800,$8000,$8000,$8000,$0000
	.dc.w	$0000,$0001,$0000,$0001,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1001,$0000,$1001,$4000,$4000,$4000,$0000
	.dc.w	$8000,$A000,$8000,$2800,$2000,$2000,$2000,$0000
	.dc.w	$8000,$8000,$8000,$5400,$2000,$2000,$2000,$0000
	.dc.w	$8000,$A000,$8000,$2800,$2000,$A000,$2000,$8000
	.dc.w	$0000,$2000,$0000,$2000,$2000,$2000,$2000,$0000
	.dc.w	$8000,$A000,$8000,$2400,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1000,$0000,$1000,$4000,$4000,$4000,$0000
	.dc.w	$4000,$5001,$4000,$1001,$4000,$4000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$8000,$8000,$8000,$0000
	.dc.w	$2000,$2600,$2000,$0600,$8000,$8000,$8000,$0000
	.dc.w	$1802,$1952,$1802,$0150,$0000,$0000,$0000,$0000
	.dc.w	$020C,$020C,$020C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01B0,$01B0,$01B0,$0000,$0000,$0000,$0000,$0000
shtimg27:		* Friendly Shot (Perspective:2 - Animation:7)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$01D0,$01D0,$01D0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$040C,$040C,$040C,$0020,$0000,$0000,$0000,$0000
	.dc.w	$09C3,$09C3,$0803,$01C0,$0000,$0000,$0000,$0000
	.dc.w	$220C,$220C,$2000,$02AC,$0000,$0000,$0000,$0000
	.dc.w	$2000,$2000,$2000,$0540,$0000,$0000,$0000,$0000
	.dc.w	$5001,$5001,$4000,$1001,$4000,$4000,$4000,$0000
	.dc.w	$4000,$4000,$4000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$8000,$8000,$0000,$A000,$A000,$2000,$8000
	.dc.w	$A000,$A000,$8000,$2000,$A000,$A000,$2000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$2000,$2000,$0000
	.dc.w	$2000,$2000,$0000,$2000,$A000,$A000,$2000,$8000
	.dc.w	$8000,$8000,$8000,$0000,$2000,$2000,$2000,$0000
	.dc.w	$1001,$1001,$0000,$1001,$4000,$4000,$4000,$0000
	.dc.w	$4001,$4001,$4000,$0001,$4000,$4000,$4000,$0000
	.dc.w	$0002,$0002,$0000,$0002,$8000,$8000,$8000,$0000
	.dc.w	$0204,$0204,$0000,$0204,$8000,$8000,$8000,$0000
	.dc.w	$11B1,$11B1,$1001,$01B0,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0400,$0400,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0150,$0150,$0150,$0000,$0000,$0000,$0000,$0000
shtimg30:		* Friendly Shot (Perspective:3 - Animation:0)
	.dc.w	8,8
	.dc.w	17,2
	.dc.w	$07F0,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1FFC,$1FFC,$1C1C,$03E0,$0000,$0000,$0000,$0000
	.dc.w	$1FFE,$1FFE,$12F6,$0D08,$0000,$0000,$0000,$0000
	.dc.w	$7E9E,$7E1E,$741A,$0A04,$0000,$0000,$0000,$0000
	.dc.w	$710F,$710F,$500F,$2100,$0000,$0000,$0000,$0000
	.dc.w	$F807,$F007,$F005,$0002,$8000,$8000,$8000,$0000
	.dc.w	$E007,$E007,$A006,$4001,$8000,$8000,$8000,$0000
	.dc.w	$E003,$E003,$A002,$4001,$8000,$8000,$8000,$0000
	.dc.w	$E003,$E003,$E003,$0000,$8000,$8000,$8000,$0000
	.dc.w	$E003,$E003,$A002,$4001,$8000,$8000,$8000,$0000
	.dc.w	$F003,$F003,$B002,$4001,$8000,$8000,$8000,$0000
	.dc.w	$F007,$F007,$D007,$2000,$8000,$8000,$8000,$0000
	.dc.w	$700F,$700F,$500D,$2002,$0000,$0000,$0000,$0000
	.dc.w	$7E1F,$7E1F,$7E1B,$0004,$0000,$0000,$0000,$0000
	.dc.w	$1FFE,$1FFE,$13F6,$0C08,$0000,$0000,$0000,$0000
	.dc.w	$1FFC,$1FFC,$1E1C,$01E0,$0000,$0000,$0000,$0000
	.dc.w	$03F0,$03F0,$03F0,$0000,$0000,$0000,$0000,$0000
shtimg31:		* Friendly Shot (Perspective:3 - Animation:1)
	.dc.w	8,8
	.dc.w	17,2
	.dc.w	$0000,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFC,$1C5C,$03A0,$0000,$0000,$0000,$0000
	.dc.w	$0040,$1FBE,$13A6,$0C58,$0000,$0000,$0000,$0000
	.dc.w	$0090,$7EAF,$7E2B,$0094,$0000,$0000,$0000,$0000
	.dc.w	$0028,$7027,$5005,$202A,$0000,$0000,$0000,$0000
	.dc.w	$0010,$F007,$D007,$2010,$0000,$8000,$8000,$0000
	.dc.w	$0000,$F003,$B002,$4001,$0000,$8000,$8000,$0000
	.dc.w	$0000,$E003,$E002,$0001,$0000,$8000,$8000,$0000
	.dc.w	$0000,$E003,$A002,$4001,$0000,$8000,$8000,$0000
	.dc.w	$0000,$E003,$E002,$0001,$0000,$8000,$8000,$0000
	.dc.w	$0000,$E007,$A007,$4000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$F007,$F005,$0002,$0000,$0000,$0000,$0000
	.dc.w	$0000,$780F,$580D,$2002,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7C3F,$6C3B,$1004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$3FFE,$37E6,$0818,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFC,$1D5C,$02A0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
shtimg32:		* Friendly Shot (Perspective:3 - Animation:2)
	.dc.w	8,8
	.dc.w	17,2
	.dc.w	$0000,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0360,$0C98,$0C98,$0360,$0000,$0000,$0000,$0000
	.dc.w	$0410,$3BEE,$3BEE,$0410,$0000,$0000,$0000,$0000
	.dc.w	$1004,$6E3B,$6E3B,$1004,$0000,$0000,$0000,$0000
	.dc.w	$2002,$581D,$580D,$2012,$0000,$0000,$0000,$0000
	.dc.w	$0002,$700D,$7005,$000A,$0000,$0000,$0000,$0000
	.dc.w	$0004,$E003,$E003,$0004,$0000,$8000,$8000,$0000
	.dc.w	$4001,$A00A,$A002,$4009,$0000,$8000,$8000,$0000
	.dc.w	$4001,$A006,$A002,$4005,$0000,$8000,$8000,$0000
	.dc.w	$0001,$E00A,$E002,$0009,$0000,$8000,$8000,$0000
	.dc.w	$0001,$7006,$7006,$0001,$0000,$8000,$8000,$0000
	.dc.w	$2002,$5005,$5005,$2002,$0000,$8000,$8000,$0000
	.dc.w	$0002,$700D,$700D,$0002,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0E1B,$0E1B,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0408,$0BF6,$0BF6,$0408,$0000,$0000,$0000,$0000
	.dc.w	$0360,$0C9C,$0C9C,$0360,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
shtimg33:		* Friendly Shot (Perspective:3 - Animation:3)
	.dc.w	8,8
	.dc.w	17,2
	.dc.w	$0000,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1CDC,$1CDC,$0320,$0000,$0000,$0000,$0000
	.dc.w	$0000,$37E6,$37E6,$0818,$0000,$0000,$0000,$0000
	.dc.w	$0000,$6C3A,$6C3A,$1004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$580F,$580F,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$F005,$F005,$0002,$0000,$8000,$8000,$0000
	.dc.w	$0000,$A006,$A006,$4001,$0000,$8000,$8000,$0000
	.dc.w	$0000,$E003,$E003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0002,$A003,$A003,$4000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$A002,$A002,$4001,$0000,$8000,$8000,$0000
	.dc.w	$0008,$F001,$F001,$000A,$0000,$8000,$8000,$0000
	.dc.w	$0015,$5007,$5007,$2010,$0000,$0000,$0000,$0000
	.dc.w	$0000,$500D,$5005,$200A,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7E1B,$7E1B,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$13F6,$13F6,$0C08,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1E1C,$1E1C,$01E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03F0,$03F0,$0000,$0000,$0000,$0000,$0000
shtimg34:		* Friendly Shot (Perspective:3 - Animation:4)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0700,$0700,$0700,$0000,$1030,$1030,$1030,$0000
	.dc.w	$2008,$2008,$2008,$0380,$4004,$4004,$4004,$0800
	.dc.w	$0004,$0004,$0004,$1000,$0002,$0002,$0002,$0000
	.dc.w	$8002,$8002,$8002,$2008,$8000,$8000,$8000,$2008
	.dc.w	$8002,$8002,$8002,$2020,$8002,$8002,$8002,$0008
	.dc.w	$4004,$4004,$4004,$1050,$4004,$4004,$4004,$0AA0
	.dc.w	$2008,$2008,$2008,$0340,$1030,$1030,$1030,$0480
	.dc.w	$0380,$0380,$0380,$0000
shtimg35:		* Friendly Shot (Perspective:3 - Animation:5)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0780,$0780,$0780,$0000,$1830,$1830,$1830,$0000
	.dc.w	$23C8,$2008,$2008,$03C0,$4804,$4004,$4004,$0800
	.dc.w	$5014,$4004,$4004,$1010,$0000,$0000,$0000,$0000
	.dc.w	$A00A,$8002,$8002,$2008,$0002,$0002,$0002,$0000
	.dc.w	$A002,$8002,$8002,$2000,$000A,$0002,$0002,$2808
	.dc.w	$1014,$0004,$0004,$5010,$4004,$4004,$4004,$2500
	.dc.w	$20C8,$2008,$2008,$08C0,$1800,$1800,$1800,$0200
	.dc.w	$04C0,$04C0,$04C0,$0000
shtimg36:		* Friendly Shot (Perspective:3 - Animation:6)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$07C0,$07C0,$07C0,$0000,$1830,$1830,$1830,$0000
	.dc.w	$2008,$2388,$2008,$0380,$4004,$4804,$4004,$0800
	.dc.w	$4004,$4014,$4004,$0010,$8002,$8002,$8002,$0000
	.dc.w	$8002,$A00A,$8002,$2808,$0002,$200A,$0002,$7008
	.dc.w	$8002,$A002,$8002,$2800,$8002,$A00A,$8002,$7408
	.dc.w	$0004,$1014,$0004,$1010,$4004,$4804,$4004,$2800
	.dc.w	$2000,$26C0,$2000,$06C0,$1820,$1820,$1820,$0000
	.dc.w	$01C0,$01C0,$01C0,$0000
shtimg37:		* Friendly Shot (Perspective:3 - Animation:7)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$05C0,$05C0,$05C0,$0000,$1810,$1810,$1810,$0000
	.dc.w	$2688,$2688,$2008,$0E80,$4024,$4024,$4004,$1420
	.dc.w	$4010,$4010,$4000,$2810,$A002,$A002,$8002,$3000
	.dc.w	$A00A,$A00A,$8002,$2008,$200A,$200A,$0002,$2008
	.dc.w	$8008,$8008,$8000,$0808,$A00A,$A00A,$8002,$2008
	.dc.w	$4014,$4014,$4004,$0010,$4820,$4820,$4000,$0820
	.dc.w	$2780,$2780,$2000,$0780,$1830,$1830,$1830,$0000
	.dc.w	$03C0,$03C0,$03C0,$0000
shtimg40:		* Friendly Shot (Perspective:4 - Animation:0)
	.dc.w	6,6
	.dc.w	13,1
	.dc.w	$0F00,$0F00,$0F00,$0000,$1F80,$1F80,$1280,$0D00
	.dc.w	$7FC0,$7FC0,$75C0,$0A00,$FF80,$FF80,$DE80,$2120
	.dc.w	$F380,$F380,$B380,$4010,$E000,$E000,$E000,$0000
	.dc.w	$E010,$E038,$A038,$4000,$E038,$E038,$E028,$0010
	.dc.w	$E010,$E078,$A078,$4000,$F870,$F8F0,$F8D0,$0020
	.dc.w	$3FE0,$3FF0,$2FB0,$1040,$3FC0,$3FE0,$30E0,$0F00
	.dc.w	$1F80,$1F80,$1F80,$0000
shtimg41:		* Friendly Shot (Perspective:4 - Animation:1)
	.dc.w	6,6
	.dc.w	13,1
	.dc.w	$0000,$1FC0,$1FC0,$0000,$0000,$3FE0,$3560,$0A80
	.dc.w	$0180,$7FF0,$6FB0,$1040,$0000,$FFF8,$DB58,$24A0
	.dc.w	$0020,$FFF8,$BFA8,$4050,$0050,$E0F8,$E0D8,$0020
	.dc.w	$0020,$E070,$E070,$0000,$0010,$E010,$A010,$4000
	.dc.w	$0000,$F000,$B000,$4000,$0020,$F020,$D020,$2000
	.dc.w	$0000,$7F00,$7F00,$0040,$0000,$1F00,$1500,$0A80
	.dc.w	$0000,$1F00,$1F00,$0000
shtimg42:		* Friendly Shot (Perspective:4 - Animation:2)
	.dc.w	6,6
	.dc.w	13,1
	.dc.w	$0000,$1FC0,$1FC0,$0000,$0A80,$1560,$1560,$0A80
	.dc.w	$1060,$7FA0,$7FA0,$0040,$2170,$D2D0,$D2D0,$2120
	.dc.w	$4030,$B3A8,$B3A8,$4010,$0050,$E0A8,$E0A8,$0050
	.dc.w	$40A0,$A0E8,$A0A8,$4040,$4050,$A0A8,$A0A8,$4050
	.dc.w	$4000,$B0F8,$B0F8,$4000,$2020,$D020,$D020,$2000
	.dc.w	$0000,$7F00,$7F00,$0040,$0E00,$1300,$1300,$0C80
	.dc.w	$0000,$1F00,$1F00,$0000
shtimg43:		* Friendly Shot (Perspective:4 - Animation:3)
	.dc.w	6,6
	.dc.w	13,1
	.dc.w	$0000,$1FC0,$1FC0,$0000,$0000,$1260,$1260,$0D80
	.dc.w	$0000,$7FB0,$7FB0,$0040,$0000,$D0D8,$D0D8,$2020
	.dc.w	$0000,$B068,$B068,$4010,$0000,$A1E8,$A1E8,$4010
	.dc.w	$0090,$E1E8,$E1E8,$0010,$00B8,$0348,$0348,$00B0
	.dc.w	$40D0,$4238,$4238,$01C0,$0080,$0338,$0338,$0080
	.dc.w	$1040,$1380,$1380,$0040,$0C00,$0E80,$0E80,$0100
	.dc.w	$0000,$0380,$0380,$0000
shtimg44:		* Friendly Shot (Perspective:4 - Animation:4)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$1600,$1600,$1600,$0000,$2080,$2280,$2280,$0000
	.dc.w	$4C00,$4D80,$4D80,$0000,$9120,$9120,$9120,$0000
	.dc.w	$A020,$A060,$A060,$0000,$A0A0,$A0A0,$A0A0,$0000
	.dc.w	$80A0,$80E0,$80E0,$0000,$8120,$8120,$8120,$1400
	.dc.w	$4A40,$4F40,$4740,$0800,$0080,$0280,$0280,$1500
	.dc.w	$1B00,$1B00,$1100,$0A00
shtimg45:		* Friendly Shot (Perspective:4 - Animation:5)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$1E00,$1E00,$1E00,$0000,$2080,$2080,$2080,$0000
	.dc.w	$0840,$0840,$0840,$0600,$9000,$9000,$9000,$0000
	.dc.w	$8020,$8020,$8020,$0080,$0020,$0060,$0060,$2000
	.dc.w	$A020,$9020,$8020,$3080,$4020,$0060,$0060,$5100
	.dc.w	$6800,$5080,$5080,$2E00,$2880,$2680,$2680,$0800
	.dc.w	$0700,$0700,$0700,$0000
shtimg46:		* Friendly Shot (Perspective:4 - Animation:6)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$1500,$1500,$1500,$0000,$2080,$2080,$2080,$0000
	.dc.w	$4C40,$4C40,$4C40,$0000,$9120,$9020,$9020,$0100
	.dc.w	$6000,$0000,$0000,$6000,$A020,$4020,$4020,$A000
	.dc.w	$A0A0,$0020,$0020,$E080,$8100,$C000,$C000,$2100
	.dc.w	$4A40,$6040,$6040,$0A00,$0080,$3480,$3480,$0000
	.dc.w	$1D00,$1D00,$1D00,$0000
shtimg47:		* Friendly Shot (Perspective:4 - Animation:7)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$0F00,$0F00,$0F00,$0000,$2000,$0000,$0000,$2000
	.dc.w	$5640,$0640,$0640,$7000,$0000,$7040,$6040,$9100
	.dc.w	$C020,$C020,$C020,$2000,$A020,$E060,$A060,$4080
	.dc.w	$C000,$E040,$C040,$2000,$0020,$3020,$2020,$1000
	.dc.w	$4040,$46C0,$40C0,$0600,$2000,$3B00,$3B00,$0000
	.dc.w	$0B00,$0B00,$0B00,$0000
shtimg50:		* Friendly Shot (Perspective:5 - Animation:0)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$0000,$0800,$0000,$0800,$3C00,$3C00,$2000,$1C00
	.dc.w	$7800,$7800,$5000,$2800,$F100,$A100,$A100,$5000
	.dc.w	$4000,$A100,$A100,$4000,$E000,$E000,$A000,$4100
	.dc.w	$7100,$7100,$5100,$2200,$2E00,$3200,$3200,$0C00
	.dc.w	$1400,$1400,$1400,$0000
shtimg51:		* Friendly Shot (Perspective:5 - Animation:1)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$0000,$1800,$1800,$0000,$1000,$3C00,$3000,$0C00
	.dc.w	$0000,$4300,$4100,$3A00,$0300,$C700,$8000,$6700
	.dc.w	$0200,$4700,$4500,$0200,$0000,$E000,$A000,$4000
	.dc.w	$2200,$5600,$5600,$2000,$1000,$2000,$2000,$1800
	.dc.w	$0000,$1400,$1400,$0000
shtimg52:		* Friendly Shot (Perspective:5 - Animation:2)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$0000,$0800,$0800,$0000,$0C00,$3200,$3200,$0C00
	.dc.w	$2200,$4D00,$4D00,$3200,$4500,$A200,$A200,$4500
	.dc.w	$4100,$A300,$A000,$4300,$0000,$A100,$A000,$4100
	.dc.w	$0200,$5200,$5200,$2000,$0800,$2C00,$2C00,$0000
	.dc.w	$0000,$1800,$1800,$0000
shtimg53:		* Friendly Shot (Perspective:5 - Animation:3)
	.dc.w	4,4
	.dc.w	8,1
	.dc.w	$0000,$1000,$1000,$0000,$0800,$2800,$2800,$1400
	.dc.w	$2400,$7500,$7500,$0200,$0000,$A280,$A280,$4100
	.dc.w	$4100,$4100,$4100,$0200,$0200,$A400,$A000,$4700
	.dc.w	$0600,$4000,$4000,$0600,$1000,$1000,$1000,$0000
shtimg54:		* Friendly Shot (Perspective:5 - Animation:4)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$2800,$3800,$3800,$0000,$4C00,$4C00,$4C00,$0000
	.dc.w	$8400,$8600,$8600,$0000,$0200,$8200,$8200,$0400
	.dc.w	$8A00,$8A00,$8A00,$1400,$0400,$5400,$4400,$3800
	.dc.w	$2800,$3800,$2800,$1000
shtimg55:		* Friendly Shot (Perspective:5 - Animation:5)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$3800,$3800,$3800,$0000,$0C00,$4C00,$4C00,$0000
	.dc.w	$8200,$C200,$C200,$0400,$0600,$8200,$8200,$0400
	.dc.w	$0C00,$2A00,$0A00,$2400,$0400,$6400,$0400,$7800
	.dc.w	$1800,$1800,$1800,$2000
shtimg56:		* Friendly Shot (Perspective:5 - Animation:6)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$1000,$1800,$1800,$0000,$4C00,$4C00,$0C00,$4000
	.dc.w	$0000,$C200,$0200,$E400,$A200,$E200,$A200,$4000
	.dc.w	$A600,$A200,$A200,$4400,$4C00,$6C00,$6C00,$1000
	.dc.w	$1000,$1800,$1800,$0000
shtimg57:		* Friendly Shot (Perspective:5 - Animation:7)
	.dc.w	4,3
	.dc.w	7,1
	.dc.w	$1000,$1400,$1400,$2000,$2A00,$2F00,$0F00,$7000
	.dc.w	$1200,$1300,$1300,$6000,$E100,$E100,$A100,$4000
	.dc.w	$4300,$2300,$2300,$4000,$7400,$5C00,$5C00,$2200
	.dc.w	$0C00,$0C00,$0C00,$1000
shtimg60:		* Friendly Shot (Perspective:6 - Animation:0)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$7000,$2000,$2000,$5000,$7800,$9000,$0000,$F800
	.dc.w	$9000,$0800,$0800,$9000,$0800,$C800,$4800,$8000
	.dc.w	$7000,$2000,$2000,$5000
shtimg61:		* Friendly Shot (Perspective:6 - Animation:1)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$7000,$2000,$2000,$5000,$9800,$5800,$5800,$8000
	.dc.w	$8800,$0800,$0000,$8800,$9800,$9000,$8000,$1800
	.dc.w	$5000,$6000,$6000,$1000
shtimg62:		* Friendly Shot (Perspective:6 - Animation:2)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$1000,$1000,$1000,$2000,$9800,$9800,$9800,$0000
	.dc.w	$0000,$8000,$8000,$0800,$2000,$B000,$A000,$5800
	.dc.w	$2000,$2000,$0000,$7000
shtimg63:		* Friendly Shot (Perspective:6 - Animation:3)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$4000,$4000,$4000,$0000,$8000,$C000,$8000,$6000
	.dc.w	$8000,$8800,$8800,$4000,$8800,$8800,$8800,$0000
	.dc.w	$6000,$7000,$7000,$0000
shtimg64:		* Friendly Shot (Perspective:6 - Animation:4)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$4000,$0000,$0000,$0000,$8000,$C000,$4000,$A000
	.dc.w	$4000,$0000,$0000,$4000
shtimg65:		* Friendly Shot (Perspective:6 - Animation:5)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$4000,$0000,$4000,$E000,$4000,$4000,$8000
	.dc.w	$0000,$0000,$0000,$4000
shtimg66:		* Friendly Shot (Perspective:6 - Animation:6)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$4000,$0000,$0000,$4000,$6000,$4000,$4000,$A000
	.dc.w	$4000,$0000,$0000,$0000
shtimg67:		* Friendly Shot (Perspective:6 - Animation:7)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$0000,$0000,$4000,$C000,$4000,$4000,$2000
	.dc.w	$4000,$0000,$0000,$4000
shtimg70:		* Friendly Shot (Perspective:7 - Animation:0)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$4000,$0000,$0000,$0000,$C000,$E000,$A000,$4000
	.dc.w	$4000,$4000,$4000,$0000
shtimg71:		* Friendly Shot (Perspective:7 - Animation:1)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$4000,$4000,$0000,$2000,$A000,$8000,$6000
	.dc.w	$0000,$4000,$4000,$0000
shtimg72:		* Friendly Shot (Perspective:7 - Animation:2)
	.dc.w	0,0
	.dc.w	1,1
	.dc.w	$8000,$0000,$0000,$8000
shtimg73:		* Friendly Shot (Perspective:7 - Animation:3)
	.dc.w	0,0
	.dc.w	1,1
	.dc.w	$0000,$0000,$0000,$8000
shtimg74:		* Friendly Shot (Perspective:7 - Animation:4)
	.dc.w	0,0
	.dc.w	1,1
	.dc.w	$8000,$8000,$8000,$0000
shtimg75:		* Friendly Shot (Perspective:7 - Animation:5)
	.dc.w	0,0
	.dc.w	1,1
	.dc.w	$0000,$8000,$8000,$0000
shtimg76:		* Friendly Shot (Perspective:7 - Animation:6)
	.dc.w	0,0
	.dc.w	1,1
	.dc.w	$0000,$8000,$8000,$0000
shtimg77:		* Friendly Shot (Perspective:7 - Animation:7)
	.dc.w	0,0
	.dc.w	1,1
	.dc.w	$0000,$8000,$8000,$0000


*
*	ENEMY MISSILE GRAPHICS (8 Perspectives - 8 Animations)
*
eshimg00:		* Enemy Shot (Perspective:0 - Animation:0)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$0000,$000F,$0008,$0000,$0000,$8000,$0000,$0000
	.dc.w	$000F,$00DF,$0050,$0000,$8000,$F000,$0000,$0000
	.dc.w	$00EF,$02FA,$0015,$0005,$8000,$8800,$0000,$0000
	.dc.w	$03EF,$07AF,$0040,$0040,$B800,$FC00,$0000,$0000
	.dc.w	$0FE0,$0EE0,$0100,$0100,$3800,$2A00,$1000,$1000
	.dc.w	$0F80,$1B80,$0400,$0400,$3F00,$3E00,$0100,$0100
	.dc.w	$1F00,$1E00,$0100,$0000,$0E00,$0A80,$0400,$0400
	.dc.w	$1E80,$5400,$0A80,$0800,$0F80,$0FC0,$0000,$0000
	.dc.w	$1C00,$1C00,$0000,$0000,$0380,$02C0,$0100,$0100
	.dc.w	$7000,$7000,$0000,$0000,$0380,$0380,$0000,$0000
	.dc.w	$7100,$D000,$2100,$2000,$0080,$0020,$0080,$0080
	.dc.w	$7000,$F000,$0000,$0000,$0000,$0020,$0080,$0000
	.dc.w	$7000,$D000,$2000,$2000,$0000,$0020,$0080,$0000
	.dc.w	$7000,$F000,$0000,$0000,$01C0,$01E0,$0000,$0000
	.dc.w	$7000,$F000,$0000,$0000,$01C0,$0160,$0080,$0080
	.dc.w	$7000,$D000,$2000,$2000,$01C0,$01E0,$0000,$0000
	.dc.w	$7800,$D800,$2000,$2000,$03C0,$0360,$0080,$0080
	.dc.w	$7800,$6800,$1000,$1000,$03C0,$02C0,$0100,$0100
	.dc.w	$3C00,$6C00,$1000,$1000,$0380,$0380,$0000,$0000
	.dc.w	$3C00,$7400,$0800,$0800,$0E00,$0E40,$0000,$0000
	.dc.w	$1F00,$3F00,$0000,$0000,$0E00,$0A00,$0400,$0400
	.dc.w	$0700,$0500,$0200,$0200,$3E00,$3E00,$0000,$0000
	.dc.w	$0700,$0F00,$0000,$0000,$7800,$6A00,$1000,$1000
	.dc.w	$007F,$007F,$0000,$0000,$F800,$D800,$2000,$2000
	.dc.w	$007F,$004A,$0035,$0035,$F000,$7800,$8000,$8000
	.dc.w	$007F,$01FF,$0000,$0000,$C000,$E000,$0000,$0000
	.dc.w	$0000,$002E,$0000,$0000,$0000,$0000,$0000,$0000
eshimg01:		* Enemy Shot (Perspective:0 - Animation:1)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$0000,$0000,$003B,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0011,$01C0,$00AA,$0000,$0000,$7000,$8000,$0000
	.dc.w	$0000,$0204,$00BB,$0000,$0000,$0000,$9C00,$0000
	.dc.w	$0000,$0040,$0440,$0000,$6800,$6000,$1400,$0000
	.dc.w	$0400,$0100,$0A40,$0000,$0000,$0200,$1C00,$0000
	.dc.w	$0000,$1000,$1400,$0000,$0000,$0800,$0F00,$0800
	.dc.w	$0000,$1000,$1100,$1000,$0200,$0000,$0500,$0000
	.dc.w	$0000,$4800,$2C00,$0000,$0000,$0000,$07C0,$0000
	.dc.w	$0000,$4000,$3800,$0000,$0080,$0000,$0140,$0000
	.dc.w	$1000,$0000,$6800,$0000,$0080,$0040,$0080,$0000
	.dc.w	$2000,$0000,$5800,$0000,$0000,$00A0,$0080,$0080
	.dc.w	$2000,$8000,$5000,$0000,$0000,$0020,$01C0,$0000
	.dc.w	$2800,$8800,$5000,$0000,$0080,$0020,$0140,$0000
	.dc.w	$2400,$8400,$5000,$0000,$0080,$0020,$0140,$0000
	.dc.w	$2800,$8800,$5000,$0000,$0080,$0020,$0140,$0000
	.dc.w	$2000,$0000,$5000,$0000,$0000,$0000,$01C0,$0000
	.dc.w	$2400,$8400,$5000,$0000,$0000,$0020,$0000,$0000
	.dc.w	$0100,$0100,$7800,$0000,$0000,$0040,$0380,$0000
	.dc.w	$1000,$4000,$2C00,$0000,$0100,$0040,$0680,$0000
	.dc.w	$0800,$4000,$3600,$0000,$0200,$0040,$0D80,$0000
	.dc.w	$0400,$2000,$1B00,$0000,$0400,$0000,$0B00,$0000
	.dc.w	$0200,$1000,$0D00,$0000,$0000,$0100,$0E00,$0000
	.dc.w	$0000,$0800,$07C0,$0000,$0000,$0200,$F000,$0000
	.dc.w	$0080,$0400,$017E,$0000,$6000,$0000,$9000,$0000
	.dc.w	$003C,$0200,$01C2,$0000,$0000,$0800,$F000,$0000
	.dc.w	$0000,$0180,$007E,$0000,$0000,$5000,$0000,$0000
	.dc.w	$0000,$001A,$0000,$0000,$0000,$8000,$0000,$0000
eshimg02:		* Enemy Shot (Perspective:0 - Animation:2)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$0000,$001F,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0180,$007F,$0000,$0000,$2000,$C000,$0000
	.dc.w	$002F,$0000,$01FF,$002F,$8000,$0800,$F000,$8000
	.dc.w	$00C0,$0400,$01FF,$00C0,$2000,$0400,$F000,$2000
	.dc.w	$0000,$0800,$07E0,$0000,$0000,$0000,$7E00,$0000
	.dc.w	$1200,$1000,$0F00,$0200,$0400,$0100,$0E00,$0400
	.dc.w	$0400,$2000,$1F00,$0400,$0400,$0080,$0E00,$0400
	.dc.w	$4800,$4000,$1E00,$0800,$0000,$0040,$0F80,$0000
	.dc.w	$0000,$0000,$1800,$0000,$0100,$0040,$0380,$0100
	.dc.w	$0000,$5000,$1000,$0000,$0100,$0000,$03C0,$0100
	.dc.w	$7000,$7000,$0000,$0000,$0080,$0000,$03C0,$0080
	.dc.w	$7000,$D000,$2000,$2000,$0080,$0020,$01C0,$0080
	.dc.w	$7C00,$FC00,$8000,$0000,$0000,$0020,$01C0,$0000
	.dc.w	$1C00,$3400,$0800,$0800,$0000,$0020,$01C0,$0000
	.dc.w	$1800,$B800,$0000,$0000,$0080,$0020,$01C0,$0080
	.dc.w	$0000,$8000,$0000,$0000,$0080,$0020,$01C0,$0080
	.dc.w	$0200,$8200,$B800,$0000,$0080,$0020,$03C0,$0080
	.dc.w	$1000,$4000,$3800,$1000,$0100,$0000,$03C0,$0100
	.dc.w	$1100,$4100,$3C00,$1000,$0000,$0040,$0780,$0000
	.dc.w	$0A20,$0220,$3C00,$0800,$0200,$0040,$0F00,$0200
	.dc.w	$0000,$2000,$1E00,$0000,$0400,$0080,$0F00,$0400
	.dc.w	$0488,$0088,$0E00,$0400,$0400,$0100,$0E00,$0400
	.dc.w	$0000,$0000,$0E00,$0000,$0000,$0000,$EE00,$0000
	.dc.w	$0200,$0600,$007F,$0000,$4000,$0400,$E000,$4000
	.dc.w	$002D,$0000,$007F,$002D,$0000,$0000,$E000,$0000
	.dc.w	$0000,$0180,$007F,$0000,$0000,$7000,$8000,$0000
	.dc.w	$0000,$003B,$0000,$0000,$0000,$8000,$0000,$0000
eshimg03:		* Enemy Shot (Perspective:0 - Animation:3)
	.dc.w	13,13
	.dc.w	27,2
	.dc.w	$0000,$001B,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$007F,$007F,$0000,$0000,$8000,$D000,$0000,$0000
	.dc.w	$00CA,$00FF,$0035,$0035,$F000,$F800,$0000,$0000
	.dc.w	$00BF,$04FF,$0040,$0040,$9000,$F400,$6000,$6000
	.dc.w	$0FE0,$0FE0,$0000,$0000,$FE00,$FE00,$0000,$0000
	.dc.w	$0900,$1F00,$0600,$0600,$1200,$1E00,$0C00,$0C00
	.dc.w	$1F00,$1F00,$0000,$0000,$1A00,$1E80,$0400,$0400
	.dc.w	$3400,$7C00,$0800,$0800,$0F80,$0FC0,$0000,$0000
	.dc.w	$2C00,$3C00,$1000,$1000,$0280,$03C0,$0100,$0100
	.dc.w	$3800,$7800,$0000,$0000,$02C0,$03C0,$0100,$0100
	.dc.w	$7000,$F000,$0000,$0000,$0340,$03C0,$0080,$0080
	.dc.w	$5200,$F200,$2000,$2000,$0140,$01E0,$0080,$0080
	.dc.w	$7000,$F000,$0000,$0000,$0140,$01E0,$0080,$0080
	.dc.w	$0400,$0400,$2000,$0000,$01C0,$01E0,$0000,$0000
	.dc.w	$0000,$7000,$8000,$0000,$0140,$01E0,$0080,$0080
	.dc.w	$0000,$7000,$A000,$2000,$01C0,$01E0,$0000,$0000
	.dc.w	$0100,$7900,$8000,$0000,$0340,$03E0,$0080,$0080
	.dc.w	$0000,$FC00,$1000,$1000,$02C0,$03C0,$0100,$0100
	.dc.w	$0000,$FC00,$4800,$4800,$4680,$47C0,$0100,$0100
	.dc.w	$0100,$FD00,$0000,$0000,$A580,$E7C0,$4200,$4200
	.dc.w	$0040,$0E40,$2000,$0000,$5F00,$5F80,$0000,$0000
	.dc.w	$0004,$0E04,$1400,$0400,$3200,$3E00,$0C00,$0C00
	.dc.w	$00EA,$0FEE,$0104,$0004,$EE00,$FE00,$1000,$1000
	.dc.w	$01B5,$05FF,$044A,$004A,$9800,$FC00,$6000,$6000
	.dc.w	$00A2,$02FF,$025D,$005D,$5000,$F800,$A000,$A000
	.dc.w	$00D0,$00FB,$002B,$002B,$F000,$F000,$0000,$0000
	.dc.w	$0071,$0071,$0000,$0000,$8000,$8000,$0000,$0000
eshimg04:		* Enemy Shot (Perspective:0 - Animation:4)
	.dc.w	14,14
	.dc.w	28,2
	.dc.w	$0000,$003F,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$001A,$01E5,$001A,$0000,$C000,$3800,$C000,$0000
	.dc.w	$00A0,$035F,$00A0,$0000,$3000,$CE00,$3000,$0000
	.dc.w	$0100,$06F0,$0100,$0000,$0400,$7A00,$0400,$0000
	.dc.w	$0200,$0D80,$0200,$0000,$0000,$0F80,$0000,$0000
	.dc.w	$0400,$0B00,$0400,$0000,$0100,$0280,$0100,$0000
	.dc.w	$0000,$3E00,$0000,$0000,$0000,$03E0,$0000,$0000
	.dc.w	$1000,$6800,$1000,$0000,$0040,$00B0,$0040,$0000
	.dc.w	$2000,$5800,$2000,$0000,$0020,$00D0,$0020,$0000
	.dc.w	$2000,$5000,$2000,$0000,$0020,$0050,$0020,$0000
	.dc.w	$2000,$D000,$2000,$0000,$0020,$0058,$0020,$0000
	.dc.w	$4000,$B000,$4000,$0000,$0010,$0068,$0010,$0000
	.dc.w	$4000,$A000,$4000,$0000,$0000,$0038,$0000,$0000
	.dc.w	$0000,$E000,$0000,$0000,$0010,$0028,$0010,$0000
	.dc.w	$4000,$A000,$4000,$0000,$0010,$0028,$0010,$0000
	.dc.w	$4000,$A000,$4000,$0000,$0000,$0038,$0000,$0000
	.dc.w	$4000,$A000,$4000,$0000,$0490,$0428,$0090,$0000
	.dc.w	$4000,$B000,$4000,$0000,$0010,$00E8,$0010,$0000
	.dc.w	$2000,$D000,$2000,$0000,$0040,$07B8,$0040,$0000
	.dc.w	$0000,$7000,$0000,$0000,$0200,$05E0,$0200,$0000
	.dc.w	$2000,$0000,$2000,$0000,$0040,$07A0,$0040,$0000
	.dc.w	$1000,$0E00,$1000,$0000,$0000,$00E0,$0100,$0000
	.dc.w	$0402,$0A02,$0400,$0000,$2000,$2700,$0080,$0000
	.dc.w	$0000,$0E00,$0000,$0000,$0200,$0500,$0200,$0000
	.dc.w	$0200,$0000,$0200,$0000,$0000,$2700,$0000,$0000
	.dc.w	$0000,$007C,$0000,$0000,$2000,$5000,$2000,$0000
	.dc.w	$00A8,$0054,$00A8,$0000,$0000,$2800,$0800,$0000
	.dc.w	$0002,$007D,$0003,$0000,$4000,$8000,$C000,$0000
eshimg05:		* Enemy Shot (Perspective:0 - Animation:5)
	.dc.w	14,14
	.dc.w	29,2
	.dc.w	$0000,$003E,$003E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01EA,$01FF,$0000,$0000,$0000,$C000,$0000
	.dc.w	$0000,$035E,$03FE,$0000,$0000,$1C00,$3C00,$0000
	.dc.w	$0000,$06F0,$07F0,$0000,$0000,$1400,$1C00,$0000
	.dc.w	$0000,$0580,$0780,$0000,$0000,$1C00,$1E00,$0000
	.dc.w	$0000,$1F00,$1F00,$0000,$0000,$0000,$0100,$0000
	.dc.w	$0000,$3400,$3C00,$0000,$0000,$0000,$0080,$0000
	.dc.w	$0000,$6C00,$7C00,$0000,$0000,$08E0,$00E0,$0000
	.dc.w	$0000,$5800,$7800,$0000,$0000,$01A0,$00E0,$0000
	.dc.w	$0000,$5000,$7000,$0000,$0000,$00E0,$00E0,$0000
	.dc.w	$0000,$D000,$F000,$0000,$0080,$01A0,$0020,$0000
	.dc.w	$0000,$B000,$F000,$0000,$0000,$0070,$0070,$0000
	.dc.w	$0000,$A000,$E000,$0000,$00A0,$00D0,$0070,$0000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$00F0,$00F0,$0000
	.dc.w	$0000,$A000,$E000,$0000,$0090,$01A0,$0130,$0000
	.dc.w	$0000,$A000,$E000,$0000,$0050,$00D0,$0080,$0000
	.dc.w	$0000,$A400,$E000,$0000,$0000,$00F0,$00F0,$0000
	.dc.w	$0000,$A000,$E000,$0000,$0000,$00A8,$00F8,$0000
	.dc.w	$0000,$F000,$F000,$0000,$0000,$00D0,$00F0,$0000
	.dc.w	$0000,$5200,$7000,$0000,$0000,$0060,$0060,$0000
	.dc.w	$0000,$5800,$7800,$0000,$0000,$01D0,$01F0,$0000
	.dc.w	$0000,$6C00,$7C00,$0000,$0000,$02E0,$03E0,$0000
	.dc.w	$0000,$3600,$3E00,$0000,$0000,$0F80,$0F80,$0000
	.dc.w	$0000,$1B08,$1F00,$0000,$0000,$1700,$1F00,$0000
	.dc.w	$0000,$0D80,$0F80,$0000,$0000,$1D00,$1F00,$0000
	.dc.w	$0000,$06F1,$07E1,$0000,$0000,$D700,$DF00,$0000
	.dc.w	$0000,$033D,$03FD,$0000,$2000,$7C00,$DC00,$0000
	.dc.w	$0002,$01E7,$01FD,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0000,$003C,$003C,$0000,$0000,$0000,$0000,$0000
eshimg06:		* Enemy Shot (Perspective:0 - Animation:6)
	.dc.w	14,14
	.dc.w	29,2
	.dc.w	$0000,$003F,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$0000,$01EA,$0000,$0000,$0000,$3000,$0000,$0000
	.dc.w	$0000,$035F,$0000,$0000,$0000,$DC00,$0000,$0000
	.dc.w	$0000,$06F0,$0000,$0000,$0000,$7700,$0000,$0000
	.dc.w	$0000,$0580,$0000,$0000,$0000,$1D80,$0000,$0000
	.dc.w	$0000,$1F00,$0000,$0000,$0000,$06C0,$0000,$0000
	.dc.w	$0000,$3400,$0000,$0000,$0000,$0340,$0000,$0000
	.dc.w	$0000,$6C00,$0000,$0000,$0800,$09E0,$0000,$0000
	.dc.w	$0000,$5800,$0000,$0000,$0100,$01A0,$0000,$0000
	.dc.w	$0000,$5000,$0000,$0000,$0000,$00E0,$0000,$0000
	.dc.w	$0000,$D000,$0000,$0000,$0100,$0120,$00A0,$0000
	.dc.w	$0000,$B000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0020,$0000,$00A0,$0000
	.dc.w	$0000,$E000,$0000,$0000,$0000,$0040,$0050,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0010,$0020,$00B0,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0000,$0000,$0050,$0000
	.dc.w	$0400,$A400,$0000,$0000,$0000,$00F8,$0000,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0000,$00A8,$0000,$0000
	.dc.w	$0000,$F000,$0000,$0000,$0000,$00D8,$0000,$0000
	.dc.w	$0200,$5200,$0000,$0000,$0000,$0070,$0000,$0000
	.dc.w	$0000,$5800,$0000,$0000,$0000,$03D0,$0000,$0000
	.dc.w	$0000,$6C00,$0000,$0000,$0000,$02F0,$0000,$0000
	.dc.w	$0000,$3600,$0000,$0000,$0000,$1F80,$0000,$0000
	.dc.w	$0008,$1B08,$0000,$0000,$0000,$1700,$0000,$0000
	.dc.w	$0000,$0D80,$0000,$0000,$0000,$1D00,$0000,$0000
	.dc.w	$0010,$06F1,$0000,$0000,$0000,$D700,$0000,$0000
	.dc.w	$0000,$033D,$0000,$0000,$0000,$5C00,$2000,$0000
	.dc.w	$0000,$01E5,$0002,$0000,$0000,$C000,$0000,$0000
	.dc.w	$0000,$003C,$0000,$0000,$0000,$0000,$0000,$0000
eshimg07:		* Enemy Shot (Perspective:0 - Animation:7)
	.dc.w	15,15
	.dc.w	31,2
	.dc.w	$0000,$003F,$003F,$0000,$0000,$7800,$7800,$0000
	.dc.w	$0000,$01E0,$01E0,$0000,$0000,$0C00,$0C00,$0000
	.dc.w	$0000,$030A,$0300,$0000,$0000,$E700,$0700,$0000
	.dc.w	$0000,$0650,$0600,$0000,$0000,$11C0,$01C0,$0000
	.dc.w	$0000,$0485,$0405,$0000,$0000,$4460,$4060,$0000
	.dc.w	$0000,$182C,$182C,$0000,$0000,$3130,$3030,$0000
	.dc.w	$0000,$3020,$3020,$0000,$0000,$0C90,$0C10,$0000
	.dc.w	$0000,$6540,$6140,$0000,$0000,$0248,$0208,$0000
	.dc.w	$0000,$4900,$4100,$0000,$0400,$0708,$0308,$0000
	.dc.w	$0000,$5300,$4300,$0000,$0000,$0128,$0108,$0000
	.dc.w	$0000,$D600,$C600,$0000,$0000,$0088,$0088,$0000
	.dc.w	$0000,$9400,$8400,$0000,$0000,$0068,$0068,$0000
	.dc.w	$0000,$2400,$0400,$0000,$0000,$0040,$0040,$0000
	.dc.w	$0000,$A800,$8800,$0000,$0000,$0044,$0040,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0044,$0040,$0000
	.dc.w	$0000,$A800,$8800,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$2000,$0000,$0000,$0000,$0074,$0000,$0000
	.dc.w	$0200,$AA00,$8800,$0000,$0000,$0082,$0082,$0000
	.dc.w	$0000,$2400,$0400,$0000,$0000,$00A2,$0082,$0000
	.dc.w	$0000,$8400,$8400,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0100,$5700,$4600,$0000,$0000,$02C6,$02C6,$0000
	.dc.w	$0000,$5300,$4300,$0000,$0000,$0204,$0204,$0000
	.dc.w	$0000,$4980,$4180,$0000,$0000,$1484,$1404,$0000
	.dc.w	$0000,$4440,$4040,$0000,$0000,$1038,$1038,$0000
	.dc.w	$0004,$3064,$3060,$0000,$0000,$0060,$0060,$0000
	.dc.w	$0000,$0929,$0829,$0000,$0000,$D140,$D040,$0000
	.dc.w	$0000,$0C8B,$0C0B,$0000,$0000,$0440,$0040,$0000
	.dc.w	$0000,$0240,$0200,$0000,$0000,$1180,$1180,$0000
	.dc.w	$0000,$0305,$0301,$0000,$0000,$0E00,$0E00,$0000
	.dc.w	$0000,$01A1,$01A1,$0000,$0000,$5000,$5000,$0000
	.dc.w	$0000,$0023,$0023,$0000,$0000,$0000,$0000,$0000
eshimg10:		* Enemy Shot (Perspective:1 - Animation:0)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$0000,$00DE,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$02FE,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0064,$049B,$0064,$0064,$0000,$4000,$0000,$0000
	.dc.w	$0002,$18FD,$0002,$0002,$0000,$3000,$0000,$0000
	.dc.w	$0150,$1D57,$0000,$0000,$0000,$9000,$0000,$0000
	.dc.w	$0828,$1428,$0800,$0800,$0000,$7800,$0000,$0000
	.dc.w	$0000,$7C00,$0000,$0000,$2000,$5400,$2000,$2000
	.dc.w	$1100,$2900,$1000,$1000,$0000,$7400,$0000,$0000
	.dc.w	$1000,$A800,$1000,$1000,$0000,$0200,$0000,$0000
	.dc.w	$0000,$7800,$0000,$0000,$0000,$0A00,$0000,$0000
	.dc.w	$2000,$D000,$2000,$2000,$0800,$0800,$0000,$0000
	.dc.w	$2000,$D000,$2000,$2000,$0000,$0200,$0000,$0000
	.dc.w	$0000,$F000,$0000,$0000,$0800,$0A00,$0000,$0000
	.dc.w	$2000,$D000,$2000,$2000,$0000,$1C00,$0000,$0000
	.dc.w	$0000,$7000,$0000,$0000,$0800,$1600,$0800,$0800
	.dc.w	$0000,$4000,$0000,$0000,$0000,$3C00,$0000,$0000
	.dc.w	$0000,$1C00,$0000,$0000,$1000,$2C00,$1000,$1000
	.dc.w	$0800,$1601,$0800,$0800,$0000,$F800,$0000,$0000
	.dc.w	$0400,$1BC1,$0400,$0400,$8000,$5000,$8000,$8000
	.dc.w	$0180,$1E7F,$0180,$0180,$0000,$D000,$0000,$0000
	.dc.w	$005C,$07A2,$005C,$005C,$0000,$4000,$0000,$0000
	.dc.w	$0000,$03FF,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0032,$0000,$0000,$0000,$0000,$0000,$0000
eshimg11:		* Enemy Shot (Perspective:1 - Animation:1)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$0000,$005A,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0300,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0004,$042C,$0008,$0008,$0000,$4000,$0000,$0000
	.dc.w	$0002,$1A83,$0201,$0201,$0000,$3000,$0000,$0000
	.dc.w	$0000,$1400,$0000,$0000,$0000,$5000,$4000,$4000
	.dc.w	$0000,$2800,$0000,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0000,$4A00,$0000,$0000,$0000,$0400,$0000,$0000
	.dc.w	$0000,$5000,$1000,$1000,$0000,$1400,$1000,$1000
	.dc.w	$0000,$9400,$1000,$1000,$0000,$0200,$0000,$0000
	.dc.w	$1000,$B000,$2000,$2000,$0000,$0A00,$0800,$0800
	.dc.w	$0000,$A800,$2000,$2000,$0000,$0A00,$0800,$0800
	.dc.w	$1000,$9400,$0000,$0000,$0000,$0200,$0800,$0000
	.dc.w	$0000,$A800,$2000,$2000,$0000,$0200,$0800,$0000
	.dc.w	$0000,$A000,$2000,$2000,$0000,$0A00,$0800,$0800
	.dc.w	$0000,$1400,$1000,$1000,$0000,$1200,$1000,$1000
	.dc.w	$0000,$4000,$0000,$0000,$0000,$1400,$1000,$1000
	.dc.w	$0000,$0800,$0800,$0800,$0000,$2400,$2000,$2000
	.dc.w	$0000,$2000,$0000,$0000,$0000,$2800,$2000,$2000
	.dc.w	$0000,$1600,$0600,$0600,$0000,$5000,$4000,$4000
	.dc.w	$0000,$1103,$0103,$0103,$0000,$3000,$0000,$0000
	.dc.w	$0000,$005C,$005C,$005C,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0301,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$00AE,$0000,$0000,$0000,$0000,$0000,$0000
eshimg12:		* Enemy Shot (Perspective:1 - Animation:2)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$0000,$00FE,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0100,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$007C,$0454,$0028,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0081,$0801,$0080,$0000,$0000,$3000,$0000,$0000
	.dc.w	$0600,$1200,$0400,$0000,$C000,$8000,$4000,$0000
	.dc.w	$0000,$2000,$0000,$0000,$2000,$0800,$2000,$0000
	.dc.w	$0800,$4000,$0800,$0000,$2000,$0000,$2000,$0000
	.dc.w	$1000,$0000,$1000,$0000,$0000,$0400,$0000,$0000
	.dc.w	$1000,$8000,$1000,$0000,$0000,$0200,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$0800,$0200,$0800,$0000
	.dc.w	$2000,$8000,$2000,$0000,$0800,$0200,$0800,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0800,$0000,$0800,$0000
	.dc.w	$2000,$0800,$2000,$0000,$0800,$0200,$0800,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0000,$0200,$0000,$0000
	.dc.w	$1000,$8200,$1000,$0000,$1000,$0200,$1000,$0000
	.dc.w	$1400,$4400,$1000,$0000,$1000,$0400,$1000,$0000
	.dc.w	$0A00,$42A0,$0800,$0000,$2000,$0400,$2000,$0000
	.dc.w	$0D00,$0500,$0800,$0000,$2000,$0800,$2000,$0000
	.dc.w	$0240,$1040,$0200,$0000,$C000,$1000,$C000,$0000
	.dc.w	$0180,$0810,$0180,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0064,$0400,$0064,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0301,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$00FC,$0000,$0000,$0000,$0000,$0000,$0000
eshimg13:		* Enemy Shot (Perspective:1 - Animation:3)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$0000,$00FE,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0301,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002C,$047C,$0050,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0181,$0183,$0002,$0000,$0000,$3000,$0000,$0000
	.dc.w	$0600,$1600,$0000,$0000,$4000,$C000,$8000,$0000
	.dc.w	$0000,$0400,$0400,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0800,$4800,$0000,$0000,$2000,$2400,$0000,$0000
	.dc.w	$0000,$5000,$0000,$0000,$0000,$1400,$0000,$0000
	.dc.w	$0000,$9000,$1000,$0000,$0000,$1200,$1000,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0000,$0200,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$0800,$0A00,$0000,$0000
	.dc.w	$0000,$A000,$2000,$0000,$0800,$0A00,$0000,$0000
	.dc.w	$0000,$2000,$0000,$0000,$0800,$0A00,$0000,$0000
	.dc.w	$0000,$A000,$0000,$0000,$0800,$0A00,$0000,$0000
	.dc.w	$1000,$9000,$0000,$0000,$1000,$9200,$0000,$0000
	.dc.w	$0000,$5000,$1000,$0000,$0000,$0400,$0000,$0000
	.dc.w	$0800,$4800,$0000,$0000,$0000,$2400,$0000,$0000
	.dc.w	$0000,$240A,$0400,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0210,$1250,$0000,$0000,$8000,$9000,$0000,$0000
	.dc.w	$00A2,$09A2,$0100,$0000,$0000,$3000,$0000,$0000
	.dc.w	$0001,$0411,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$002A,$032A,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0076,$0000,$0000,$0000,$0000,$0000,$0000
eshimg14:		* Enemy Shot (Perspective:1 - Animation:4)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$005A,$00DA,$0080,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0201,$0311,$0110,$0000,$8000,$8000,$0000,$0000
	.dc.w	$0000,$0040,$0040,$0000,$4000,$4000,$0000,$0000
	.dc.w	$1800,$1C82,$0482,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1000,$1000,$0000,$1000,$1000,$0000,$0000
	.dc.w	$2000,$2000,$0000,$0000,$0800,$0800,$0000,$0000
	.dc.w	$4000,$4000,$0000,$0000,$0000,$1800,$1000,$0000
	.dc.w	$4000,$4800,$0800,$0000,$0400,$0400,$0000,$0000
	.dc.w	$8000,$9000,$1000,$0000,$0200,$0200,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0200,$2A00,$2800,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0200,$0000,$0000
	.dc.w	$8000,$8000,$0000,$0000,$0A00,$0A00,$0000,$0000
	.dc.w	$8000,$A000,$2000,$0000,$0200,$0200,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$0000,$2000,$0000,$0000
	.dc.w	$8000,$8000,$0000,$0000,$0A00,$0A00,$0000,$0000
	.dc.w	$4000,$4800,$0800,$0000,$2400,$2400,$0000,$0000
	.dc.w	$0000,$0001,$0000,$0000,$4000,$4000,$0000,$0000
	.dc.w	$0000,$2400,$0400,$0000,$2800,$2800,$0000,$0000
	.dc.w	$0001,$0201,$0200,$0000,$5000,$5000,$0000,$0000
	.dc.w	$0800,$1800,$0000,$0000,$8000,$9000,$0000,$0000
	.dc.w	$0000,$0496,$0094,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0201,$0211,$0010,$0000,$0000,$8000,$0000,$0000
	.dc.w	$00C4,$00CE,$0000,$0000,$0000,$0000,$0000,$0000
eshimg15:		* Enemy Shot (Perspective:1 - Animation:5)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$0042,$0042,$0094,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0200,$0200,$0100,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0000,$0000,$0400,$0000,$0000,$0000,$4000,$0000
	.dc.w	$1000,$1000,$0800,$0000,$0000,$4000,$3000,$0000
	.dc.w	$0000,$0000,$1000,$0000,$0000,$A000,$5000,$0000
	.dc.w	$0000,$0000,$2000,$0000,$0800,$4800,$0000,$0000
	.dc.w	$4000,$4000,$0000,$0000,$0000,$0000,$2000,$0000
	.dc.w	$8000,$8000,$0000,$0000,$0000,$1400,$0800,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0800,$0200,$0000
	.dc.w	$4000,$4000,$0000,$0000,$0000,$0000,$0600,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0000,$0A00,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0000,$0A00,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0400,$0200,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0200,$0000,$0000
	.dc.w	$0000,$0000,$4000,$0000,$0000,$0000,$0400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0400,$0800,$0000
	.dc.w	$0000,$0000,$2000,$0000,$0000,$1000,$0000,$0000
	.dc.w	$0000,$0000,$1000,$0000,$0000,$0000,$1000,$0000
	.dc.w	$0000,$0000,$1000,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0400,$0400,$0000,$0000,$0000,$8000,$4000,$0000
	.dc.w	$0000,$0000,$0301,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0094,$0096,$0048,$0000,$0000,$0000,$0000,$0000
eshimg16:		* Enemy Shot (Perspective:1 - Animation:6)
	.dc.w	12,12
	.dc.w	25,2
	.dc.w	$0000,$00FF,$00FF,$0000,$0000,$8000,$8000,$0000
	.dc.w	$006F,$0390,$03FF,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0190,$026F,$03FF,$0000,$0000,$F000,$F000,$0000
	.dc.w	$0000,$1FFF,$1FFF,$0000,$A000,$5C00,$FC00,$0000
	.dc.w	$0904,$168B,$1F8F,$0000,$1800,$E400,$FC00,$0000
	.dc.w	$0800,$178F,$1F8F,$0000,$A800,$5400,$FC00,$0000
	.dc.w	$0000,$7C01,$7C01,$0000,$1000,$EF00,$FF00,$0000
	.dc.w	$2000,$5003,$7003,$0000,$0A00,$B500,$BF00,$0000
	.dc.w	$2001,$5002,$7003,$0000,$0200,$9D00,$9F00,$0000
	.dc.w	$0000,$F003,$F003,$0000,$0800,$9780,$9F80,$0000
	.dc.w	$4000,$A000,$E000,$0000,$0100,$1E80,$1F80,$0000
	.dc.w	$4000,$A000,$E000,$0000,$0000,$0380,$0380,$0000
	.dc.w	$4000,$A000,$E000,$0000,$0000,$0100,$0000,$0000
	.dc.w	$4000,$A000,$E000,$0000,$0000,$0380,$0380,$0000
	.dc.w	$0000,$E000,$E000,$0000,$0100,$0280,$0380,$0000
	.dc.w	$0000,$7000,$7000,$0000,$0000,$0380,$0380,$0000
	.dc.w	$2000,$5000,$7000,$0000,$0000,$0700,$0700,$0000
	.dc.w	$0000,$7800,$7800,$0000,$0200,$0500,$0700,$0000
	.dc.w	$1000,$2800,$3800,$0000,$0000,$0700,$0700,$0000
	.dc.w	$0000,$3800,$3800,$0000,$0000,$1C00,$1C00,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0800,$7400,$7C00,$0000
	.dc.w	$0200,$0580,$0780,$0000,$2000,$5C00,$7C00,$0000
	.dc.w	$0100,$06FE,$07FE,$0000,$0000,$7000,$7000,$0000
	.dc.w	$005C,$03A2,$03FF,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00FE,$00FE,$0000,$0000,$0000,$0000,$0000
eshimg17:		* Enemy Shot (Perspective:1 - Animation:7)
	.dc.w	12,12
	.dc.w	25,2
	.dc.w	$0000,$00FF,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$03FF,$0067,$0067,$0000,$C000,$0000,$0000
	.dc.w	$0000,$07FF,$010A,$010A,$0000,$C000,$8000,$8000
	.dc.w	$0000,$1FBF,$0214,$0214,$0000,$F800,$0000,$0000
	.dc.w	$0000,$1FFE,$0800,$0800,$0000,$3C00,$1000,$1000
	.dc.w	$0000,$3CE0,$0840,$0840,$0000,$FF00,$0800,$0800
	.dc.w	$0000,$7CE0,$1000,$1000,$0000,$FF00,$4200,$4200
	.dc.w	$0000,$7800,$2000,$2000,$0000,$E700,$0000,$0000
	.dc.w	$0000,$F000,$2000,$2000,$0000,$0380,$0000,$0000
	.dc.w	$0000,$F000,$4000,$4000,$0000,$0380,$0100,$0100
	.dc.w	$0000,$E000,$4000,$4000,$0000,$0380,$0000,$0000
	.dc.w	$0000,$E000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$E000,$0000,$0000,$0000,$0000,$0100,$0000
	.dc.w	$0000,$E000,$4000,$4000,$0100,$0000,$0100,$0000
	.dc.w	$0000,$E000,$4000,$4000,$0100,$0000,$0100,$0000
	.dc.w	$0000,$F000,$4000,$4000,$0100,$0000,$0100,$0000
	.dc.w	$0000,$F000,$2000,$2000,$0200,$0000,$0200,$0000
	.dc.w	$0000,$7800,$2000,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7800,$1000,$1000,$0000,$1C00,$0000,$0000
	.dc.w	$0000,$3E00,$0000,$0000,$0000,$3C00,$0800,$0800
	.dc.w	$0000,$1E00,$0C00,$0C00,$0000,$3C00,$1800,$1800
	.dc.w	$0000,$1F81,$0000,$0000,$0000,$FC00,$0000,$0000
	.dc.w	$0000,$03FF,$0100,$0100,$0000,$E000,$C000,$C000
	.dc.w	$0000,$03FF,$0073,$0073,$0000,$E000,$0000,$0000
	.dc.w	$0000,$00FF,$0000,$0000,$0000,$8000,$0000,$0000
eshimg20:		* Enemy Shot (Perspective:2 - Animation:0)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0000,$01D0,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07EC,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01C0,$0E3F,$01C0,$01C0,$0000,$0000,$0000,$0000
	.dc.w	$020C,$25F2,$020C,$020C,$0000,$0000,$0000,$0000
	.dc.w	$0000,$3F1F,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$1001,$6802,$1001,$1001,$0000,$C000,$0000,$0000
	.dc.w	$0000,$7803,$0000,$0000,$0000,$C000,$0000,$0000
	.dc.w	$0000,$F001,$0000,$0000,$8000,$6000,$8000,$8000
	.dc.w	$2000,$D001,$2000,$2000,$8000,$6000,$8000,$8000
	.dc.w	$0000,$7001,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$2000,$5001,$2000,$2000,$8000,$6000,$8000,$8000
	.dc.w	$0000,$F803,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$1001,$2802,$1001,$1001,$0000,$C000,$0000,$0000
	.dc.w	$0001,$7806,$0001,$0001,$0000,$C000,$0000,$0000
	.dc.w	$0002,$070D,$0002,$0002,$0000,$8000,$0000,$0000
	.dc.w	$0204,$05FB,$0204,$0204,$0000,$8000,$0000,$0000
	.dc.w	$01B0,$164F,$01B0,$01B0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07F8,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0150,$0000,$0000,$0000,$0000,$0000,$0000
eshimg21:		* Enemy Shot (Perspective:2 - Animation:1)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0000,$00F0,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0604,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1862,$0060,$0060,$0000,$0000,$0000,$0000
	.dc.w	$0000,$2604,$0604,$0604,$0000,$8000,$0000,$0000
	.dc.w	$0000,$2800,$0800,$0800,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0001,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1001,$1001,$1001,$0000,$4000,$0000,$0000
	.dc.w	$0000,$A000,$2000,$2000,$0000,$2000,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0000,$A000,$2000,$2000,$0000,$A000,$8000,$8000
	.dc.w	$0000,$2000,$2000,$2000,$0000,$2000,$0000,$0000
	.dc.w	$0000,$A000,$2000,$2000,$0000,$8000,$8000,$8000
	.dc.w	$0000,$1000,$1000,$1000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$5001,$1001,$1001,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$2604,$0604,$0604,$0000,$8000,$0000,$0000
	.dc.w	$0000,$1952,$0150,$0150,$0000,$0000,$0000,$0000
	.dc.w	$0000,$020C,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01B0,$0000,$0000,$0000,$0000,$0000,$0000
eshimg22:		* Enemy Shot (Perspective:2 - Animation:2)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0000,$0170,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$020C,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01D0,$1001,$01D0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$040C,$2000,$040C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0802,$0000,$0802,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1000,$0000,$1000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$4000,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$2000,$8000,$2000,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$8000,$2000,$8000,$0000
	.dc.w	$2000,$8000,$2000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$8000,$2000,$0000,$8000,$0000,$8000,$0000
	.dc.w	$2000,$8000,$2000,$0000,$8000,$2000,$8000,$0000
	.dc.w	$1000,$4000,$1000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$1001,$4000,$1001,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0002,$2000,$0002,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0404,$2000,$0404,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0060,$0803,$0060,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$020C,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01F0,$0000,$0000,$0000,$0000,$0000,$0000
eshimg23:		* Enemy Shot (Perspective:2 - Animation:3)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0000,$0190,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$040C,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01E0,$09E3,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0604,$2604,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0002,$2002,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$1000,$5000,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$2000,$A000,$0000,$0000,$8000,$A000,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$8000,$8000,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$8000,$A000,$0000,$0000
	.dc.w	$2000,$2000,$0000,$0000,$8000,$A000,$0000,$0000
	.dc.w	$2000,$2000,$0000,$0000,$8000,$A000,$0000,$0000
	.dc.w	$1001,$1001,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0001,$4001,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$2000,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0404,$2404,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0190,$0191,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0408,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01D0,$0000,$0000,$0000,$0000,$0000,$0000
eshimg24:		* Enemy Shot (Perspective:2 - Animation:4)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0090,$0090,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$040C,$040C,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0129,$0128,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$2400,$0400,$0000,$8000,$8000,$0000,$0000
	.dc.w	$2000,$2802,$0802,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4000,$4000,$0000,$0000
	.dc.w	$4000,$5000,$1000,$0000,$4000,$C000,$8000,$0000
	.dc.w	$8000,$A000,$0000,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$A000,$8000,$0000
	.dc.w	$8000,$8000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$2000,$2000,$0000,$2000,$A000,$8000,$0000
	.dc.w	$8000,$8000,$0000,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1001,$1001,$0000,$4000,$4000,$0000,$0000
	.dc.w	$0000,$0002,$0000,$0000,$8000,$8000,$0000,$0000
	.dc.w	$2000,$2480,$0480,$0000,$8000,$8000,$0000,$0000
	.dc.w	$1802,$1822,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0604,$0604,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0160,$0160,$0000,$0000,$0000,$0000,$0000,$0000
eshimg25:		* Enemy Shot (Perspective:2 - Animation:5)
	.dc.w	9,9
	.dc.w	19,2
	.dc.w	$0000,$0000,$01B0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0200,$0200,$040C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0803,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1000,$1000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$2000,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0000,$0000,$4000,$0000,$0000,$0000,$4000,$0000
	.dc.w	$2000,$2000,$4000,$0000,$4000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0000,$2000,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0000,$2000,$0000
	.dc.w	$4000,$4000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$8000,$0000,$4000,$4000,$2000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$2000,$0000
	.dc.w	$1000,$1000,$4000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$4000,$0000
	.dc.w	$0000,$0000,$2000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0400,$2000,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0012,$0012,$1001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$040C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0160,$0000,$0000,$0000,$0000,$0000
eshimg26:		* Enemy Shot (Perspective:2 - Animation:6)
	.dc.w	10,10
	.dc.w	21,2
	.dc.w	$0000,$01FC,$01FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00A8,$0754,$07FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0300,$1CFF,$1FFF,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0801,$3782,$3F83,$0000,$8000,$6000,$E000,$0000
	.dc.w	$1000,$2C03,$3C03,$0000,$4000,$A000,$E000,$0000
	.dc.w	$1000,$2800,$3800,$0000,$4000,$B000,$F000,$0000
	.dc.w	$0000,$7800,$7800,$0000,$2000,$D000,$F000,$0000
	.dc.w	$2000,$D000,$F000,$0000,$2000,$5800,$7800,$0000
	.dc.w	$4000,$B000,$F000,$0000,$1000,$6800,$7800,$0000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$3800,$3800,$0000
	.dc.w	$4000,$A000,$E000,$0000,$1000,$2800,$3800,$0000
	.dc.w	$0000,$E000,$E000,$0000,$1000,$2800,$3800,$0000
	.dc.w	$4000,$B000,$F000,$0000,$0000,$3800,$3800,$0000
	.dc.w	$2000,$D000,$F000,$0000,$0000,$7000,$7000,$0000
	.dc.w	$2000,$5800,$7800,$0000,$2000,$5000,$7000,$0000
	.dc.w	$1000,$6800,$7800,$0000,$0000,$7000,$7000,$0000
	.dc.w	$0000,$3E01,$3E01,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0400,$0B07,$0F07,$0000,$8000,$4000,$C000,$0000
	.dc.w	$0202,$0D7D,$0F7F,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0030,$074F,$077F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0078,$0078,$0000,$0000,$0000,$0000,$0000
eshimg27:		* Enemy Shot (Perspective:2 - Animation:7)
	.dc.w	10,10
	.dc.w	21,2
	.dc.w	$0000,$01FC,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03FF,$00B8,$00B8,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFF,$0106,$0106,$0000,$C000,$0000,$0000
	.dc.w	$0000,$1F8F,$0C01,$0C01,$0000,$C000,$8000,$8000
	.dc.w	$0000,$3E03,$0000,$0000,$0000,$C000,$0000,$0000
	.dc.w	$0000,$7800,$1000,$1000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7800,$2000,$2000,$0000,$7000,$0000,$0000
	.dc.w	$0000,$7000,$2000,$2000,$0000,$7800,$2000,$2000
	.dc.w	$0000,$F000,$0000,$0000,$0000,$7800,$1000,$1000
	.dc.w	$0000,$E000,$4000,$4000,$0000,$3800,$1000,$1000
	.dc.w	$0000,$E000,$0000,$0000,$0000,$3800,$1000,$1000
	.dc.w	$0000,$E000,$4000,$4000,$0000,$3800,$1000,$1000
	.dc.w	$0000,$F000,$4000,$4000,$0000,$3800,$1000,$1000
	.dc.w	$0000,$F000,$2000,$2000,$0000,$3800,$0000,$0000
	.dc.w	$0000,$7800,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$0000,$3800,$1000,$1000,$0000,$E000,$4000,$4000
	.dc.w	$0000,$3E00,$0000,$0000,$0000,$E000,$4000,$4000
	.dc.w	$0000,$1F07,$0C00,$0C00,$0000,$E000,$0000,$0000
	.dc.w	$0000,$1FFF,$0202,$0202,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07FF,$00B0,$00B0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01F8,$0000,$0000,$0000,$0000,$0000,$0000
eshimg30:		* Enemy Shot (Perspective:3 - Animation:0)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0000,$05C0,$0000,$0000,$0000,$1FD0,$0000,$0000
	.dc.w	$0680,$2978,$0680,$0680,$0020,$4FDC,$0020,$0020
	.dc.w	$0010,$7068,$0010,$0010,$2000,$D03E,$2000,$2000
	.dc.w	$2008,$D016,$2008,$2008,$2008,$5016,$2008,$2008
	.dc.w	$0008,$F014,$0008,$0008,$2008,$D036,$2008,$2008
	.dc.w	$0010,$7C6C,$0010,$0010,$0820,$57D8,$0820,$0820
	.dc.w	$0780,$3870,$0780,$0780,$0000,$1FF0,$0000,$0000
	.dc.w	$0000,$03C0,$0000,$0000
eshimg31:		* Enemy Shot (Perspective:3 - Animation:1)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0000,$07C0,$0000,$0000,$0000,$1830,$0000,$0000
	.dc.w	$0000,$2388,$0380,$0380,$0000,$4804,$0800,$0800
	.dc.w	$0000,$4014,$0010,$0010,$0000,$8002,$0000,$0000
	.dc.w	$0000,$A00A,$2008,$2008,$0000,$200A,$2008,$2008
	.dc.w	$0000,$A002,$2000,$2000,$0000,$A00A,$2008,$2008
	.dc.w	$0000,$1014,$1010,$1010,$0000,$4804,$0800,$0800
	.dc.w	$0000,$26C0,$06C0,$06C0,$0000,$1820,$0000,$0000
	.dc.w	$0000,$01C0,$0000,$0000
eshimg32:		* Enemy Shot (Perspective:3 - Animation:2)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0000,$0780,$0000,$0000,$0000,$1830,$0000,$0000
	.dc.w	$03C0,$2008,$03C0,$0000,$0800,$4004,$0800,$0000
	.dc.w	$1010,$4004,$1010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2008,$8002,$2008,$0000,$0000,$0002,$0000,$0000
	.dc.w	$2000,$8002,$2000,$0000,$0008,$0002,$0008,$0000
	.dc.w	$1010,$0004,$1010,$0000,$0000,$4004,$0000,$0000
	.dc.w	$00C0,$2008,$00C0,$0000,$0000,$1800,$0000,$0000
	.dc.w	$0000,$04C0,$0000,$0000
eshimg33:		* Enemy Shot (Perspective:3 - Animation:3)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0000,$0700,$0000,$0000,$0000,$1030,$0000,$0000
	.dc.w	$0380,$2388,$0000,$0000,$0800,$4804,$0000,$0000
	.dc.w	$1000,$1004,$0000,$0000,$0000,$0002,$0000,$0000
	.dc.w	$2008,$A00A,$0000,$0000,$2008,$A008,$0000,$0000
	.dc.w	$2000,$A002,$0000,$0000,$0008,$800A,$0000,$0000
	.dc.w	$1010,$5014,$0000,$0000,$0820,$4824,$0000,$0000
	.dc.w	$0340,$2348,$0000,$0000,$0000,$1030,$0000,$0000
	.dc.w	$0000,$0380,$0000,$0000
eshimg34:		* Enemy Shot (Perspective:3 - Animation:4)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0640,$0640,$0000,$0000,$1030,$1030,$0000,$0000
	.dc.w	$2008,$2008,$0000,$0000,$4000,$4000,$0000,$0000
	.dc.w	$0004,$0004,$0000,$0000,$8002,$8002,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$8000,$8000,$0000,$0000
	.dc.w	$8002,$8002,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$4000,$0000,$0000,$4004,$4004,$0000,$0000
	.dc.w	$0008,$0008,$0000,$0000,$1810,$1810,$0000,$0000
	.dc.w	$03C0,$03C0,$0000,$0000
eshimg35:		* Enemy Shot (Perspective:3 - Animation:5)
	.dc.w	7,7
	.dc.w	15,1
	.dc.w	$0000,$0000,$06C0,$0000,$0000,$0000,$0820,$0000
	.dc.w	$0000,$0000,$2008,$0000,$0000,$0000,$4004,$0000
	.dc.w	$0000,$0000,$0004,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$8002,$0000,$0000,$0000,$8002,$0000
	.dc.w	$0000,$0000,$0002,$0000,$0000,$0000,$0002,$0000
	.dc.w	$0000,$0000,$4004,$0000,$0000,$0000,$0004,$0000
	.dc.w	$0000,$0000,$0008,$0000,$0000,$0000,$0810,$0000
	.dc.w	$0000,$0000,$06C0,$0000
eshimg36:		* Enemy Shot (Perspective:3 - Animation:6)
	.dc.w	8,8
	.dc.w	17,2
	.dc.w	$0000,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$03A0,$1C5C,$1FFC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0C18,$13E6,$1FFE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$7E3B,$7E3F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2002,$500D,$700F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2002,$D005,$F007,$0000,$0000,$8000,$8000,$0000
	.dc.w	$4001,$B006,$F007,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$E002,$E003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$4001,$A002,$E003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$E002,$E003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$4000,$A007,$E007,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0002,$F005,$F007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2002,$580D,$780F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1004,$6C3B,$7C3F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0818,$37E6,$3FFE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$02A0,$1D5C,$1FFC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07F0,$07F0,$0000,$0000,$0000,$0000,$0000
eshimg37:		* Enemy Shot (Perspective:3 - Animation:7)
	.dc.w	8,8
	.dc.w	17,2
	.dc.w	$0000,$07F0,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFC,$03E0,$03E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFE,$0C08,$0C08,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7E1E,$0004,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$700F,$2000,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$F007,$0002,$0002,$0000,$8000,$0000,$0000
	.dc.w	$0000,$E007,$4001,$4001,$0000,$8000,$0000,$0000
	.dc.w	$0000,$E003,$4001,$4001,$0000,$8000,$0000,$0000
	.dc.w	$0000,$E003,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$E003,$4001,$4001,$0000,$8000,$0000,$0000
	.dc.w	$0000,$F003,$4001,$4001,$0000,$8000,$0000,$0000
	.dc.w	$0000,$F007,$2000,$2000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$700F,$2002,$2002,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7E1F,$0004,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFE,$0C08,$0C08,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFC,$01E0,$01E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03F0,$0000,$0000,$0000,$0000,$0000,$0000
eshimg40:		* Enemy Shot (Perspective:4 - Animation:0)
	.dc.w	4,5
	.dc.w	11,1
	.dc.w	$0000,$1E00,$1200,$0000,$0A00,$4A00,$0000,$0000
	.dc.w	$3300,$BF80,$8C00,$0C00,$C100,$EB00,$2200,$2200
	.dc.w	$0100,$5540,$5400,$4000,$A280,$E3C0,$4100,$4100
	.dc.w	$0100,$D500,$D400,$4000,$9500,$B740,$2200,$2200
	.dc.w	$1100,$DD80,$4C80,$0C00,$1A00,$5A00,$4000,$0000
	.dc.w	$0000,$1600,$1200,$0000
eshimg41:		* Enemy Shot (Perspective:4 - Animation:1)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$0000,$1500,$0000,$0000,$0000,$2480,$0000,$0000
	.dc.w	$0800,$4240,$0C00,$0000,$0100,$8420,$1100,$0000
	.dc.w	$2080,$0000,$2080,$0000,$2000,$80A0,$2000,$0000
	.dc.w	$0000,$8160,$2080,$0000,$0100,$8880,$0100,$0000
	.dc.w	$0A00,$5440,$0A00,$0000,$0000,$0880,$0000,$0000
	.dc.w	$0000,$1D00,$0000,$0000
eshimg42:		* Enemy Shot (Perspective:4 - Animation:2)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$0000,$1E00,$0000,$0000,$0000,$2080,$0000,$0000
	.dc.w	$0E00,$0E40,$0000,$0000,$1000,$9000,$0000,$0000
	.dc.w	$0080,$80A0,$0000,$0000,$2000,$2020,$0000,$0000
	.dc.w	$0080,$80A0,$0000,$0000,$1100,$1120,$0000,$0000
	.dc.w	$0600,$4600,$0000,$0000,$0000,$2080,$0000,$0000
	.dc.w	$0000,$0700,$0000,$0000
eshimg43:		* Enemy Shot (Perspective:4 - Animation:3)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$0000,$1600,$0000,$0000,$0000,$2080,$0000,$0000
	.dc.w	$0C00,$4E00,$0000,$0000,$1100,$9120,$0000,$0000
	.dc.w	$2000,$A0A0,$0000,$0000,$2080,$A0A0,$0000,$0000
	.dc.w	$0080,$A0A0,$0000,$0000,$0000,$9120,$0000,$0000
	.dc.w	$0A00,$4E40,$0000,$0000,$0000,$0080,$0000,$0000
	.dc.w	$0000,$1D00,$0000,$0000
eshimg44:		* Enemy Shot (Perspective:4 - Animation:4)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$1B00,$1B00,$0000,$0000,$0080,$2080,$0000,$0000
	.dc.w	$4040,$4040,$0000,$0000,$8020,$8020,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0020,$8020,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$8020,$8020,$0000,$0000
	.dc.w	$0040,$4040,$0000,$0000,$2000,$2080,$0000,$0000
	.dc.w	$1200,$1E00,$0000,$0000
eshimg45:		* Enemy Shot (Perspective:4 - Animation:5)
	.dc.w	5,5
	.dc.w	11,1
	.dc.w	$0000,$0A00,$1500,$0000,$0000,$0000,$0080,$0000
	.dc.w	$0000,$0000,$4040,$0000,$0000,$0000,$8020,$0000
	.dc.w	$0000,$8020,$0000,$0000,$0000,$0000,$8020,$0000
	.dc.w	$0000,$8000,$0020,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0000,$0000,$4040,$0000,$0000,$0080,$0000,$0000
	.dc.w	$0000,$0300,$1C00,$0000
eshimg46:		* Enemy Shot (Perspective:4 - Animation:6)
	.dc.w	6,6
	.dc.w	13,1
	.dc.w	$0000,$1FC0,$1FC0,$0000,$0A80,$3560,$3FE0,$0000
	.dc.w	$1040,$6FB0,$7FF0,$0000,$2020,$D8D8,$F8F8,$0000
	.dc.w	$4010,$B068,$F078,$0000,$0000,$E038,$E038,$0000
	.dc.w	$0000,$E038,$E038,$0000,$4010,$A028,$E038,$0000
	.dc.w	$4000,$B078,$F078,$0000,$2020,$D0D0,$F0F0,$0000
	.dc.w	$0040,$7FB0,$7FF0,$0000,$0A80,$1560,$1FE0,$0000
	.dc.w	$0000,$1FC0,$1FC0,$0000
eshimg47:		* Enemy Shot (Perspective:4 - Animation:7)
	.dc.w	6,6
	.dc.w	13,1
	.dc.w	$0000,$1FC0,$0000,$0000,$0000,$1FE0,$0C80,$0C80
	.dc.w	$0000,$7FF0,$0040,$0040,$0000,$F0F8,$2020,$2020
	.dc.w	$0000,$F078,$4010,$4010,$0000,$E038,$0000,$0000
	.dc.w	$0000,$E038,$4010,$4010,$0000,$E038,$0010,$0010
	.dc.w	$0000,$E078,$4000,$4000,$0000,$F8F0,$0020,$0020
	.dc.w	$0000,$3FF0,$1040,$1040,$0000,$3FE0,$0F00,$0F00
	.dc.w	$0000,$1F80,$0000,$0000
eshimg50:		* Enemy Shot (Perspective:5 - Animation:0)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$0000,$3800,$0000,$0000,$2800,$7C00,$1000,$1000
	.dc.w	$0000,$C600,$C600,$4400,$0000,$8400,$4400,$0400
	.dc.w	$0000,$8600,$4400,$0400,$0000,$7C00,$3C00,$2800
	.dc.w	$0000,$3800,$2000,$0000
eshimg51:		* Enemy Shot (Perspective:5 - Animation:1)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$0000,$1000,$0000,$0000,$3000,$4400,$3000,$0000
	.dc.w	$4400,$8000,$4400,$0000,$0400,$8200,$0400,$0000
	.dc.w	$4000,$8200,$4000,$0000,$1800,$4000,$1800,$0000
	.dc.w	$0000,$1000,$0000,$0000
eshimg52:		* Enemy Shot (Perspective:5 - Animation:2)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$0000,$3800,$0000,$0000,$0000,$4400,$1800,$0000
	.dc.w	$0000,$8200,$4400,$0000,$0000,$8200,$4400,$0000
	.dc.w	$0000,$8000,$0400,$0000,$0000,$4400,$2800,$0000
	.dc.w	$0000,$3800,$0000,$0000
eshimg53:		* Enemy Shot (Perspective:5 - Animation:3)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$0000,$2000,$0000,$0000,$3800,$7800,$0000,$0000
	.dc.w	$4400,$C400,$0000,$0000,$4400,$4600,$0000,$0000
	.dc.w	$4400,$C600,$0000,$0000,$3800,$3C00,$0000,$0000
	.dc.w	$0000,$2800,$0000,$0000
eshimg54:		* Enemy Shot (Perspective:5 - Animation:4)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$2800,$2800,$0000,$0000,$0000,$0400,$0000,$0000
	.dc.w	$8200,$8200,$0000,$0000,$0000,$8200,$0000,$0000
	.dc.w	$8200,$8200,$0000,$0000,$0400,$4400,$0000,$0000
	.dc.w	$3000,$3000,$0000,$0000
eshimg55:		* Enemy Shot (Perspective:5 - Animation:5)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$0000,$0000,$1800,$0000,$0000,$0000,$4400,$0000
	.dc.w	$0000,$0000,$8200,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0000,$0000,$8000,$0000,$0000,$0000,$4400,$0000
	.dc.w	$0000,$0000,$3000,$0000
eshimg56:		* Enemy Shot (Perspective:5 - Animation:6)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$0000,$3E00,$3E00,$0000,$1C00,$2300,$3F00,$0000
	.dc.w	$0200,$FD80,$FF80,$0000,$4100,$A680,$E780,$0000
	.dc.w	$0000,$E380,$E380,$0000,$4100,$B680,$F780,$0000
	.dc.w	$2200,$DD80,$FF80,$0000,$1800,$6700,$7F00,$0000
	.dc.w	$0000,$3C00,$3C00,$0000
eshimg57:		* Enemy Shot (Perspective:5 - Animation:7)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$0000,$3E00,$1200,$0000,$0000,$3F00,$1C00,$1C00
	.dc.w	$0000,$FF80,$0A80,$0200,$0000,$E780,$4500,$4100
	.dc.w	$0000,$E380,$2000,$0000,$0000,$F780,$5100,$4100
	.dc.w	$0000,$FF80,$AA80,$2200,$0000,$7F00,$1800,$1800
	.dc.w	$0000,$3C00,$2000,$0000
eshimg60:		* Enemy Shot (Perspective:6 - Animation:0)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$0000,$5000,$0000,$0000,$0000,$2800,$2000,$2000
	.dc.w	$0000,$D000,$5000,$5000,$0000,$A800,$2000,$2000
	.dc.w	$0000,$6000,$0000,$0000
eshimg61:		* Enemy Shot (Perspective:6 - Animation:1)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$0000,$3000,$0000,$0000,$2000,$8000,$2000,$0000
	.dc.w	$5000,$8800,$5000,$0000,$2000,$8800,$2000,$0000
	.dc.w	$0000,$6000,$0000,$0000
eshimg62:		* Enemy Shot (Perspective:6 - Animation:2)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$0000,$7000,$0000,$0000,$0000,$8800,$2000,$0000
	.dc.w	$0000,$8800,$1000,$0000,$0000,$8800,$2000,$0000
	.dc.w	$0000,$6000,$0000,$0000
eshimg63:		* Enemy Shot (Perspective:6 - Animation:3)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$0000,$6000,$0000,$0000,$2000,$A800,$0000,$0000
	.dc.w	$1000,$9800,$0000,$0000,$2000,$A800,$0000,$0000
	.dc.w	$0000,$7000,$0000,$0000
eshimg64:		* Enemy Shot (Perspective:6 - Animation:4)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$6000,$7000,$0000,$0000,$0800,$8800,$0000,$0000
	.dc.w	$8800,$8800,$0000,$0000,$8800,$8800,$0000,$0000
	.dc.w	$7000,$7000,$0000,$0000
eshimg65:		* Enemy Shot (Perspective:6 - Animation:5)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$2000,$2000,$5000,$0000,$0800,$0800,$8000,$0000
	.dc.w	$0000,$0000,$8800,$0000,$0000,$0000,$8800,$0000
	.dc.w	$1000,$1000,$6000,$0000
eshimg66:		* Enemy Shot (Perspective:6 - Animation:6)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$1000,$4000,$7000,$0000,$8800,$0000,$8800,$0000
	.dc.w	$0800,$0000,$8800,$0000,$8800,$0000,$8800,$0000
	.dc.w	$4000,$2000,$7000,$0000
eshimg67:		* Enemy Shot (Perspective:6 - Animation:7)
	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$1000,$7000,$6000,$6000,$8000,$8800,$0800,$0800
	.dc.w	$0000,$8800,$8800,$8800,$8000,$8800,$0800,$0800
	.dc.w	$0000,$7000,$7000,$7000
eshimg70:		* Enemy Shot (Perspective:7 - Animation:0)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$4000,$0000,$0000,$4000,$E000,$0000,$0000
	.dc.w	$0000,$4000,$0000,$0000
eshimg71:		* Enemy Shot (Perspective:7 - Animation:1)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$4000,$0000,$0000,$0000,$A000,$4000,$0000
	.dc.w	$0000,$4000,$0000,$0000
eshimg72:		* Enemy Shot (Perspective:7 - Animation:2)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$4000,$0000,$0000,$4000,$A000,$4000,$0000
	.dc.w	$0000,$4000,$0000,$0000
eshimg73:		* Enemy Shot (Perspective:7 - Animation:3)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$4000,$0000,$0000,$0000,$E000,$4000,$4000
	.dc.w	$0000,$4000,$0000,$0000
eshimg74:		* Enemy Shot (Perspective:7 - Animation:4)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$4000,$4000,$0000,$0000,$A000,$A000,$0000,$0000
	.dc.w	$4000,$4000,$0000,$0000
eshimg75:		* Enemy Shot (Perspective:7 - Animation:5)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$0000,$4000,$0000,$0000,$0000,$A000,$0000
	.dc.w	$0000,$0000,$4000,$0000
eshimg76:		* Enemy Shot (Perspective:7 - Animation:6)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$4000,$0000,$4000,$0000,$A000,$0000,$A000,$0000
	.dc.w	$4000,$0000,$4000,$0000
eshimg77:		* Enemy Shot (Perspective:7 - Animation:7)
	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$4000,$4000,$4000,$0000,$A000,$A000,$A000
	.dc.w	$0000,$4000,$4000,$4000

	.end
