*
*	SHIPDATA.S	ST Star-Raiders SHIP Image Data
*

*
*	PUBLIC SYMBOLS
*
	.globl	shipf
	.globl	shipe
	.globl	shipd
	.globl	shipc
	.globl	shipb
	.globl	shipa
	.globl	ship9
	.globl	ship8
	.globl	ship7
	.globl	ship6
	.globl	ship5
	.globl	ship4
	.globl	ship3
	.globl	ship2
	.globl	ship1
	.globl	ship0
	.globl	ashipf
	.globl	ashipe
	.globl	ashipd
	.globl	ashipc
	.globl	ashipb
	.globl	ashipa
	.globl	aship9
	.globl	aship8
	.globl	aship7
	.globl	aship6
	.globl	aship5
	.globl	aship4
	.globl	aship3
	.globl	aship2
	.globl	aship1
	.globl	aship0
	.globl	bshipf
	.globl	bshipe
	.globl	bshipd
	.globl	bshipc
	.globl	bshipb
	.globl	bshipa
	.globl	bship9
	.globl	bship8
	.globl	bship7
	.globl	bship6
	.globl	bship5
	.globl	bship4
	.globl	bship3
	.globl	bship2
	.globl	bship1
	.globl	bship0
	.globl	cshipf
	.globl	cshipe
	.globl	cshipd
	.globl	cshipc
	.globl	cshipb
	.globl	cshipa
	.globl	cship9
	.globl	cship8
	.globl	cship7
	.globl	cship6
	.globl	cship5
	.globl	cship4
	.globl	cship3
	.globl	cship2
	.globl	cship1
	.globl	cship0
	.globl	dshipf
	.globl	dshipe
	.globl	dshipd
	.globl	dshipc
	.globl	dshipb
	.globl	dshipa
	.globl	dship9
	.globl	dship8
	.globl	dship7
	.globl	dship6
	.globl	dship5
	.globl	dship4
	.globl	dship3
	.globl	dship2
	.globl	dship1
	.globl	dship0
	.globl	eshipf
	.globl	eshipe
	.globl	eshipd
	.globl	eshipc
	.globl	eshipb
	.globl	eshipa
	.globl	eship9
	.globl	eship8
	.globl	eship7
	.globl	eship6
	.globl	eship5
	.globl	eship4
	.globl	eship3
	.globl	eship2
	.globl	eship1
	.globl	eship0
	.globl	fshipf
	.globl	fshipe
	.globl	fshipd
	.globl	fshipc
	.globl	fshipb
	.globl	fshipa
	.globl	fship9
	.globl	fship8
	.globl	fship7
	.globl	fship6
	.globl	fship5
	.globl	fship4
	.globl	fship3
	.globl	fship2
	.globl	fship1
	.globl	fship0
	.globl	ushipf
	.globl	ushipe
	.globl	ushipd
	.globl	ushipc
	.globl	ushipb
	.globl	ushipa
	.globl	uship9
	.globl	uship8
	.globl	uship7
	.globl	uship6
	.globl	uship5
	.globl	uship4
	.globl	uship3
	.globl	uship2
	.globl	uship1
	.globl	uship0


*
*	SHIP Image data
*		Xoffset,Yoffset (pixels)
*		Height (lines), Width (words)
*		Image_Data
*
*	By Ship Type, Each SHIP Having SIXTEEN Perspective Depths
*

	.data
	.even

*
*	CILLER (WC Fields)
*
ship0:	.dc.w	2,1
	.dc.w	3,1
	.dc.w	$1000,$7000,$0000,$0000,$2000,$F800,$0000,$0000
	.dc.w	$0000,$7000,$0000,$0000
ship1:	.dc.w	2,1
	.dc.w	4,1
	.dc.w	$2000,$6000,$1000,$0000,$7000,$F800,$0000,$0000
	.dc.w	$2000,$F800,$8800,$0000,$0000,$2000,$0000,$0000
ship2:	.dc.w	3,2
	.dc.w	5,1
	.dc.w	$0000,$3800,$1000,$0000,$3000,$7400,$0800,$0000
	.dc.w	$2800,$EE00,$1000,$0000,$1000,$7C00,$2800,$0000
	.dc.w	$1000,$1000,$0000,$0000
ship3:	.dc.w	5,2
	.dc.w	6,1
	.dc.w	$0A00,$1F00,$0400,$0000,$0C00,$3D80,$1300,$0000
	.dc.w	$0D80,$FDE0,$0200,$0000,$0400,$3F80,$0000,$0000
	.dc.w	$0000,$1500,$0000,$0000,$0400,$0400,$0000,$0000
ship4:	.dc.w	6,3
	.dc.w	8,1
	.dc.w	$0880,$0D80,$0000,$0000,$0200,$1FC0,$0880,$0000
	.dc.w	$0500,$3CE0,$1340,$0000,$9448,$FCF8,$0300,$0000
	.dc.w	$0200,$3FE0,$0880,$0000,$0000,$1FC0,$0880,$0000
	.dc.w	$0000,$0200,$0000,$0000,$0200,$0200,$0000,$0000
ship5:	.dc.w	8,3
	.dc.w	9,2
	.dc.w	$0420,$0760,$0010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A08,$0BE8,$0020,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0160,$1734,$00C0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0D28,$FF3F,$00C0,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0C98,$3FBE,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0808,$1FFC,$0020,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0DD8,$0808,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0080,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0080,$0000,$0000,$0000,$0000,$0000,$0000
ship6:	.dc.w	10,4
	.dc.w	10,2
	.dc.w	$0104,$01DC,$0202,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0401,$0777,$018C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$08C8,$09CC,$0030,$0000,$8000,$8000,$0000,$0000
	.dc.w	$0290,$1787,$0479,$0000,$0000,$4000,$0000,$0000
	.dc.w	$84C9,$FDCD,$0232,$0000,$8800,$F800,$0000,$0000
	.dc.w	$1870,$1BFE,$0401,$0000,$C000,$C000,$0000,$0000
	.dc.w	$0451,$0FDF,$0326,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0050,$0376,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0020,$0020,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0020,$0000,$0000,$0000,$0000,$0000
ship7:	.dc.w	11,4
	.dc.w	10,2
	.dc.w	$0181,$00EC,$0103,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0200,$01BB,$02C6,$0000,$8000,$0000,$8000,$0000
	.dc.w	$0064,$0064,$049A,$0000,$0000,$0000,$4000,$0000
	.dc.w	$0940,$09DB,$003C,$0018,$2000,$2000,$0000,$0000
	.dc.w	$8648,$FEC2,$013D,$0000,$C200,$FE00,$0000,$0000
	.dc.w	$1C20,$3DE7,$0218,$0000,$7000,$7800,$8000,$0000
	.dc.w	$0228,$1FEF,$0193,$0000,$8000,$F000,$0000,$0000
	.dc.w	$0028,$03BB,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0010,$0010,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0010,$0000,$0000,$0000,$0000,$0000
ship8:	.dc.w	12,5
	.dc.w	12,2
	.dc.w	$00C3,$0196,$0161,$0100,$0000,$4000,$C000,$4000
	.dc.w	$0200,$00DD,$02E3,$0000,$2000,$8000,$A000,$0000
	.dc.w	$013E,$017F,$0400,$0000,$4000,$4000,$1000,$0000
	.dc.w	$08A4,$08E1,$001E,$0000,$0800,$0800,$8000,$0000
	.dc.w	$046B,$15E5,$001E,$0004,$1000,$D400,$0000,$0000
	.dc.w	$196D,$78E1,$871E,$0000,$4C00,$8F00,$7080,$0000
	.dc.w	$03B2,$33F3,$2C0C,$0000,$E000,$E600,$1A00,$0000
	.dc.w	$065D,$0FFF,$0180,$0000,$1000,$D800,$E000,$0000
	.dc.w	$000A,$03CA,$0014,$0000,$0000,$E000,$0000,$0000
	.dc.w	$0008,$0008,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0008,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$0000,$0008,$0000,$0000,$0000,$0000,$0000
ship9:	.dc.w	13,5
	.dc.w	13,2
	.dc.w	$0071,$00DB,$00A0,$0080,$5000,$6000,$B000,$3000
	.dc.w	$0008,$01EA,$0171,$0100,$8000,$6800,$D800,$0800
	.dc.w	$000E,$005F,$0220,$0000,$0000,$C000,$2400,$0000
	.dc.w	$0510,$0532,$004F,$0002,$8A00,$8A00,$4000,$0000
	.dc.w	$0822,$0865,$009F,$0005,$3000,$7100,$8000,$0000
	.dc.w	$3CA5,$7C62,$839F,$0002,$3380,$43E0,$BC10,$0000
	.dc.w	$0882,$3BA0,$045F,$0000,$B200,$BB80,$4400,$0000
	.dc.w	$0939,$1879,$0786,$0000,$9300,$C300,$3C00,$0000
	.dc.w	$010C,$07E8,$00D7,$0000,$1000,$7C00,$6000,$0000
	.dc.w	$0000,$038E,$0000,$0000,$0000,$3800,$0000,$0000
	.dc.w	$0000,$0002,$0004,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0004,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0004,$0004,$0004,$0000,$0000,$0000,$0000
shipa:	.dc.w	15,6
	.dc.w	15,2
	.dc.w	$000C,$006E,$0070,$0060,$2C00,$6000,$1C00,$0400
	.dc.w	$0084,$0036,$00F8,$0000,$1600,$C800,$3E00,$0200
	.dc.w	$0048,$0173,$013C,$0100,$2000,$D900,$3D00,$0100
	.dc.w	$011E,$012E,$0211,$0000,$2100,$3100,$C880,$0000
	.dc.w	$04AD,$049C,$0023,$0000,$2A40,$FA40,$C000,$C000
	.dc.w	$0028,$0819,$0067,$0001,$5480,$9EA0,$E000,$C000
	.dc.w	$9E49,$7E38,$81E7,$0000,$1679,$D87E,$E781,$C000
	.dc.w	$066E,$11EE,$0E11,$0000,$2650,$3798,$C860,$0000
	.dc.w	$03B3,$107F,$0F80,$0000,$C9D0,$EE18,$11E0,$0000
	.dc.w	$0305,$0F7C,$00E3,$0000,$01C0,$3DE0,$CE00,$0000
	.dc.w	$0003,$01E2,$0001,$0000,$4000,$4700,$8000,$0000
	.dc.w	$0000,$0001,$0002,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0001,$0000,$0000,$0000,$0000
shipb:	.dc.w	17,7
	.dc.w	16,3
	.dc.w	$0012,$0023,$003C,$0020,$0980,$3A00,$0780,$0380
	.dc.w	$0000,$0000,$0000,$0000,$0003,$007D,$005E,$0040
	.dc.w	$2940,$A600,$1F40,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0082,$003D,$009A,$0000,$0900,$E720,$1E20,$0020
	.dc.w	$0000,$0000,$0000,$0000,$0103,$0013,$018C,$0000
	.dc.w	$1810,$1A10,$E440,$0000,$0000,$0000,$0000,$0000
	.dc.w	$005A,$0056,$0209,$0000,$4888,$2C88,$F200,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0436,$062E,$0011,$0000
	.dc.w	$A700,$5594,$FA00,$7000,$0000,$0000,$0000,$0000
	.dc.w	$0036,$09EE,$0011,$0000,$8580,$74E2,$FB00,$7000
	.dc.w	$0000,$0000,$0000,$0000,$8F26,$7F1E,$80F1,$0000
	.dc.w	$549E,$261F,$FBE0,$2000,$4000,$8000,$4000,$0000
	.dc.w	$0B33,$08F7,$0708,$0000,$1B9C,$1FE6,$E018,$0000
	.dc.w	$0000,$0000,$0000,$0000,$09D9,$083B,$07C4,$0000
	.dc.w	$E274,$FB86,$0478,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0180,$079E,$0071,$0000,$5070,$1F78,$E180,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0061,$01FD,$0018,$0000
	.dc.w	$2080,$37F0,$C300,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$C000,$A000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$8000,$4000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$0000,$4000,$0000,$0000,$0000,$0000,$0000
shipc:	.dc.w	18,7
	.dc.w	18,3
	.dc.w	$0002,$0010,$001F,$0010,$8560,$DC00,$03E0,$0060
	.dc.w	$0000,$0000,$0000,$0000,$0003,$003E,$002D,$0020
	.dc.w	$4A50,$59A0,$87D0,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0001,$004E,$0047,$0040,$0200,$79C8,$8788,$0008
	.dc.w	$0000,$0000,$0000,$0000,$0087,$000D,$00C2,$0000
	.dc.w	$C704,$C680,$390C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0129,$002F,$0104,$0004,$A212,$9B90,$7C82,$1880
	.dc.w	$0000,$0000,$0000,$0000,$000B,$0017,$0288,$0000
	.dc.w	$1980,$2522,$F6C1,$3400,$0000,$0000,$0000,$0000
	.dc.w	$004B,$0047,$0418,$0000,$0904,$3524,$FEC0,$3C00
	.dc.w	$0000,$0000,$8000,$0000,$8F13,$7F0F,$80F8,$0000
	.dc.w	$2563,$1983,$FEFC,$1800,$C800,$F000,$0800,$0000
	.dc.w	$00E5,$1FE3,$1C1C,$0000,$9A1C,$831F,$7CE1,$0000
	.dc.w	$0000,$E000,$E000,$0000,$0719,$0CFB,$0304,$0000
	.dc.w	$C6E2,$C7FC,$3803,$0000,$8000,$C000,$0000,$0000
	.dc.w	$05EC,$0C1D,$03E2,$0000,$789C,$FEE0,$011F,$0000
	.dc.w	$8000,$C000,$0000,$0000,$01C0,$03CF,$0038,$0000
	.dc.w	$A40C,$87CF,$7870,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0030,$01FE,$000C,$0000,$4830,$CDFC,$30C0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0078,$0000,$0000
	.dc.w	$4800,$78F8,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$2000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$2000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$2000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$0000,$2000,$0000,$0000,$0000,$0000,$0000
shipd:	.dc.w	19,8
	.dc.w	20,3
	.dc.w	$0005,$0009,$000E,$0008,$80E0,$C600,$01C0,$0040
	.dc.w	$0000,$0000,$0000,$0000,$0002,$001C,$001F,$0018
	.dc.w	$8310,$EEE0,$01F0,$0030,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0026,$002F,$0020,$4428,$6DC0,$83E8,$0008
	.dc.w	$0000,$0000,$0000,$0000,$0005,$0044,$0043,$0040
	.dc.w	$7C40,$FFC4,$0184,$0104,$0000,$0000,$0000,$0000
	.dc.w	$0081,$0003,$00A2,$0002,$C202,$C3C0,$3C8A,$0080
	.dc.w	$0000,$0000,$0000,$0000,$0011,$0017,$0104,$0004
	.dc.w	$9090,$8D50,$7EC1,$0C40,$0000,$0000,$0000,$0000
	.dc.w	$0005,$0013,$028C,$0000,$2D40,$1390,$FA62,$1A00
	.dc.w	$0000,$0000,$8000,$0000,$0459,$0453,$000C,$0000
	.dc.w	$2504,$1B94,$FE60,$1E00,$4000,$4000,$0000,$0000
	.dc.w	$8F19,$7F07,$80FC,$0000,$3331,$0DC1,$FE7E,$0C00
	.dc.w	$E200,$FC00,$0200,$0000,$00E1,$1FE3,$1C1C,$0000
	.dc.w	$9C8E,$810F,$7EF0,$0000,$0000,$F000,$7000,$0000
	.dc.w	$0B1D,$08FF,$0700,$0000,$C271,$C37E,$3C81,$0000
	.dc.w	$C000,$6000,$8000,$0000,$01E4,$081D,$07E2,$0000
	.dc.w	$7CCF,$FEF0,$010F,$0000,$4000,$6000,$8000,$0000
	.dc.w	$0233,$060F,$01F8,$0000,$0118,$7DE0,$823F,$0000
	.dc.w	$8000,$C000,$0000,$0000,$0030,$01FE,$000C,$0000
	.dc.w	$5498,$C7FF,$3860,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$007C,$0000,$0000,$5400,$447C,$3800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$3800,$6C00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$2800,$1000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$1000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$1000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1000,$1000,$1000,$0000,$0000,$0000,$0000
shipe:	.dc.w	20,9
	.dc.w	22,3
	.dc.w	$000C,$0000,$000F,$0008,$C0B8,$E380,$0070,$0010
	.dc.w	$0000,$0000,$0000,$0000,$0001,$001E,$001F,$0018
	.dc.w	$414C,$7730,$80FC,$000C,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0027,$002F,$0020,$A28A,$3670,$C1FA,$0002
	.dc.w	$0000,$0000,$0000,$0000,$0008,$004F,$0047,$0040
	.dc.w	$BE88,$3E71,$C1F9,$0001,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0087,$0083,$0081,$C190,$C1F0,$3E60,$0040
	.dc.w	$0000,$8000,$8000,$8000,$0101,$0007,$0142,$0002
	.dc.w	$1E40,$0070,$FFA1,$0020,$4000,$0000,$4000,$0000
	.dc.w	$0223,$0025,$0206,$0004,$3762,$0852,$FFB0,$0E10
	.dc.w	$2000,$0000,$2000,$0000,$0006,$0012,$050D,$0000
	.dc.w	$6FB0,$1024,$F9D8,$1900,$0000,$0000,$5000,$0000
	.dc.w	$089E,$0892,$000D,$0000,$67A8,$1820,$FDDC,$1D00
	.dc.w	$8800,$8800,$0000,$0000,$8F1A,$7F06,$80FD,$0000
	.dc.w	$62AC,$1D30,$FFDF,$1F00,$7880,$7F00,$8080,$0000
	.dc.w	$00E3,$1FE1,$1C1E,$0000,$3163,$0E43,$FFBC,$0E00
	.dc.w	$8000,$FC00,$1C00,$0000,$0B1D,$08FD,$0702,$0000
	.dc.w	$1E5C,$005F,$FFA0,$0000,$7000,$9800,$6000,$0000
	.dc.w	$09E6,$081E,$07E1,$0000,$C1B3,$C1BC,$3E43,$0000
	.dc.w	$D000,$1000,$E000,$0000,$0631,$0607,$01F8,$0000
	.dc.w	$BEC6,$BEF0,$410F,$0000,$2000,$2000,$C000,$0000
	.dc.w	$01C0,$03CF,$003E,$0000,$4901,$C1F9,$3E3E,$0000
	.dc.w	$C000,$C000,$0000,$0000,$0032,$00FF,$000C,$0000
	.dc.w	$2A26,$637F,$1C18,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$003C,$0000,$0000,$2A00,$221E,$1C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1C00,$3600,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1400,$0800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0800,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0800,$0800,$0800,$0000,$0000,$0000,$0000
shipf:	.dc.w	21,10
	.dc.w	24,3
	.dc.w	$0006,$0000,$0007,$0004,$605C,$71C0,$8038,$0008
	.dc.w	$0000,$0000,$0000,$0000,$0000,$000F,$000F,$000C
	.dc.w	$A0A6,$3B98,$C07E,$0006,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0013,$0017,$0010,$5145,$9B38,$E0FD,$0001
	.dc.w	$0000,$0000,$0000,$0000,$0004,$0027,$0023,$0020
	.dc.w	$5F44,$9F38,$E0FC,$0000,$0000,$8000,$8000,$8000
	.dc.w	$0002,$0043,$0041,$0040,$60C8,$E0F8,$9F30,$8020
	.dc.w	$0000,$4000,$4000,$4000,$0080,$0003,$00A1,$0001
	.dc.w	$8F20,$8038,$7FD0,$0010,$2000,$0000,$A000,$0000
	.dc.w	$0111,$0014,$0103,$0000,$9BB9,$842D,$7FD0,$0700
	.dc.w	$1000,$0000,$1000,$0000,$0007,$000D,$0282,$0000
	.dc.w	$37D4,$0816,$FCE8,$0C80,$0000,$0000,$2800,$0000
	.dc.w	$004B,$0059,$0406,$0000,$33DA,$0C13,$FEEC,$0E80
	.dc.w	$4000,$4000,$0400,$0000,$080F,$0839,$0006,$0000
	.dc.w	$3155,$0E91,$FFEE,$0F80,$0200,$8200,$0000,$0000
	.dc.w	$8F8D,$7F83,$807E,$0000,$3056,$0F98,$FFEF,$0F80
	.dc.w	$3E20,$3FC0,$C020,$0000,$0071,$1FF0,$1E0F,$0000
	.dc.w	$98B1,$8721,$7FDE,$0700,$C000,$FF00,$0700,$0000
	.dc.w	$051E,$0CFE,$0301,$0000,$8F2F,$802F,$7FD0,$0000
	.dc.w	$1400,$E600,$1800,$0000,$04C7,$0C3F,$03C0,$0000
	.dc.w	$60DC,$60DF,$9F20,$0000,$E400,$0600,$F800,$0000
	.dc.w	$0319,$0707,$00F8,$0000,$DF73,$DF7C,$2083,$0000
	.dc.w	$1800,$1C00,$E000,$0000,$00E0,$03E7,$001F,$0000
	.dc.w	$2480,$E0FC,$1F1F,$0000,$E000,$F800,$0000,$0000
	.dc.w	$0019,$00FF,$0006,$0000,$1513,$B1BF,$0E0C,$0000
	.dc.w	$0000,$E000,$0000,$0000,$0000,$003E,$0000,$0000
	.dc.w	$1300,$150F,$0E00,$0400,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0100,$0E00,$1B00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0A00,$0400,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0400,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0000,$0400,$0400,$0000,$0000,$0000,$0000

*
*	CILLERTWO (the BUTTERFLY)
*
aship0:	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$E000,$0000,$0000,$0000,$A000,$4000,$0000
	.dc.w	$0000,$E000,$0000,$0000
aship1:	.dc.w	2,2
	.dc.w	4,1
	.dc.w	$0000,$7000,$2000,$0000,$5000,$F800,$0000,$0000
	.dc.w	$5000,$D800,$2000,$0000,$5000,$7000,$0000,$0000
aship2:	.dc.w	3,2
	.dc.w	4,1
	.dc.w	$5400,$7C00,$0000,$0000,$4400,$D600,$2800,$0000
	.dc.w	$5400,$C600,$3800,$0000,$4400,$6C00,$1000,$0000
aship3:	.dc.w	4,3
	.dc.w	5,1
	.dc.w	$4900,$7F00,$1400,$0000,$5500,$DD80,$2200,$0000
	.dc.w	$5D00,$DD80,$2200,$0000,$5D00,$D580,$2A00,$0000
	.dc.w	$4100,$7700,$0800,$0000
aship4:	.dc.w	4,4
	.dc.w	7,1
	.dc.w	$0800,$6B00,$0000,$0000,$1400,$9C80,$6300,$0000
	.dc.w	$3600,$9C80,$6300,$0000,$BE80,$9C80,$6300,$0000
	.dc.w	$BE80,$9480,$6B00,$0000,$1C00,$9C80,$6300,$0000
	.dc.w	$2A00,$7F00,$1400,$0000
aship5:	.dc.w	5,4
	.dc.w	8,1
	.dc.w	$0400,$3580,$0000,$0000,$4040,$4E40,$3180,$0000
	.dc.w	$6AC0,$DF60,$3180,$1100,$5540,$C460,$3B80,$0000
	.dc.w	$60C0,$D560,$3F80,$1500,$5540,$C460,$3B80,$0000
	.dc.w	$4040,$4E40,$3180,$0000,$0400,$3580,$0000,$0000
aship6:	.dc.w	6,5
	.dc.w	10,1
	.dc.w	$0200,$3260,$0000,$0000,$28A0,$6AB0,$1040,$0000
	.dc.w	$6DB0,$D758,$38E0,$1040,$4F90,$D758,$38E0,$1040
	.dc.w	$3DE0,$8508,$7AF0,$1040,$4D90,$D758,$3AE0,$1240
	.dc.w	$2DA0,$9548,$7AF0,$1040,$5250,$4710,$38E0,$0000
	.dc.w	$0000,$3260,$0000,$0000,$0200,$0200,$0000,$0000
aship7:	.dc.w	8,6
	.dc.w	12,2
	.dc.w	$0000,$0000,$0080,$0000,$0000,$0000,$0000,$0000
	.dc.w	$388E,$3C9E,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5415,$46B1,$380E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2A2A,$93E4,$7C1F,$1004,$0000,$8000,$0000,$0000
	.dc.w	$36B6,$8BE8,$7C1F,$180C,$0000,$8000,$0000,$0000
	.dc.w	$5635,$CB69,$3C9E,$0808,$0000,$8000,$0000,$0000
	.dc.w	$3636,$8BE8,$7C9F,$188C,$0000,$8000,$0000,$0000
	.dc.w	$5635,$CB69,$3C9E,$0808,$0000,$8000,$0000,$0000
	.dc.w	$588D,$C3E1,$3C1E,$0000,$0000,$8000,$0000,$0000
	.dc.w	$380E,$7DDF,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0080,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0080,$0000,$0000,$0000,$0000,$0000
aship8:	.dc.w	8,7
	.dc.w	14,2
	.dc.w	$0000,$0000,$0080,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3086,$788F,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1414,$8490,$780F,$0000,$0000,$8000,$0000,$0000
	.dc.w	$A002,$93E4,$7C1F,$1004,$8000,$8000,$0000,$0000
	.dc.w	$D88D,$A3E2,$7C1F,$3006,$8000,$8000,$0000,$0000
	.dc.w	$594D,$C361,$3C9E,$0000,$0000,$8000,$0000,$0000
	.dc.w	$D80D,$A222,$7DDF,$3006,$8000,$8000,$0000,$0000
	.dc.w	$59CD,$C221,$3DDE,$0080,$0000,$8000,$0000,$0000
	.dc.w	$D80D,$A222,$7DDF,$3006,$8000,$8000,$0000,$0000
	.dc.w	$A1C2,$93E4,$7C1F,$1004,$8000,$8000,$0000,$0000
	.dc.w	$280A,$6DDB,$1004,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0080,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0080,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0000,$0080,$0000,$0000,$0000,$0000,$0000
aship9:	.dc.w	9,8
	.dc.w	16,2
	.dc.w	$0040,$0000,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$3843,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$2802,$6C46,$1001,$0000,$8000,$C000,$0000,$0000
	.dc.w	$5405,$C64C,$3803,$0000,$4000,$6000,$8000,$0000
	.dc.w	$AE0E,$93F9,$7C07,$1001,$A000,$2000,$C000,$0000
	.dc.w	$B6ED,$8BFA,$7C07,$1803,$A000,$2000,$C000,$0000
	.dc.w	$560D,$CB1A,$3CE7,$0802,$4000,$6000,$8000,$0000
	.dc.w	$B60D,$8B1A,$7CE7,$1803,$A000,$2000,$C000,$0000
	.dc.w	$56ED,$CB1A,$3CE7,$08E2,$4000,$6000,$8000,$0000
	.dc.w	$B60D,$8B1A,$7CE7,$1803,$A000,$2000,$C000,$0000
	.dc.w	$2E0E,$971D,$78E3,$1001,$8000,$2000,$C000,$0000
	.dc.w	$10E1,$45F4,$3803,$0000,$0000,$4000,$8000,$0000
	.dc.w	$0000,$0040,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0040,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$0040,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0040,$0000,$0000,$0000,$0000,$0000
ashipa:	.dc.w	11,10
	.dc.w	19,2
	.dc.w	$0010,$0000,$0010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$1C10,$0000,$0000,$0000,$7000,$0000,$0000
	.dc.w	$2200,$6311,$1C00,$0000,$8800,$8C00,$7000,$0000
	.dc.w	$5501,$C9BB,$3E00,$0800,$5400,$2600,$F800,$2000
	.dc.w	$5101,$CDBB,$3E00,$0C00,$1400,$6600,$F800,$6000
	.dc.w	$297D,$E5BB,$1E44,$0C00,$2800,$4E00,$F000,$6000
	.dc.w	$5945,$C583,$3E7C,$0C00,$3400,$4600,$F800,$6000
	.dc.w	$2901,$E583,$1E7C,$0400,$2800,$4E00,$F000,$4000
	.dc.w	$5945,$C5C7,$3E38,$0C00,$3400,$4600,$F800,$6000
	.dc.w	$297D,$E5C7,$1E38,$0438,$2800,$4E00,$F000,$4000
	.dc.w	$5945,$C5C7,$3E38,$0C00,$3400,$4600,$F800,$6000
	.dc.w	$5145,$CDC7,$3E38,$0C00,$1400,$6600,$F800,$6000
	.dc.w	$2A38,$637D,$1C00,$0000,$A800,$8C00,$7000,$0000
	.dc.w	$0800,$1C7C,$0000,$0000,$2000,$7000,$0000,$0000
	.dc.w	$0000,$0010,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0010,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0010,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0010,$0000,$0000,$0000,$0000,$0000
ashipb:	.dc.w	13,11
	.dc.w	21,2
	.dc.w	$0004,$0000,$0004,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0004,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0004,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1800,$3C04,$0000,$0000,$0180,$03C0,$0000,$0000
	.dc.w	$2A00,$6304,$1C00,$0000,$0540,$0C60,$0380,$0000
	.dc.w	$5500,$C96F,$3E00,$0800,$0AA0,$6930,$07C0,$0100
	.dc.w	$4A1F,$D48F,$3F70,$1C00,$8520,$12B0,$EEC0,$0280
	.dc.w	$2A3F,$E48F,$1F70,$0400,$C540,$1270,$EF80,$0200
	.dc.w	$4A50,$D4A0,$3F7F,$1C20,$A520,$52B0,$EFC0,$4380
	.dc.w	$2A00,$E4E0,$1F7F,$0460,$0540,$7270,$EF80,$6200
	.dc.w	$4A1F,$D490,$3F6F,$1C0F,$8520,$92B0,$6FC0,$0380
	.dc.w	$2A39,$E49F,$1F66,$0400,$C540,$9270,$6F80,$0200
	.dc.w	$4A1F,$D4F0,$3F6F,$1C6F,$8520,$F2B0,$6FC0,$6380
	.dc.w	$4040,$DCB0,$3F6F,$1C20,$2020,$D3B0,$6FC0,$4380
	.dc.w	$202F,$611F,$1E60,$0000,$4040,$8860,$6780,$0000
	.dc.w	$1860,$3EFF,$0000,$0000,$6380,$F7C0,$0000,$0000
	.dc.w	$0000,$006F,$0000,$0000,$0000,$6000,$0000,$0000
	.dc.w	$0000,$0004,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0004,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0004,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0004,$0000,$0000,$0000,$0000,$0000
ashipc:	.dc.w	14,11
	.dc.w	22,2
	.dc.w	$0000,$0000,$0002,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0002,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$3E02,$0000,$0000,$0000,$03E0,$0000,$0000
	.dc.w	$2200,$6302,$1C00,$0000,$0220,$0630,$01C0,$0000
	.dc.w	$1D00,$81BF,$7E00,$0000,$05C0,$EC08,$03F0,$0000
	.dc.w	$B530,$89FF,$7E00,$0800,$6568,$FC88,$03F0,$0080
	.dc.w	$AD4F,$91CF,$7E30,$1800,$95A8,$9C48,$6370,$0040
	.dc.w	$6D1F,$E18F,$1E70,$0000,$C5B0,$8C38,$73C0,$0000
	.dc.w	$AD40,$9190,$7E7F,$1810,$15A8,$4C48,$F3F0,$40C0
	.dc.w	$6D4F,$E1B0,$1E7F,$003F,$95B0,$6C38,$F3C0,$E000
	.dc.w	$AD48,$91CF,$7E37,$1800,$95A8,$9C48,$63F0,$00C0
	.dc.w	$6D18,$E18F,$1E77,$0000,$C5B0,$8C38,$73C0,$0000
	.dc.w	$AD0F,$91F0,$7E4F,$180F,$85A8,$7C48,$93F0,$80C0
	.dc.w	$B520,$8990,$7E7F,$0810,$2568,$4C88,$F3F0,$4080
	.dc.w	$991F,$818F,$7E70,$0000,$C4C0,$8C08,$73F0,$0000
	.dc.w	$4A4F,$C34F,$3C30,$0000,$9280,$9610,$61E0,$0000
	.dc.w	$2430,$6677,$1800,$0000,$6140,$7360,$0080,$0000
	.dc.w	$0000,$0002,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0002,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0002,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0002,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0000,$0002,$0000,$0000,$0000,$0000,$0000
ashipd:	.dc.w	16,12
	.dc.w	24,3
	.dc.w	$0000,$0000,$0000,$0000,$8000,$0000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$8000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1E00,$0000,$0000,$8000,$803C,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1E00,$3F00,$0000,$0000
	.dc.w	$003C,$807E,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2100,$6180,$1E00,$0000,$0042,$80C3,$003C,$0000
	.dc.w	$0000,$0000,$0000,$0000,$5480,$C8DB,$3F00,$0800
	.dc.w	$0095,$E989,$007E,$0008,$0000,$8000,$0000,$0000
	.dc.w	$4298,$DCDB,$3F00,$1C00,$08A1,$ED9D,$007E,$001C
	.dc.w	$0000,$8000,$0000,$0000,$4A87,$D4E3,$3F1C,$1C00
	.dc.w	$F4A9,$E795,$1876,$0014,$0000,$8000,$0000,$0000
	.dc.w	$2EB4,$E0E8,$1F1F,$0008,$18BA,$0183,$FE7C,$0000
	.dc.w	$0000,$8000,$0000,$0000,$4A8B,$D4D8,$3F37,$1C13
	.dc.w	$ECA9,$0995,$F67E,$E01C,$0000,$8000,$0000,$0000
	.dc.w	$2E80,$E0DA,$1F3F,$0018,$04BA,$2983,$FE7C,$0800
	.dc.w	$0000,$8000,$0000,$0000,$4A84,$D4E5,$3F1B,$1C00
	.dc.w	$14A9,$D795,$E87E,$001C,$0000,$8000,$0000,$0000
	.dc.w	$2EAC,$E0E5,$1F1B,$0000,$12BA,$D383,$EC7C,$0000
	.dc.w	$0000,$8000,$0000,$0000,$4A84,$D4FD,$3F33,$1C00
	.dc.w	$10A9,$DF95,$E67E,$001C,$0000,$8000,$0000,$0000
	.dc.w	$2E87,$E0DC,$1F3B,$001B,$F4BA,$1983,$EE7C,$E800
	.dc.w	$0000,$8000,$0000,$0000,$54BB,$C8F7,$3F08,$0800
	.dc.w	$E6B5,$F789,$087E,$0008,$0000,$8000,$0000,$0000
	.dc.w	$2103,$61A7,$1E18,$0000,$E442,$F6C3,$083C,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1E18,$3F1F,$0000,$0000
	.dc.w	$083C,$FC7E,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1E0B,$0000,$0000,$0000,$E83C,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$8000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$8000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$0000,$8000,$0000,$0000,$0000,$0000,$0000
ashipe:	.dc.w	17,13
	.dc.w	26,3
	.dc.w	$0000,$0000,$0000,$0000,$4000,$0000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$4000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1F00,$0000,$0000,$4000,$401F,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1900,$3980,$0600,$0000
	.dc.w	$4011,$4031,$000E,$0000,$0000,$8000,$0000,$0000
	.dc.w	$2480,$60C0,$1F00,$0000,$0024,$4060,$001F,$0000
	.dc.w	$8000,$C000,$0000,$0000,$4A40,$C44D,$3F80,$0400
	.dc.w	$005B,$F644,$003F,$0004,$4000,$6000,$8000,$0000
	.dc.w	$514D,$CE5D,$3F80,$0E00,$F651,$F74E,$003F,$000E
	.dc.w	$4000,$6000,$8000,$0000,$5553,$CA51,$3F8E,$0E00
	.dc.w	$F955,$F14A,$0E3B,$000A,$4000,$6000,$8000,$0000
	.dc.w	$5546,$CA60,$3F9F,$0E00,$0C55,$00CA,$FF3F,$000E
	.dc.w	$4000,$6000,$8000,$0000,$352B,$F1E4,$0E1F,$0005
	.dc.w	$FA95,$04F1,$FF0E,$F400,$8000,$E000,$0000,$0000
	.dc.w	$5570,$CA6D,$3F9B,$0E08,$01D5,$F6CA,$FB3F,$020E
	.dc.w	$4000,$6000,$8000,$0000,$3530,$F1ED,$0E1F,$000C
	.dc.w	$4195,$B6F1,$FF0E,$A600,$8000,$E000,$0000,$0000
	.dc.w	$5552,$CA53,$3F8D,$0E01,$0955,$F94A,$F63F,$100E
	.dc.w	$4000,$6000,$8000,$0000,$3507,$F1E2,$0E1D,$0000
	.dc.w	$1C15,$E8F1,$F70E,$0000,$8000,$E000,$0000,$0000
	.dc.w	$5543,$CA5E,$3F91,$0E00,$1855,$EF4A,$F13F,$000E
	.dc.w	$4000,$6000,$8000,$0000,$3532,$F1EF,$0E1D,$000C
	.dc.w	$E995,$1EF1,$F70E,$0600,$8000,$E000,$0000,$0000
	.dc.w	$5161,$CE6E,$3F95,$0E05,$F0D1,$0ECE,$F53F,$F40E
	.dc.w	$4000,$6000,$8000,$0000,$4A44,$C462,$3F9D,$0400
	.dc.w	$045B,$08C4,$F73F,$0004,$4000,$6000,$8000,$0000
	.dc.w	$2491,$60D3,$1F0C,$0000,$F124,$F960,$061F,$0000
	.dc.w	$8000,$C000,$0000,$0000,$190D,$399F,$0600,$0000
	.dc.w	$F611,$FF31,$000E,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$1F00,$0000,$0000,$0000,$401F,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$4000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$4000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$0000,$4000,$0000,$0000,$0000,$0000,$0000
ashipf:	.dc.w	21,14
	.dc.w	28,3
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0400,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1F00,$0000,$0000,$0400,$0400,$0000,$0000
	.dc.w	$0000,$1F00,$0000,$0000,$1F00,$3F80,$0000,$0000
	.dc.w	$0400,$0400,$0000,$0000,$1F00,$3F80,$0000,$0000
	.dc.w	$2080,$60C0,$1F00,$0000,$0000,$0400,$0000,$0000
	.dc.w	$2080,$60C0,$1F00,$0000,$2E80,$60C0,$1F00,$0000
	.dc.w	$0000,$0400,$0000,$0000,$2E80,$60C0,$1F00,$0000
	.dc.w	$5B40,$C461,$3F80,$0400,$0000,$BFB0,$0000,$0000
	.dc.w	$5B40,$C460,$3F80,$0400,$5141,$CE63,$3F80,$0E00
	.dc.w	$BFB0,$BFB8,$0000,$0000,$5140,$CE60,$3F80,$0E00
	.dc.w	$5542,$CA66,$3F81,$0E00,$4048,$000C,$FFF0,$0000
	.dc.w	$5540,$CA60,$3B80,$0A00,$5544,$CA6C,$3F83,$0E00
	.dc.w	$FFE4,$0006,$FFF8,$3F80,$5540,$CA60,$3B80,$0A00
	.dc.w	$358D,$F1FC,$0E03,$0000,$4052,$BFA3,$FFFC,$8020
	.dc.w	$3580,$F1E0,$0E00,$0000,$554A,$CA79,$3F87,$0E01
	.dc.w	$000A,$BFB3,$FFFC,$0010,$5540,$CA60,$3F80,$0E00
	.dc.w	$358A,$F1E9,$0E07,$0001,$060A,$B9B2,$FFFC,$8E30
	.dc.w	$3580,$F1E0,$0E00,$0000,$5542,$CA6E,$3F89,$0E00
	.dc.w	$4148,$7ECE,$BFB2,$1100,$5540,$CA60,$3F80,$0E00
	.dc.w	$3584,$F1EC,$0E03,$0000,$C064,$7FC6,$BFB8,$1100
	.dc.w	$3580,$F1E0,$0E00,$0000,$5540,$CA6F,$3F8E,$0E00
	.dc.w	$4040,$FFFE,$3F8E,$1100,$5540,$CA60,$3F80,$0E00
	.dc.w	$358A,$F1F9,$0E07,$0001,$404A,$FFF3,$BFBC,$8E30
	.dc.w	$3580,$F1E0,$0E00,$0000,$514C,$CE7D,$3F83,$0E00
	.dc.w	$0002,$FFF3,$BFBC,$8020,$5140,$CE60,$3F80,$0E00
	.dc.w	$5B44,$C46C,$3F83,$0400,$BFA4,$4046,$BFB8,$3F80
	.dc.w	$5B40,$C460,$3F80,$0400,$2E82,$60C6,$1F01,$0000
	.dc.w	$0008,$404C,$BFB0,$0000,$2E80,$60C0,$1F00,$0000
	.dc.w	$2081,$60C3,$1F00,$0000,$BFB0,$FFF8,$0000,$0000
	.dc.w	$2080,$60C0,$1F00,$0000,$1F00,$3F81,$0000,$0000
	.dc.w	$0000,$BFB0,$0000,$0000,$1F00,$3F80,$0000,$0000
	.dc.w	$0000,$1F00,$0000,$0000,$0000,$0400,$0000,$0000
	.dc.w	$0000,$1F00,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0400,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0400,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0400,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0000,$0400,$0000,$0000,$0000,$0000,$0000

*
*	CILLER SEVEN (Titties)
*
bship0:	.dc.w	4,1
	.dc.w	3,1
	.dc.w	$0000,$3E00,$1C00,$0000,$1C00,$DD80,$3600,$0000
	.dc.w	$0000,$3E00,$1400,$0000
bship1:	.dc.w	5,2
	.dc.w	5,1
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$3F80,$2080,$0000
	.dc.w	$2080,$E0E0,$1500,$0A00,$0000,$3F80,$1100,$0000
	.dc.w	$0000,$3180,$3180,$0000
bship2:	.dc.w	5,2
	.dc.w	5,1
	.dc.w	$0000,$1F00,$1F00,$0000,$1100,$3F80,$0000,$0000
	.dc.w	$2E80,$E0E0,$1500,$0A00,$0000,$FFE0,$D160,$0000
	.dc.w	$0000,$3B80,$3B80,$0000
bship3:	.dc.w	6,3
	.dc.w	7,1
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0FC0,$08C0,$0000
	.dc.w	$0F80,$3FE0,$2020,$0000,$2DA0,$E238,$1AC0,$0700
	.dc.w	$1740,$3FE0,$0000,$0000,$0000,$3FE0,$28A0,$0000
	.dc.w	$0000,$38E0,$38E0,$0000
bship4:	.dc.w	7,3
	.dc.w	8,1
	.dc.w	$0000,$07C0,$07C0,$0000,$07C0,$1FF0,$1830,$0000
	.dc.w	$1010,$3018,$2FE8,$0000,$2AA8,$E54E,$1930,$0380
	.dc.w	$0440,$3C78,$2388,$0000,$1390,$7FFC,$4004,$0000
	.dc.w	$0000,$7FFC,$6C6C,$0000,$0000,$3838,$3838,$0000
bship5:	.dc.w	8,3
	.dc.w	9,2
	.dc.w	$0000,$03E0,$03E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$03E0,$0FF8,$0C18,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0808,$380E,$37F6,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2552,$E2A3,$1C9C,$01C0,$0000,$8000,$0000,$0000
	.dc.w	$0410,$1C1C,$13E4,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0220,$3E3E,$31C6,$0000,$0000,$0000,$0000,$0000
	.dc.w	$09C8,$3FFE,$2002,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$3FFE,$3636,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1C1C,$1C1C,$0000,$0000,$0000,$0000,$0000
bship6:	.dc.w	9,3
	.dc.w	9,2
	.dc.w	$0000,$01F0,$01F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01F0,$07FC,$060C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$05F4,$3C07,$03F8,$0000,$0000,$8000,$0000,$0000
	.dc.w	$24A4,$E358,$1F5F,$02E8,$8000,$E000,$0000,$0000
	.dc.w	$0444,$1C47,$13B9,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0248,$3E4F,$31B1,$0000,$0000,$8000,$8000,$0000
	.dc.w	$09F2,$3FFF,$2000,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$3FBF,$360D,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$1C07,$1C07,$0000,$0000,$0000,$0000,$0000
bship7:	.dc.w	10,3
	.dc.w	10,2
	.dc.w	$0000,$00F8,$00F8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00F8,$07FF,$0707,$0000,$0000,$0000,$0000,$0000
	.dc.w	$06FB,$0E03,$09FC,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0D55,$7CA9,$03AE,$0070,$8000,$F000,$0000,$0000
	.dc.w	$2405,$E3FE,$1E8B,$0202,$2000,$3800,$C000,$0000
	.dc.w	$0489,$1CA9,$1356,$0000,$0000,$C000,$4000,$0000
	.dc.w	$028A,$3EAB,$3154,$0000,$0000,$E000,$6000,$0000
	.dc.w	$09DC,$3FFF,$2000,$0000,$8000,$E000,$2000,$0000
	.dc.w	$0088,$3FDF,$3603,$0000,$0000,$E000,$6000,$0000
	.dc.w	$0000,$1C01,$1C01,$0000,$0000,$C000,$C000,$0000
bship8:	.dc.w	11,4
	.dc.w	11,2
	.dc.w	$0000,$007C,$007C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$007C,$01FF,$0183,$0000,$0000,$0000,$0000,$0000
	.dc.w	$017D,$0301,$00FE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$02FE,$067C,$0183,$0000,$8000,$C000,$0000,$0000
	.dc.w	$13AB,$7054,$0FD7,$00BA,$9000,$1C00,$E000,$0000
	.dc.w	$2638,$E1FF,$1F45,$0101,$C800,$0E00,$F000,$0000
	.dc.w	$0482,$1C92,$136D,$0000,$4000,$7000,$9000,$0000
	.dc.w	$0282,$3E92,$316D,$0000,$8000,$F800,$1800,$0000
	.dc.w	$09EF,$3FFF,$2000,$0000,$2000,$F800,$0800,$0000
	.dc.w	$0082,$3FEF,$3600,$0000,$0000,$F800,$D800,$0000
	.dc.w	$0000,$1C00,$1C00,$0000,$0000,$7000,$7000,$0000
bship9:	.dc.w	11,4
	.dc.w	12,2
	.dc.w	$0000,$007C,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$007C,$01FF,$0101,$0000,$0000,$0000,$0000,$0000
	.dc.w	$017D,$0301,$00FE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0282,$067C,$0183,$0000,$8000,$C000,$0000,$0000
	.dc.w	$13AB,$7054,$0FD7,$00BA,$9000,$1C00,$E000,$0000
	.dc.w	$2600,$E1C7,$1F7D,$0101,$C800,$0E00,$F000,$0000
	.dc.w	$0FFF,$1FFF,$1000,$0000,$C000,$E000,$2000,$0000
	.dc.w	$0682,$1C92,$137D,$0000,$C000,$7000,$9000,$0000
	.dc.w	$0282,$3E92,$317D,$0000,$8000,$F800,$1800,$0000
	.dc.w	$09EF,$3FFF,$2010,$0000,$2000,$F800,$0800,$0000
	.dc.w	$0082,$3FEF,$3600,$0000,$0000,$F800,$D800,$0000
	.dc.w	$0000,$1C00,$1C00,$0000,$0000,$7000,$7000,$0000
bshipa:	.dc.w	12,4
	.dc.w	13,2
	.dc.w	$0000,$003E,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$003E,$00FF,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$00BE,$0180,$007F,$0000,$8000,$C000,$0000,$0000
	.dc.w	$0141,$033E,$00FF,$0000,$4000,$6000,$8000,$0000
	.dc.w	$1955,$78AA,$07EB,$00DD,$4C00,$8F00,$F000,$8000
	.dc.w	$329C,$F163,$0FBE,$0180,$A600,$4780,$F800,$C000
	.dc.w	$0000,$03FF,$0200,$0000,$0000,$E000,$2000,$0000
	.dc.w	$00B6,$0249,$03BE,$0200,$8000,$2000,$E000,$2000
	.dc.w	$0241,$0F49,$09BE,$0100,$2000,$7800,$C800,$4000
	.dc.w	$0141,$1F49,$18BE,$0000,$4000,$7C00,$8C00,$0000
	.dc.w	$04F7,$1FFF,$1008,$0000,$9000,$FC00,$0400,$0000
	.dc.w	$0041,$1FF7,$1B00,$0000,$0000,$FC00,$6C00,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$3800,$3800,$0000
bshipb:	.dc.w	13,4
	.dc.w	14,2
	.dc.w	$0000,$001F,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$001F,$00FF,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$0080,$01BF,$005F,$001F,$2000,$B000,$4000,$0000
	.dc.w	$0120,$031F,$00FF,$0000,$9000,$1800,$E000,$0000
	.dc.w	$19A0,$7855,$07F5,$006E,$B300,$43C0,$FC00,$C000
	.dc.w	$3360,$F0BF,$0FDF,$00CE,$D980,$A1E0,$7E00,$6000
	.dc.w	$0000,$03FF,$03FF,$0000,$0000,$F800,$F800,$0000
	.dc.w	$005B,$0724,$07DF,$0100,$4000,$9C00,$7C00,$1000
	.dc.w	$013B,$0FA4,$08DF,$0080,$9000,$BE00,$6200,$2000
	.dc.w	$02A0,$1FA4,$105F,$0000,$A800,$BF00,$4100,$0000
	.dc.w	$057B,$1DFF,$1204,$0000,$D400,$F700,$0900,$0000
	.dc.w	$0220,$1FFB,$1000,$0000,$8800,$FF00,$0100,$0000
	.dc.w	$0000,$0F80,$0880,$0000,$0000,$3E00,$2200,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$1C00,$1C00,$0000
bshipc:	.dc.w	14,4
	.dc.w	16,2
	.dc.w	$0000,$000F,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$000F,$007F,$0000,$0000,$8000,$F000,$0000,$0000
	.dc.w	$0040,$00DF,$002F,$000F,$1000,$D800,$A000,$8000
	.dc.w	$0090,$038F,$007F,$0000,$4800,$8E00,$F000,$0000
	.dc.w	$1991,$786A,$07FA,$0077,$4CC0,$B0F0,$FF00,$7000
	.dc.w	$3330,$F0DF,$0FEF,$00E7,$6660,$D878,$BF80,$3800
	.dc.w	$0000,$07FF,$07FF,$0000,$0000,$FE00,$FE00,$0000
	.dc.w	$0140,$023F,$03EF,$012F,$1400,$E200,$BE00,$A400
	.dc.w	$0025,$0F9A,$0CEF,$0088,$2000,$CF80,$B980,$8800
	.dc.w	$029D,$0F92,$086F,$0000,$CA00,$4F80,$B080,$0000
	.dc.w	$0650,$1ED2,$112F,$0000,$5300,$5BC0,$A440,$0000
	.dc.w	$053D,$1C7F,$1382,$0000,$E500,$F1C0,$0E40,$0000
	.dc.w	$06D0,$1EFD,$1100,$0000,$5B00,$FBC0,$0440,$0000
	.dc.w	$0380,$0FE0,$0820,$0000,$0E00,$3F80,$2080,$0000
	.dc.w	$0000,$0FE0,$0C60,$0000,$0000,$3F80,$3180,$0000
	.dc.w	$0000,$0380,$0380,$0000,$0000,$0E00,$0E00,$0000
bshipd:	.dc.w	16,5
	.dc.w	18,3
	.dc.w	$0000,$0003,$0003,$0000,$0000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0003,$000F,$000C,$0000
	.dc.w	$E000,$F800,$1800,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$001C,$0003,$0000,$0800,$1C00,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0013,$0034,$000B,$0003
	.dc.w	$E400,$1600,$E800,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0024,$00E3,$001F,$0000,$1200,$E380,$FC00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1999,$7866,$07FA,$0079
	.dc.w	$0CCC,$F30F,$AFF0,$CF00,$0000,$0000,$0000,$0000
	.dc.w	$333C,$F0CF,$0FF3,$00F1,$1E66,$F987,$E7F8,$C780
	.dc.w	$0000,$8000,$0000,$0000,$0000,$01FF,$01FF,$0000
	.dc.w	$0000,$FFC0,$FFC0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0050,$038F,$037B,$004B,$0500,$F8E0,$EF60,$E900
	.dc.w	$0000,$0000,$0000,$0000,$00C9,$07E6,$043B,$0022
	.dc.w	$4980,$B3F0,$EE10,$2200,$0000,$0000,$0000,$0000
	.dc.w	$0127,$0F64,$0C9B,$0000,$7240,$9378,$EC98,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0254,$0E34,$09CB,$0000
	.dc.w	$1520,$9638,$E9C8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$02AF,$0E5F,$09E0,$0040,$7AA0,$FD38,$83C8,$0100
	.dc.w	$0000,$0000,$0000,$0000,$0244,$0E0F,$09F0,$0000
	.dc.w	$1120,$7838,$07C8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0110,$0F1C,$0CE4,$0000,$0440,$1C78,$1398,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00E0,$07FC,$0404,$0000
	.dc.w	$0380,$1FF0,$1010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03F8,$0318,$0000,$0000,$0FE0,$0C60,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$01F0,$01F0,$0000
	.dc.w	$0000,$07C0,$07C0,$0000,$0000,$0000,$0000,$0000
bshipe:	.dc.w	17,6
	.dc.w	20,3
	.dc.w	$0000,$0001,$0001,$0000,$0000,$F000,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$000D,$000C,$0000
	.dc.w	$0000,$F600,$0600,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$001F,$0012,$0000,$F000,$FF00,$0900,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000C,$003E,$0023,$0000
	.dc.w	$0600,$0F80,$F880,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0013,$0070,$004F,$0003,$F900,$01C0,$FE40,$F800
	.dc.w	$0000,$0000,$0000,$0000,$0666,$1E19,$01FF,$001C
	.dc.w	$0CCC,$F30F,$FFF0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07FD,$00FB,$0700,$201C,$F7FC,$5BE0,$E01C
	.dc.w	$0000,$0000,$0000,$0000,$333E,$F0CF,$0FF1,$00F0
	.dc.w	$0F99,$FE61,$F1FE,$E1E0,$8000,$E000,$0000,$0000
	.dc.w	$0000,$03FF,$03FF,$0000,$0000,$FFF8,$FFF8,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00D0,$078F,$047D,$004D
	.dc.w	$0160,$FE3C,$F7C4,$F640,$0000,$0000,$0000,$0000
	.dc.w	$0308,$0F27,$08FD,$0025,$A218,$5C9E,$F7E2,$1480
	.dc.w	$0000,$0000,$0000,$0000,$02A7,$1E62,$119D,$0000
	.dc.w	$BCA8,$48CF,$F731,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0592,$1C72,$13CD,$0040,$0934,$49C7,$F679,$0040
	.dc.w	$0000,$0000,$0000,$0000,$054F,$1CBF,$13E0,$00E0
	.dc.w	$BE54,$FFA7,$40F9,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$05B2,$1C4F,$13F0,$0040,$09B4,$BE47,$01F9,$0040
	.dc.w	$0000,$0000,$0000,$0000,$02E8,$1E0F,$11F1,$0000
	.dc.w	$02E8,$1E0F,$11F1,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0318,$0F1E,$08E2,$0000,$0318,$0F1E,$08E2,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00E0,$07FC,$0404,$0000
	.dc.w	$00E0,$07FC,$0404,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03F8,$0208,$0000,$0000,$03F8,$0208,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$01F0,$01F0,$0000
	.dc.w	$0000,$01F0,$01F0,$0000,$0000,$0000,$0000,$0000
bshipf:	.dc.w	18,6
	.dc.w	21,3
	.dc.w	$0000,$0001,$0001,$0000,$0000,$FC00,$FC00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$000F,$000E,$0000
	.dc.w	$0000,$FF80,$0380,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$001F,$0012,$0000,$FC00,$FFC0,$0240,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000C,$003E,$0023,$0000
	.dc.w	$0180,$03E0,$FE20,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0013,$0070,$004F,$0003,$FE40,$0070,$FF90,$FE00
	.dc.w	$0000,$0000,$0000,$0000,$0666,$1E19,$01FF,$001C
	.dc.w	$0333,$FCC3,$FFFC,$01C0,$0000,$C000,$0000,$0000
	.dc.w	$0700,$07FD,$00FB,$0700,$5007,$EDF8,$AEF8,$E800
	.dc.w	$0000,$0000,$0000,$0000,$333E,$F0CF,$0FF1,$00F0
	.dc.w	$03E6,$FF98,$FC7F,$F878,$6000,$7800,$8000,$0000
	.dc.w	$0000,$0FFF,$0FFF,$0000,$0000,$FFFF,$FFFF,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0350,$1F0F,$18FD,$004D
	.dc.w	$0056,$FF87,$FDF8,$FD90,$0000,$C000,$C000,$0000
	.dc.w	$04E8,$1C07,$13FD,$0025,$50B9,$AF01,$FDFE,$0520
	.dc.w	$0000,$C000,$4000,$0000,$0D27,$3CE2,$239D,$0080
	.dc.w	$5725,$AA39,$FDCE,$0008,$8000,$E000,$2000,$0000
	.dc.w	$0A52,$39B2,$27CD,$01C0,$0252,$AA6C,$FD9F,$001C
	.dc.w	$8000,$E000,$2000,$0000,$0AEF,$391F,$27E0,$01E0
	.dc.w	$57BA,$FFC4,$A83F,$003C,$8000,$E000,$2000,$0000
	.dc.w	$0A42,$39BF,$27F0,$01F0,$0212,$DFEC,$887F,$007C
	.dc.w	$8000,$E000,$2000,$0000,$0D16,$3CE7,$23F8,$00E0
	.dc.w	$0345,$8F39,$88FE,$0038,$8000,$E000,$2000,$0000
	.dc.w	$04E4,$1C07,$13F9,$0000,$0139,$0701,$04FE,$0000
	.dc.w	$0000,$C000,$4000,$0000,$0318,$1F1F,$18E3,$0000
	.dc.w	$00C6,$07C7,$0638,$0000,$0000,$C000,$C000,$0000
	.dc.w	$01F0,$0FFE,$0C06,$0000,$007C,$03FF,$0301,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$07FC,$060C,$0000
	.dc.w	$0000,$01FF,$0183,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01F0,$01F0,$0000,$0000,$007C,$007C,$0000
	.dc.w	$0000,$0000,$0000,$0000

*
*	CILLERFOUR (the T.V.)
*
cship0:	.dc.w	1,1
	.dc.w	3,1
	.dc.w	$0000,$E000,$E000,$0000,$4000,$E000,$0000,$0000
	.dc.w	$0000,$A000,$0000,$0000
cship1:	.dc.w	1,2
	.dc.w	5,1
	.dc.w	$0000,$A000,$A000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$E000,$E000,$0000,$0000,$4000,$E000,$0000,$0000
	.dc.w	$0000,$A000,$A000,$0000
cship2:	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$0000,$A800,$0000,$0000,$A800,$F800,$0000,$0000
	.dc.w	$5000,$D800,$2000,$0000,$2000,$F800,$0000,$0000
	.dc.w	$0000,$5000,$0000,$0000
cship3:	.dc.w	2,2
	.dc.w	5,1
	.dc.w	$0000,$A800,$0000,$0000,$A800,$F800,$0000,$0000
	.dc.w	$7000,$5000,$A800,$0000,$2000,$F800,$0000,$0000
	.dc.w	$0000,$5000,$0000,$0000
cship4:	.dc.w	3,2
	.dc.w	6,1
	.dc.w	$0000,$BA00,$1000,$0000,$AA00,$FE00,$0000,$0000
	.dc.w	$4C00,$5C00,$B200,$1000,$6400,$F600,$0800,$0000
	.dc.w	$2800,$FE00,$1000,$0000,$0000,$2800,$0000,$0000
cship5:	.dc.w	4,2
	.dc.w	6,1
	.dc.w	$0000,$9C80,$0800,$0000,$9480,$BE80,$0000,$0000
	.dc.w	$2600,$6F00,$9880,$0800,$3200,$FB80,$0400,$0000
	.dc.w	$1400,$BE80,$0800,$0000,$0000,$1400,$0000,$0000
cship6:	.dc.w	4,3
	.dc.w	7,1
	.dc.w	$0000,$9C80,$0800,$0000,$9480,$BE80,$0000,$0000
	.dc.w	$2A00,$6B00,$9480,$0000,$8080,$7F00,$8880,$0800
	.dc.w	$2200,$EB80,$1400,$0000,$1400,$BE80,$0800,$0000
	.dc.w	$0000,$1400,$0000,$0000
cship7:	.dc.w	5,3
	.dc.w	7,1
	.dc.w	$0000,$8E20,$0400,$0000,$8A20,$9F20,$0000,$0000
	.dc.w	$1F00,$3580,$8A20,$0000,$C460,$7BC0,$8420,$0400
	.dc.w	$1B00,$B5A0,$0A00,$0000,$0A00,$9F20,$0400,$0000
	.dc.w	$0000,$0A00,$0000,$0000
cship8:	.dc.w	6,3
	.dc.w	7,1
	.dc.w	$0500,$8F88,$0200,$0000,$8888,$9AC8,$0500,$0000
	.dc.w	$12C0,$37E0,$8D08,$0500,$C718,$78F0,$8708,$0700
	.dc.w	$1840,$BB68,$0580,$0100,$0880,$9AC8,$0700,$0000
	.dc.w	$0000,$0D80,$0000,$0000
cship9:	.dc.w	7,4
	.dc.w	9,1
	.dc.w	$0280,$87C2,$0100,$0000,$8442,$8D62,$0280,$0000
	.dc.w	$0960,$1970,$8682,$0000,$8822,$1AB0,$87C2,$0280
	.dc.w	$E38E,$7C7C,$8382,$0380,$0920,$1BB0,$86C2,$0280
	.dc.w	$0C20,$9D32,$02C0,$0000,$0440,$8D62,$0380,$0000
	.dc.w	$0000,$06C0,$0000,$0000
cshipa:	.dc.w	9,5
	.dc.w	11,2
	.dc.w	$0110,$03F8,$00E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0208,$C6EC,$0110,$0000,$0000,$6000,$0000,$0000
	.dc.w	$C4EC,$CCEE,$4310,$0000,$6000,$6000,$4000,$0000
	.dc.w	$4514,$4C06,$C3F8,$0000,$4000,$4000,$6000,$0000
	.dc.w	$C4E4,$4D16,$C3F8,$01F0,$6000,$4000,$6000,$0000
	.dc.w	$F1F1,$7E4F,$C110,$01F0,$E000,$C000,$6000,$0000
	.dc.w	$44E4,$4D16,$C3F8,$01F0,$4000,$4000,$6000,$0000
	.dc.w	$45F4,$CCE6,$4318,$0000,$4000,$6000,$4000,$0000
	.dc.w	$0604,$CEE6,$0118,$0000,$0000,$6000,$0000,$0000
	.dc.w	$0208,$06EC,$01F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0318,$0000,$0000,$0000,$0000,$0000,$0000
cshipb:	.dc.w	11,6
	.dc.w	13,2
	.dc.w	$0000,$0082,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0082,$01FF,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$017D,$E37D,$0082,$0000,$0000,$8E00,$0000,$0000
	.dc.w	$E201,$E601,$41FE,$0000,$8E00,$CE00,$0400,$0000
	.dc.w	$42FE,$4600,$E1FF,$007C,$8400,$C400,$0E00,$0000
	.dc.w	$E2DE,$4644,$E1C7,$00B2,$8E00,$C400,$0E00,$0000
	.dc.w	$F8BA,$5F11,$E082,$00FE,$3E00,$F400,$0E00,$0000
	.dc.w	$42D6,$4644,$E1C7,$00BA,$8400,$C400,$0E00,$0000
	.dc.w	$E0FE,$E701,$40FE,$007C,$0E00,$CE00,$0400,$0000
	.dc.w	$42FE,$E67C,$4183,$0000,$8400,$CE00,$0400,$0000
	.dc.w	$0300,$E77C,$0083,$0000,$8000,$CE00,$0000,$0000
	.dc.w	$0101,$037D,$00FE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0183,$0000,$0000,$0000,$0000,$0000,$0000
cshipc:	.dc.w	12,7
	.dc.w	14,2
	.dc.w	$0000,$0080,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0080,$01BE,$0000,$0000,$8000,$C000,$0000,$0000
	.dc.w	$013E,$037F,$0080,$0000,$4000,$6000,$8000,$0000
	.dc.w	$0200,$E641,$01BE,$0000,$6000,$7380,$8000,$0000
	.dc.w	$A2FF,$A600,$01FF,$403E,$A280,$3280,$C000,$0100
	.dc.w	$009C,$0722,$A0FF,$401C,$8000,$7000,$8280,$0100
	.dc.w	$A2AE,$0663,$A1E3,$4098,$A280,$3000,$C280,$8100
	.dc.w	$B89C,$1F49,$A0C1,$40BE,$8E80,$7C00,$8280,$8100
	.dc.w	$02AA,$0663,$A1E3,$409C,$A000,$3000,$C280,$8100
	.dc.w	$A09C,$A722,$00FF,$401C,$8280,$7280,$8000,$0100
	.dc.w	$02FF,$A600,$01FF,$403E,$A000,$3280,$C000,$0100
	.dc.w	$033E,$E77F,$0080,$0000,$2000,$3380,$C000,$0000
	.dc.w	$0100,$037F,$0080,$0000,$4000,$6000,$8000,$0000
	.dc.w	$0000,$01BE,$003E,$0000,$0000,$C000,$0000,$0000
cshipd:	.dc.w	13,8
	.dc.w	17,2
	.dc.w	$0040,$00C0,$0000,$0000,$4000,$6000,$0000,$0000
	.dc.w	$0080,$019F,$0040,$0000,$2000,$3000,$4000,$0000
	.dc.w	$015F,$033F,$00C0,$0000,$5000,$9800,$6000,$0000
	.dc.w	$0200,$E660,$01DF,$0040,$1800,$DCE0,$6000,$4000
	.dc.w	$E2BF,$A640,$01FF,$405F,$A8E0,$4CA0,$F000,$4040
	.dc.w	$408E,$0711,$A0FF,$400E,$2040,$1C00,$E0A0,$0040
	.dc.w	$E29F,$067F,$A1FF,$4080,$28E0,$CC00,$F0A0,$2040
	.dc.w	$E2D7,$0631,$A1F1,$40CC,$68E0,$8C00,$F0A0,$6040
	.dc.w	$F8CE,$1F24,$A0E0,$40DF,$63E0,$9F00,$E0A0,$6040
	.dc.w	$42D5,$0631,$A1F1,$40CE,$6840,$8C00,$F0A0,$6040
	.dc.w	$E29F,$A67F,$01FF,$4080,$28E0,$CCA0,$F000,$2040
	.dc.w	$E08E,$A711,$00FF,$400E,$20E0,$1CA0,$E000,$0040
	.dc.w	$42BF,$A640,$01FF,$405F,$A840,$4CA0,$F000,$4040
	.dc.w	$031F,$E77F,$00C0,$0040,$0800,$CCE0,$7000,$4000
	.dc.w	$0140,$033F,$00C0,$0000,$5000,$9800,$6000,$0000
	.dc.w	$0040,$01DF,$001F,$0000,$4000,$7000,$0000,$0000
	.dc.w	$0000,$00C0,$0000,$0000,$0000,$6000,$0000,$0000
cshipe:	.dc.w	14,8
	.dc.w	17,2
	.dc.w	$0060,$00EF,$0000,$0000,$3000,$B800,$0000,$0000
	.dc.w	$00CF,$01DF,$0020,$0000,$8800,$CC00,$3000,$0000
	.dc.w	$0120,$0310,$00EF,$0000,$2400,$4600,$B800,$0000
	.dc.w	$025F,$E620,$01FF,$002F,$D600,$2738,$F800,$A000
	.dc.w	$A290,$E66F,$01FF,$4060,$4A28,$B338,$FC00,$3010
	.dc.w	$00C7,$4708,$A0FF,$4007,$1800,$8710,$F828,$0010
	.dc.w	$A28F,$467F,$A1FF,$4080,$8A28,$F310,$FC28,$0810
	.dc.w	$A2AB,$4658,$A1F8,$40A6,$AA28,$D310,$FC28,$2810
	.dc.w	$B8A7,$5F52,$A0F0,$40AF,$28E8,$57D0,$7828,$A810
	.dc.w	$02AA,$4658,$A1F8,$40A7,$AA00,$D310,$FC28,$2810
	.dc.w	$A28F,$E67F,$01FF,$4080,$8A28,$F338,$FC00,$0810
	.dc.w	$A0C7,$E708,$00FF,$4007,$1828,$8738,$F800,$0010
	.dc.w	$0290,$E66F,$01F0,$4060,$4A00,$B338,$7C00,$3010
	.dc.w	$035F,$E720,$00FF,$002F,$D200,$2338,$FC00,$A000
	.dc.w	$012F,$031F,$00E0,$0000,$A400,$C600,$3800,$0000
	.dc.w	$0060,$01FF,$0000,$0000,$3000,$FC00,$0000,$0000
	.dc.w	$0000,$00EF,$000F,$0000,$0000,$B800,$8000,$0000
cshipf:	.dc.w	15,9
	.dc.w	19,2
	.dc.w	$0000,$006F,$0000,$0000,$0000,$EC00,$0000,$0000
	.dc.w	$006F,$00FF,$0000,$0000,$EC00,$FE00,$0000,$0000
	.dc.w	$00C0,$01D0,$002F,$0000,$0200,$1300,$EC00,$0000
	.dc.w	$012F,$0310,$00EF,$000F,$E900,$1180,$EE00,$E000
	.dc.w	$0240,$E63F,$01EF,$0020,$0580,$F9CE,$EE00,$0800
	.dc.w	$E287,$E679,$01EF,$4066,$C28E,$3CCE,$EF00,$CC04
	.dc.w	$40CE,$471E,$A0EE,$4001,$E604,$F1C4,$EE0A,$0004
	.dc.w	$E289,$4678,$A1E8,$4087,$228E,$3CC4,$2F0A,$C204
	.dc.w	$E2A2,$4651,$A1E0,$40AF,$8A8E,$14C4,$0F0A,$6A04
	.dc.w	$F8A7,$4F51,$B0E0,$40AF,$CA3E,$15E4,$0E1A,$EA04
	.dc.w	$42A2,$4651,$A1E0,$40AF,$8A84,$14C4,$0F0A,$EA04
	.dc.w	$E289,$E678,$01E8,$4087,$228E,$3CCE,$2F00,$C204
	.dc.w	$E0CE,$E71E,$00EE,$4001,$E60E,$F1CE,$EE00,$0004
	.dc.w	$4287,$E679,$01EF,$4066,$C284,$3CCE,$EF00,$CC04
	.dc.w	$0340,$E73F,$00EF,$0020,$0480,$F8CE,$EF00,$0800
	.dc.w	$012F,$0310,$00EF,$000F,$E900,$1180,$EE00,$E000
	.dc.w	$0080,$0190,$006F,$0000,$0200,$1300,$EC00,$0000
	.dc.w	$006F,$00FF,$0000,$0000,$EC00,$FE00,$0000,$0000
	.dc.w	$0000,$006F,$0000,$0000,$0000,$EC00,$0000,$0000

*
*	CILLERFIVE (the FLAT IRON)
*
dship0:	.dc.w	3,0
	.dc.w	3,1
	.dc.w	$2400,$F600,$1800,$0000,$1000,$3800,$3800,$0000
	.dc.w	$0000,$1000,$1000,$0000
dship1:	.dc.w	5,0
	.dc.w	3,1
	.dc.w	$1280,$F4E0,$0F00,$0000,$0A00,$9B20,$8A20,$0400
	.dc.w	$0000,$1100,$1100,$0000
dship2:	.dc.w	7,0
	.dc.w	3,1
	.dc.w	$3558,$F39E,$0C60,$0000,$0380,$C6C6,$C286,$0100
	.dc.w	$0000,$07C0,$0380,$0000
dship3:	.dc.w	9,0
	.dc.w	4,2
	.dc.w	$3359,$F0E1,$0F1E,$0000,$8000,$E000,$0000,$0000
	.dc.w	$01F0,$C1B0,$C0A0,$0040,$0000,$6000,$6000,$0000
	.dc.w	$0040,$01F0,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0110,$0110,$0000,$0000,$0000,$0000,$0000
dship4:	.dc.w	12,1
	.dc.w	5,2
	.dc.w	$0000,$0041,$0041,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1CD5,$FC36,$03C9,$0000,$9C00,$1F80,$E000,$0000
	.dc.w	$002A,$C022,$0063,$001C,$0000,$0180,$0000,$0000
	.dc.w	$005D,$007F,$0008,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0041,$0000,$0000,$0000,$0000,$0000,$0000
dship5:	.dc.w	13,1
	.dc.w	6,2
	.dc.w	$0000,$0020,$0020,$0000,$0000,$8000,$8000,$0000
	.dc.w	$1C75,$FC11,$03EE,$0000,$C700,$07E0,$F800,$0000
	.dc.w	$0035,$C011,$0031,$000E,$8000,$0060,$8000,$0000
	.dc.w	$000E,$001B,$0020,$0004,$0000,$0000,$8000,$0000
	.dc.w	$0024,$003F,$0000,$0000,$8000,$8000,$0000,$0000
	.dc.w	$0000,$0020,$0000,$0000,$0000,$8000,$0000,$0000
dship6:	.dc.w	15,1
	.dc.w	6,2
	.dc.w	$0000,$0008,$0000,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0E3D,$FE04,$01FB,$0000,$78E0,$40FE,$BF00,$0000
	.dc.w	$000D,$C004,$000C,$0003,$6000,$4006,$6000,$8000
	.dc.w	$0001,$0004,$0008,$0003,$0000,$4000,$2000,$8000
	.dc.w	$000A,$000E,$0001,$0000,$A000,$E000,$0000,$0000
	.dc.w	$0000,$0008,$0000,$0000,$0000,$2000,$0000,$0000
dship7:	.dc.w	17,1
	.dc.w	6,3
	.dc.w	$0000,$0004,$0000,$0000,$0000,$0400,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0F1F,$FF03,$00FC,$0000
	.dc.w	$5F1E,$181F,$E7E0,$0000,$0000,$E000,$0000,$0000
	.dc.w	$4006,$C002,$0006,$0001,$AC00,$4800,$0C00,$F000
	.dc.w	$2000,$6000,$0000,$0000,$0002,$0002,$0006,$0001
	.dc.w	$A800,$4800,$0C00,$F000,$0000,$0000,$0000,$0000
	.dc.w	$0005,$0007,$0000,$0000,$1400,$1C00,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0004,$0000,$0000
	.dc.w	$0000,$0400,$0000,$0000,$0000,$0000,$0000,$0000
dship8:	.dc.w	18,1
	.dc.w	6,3
	.dc.w	$0000,$0002,$0000,$0000,$0000,$0200,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0F1F,$FF01,$00FE,$0000
	.dc.w	$77C7,$2407,$DBF8,$0000,$8000,$F800,$0000,$0000
	.dc.w	$4003,$4001,$0003,$0000,$5600,$0400,$0600,$F800
	.dc.w	$1000,$1000,$0000,$0000,$0001,$C001,$0003,$0000
	.dc.w	$5400,$0400,$0600,$F800,$0800,$1800,$0000,$0000
	.dc.w	$0002,$0003,$0000,$0000,$AA00,$AE00,$5000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0001,$0000
	.dc.w	$0000,$AE00,$AC00,$0000,$0000,$0000,$0000,$0000
dship9:	.dc.w	20,1
	.dc.w	6,3
	.dc.w	$0000,$0001,$0000,$0000,$0000,$0040,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0F0F,$FF00,$00FF,$0000
	.dc.w	$B6F8,$9480,$6B7F,$0000,$7800,$7F80,$8000,$0000
	.dc.w	$4001,$4000,$0001,$0000,$88C0,$A280,$80C0,$7F00
	.dc.w	$0100,$0100,$0000,$0000,$2000,$E000,$0001,$0000
	.dc.w	$8880,$A280,$80C0,$7F00,$0080,$0380,$0000,$0000
	.dc.w	$0001,$0001,$0000,$0000,$B6C0,$94C0,$6B00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0000,$0000
	.dc.w	$2200,$EBC0,$0000,$0000,$0000,$0000,$0000,$0000
dshipa:	.dc.w	21,1
	.dc.w	6,3
	.dc.w	$0000,$0000,$0000,$0000,$0000,$8020,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0F0F,$FF00,$00FF,$0000
	.dc.w	$DB7E,$4A40,$B5BF,$0000,$1E00,$1FE0,$E000,$0000
	.dc.w	$4000,$4000,$0000,$0000,$C460,$5140,$C060,$3F80
	.dc.w	$0040,$0040,$0000,$0000,$2000,$E000,$4000,$0000
	.dc.w	$4440,$5140,$C060,$3F80,$0020,$00E0,$0040,$0000
	.dc.w	$0000,$4000,$0000,$0000,$DB60,$CA60,$3580,$0000
	.dc.w	$0000,$0040,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1100,$F5E0,$0000,$0000,$0000,$0000,$0000,$0000
dshipb:	.dc.w	22,1
	.dc.w	7,3
	.dc.w	$0000,$0000,$0000,$0000,$0008,$8008,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0F0F,$FF00,$00FF,$0000
	.dc.w	$EABF,$6730,$98CF,$0000,$8780,$07F8,$F800,$0000
	.dc.w	$4000,$4000,$0000,$0000,$D2A8,$48C0,$C008,$3FF0
	.dc.w	$0010,$0010,$0000,$0000,$6000,$E000,$4000,$0000
	.dc.w	$6AB0,$6030,$98C8,$0700,$0018,$0038,$0010,$0000
	.dc.w	$0000,$4000,$0000,$0000,$D258,$C898,$4010,$3FE0
	.dc.w	$0000,$0010,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2AA0,$E738,$18C0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$8008,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000
dshipc:	.dc.w	24,1
	.dc.w	7,4
	.dc.w	$0000,$0000,$0000,$0000,$4000,$4000,$0001,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0787,$FF80,$007F,$0000,$F557,$3366,$CEB9,$0220
	.dc.w	$F0F0,$00FF,$FF00,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$6000,$0000,$6BEB,$26B2,$6003,$1FFC
	.dc.w	$0000,$0000,$0003,$0000,$0000,$0000,$0000,$0000
	.dc.w	$E000,$E000,$7000,$0000,$15D4,$32A6,$4E39,$03E0
	.dc.w	$0004,$0004,$0000,$0003,$0000,$0000,$8000,$0000
	.dc.w	$6000,$6000,$0000,$0000,$6BEB,$66B3,$2002,$1FFC
	.dc.w	$0003,$0003,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1554,$7367,$0EB8,$0220
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4001,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
dshipd:	.dc.w	26,1
	.dc.w	7,4
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$2000,$0000
	.dc.w	$2000,$0000,$2000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0783,$FF80,$007F,$0000,$FAAA,$198C,$E777,$0104
	.dc.w	$FE0F,$C00F,$3FF0,$0000,$0000,$F800,$0000,$0000
	.dc.w	$0000,$0000,$6000,$0000,$3575,$1326,$3000,$0FFF
	.dc.w	$6000,$4000,$6000,$8000,$0000,$0000,$3000,$0000
	.dc.w	$8000,$8000,$1000,$6000,$0A72,$1924,$2707,$01FC
	.dc.w	$8000,$C000,$2000,$0000,$7000,$4000,$0800,$3000
	.dc.w	$6000,$6000,$0000,$0000,$3575,$3326,$1000,$0FFF
	.dc.w	$6000,$6000,$4000,$8000,$3000,$3000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0AAA,$398C,$0777,$0104
	.dc.w	$8000,$E000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0000,$2000,$0000,$0000,$0000,$0000,$0000,$0000
dshipe:	.dc.w	28,1
	.dc.w	7,4
	.dc.w	$0000,$0000,$0000,$0000,$1000,$0000,$1000,$0000
	.dc.w	$0000,$0400,$0400,$0400,$0000,$0000,$0000,$0000
	.dc.w	$07C1,$FFC0,$003F,$0000,$FD6B,$0CA2,$F3DD,$00C1
	.dc.w	$5FC1,$9801,$E7FE,$8000,$F000,$FF80,$0000,$0000
	.dc.w	$2000,$0000,$6000,$0000,$1D5D,$0CC9,$1C00,$03FF
	.dc.w	$5C00,$9800,$1C00,$E000,$0100,$0000,$0300,$0000
	.dc.w	$E000,$8000,$1000,$6000,$055D,$0C88,$13C1,$00FF
	.dc.w	$5000,$9800,$E400,$8000,$0400,$0700,$0080,$0300
	.dc.w	$6000,$6000,$0000,$0000,$1D5D,$1CC9,$0C00,$03FF
	.dc.w	$5C00,$9C00,$1800,$E000,$0300,$0300,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$056B,$1CA2,$03DD,$00C1
	.dc.w	$5000,$9C00,$E000,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$0000,$0000
	.dc.w	$0000,$0400,$0000,$0000,$0000,$0000,$0000,$0000
dshipf:	.dc.w	29,1
	.dc.w	7,4
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$1000,$1000
	.dc.w	$0100,$0000,$0100,$0100,$0000,$0000,$0000,$0000
	.dc.w	$07C1,$FFC0,$003F,$0000,$FD55,$0CB1,$F3CE,$00C0
	.dc.w	$57F0,$A600,$79FF,$6000,$7C00,$7FE0,$8000,$0000
	.dc.w	$2000,$0000,$6000,$0000,$1D6E,$0CE0,$1C20,$03DB
	.dc.w	$D700,$E600,$8700,$7800,$0040,$0000,$00C0,$0000
	.dc.w	$1000,$6000,$9000,$6000,$056E,$0CA0,$13E0,$00DB
	.dc.w	$D400,$A600,$F900,$6000,$00E0,$00C0,$0120,$00C0
	.dc.w	$8000,$E000,$1000,$6000,$1D6E,$1CE0,$0C20,$03DB
	.dc.w	$D700,$E700,$8600,$7800,$01C0,$01C0,$0020,$00C0
	.dc.w	$6000,$6000,$0000,$0000,$0555,$1CB1,$03CE,$00C0
	.dc.w	$5400,$A700,$7800,$6000,$00C0,$00C0,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$0000,$0000
	.dc.w	$0000,$0100,$0000,$0000,$0000,$0000,$0000,$0000

*
*	CILLERSIX	(The EYEBALL)
*
eship0:	.dc.w	2,1
	.dc.w	4,1
	.dc.w	$0000,$6000,$6000,$0000,$2000,$F000,$9000,$0000
	.dc.w	$0000,$F000,$9000,$0000,$0000,$6000,$6000,$0000
eship1:	.dc.w	3,1
	.dc.w	4,1
	.dc.w	$0000,$7000,$0000,$0000,$3000,$E800,$1000,$0000
	.dc.w	$3000,$F800,$0000,$0000,$0000,$7000,$0000,$0000
eship2:	.dc.w	3,1
	.dc.w	4,1
	.dc.w	$2000,$7000,$0000,$0000,$5000,$C800,$3000,$0000
	.dc.w	$4000,$C800,$3000,$0000,$2000,$7000,$0000,$0000
eship3:	.dc.w	3,1
	.dc.w	4,1
	.dc.w	$3000,$7000,$0000,$0000,$5800,$C800,$3000,$0000
	.dc.w	$4800,$C800,$3000,$0000,$3000,$7000,$0000,$0000
eship4:	.dc.w	4,2
	.dc.w	6,1
	.dc.w	$0000,$7C00,$4400,$0000,$2000,$E600,$9A00,$0000
	.dc.w	$1800,$D600,$2800,$0000,$4800,$C200,$3C00,$0000
	.dc.w	$2800,$FE00,$8200,$0000,$0000,$7C00,$4400,$0000
eship5:	.dc.w	4,2
	.dc.w	6,1
	.dc.w	$3800,$7C00,$4400,$0000,$4800,$C200,$BE00,$0000
	.dc.w	$D600,$DE00,$2800,$0800,$8A00,$8200,$7C00,$0000
	.dc.w	$5400,$D600,$AA00,$0000,$3800,$7C00,$4400,$0000
eship6:	.dc.w	5,3
	.dc.w	8,1
	.dc.w	$0000,$1C00,$1C00,$0000,$1400,$7F00,$6300,$0000
	.dc.w	$2000,$E580,$9E80,$0400,$4500,$EB80,$9480,$0000
	.dc.w	$4500,$C180,$BE80,$0000,$0000,$EB80,$9480,$0000
	.dc.w	$1C00,$7F00,$4100,$0000,$0000,$1C00,$1C00,$0000
eship7:	.dc.w	5,3
	.dc.w	8,1
	.dc.w	$0000,$3E00,$2200,$0000,$0000,$6B00,$1400,$0000
	.dc.w	$4F00,$C180,$BE00,$0000,$4E00,$EA80,$9F80,$0000
	.dc.w	$4600,$C080,$3F00,$0000,$4900,$EB80,$9C80,$0000
	.dc.w	$3E00,$7F00,$0000,$0000,$0000,$3E00,$2A00,$0000
eship8:	.dc.w	6,4
	.dc.w	10,1
	.dc.w	$0000,$1F00,$1F00,$0000,$0E00,$3F80,$0000,$0000
	.dc.w	$0600,$75C0,$5F40,$0000,$2400,$E360,$9FA0,$0300
	.dc.w	$3880,$F260,$DAE0,$0700,$2740,$E060,$9FA0,$0000
	.dc.w	$3180,$F1E0,$DB60,$0400,$1F00,$7FC0,$0000,$0000
	.dc.w	$0400,$7FC0,$5540,$0000,$0000,$1F00,$1F00,$0000
eship9:	.dc.w	7,4
	.dc.w	11,1
	.dc.w	$0100,$2FA0,$2AA0,$0000,$0C40,$3C60,$23A0,$0000
	.dc.w	$1B80,$BAA8,$AFE8,$0000,$1A60,$79B0,$07C0,$0180
	.dc.w	$31E0,$F038,$A568,$0A80,$19A0,$7830,$07C0,$0000
	.dc.w	$3460,$F478,$A128,$0A80,$0FC0,$3FE0,$0000,$0000
	.dc.w	$0F80,$BFE8,$AAA8,$0000,$0000,$0F80,$0000,$0000
	.dc.w	$0000,$2AA0,$2AA0,$0000
eshipa:	.dc.w	9,6
	.dc.w	15,2
	.dc.w	$0000,$0AA8,$0AA8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03E0,$0220,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A48,$2F5A,$2A0A,$00A0,$0000,$0000,$0000,$0000
	.dc.w	$0310,$1F1C,$10E4,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2CEA,$BC06,$A952,$02A8,$0000,$8000,$8000,$0000
	.dc.w	$0CB8,$3C4E,$03F0,$0060,$0000,$0000,$0000,$0000
	.dc.w	$2472,$B406,$A152,$0AA8,$0000,$8000,$8000,$0000
	.dc.w	$0CF8,$3C0E,$03F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2442,$B406,$A152,$0AA8,$0000,$8000,$8000,$0000
	.dc.w	$0610,$3E1E,$21E2,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0948,$BD5E,$B80E,$02A0,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0FF8,$0808,$0000,$0000,$0000,$0000,$0000
	.dc.w	$02A0,$2BEA,$2AAA,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0AA8,$0AA8,$0000,$0000,$0000,$0000,$0000
eshipb:	.dc.w	11,8
	.dc.w	19,2
	.dc.w	$0000,$02AA,$02AA,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$02AA,$0AAA,$0AAA,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0070,$00F8,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0B4E,$2B44,$2A10,$00AA,$8000,$A000,$A000,$0000
	.dc.w	$033A,$0703,$00FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$286E,$AC11,$A954,$02BA,$A000,$2800,$2800,$8000
	.dc.w	$0659,$0E25,$01FE,$003C,$0000,$8000,$0000,$0000
	.dc.w	$2C4F,$AC11,$A954,$02BA,$0000,$0800,$0800,$A000
	.dc.w	$067D,$0E01,$01FE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$2C11,$AC01,$A954,$02AA,$2000,$2800,$2800,$8000
	.dc.w	$0303,$0F03,$08FC,$0000,$0000,$8000,$8000,$0000
	.dc.w	$2B04,$AF05,$AA50,$00AA,$2000,$2800,$2800,$8000
	.dc.w	$01FC,$03FE,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0AF2,$2AF2,$2AA2,$0008,$8000,$A000,$A000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$02AA,$0AAA,$0AAA,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$02AA,$02AA,$0000,$0000,$0000,$0000,$0000
eshipc:	.dc.w	13,10
	.dc.w	23,2
	.dc.w	$0000,$002A,$002A,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00AA,$0AAA,$0AAA,$0000,$8000,$A800,$A800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0AA0,$2AF5,$2AF5,$000A,$2800,$2A00,$2A00,$8000
	.dc.w	$001C,$00FF,$0080,$0000,$0000,$8000,$8000,$0000
	.dc.w	$2A43,$2B41,$2B14,$00AA,$8A00,$4A00,$4A00,$A000
	.dc.w	$00CE,$03C0,$023F,$0000,$8000,$E000,$2000,$0000
	.dc.w	$2A1B,$AF04,$AE55,$00AE,$A200,$5280,$1280,$A800
	.dc.w	$0136,$0709,$04FF,$000F,$4000,$7000,$9000,$0000
	.dc.w	$2912,$AD05,$AC55,$02AF,$C200,$5280,$1280,$A800
	.dc.w	$0130,$070F,$04FF,$000F,$4000,$7000,$9000,$0000
	.dc.w	$2911,$AD04,$AC55,$02AE,$4200,$5280,$1280,$A800
	.dc.w	$009E,$0780,$047F,$0000,$4000,$7000,$9000,$0000
	.dc.w	$2840,$A940,$A815,$02AA,$0A00,$4A80,$0A80,$A000
	.dc.w	$007F,$01FF,$0100,$0000,$0000,$C000,$4000,$0000
	.dc.w	$0A94,$2AD5,$2A80,$002A,$2800,$2A00,$2A00,$8000
	.dc.w	$0000,$007F,$007F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0AAA,$2AAA,$2AAA,$0000,$A800,$AA00,$AA00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00AA,$0AAA,$0AAA,$0000,$8000,$A800,$A800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$002A,$002A,$0000,$0000,$0000,$0000,$0000
eshipd:	.dc.w	13,10
	.dc.w	23,2
	.dc.w	$0000,$002A,$002A,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00A0,$0AA0,$0AA0,$000A,$8000,$A800,$A800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A0A,$2A55,$2A41,$00AA,$8800,$0A00,$0A00,$A000
	.dc.w	$0022,$00E3,$001C,$0000,$0000,$8000,$0000,$0000
	.dc.w	$282C,$2902,$2855,$02AA,$2A00,$CA00,$0A00,$A000
	.dc.w	$0131,$030E,$00FF,$000E,$4000,$6000,$8000,$0000
	.dc.w	$2164,$A51B,$A455,$0ABF,$4200,$F280,$1280,$A800
	.dc.w	$026F,$0610,$01F9,$0019,$A000,$3000,$C000,$0000
	.dc.w	$206C,$A413,$A155,$0ABF,$2200,$9280,$4280,$A800
	.dc.w	$0260,$061F,$01FF,$001F,$A000,$3000,$C000,$0000
	.dc.w	$207B,$A404,$A155,$0AAE,$A200,$1280,$4280,$A800
	.dc.w	$013F,$0700,$04FF,$0000,$2000,$3000,$D000,$0000
	.dc.w	$211E,$A100,$A055,$0AAA,$C200,$4280,$0280,$A800
	.dc.w	$0080,$0180,$007F,$0000,$8000,$C000,$0000,$0000
	.dc.w	$0841,$2841,$2814,$02AA,$0800,$0A00,$0A00,$A000
	.dc.w	$0000,$007F,$0041,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A00,$2A00,$2A00,$00AA,$2800,$2A00,$2A00,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00AA,$0AAA,$0AAA,$0000,$8000,$A800,$A800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$002A,$002A,$0000,$0000,$0000,$0000,$0000
eshipe:	.dc.w	13,10
	.dc.w	23,2
	.dc.w	$002A,$02AA,$02AA,$0000,$0000,$A000,$A000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A0A,$0A00,$0A00,$00AA,$2800,$2800,$2800,$8000
	.dc.w	$0000,$003E,$0022,$0000,$0000,$0000,$0000,$0000
	.dc.w	$28A0,$285F,$2800,$02AA,$2A00,$8A00,$0A00,$A000
	.dc.w	$0063,$03E3,$021C,$0000,$0000,$E000,$2000,$0000
	.dc.w	$2286,$A52A,$A455,$0AAA,$8200,$F280,$1280,$A800
	.dc.w	$0131,$070E,$00FF,$000E,$4000,$7000,$9000,$0000
	.dc.w	$83CE,$853B,$8055,$2ABF,$E880,$F080,$0080,$AA00
	.dc.w	$026F,$0E10,$01F9,$0019,$A000,$3800,$C000,$0000
	.dc.w	$82C6,$843B,$8155,$2ABF,$8880,$B080,$4080,$AA00
	.dc.w	$0260,$0E1F,$01FF,$001F,$A000,$3800,$C000,$0000
	.dc.w	$82D1,$842E,$8155,$2AAE,$0880,$B080,$4080,$AA00
	.dc.w	$033F,$0F00,$08FF,$0000,$2000,$3800,$C800,$0000
	.dc.w	$83B4,$850A,$8055,$2AAA,$6880,$D080,$1080,$AA00
	.dc.w	$0080,$0780,$047F,$0000,$C000,$F000,$1000,$0000
	.dc.w	$20EB,$A141,$A114,$0AAA,$A200,$4280,$0280,$A800
	.dc.w	$0000,$00FF,$0080,$0000,$0000,$8000,$8000,$0000
	.dc.w	$282A,$2814,$2814,$02AA,$8A00,$0A00,$0A00,$A000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$02A0,$0AA0,$0AA0,$000A,$A000,$A800,$A800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002A,$02AA,$02AA,$0000,$0000,$A000,$A000,$0000
eshipf:	.dc.w	13,10
	.dc.w	23,2
	.dc.w	$0080,$0A80,$0A80,$002A,$8000,$A800,$A800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0AA0,$280A,$2800,$02AA,$A800,$0A00,$0A00,$A000
	.dc.w	$0000,$003E,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2A1E,$A0FF,$A000,$0AAA,$8A00,$A280,$0280,$A800
	.dc.w	$00E3,$03E3,$001C,$0000,$8000,$E000,$0000,$0000
	.dc.w	$892E,$87A8,$8055,$2AA8,$E880,$7080,$0080,$2A00
	.dc.w	$0331,$070E,$00FF,$000E,$6000,$7000,$8000,$0000
	.dc.w	$AD6E,$87B1,$8055,$2AB5,$F280,$5880,$0080,$0A00
	.dc.w	$066F,$0E10,$01F9,$0019,$B000,$3800,$C000,$0000
	.dc.w	$2C6E,$06B9,$0155,$AABD,$B200,$3800,$4000,$2A80
	.dc.w	$0660,$0E1F,$01FF,$001F,$B000,$3800,$C000,$0000
	.dc.w	$2C7B,$06AE,$0155,$AAAE,$B200,$B800,$4000,$AA80
	.dc.w	$073F,$0F00,$00FF,$0000,$3000,$3800,$C000,$0000
	.dc.w	$A91E,$87AA,$8055,$2AAA,$C280,$F880,$0080,$AA00
	.dc.w	$0180,$0780,$007F,$0000,$C000,$F000,$0000,$0000
	.dc.w	$8A41,$81EB,$8014,$2AAA,$0A80,$E080,$0080,$AA00
	.dc.w	$003E,$00FF,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$2A80,$A03E,$A000,$0AAA,$2A00,$8280,$0280,$A800
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0AAA,$2800,$2800,$02AA,$A800,$0A00,$0A00,$A000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0A80,$0A80,$002A,$8000,$A800,$A800,$0000


*
*	CILLER EGYPT (KING TUT)
*
fship0:	.dc.w	2,1
	.dc.w	3,1
	.dc.w	$0000,$7000,$5000,$0000,$5000,$D800,$2000,$0000
	.dc.w	$0000,$5000,$0000,$0000
fship1:	.dc.w	3,1
	.dc.w	4,1
	.dc.w	$0000,$7C00,$0000,$0000,$5400,$D600,$2800,$0000
	.dc.w	$6C00,$6C00,$9200,$0000,$0000,$3800,$0000,$0000
fship2:	.dc.w	4,1
	.dc.w	5,1
	.dc.w	$1C00,$7F00,$4100,$0000,$4900,$C980,$B680,$0000
	.dc.w	$6300,$F780,$8880,$0000,$EB80,$E380,$1C00,$0000
	.dc.w	$0000,$3E00,$0000,$0000
fship3:	.dc.w	5,2
	.dc.w	6,1
	.dc.w	$0A00,$3F80,$0000,$0000,$1500,$75C0,$4A40,$0000
	.dc.w	$3580,$F5E0,$8A20,$0000,$5140,$DB60,$2E80,$0000
	.dc.w	$5540,$D160,$2E80,$0000,$0000,$1F00,$0000,$0000
fship4:	.dc.w	5,2
	.dc.w	7,1
	.dc.w	$0A00,$3F80,$0000,$0000,$0400,$2480,$1B00,$0000
	.dc.w	$3F80,$75C0,$0A00,$0000,$5140,$DB60,$2E80,$0000
	.dc.w	$2480,$FBE0,$8420,$0000,$9520,$9120,$6EC0,$0000
	.dc.w	$0000,$1F00,$0000,$0000
fship5:	.dc.w	6,3
	.dc.w	9,1
	.dc.w	$18C0,$3FE0,$0000,$0000,$0500,$3760,$28A0,$0000
	.dc.w	$1540,$7270,$0D80,$0000,$0D80,$FFF8,$8208,$0000
	.dc.w	$4A90,$DFD8,$2520,$0000,$1040,$FDF8,$C718,$0000
	.dc.w	$9248,$9048,$6FB0,$0000,$0500,$0F80,$0000,$0000
	.dc.w	$0000,$0500,$0000,$0000
fship6:	.dc.w	6,3
	.dc.w	10,1
	.dc.w	$1540,$3760,$0880,$0000,$0500,$3760,$28A0,$0000
	.dc.w	$3760,$7270,$0D80,$0000,$1AC0,$FFF8,$8508,$0000
	.dc.w	$4890,$DDD8,$3760,$0000,$1040,$F578,$AFA8,$0000
	.dc.w	$5250,$FDF8,$0200,$0000,$9248,$9048,$6FB0,$0000
	.dc.w	$0880,$1AC0,$0500,$0000,$0000,$0500,$0000,$0000
fship7:	.dc.w	7,3
	.dc.w	10,1
	.dc.w	$0820,$1930,$06C0,$0000,$0280,$1BB0,$1450,$0000
	.dc.w	$2548,$610C,$1EF0,$0000,$0920,$FFFE,$86C2,$0000
	.dc.w	$4444,$DEF6,$2BA8,$0000,$0820,$FABE,$97D2,$0000
	.dc.w	$2108,$FEFE,$1550,$0000,$9932,$9832,$67CC,$0000
	.dc.w	$0AA0,$1BB0,$0540,$0000,$0000,$0280,$0000,$0000
fship8:	.dc.w	8,4
	.dc.w	11,2
	.dc.w	$0490,$1CDC,$0320,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0E38,$1C9C,$1364,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0140,$3DDE,$0220,$0000,$0000,$0000,$0000,$0000
	.dc.w	$37F6,$72A7,$0D58,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0490,$FFFF,$AB6A,$0000,$0000,$8000,$8000,$0000
	.dc.w	$5005,$CD59,$37F6,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0220,$F94F,$EFFB,$0000,$0000,$8000,$8000,$0000
	.dc.w	$3086,$FF7F,$0FF8,$0000,$0000,$8000,$0000,$0000
	.dc.w	$F007,$9084,$6FFB,$0080,$8000,$8000,$0000,$0000
	.dc.w	$0550,$0DD8,$02A0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0140,$0000,$0000,$0000,$0000,$0000,$0000
fship9:	.dc.w	9,6
	.dc.w	14,2
	.dc.w	$02E8,$0EEE,$0110,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0358,$07FC,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0248,$1EEF,$1111,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0DB6,$3C47,$03B8,$0000,$0000,$8000,$0000,$0000
	.dc.w	$00A0,$7EEF,$5515,$0000,$0000,$C000,$4000,$0000
	.dc.w	$36ED,$F359,$0DB6,$0000,$8000,$E000,$0000,$0000
	.dc.w	$0404,$FFBF,$FBFB,$0000,$0000,$E000,$E000,$0000
	.dc.w	$5001,$CEAE,$37FD,$0000,$4000,$6000,$8000,$0000
	.dc.w	$0040,$FDB7,$EFFE,$0110,$0000,$E000,$E000,$0000
	.dc.w	$1843,$FFBF,$07FC,$0000,$0000,$E000,$0000,$0000
	.dc.w	$98E3,$F803,$67FC,$6040,$2000,$E000,$C000,$C000
	.dc.w	$0208,$064C,$01F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00A0,$00E0,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00A0,$0000,$0000,$0000,$0000,$0000,$0000
fshipa:	.dc.w	10,7
	.dc.w	15,2
	.dc.w	$0489,$0401,$03FE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$03AE,$07FF,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0306,$0F07,$00F8,$0000,$0000,$8000,$0000,$0000
	.dc.w	$1050,$1FAF,$0555,$0000,$4000,$C000,$0000,$0000
	.dc.w	$0D05,$3C71,$038E,$0000,$8000,$E000,$0000,$0000
	.dc.w	$0070,$7EFB,$3F8F,$0000,$0000,$F000,$E000,$0000
	.dc.w	$3653,$F38E,$0DFD,$0000,$6000,$7800,$8000,$0000
	.dc.w	$0401,$FF57,$FBFE,$0000,$0000,$F800,$F800,$0000
	.dc.w	$5104,$CF57,$36FB,$0000,$5000,$9800,$6000,$0000
	.dc.w	$0020,$FEDB,$EDFD,$0088,$0000,$F800,$B800,$0000
	.dc.w	$0C21,$FFDF,$03FE,$0000,$8000,$F800,$0000,$0000
	.dc.w	$0C71,$FC01,$63FE,$6020,$8000,$F800,$3000,$3000
	.dc.w	$028A,$0623,$01FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0050,$0070,$0020,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0050,$0000,$0000,$0000,$0000,$0000,$0000
fshipb:	.dc.w	11,8
	.dc.w	16,2
	.dc.w	$0244,$0200,$01FF,$0000,$8000,$8000,$0000,$0000
	.dc.w	$01D7,$03FF,$0028,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0400,$07FF,$00AA,$0000,$4000,$C000,$0000,$0000
	.dc.w	$0339,$0F01,$00FE,$0000,$8000,$E000,$0000,$0000
	.dc.w	$1028,$1FD7,$0FEF,$0000,$1000,$F000,$E000,$0000
	.dc.w	$0C82,$3C38,$03C7,$0000,$6000,$7800,$8000,$0000
	.dc.w	$0038,$7F7D,$3FC7,$0000,$0000,$FC00,$F800,$0000
	.dc.w	$3339,$F1D7,$0EEE,$0000,$9800,$1E00,$E000,$0000
	.dc.w	$0200,$FFAB,$FDFF,$0000,$8000,$FE00,$7E00,$0000
	.dc.w	$2882,$E7AB,$1B7D,$0000,$2800,$CE00,$B000,$0000
	.dc.w	$0010,$FF6D,$F6FE,$0044,$0000,$FE00,$DE00,$0000
	.dc.w	$0610,$FFEF,$01FF,$0000,$C000,$FE00,$0000,$0000
	.dc.w	$3638,$CE00,$31FF,$3010,$D800,$E600,$1800,$1800
	.dc.w	$0282,$0654,$01FF,$0044,$8000,$C000,$0000,$0000
	.dc.w	$0028,$0038,$0010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0028,$0000,$0000,$0000,$0000,$0000,$0000
fshipc:	.dc.w	12,8
	.dc.w	16,2
	.dc.w	$015D,$0322,$00FF,$0022,$4000,$6000,$8000,$0000
	.dc.w	$00EB,$01FF,$0014,$0000,$8000,$C000,$0000,$0000
	.dc.w	$0400,$07FF,$0255,$0000,$1000,$F000,$2000,$0000
	.dc.w	$0336,$0F08,$00FF,$0008,$6000,$7800,$8000,$0000
	.dc.w	$1022,$1FDD,$0FE3,$0000,$0400,$FC00,$F800,$0000
	.dc.w	$0C80,$3C3E,$03C1,$0000,$9800,$1E00,$E000,$0000
	.dc.w	$003E,$7F7F,$3FC1,$0000,$0000,$7F00,$FE00,$0000
	.dc.w	$333E,$F1DD,$0EE3,$0000,$6600,$C780,$B800,$0000
	.dc.w	$0200,$FFA2,$FDFF,$0000,$2000,$FF80,$DF80,$0000
	.dc.w	$2880,$E7E3,$1B7F,$0041,$8A00,$F380,$6C00,$0000
	.dc.w	$005D,$FFA2,$F6FF,$00C1,$0000,$FF80,$B780,$8000
	.dc.w	$061C,$FFE3,$01FF,$0000,$3000,$FF80,$C000,$0000
	.dc.w	$363E,$CE00,$31FF,$301C,$3600,$3980,$C600,$0600
	.dc.w	$0280,$0655,$01FF,$0041,$A000,$3000,$C000,$0000
	.dc.w	$002A,$003E,$0014,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$002A,$0000,$0000,$0000,$0000,$0000,$0000
fshipd:	.dc.w	13,9
	.dc.w	18,2
	.dc.w	$0160,$011F,$00FF,$003F,$D000,$1000,$E000,$8000
	.dc.w	$0040,$01EA,$003F,$0000,$4000,$F000,$8000,$0000
	.dc.w	$0015,$00FF,$002A,$0000,$0000,$E000,$8000,$0000
	.dc.w	$0400,$07FF,$032A,$0000,$0400,$FC00,$9800,$0000
	.dc.w	$0331,$0F0E,$00FF,$000E,$9800,$1E00,$E000,$0000
	.dc.w	$1020,$1FDF,$0FE0,$0000,$8100,$7F00,$FE00,$0000
	.dc.w	$0C80,$3C3F,$03E0,$0000,$2600,$8780,$F800,$0000
	.dc.w	$001F,$7F7F,$3FE0,$0000,$0000,$DFC0,$FF80,$0000
	.dc.w	$333F,$F1DF,$0EE0,$0000,$9980,$71E0,$EE00,$0000
	.dc.w	$0200,$FFB1,$FDFF,$0000,$0800,$BFE0,$F7E0,$0000
	.dc.w	$2880,$E7F1,$1B7F,$0020,$2280,$FCE0,$DB00,$8000
	.dc.w	$002E,$FFD1,$F6FF,$0060,$8000,$7FE0,$EDE0,$C000
	.dc.w	$060E,$FFF1,$01FF,$0000,$0C00,$FFE0,$F000,$0000
	.dc.w	$363F,$CE00,$31FF,$301F,$8D80,$0E60,$F180,$0180
	.dc.w	$0295,$066A,$01FF,$0060,$2800,$CC00,$F000,$C000
	.dc.w	$0000,$000A,$001F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0015,$001F,$000A,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0015,$0000,$0000,$0000,$0000,$0000,$0000
fshipe:	.dc.w	14,10
	.dc.w	19,2
	.dc.w	$015F,$0120,$00EF,$002F,$D400,$2400,$B800,$A000
	.dc.w	$008A,$0195,$007F,$0000,$8800,$4C00,$F000,$0000
	.dc.w	$0040,$00D5,$003F,$0000,$1000,$5800,$E000,$0000
	.dc.w	$006A,$03FF,$0015,$0000,$B000,$FE00,$4000,$0000
	.dc.w	$0400,$07FF,$0395,$0000,$0100,$FF00,$4E00,$0000
	.dc.w	$0338,$0F07,$00FF,$0007,$E600,$0780,$F800,$0000
	.dc.w	$1030,$1FCF,$0FF0,$0000,$6040,$9FC0,$7F80,$0000
	.dc.w	$0C80,$3C1F,$03F0,$0000,$0980,$C1E0,$7E00,$0000
	.dc.w	$000F,$7F3F,$3FF0,$0000,$8000,$E7F0,$7FE0,$0000
	.dc.w	$339F,$F1EF,$0E70,$0000,$CE60,$BC78,$7380,$0000
	.dc.w	$0300,$FFD8,$FCFF,$0000,$0600,$DFF8,$F9F8,$0000
	.dc.w	$2840,$E7F8,$19BF,$0010,$10A0,$FF38,$ECC0,$4000
	.dc.w	$0017,$FFE8,$F37F,$0030,$4000,$BFF8,$F678,$6000
	.dc.w	$0707,$FFF8,$00FF,$0000,$0700,$FFF8,$F800,$0000
	.dc.w	$371F,$CF00,$30FF,$300F,$C760,$0798,$F860,$8060
	.dc.w	$000A,$03F5,$03FF,$0000,$8000,$7E00,$FE00,$0000
	.dc.w	$0140,$0335,$00FF,$0030,$1400,$6600,$F800,$6000
	.dc.w	$000A,$000F,$0005,$0000,$8000,$8000,$0000,$0000
	.dc.w	$0000,$000A,$0000,$0000,$0000,$8000,$0000,$0000
fshipf:	.dc.w	15,11
	.dc.w	21,2
	.dc.w	$014F,$0130,$00F7,$0037,$E500,$1900,$DE00,$D800
	.dc.w	$0120,$011F,$00FF,$0015,$0900,$F100,$FE00,$5000
	.dc.w	$0095,$018A,$007F,$0000,$5200,$A300,$FC00,$0000
	.dc.w	$0040,$00CA,$003F,$0000,$0400,$A600,$F800,$0000
	.dc.w	$00B5,$03FF,$000A,$0000,$5A00,$FF80,$A000,$0000
	.dc.w	$0400,$07FF,$03CA,$0000,$0040,$FFC0,$A780,$0000
	.dc.w	$033F,$0F00,$00FF,$0007,$F980,$01E0,$FE00,$C000
	.dc.w	$1030,$1FCF,$0FF8,$0000,$1810,$E7F0,$3FE0,$0000
	.dc.w	$0C80,$3C1F,$03F8,$0000,$0260,$F078,$3F80,$0000
	.dc.w	$0007,$7F3F,$3FF8,$0000,$C000,$F9FC,$3FF8,$0000
	.dc.w	$338F,$F1F7,$0E78,$0000,$E398,$DF1E,$3CE0,$0000
	.dc.w	$0300,$FFEC,$FCFF,$0000,$0180,$6FFE,$FE7E,$0000
	.dc.w	$2820,$E7FC,$19DF,$0008,$0828,$7FCE,$F730,$2000
	.dc.w	$001B,$FFE4,$F3BF,$0018,$B000,$4FFE,$FB9E,$3000
	.dc.w	$0783,$FFFC,$007F,$0000,$83C0,$7FFE,$FC00,$0000
	.dc.w	$378F,$CF80,$307F,$3007,$E3D8,$03E6,$FC18,$C018
	.dc.w	$0000,$03FF,$03FF,$0005,$0000,$FF80,$FF80,$4000
	.dc.w	$014D,$0332,$00FF,$0038,$6500,$9980,$FE00,$3800
	.dc.w	$0000,$0002,$0007,$0000,$0000,$8000,$C000,$0000
	.dc.w	$0005,$0007,$0002,$0000,$4000,$C000,$8000,$0000
	.dc.w	$0000,$0005,$0000,$0000,$0000,$4000,$0000,$0000

*
*	VICTORY SHIP
*
uship0:	.dc.w	5,2
	.dc.w	5,1
	.dc.w	$0000,$60C0,$60C0,$0000,$64C0,$EEE0,$EEE0,$0000
	.dc.w	$7BC0,$FBE0,$FBE0,$0400,$64C0,$EEE0,$EEE0,$0000
	.dc.w	$0000,$60C0,$60C0,$0000
uship1:	.dc.w	7,2
	.dc.w	5,1
	.dc.w	$0000,$711C,$711C,$0000,$5394,$DAB6,$DAB6,$2108
	.dc.w	$739C,$C286,$C286,$3D78,$5394,$DAB6,$DAB6,$2108
	.dc.w	$0000,$711C,$711C,$0000
uship2:	.dc.w	8,4
	.dc.w	7,2
	.dc.w	$0000,$3006,$3006,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1144,$594D,$594D,$2082,$0000,$0000,$0000,$0000
	.dc.w	$594D,$DDDD,$DD5D,$2082,$0000,$8000,$8000,$0000
	.dc.w	$0DD8,$B5D6,$85D0,$7A2F,$0000,$8000,$8000,$0000
	.dc.w	$4A29,$FEBF,$CEB9,$3146,$0000,$8000,$8000,$0000
	.dc.w	$31C6,$79CF,$79CF,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$3006,$3006,$0000,$0000,$0000,$0000,$0000
uship3:	.dc.w	9,5
	.dc.w	8,2
	.dc.w	$0000,$3001,$3001,$0000,$0000,$8000,$8000,$0000
	.dc.w	$3001,$7803,$7803,$0000,$8000,$C000,$C000,$0000
	.dc.w	$58A3,$DCE7,$DCA7,$2040,$4000,$6000,$6000,$8000
	.dc.w	$18E3,$9CE7,$9CA7,$6000,$0000,$2000,$2000,$C000
	.dc.w	$0EEE,$B6ED,$86EC,$7913,$0000,$A000,$2000,$C000
	.dc.w	$4B1A,$FF5F,$CF5E,$30A1,$4000,$E000,$6000,$8000
	.dc.w	$30A1,$78A3,$78A3,$0040,$8000,$C000,$C000,$0000
	.dc.w	$0000,$3001,$3001,$0000,$0000,$8000,$8000,$0000
uship4:	.dc.w	10,6
	.dc.w	8,2
	.dc.w	$0000,$3800,$3800,$0000,$0000,$E000,$E000,$0000
	.dc.w	$2800,$6C01,$6C01,$1000,$A000,$B000,$B000,$4000
	.dc.w	$7C51,$EE73,$EE53,$1020,$F000,$B800,$B800,$4000
	.dc.w	$7C51,$EE73,$EE53,$1000,$F000,$B800,$B800,$4000
	.dc.w	$5777,$FB76,$C376,$3C89,$5000,$F800,$1800,$E000
	.dc.w	$44A9,$FEAB,$C6AB,$3850,$1000,$F800,$1800,$E000
	.dc.w	$398C,$6DAD,$6DAD,$1050,$E000,$B000,$B000,$4000
	.dc.w	$00D8,$38D8,$38D8,$0020,$0000,$E000,$E000,$0000
uship5:	.dc.w	11,7
	.dc.w	10,2
	.dc.w	$0000,$3800,$3800,$0000,$0000,$3800,$3800,$0000
	.dc.w	$3800,$7C00,$7C00,$0000,$2800,$6C00,$6C00,$1000
	.dc.w	$2800,$AA00,$AA00,$5400,$2800,$AA00,$AA00,$5400
	.dc.w	$D46C,$EE6C,$EE44,$1028,$5600,$EE00,$EE00,$1000
	.dc.w	$FE6C,$EE7C,$EE54,$1000,$FE00,$EE00,$EE00,$1000
	.dc.w	$D76D,$FB55,$C355,$3CAA,$D600,$BE00,$8600,$7800
	.dc.w	$5482,$FEBA,$C692,$386C,$5400,$FE00,$C600,$3800
	.dc.w	$0583,$55BB,$45BB,$3844,$4000,$5400,$4400,$3800
	.dc.w	$1082,$38BA,$38BA,$0044,$1000,$3800,$3800,$0000
	.dc.w	$0000,$0000,$0000,$0038,$0000,$0000,$0000,$0000
uship6:	.dc.w	12,8
	.dc.w	11,2
	.dc.w	$0000,$3800,$3800,$0000,$0000,$0E00,$0E00,$0000
	.dc.w	$3800,$7C00,$7C00,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$0000,$AA00,$AA00,$5400,$0000,$2A80,$2A80,$1500
	.dc.w	$D636,$EE36,$EE22,$1014,$3580,$3B80,$3B80,$0400
	.dc.w	$4636,$7C3E,$6C2A,$9200,$3100,$1F00,$1B00,$2480
	.dc.w	$FBB6,$BDAA,$81AA,$7E55,$EE80,$DF80,$C080,$3F00
	.dc.w	$AA00,$921C,$8208,$7C36,$2A80,$2480,$2080,$1F00
	.dc.w	$54C1,$C6DD,$C69C,$3863,$9500,$B180,$B180,$0E00
	.dc.w	$387F,$7C5D,$7C5D,$0022,$0E00,$1F00,$1F00,$0000
	.dc.w	$0041,$385D,$385D,$0022,$0000,$0E00,$0E00,$0000
	.dc.w	$0000,$0000,$0000,$001C,$0000,$0000,$0000,$0000
uship7:	.dc.w	15,9
	.dc.w	13,2
	.dc.w	$0000,$1C00,$1C00,$0000,$0000,$0070,$0070,$0000
	.dc.w	$1400,$3600,$3600,$0800,$0050,$00D8,$00D8,$0020
	.dc.w	$2A00,$6300,$6300,$1C00,$00A8,$018C,$018C,$0070
	.dc.w	$6B00,$F780,$F780,$0800,$01AC,$03DE,$03DE,$0020
	.dc.w	$4906,$FF86,$F784,$0802,$C124,$C3FE,$43DE,$8020
	.dc.w	$0804,$B687,$B685,$4100,$4020,$C2DA,$42DA,$0104
	.dc.w	$5DE6,$B6E5,$80E5,$771A,$CF74,$4EDA,$4E02,$B1DC
	.dc.w	$5508,$C98B,$C189,$3E06,$2154,$A326,$2306,$C0F8
	.dc.w	$5530,$C983,$C183,$3E6C,$1954,$8326,$8306,$6CF8
	.dc.w	$2AAB,$639B,$6383,$1C7C,$AAA8,$B38C,$838C,$7C70
	.dc.w	$1C14,$3E13,$3E10,$000C,$5070,$90F8,$10F8,$6000
	.dc.w	$0010,$1C13,$1C13,$000C,$1000,$9070,$9070,$6000
	.dc.w	$0000,$0000,$0000,$0003,$0000,$0000,$0000,$8000
uship8:	.dc.w	17,9
	.dc.w	15,3
	.dc.w	$0000,$3E00,$3E00,$0000,$0000,$000F,$000F,$0000
	.dc.w	$0000,$8000,$8000,$0000,$2200,$6300,$6300,$1C00
	.dc.w	$0008,$0018,$0018,$0007,$8000,$C000,$C000,$0000
	.dc.w	$5D00,$D580,$D580,$2A00,$0017,$0035,$0035,$000A
	.dc.w	$4000,$6000,$6000,$8000,$2A00,$B680,$B680,$4900
	.dc.w	$000A,$002D,$002D,$0012,$8000,$A000,$A000,$4000
	.dc.w	$0803,$BE82,$B682,$4901,$B812,$A82F,$082D,$B012
	.dc.w	$4000,$A000,$A000,$4000,$4882,$B683,$B683,$4100
	.dc.w	$0832,$F82D,$582D,$0010,$4000,$A000,$A000,$4000
	.dc.w	$5DF2,$B6F3,$80F3,$770C,$A9F7,$59ED,$59E0,$A61D
	.dc.w	$4000,$A000,$2000,$C000,$5D85,$B684,$8084,$7703
	.dc.w	$5437,$E42D,$4420,$B81D,$4000,$A000,$2000,$C000
	.dc.w	$6319,$9C81,$8081,$7F36,$1318,$F027,$F020,$0D9F
	.dc.w	$C000,$2000,$2000,$C000,$5DBE,$C18C,$C180,$3E7D
	.dc.w	$0FB7,$E630,$0030,$17CF,$4000,$6000,$6000,$8000
	.dc.w	$6357,$E3CF,$E3C1,$1C3E,$BD58,$FE78,$B078,$0F87
	.dc.w	$C000,$E000,$E000,$0000,$3E0B,$7F08,$7F08,$0007
	.dc.w	$1A0F,$E21F,$021F,$1C00,$8000,$C000,$C000,$0000
	.dc.w	$0008,$3E09,$3E08,$0007,$0200,$F20F,$E20F,$1C00
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0001,$0001,$0002
	.dc.w	$0000,$1000,$1000,$E800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0002,$0002,$0000,$0000,$E800,$E800,$0000
	.dc.w	$0000,$0000,$0000,$0000
uship9:	.dc.w	21,10
	.dc.w	16,3
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$3800,$3800,$0000,$0000,$3180,$3180,$0E00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$C600,$C600,$3800
	.dc.w	$2E80,$60C0,$60C0,$1F00,$0000,$0001,$0001,$0000
	.dc.w	$BA00,$8300,$8300,$7C00,$1500,$4A40,$4A40,$3580
	.dc.w	$0000,$0001,$0001,$0000,$5400,$2900,$2900,$D600
	.dc.w	$64C0,$DF60,$DB60,$2480,$7701,$5503,$4103,$3600
	.dc.w	$9300,$7D80,$6D80,$9200,$2480,$BBA0,$BBA0,$4040
	.dc.w	$4100,$7F02,$6B02,$0001,$9200,$EE80,$EE80,$0100
	.dc.w	$0400,$BBA0,$BBA0,$4040,$2200,$1C02,$0802,$6301
	.dc.w	$1000,$EE80,$EE80,$0100,$2EBC,$9B3C,$803C,$7BC3
	.dc.w	$D59E,$AA9E,$AA9E,$5561,$BA00,$6C80,$0080,$EF00
	.dc.w	$2E81,$9B21,$8021,$7BC0,$2A40,$5D42,$0842,$F781
	.dc.w	$BA00,$6C80,$0080,$EF00,$71C6,$CE60,$C060,$3F8D
	.dc.w	$6331,$7F03,$3E03,$C1D8,$C700,$3980,$0180,$FE00
	.dc.w	$4E2F,$C063,$C060,$3F9F,$80FA,$1C63,$0003,$637C
	.dc.w	$3900,$0180,$0180,$FE00,$2095,$60D3,$60D0,$1F0F
	.dc.w	$F7D4,$FFE5,$7705,$80F8,$8200,$8300,$8300,$7C00
	.dc.w	$1F02,$3F82,$3F82,$0001,$E3A0,$5D20,$0020,$E3C0
	.dc.w	$7C00,$FE00,$FE00,$0000,$0002,$1F02,$1F02,$0001
	.dc.w	$4120,$7F20,$1C20,$E3C0,$0000,$7C00,$7C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$DD80,$A280,$A280,$5D00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5D00,$5D00,$5D00,$0000,$0000,$0000,$0000,$0000
ushipa:	.dc.w	21,11
	.dc.w	18,3
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$3180,$3180,$0E00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$3180,$3180,$0E00
	.dc.w	$2E80,$60C0,$60C0,$1F00,$0000,$0000,$0000,$0000
	.dc.w	$2E80,$60C0,$60C0,$1F00,$1500,$4A40,$4A40,$3580
	.dc.w	$0000,$0000,$0000,$0000,$1500,$4A40,$4A40,$3580
	.dc.w	$64C0,$DF60,$DB60,$2480,$5B40,$4A40,$4040,$3B80
	.dc.w	$64C0,$DF60,$DB60,$2480,$0400,$9B20,$9B20,$60C0
	.dc.w	$0A00,$3F80,$3580,$4040,$2480,$BBA0,$BBA0,$4040
	.dc.w	$0400,$BBA0,$BBA0,$4040,$1B00,$0E00,$0400,$71C0
	.dc.w	$0400,$BBA0,$BBA0,$4040,$043C,$BBBC,$BBBC,$4043
	.dc.w	$2A87,$3F87,$3F87,$C078,$8400,$BBA0,$BBA0,$4040
	.dc.w	$2E8C,$9B3C,$803C,$7BC3,$7BC6,$5547,$5547,$AAB8
	.dc.w	$2E80,$9B20,$8020,$7BC0,$2E80,$9B20,$8020,$7BC0
	.dc.w	$9520,$AEA0,$8420,$7BC0,$2E80,$9B20,$8020,$7BC0
	.dc.w	$51C5,$CE62,$C060,$3F8E,$3194,$3F88,$1F00,$E0EE
	.dc.w	$7140,$CE60,$C060,$3F80,$0EAD,$40E3,$40E0,$3F1F
	.dc.w	$C076,$8E38,$0000,$B1BF,$AE00,$E040,$E040,$1F80
	.dc.w	$2116,$6191,$6190,$1E0F,$FBED,$FFF1,$3B81,$C07E
	.dc.w	$1080,$30C0,$30C0,$0F00,$1E01,$3F81,$3F81,$0000
	.dc.w	$71D0,$2E90,$0010,$F1E0,$0F00,$3F80,$3F80,$0000
	.dc.w	$0001,$1F01,$1F01,$0000,$2090,$3F90,$0E10,$F1E0
	.dc.w	$0000,$1F00,$1F00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8E20,$BFA0,$8E20,$71C0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6EC0,$5140,$5140,$2E80
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2E80,$2E80,$2E80,$0000,$0000,$0000,$0000,$0000
ushipb:	.dc.w	23,12
	.dc.w	20,3
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01C0,$01C0,$0000,$0700,$1FC0,$1FC0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$01C0,$07F0,$07F0,$0000
	.dc.w	$18C0,$38E0,$38E0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$0630,$0E38,$0E38,$01C0,$0720,$6030,$6030,$1FC0
	.dc.w	$0000,$0000,$0000,$0000,$09C0,$180C,$180C,$07F0
	.dc.w	$2AA0,$6530,$6430,$1AC0,$0000,$0000,$0000,$0000
	.dc.w	$0AA8,$194C,$190C,$06B0,$1270,$4FB8,$4C38,$3240
	.dc.w	$16D0,$1290,$1010,$0EE0,$1C90,$3BE4,$3B04,$0498
	.dc.w	$5250,$DDD8,$DC58,$2020,$1010,$0D60,$0FE0,$1010
	.dc.w	$1494,$3776,$3716,$0808,$4210,$DDD8,$DC18,$2020
	.dc.w	$1450,$0100,$0380,$1C70,$1084,$3776,$3706,$0808
	.dc.w	$421E,$DDDE,$DC1E,$2021,$1AB0,$0FE0,$0FE0,$F01F
	.dc.w	$F084,$F776,$F706,$0808,$5752,$CD9E,$C01E,$3DE1
	.dc.w	$1EF0,$1550,$1550,$EAAF,$95D4,$F366,$F006,$0F78
	.dc.w	$5750,$CD90,$C010,$3DE0,$2548,$2BA8,$2108,$1EF0
	.dc.w	$15D4,$1366,$1006,$0F78,$18E2,$4731,$4030,$3FC7
	.dc.w	$CC66,$8FE3,$07C0,$B83B,$8E30,$19C4,$1804,$C7F8
	.dc.w	$2FA0,$6020,$6020,$1FC0,$2548,$2FE8,$26C8,$1830
	.dc.w	$0BE8,$080C,$080C,$07F0,$1756,$3071,$3070,$0F8F
	.dc.w	$739C,$E38F,$0000,$EC6F,$D5D0,$1C18,$1C18,$E3E0
	.dc.w	$188B,$38C8,$38C8,$0707,$3FF9,$FFFE,$0EE0,$F01F
	.dc.w	$A230,$2638,$2638,$C1C0,$0F00,$1F80,$1F80,$0000
	.dc.w	$5FF4,$4BA4,$4004,$3C78,$01E0,$03F0,$03F0,$0000
	.dc.w	$0000,$0700,$0700,$0000,$4824,$4FE4,$4384,$3C78
	.dc.w	$0000,$01C0,$01C0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2388,$2FE8,$2388,$1C70,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1BB0,$1450,$1450,$0BA0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0BA0,$0BA0,$0BA0,$0000,$0000,$0000,$0000,$0000
ushipc:	.dc.w	25,13
	.dc.w	22,4
	.dc.w	$0000,$0F80,$0F80,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$003E,$003E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0700,$1FC0,$1FC0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$001C,$007F,$007F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$18C0,$38E0,$38E0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$0063,$00E3,$00E3,$001C,$0000,$8000,$8000,$0000
	.dc.w	$1760,$3070,$3070,$0F80,$0000,$0000,$0000,$0000
	.dc.w	$00DD,$01C1,$01C1,$003E,$0000,$8000,$8000,$0000
	.dc.w	$0BA0,$6530,$6030,$1AC0,$0000,$0000,$0000,$0000
	.dc.w	$00AE,$0194,$0180,$006B,$0000,$C000,$C000,$0000
	.dc.w	$39D0,$6718,$6018,$1AE0,$01B0,$04A4,$0000,$07BC
	.dc.w	$0167,$031C,$0300,$00EB,$8000,$C000,$C000,$0000
	.dc.w	$33D0,$6F98,$6018,$1260,$01B0,$04A4,$0000,$07BC
	.dc.w	$014F,$033E,$0300,$00C9,$8000,$C000,$C000,$0000
	.dc.w	$53E8,$CD88,$C008,$3070,$00A0,$075C,$03F8,$0404
	.dc.w	$02CF,$0236,$0200,$01C1,$4000,$6000,$6000,$8000
	.dc.w	$43E8,$DDC8,$C008,$2030,$01B0,$0444,$00E0,$071C
	.dc.w	$028F,$0277,$0200,$0180,$4000,$6000,$6000,$8000
	.dc.w	$43EF,$DDCF,$C00F,$2030,$02A8,$07FC,$03F8,$FC07
	.dc.w	$1E8F,$1E77,$1E00,$E180,$4000,$6000,$6000,$8000
	.dc.w	$5769,$CD8F,$C00F,$3DF0,$0BBA,$0952,$0952,$F6AD
	.dc.w	$12DD,$1E36,$1E00,$E1F7,$4000,$6000,$6000,$8000
	.dc.w	$5768,$CD88,$C008,$3DF0,$1515,$12A9,$1001,$0FFE
	.dc.w	$02DD,$0236,$0200,$01F7,$4000,$6000,$6000,$8000
	.dc.w	$38D1,$6718,$6018,$1FE3,$671C,$C3F8,$01F0,$DE0F
	.dc.w	$D163,$631C,$0300,$78FF,$8000,$C000,$C000,$0000
	.dc.w	$2FA0,$6030,$6030,$1FC0,$1515,$13B9,$11F1,$0E0E
	.dc.w	$00BE,$0180,$0180,$007F,$8000,$C000,$C000,$0000
	.dc.w	$176B,$3078,$3078,$0F87,$3C07,$F001,$00E0,$F319
	.dc.w	$9ADD,$E3C1,$03C1,$FC3E,$0000,$8000,$8000,$0000
	.dc.w	$18C5,$38E4,$38E4,$0703,$9F1F,$7BBB,$03F8,$F803
	.dc.w	$3463,$C4E3,$04E3,$F81C,$0000,$8000,$8000,$0000
	.dc.w	$0700,$1FC0,$1FC0,$0000,$2B1A,$260C,$20E0,$1F1F
	.dc.w	$801C,$807F,$807F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$260C,$23F8,$20E0,$1F1F
	.dc.w	$8000,$801C,$801C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$14E5,$13F9,$10E1,$0F1E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0AEA,$0912,$0912,$06EC
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0404,$0514,$0514,$02E8
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$02E8,$02E8,$02E8,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
ushipd:	.dc.w	26,13
	.dc.w	23,4
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0007,$0007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0700,$1FC0,$1FC0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$001F,$001F,$0000,$0000,$C000,$C000,$0000
	.dc.w	$18C0,$38E0,$38E0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$0018,$0038,$0038,$0007,$C000,$E000,$E000,$0000
	.dc.w	$1760,$3070,$3070,$0F80,$0000,$0000,$0000,$0000
	.dc.w	$0037,$0070,$0070,$000F,$4000,$6000,$6000,$8000
	.dc.w	$0EA0,$6430,$6130,$1AC0,$0000,$0000,$0000,$0000
	.dc.w	$002E,$0064,$0061,$001A,$A000,$3000,$3000,$C000
	.dc.w	$3CD0,$6618,$6118,$1AE0,$02DA,$0252,$0000,$03DE
	.dc.w	$005C,$00C6,$00C1,$003A,$E000,$3000,$3000,$C000
	.dc.w	$7E50,$6E18,$6198,$1260,$02DA,$0252,$0000,$03DE
	.dc.w	$005E,$00CE,$00C1,$0032,$7000,$3000,$B000,$4000
	.dc.w	$5E68,$CC08,$C188,$3070,$0202,$03FE,$01FC,$0252
	.dc.w	$00BE,$008C,$0081,$0070,$5000,$1800,$9800,$6000
	.dc.w	$5E28,$DC08,$C1C8,$2030,$028A,$0272,$0070,$03DE
	.dc.w	$00BE,$009C,$0081,$0060,$1000,$1800,$D800,$2000
	.dc.w	$5E29,$DC0F,$C1CF,$2030,$8356,$83FE,$81FC,$7E03
	.dc.w	$0CBE,$0F9C,$0F81,$F060,$1000,$1800,$D800,$2000
	.dc.w	$5E28,$DC08,$C1C8,$2037,$7A8A,$0623,$0222,$FDDD
	.dc.w	$F0BE,$009C,$0081,$FF60,$1000,$1800,$D800,$2000
	.dc.w	$5769,$CD8F,$C00F,$3DF0,$85DD,$84A9,$84A9,$7B56
	.dc.w	$0CB7,$0F8D,$0F80,$F07D,$5000,$9800,$1800,$E000
	.dc.w	$5768,$CD88,$C008,$3DF0,$0A8A,$0954,$0800,$07FF
	.dc.w	$80B7,$808D,$8080,$007D,$5000,$9800,$1800,$E000
	.dc.w	$38D2,$671A,$601A,$1FE1,$B38E,$61FC,$00F8,$EF07
	.dc.w	$6A58,$32C7,$02C0,$BC3F,$E000,$3000,$3000,$C000
	.dc.w	$2FA0,$6030,$6030,$1FC0,$0AAA,$09DC,$08F8,$0707
	.dc.w	$802F,$8060,$8060,$001F,$A000,$3000,$3000,$C000
	.dc.w	$0729,$2038,$2038,$1FC7,$9E73,$7800,$0070,$F98C
	.dc.w	$CCA7,$F0E0,$00E0,$FF1F,$0000,$2000,$2000,$C000
	.dc.w	$08C4,$38E4,$38E4,$0703,$CFAF,$3DDD,$01FC,$FC01
	.dc.w	$9918,$E138,$0138,$FE07,$8000,$E000,$E000,$0000
	.dc.w	$0700,$1FC0,$1FC0,$0000,$15FD,$1306,$1070,$0F8F
	.dc.w	$4007,$401F,$401F,$8000,$0000,$C000,$C000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$1306,$11FC,$1070,$0F8F
	.dc.w	$4000,$4007,$4007,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0A72,$09FC,$0870,$078F
	.dc.w	$8000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0575,$0489,$0489,$0376
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0202,$028A,$028A,$0174
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0174,$0174,$0174,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
ushipe:	.dc.w	29,13
	.dc.w	24,4
	.dc.w	$0000,$0380,$0380,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$3800,$3800,$0000
	.dc.w	$0380,$0FE0,$0FE0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$3800,$FE00,$FE00,$0000
	.dc.w	$0C60,$1C70,$1C70,$0380,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$C600,$C700,$C700,$3800
	.dc.w	$1390,$3018,$3018,$0FE0,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$3900,$0180,$0180,$FE00
	.dc.w	$15D0,$3018,$3298,$0D60,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$5D00,$0180,$2980,$D600
	.dc.w	$2CE8,$610C,$628C,$1D70,$00DB,$004A,$0040,$003B
	.dc.w	$6002,$4006,$4006,$8001,$CE80,$10C0,$28C0,$D700
	.dc.w	$29E8,$610C,$66CC,$1930,$00DB,$004A,$0040,$003B
	.dc.w	$6002,$4006,$4006,$8001,$9E80,$10C0,$6CC0,$9300
	.dc.w	$59F4,$C006,$C6C6,$3838,$008A,$0075,$007F,$000A
	.dc.w	$2005,$C00C,$C00C,$0003,$9F40,$0060,$6C60,$8380
	.dc.w	$59D4,$C806,$C6E6,$3018,$00DB,$0044,$004E,$003B
	.dc.w	$6005,$400C,$400C,$8003,$9D40,$8060,$6E60,$0180
	.dc.w	$59D4,$C807,$C6E7,$3018,$60EA,$E07F,$E07F,$1F00
	.dc.w	$E0C5,$C0FC,$C0FC,$1F03,$9D40,$8060,$6E60,$0180
	.dc.w	$59D4,$C806,$C6E6,$3019,$1E91,$0184,$0084,$FF7B
	.dc.w	$2F05,$300C,$200C,$DFF3,$9D40,$8060,$6E60,$0180
	.dc.w	$5BB4,$C6C7,$C007,$3EF8,$617B,$E115,$E115,$1EEA
	.dc.w	$D0C5,$10FC,$10FC,$EF03,$BB40,$6C60,$0060,$EF80
	.dc.w	$5BB4,$C6C6,$C006,$3EF8,$02D1,$022E,$0204,$01FB
	.dc.w	$6805,$880C,$080C,$F003,$BB40,$6C60,$0060,$EF80
	.dc.w	$2D68,$638C,$600C,$1FF0,$577F,$4CFF,$4011,$3DEE
	.dc.w	$DD42,$E646,$0046,$F781,$D680,$38C0,$00C0,$FF00
	.dc.w	$2C68,$638C,$600C,$1FF0,$ACB1,$987F,$801F,$7BE0
	.dc.w	$A6A2,$C326,$0026,$FBC1,$C680,$38C0,$00C0,$FF00
	.dc.w	$17D0,$3018,$3018,$0FE0,$02D1,$023F,$021F,$01E4
	.dc.w	$6801,$8803,$0803,$F000,$7D00,$0180,$0180,$FE00
	.dc.w	$1BB6,$383E,$383E,$07C1,$6780,$1E0E,$000E,$FE7F
	.dc.w	$3CCD,$0F0F,$000F,$CFF0,$BB00,$8380,$8380,$7C00
	.dc.w	$0C61,$1C71,$1C71,$0380,$33F1,$0F3F,$003F,$FF04
	.dc.w	$F990,$9E11,$8011,$1FE0,$C600,$C700,$C700,$3800
	.dc.w	$0380,$0FE0,$0FE0,$0000,$0571,$04EE,$040E,$03FF
	.dc.w	$D400,$E400,$0400,$F800,$3800,$FE00,$FE00,$0000
	.dc.w	$0000,$0380,$0380,$0000,$04A0,$047F,$040E,$03F1
	.dc.w	$A400,$C400,$0400,$F800,$0000,$3800,$3800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$02CE,$023F,$020E,$01F1
	.dc.w	$6800,$8800,$0800,$F000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$016E,$0111,$0111,$00EE
	.dc.w	$D000,$1000,$1000,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0080,$0091,$0091,$006E
	.dc.w	$2000,$2000,$2000,$C000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$006E,$006E,$006E,$0000
	.dc.w	$C000,$C000,$C000,$0000,$0000,$0000,$0000,$0000
ushipf:	.dc.w	30,13
	.dc.w	25,4
	.dc.w	$0000,$07C0,$07C0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1F00,$1F00,$0000
	.dc.w	$0380,$0FE0,$0FE0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0E00,$3F80,$3F80,$0000
	.dc.w	$0C60,$1C70,$1C70,$0380,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$3180,$71C0,$71C0,$0E00
	.dc.w	$1BB0,$3838,$3838,$07C0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6EC0,$E0E0,$E0E0,$1F00
	.dc.w	$1750,$3098,$3298,$0DE0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$5D40,$C260,$CA60,$3780
	.dc.w	$2E28,$61CC,$66CC,$19F0,$006D,$0025,$0020,$001D
	.dc.w	$B000,$2001,$2001,$C000,$B8A0,$8730,$9B30,$67C0
	.dc.w	$2F28,$61CC,$66CC,$19F0,$006D,$0025,$0020,$001D
	.dc.w	$B000,$2001,$2001,$C000,$BCA0,$8730,$9B30,$67C0
	.dc.w	$5F34,$C0C6,$CEE6,$30D8,$0045,$003A,$003A,$0000
	.dc.w	$1001,$E003,$E003,$0000,$7CD0,$0318,$3B98,$C360
	.dc.w	$4F24,$C0C6,$DEF6,$20C8,$006D,$0022,$0022,$0018
	.dc.w	$B001,$2003,$2003,$C000,$3C90,$0318,$7BD8,$8320
	.dc.w	$4F24,$C0C7,$DEF7,$20C8,$7075,$F03F,$F03F,$0F80
	.dc.w	$7071,$E07F,$E07F,$0F80,$3C90,$0318,$7BD8,$8320
	.dc.w	$4F25,$C0C7,$DEF7,$20C8,$0F48,$00C2,$0042,$FFBD
	.dc.w	$9785,$1807,$1007,$EFF8,$3C90,$0318,$7BD8,$8320
	.dc.w	$5BB4,$C6C7,$C007,$3EF8,$70BD,$F08A,$F08A,$0F75
	.dc.w	$E871,$887F,$887F,$7780,$6ED0,$1B18,$0018,$FBE0
	.dc.w	$5BB4,$C6C6,$C006,$3EF8,$0168,$0117,$0102,$00FD
	.dc.w	$B401,$4403,$0403,$F800,$6ED0,$1B18,$0018,$FBE0
	.dc.w	$5BB4,$C6C6,$C006,$3EF8,$15D5,$1337,$1002,$0F7D
	.dc.w	$5D41,$6643,$0043,$F780,$6ED0,$1B18,$0018,$FBE0
	.dc.w	$2D68,$638C,$600C,$1FF0,$2BBF,$2678,$2008,$1EF0
	.dc.w	$EEA0,$F321,$8021,$7BC0,$B5A0,$8E30,$8030,$7FC0
	.dc.w	$2C68,$638C,$600C,$1FF0,$5658,$4C3F,$400F,$3DF0
	.dc.w	$D350,$E191,$8011,$7DE0,$B1A0,$8E30,$8030,$7FC0
	.dc.w	$17D0,$3018,$3018,$0FE0,$016A,$011D,$010F,$00F2
	.dc.w	$B400,$C400,$8400,$7800,$5F40,$C060,$C060,$3F80
	.dc.w	$1BB7,$383F,$383F,$07C0,$33C7,$0F00,$0007,$FF3F
	.dc.w	$1E67,$0787,$0007,$E7F8,$6EC0,$E0E0,$E0E0,$1F00
	.dc.w	$0C61,$1C71,$1C71,$0380,$99FA,$879D,$801F,$7F82
	.dc.w	$FCCC,$CF0C,$C00C,$0FF0,$3180,$71C0,$71C0,$0E00
	.dc.w	$0380,$0FE0,$0FE0,$0000,$02BF,$0270,$0207,$01FF
	.dc.w	$EA00,$7200,$0200,$FC00,$0E00,$3F80,$3F80,$0000
	.dc.w	$0000,$03C0,$03C0,$0000,$0250,$023F,$0207,$01F8
	.dc.w	$5200,$E200,$0200,$FC00,$0000,$0F00,$0F00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0167,$011F,$0107,$00F8
	.dc.w	$3400,$C400,$0400,$F800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00B7,$0088,$0088,$0077
	.dc.w	$6800,$8800,$8800,$7000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0040,$0048,$0048,$0037
	.dc.w	$1000,$9000,$9000,$6000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0037,$0037,$0037,$0000
	.dc.w	$6000,$6000,$6000,$0000,$0000,$0000,$0000,$0000

	.end
