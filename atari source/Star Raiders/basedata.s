*
*	BASEDATA.S	ST Star-Raiders STARBASE Image Data
*

*
*	PUBLIC SYMBOLS
*
	.globl	base00
	.globl	base01
	.globl	base02
	.globl	base03
	.globl	base04
	.globl	base05
	.globl	base06
	.globl	base07
	.globl	base10
	.globl	base11
	.globl	base12
	.globl	base13
	.globl	base14
	.globl	base15
	.globl	base16
	.globl	base17
	.globl	base20
	.globl	base21
	.globl	base22
	.globl	base23
	.globl	base24
	.globl	base25
	.globl	base26
	.globl	base27
	.globl	base30
	.globl	base31
	.globl	base32
	.globl	base33
	.globl	base34
	.globl	base35
	.globl	base36
	.globl	base37
	.globl	base40
	.globl	base41
	.globl	base42
	.globl	base43
	.globl	base44
	.globl	base45
	.globl	base46
	.globl	base47
	.globl	base50
	.globl	base51
	.globl	base52
	.globl	base53
	.globl	base54
	.globl	base55
	.globl	base56
	.globl	base57
	.globl	base60
	.globl	base61
	.globl	base62
	.globl	base63
	.globl	base64
	.globl	base65
	.globl	base66
	.globl	base67
	.globl	base70
	.globl	base71
	.globl	base72
	.globl	base73
	.globl	base74
	.globl	base75
	.globl	base76
	.globl	base77

*
*	STARBASE Image data
*		Xoffset,Yoffset (pixels)
*		Height (lines), Width (words)
*		Image_Data
*
*	        Each BASE Having EIGHT Perspective Depths
*

	.data
	.even

base00:		* StarBase (Perspective:0 - Animation:0)
	.dc.w	47,12
	.dc.w	24,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0005,$000C,$000C,$0003,$4000,$6000,$6000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0025,$0063,$0060,$001F,$4800,$8C00,$0C00,$F000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0050,$00DF,$00D7,$0020,$1400,$F600,$9600,$0800
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0087,$01BF,$019F,$0040,$0200,$FB00,$C300,$0400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0380,$0380,$0000
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0158,$0378,$0378,$0087,$C500,$FD80,$F580,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0380,$07C0,$07C0,$0000
	.dc.w	$0880,$18C0,$18C0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$06B7,$0670,$0670,$018F,$66C0,$78C0,$70C0,$8F00
	.dc.w	$0000,$0000,$0000,$0000,$0440,$0C60,$0C60,$0380
	.dc.w	$1040,$3060,$3060,$0F80,$0000,$0000,$0000,$0000
	.dc.w	$0CAF,$0C60,$0C60,$039F,$A660,$3860,$3060,$CB80
	.dc.w	$0000,$0000,$0000,$0000,$0820,$1830,$1830,$07C0
	.dc.w	$2720,$6030,$6030,$1FC0,$0000,$0000,$0000,$0000
	.dc.w	$0058,$03C7,$03C0,$003F,$D000,$1F80,$1F80,$E000
	.dc.w	$0000,$0000,$0000,$0000,$1390,$3018,$3018,$0FE0
	.dc.w	$2520,$6230,$6030,$1FC0,$0000,$0000,$0000,$0000
	.dc.w	$0C5A,$0CC7,$0CC0,$033F,$D660,$1860,$1860,$E780
	.dc.w	$0000,$0000,$0000,$0000,$1290,$3118,$3018,$0FE0
	.dc.w	$4A90,$C718,$C018,$3FE0,$03E0,$03FF,$0000,$03FF
	.dc.w	$F8B7,$018D,$0180,$FE7D,$683E,$8C01,$0C00,$F3FF
	.dc.w	$0F80,$FF80,$0000,$FF80,$2548,$638C,$600C,$1FF0
	.dc.w	$4A90,$C718,$C018,$3FE4,$0000,$0000,$0000,$0000
	.dc.w	$1CB7,$1D8D,$1D80,$027D,$6A70,$8C70,$0C70,$F380
	.dc.w	$0000,$0000,$0000,$0000,$2548,$638C,$600C,$9FF0
	.dc.w	$4A91,$C719,$C018,$3FE3,$F03F,$FFC0,$0000,$FFFF
	.dc.w	$00B7,$018D,$0180,$FE7D,$6A03,$8E00,$0E00,$F1FF
	.dc.w	$F03E,$0FFE,$0000,$FFFF,$2548,$638C,$600C,$1FF0
	.dc.w	$0A90,$F718,$F018,$0FE0,$0000,$0000,$0000,$0000
	.dc.w	$1C82,$1DBD,$1DBD,$027D,$0A70,$EC70,$EC70,$F380
	.dc.w	$0000,$0000,$0000,$0000,$2540,$63BC,$603C,$1FC0
	.dc.w	$0A91,$E719,$E018,$1FE3,$F03F,$FFC0,$0000,$FFFF
	.dc.w	$00A2,$019D,$019D,$FE7D,$2A03,$CE00,$CE00,$F1FF
	.dc.w	$F03E,$0FFE,$0000,$FFFF,$2540,$639C,$601C,$1FE0
	.dc.w	$0A90,$E718,$E018,$1FE4,$0000,$0000,$0000,$0000
	.dc.w	$1CA2,$1D9D,$1D9D,$027D,$2A70,$CC70,$CC70,$F380
	.dc.w	$0000,$0000,$0000,$0000,$2540,$639C,$601C,$9FE0
	.dc.w	$2A90,$E718,$E018,$1FE0,$001E,$001F,$0000,$001F
	.dc.w	$1EB2,$E18D,$018D,$FE7D,$68F0,$8C0F,$8C00,$F3FF
	.dc.w	$F000,$F000,$0000,$F000,$2550,$639C,$601C,$1FE0
	.dc.w	$2520,$6230,$6030,$1FC0,$0000,$0000,$0000,$0000
	.dc.w	$0C52,$0CCF,$0CCD,$033F,$5660,$9860,$9860,$E780
	.dc.w	$0000,$0000,$0000,$0000,$1290,$3118,$3018,$0FE0
	.dc.w	$2720,$6030,$6030,$1FC0,$0000,$0000,$0000,$0000
	.dc.w	$0458,$0FC7,$0BC5,$003F,$D040,$1FE0,$1FA0,$E400
	.dc.w	$0000,$0000,$0000,$0000,$1390,$3018,$3018,$0FE0
	.dc.w	$1040,$3060,$3060,$0F80,$0000,$0000,$0000,$0000
	.dc.w	$0CAA,$0C65,$0C65,$039F,$AE60,$3060,$3060,$CF80
	.dc.w	$0000,$0000,$0000,$0000,$0820,$1830,$1830,$07C0
	.dc.w	$0880,$18C0,$18C0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$0037,$0070,$0070,$000F,$6000,$7000,$7000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0440,$0C60,$0C60,$0380
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0018,$0038,$0038,$0007,$C000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0380,$07C0,$07C0,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$001F,$001F,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0380,$0380,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$000F,$000F,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0001,$0000,$0001,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base01:		* StarBase (Perspective:0 - Animation:1)
	.dc.w	45,12
	.dc.w	24,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0015,$0031,$0031,$000E,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0095,$018E,$0180,$007F,$2000,$3000,$3000,$C000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$014E,$FB71,$FB40,$008E,$5000,$D800,$5800,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$7200,$FEFF,$FE00,$010E,$0800,$EC00,$0C00,$1000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1C00,$1C00,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$0001,$0003,$0003,$0000
	.dc.w	$8D1F,$8FFF,$8F11,$700E,$1400,$F780,$1780,$0800
	.dc.w	$0000,$0000,$0000,$0000,$1C00,$3E00,$3E00,$0000
	.dc.w	$0E00,$1F00,$1F00,$0000,$0003,$0007,$0007,$0000
	.dc.w	$763F,$07FF,$0700,$F8FF,$9B80,$E3C0,$03C0,$FC00
	.dc.w	$0000,$0000,$0000,$0000,$2200,$6300,$6300,$1C00
	.dc.w	$1F00,$3F80,$3F80,$0000,$0002,$0006,$0006,$0001
	.dc.w	$FA3F,$03FB,$0300,$FCFB,$99C0,$E1E0,$01E0,$EE00
	.dc.w	$0000,$0000,$0000,$0000,$5D00,$C180,$C180,$3E00
	.dc.w	$3180,$71C0,$71C0,$0E00,$0005,$000C,$000C,$0003
	.dc.w	$8D00,$71FF,$01FF,$FE00,$0060,$FE70,$FE70,$0180
	.dc.w	$0000,$0001,$0001,$0000,$A280,$9CC0,$80C0,$7F00
	.dc.w	$3580,$71C0,$71C0,$0E00,$0005,$000C,$000C,$0003
	.dc.w	$AD1F,$71FB,$0180,$FE7B,$39E0,$C1F0,$01F0,$FE00
	.dc.w	$0000,$0001,$0001,$0000,$AA80,$9CC0,$80C0,$7F00
	.dc.w	$6AC0,$E4E0,$E0E0,$1F00,$07CB,$07F8,$0018,$07E7
	.dc.w	$76BB,$D8FF,$00FF,$DF00,$C1F0,$C00F,$C000,$3FFF
	.dc.w	$7C01,$FC03,$0003,$FC00,$5D40,$3E60,$0060,$FF80
	.dc.w	$6AC0,$E4F0,$E0E0,$1F10,$000B,$0018,$0018,$0007
	.dc.w	$769F,$D8FB,$00C0,$DF3B,$39B0,$C1B8,$01B8,$FE40
	.dc.w	$0001,$0003,$0003,$0000,$5D40,$3E60,$0060,$FF80
	.dc.w	$6AC0,$E4EF,$E0C0,$1F2F,$0FEB,$F018,$0018,$FFE7
	.dc.w	$769B,$D8DF,$00DF,$DF20,$F80F,$F800,$F800,$07FF
	.dc.w	$C0FD,$3FFF,$0003,$FFFC,$5D40,$3E60,$0060,$FF80
	.dc.w	$6AC0,$E4E0,$E0C0,$1F20,$000F,$0018,$001F,$0000
	.dc.w	$FE9F,$40FB,$BCC0,$433B,$39B0,$C1B8,$01B8,$FE40
	.dc.w	$0001,$0003,$0003,$0000,$5C00,$3FE0,$01E0,$FE00
	.dc.w	$6AC0,$E4EF,$E0C0,$1F2F,$0FEB,$F018,$001B,$FFE4
	.dc.w	$FE9B,$40DF,$B8DF,$4720,$F80F,$F800,$F800,$07FF
	.dc.w	$C0FD,$3FFF,$0003,$FFFC,$5C00,$3FE0,$01E0,$FE00
	.dc.w	$6AC0,$E4F0,$E0E0,$1F10,$000B,$0018,$001B,$0004
	.dc.w	$FE9F,$40FB,$B8C0,$473B,$39B0,$C1B8,$01B8,$FE40
	.dc.w	$0001,$0003,$0003,$0000,$5D00,$3EE0,$00E0,$FF00
	.dc.w	$6AC0,$E4E0,$E0E0,$1F00,$006B,$0078,$0019,$0066
	.dc.w	$F6BB,$48FF,$B0FF,$4F00,$C3C3,$C03F,$C000,$3FFF
	.dc.w	$C001,$C003,$0003,$C000,$5D00,$3EE0,$00E0,$FF00
	.dc.w	$3580,$71C0,$71C0,$0E00,$0005,$000C,$000D,$0002
	.dc.w	$BD1F,$41FB,$B180,$4E7B,$39E0,$C1F0,$01F0,$FE00
	.dc.w	$0000,$0001,$0001,$0000,$AA80,$9CC0,$80C0,$7F00
	.dc.w	$3180,$71C0,$71C0,$0E00,$0005,$000C,$000C,$0003
	.dc.w	$AD00,$51FF,$A1FF,$5E08,$0060,$FFF0,$FF70,$8800
	.dc.w	$0000,$0001,$0001,$0000,$A280,$9CC0,$80C0,$7F00
	.dc.w	$1F00,$3F80,$3F80,$0000,$0002,$0006,$0006,$0001
	.dc.w	$FA9F,$037B,$A300,$5CFB,$39C0,$C1E0,$01E0,$FE00
	.dc.w	$0000,$0000,$0000,$0000,$5D00,$C180,$C180,$3E00
	.dc.w	$0E00,$1F00,$1F00,$0000,$0003,$0007,$0007,$0000
	.dc.w	$760E,$070E,$070E,$F800,$0380,$07C0,$07C0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2200,$6300,$6300,$1C00
	.dc.w	$0000,$0E00,$0E00,$0000,$0001,$0003,$0003,$0000
	.dc.w	$8C08,$8E08,$8E08,$7006,$0000,$0380,$0380,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1C00,$3E00,$3E00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$700E,$FC00,$FC0A,$000E,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1C00,$1C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$F804,$F800,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0004,$0000,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base02:		* StarBase (Perspective:0 - Animation:2)
	.dc.w	43,12
	.dc.w	24,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0054,$00C6,$00C6,$0038,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0254,$0638,$0600,$01FF,$8000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0539,$0DC7,$0D01,$0238,$4000,$6000,$6000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$00E0,$00E0,$0000
	.dc.w	$0800,$1BFF,$1800,$0438,$2000,$B000,$3000,$4000
	.dc.w	$0000,$0001,$0001,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$00E0,$01F0,$01F0,$0000
	.dc.w	$147C,$37FF,$3444,$0838,$5000,$D81C,$581C,$2000
	.dc.w	$0001,$0003,$0003,$0000,$C000,$E000,$E000,$0000
	.dc.w	$0E00,$1F00,$1F00,$0000,$0110,$0318,$0318,$00E0
	.dc.w	$6CFE,$63FF,$6000,$1FFF,$6C1C,$8C3E,$0C3E,$F000
	.dc.w	$0002,$0006,$0006,$0001,$2000,$3000,$3000,$C000
	.dc.w	$1F00,$3F80,$3F80,$0000,$02E8,$060C,$060C,$01F0
	.dc.w	$CCFE,$C3EF,$C000,$3FEF,$663E,$867F,$067F,$B800
	.dc.w	$0005,$000C,$000C,$0003,$D000,$1800,$1800,$E000
	.dc.w	$3180,$71C0,$71C0,$0E00,$0514,$0CE6,$0C06,$03F8
	.dc.w	$0000,$3FFF,$3FFF,$0000,$0063,$F8E3,$F8E3,$001C
	.dc.w	$000A,$8019,$8018,$0007,$2800,$CC00,$0C00,$F000
	.dc.w	$3580,$71C0,$71C0,$0E00,$0554,$0CE6,$0C06,$03F8
	.dc.w	$CE7C,$C1EF,$C000,$3FEF,$E66B,$06E3,$06E3,$F81C
	.dc.w	$000A,$8019,$8018,$0007,$A800,$CC00,$0C00,$F000
	.dc.w	$6AC0,$E4E0,$E0E0,$1F00,$0AEA,$19B3,$1803,$07BC
	.dc.w	$83EE,$03FE,$03FE,$FC01,$0F83,$007F,$0000,$FFFF
	.dc.w	$E015,$E033,$0030,$E00F,$D400,$E600,$0600,$F800
	.dc.w	$6AE0,$E4C0,$E0C0,$1F20,$0AEA,$19B3,$1803,$07BC
	.dc.w	$CE7C,$C1EF,$C000,$3FEF,$E6D5,$07C9,$07C1,$F83E
	.dc.w	$8015,$C033,$C030,$000F,$D400,$E600,$0600,$F800
	.dc.w	$6ABF,$E480,$E080,$1F7F,$EAEA,$19B3,$1803,$E7BC
	.dc.w	$38EF,$C0FF,$00FF,$FF00,$E07E,$E001,$E000,$1FFF
	.dc.w	$07D5,$FFF3,$0030,$FFCF,$D400,$E600,$0600,$F800
	.dc.w	$6A80,$E480,$E080,$1F40,$0082,$1083,$1F7B,$0084
	.dc.w	$CE7C,$C1EF,$C000,$3FEF,$E6D5,$07C9,$07C1,$F83E
	.dc.w	$8015,$C033,$C030,$000F,$8000,$FE00,$7E00,$8000
	.dc.w	$6ABF,$E480,$E080,$1F7F,$E88A,$1883,$1F73,$E08C
	.dc.w	$38EF,$C0FF,$00FF,$FF00,$E07E,$E001,$E000,$1FFF
	.dc.w	$07D5,$FFF3,$0030,$FFCF,$8000,$FE00,$7E00,$8000
	.dc.w	$6AE0,$E4C0,$E0C0,$1F20,$088A,$1883,$1F73,$008C
	.dc.w	$CE7C,$C1EF,$C000,$3FEF,$E6D5,$07C9,$07C1,$F83E
	.dc.w	$8015,$C033,$C030,$000F,$C400,$FE00,$3E00,$C000
	.dc.w	$6AC0,$E4E0,$E0E0,$1F00,$088A,$1893,$1B63,$049C
	.dc.w	$E1EF,$01FF,$01FF,$FE00,$0F0F,$00FF,$0000,$FFFF
	.dc.w	$8015,$C033,$C030,$000F,$C400,$FE00,$3E00,$C000
	.dc.w	$3580,$71C0,$71C0,$0E00,$0414,$0C86,$0F66,$0098
	.dc.w	$CE7C,$C1EF,$C000,$3FEF,$E66B,$06E3,$06E3,$F81C
	.dc.w	$000A,$8019,$8018,$0007,$A800,$DC00,$1C00,$E000
	.dc.w	$3180,$71C0,$71C0,$0E00,$0414,$0CA6,$0D46,$02B8
	.dc.w	$1000,$EFFF,$FFFF,$0111,$1063,$EEE3,$FEE3,$001C
	.dc.w	$000A,$8019,$8018,$0007,$2800,$DC00,$1C00,$E000
	.dc.w	$1F00,$3F80,$3F80,$0000,$02E8,$060C,$060C,$01F0
	.dc.w	$CE7C,$C1EF,$C000,$3FEF,$E63E,$067F,$067F,$F800
	.dc.w	$0005,$000C,$000C,$0003,$D000,$1800,$1800,$E000
	.dc.w	$0E00,$1F00,$1F00,$0000,$0110,$0318,$0318,$00E0
	.dc.w	$0038,$0038,$0038,$0000,$001C,$003E,$003E,$0000
	.dc.w	$0002,$0006,$0006,$0001,$2000,$3000,$3000,$C000
	.dc.w	$0000,$0E00,$0E00,$0000,$00E0,$01F0,$01F0,$0000
	.dc.w	$0020,$0020,$0020,$0018,$0000,$001C,$001C,$0000
	.dc.w	$0001,$0003,$0003,$0000,$C000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$00E0,$00E0,$0000
	.dc.w	$0010,$0000,$0010,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0010,$0000,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0010,$0000,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base03:		* StarBase (Perspective:0 - Animation:3)
	.dc.w	41,12
	.dc.w	24,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0150,$0318,$0318,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0952,$18E3,$1803,$07FC,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$14E5,$371D,$3405,$08E2,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$E000,$E000,$0000
	.dc.w	$2000,$6FFE,$6000,$10E1,$8000,$C000,$C000,$0000
	.dc.w	$0000,$001C,$001C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0E01,$0E01,$0000,$E000,$F000,$F000,$0000
	.dc.w	$51F1,$DFFF,$D111,$20E0,$4000,$6001,$6001,$8000
	.dc.w	$001C,$C03E,$C03E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0E01,$1F03,$1F03,$0000,$1001,$1801,$1801,$E000
	.dc.w	$B3F9,$8FFE,$8000,$7FFF,$B001,$3003,$3003,$C000
	.dc.w	$C022,$E063,$E063,$001C,$0000,$0000,$0000,$0000
	.dc.w	$1F02,$3F86,$3F86,$0001,$E803,$0C03,$0C03,$F000
	.dc.w	$33F9,$0FBE,$0000,$FFBE,$9803,$1807,$1807,$E000
	.dc.w	$E05D,$F0C1,$F0C1,$003E,$0000,$8000,$8000,$0000
	.dc.w	$3185,$71CC,$71CC,$0E03,$1400,$E600,$0600,$F800
	.dc.w	$0000,$FFFF,$FFFF,$0000,$0006,$E00E,$E00E,$0001
	.dc.w	$30A2,$399C,$3980,$C07F,$8000,$C000,$C000,$0000
	.dc.w	$3585,$71CC,$71CC,$0E03,$5403,$E603,$0603,$F800
	.dc.w	$39F3,$07BC,$0000,$FFBF,$9806,$180E,$180E,$E001
	.dc.w	$B0AA,$399C,$3980,$C07F,$8000,$C000,$C000,$0000
	.dc.w	$6ACA,$E4F9,$E0F8,$1F07,$EA3E,$B3C0,$0300,$BCFF
	.dc.w	$0FB0,$0FF0,$0FF0,$F00F,$7C1F,$03FF,$0000,$FFFF
	.dc.w	$595D,$9F36,$1F00,$E0F7,$4000,$6000,$6000,$8000
	.dc.w	$6ACA,$E4F9,$E0F8,$1F07,$EA03,$B303,$0303,$BC00
	.dc.w	$39F3,$07BC,$0000,$FFBF,$980D,$181C,$181C,$E003
	.dc.w	$595D,$9F36,$1F00,$E0F7,$4000,$6000,$6000,$8000
	.dc.w	$6ACA,$E4D9,$E0D8,$1F27,$EA87,$B3F8,$0300,$BCFF
	.dc.w	$87BF,$07FF,$07FF,$F800,$81F8,$8007,$8000,$7FFF
	.dc.w	$1D5D,$FF36,$0300,$FCF7,$4000,$6000,$6000,$8000
	.dc.w	$6ACF,$E4DF,$E0D8,$1F20,$FA03,$FB03,$0B03,$8400
	.dc.w	$39F3,$07BC,$0000,$FFBF,$980D,$181C,$181C,$E003
	.dc.w	$5950,$9F3F,$1F0F,$E0F0,$4000,$E000,$E000,$0000
	.dc.w	$6ACF,$E4DF,$E0D8,$1F20,$FA87,$F3F8,$0300,$8CFF
	.dc.w	$87BF,$07FF,$07FF,$F800,$81F8,$8007,$8000,$7FFF
	.dc.w	$1D50,$FF3F,$030F,$FCF0,$4000,$E000,$E000,$0000
	.dc.w	$6ACF,$E4FF,$E0F8,$1F00,$FA03,$F303,$0303,$8C00
	.dc.w	$39F3,$07BC,$0000,$FFBF,$980D,$181C,$181C,$E003
	.dc.w	$5958,$9F37,$1F07,$E0F0,$4000,$E000,$E000,$0000
	.dc.w	$6ACB,$E4FB,$E0F8,$1F04,$EA87,$F3F8,$0300,$9CFF
	.dc.w	$87BC,$07FC,$07FC,$F803,$3C3D,$03FC,$0000,$FFFF
	.dc.w	$5958,$9F37,$1F07,$E0F0,$4000,$E000,$E000,$0000
	.dc.w	$3585,$71CD,$71CC,$0E02,$5403,$E603,$0603,$B800
	.dc.w	$39F3,$07BC,$0000,$FFBF,$9806,$180E,$180E,$E001
	.dc.w	$B0A8,$399F,$3983,$C07C,$8000,$C000,$C000,$0000
	.dc.w	$3185,$71CD,$71CC,$0E02,$5400,$E603,$0601,$B800
	.dc.w	$0000,$FFFF,$FFFF,$2222,$0006,$D80E,$F80E,$0001
	.dc.w	$30A0,$399D,$3981,$C07E,$8000,$C000,$C000,$0000
	.dc.w	$1F02,$3F86,$3F86,$0001,$E803,$0C03,$0C03,$F000
	.dc.w	$39F3,$07BC,$0000,$FFBF,$9803,$1807,$1807,$E000
	.dc.w	$E05D,$F0C1,$F0C1,$003E,$0000,$8000,$8000,$0000
	.dc.w	$0E01,$1F03,$1F03,$0000,$1000,$1800,$1800,$E000
	.dc.w	$00E0,$00E0,$00E0,$0000,$0001,$0003,$0003,$0000
	.dc.w	$C022,$E063,$E063,$001C,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0E01,$0E01,$0000,$E000,$F000,$F000,$0000
	.dc.w	$0080,$0080,$0080,$0060,$0000,$0001,$0001,$0000
	.dc.w	$001C,$C03E,$C03E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$E000,$E000,$0000
	.dc.w	$00E0,$0000,$00A0,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$001C,$001C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0040,$0000,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$0040,$0000,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base04:		* StarBase (Perspective:0 - Animation:4)
	.dc.w	38,12
	.dc.w	24,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A80,$18C0,$18C0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4A90,$C718,$C018,$3FE0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$A728,$B8EC,$A02C,$4710,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$00E0,$00E0,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0004,$7FF6,$0006,$8708
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0700,$0700,$0000
	.dc.w	$00E0,$0FF0,$0FF0,$0000,$0002,$0006,$0006,$0001
	.dc.w	$8F8A,$FFFB,$888B,$0704,$0000,$0000,$0000,$0000
	.dc.w	$0700,$7F80,$7F80,$0000,$0D10,$1F18,$1F18,$00E0
	.dc.w	$000D,$000C,$000C,$0003,$9FCD,$7FF1,$0001,$FFFE
	.dc.w	$8000,$8000,$8000,$0000,$6880,$F8C0,$F8C0,$0700
	.dc.w	$1AE8,$3E0C,$3E0C,$01F0,$0019,$0018,$0018,$0007
	.dc.w	$9FCC,$7DF0,$0000,$FDF7,$C000,$C001,$C001,$0000
	.dc.w	$D740,$F060,$F060,$0F80,$3514,$7CE6,$7C06,$03F8
	.dc.w	$0000,$0007,$0007,$0000,$0000,$FFFF,$FFFF,$0000
	.dc.w	$0001,$0003,$0003,$0000,$A8A0,$E730,$E030,$1FC0
	.dc.w	$3554,$7CE6,$7C06,$03F8,$0019,$0018,$0018,$0007
	.dc.w	$CF9C,$3DE0,$0000,$FDFF,$C001,$C003,$C003,$0000
	.dc.w	$AAA0,$E730,$E030,$1FC0,$6AEA,$F9B3,$F803,$07BC
	.dc.w	$41F0,$7E00,$0000,$7FFF,$7DF0,$7FF0,$7FF0,$800F
	.dc.w	$7C1F,$03FF,$0001,$FFFE,$5750,$CD98,$C018,$3DE0
	.dc.w	$6AEA,$F9B3,$F803,$07BC,$0019,$0018,$0018,$0007
	.dc.w	$CF9C,$3DE0,$0000,$FDFF,$C003,$C007,$C007,$0000
	.dc.w	$5750,$CD98,$C018,$3DE0,$6AEA,$F9B3,$F803,$07BC
	.dc.w	$C1F0,$FE00,$0000,$FFFF,$7DF8,$7FF8,$7FF8,$8007
	.dc.w	$1F83,$007F,$0000,$FFFF,$5750,$CD98,$C018,$3DE0
	.dc.w	$691A,$FFF3,$F913,$000C,$0019,$0018,$0018,$0007
	.dc.w	$CF9C,$3DE0,$0000,$FDFF,$C003,$C007,$C007,$0000
	.dc.w	$5090,$CFF8,$C098,$3800,$690A,$FFF3,$F903,$001C
	.dc.w	$C1F0,$FE00,$0000,$FFFF,$7DF8,$7FF8,$7FF8,$8007
	.dc.w	$1F83,$007F,$0000,$FFFF,$5090,$CFF8,$C098,$3800
	.dc.w	$690A,$FFF3,$F903,$001C,$0019,$0018,$0018,$0007
	.dc.w	$CF9C,$3DE0,$0000,$FDFF,$C003,$C007,$C007,$0000
	.dc.w	$5090,$CFF8,$C098,$3800,$6D2A,$FFF3,$FD03,$003C
	.dc.w	$3C3C,$3FC0,$0000,$3FFF,$3DE1,$3FE0,$3FE0,$C01F
	.dc.w	$E1E3,$1FE7,$0007,$FFE0,$54B0,$CFF8,$C0B8,$3C00
	.dc.w	$3554,$7FE6,$7D06,$0078,$0019,$0018,$0018,$0007
	.dc.w	$CF9C,$3DE0,$0000,$FDFF,$C001,$C003,$C003,$0000
	.dc.w	$AAA0,$E7F0,$E0B0,$1E00,$3714,$7FE6,$7F06,$0078
	.dc.w	$0008,$001F,$0017,$0000,$0000,$FFFF,$FFFF,$8888
	.dc.w	$8001,$C003,$4003,$0000,$A8E0,$E7F0,$E0F0,$1E00
	.dc.w	$1AE8,$3E0C,$3E0C,$01F0,$0019,$0018,$0018,$0007
	.dc.w	$CF9C,$3DE0,$0000,$FDFF,$C000,$C001,$C001,$0000
	.dc.w	$D740,$F060,$F060,$0F80,$0D10,$1F18,$1F18,$00E0
	.dc.w	$0000,$0000,$0000,$0000,$0700,$0700,$0700,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6880,$F8C0,$F8C0,$0700
	.dc.w	$00E0,$0FF0,$0FF0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0400,$0400,$0300,$0000,$0000,$0000,$0000
	.dc.w	$0700,$7F80,$7F80,$0000,$0000,$00E0,$00E0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0A80,$0000,$0880,$0A80
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0700,$0700,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0200,$0000,$0200,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0200,$0200,$0000,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base05:		* StarBase (Perspective:0 - Animation:5)
	.dc.w	42,12
	.dc.w	24,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00A8,$018C,$018C,$0070,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$04A9,$0C71,$0C01,$03FE,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A72,$1B8E,$1A02,$0471,$8000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1000,$37FF,$3000,$0870,$4000,$6000,$6000,$8000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$7000,$7000,$0000
	.dc.w	$28F8,$6FFF,$6888,$1070,$A000,$B001,$B001,$4000
	.dc.w	$E000,$F00E,$F00E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0880,$18C0,$18C0,$0700,$7000,$F800,$F800,$0000
	.dc.w	$D9FC,$C7FF,$C000,$3FFF,$D801,$1803,$1803,$E000
	.dc.w	$100E,$181F,$181F,$E000,$0000,$0000,$0000,$0000
	.dc.w	$1740,$3061,$3061,$0F80,$F801,$FC01,$FC01,$0000
	.dc.w	$99FC,$87DF,$8000,$7FDF,$CC02,$0C06,$0C06,$7001
	.dc.w	$E81F,$0C3F,$0C3F,$F000,$0000,$8000,$8000,$0000
	.dc.w	$28A1,$6733,$6033,$1FC0,$8C00,$8E00,$8E00,$7000
	.dc.w	$0000,$7FFF,$7FFF,$0000,$0005,$F00C,$F00C,$0003
	.dc.w	$1431,$E671,$0671,$F80E,$8000,$C000,$C000,$0000
	.dc.w	$2AA1,$6733,$6033,$1FC0,$AC01,$8E01,$8E01,$7000
	.dc.w	$9CF9,$83DE,$8000,$7FDF,$CC05,$0C0C,$0C0C,$F003
	.dc.w	$5435,$E671,$0671,$F80E,$8000,$C000,$C000,$0000
	.dc.w	$5753,$CD9F,$C01F,$3DE0,$5F83,$2FFC,$0000,$FFFF
	.dc.w	$E0DF,$00FF,$00FF,$FF00,$07CA,$0039,$0018,$FFE7
	.dc.w	$EA6A,$B3E4,$03E0,$BC1F,$C000,$E000,$E000,$0000
	.dc.w	$5753,$CD9F,$C01F,$3DE0,$5601,$2701,$0701,$F800
	.dc.w	$9CF9,$83DE,$8000,$7FDF,$CC0A,$0C19,$0C18,$F007
	.dc.w	$EA6A,$B3E4,$03E0,$BC1F,$C000,$E000,$E000,$0000
	.dc.w	$5757,$CD9F,$C018,$3DE7,$81F8,$FE00,$0000,$FFFF
	.dc.w	$1FDE,$1FFE,$1FFE,$E001,$1E0A,$01F9,$0018,$FFE7
	.dc.w	$EA6A,$B364,$0360,$BC9F,$C000,$E000,$E000,$0000
	.dc.w	$4153,$FF9F,$FE1F,$01E0,$5601,$2701,$0701,$F800
	.dc.w	$9CF9,$83DE,$8000,$7FDF,$CC0B,$0C19,$0C18,$F006
	.dc.w	$FE6A,$FF64,$0360,$209F,$C000,$E000,$E000,$0000
	.dc.w	$4157,$FF9F,$FE18,$01E7,$81F8,$FE00,$0000,$FFFF
	.dc.w	$1FDE,$1FFE,$1FFE,$E001,$1E0B,$01F9,$0018,$FFE6
	.dc.w	$FE6A,$FF64,$0360,$209F,$C000,$E000,$E000,$0000
	.dc.w	$4353,$FD9F,$FC1F,$01E0,$5601,$2701,$0701,$F800
	.dc.w	$9CF9,$83DE,$8000,$7FDF,$CC0B,$0C19,$0C18,$F006
	.dc.w	$FE6A,$FFE4,$03E0,$201F,$C000,$E000,$E000,$0000
	.dc.w	$4353,$FD9F,$FC1F,$01E0,$57C3,$27FC,$0400,$FBFF
	.dc.w	$C3DE,$03FE,$03FE,$FC01,$1E0A,$01F9,$0018,$FFE7
	.dc.w	$FA6A,$FBE4,$03E0,$241F,$C000,$E000,$E000,$0000
	.dc.w	$22A1,$7F33,$7833,$07C0,$AC01,$8E01,$8E01,$7000
	.dc.w	$9CF9,$83DE,$8000,$7FDF,$CC05,$0C0C,$0C0C,$F003
	.dc.w	$5435,$F671,$0671,$A80E,$8000,$C000,$C000,$0000
	.dc.w	$20A1,$7733,$7033,$0FC0,$8C00,$8E01,$8E01,$7000
	.dc.w	$0000,$BFFF,$FFFF,$0444,$0005,$FC0C,$F80C,$4003
	.dc.w	$5431,$F671,$0671,$A80E,$8000,$C000,$C000,$0000
	.dc.w	$1740,$3061,$3061,$0F80,$F801,$FC01,$FC01,$0000
	.dc.w	$9CF9,$83DE,$8000,$7FDF,$CC02,$0C06,$0C06,$F001
	.dc.w	$E81F,$0C3F,$0C3F,$F000,$0000,$8000,$8000,$0000
	.dc.w	$0880,$18C0,$18C0,$0700,$7000,$F800,$F800,$0000
	.dc.w	$0070,$0070,$0070,$0000,$0001,$0003,$0003,$0000
	.dc.w	$100E,$181F,$181F,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$7000,$7000,$0000
	.dc.w	$0040,$0040,$0040,$0030,$0000,$0001,$0001,$0000
	.dc.w	$E000,$F00E,$F00E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0070,$0000,$0050,$0070,$0000,$0000,$0000,$0000
	.dc.w	$0000,$E000,$E000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0020,$0000,$0020,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0020,$0020,$0000,$0020,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base06:		* StarBase (Perspective:0 - Animation:6)
	.dc.w	44,12
	.dc.w	24,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002A,$0063,$0063,$001C,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$012A,$031C,$0300,$00FF,$4000,$6000,$6000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$029C,$06E3,$0680,$011C,$A000,$B000,$B000,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0DFF,$0C00,$021C,$1000,$D80E,$180E,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$0070,$0070,$0000
	.dc.w	$0A3E,$1BFF,$1A22,$041C,$280E,$EC1F,$2C1F,$1000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$E000,$E000,$0000
	.dc.w	$0880,$18C0,$18C0,$0700,$0070,$00F8,$00F8,$0000
	.dc.w	$367F,$31FF,$3000,$0FFF,$3611,$C631,$0631,$F80E
	.dc.w	$0000,$8001,$8001,$0000,$E000,$F000,$F000,$0000
	.dc.w	$1740,$3060,$3060,$0F80,$00F8,$01FC,$01FC,$0000
	.dc.w	$667F,$61F7,$6000,$1FF7,$332E,$C360,$0360,$DC1F
	.dc.w	$8001,$C003,$C003,$0000,$F000,$F800,$F800,$0000
	.dc.w	$28A0,$6730,$6030,$1FC0,$018C,$038E,$038E,$0070
	.dc.w	$0000,$1FFF,$1FFF,$0000,$0051,$FCCE,$FCC0,$003F
	.dc.w	$4003,$6007,$6007,$8000,$1800,$1C00,$1C00,$E000
	.dc.w	$2AA0,$6730,$6030,$1FC0,$01AC,$038E,$038E,$0070
	.dc.w	$673E,$60F7,$6000,$1FF7,$7355,$83CE,$03C0,$FC3F
	.dc.w	$4003,$6007,$6007,$8000,$5800,$1C00,$1C00,$E000
	.dc.w	$5750,$CF98,$C018,$3FE0,$07C1,$07FE,$0000,$07FF
	.dc.w	$F077,$007F,$007F,$FF80,$C0AE,$C19B,$C180,$3E7B
	.dc.w	$AC06,$3C0E,$300E,$CC01,$AC00,$4E00,$0E00,$F000
	.dc.w	$5750,$CF98,$C018,$3FE0,$0356,$0727,$0707,$00F8
	.dc.w	$673E,$60F7,$6000,$1FF7,$72AE,$839B,$0380,$FC7B
	.dc.w	$A006,$3006,$3006,$C009,$AC00,$4E00,$0E00,$F000
	.dc.w	$5757,$CF9F,$C018,$3FE7,$C0FC,$FF00,$0000,$FFFF
	.dc.w	$07F7,$07FF,$07FF,$F800,$1CAE,$039B,$0180,$FE7B
	.dc.w	$AFFE,$3002,$3002,$CFFD,$AC00,$4E00,$0E00,$F000
	.dc.w	$0350,$FF98,$FC18,$03E0,$0356,$0727,$0707,$00F8
	.dc.w	$673E,$60F7,$6000,$1FF7,$7282,$8382,$03BD,$FC42
	.dc.w	$0006,$1002,$F002,$0005,$AC00,$4E00,$0E00,$F000
	.dc.w	$0357,$FF9F,$FC18,$03E7,$C0FC,$FF00,$0000,$FFFF
	.dc.w	$07F7,$07FF,$07FF,$F800,$1CA2,$0382,$019D,$FE62
	.dc.w	$2FFE,$3002,$F002,$0FFD,$AC00,$4E00,$0E00,$F000
	.dc.w	$4750,$FF98,$F818,$07E0,$0356,$0727,$0707,$00F8
	.dc.w	$673E,$60F7,$6000,$1FF7,$72A2,$8382,$039D,$FC62
	.dc.w	$2006,$3006,$F006,$0009,$AC00,$4E00,$0E00,$F000
	.dc.w	$4750,$FF98,$F818,$07E0,$03F0,$07FF,$0700,$00FF
	.dc.w	$F0F7,$00FF,$00FF,$FF00,$86A2,$8192,$818D,$7E72
	.dc.w	$2006,$300E,$B00E,$4001,$AC00,$4E00,$0E00,$F000
	.dc.w	$2AA0,$7730,$7030,$0FC0,$01AC,$038E,$038E,$0070
	.dc.w	$673E,$60F7,$6000,$1FF7,$7350,$83C2,$03CD,$FC32
	.dc.w	$4003,$6007,$E007,$0000,$5800,$1C00,$1C00,$E000
	.dc.w	$28A0,$7730,$7030,$0FC0,$018C,$038E,$038E,$0070
	.dc.w	$0800,$77FF,$7FFF,$0088,$0850,$F7CA,$FFC5,$803A
	.dc.w	$4003,$6007,$6007,$8000,$1800,$1C00,$1C00,$E000
	.dc.w	$1740,$3060,$3060,$0F80,$00F8,$01FC,$01FC,$0000
	.dc.w	$673E,$60F7,$6000,$1FF7,$732A,$8360,$0360,$FC1F
	.dc.w	$8001,$C003,$C003,$0000,$F000,$F800,$F800,$0000
	.dc.w	$0880,$18C0,$18C0,$0700,$0070,$00F8,$00F8,$0000
	.dc.w	$001C,$001C,$001C,$0000,$0011,$0031,$0031,$000E
	.dc.w	$0000,$8001,$8001,$0000,$E000,$F000,$F000,$0000
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$0070,$0070,$0000
	.dc.w	$0010,$0010,$0010,$000C,$000E,$001F,$001F,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$E000,$E000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$0000,$0008,$0008,$0000,$000E,$000E,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0008,$0000,$0008,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$0008,$0000,$0008,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base07:		* StarBase (Perspective:0 - Animation:7)
	.dc.w	46,12
	.dc.w	24,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000A,$0018,$0018,$0007,$8000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$004A,$00C7,$00C0,$003F,$9000,$1800,$1800,$E000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00A7,$01B8,$01A0,$0047,$2800,$EFE0,$2FE0,$1000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0100,$037F,$0300,$0087,$01C0,$F7F0,$07F0,$0800
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$0000,$0000,$0000
	.dc.w	$028F,$3EFF,$3E88,$0107,$8630,$FE38,$9E38,$01C0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0E00,$0E00,$0000
	.dc.w	$0880,$18C0,$18C0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$3D9F,$7C7F,$7C00,$03FF,$CDD8,$FC1C,$1C1C,$E3E0
	.dc.w	$0000,$0000,$0000,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$1740,$3060,$3060,$0F80,$0000,$0000,$0000,$0000
	.dc.w	$799F,$F87D,$F800,$07FD,$CBE8,$F80C,$180C,$E7F0
	.dc.w	$0000,$0000,$0000,$0000,$1F00,$3F80,$3F80,$0000
	.dc.w	$28A0,$6730,$6030,$1FC0,$0000,$0001,$0001,$0000
	.dc.w	$C000,$C7FF,$C7FF,$3800,$1634,$F1C6,$F006,$0FF8
	.dc.w	$0000,$0000,$0000,$0000,$3180,$71C0,$71C0,$0E00
	.dc.w	$2AA0,$6730,$6030,$1FC0,$0000,$0001,$0001,$0000
	.dc.w	$D9CF,$D83D,$D800,$27FD,$96B4,$F1C6,$3006,$CFF8
	.dc.w	$0000,$0000,$0000,$0000,$3580,$71C0,$71C0,$0E00
	.dc.w	$5750,$CF98,$C018,$3FE0,$03E0,$03FF,$0000,$03FF
	.dc.w	$F87D,$007F,$007F,$FF80,$ADDA,$E363,$E003,$1F7C
	.dc.w	$1F00,$FF00,$0000,$FF00,$6AC0,$E4E0,$E0E0,$1F00
	.dc.w	$5750,$CF98,$C018,$3FE0,$0001,$0003,$0003,$0000
	.dc.w	$B9CF,$983D,$9800,$67FD,$ADDA,$E363,$6003,$9F7C
	.dc.w	$0000,$0001,$0000,$0001,$6AC0,$E4E0,$E0E0,$1F00
	.dc.w	$5757,$CF9F,$C018,$3FE7,$E07F,$FF80,$0000,$FFFF
	.dc.w	$01FD,$01FF,$01FF,$FE00,$ADDA,$E363,$E003,$1F7C
	.dc.w	$FF00,$00FF,$0000,$FFFF,$6AC0,$E4E0,$60E0,$9F00
	.dc.w	$0750,$FF98,$F818,$07E0,$0001,$0003,$0003,$0000
	.dc.w	$B9CF,$983D,$9800,$67FD,$AFFE,$E043,$67BF,$9840
	.dc.w	$0000,$0000,$0000,$0000,$6AC0,$E4E0,$60E0,$9F00
	.dc.w	$0757,$FF9F,$F818,$07E7,$E07F,$FF80,$0000,$FFFF
	.dc.w	$01FD,$01FF,$01FF,$FE00,$AFFA,$E043,$E3BB,$1C44
	.dc.w	$FF00,$00FF,$0000,$FFFF,$6AC0,$E4E0,$60E0,$9F00
	.dc.w	$0750,$FF98,$F018,$0FE0,$0001,$0003,$0003,$0000
	.dc.w	$B9CF,$983D,$9800,$67FD,$AFFA,$E043,$63BB,$9C44
	.dc.w	$0000,$0001,$0000,$0001,$6AC0,$E4E0,$E0E0,$1F00
	.dc.w	$0750,$FF98,$F018,$0FE0,$003C,$003F,$0000,$003F
	.dc.w	$3C3D,$C03F,$003F,$FFC0,$ADFA,$E243,$E1B3,$1E4C
	.dc.w	$E000,$E000,$0000,$E000,$6AC0,$E4E0,$E0E0,$1F00
	.dc.w	$0AA0,$6730,$6030,$1FC0,$0000,$0001,$0001,$0000
	.dc.w	$D9CF,$D83D,$D800,$27FD,$97B4,$F046,$31B6,$CE48
	.dc.w	$0000,$0000,$0000,$0000,$3580,$71C0,$71C0,$0E00
	.dc.w	$08A0,$6730,$6030,$1FC0,$0000,$0001,$0001,$0000
	.dc.w	$C000,$DFFF,$CFFF,$2111,$16B4,$F146,$F0A6,$0F58
	.dc.w	$0000,$0000,$0000,$0000,$3180,$71C0,$71C0,$0E00
	.dc.w	$1740,$3060,$3060,$0F80,$0000,$0000,$0000,$0000
	.dc.w	$79CF,$F83D,$F800,$07FD,$8BE8,$F80C,$18AC,$E750
	.dc.w	$0000,$0000,$0000,$0000,$1F00,$3F80,$3F80,$0000
	.dc.w	$0880,$18C0,$18C0,$0700,$0000,$0000,$0000,$0000
	.dc.w	$3807,$7C07,$7C07,$0000,$0DD8,$1C1C,$1C1C,$03E0
	.dc.w	$0000,$0000,$0000,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$0700,$0F80,$0F80,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$3804,$3804,$0003,$0630,$0E38,$0E38,$01C0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0E00,$0E00,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0005,$0007,$01C0,$07F0,$07F0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0002,$0000,$0002,$0000,$03E0,$03E0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0002,$0000,$0002,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base10:		* StarBase (Perspective:1 - Animation:0)
	.dc.w	41,10
	.dc.w	20,6
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0348,$0308,$0308,$00F0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A2A,$1BDB,$1BDB,$0424,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$19C5,$3FFD,$3FFD,$0002,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0018,$0018,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0E00,$0F00,$0F00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2632,$6E3E,$6E3E,$11C1,$8000,$C000,$C000,$0000
	.dc.w	$0018,$007E,$007E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1100,$1180,$1180,$0E00,$0000,$0000,$0000,$0000
	.dc.w	$CDDB,$DC1C,$DC1C,$23E3,$4000,$4000,$4000,$8000
	.dc.w	$0066,$00E7,$00E7,$0018,$0000,$0000,$0000,$0000
	.dc.w	$3080,$30C0,$30C0,$0F00,$0001,$0001,$0001,$0000
	.dc.w	$8BF3,$9814,$9814,$67E9,$2000,$2000,$2000,$C000
	.dc.w	$00C3,$01C3,$01C3,$003C,$0000,$8000,$8000,$0000
	.dc.w	$6E40,$6040,$6040,$1F80,$0000,$0000,$0000,$0000
	.dc.w	$662B,$71CF,$700F,$0FF0,$C000,$C000,$C000,$0000
	.dc.w	$0099,$0181,$0181,$007E,$0000,$8000,$8000,$0000
	.dc.w	$4500,$CE20,$C020,$3FC0,$1E0F,$1FF3,$0003,$1FFC
	.dc.w	$9DD5,$B366,$B006,$4F79,$3E1E,$31FE,$3000,$CFFE
	.dc.w	$0124,$0318,$0300,$00FF,$8000,$C000,$C000,$0000
	.dc.w	$4500,$CE20,$C020,$3FD0,$0003,$0000,$0000,$0003
	.dc.w	$1DD4,$3366,$3006,$CF79,$3000,$0000,$0000,$F000
	.dc.w	$0124,$0318,$0300,$04FF,$8000,$C000,$C000,$0000
	.dc.w	$4507,$CE27,$C020,$3FCF,$81F3,$FE03,$0003,$FFFC
	.dc.w	$9DD5,$B366,$B006,$4F79,$33E0,$301F,$3000,$CFFF
	.dc.w	$F924,$FB18,$0300,$F8FF,$8000,$C000,$C000,$0000
	.dc.w	$0500,$FE20,$F020,$0FC0,$0000,$0000,$0000,$0003
	.dc.w	$1085,$3F77,$3F77,$C008,$0000,$0000,$0000,$F000
	.dc.w	$0124,$031B,$0303,$00FC,$0000,$C000,$C000,$0000
	.dc.w	$0507,$EE27,$E020,$1FCF,$81F3,$FE03,$0003,$FFFC
	.dc.w	$9895,$B766,$B766,$4819,$33E0,$301F,$3000,$CFFF
	.dc.w	$F924,$FB19,$0301,$F8FE,$0000,$C000,$C000,$0000
	.dc.w	$2500,$EE20,$E020,$1FC0,$01E3,$01FC,$0000,$01FF
	.dc.w	$DC95,$3367,$3367,$CC18,$00E0,$0FE0,$0000,$FFE0
	.dc.w	$0125,$0319,$0301,$00FE,$0000,$C000,$C000,$0000
	.dc.w	$2A40,$6440,$6040,$1F80,$0001,$0001,$0001,$0000
	.dc.w	$848B,$93EC,$936C,$6C93,$2000,$2000,$2000,$C000
	.dc.w	$0099,$0181,$0181,$007E,$0000,$8000,$8000,$0000
	.dc.w	$2E40,$6040,$6040,$1F80,$0000,$0001,$0000,$0000
	.dc.w	$2628,$F1CD,$D14F,$0EB0,$4000,$E000,$A000,$0000
	.dc.w	$0099,$0181,$0181,$007E,$0000,$8000,$8000,$0000
	.dc.w	$1080,$30C0,$30C0,$0F00,$0001,$0001,$0001,$0000
	.dc.w	$9AB7,$8958,$8958,$76A7,$2000,$2000,$2000,$C000
	.dc.w	$0042,$00C3,$00C3,$003C,$0000,$0000,$0000,$0000
	.dc.w	$0100,$1180,$1180,$0E00,$0000,$0000,$0000,$0000
	.dc.w	$0DD0,$0C18,$0C18,$03E0,$0000,$0000,$0000,$0000
	.dc.w	$0024,$0066,$0066,$0018,$0000,$0000,$0000,$0000
	.dc.w	$0E00,$0F00,$0F00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0620,$0E30,$0E30,$01C0,$0000,$0000,$0000,$0000
	.dc.w	$0018,$003C,$003C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$03E0,$03F0,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$0040,$0000,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base11:		* StarBase (Perspective:1 - Animation:1)
	.dc.w	39,10
	.dc.w	20,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0D20,$0C20,$0C20,$03C0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$000F,$000F,$0000,$2BA8,$6C6C,$6C6C,$1390
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000E,$001F,$001F,$0000
	.dc.w	$6014,$FFF6,$FC76,$0388,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00C0,$00C0,$0000,$0000,$1C00,$1C00,$0000
	.dc.w	$0011,$0031,$0031,$000E,$078A,$BFFB,$BC7B,$4384
	.dc.w	$0000,$8000,$8000,$0000,$00C0,$03F0,$03F0,$0000
	.dc.w	$1C00,$3E00,$3E00,$0000,$003E,$0070,$0070,$000F
	.dc.w	$8FCD,$FFF1,$C001,$3FFE,$8000,$C000,$C000,$0000
	.dc.w	$0330,$0738,$0738,$00C0,$3E00,$3F00,$3F00,$0000
	.dc.w	$006F,$0060,$0060,$001F,$4FCC,$7EF0,$6000,$9EF7
	.dc.w	$C000,$E000,$E000,$0000,$06D8,$0E1C,$0E1C,$01E0
	.dc.w	$6300,$6300,$6300,$1C00,$0051,$00CE,$00C0,$003F
	.dc.w	$8FFF,$3FFF,$3FFF,$C000,$6000,$7000,$7000,$8000
	.dc.w	$0528,$0CCC,$0C0C,$03F0,$5500,$C980,$C180,$3E00
	.dc.w	$38BE,$3F8B,$0180,$3E7B,$E79C,$3EE0,$3000,$CEFF
	.dc.w	$B878,$B7F8,$B000,$4FF8,$0AD4,$19E6,$1806,$07F8
	.dc.w	$5500,$C9C0,$C180,$3E40,$00BE,$018B,$0180,$007B
	.dc.w	$EEF0,$3FF0,$3FF0,$C00F,$F000,$0800,$0800,$F000
	.dc.w	$0AD4,$19E6,$1806,$07F8,$5500,$C9BF,$C100,$3EBF
	.dc.w	$7EBE,$818B,$0180,$FE7B,$E79C,$3EE0,$3000,$CEFF
	.dc.w	$BF83,$B07F,$B000,$4FFF,$EAD4,$F9E6,$1806,$E7F8
	.dc.w	$5500,$C980,$C100,$3E80,$0088,$01FF,$01F7,$0008
	.dc.w	$66FC,$B7FC,$B7FC,$4803,$0000,$0800,$0800,$F000
	.dc.w	$0AC0,$19FE,$181E,$07E0,$5500,$C9BF,$C100,$3EBF
	.dc.w	$7E88,$81BF,$01B7,$FE48,$E79C,$3EE0,$3000,$CEFF
	.dc.w	$BF83,$B07F,$B000,$4FFF,$EAC0,$F9FE,$181E,$E7E0
	.dc.w	$5500,$C980,$C180,$3E00,$06A8,$079F,$0196,$0669
	.dc.w	$E6FC,$37FC,$37FC,$C803,$0380,$0F80,$0000,$FF80
	.dc.w	$0AD0,$19EE,$180E,$07F0,$6B00,$6300,$6300,$1C00
	.dc.w	$0041,$00DE,$00D6,$0029,$A79C,$3EE0,$2000,$DEFF
	.dc.w	$E000,$F000,$F000,$0000,$0568,$0CCC,$0C0C,$03F0
	.dc.w	$2300,$6300,$6300,$1C00,$0051,$00CE,$00C4,$003B
	.dc.w	$8004,$36DF,$3FFB,$C000,$6000,$F000,$7000,$0000
	.dc.w	$0528,$0CCC,$0C0C,$03F0,$3E00,$3F00,$3F00,$0000
	.dc.w	$002B,$0064,$0064,$001B,$679C,$5EE0,$4000,$BEFF
	.dc.w	$C000,$E000,$E000,$0000,$02D0,$0618,$0618,$01E0
	.dc.w	$1C00,$3E00,$3E00,$0000,$003E,$0070,$0070,$000F
	.dc.w	$C381,$C383,$C383,$0000,$8000,$C000,$C000,$0000
	.dc.w	$0120,$0330,$0330,$00C0,$0000,$1C00,$1C00,$0000
	.dc.w	$0011,$0031,$0031,$000E,$8200,$C201,$C201,$0180
	.dc.w	$0000,$8000,$8000,$0000,$00C0,$01E0,$01E0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$000F,$000F,$0000
	.dc.w	$0280,$0100,$0280,$0380,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0100,$0100,$0000,$0100
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base12:		* StarBase (Perspective:1 - Animation:2)
	.dc.w	37,10
	.dc.w	20,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3480,$3080,$3080,$0F00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$AEA0,$B1B0,$B1B0,$4E40
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0E03,$0E03,$0000
	.dc.w	$8050,$FFD8,$F1D8,$0E20,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$1C00,$1C00,$0000
	.dc.w	$0E02,$1F06,$1F06,$0001,$1E28,$FFEC,$F1EC,$0E10
	.dc.w	$0000,$1800,$1800,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$1C00,$3C00,$3C00,$0000,$110D,$318C,$318C,$0E03
	.dc.w	$3F34,$FFC4,$0004,$FFF8,$1800,$3C00,$3C00,$0000
	.dc.w	$1100,$3180,$3180,$0E00,$3E00,$7E00,$7E00,$0000
	.dc.w	$2E99,$60D8,$60D8,$1F07,$3F32,$FBC2,$0002,$FBDC
	.dc.w	$3C00,$7E00,$7E00,$0000,$2E80,$60C0,$60C0,$1F00
	.dc.w	$6600,$E700,$E700,$1800,$3147,$6E47,$6047,$1F80
	.dc.w	$FFFC,$FFFC,$FFFC,$0000,$6600,$E700,$E700,$1800
	.dc.w	$51C0,$4EC0,$40C0,$3F00,$D700,$CB80,$C380,$3C00
	.dc.w	$4ED9,$DB78,$C078,$3B87,$9E73,$7B82,$0002,$FBFD
	.dc.w	$E1E0,$1FE0,$0000,$FFE0,$6E40,$DF60,$C060,$3F80
	.dc.w	$D780,$CB00,$C300,$3C80,$4ED0,$DB60,$C060,$3B9F
	.dc.w	$FBC2,$FFC1,$FFC1,$003E,$DB00,$C380,$C380,$3C00
	.dc.w	$6E40,$DF60,$C060,$3F80,$D6FF,$CA00,$C200,$3DFF
	.dc.w	$4ED9,$DB78,$C078,$3B87,$9E72,$7B82,$0002,$FBFD
	.dc.w	$7C1F,$03FF,$0000,$FFFF,$6E40,$DF60,$C060,$3F80
	.dc.w	$D600,$CA00,$C200,$3D00,$0847,$FFF8,$F7E0,$081F
	.dc.w	$3BF0,$3FF1,$3FF1,$C00E,$DB00,$C380,$C380,$3C00
	.dc.w	$6C00,$DFE0,$C3E0,$3C00,$D6FF,$CA00,$C200,$3DFF
	.dc.w	$48D9,$FF78,$F778,$0887,$9E72,$7B82,$0002,$FBFD
	.dc.w	$7C1F,$03FF,$0000,$FFFF,$6C00,$DFE0,$C3E0,$3C00
	.dc.w	$D700,$CB80,$C380,$3C00,$48C7,$DF78,$D660,$299F
	.dc.w	$3BF1,$3FF0,$3FF0,$C00F,$0F00,$FF80,$0180,$FE00
	.dc.w	$6E40,$DFE0,$C1E0,$3E00,$6A00,$E300,$E300,$1C00
	.dc.w	$2159,$7E58,$7658,$0987,$9E72,$7B82,$0002,$FBFC
	.dc.w	$6600,$E700,$E700,$1800,$5580,$CEC0,$C0C0,$3F00
	.dc.w	$6600,$E700,$E700,$1800,$2144,$7E5F,$745B,$0B80
	.dc.w	$0008,$6DBE,$FFF6,$0000,$6600,$E700,$E700,$1800
	.dc.w	$5180,$4EC0,$40C0,$3F00,$3E00,$7E00,$7E00,$0000
	.dc.w	$0E99,$20D8,$20D8,$1F07,$9E72,$7B82,$0002,$FBFC
	.dc.w	$3C00,$7E00,$7E00,$0000,$2E00,$6080,$6080,$1F00
	.dc.w	$1C00,$3C00,$3C00,$0000,$1100,$1180,$1180,$0E00
	.dc.w	$0E00,$0E00,$0E00,$0000,$1800,$3C00,$3C00,$0000
	.dc.w	$1100,$3100,$3100,$0E00,$0000,$1C00,$1C00,$0000
	.dc.w	$0E00,$1F00,$1F00,$0000,$0800,$0800,$0800,$0600
	.dc.w	$0000,$1800,$1800,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$0000,$0400,$0400,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0400,$0000,$0400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base13:		* StarBase (Perspective:1 - Animation:3)
	.dc.w	36,10
	.dc.w	20,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$6900,$6100,$6100,$1E00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$5D40,$6360,$6360,$9C80
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0003,$0000,$0003,$8007,$8007,$0000
	.dc.w	$00A0,$FFB0,$E3B0,$1C40,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7000,$7000,$0000,$0003,$0C07,$0C07,$0000
	.dc.w	$8004,$C00D,$C00D,$0002,$3C50,$FFD8,$E3D8,$1C20
	.dc.w	$0000,$0180,$0180,$0000,$7000,$F800,$F800,$0000
	.dc.w	$0C04,$3F0C,$3F0C,$0003,$401A,$4019,$4018,$8007
	.dc.w	$7E68,$FF88,$0008,$FFF0,$0180,$03C0,$03C0,$0000
	.dc.w	$8800,$8C00,$8C00,$7000,$3F0B,$7F88,$7F88,$0007
	.dc.w	$A032,$2031,$2030,$C00F,$7E64,$F784,$0004,$F7B8
	.dc.w	$03C0,$07E1,$07E1,$0000,$7400,$0600,$0600,$F800
	.dc.w	$3304,$7393,$7390,$0C0F,$600F,$B00F,$300F,$C000
	.dc.w	$FFF8,$FFF8,$FFF8,$0000,$0621,$0E33,$0E33,$01C0
	.dc.w	$8A00,$7200,$0200,$FC00,$6D9B,$E1F6,$E1F0,$1E0E
	.dc.w	$91F3,$DE30,$1830,$E7CF,$3CE7,$F704,$0004,$F7FB
	.dc.w	$C3F2,$3FFE,$003E,$FFC1,$7400,$D900,$0100,$DE00
	.dc.w	$6D9B,$E1F6,$E1F0,$1E0E,$9021,$D801,$1801,$E03E
	.dc.w	$F784,$FF80,$FF80,$007C,$0D72,$1CBE,$1C3E,$03C1
	.dc.w	$7400,$D900,$0100,$DE00,$6D9B,$E1B6,$E1B0,$1E4E
	.dc.w	$9473,$DFB0,$1830,$E7CF,$3CE4,$F704,$0004,$F7FB
	.dc.w	$F83A,$07FE,$0006,$FFF9,$7400,$D900,$0100,$DE00
	.dc.w	$6D92,$E1BF,$E1BD,$1E42,$1038,$D800,$D800,$203F
	.dc.w	$F7E0,$FFE0,$FFE0,$001C,$0D72,$1CBE,$1C3E,$03C1
	.dc.w	$4000,$FF00,$3F00,$C000,$6D92,$E1BF,$E1BD,$1E42
	.dc.w	$1473,$DFB0,$D830,$27CF,$3CE4,$F704,$0004,$F7FB
	.dc.w	$F83A,$07FE,$0006,$FFF9,$4000,$FF00,$3F00,$C000
	.dc.w	$6D92,$E1FF,$E1FD,$1E02,$1478,$DF80,$9800,$67FF
	.dc.w	$F70E,$FF01,$FF00,$00FF,$1D72,$FCBE,$003E,$FFC1
	.dc.w	$6000,$DF00,$1F00,$C000,$3300,$7397,$7395,$0C0A
	.dc.w	$6033,$B030,$3030,$C00F,$3CE4,$F704,$0004,$F7F8
	.dc.w	$06A1,$0E33,$0E33,$01C0,$A200,$7E00,$0E00,$F000
	.dc.w	$3300,$7397,$7395,$0C0A,$6004,$B03F,$301B,$C000
	.dc.w	$0008,$6DBC,$FFF4,$0000,$0621,$0E33,$0E33,$01C0
	.dc.w	$8200,$7600,$0600,$F800,$1E0B,$3F08,$3F08,$0007
	.dc.w	$8033,$2030,$2030,$C00F,$3CE4,$F704,$0004,$F7F8
	.dc.w	$03C0,$07E1,$07E1,$0000,$7400,$0600,$0600,$F800
	.dc.w	$0C04,$1E0C,$1E0C,$0003,$4000,$4000,$4000,$8000
	.dc.w	$1C00,$1C00,$1C00,$0000,$0180,$03C0,$03C0,$0000
	.dc.w	$8800,$8C00,$8C00,$7000,$0003,$0C07,$0C07,$0000
	.dc.w	$8000,$C000,$C000,$0000,$1000,$1000,$1000,$0C00
	.dc.w	$0000,$0180,$0180,$0000,$7000,$F800,$F800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1400,$0800,$1400,$1C00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$0800,$0000,$0800
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base14:		* StarBase (Perspective:1 - Animation:4)
	.dc.w	33,10
	.dc.w	20,5
	.dc.w	$0000,$0000,$0000,$0000,$0003,$0003,$0003,$0000
	.dc.w	$4800,$0800,$0800,$F000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000A,$001B,$001B,$0004,$EA00,$1B00,$1B00,$E400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0180,$0180,$0000,$0018,$003F,$003F,$0000
	.dc.w	$0500,$FD80,$1D80,$E200,$0000,$000C,$000C,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0180,$1FE0,$1FE0,$0000
	.dc.w	$0021,$006F,$006F,$0010,$E280,$FEC0,$1EC0,$E100
	.dc.w	$000C,$00FF,$00FF,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1660,$3E70,$3E70,$0180,$00D3,$00CF,$00C0,$003F
	.dc.w	$F340,$FC40,$0040,$FF80,$00D3,$01F3,$01F3,$000C
	.dc.w	$0000,$8000,$8000,$0000,$2DB0,$3C38,$3C38,$03C0
	.dc.w	$0193,$018F,$0180,$007F,$F320,$BC20,$0020,$BDC0
	.dc.w	$01AD,$01E1,$01E1,$001E,$8000,$C000,$C000,$0000
	.dc.w	$2A50,$7998,$7818,$07E0,$007F,$007F,$007F,$0000
	.dc.w	$FFC0,$FFC0,$FFC0,$0000,$0152,$03CC,$03C0,$003F
	.dc.w	$8000,$C000,$C000,$0000,$55AA,$F34F,$F00C,$0F73
	.dc.w	$0F99,$F187,$0180,$FE7F,$E73E,$B821,$0020,$BFDF
	.dc.w	$1EAD,$FF9E,$0180,$FE7F,$4000,$6000,$6000,$8000
	.dc.w	$55A8,$F34C,$F00C,$0F70,$010F,$000F,$000F,$01F0
	.dc.w	$BC20,$FC00,$FC00,$03E0,$02AD,$079E,$0780,$007F
	.dc.w	$4000,$6000,$6000,$8000,$55AA,$F34F,$F00C,$0F73
	.dc.w	$0F99,$F187,$0180,$FE7F,$E72F,$B820,$0020,$BFDF
	.dc.w	$82AD,$7F9E,$0180,$FE7F,$4000,$6000,$6000,$8000
	.dc.w	$5268,$FFCC,$FFCC,$0030,$010F,$000F,$000F,$01F0
	.dc.w	$BE00,$FE00,$FE00,$01E0,$02A2,$079F,$078F,$0070
	.dc.w	$4000,$E000,$E000,$0000,$522A,$FFCF,$FF8C,$0073
	.dc.w	$0F99,$F187,$0180,$FE7F,$E72F,$B820,$0020,$BFDF
	.dc.w	$82A2,$7F9F,$018F,$FE70,$4000,$E000,$E000,$0000
	.dc.w	$5A29,$FFCD,$FF8C,$0071,$E30F,$FC0F,$000F,$FFF0
	.dc.w	$BE10,$FE0F,$FE00,$01FF,$E2AA,$E79F,$0787,$E078
	.dc.w	$C000,$E000,$E000,$0000,$2AD0,$7F98,$7F18,$00E0
	.dc.w	$0199,$0187,$0180,$007F,$E720,$B820,$0020,$BFC0
	.dc.w	$0152,$03CF,$03C7,$0038,$8000,$C000,$C000,$0000
	.dc.w	$2E50,$7F98,$7F18,$00E0,$0080,$01ED,$017F,$0000
	.dc.w	$0000,$B6E0,$FFC0,$0000,$0153,$03CF,$03C7,$0038
	.dc.w	$8000,$C000,$C000,$0000,$35A0,$3C30,$3C30,$03C0
	.dc.w	$0199,$0187,$0180,$007F,$E720,$B820,$0020,$BFC0
	.dc.w	$01AD,$01E1,$01E1,$001E,$0000,$8000,$8000,$0000
	.dc.w	$1A40,$3E60,$3E60,$0180,$0000,$0000,$0000,$0000
	.dc.w	$E000,$E000,$E000,$0000,$00D2,$01F3,$01F3,$000C
	.dc.w	$0000,$0000,$0000,$0000,$0180,$1FC0,$1FC0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$8000,$8000,$8000,$6000
	.dc.w	$000C,$00FE,$00FE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0001,$0001
	.dc.w	$1000,$4000,$1000,$5000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4000,$4000,$0000,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base15:		* StarBase (Perspective:1 - Animation:5)
	.dc.w	37,10
	.dc.w	20,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3480,$3080,$3080,$0F00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$AEA0,$B1B0,$B1B0,$4E40
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0600,$0600,$0000,$0001,$0003,$0003,$0000
	.dc.w	$8050,$FFD8,$F1D8,$0E20,$0000,$00E0,$00E0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0600,$1F81,$1F81,$0000
	.dc.w	$0002,$C006,$C006,$0001,$1E28,$FFEC,$F1EC,$0E10
	.dc.w	$00E0,$01F0,$01F0,$0000,$0000,$3800,$3800,$0000
	.dc.w	$1981,$39C3,$39C3,$0600,$C00D,$E00C,$E00C,$0003
	.dc.w	$3F34,$FFC4,$0004,$FFF8,$0110,$0310,$0310,$00E0
	.dc.w	$3800,$7C00,$7C00,$0000,$36C3,$70E7,$70E7,$0F00
	.dc.w	$E019,$E018,$E018,$0007,$3F32,$FBC2,$0002,$FBDC
	.dc.w	$02E8,$0608,$0608,$01F0,$7C00,$FE00,$FE00,$0000
	.dc.w	$2946,$6666,$6066,$1F81,$2007,$3007,$3007,$C000
	.dc.w	$FFFC,$FFFC,$FFFC,$0000,$0504,$0CE4,$0C04,$03F8
	.dc.w	$4600,$C700,$C700,$3800,$56A5,$CF3D,$C03C,$3FC3
	.dc.w	$E0F9,$FF18,$0018,$FFE7,$9E73,$7B82,$0002,$FBFD
	.dc.w	$EAF4,$19A7,$0807,$F7B8,$AB00,$9300,$8300,$7C00
	.dc.w	$56A5,$CF3C,$C03C,$3FC3,$5010,$9800,$1800,$E01F
	.dc.w	$FBC2,$FFC0,$FFC0,$003E,$0AF4,$09A7,$0807,$07B8
	.dc.w	$AB00,$9300,$8300,$7C00,$56AE,$CF3F,$C030,$3FCF
	.dc.w	$0FD9,$F018,$0018,$FFE7,$9E73,$7B82,$0002,$FBFD
	.dc.w	$0AF4,$F9A6,$0806,$F7B9,$AB00,$9300,$8300,$7C00
	.dc.w	$42A5,$FF3C,$FC3C,$03C3,$5001,$9801,$1801,$E01E
	.dc.w	$FB86,$FF80,$FF80,$007E,$0A24,$09FE,$09DE,$0621
	.dc.w	$AB00,$9300,$8300,$7C00,$42AE,$FF3F,$FC30,$03CF
	.dc.w	$0FD9,$F018,$0018,$FFE7,$9E73,$7B82,$0002,$FBFD
	.dc.w	$0A24,$F9FE,$09DE,$F621,$AB00,$9300,$8300,$7C00
	.dc.w	$42A5,$FF3C,$FC3C,$03C3,$5E21,$9FC1,$0001,$FFFE
	.dc.w	$FB87,$FF80,$FF80,$007F,$0A24,$F9FF,$08DF,$F720
	.dc.w	$AB00,$9300,$8300,$7C00,$2146,$7E66,$7866,$0781
	.dc.w	$A019,$3018,$3018,$C007,$9E72,$7B82,$0002,$FBFC
	.dc.w	$050C,$0CFC,$0C5C,$03A0,$5600,$C700,$C700,$3800
	.dc.w	$2146,$7666,$7066,$0F81,$2004,$301F,$301B,$C000
	.dc.w	$0008,$6DBE,$FFF6,$0000,$050C,$0CEC,$0C4C,$03B0
	.dc.w	$4600,$C700,$C700,$3800,$1683,$30C7,$30C7,$0F00
	.dc.w	$E019,$E018,$E018,$0007,$9E72,$7B82,$0002,$FBFC
	.dc.w	$02F8,$0618,$0618,$01E0,$7C00,$7E00,$7E00,$0000
	.dc.w	$0901,$1983,$1983,$0600,$C000,$E000,$E000,$0000
	.dc.w	$0E00,$0E00,$0E00,$0000,$0110,$0310,$0310,$00E0
	.dc.w	$3800,$7C00,$7C00,$0000,$0600,$0F01,$0F01,$0000
	.dc.w	$0000,$C000,$C000,$0000,$0800,$0800,$0800,$0600
	.dc.w	$00E0,$01E0,$01E0,$0000,$0000,$3800,$3800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0A00,$0400,$0A00,$0E00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0400,$0000,$0400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base16:		* StarBase (Perspective:1 - Animation:6)
	.dc.w	38,10
	.dc.w	20,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1A40,$1840,$1840,$0780,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$5750,$D8D8,$D8D8,$2720
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$0001,$0001,$0000
	.dc.w	$C028,$FFEC,$F8EC,$0710,$0000,$0C00,$0C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0E00,$3F00,$3F00,$0000
	.dc.w	$0001,$0703,$0703,$0000,$0F14,$7FF6,$78F6,$8708
	.dc.w	$0C00,$3F00,$3F00,$0000,$0000,$0700,$0700,$0000
	.dc.w	$3100,$7180,$7180,$0E00,$0706,$0F86,$0F86,$0001
	.dc.w	$9F9A,$7FE2,$0002,$FFFC,$3300,$7380,$7380,$0C00
	.dc.w	$0700,$0F80,$0F80,$0000,$6F80,$61C0,$61C0,$1E00
	.dc.w	$0F8C,$0FCC,$0FCC,$0003,$9F99,$7DE1,$0001,$FDEE
	.dc.w	$6D80,$6180,$6180,$1E00,$0F80,$1F80,$1F80,$0000
	.dc.w	$5080,$CEC0,$C0C0,$3F00,$08C3,$18E3,$18E3,$0700
	.dc.w	$FFFE,$FFFE,$FFFE,$0000,$5280,$CCC0,$C0C0,$3F00
	.dc.w	$1880,$38C0,$38C0,$0700,$2F40,$9E60,$8060,$7F80
	.dc.w	$F07C,$FF8C,$000C,$FFF3,$CF38,$3DC1,$0001,$FDFE
	.dc.w	$AD40,$9E60,$8060,$7F80,$3540,$3260,$3060,$0F80
	.dc.w	$2F40,$9E60,$8060,$7F80,$1568,$3260,$3060,$0F8F
	.dc.w	$7DE0,$7FE1,$7FE1,$801E,$AD40,$9E60,$8060,$7F80
	.dc.w	$3540,$3260,$3060,$0F80,$2F5E,$9E7F,$8060,$7F9F
	.dc.w	$0FCC,$F00C,$000C,$FFF3,$CF38,$3DC1,$0001,$FDFE
	.dc.w	$AD5F,$9E60,$8060,$7F9F,$F540,$1260,$1060,$EF80
	.dc.w	$0740,$FE60,$F860,$0780,$1560,$3260,$3060,$0F8F
	.dc.w	$FD8E,$FF81,$FF81,$007E,$8400,$BFE0,$BBE0,$4400
	.dc.w	$3540,$1260,$1060,$2F80,$075E,$FE7F,$F860,$079F
	.dc.w	$0FCC,$F00C,$000C,$FFF3,$CF38,$3DC1,$0001,$FDFE
	.dc.w	$A45F,$9FE0,$9BE0,$641F,$F540,$1260,$1060,$EF80
	.dc.w	$0F40,$FE60,$F060,$0F80,$1F10,$3FE0,$3000,$0FFF
	.dc.w	$FD8E,$FF81,$FF81,$007E,$A440,$9F60,$8B60,$7480
	.dc.w	$3540,$3260,$3060,$0F80,$5480,$6EC0,$60C0,$1F00
	.dc.w	$0ACC,$18EC,$18EC,$0703,$CF39,$3DC1,$0001,$FDFE
	.dc.w	$5080,$CFC0,$CBC0,$3400,$1A80,$38C0,$38C0,$0700
	.dc.w	$5080,$6EC0,$60C0,$1F00,$08C0,$18EE,$18E7,$0700
	.dc.w	$0002,$DB6F,$FFFD,$0000,$5080,$CEC0,$C2C0,$3D00
	.dc.w	$1880,$38C0,$38C0,$0700,$2F00,$6180,$6180,$1E00
	.dc.w	$0F8C,$0FCC,$0FCC,$0003,$CF39,$3DC1,$0001,$FDFE
	.dc.w	$2D00,$6180,$6180,$1E00,$0F80,$1F80,$1F80,$0000
	.dc.w	$1100,$3180,$3180,$0E00,$0700,$0F80,$0F80,$0000
	.dc.w	$0700,$0700,$0700,$0000,$1200,$3300,$3300,$0C00
	.dc.w	$0700,$0F80,$0F80,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0400,$0400,$0400,$0300
	.dc.w	$0C00,$1E00,$1E00,$0000,$0000,$0700,$0700,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0200,$0000,$0200,$0200,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0200,$0200,$0000,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base17:		* StarBase (Perspective:1 - Animation:7)
	.dc.w	40,10
	.dc.w	20,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0690,$0610,$0610,$01E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$15D4,$3634,$3634,$09C8
	.dc.w	$0000,$C000,$C000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0E00,$0E00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3008,$7FFB,$7E3B,$01C4,$C000,$F000,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$0000,$0007,$0007,$0000,$43C3,$DFFF,$DE3F,$21C0
	.dc.w	$3000,$3800,$3800,$C000,$0000,$0060,$0060,$0000
	.dc.w	$1100,$3180,$3180,$0E00,$0007,$0007,$0007,$0000
	.dc.w	$A7E6,$9FFE,$800E,$7FF1,$D800,$1C00,$1C00,$E000
	.dc.w	$0060,$00F0,$00F0,$0000,$2E80,$6080,$6080,$1F00
	.dc.w	$0007,$000F,$000F,$0000,$27ED,$1F7C,$001C,$FF63
	.dc.w	$E800,$0C00,$0C00,$F000,$00F0,$01F8,$01F8,$0000
	.dc.w	$3100,$6E40,$6040,$1F80,$0008,$0018,$0018,$0007
	.dc.w	$FFEB,$FFF8,$FFF8,$0007,$3400,$C600,$0600,$F800
	.dc.w	$0198,$039C,$039C,$0060,$4EC0,$DF60,$C060,$3F80
	.dc.w	$3C1F,$3FE3,$0003,$3FFC,$33D6,$0F71,$0030,$FF4F
	.dc.w	$DA38,$E3F8,$0200,$FDF8,$034C,$072E,$070E,$00F0
	.dc.w	$4EC0,$DF60,$C060,$3F80,$001E,$0038,$0038,$0007
	.dc.w	$1F56,$1FF1,$1FF0,$E00F,$DA00,$E200,$0200,$FC00
	.dc.w	$034C,$0F2E,$070E,$08F0,$4EDF,$DF7F,$C060,$3F9F
	.dc.w	$03F3,$FC03,$0003,$FFFC,$33D6,$0F71,$0030,$FF4F
	.dc.w	$DBFC,$E203,$0200,$FDFF,$034C,$FF2E,$030E,$FCF0
	.dc.w	$0EC0,$FF60,$F060,$0F80,$001C,$0038,$0038,$0007
	.dc.w	$3F54,$3FF3,$3FF3,$C00C,$4200,$FE00,$BE00,$4000
	.dc.w	$034C,$072E,$030E,$04F0,$0EDF,$FF7F,$F060,$0F9F
	.dc.w	$03F3,$FC03,$0003,$FFFC,$33D6,$0F71,$0031,$FF4E
	.dc.w	$43FC,$FA03,$BA00,$45FF,$034C,$FF2E,$030E,$FCF0
	.dc.w	$0EC0,$FF60,$E060,$1F80,$03C4,$03F8,$0000,$03FF
	.dc.w	$3F56,$3FF1,$3FF0,$C00F,$4BC0,$F3C0,$B200,$4DC0
	.dc.w	$034C,$072E,$070E,$00F0,$1500,$6E40,$6040,$1F80
	.dc.w	$000B,$001B,$001B,$0004,$33CB,$0F78,$0018,$FF67
	.dc.w	$0400,$F600,$B600,$4800,$01B8,$039C,$039C,$0060
	.dc.w	$1100,$6E40,$6040,$1F80,$0009,$001B,$001A,$0004
	.dc.w	$000B,$DB68,$FFF8,$0007,$1400,$E600,$2600,$D800
	.dc.w	$0198,$039C,$039C,$0060,$0E80,$2080,$2080,$1F00
	.dc.w	$0007,$000F,$000F,$0000,$33C5,$0F7C,$000C,$FF73
	.dc.w	$C800,$2C00,$2C00,$D000,$00F0,$01F8,$01F8,$0000
	.dc.w	$1100,$1180,$1180,$0E00,$0007,$0007,$0007,$0000
	.dc.w	$01C6,$81CE,$81CE,$0001,$D800,$1C00,$1C00,$E000
	.dc.w	$0060,$00F0,$00F0,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$0000,$0007,$0007,$0000,$0103,$0107,$0107,$00C0
	.dc.w	$3000,$3800,$3800,$C000,$0000,$0060,$0060,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0140,$0081,$0141,$01C0,$0000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0080,$0080,$0000,$0080
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base20:		* StarBase (Perspective:2 - Animation:0)
	.dc.w	34,8
	.dc.w	16,5
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$A800,$8C00,$8C00,$7000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0007,$0007,$0000,$0400,$FD00,$FD00,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1C00,$1E00,$1E00,$0000,$000B,$000B,$000B,$0004
	.dc.w	$9080,$9E80,$9E80,$6100,$0001,$0003,$0003,$0000
	.dc.w	$8000,$8000,$8000,$0000,$3200,$3200,$3200,$0C00
	.dc.w	$0015,$0013,$0013,$000C,$6940,$0E40,$0C40,$F380
	.dc.w	$0002,$0006,$0006,$0001,$4000,$4000,$4000,$8000
	.dc.w	$4D00,$4180,$4180,$3E00,$0013,$0016,$0016,$0009
	.dc.w	$9540,$6640,$0640,$F980,$0001,$0000,$0000,$0007
	.dc.w	$A000,$3000,$3000,$C000,$4500,$4980,$4180,$3E00
	.dc.w	$0013,$0016,$0016,$0009,$D540,$6640,$0640,$F980
	.dc.w	$0008,$0009,$0008,$0007,$A000,$3000,$3000,$C000
	.dc.w	$1A80,$8C80,$8080,$7F40,$71E5,$01EC,$01EC,$7E13
	.dc.w	$6B78,$B378,$0378,$BC87,$7803,$0011,$0010,$F82F
	.dc.w	$1000,$9000,$1000,$E000,$1A9E,$8C9F,$8080,$7F3F
	.dc.w	$1E75,$E07C,$007C,$FF83,$6B77,$B270,$0270,$BD8F
	.dc.w	$8383,$7F91,$0010,$FFCF,$1000,$9000,$1000,$E000
	.dc.w	$1A80,$EC80,$E080,$1F00,$0004,$000F,$000F,$0070
	.dc.w	$4300,$BB00,$BB00,$04F0,$0003,$0011,$0010,$000F
	.dc.w	$0000,$F000,$7000,$8000,$1A9E,$CC9F,$C080,$3F7F
	.dc.w	$1E74,$E07D,$007D,$FF82,$4B77,$B270,$B270,$0D8F
	.dc.w	$8383,$7F91,$0010,$FFEF,$0000,$B000,$3000,$C000
	.dc.w	$5A80,$CC80,$C080,$3F00,$00F4,$00FD,$00FD,$0F02
	.dc.w	$4AF8,$B3F8,$B3F8,$0C07,$0003,$0011,$0010,$800F
	.dc.w	$2000,$B000,$3000,$C000,$4D00,$4180,$4180,$3E00
	.dc.w	$0003,$001E,$001E,$0001,$1440,$E7C0,$A780,$5800
	.dc.w	$0009,$0008,$0008,$0007,$A000,$3000,$3000,$C000
	.dc.w	$2000,$6100,$6100,$1E00,$0014,$0012,$0012,$000D
	.dc.w	$5B40,$AC40,$AC40,$5380,$0004,$000C,$000C,$0003
	.dc.w	$4000,$6000,$6000,$8000,$0C00,$1E00,$1E00,$0000
	.dc.w	$0001,$0001,$0001,$0000,$9000,$9800,$9800,$6000
	.dc.w	$0001,$0003,$0003,$0000,$8000,$8000,$8000,$0000
	.dc.w	$0000,$0C00,$0C00,$0000,$0000,$0001,$0001,$0000
	.dc.w	$6800,$F000,$F800,$0800,$0000,$0001,$0001,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$2000,$0000,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base21:		* StarBase (Perspective:2 - Animation:1)
	.dc.w	33,8
	.dc.w	16,5
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0003,$0003,$0000
	.dc.w	$5000,$1800,$1800,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0006,$00EF,$00EF,$0000,$E800,$1A00,$1A00,$E400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1C00,$1C00,$0000,$0114,$031F,$031F,$00E0
	.dc.w	$E100,$FDC0,$1DC0,$E200,$0006,$000F,$000F,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1C00,$1C00,$1C00,$0000
	.dc.w	$02E9,$020F,$020C,$01F3,$F2C0,$FCE0,$00E0,$FF00
	.dc.w	$0009,$0019,$0019,$0006,$0000,$0000,$0000,$0000
	.dc.w	$2200,$6300,$6300,$1C00,$0115,$04E7,$0404,$03FB
	.dc.w	$F220,$FC30,$0030,$FFC0,$0009,$0026,$0020,$001F
	.dc.w	$8000,$C000,$C000,$0000,$2A00,$6300,$6300,$1C00
	.dc.w	$0154,$04E7,$0404,$03FB,$E6E0,$B8F0,$00F0,$BF00
	.dc.w	$0009,$0026,$0020,$001F,$8000,$C000,$C000,$0000
	.dc.w	$7700,$EB80,$E300,$1C80,$E7F8,$0CA2,$0C02,$F3BD
	.dc.w	$BE78,$FE78,$FE78,$0187,$E036,$006F,$0060,$E01F
	.dc.w	$4000,$6000,$6000,$8000,$7701,$EB7E,$E300,$1C7F
	.dc.w	$F7F8,$0CA3,$0C02,$F3BD,$E6CF,$B8C0,$00C0,$BF3F
	.dc.w	$07B6,$FFEF,$0060,$FF9F,$4000,$6000,$6000,$8000
	.dc.w	$7700,$EB00,$E300,$1C00,$0488,$0FF2,$0F72,$008D
	.dc.w	$BE10,$FE18,$FE18,$01E0,$0036,$006F,$0060,$001F
	.dc.w	$0000,$E000,$E000,$0000,$7701,$EBFE,$E300,$1CFF
	.dc.w	$F498,$0FE3,$0F62,$F09D,$E6CF,$B8C0,$00C0,$BF3F
	.dc.w	$07B6,$FFEF,$0060,$FF9F,$0000,$E000,$E000,$0000
	.dc.w	$7700,$EB00,$E300,$1C00,$0699,$0DE3,$0D63,$129C
	.dc.w	$BF80,$FF80,$FF80,$007F,$0036,$006F,$0060,$001F
	.dc.w	$0000,$E000,$E000,$0000,$2200,$6300,$6300,$1C00
	.dc.w	$0114,$04E7,$0447,$03B8,$0020,$6DB0,$FFB0,$0040
	.dc.w	$0009,$0026,$0020,$001F,$8000,$C000,$C000,$0000
	.dc.w	$1C00,$3E00,$3E00,$0000,$02A8,$024F,$024C,$01B3
	.dc.w	$E6C0,$B8E0,$00E0,$BF00,$0016,$0010,$0010,$000F
	.dc.w	$0000,$8000,$8000,$0000,$0000,$1C00,$1C00,$0000
	.dc.w	$0110,$0318,$0318,$00E0,$8000,$80C0,$80C0,$6000
	.dc.w	$0006,$000F,$000F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00E0,$01F0,$01F0,$0000
	.dc.w	$E000,$0000,$A000,$E000,$0000,$0006,$0006,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4000,$4000,$0000,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base22:		* StarBase (Perspective:2 - Animation:2)
	.dc.w	31,8
	.dc.w	16,4
	.dc.w	$0000,$0000,$0000,$0000,$0005,$000C,$000C,$0003
	.dc.w	$4000,$6000,$6000,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$001B,$003C,$003C,$0003
	.dc.w	$A000,$6800,$6800,$9000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1800,$1800,$0000,$7053,$705F,$705C,$0023
	.dc.w	$8400,$F418,$7418,$8800,$0070,$0070,$0070,$0000
	.dc.w	$3800,$3C00,$3C00,$0000,$00B7,$008F,$0080,$F87F
	.dc.w	$CA18,$F23C,$023C,$FC00,$0088,$0088,$0088,$0070
	.dc.w	$2401,$6603,$6603,$1800,$04B7,$748F,$0480,$F87F
	.dc.w	$CA64,$F266,$0266,$FC18,$0104,$0374,$0304,$00F8
	.dc.w	$6401,$6603,$6603,$1800,$24B3,$748E,$0480,$F87E
	.dc.w	$9A64,$E266,$0266,$FC18,$0124,$0374,$0304,$00F8
	.dc.w	$5B02,$C202,$C202,$3D01,$F866,$5387,$0207,$DDF8
	.dc.w	$F9E3,$F9E0,$F9E0,$061F,$82F8,$0272,$0202,$81FC
	.dc.w	$59FE,$C002,$C002,$3FFD,$F9B3,$538E,$0380,$DC7E
	.dc.w	$9B7C,$E303,$0300,$FCFF,$3EF8,$FE72,$0202,$FDFC
	.dc.w	$5800,$C003,$C003,$3E00,$4066,$FB87,$BA07,$45F8
	.dc.w	$F85A,$F8C3,$F8C3,$073C,$02E0,$027E,$021E,$01E0
	.dc.w	$5BFE,$C203,$C203,$3DFC,$49B3,$F38E,$B380,$4C7E
	.dc.w	$9B7C,$E303,$0300,$FCFF,$3EF0,$FE7E,$020E,$FDF0
	.dc.w	$5A02,$C302,$C302,$3C01,$481E,$F21F,$B21F,$4DE0
	.dc.w	$FE02,$FE03,$FE03,$01FC,$02F0,$027E,$020E,$01F0
	.dc.w	$2401,$6603,$6603,$1800,$0440,$74F6,$24BF,$D800
	.dc.w	$0464,$DE66,$FA66,$0018,$0104,$037C,$030C,$00F0
	.dc.w	$3800,$7C01,$7C01,$0000,$F8B3,$8C8E,$8C80,$707E
	.dc.w	$9A3C,$E27C,$027C,$FC00,$00F8,$018C,$018C,$0070
	.dc.w	$0000,$1800,$1800,$0000,$7002,$7002,$7002,$0001
	.dc.w	$0000,$0018,$0018,$8000,$0070,$0070,$0070,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$7000,$7001,$0001
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0070,$0070,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0000,$0001
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base23:		* StarBase (Perspective:2 - Animation:3)
	.dc.w	30,8
	.dc.w	16,4
	.dc.w	$0000,$0000,$0000,$0000,$000A,$0018,$0018,$0007
	.dc.w	$8000,$C000,$C000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0037,$0078,$0078,$0007
	.dc.w	$4000,$D000,$D000,$2000,$0000,$0000,$0000,$0000
	.dc.w	$000C,$181E,$181E,$0000,$00A7,$00BF,$00B8,$0047
	.dc.w	$0800,$E803,$E803,$1000,$0180,$03C0,$03C0,$0000
	.dc.w	$1812,$1C13,$1C13,$000C,$016F,$011F,$0100,$00FF
	.dc.w	$9403,$E407,$0407,$F800,$0240,$8660,$8660,$0180
	.dc.w	$2632,$676C,$6760,$181F,$016F,$811F,$8100,$00FF
	.dc.w	$9404,$E40C,$040C,$F803,$C240,$E990,$E810,$07E0
	.dc.w	$2E32,$676C,$6760,$181F,$0167,$811D,$8100,$00FD
	.dc.w	$3405,$C40C,$040C,$F803,$C240,$E990,$E810,$07E0
	.dc.w	$734D,$EBDE,$E3C0,$1C3F,$A71D,$C61F,$C61F,$39E0
	.dc.w	$F3C3,$F3C0,$F3C0,$0C3F,$EDB0,$3BD8,$3818,$C7E0
	.dc.w	$734D,$EBDE,$E3C0,$1C3F,$A767,$FB1D,$C300,$3CFD
	.dc.w	$36F8,$C607,$0600,$F9FF,$6DB0,$FBD8,$1818,$E7E0
	.dc.w	$7349,$EBFF,$E3F7,$1C08,$831D,$C01F,$C01F,$03E0
	.dc.w	$F00A,$F019,$F018,$0E07,$6D10,$7BF8,$78F8,$8700
	.dc.w	$7349,$EBFE,$E3F6,$1C09,$A767,$FB1D,$C300,$3CFD
	.dc.w	$36F8,$C607,$0600,$F9FF,$6D10,$FBF8,$18F8,$E700
	.dc.w	$7349,$EBDE,$E3D4,$1C2B,$80FD,$C0FF,$C0FF,$3F00
	.dc.w	$FE00,$FE01,$FE00,$01FF,$6D10,$7BF8,$78F8,$8700
	.dc.w	$2622,$677C,$6770,$180F,$0000,$81B6,$81FF,$0000
	.dc.w	$0004,$DC0C,$F80C,$0003,$C200,$E9B0,$E830,$07C0
	.dc.w	$1C0D,$3E21,$3E21,$001E,$0167,$011D,$0100,$00FD
	.dc.w	$3407,$C407,$0407,$F800,$85A0,$C420,$C420,$03C0
	.dc.w	$000C,$181E,$181E,$0000,$0004,$0004,$0004,$0003
	.dc.w	$0000,$0003,$0003,$0000,$0180,$03C0,$03C0,$0000
	.dc.w	$0000,$000C,$000C,$0000,$0007,$0000,$0005,$0007
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0180,$0180,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0002,$0002,$0000,$0002
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base24:		* StarBase (Perspective:2 - Animation:4)
	.dc.w	27,8
	.dc.w	16,4
	.dc.w	$0000,$0000,$0000,$0000,$0054,$00C6,$00C6,$0038
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$01BA,$03C6,$03C6,$0039
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0700,$3F00,$3F00,$0000,$0538,$05FF,$05C7,$0238
	.dc.w	$4000,$4001,$4001,$8000,$3000,$F800,$F800,$0000
	.dc.w	$3880,$3880,$3880,$0700,$0B7C,$08FF,$0800,$07FF
	.dc.w	$A001,$2003,$2003,$C000,$4800,$C800,$C800,$3000
	.dc.w	$5040,$F740,$F040,$0F80,$0B7C,$08FF,$0800,$07FF
	.dc.w	$A006,$2007,$2007,$C000,$4C00,$3600,$0600,$F800
	.dc.w	$5240,$F740,$F040,$0F80,$0B39,$08EE,$0800,$07EF
	.dc.w	$A006,$2007,$2007,$C000,$6C00,$3600,$0600,$F800
	.dc.w	$EF9C,$E520,$E020,$1DDF,$78EF,$78FF,$78FF,$8700
	.dc.w	$1C75,$1C0F,$1C0F,$E3F0,$B200,$5B00,$0300,$DC00
	.dc.w	$EF98,$E53F,$E020,$1DDF,$FB39,$18EE,$1800,$E7EF
	.dc.w	$B785,$307F,$3003,$CFFC,$B200,$5B00,$0300,$DC00
	.dc.w	$E080,$FF20,$FF20,$00C0,$10EF,$00FF,$00FF,$1F00
	.dc.w	$0005,$000F,$000F,$F000,$8A00,$7F00,$3F00,$C000
	.dc.w	$E098,$FF3F,$FF20,$00DF,$FB39,$18EE,$1800,$E7EF
	.dc.w	$B785,$307F,$3003,$CFFC,$8A00,$7F00,$3F00,$C000
	.dc.w	$F180,$FF20,$FE20,$01C7,$0FEF,$0FFF,$0FFF,$F000
	.dc.w	$E005,$E00F,$E00F,$1FC0,$8E00,$7F00,$3F00,$C000
	.dc.w	$5840,$FF40,$FC40,$0380,$0800,$0EDB,$07FF,$0000
	.dc.w	$0006,$6007,$E007,$0000,$4C00,$3E00,$1E00,$E000
	.dc.w	$2F80,$78C0,$78C0,$0700,$0B39,$08EE,$0800,$07EF
	.dc.w	$A003,$2007,$2007,$C000,$B000,$8400,$8400,$7800
	.dc.w	$0700,$3F00,$3F00,$0000,$0020,$0020,$0020,$0018
	.dc.w	$0000,$0001,$0001,$0000,$3000,$F800,$F800,$0000
	.dc.w	$0000,$0700,$0700,$0000,$0054,$0000,$0044,$0054
	.dc.w	$0000,$0000,$0000,$0000,$0000,$3000,$3000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0010,$0010,$0000,$0010
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base25:		* StarBase (Perspective:2 - Animation:5)
	.dc.w	30,8
	.dc.w	16,4
	.dc.w	$0000,$0000,$0000,$0000,$000A,$0018,$0018,$0007
	.dc.w	$8000,$C000,$C000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0037,$0078,$0078,$0007
	.dc.w	$4000,$D000,$D000,$2000,$0000,$0000,$0000,$0000
	.dc.w	$1C00,$1C0C,$1C0C,$0000,$00A7,$00BF,$00B8,$0047
	.dc.w	$0803,$E807,$E807,$1000,$8000,$8180,$8180,$0000
	.dc.w	$260C,$261E,$261E,$1800,$016F,$011F,$0100,$00FF
	.dc.w	$9404,$E404,$0404,$F803,$C180,$C3C0,$C3C0,$0000
	.dc.w	$4513,$D933,$C133,$3E0C,$016F,$011F,$0100,$00FF
	.dc.w	$940C,$E41B,$0418,$F807,$A660,$2660,$2660,$C180
	.dc.w	$4D13,$D933,$C133,$3E0C,$0167,$011D,$0100,$00FD
	.dc.w	$340D,$C41B,$0418,$F807,$A660,$2660,$2660,$C180
	.dc.w	$BA2F,$94E0,$80E0,$771F,$E67D,$067F,$067F,$F980
	.dc.w	$C733,$C316,$C310,$3CEE,$45A0,$9C30,$1C30,$E3C0
	.dc.w	$BA70,$94FF,$8080,$777F,$FB67,$031D,$0300,$FCFD
	.dc.w	$3713,$C6F6,$0610,$F9EE,$45A0,$9430,$1430,$EBC0
	.dc.w	$822D,$FCE1,$F8E1,$071E,$007D,$807F,$807F,$0380
	.dc.w	$C610,$C017,$C017,$3E08,$05A0,$F430,$F430,$0BC0
	.dc.w	$8A70,$F4FF,$F080,$077F,$FB67,$031D,$0300,$FCFD
	.dc.w	$3710,$C6F7,$0617,$F9E8,$05A0,$FC30,$FC30,$03C0
	.dc.w	$8A2D,$F4E1,$F0E1,$071E,$01FD,$01FF,$01FF,$FE00
	.dc.w	$F810,$F817,$F813,$07EC,$05A0,$DC30,$DC30,$23C0
	.dc.w	$4513,$F933,$E133,$1E0C,$0080,$01ED,$017F,$0000
	.dc.w	$000C,$B41B,$FC19,$0006,$2660,$A660,$A660,$4180
	.dc.w	$3A1E,$631F,$631F,$1C00,$0167,$011D,$0100,$00FD
	.dc.w	$3403,$C408,$0408,$F807,$43C0,$67E0,$67E0,$8000
	.dc.w	$1800,$1C0C,$1C0C,$0000,$0004,$0004,$0004,$0003
	.dc.w	$0003,$0007,$0007,$0000,$0000,$8180,$8180,$0000
	.dc.w	$0000,$1800,$1800,$0000,$0007,$0000,$0005,$0007
	.dc.w	$0000,$0003,$0003,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0002,$0002,$0000,$0002
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base26:		* StarBase (Perspective:2 - Animation:6)
	.dc.w	32,8
	.dc.w	16,4
	.dc.w	$0000,$0000,$0000,$0000,$0002,$0006,$0006,$0001
	.dc.w	$A000,$3000,$3000,$C000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000D,$001E,$001E,$0001
	.dc.w	$D000,$3400,$3400,$C800,$0000,$0000,$0000,$0000
	.dc.w	$0C00,$1E00,$1E00,$0000,$0029,$382F,$382E,$0011
	.dc.w	$C20C,$FA1E,$3A1E,$C400,$0000,$0038,$0038,$0000
	.dc.w	$1200,$3200,$3200,$0C00,$385B,$3847,$3840,$003F
	.dc.w	$E512,$F932,$0132,$FE0C,$0038,$0038,$0038,$0000
	.dc.w	$1300,$4D80,$4180,$3E00,$445B,$C647,$C640,$383F
	.dc.w	$E513,$F94D,$0141,$FE3E,$0044,$80C6,$80C6,$0038
	.dc.w	$1300,$4D80,$4180,$3E00,$5459,$C647,$C640,$383F
	.dc.w	$CD13,$714D,$0141,$7E3E,$0054,$80C6,$80C6,$0038
	.dc.w	$6C81,$DEC0,$C0C0,$3F01,$C79F,$079F,$079F,$F860
	.dc.w	$666C,$E1DE,$E0C0,$1F3F,$B0EE,$C0D6,$C0C6,$3138
	.dc.w	$6CB8,$DEFF,$C0C0,$3F3F,$3CD9,$C0C7,$00C0,$FF3F
	.dc.w	$CD6C,$71DE,$01C0,$7E3F,$BFEE,$C056,$C046,$3FB8
	.dc.w	$0480,$FEC1,$F8C1,$0700,$EE1F,$D61F,$C61F,$38E0
	.dc.w	$6644,$E1FF,$E0FB,$1F04,$00EE,$C056,$C046,$00B8
	.dc.w	$4CB8,$FEFF,$F0C0,$0F3F,$3CD9,$C0C7,$00C0,$FF3F
	.dc.w	$CD64,$71DF,$01DB,$7E24,$BEEE,$C0D6,$C0C6,$3F38
	.dc.w	$4C80,$FEC1,$F0C1,$0F00,$C07F,$C07F,$C07F,$3F80
	.dc.w	$7864,$F8DE,$F8CA,$0735,$80EE,$C1D6,$C1C6,$0038
	.dc.w	$1300,$6D80,$6180,$1E00,$4400,$C66D,$C67F,$3800
	.dc.w	$0011,$B74F,$FE4B,$0034,$0044,$80C6,$80C6,$0038
	.dc.w	$2C00,$2100,$2100,$1E00,$3859,$7C47,$7C40,$003F
	.dc.w	$CD2C,$7121,$0121,$7E1E,$0038,$007C,$007C,$0000
	.dc.w	$0C00,$1E00,$1E00,$0000,$0001,$3801,$3801,$0000
	.dc.w	$000C,$001E,$001E,$C000,$0000,$0038,$0038,$0000
	.dc.w	$0000,$0C00,$0C00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$000C,$800C,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$8000,$0000,$8000,$0000,$0000,$0000,$0000
base27:		* StarBase (Perspective:2 - Animation:7)
	.dc.w	33,8
	.dc.w	16,5
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0003,$0003,$0000
	.dc.w	$5000,$1800,$1800,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0006,$000F,$000F,$0000,$E800,$1BE0,$1BE0,$E400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1C00,$1C00,$1C00,$0000,$0014,$00F7,$00F7,$0008
	.dc.w	$E320,$FF30,$1F30,$E0C0,$0000,$0006,$0006,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2200,$2200,$2200,$1C00
	.dc.w	$00ED,$00E3,$00E0,$001F,$F2D0,$FE18,$0618,$F9E0
	.dc.w	$0006,$000F,$000F,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4100,$DD00,$C100,$3E00,$010D,$0303,$0300,$00FF
	.dc.w	$F728,$FCCC,$0C0C,$F3F0,$0019,$0019,$0019,$0006
	.dc.w	$0000,$8000,$8000,$0000,$4900,$DD00,$C100,$3E00
	.dc.w	$012C,$0323,$0320,$00DF,$E7A8,$BCCC,$0C0C,$B3F0
	.dc.w	$0019,$0019,$0019,$0006,$0000,$8000,$8000,$0000
	.dc.w	$BE00,$9C80,$8080,$7F00,$E38F,$038F,$038F,$FC70
	.dc.w	$AAD4,$F964,$F804,$077B,$E016,$0070,$0030,$E04F
	.dc.w	$8000,$C000,$C000,$0000,$BE7C,$9CFF,$8080,$7F7F
	.dc.w	$3E6C,$C063,$0060,$FF9F,$EAD7,$B964,$1804,$A77B
	.dc.w	$F016,$0FF0,$0010,$FFEF,$8000,$C000,$C000,$0000
	.dc.w	$1E00,$FC80,$E080,$1F00,$038F,$030F,$030F,$00F0
	.dc.w	$A844,$FBFC,$FBBC,$0440,$0016,$0030,$0010,$002F
	.dc.w	$8000,$C000,$C000,$0000,$1E7C,$FCFF,$E080,$1F7F
	.dc.w	$3EEC,$C063,$0060,$FF9F,$EA47,$B9F4,$19B4,$A64B
	.dc.w	$F016,$0FF0,$0030,$FFCF,$8000,$C000,$C000,$0000
	.dc.w	$1E00,$FC80,$E080,$1F00,$003F,$003F,$003F,$1FC0
	.dc.w	$AA44,$F9F4,$F9B4,$064B,$0016,$0030,$0030,$000F
	.dc.w	$8000,$C000,$C000,$0000,$0100,$DD00,$C100,$3E00
	.dc.w	$0120,$033B,$031F,$00C0,$0708,$7CEC,$FCAC,$0350
	.dc.w	$0019,$0019,$0019,$0006,$0000,$8000,$8000,$0000
	.dc.w	$3E00,$6300,$6300,$1C00,$00EC,$01E3,$01E0,$001F
	.dc.w	$E150,$BCB8,$04B8,$BB40,$000F,$001F,$001F,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1C00,$1C00,$1C00,$0000
	.dc.w	$0000,$00E0,$00E0,$0000,$8320,$8330,$8330,$60C0
	.dc.w	$0000,$0006,$0006,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1C00,$1C00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$E0C0,$03E0,$A3E0,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4000,$4000,$0000,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base30:		* StarBase (Perspective:3 - Animation:0)
	.dc.w	28,7
	.dc.w	13,4
	.dc.w	$0000,$0000,$0000,$0000,$002C,$0024,$0024,$0018
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00C2,$00FE,$00FE,$0001
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1800,$3800,$3800,$0000,$01A4,$01E7,$01E7,$0018
	.dc.w	$0000,$4000,$4000,$8000,$1800,$1C00,$1C00,$0000
	.dc.w	$2000,$2400,$2400,$1800,$025C,$02C7,$02C6,$0139
	.dc.w	$C000,$4000,$4000,$8000,$0400,$2400,$2400,$1800
	.dc.w	$5A00,$4200,$4200,$3C00,$02A6,$039B,$0383,$007C
	.dc.w	$8000,$0000,$0000,$C000,$5A00,$4200,$4200,$3C00
	.dc.w	$2000,$9900,$8100,$7E03,$E05D,$FF29,$FF01,$00EE
	.dc.w	$0700,$3F00,$3F00,$C0C0,$0400,$9900,$8100,$7E00
	.dc.w	$2070,$997F,$8100,$7EFF,$E65D,$0729,$0701,$F8EE
	.dc.w	$A70E,$20FE,$2000,$DFFF,$0400,$9900,$8100,$7E00
	.dc.w	$2070,$D97F,$C100,$3EFF,$E051,$012D,$012D,$FEC2
	.dc.w	$870E,$80FE,$8000,$7FFF,$0400,$9B00,$8300,$7C00
	.dc.w	$6000,$D900,$C100,$3E00,$3255,$3F29,$3F29,$40C6
	.dc.w	$8C00,$3C00,$3C00,$C300,$0600,$9B00,$8300,$7C00
	.dc.w	$5A00,$4200,$4200,$3C00,$00A6,$039B,$038B,$0074
	.dc.w	$4000,$C000,$8000,$0000,$5A00,$4200,$4200,$3C00
	.dc.w	$0400,$4600,$4600,$3800,$0271,$02CA,$02CA,$0135
	.dc.w	$8000,$0000,$0000,$C000,$2000,$6200,$6200,$1C00
	.dc.w	$1800,$3800,$3800,$0000,$0024,$0064,$0064,$0018
	.dc.w	$0000,$0000,$0000,$0000,$1800,$1C00,$1C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0038,$0038,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base31:		* StarBase (Perspective:3 - Animation:1)
	.dc.w	27,7
	.dc.w	13,4
	.dc.w	$0000,$0000,$0000,$0000,$0058,$0048,$0048,$0030
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$01B4,$1DCD,$1DCD,$0032
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1000,$1000,$0000,$1338,$33FE,$33CE,$0C31
	.dc.w	$0000,$C000,$C000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$1000,$3800,$3800,$0000,$2E79,$23FE,$2300,$1CFF
	.dc.w	$C000,$E000,$E000,$0000,$5000,$D800,$D800,$2000
	.dc.w	$6C00,$6C00,$6C00,$1000,$133B,$4DEC,$4180,$3E6F
	.dc.w	$6000,$7001,$7001,$8000,$5000,$2400,$0400,$F800
	.dc.w	$4401,$D601,$C601,$3802,$6EEE,$D4FE,$C0FE,$3701
	.dc.w	$0701,$3F01,$3F01,$C0C0,$AC00,$7400,$0400,$F800
	.dc.w	$440F,$D7F0,$C400,$3BFF,$6EBB,$D4EC,$C080,$376F
	.dc.w	$6E1F,$61FF,$6001,$9FFE,$AC00,$7400,$0400,$F800
	.dc.w	$440F,$D7F0,$C400,$3BFF,$42AF,$FCBF,$FCBF,$0340
	.dc.w	$0E1F,$01FF,$0001,$FFFE,$A000,$7C00,$0C00,$F000
	.dc.w	$4400,$D600,$C600,$3800,$62BB,$DCEC,$DC80,$236F
	.dc.w	$4C01,$7C01,$7C01,$8200,$A800,$7400,$0400,$F800
	.dc.w	$6C00,$6C00,$6C00,$1000,$0380,$5DED,$597F,$2600
	.dc.w	$2000,$B001,$B001,$4000,$5000,$2400,$0400,$F800
	.dc.w	$3800,$7C00,$7C00,$0000,$24BB,$396C,$3900,$06EF
	.dc.w	$6000,$6000,$6000,$8000,$A800,$8800,$8800,$7000
	.dc.w	$0000,$1000,$1000,$0000,$1228,$3200,$3228,$0C38
	.dc.w	$0000,$C000,$C000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1C10,$1C00,$0010
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base32:		* StarBase (Perspective:3 - Animation:2)
	.dc.w	26,7
	.dc.w	13,4
	.dc.w	$0000,$0000,$0000,$0000,$00B0,$0090,$0090,$0060
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0368,$039A,$039A,$0064
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$1803,$1803,$0000,$8670,$87FD,$879D,$0062
	.dc.w	$0001,$0801,$0801,$0000,$8000,$C000,$C000,$0000
	.dc.w	$1806,$3806,$3806,$0001,$4AF3,$49FD,$4801,$87FE
	.dc.w	$1802,$1C02,$1C02,$0001,$4000,$4000,$4000,$8000
	.dc.w	$2406,$640D,$640C,$1803,$0B76,$A8D8,$2800,$C7DF
	.dc.w	$3404,$3605,$3604,$0803,$6000,$B000,$3000,$C000
	.dc.w	$4C09,$D60A,$C608,$3806,$E1DC,$B1FC,$31FC,$CE03
	.dc.w	$1C47,$FC0D,$FC0C,$03C3,$9000,$D000,$1000,$E000
	.dc.w	$4FF9,$D40A,$C408,$3BF6,$FB76,$B8D8,$3800,$C7DF
	.dc.w	$F0F7,$F00D,$F00C,$0FF3,$9000,$D000,$1000,$E000
	.dc.w	$4FF8,$D40F,$C40F,$3BF0,$64DE,$B8FE,$A0FE,$5F01
	.dc.w	$F0F7,$F00D,$F00C,$0FF3,$8000,$F000,$7000,$8000
	.dc.w	$4C08,$D60B,$C60B,$3804,$6B76,$B8D8,$B800,$47DF
	.dc.w	$1807,$F90D,$F90C,$0603,$9000,$F000,$7000,$8000
	.dc.w	$2404,$640F,$640F,$1800,$0402,$BF6F,$3BFD,$C000
	.dc.w	$3400,$3605,$3604,$0803,$6000,$B000,$3000,$C000
	.dc.w	$3801,$3C04,$3C04,$0003,$CB76,$48D8,$4800,$87DF
	.dc.w	$1C03,$3C02,$3C02,$0001,$8000,$2000,$2000,$C000
	.dc.w	$0001,$1803,$1803,$0000,$8060,$8040,$8060,$0020
	.dc.w	$0001,$0801,$0801,$0000,$8000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0020,$0000,$0020
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base33:		* StarBase (Perspective:3 - Animation:3)
	.dc.w	24,7
	.dc.w	13,4
	.dc.w	$0000,$0000,$0000,$0000,$02C0,$0240,$0240,$0180
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0DA0,$0E68,$0E68,$0190
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0060,$3070,$3070,$0000,$19C0,$1FF4,$1E74,$0188
	.dc.w	$000C,$060E,$060E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3090,$7090,$7090,$0060,$2BCC,$27F4,$2004,$1FF8
	.dc.w	$0612,$0E12,$0E12,$000C,$0000,$0000,$0000,$0000
	.dc.w	$4918,$CD68,$CD08,$30F0,$2DD8,$2360,$2000,$1F7C
	.dc.w	$0923,$19AD,$19A1,$061E,$0000,$0000,$0000,$0000
	.dc.w	$BCE1,$8E75,$8E05,$71FA,$0770,$C7F3,$C7F3,$380C
	.dc.w	$719C,$F1CE,$F1C0,$0E3F,$0000,$8000,$8000,$0000
	.dc.w	$BCE2,$8E77,$8E04,$71FB,$6DDB,$E363,$6003,$9F7C
	.dc.w	$C39C,$C04E,$C040,$3FBF,$0000,$8000,$8000,$0000
	.dc.w	$BC42,$8FF7,$8FB4,$704B,$637B,$83FB,$03FB,$FC04
	.dc.w	$C398,$C04F,$C047,$3FB8,$0000,$8000,$8000,$0000
	.dc.w	$BC41,$8EF5,$8EA5,$715A,$2DD8,$E363,$E003,$1F7C
	.dc.w	$C798,$C1CF,$C1C7,$3E38,$0000,$8000,$8000,$0000
	.dc.w	$4918,$CD68,$CD08,$30F0,$0804,$3EDC,$37F8,$0000
	.dc.w	$0921,$19AD,$19A1,$061E,$0000,$0000,$0000,$0000
	.dc.w	$70E0,$7988,$7988,$0070,$2DD8,$2360,$2000,$1F7C
	.dc.w	$0E1C,$0F31,$0F31,$000E,$0000,$0000,$0000,$0000
	.dc.w	$0060,$3070,$3070,$0000,$0140,$0000,$0140,$01C0
	.dc.w	$000C,$060E,$060E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0080,$0000,$0080
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base34:		* StarBase (Perspective:3 - Animation:4)
	.dc.w	23,7
	.dc.w	13,3
	.dc.w	$0000,$0000,$0000,$0000,$0580,$0480,$0480,$0300
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1B40,$1CD0,$1CD0,$0320,$0000,$0000,$0000,$0000
	.dc.w	$0600,$1F00,$1F00,$0000,$3380,$3FE8,$3CE8,$0310
	.dc.w	$0060,$01F0,$01F0,$0000,$1900,$3900,$3900,$0600
	.dc.w	$5798,$4FE8,$4008,$3FF0,$0110,$0390,$0390,$0060
	.dc.w	$3180,$7680,$7080,$0F00,$5BB0,$46C0,$4000,$3EF8
	.dc.w	$0218,$076C,$070C,$00F0,$4E0C,$E74F,$E04F,$1FB0
	.dc.w	$0EE0,$8FE7,$8FE7,$7018,$E1E4,$E354,$E304,$1CD8
	.dc.w	$4E33,$E743,$E043,$1FBC,$DBB7,$C6C7,$C007,$3EF8
	.dc.w	$1DE4,$0354,$0304,$FCD8,$4031,$FF41,$FE41,$01BE
	.dc.w	$CEE7,$CFE7,$CFE7,$3018,$1D94,$037C,$037C,$FC80
	.dc.w	$5206,$FF47,$FC47,$0398,$5BB1,$C6C7,$C007,$3EF8
	.dc.w	$85DC,$877C,$873C,$60C0,$3980,$7E80,$7C80,$0300
	.dc.w	$4000,$76D8,$3FF8,$0000,$0218,$077C,$071C,$00E0
	.dc.w	$2E00,$3880,$3880,$0700,$5BB0,$46C0,$4000,$3EF8
	.dc.w	$03E0,$0388,$0388,$0070,$0600,$1F00,$1F00,$0000
	.dc.w	$0640,$0200,$0640,$0540,$0060,$01F0,$01F0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0100,$0000,$0100
	.dc.w	$0000,$0000,$0000,$0000
base35:		* StarBase (Perspective:3 - Animation:5)
	.dc.w	25,7
	.dc.w	13,4
	.dc.w	$0000,$0000,$0000,$0000,$0160,$0120,$0120,$00C0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$06D0,$0734,$0734,$00C8
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1800,$3830,$3830,$0000,$0CE0,$0FFA,$0F3A,$00C4
	.dc.w	$0300,$0706,$0706,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2430,$2438,$2438,$1800,$15E6,$13FA,$1002,$0FFC
	.dc.w	$0586,$0587,$0587,$0200,$0000,$0000,$0000,$0000
	.dc.w	$6248,$5ACC,$42CC,$3C30,$16EC,$11B0,$1000,$0FBE
	.dc.w	$0C49,$0B59,$0859,$0786,$0000,$8000,$8000,$0000
	.dc.w	$1CC7,$B9C7,$81C7,$7E38,$03B8,$E3F9,$E3F9,$1C06
	.dc.w	$439E,$D738,$D038,$2FC7,$8000,$8000,$8000,$0000
	.dc.w	$1CC6,$B904,$8104,$7EFB,$76ED,$71B1,$7001,$8FBE
	.dc.w	$A39E,$9738,$9038,$6FC7,$8000,$8000,$8000,$0000
	.dc.w	$0CC6,$F904,$F104,$0EFB,$67B3,$67F1,$67F1,$980E
	.dc.w	$A11E,$97F8,$96F8,$6907,$8000,$8000,$8000,$0000
	.dc.w	$0CF1,$F9C1,$F1C1,$0E3E,$96EC,$F1B1,$F001,$0FBE
	.dc.w	$411E,$D7B8,$D2B8,$2D47,$8000,$8000,$8000,$0000
	.dc.w	$4248,$5ACC,$42CC,$3C30,$0800,$1EDA,$17FE,$0000
	.dc.w	$0C49,$0B59,$0859,$0786,$0000,$8000,$8000,$0000
	.dc.w	$1C38,$4678,$4678,$3800,$16EC,$11B0,$1000,$0FBE
	.dc.w	$0387,$08CF,$08CF,$0700,$0000,$0000,$0000,$0000
	.dc.w	$1800,$3830,$3830,$0000,$00A0,$0000,$00A0,$00E0
	.dc.w	$0300,$0706,$0706,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0040,$0000,$0040
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base36:		* StarBase (Perspective:3 - Animation:6)
	.dc.w	26,7
	.dc.w	13,4
	.dc.w	$0000,$0000,$0000,$0000,$00B0,$0090,$0090,$0060
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0368,$039A,$039A,$0064
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3800,$3801,$3801,$0000,$0670,$87FD,$879D,$0062
	.dc.w	$1C00,$1C01,$1C01,$0000,$0000,$8000,$8000,$0000
	.dc.w	$6401,$6403,$6403,$1800,$8AF3,$89FD,$8801,$07FE
	.dc.w	$3601,$3601,$3601,$0800,$C000,$C000,$C000,$0000
	.dc.w	$6202,$DA06,$C206,$3C01,$4B76,$48D8,$4800,$87DF
	.dc.w	$1602,$4B02,$4302,$3C01,$4000,$6000,$6000,$8000
	.dc.w	$9E03,$BB03,$8303,$7C1C,$81DC,$F1FC,$F1FC,$0E03
	.dc.w	$6903,$5506,$4106,$B601,$2000,$B000,$3000,$C000
	.dc.w	$9EF0,$BB00,$8300,$7CFF,$FB76,$F8D8,$F800,$07DF
	.dc.w	$E9FF,$D502,$C102,$36FD,$2000,$B000,$3000,$C000
	.dc.w	$1EF0,$FB00,$E300,$1CFF,$F3D3,$F3F0,$F3F0,$0C0F
	.dc.w	$61FF,$DF02,$5F02,$A0FD,$2000,$B000,$3000,$C000
	.dc.w	$9E04,$FB0C,$E30C,$1C03,$CB76,$F8D8,$F800,$07DF
	.dc.w	$E103,$DD06,$CD06,$3201,$2000,$B000,$3000,$C000
	.dc.w	$6002,$DA06,$C206,$3C01,$4201,$4FB7,$4DFE,$8000
	.dc.w	$1202,$4F02,$4F02,$3001,$4000,$6000,$6000,$8000
	.dc.w	$1C03,$4403,$4403,$3800,$8B76,$C8D8,$C800,$07DF
	.dc.w	$2001,$2203,$2203,$1C00,$C000,$C000,$C000,$0000
	.dc.w	$1800,$3801,$3801,$0000,$0060,$8040,$8060,$0020
	.dc.w	$0800,$1C01,$1C01,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0020,$0000,$0020
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
base37:		* StarBase (Perspective:3 - Animation:7)
	.dc.w	27,7
	.dc.w	13,4
	.dc.w	$0000,$0000,$0000,$0000,$0058,$0048,$0048,$0030
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$01B4,$01CD,$01CD,$0032
	.dc.w	$0000,$E000,$E000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3800,$3800,$3800,$0000,$0338,$0FFF,$0FCF,$0030
	.dc.w	$2000,$3000,$3000,$C000,$0000,$2000,$2000,$0000
	.dc.w	$6C00,$6C00,$6C00,$1000,$0D79,$1CFF,$1C03,$03FC
	.dc.w	$D000,$1800,$1800,$E000,$7000,$7000,$7000,$0000
	.dc.w	$2C00,$9600,$8600,$7800,$1DBB,$3C6E,$3C02,$03ED
	.dc.w	$2800,$C800,$0800,$F000,$D800,$D800,$D800,$2000
	.dc.w	$D601,$BA01,$8201,$7C0E,$C0ED,$FCFC,$FCFC,$0303
	.dc.w	$D000,$A401,$0401,$BBC0,$8800,$AC00,$8C00,$7000
	.dc.w	$D7E1,$BBFE,$8200,$7DFF,$FDBD,$1C6C,$1C04,$E3EB
	.dc.w	$D3C0,$A43F,$0400,$BBFF,$8800,$AC00,$8C00,$7000
	.dc.w	$17E1,$FBFE,$E200,$1DFF,$E1ED,$01FC,$01FC,$FE03
	.dc.w	$03C0,$F43F,$F400,$0BFF,$8800,$AC00,$8C00,$7000
	.dc.w	$1600,$FA00,$C200,$3C00,$61BD,$7C6C,$7C04,$83EB
	.dc.w	$1000,$E401,$E401,$1A00,$8800,$AC00,$8C00,$7000
	.dc.w	$2800,$9200,$8200,$7C00,$1403,$376E,$33FE,$0801
	.dc.w	$0800,$E800,$6800,$9000,$D800,$D800,$D800,$2000
	.dc.w	$5400,$4400,$4400,$3800,$1DB8,$1C6E,$1C02,$03ED
	.dc.w	$9000,$7800,$7800,$8000,$7000,$F800,$F800,$0000
	.dc.w	$1000,$3800,$3800,$0000,$0029,$0C01,$0C29,$0038
	.dc.w	$2000,$3000,$3000,$C000,$0000,$2000,$2000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0010,$0000,$0010
	.dc.w	$0000,$E000,$E000,$0000,$0000,$0000,$0000,$0000
base40:		* StarBase (Perspective:4 - Animation:0)
	.dc.w	21,6
	.dc.w	11,3
	.dc.w	$0000,$0000,$0000,$0000,$0E00,$1F00,$1F00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3180,$3F80,$3F80,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$4800,$4800,$3000,$7FC0,$5340,$5340,$2C80
	.dc.w	$0080,$0280,$0280,$0100,$3000,$0400,$0400,$7800
	.dc.w	$6340,$6D40,$6140,$1E80,$0140,$0440,$0440,$0380
	.dc.w	$0438,$B43F,$843F,$7800,$3E03,$ACBF,$A0BF,$5F40
	.dc.w	$8580,$8520,$8420,$03C0,$058E,$B5F0,$8400,$7BFF
	.dc.w	$3E0E,$2C81,$2080,$DF7F,$3580,$F520,$0420,$F3C0
	.dc.w	$058E,$B5F0,$8400,$7BFF,$200E,$3E81,$3E80,$C17F
	.dc.w	$3580,$F560,$0460,$F380,$040C,$B40F,$840F,$7800
	.dc.w	$7246,$ACBE,$ACBE,$5340,$05C0,$0560,$0460,$0380
	.dc.w	$4800,$4800,$4800,$3000,$3080,$1D00,$1D00,$62C0
	.dc.w	$0200,$0240,$0240,$0180,$3000,$3000,$3000,$0000
	.dc.w	$0200,$1200,$1200,$0C00,$0100,$0180,$0180,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0C00,$0C00,$0000
	.dc.w	$0000,$0000,$0000,$0000
base41:		* StarBase (Perspective:4 - Animation:1)
	.dc.w	20,6
	.dc.w	11,3
	.dc.w	$0000,$0000,$0000,$0000,$1C00,$3E00,$3E00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0003,$0000
	.dc.w	$6B00,$F700,$F700,$0800,$0000,$0000,$0000,$0000
	.dc.w	$2001,$7004,$7004,$0003,$6BC0,$2AC0,$22C0,$DD00
	.dc.w	$0400,$0500,$0500,$0200,$5006,$D805,$D804,$2003
	.dc.w	$FDA0,$1EA0,$00A0,$FF40,$0C00,$0A80,$0880,$0700
	.dc.w	$8871,$A87A,$8878,$7006,$6AC7,$BCBF,$20BF,$DF40
	.dc.w	$0380,$1680,$1080,$0F00,$8871,$AF8A,$8808,$77F6
	.dc.w	$7703,$BF00,$3F00,$C0FF,$8380,$7680,$1080,$EF00
	.dc.w	$8870,$AF8B,$880B,$77F4,$6A83,$BC80,$A080,$5F7F
	.dc.w	$8200,$7780,$1180,$EE00,$8810,$A81B,$881B,$7004
	.dc.w	$76CC,$BE3C,$3E3C,$C1C0,$0300,$1680,$1080,$0F00
	.dc.w	$7000,$7007,$7007,$0000,$EAC0,$5CE0,$40E0,$BF00
	.dc.w	$0300,$0900,$0900,$0600,$0002,$2002,$2002,$0001
	.dc.w	$9400,$C0C0,$D4C0,$1C00,$0200,$0600,$0600,$0000
	.dc.w	$0000,$0003,$0003,$0000,$0000,$8800,$8000,$0800
	.dc.w	$0000,$0000,$0000,$0000
base42:		* StarBase (Perspective:4 - Animation:2)
	.dc.w	19,6
	.dc.w	11,3
	.dc.w	$0000,$0000,$0000,$0000,$3800,$7C00,$7C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$D600,$EE00,$EE00,$1000,$0000,$0000,$0000,$0000
	.dc.w	$2029,$7029,$7029,$0010,$D710,$5530,$4530,$BA00
	.dc.w	$1000,$1400,$1400,$0800,$5069,$D055,$D045,$2038
	.dc.w	$BB28,$7D68,$0168,$FE10,$3000,$2A00,$2200,$1C00
	.dc.w	$8017,$A8AF,$8887,$7068,$550E,$39FE,$01FE,$FE00
	.dc.w	$0E00,$5A00,$4200,$3C00,$8F15,$A0AE,$8084,$7F6B
	.dc.w	$AEE3,$3EE0,$3EE0,$C11F,$8E00,$5A00,$4200,$BC00
	.dc.w	$8F07,$A0FF,$80FF,$7F00,$55E3,$39E0,$01E0,$FE1F
	.dc.w	$8800,$5E00,$4600,$B800,$8007,$A8BC,$88B4,$704B
	.dc.w	$2D1C,$3CFC,$3CFC,$C300,$0A00,$5E00,$4600,$3800
	.dc.w	$7011,$7041,$7041,$0038,$5530,$3938,$0138,$FE00
	.dc.w	$0C00,$2400,$2400,$1800,$0010,$2038,$2038,$0000
	.dc.w	$0000,$0010,$0010,$1000,$0800,$1800,$1800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$0000,$1000
	.dc.w	$0000,$0000,$0000,$0000
base43:		* StarBase (Perspective:4 - Animation:3)
	.dc.w	18,6
	.dc.w	11,3
	.dc.w	$0000,$0000,$0000,$0000,$7000,$F800,$F800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0000
	.dc.w	$AC00,$DC00,$DC00,$2000,$0000,$0000,$0000,$0000
	.dc.w	$2083,$6282,$6282,$0101,$AE0C,$AA0C,$8A0C,$7400
	.dc.w	$5000,$5000,$5000,$2000,$50C3,$D542,$D442,$2381
	.dc.w	$7612,$FA12,$0212,$FC0C,$D000,$A800,$8800,$7000
	.dc.w	$9702,$BCBE,$9C3E,$62C1,$AA1E,$73FF,$03FF,$FC00
	.dc.w	$2800,$5800,$0800,$D000,$9707,$B4B8,$9420,$6ADF
	.dc.w	$5DC7,$7DC0,$7DC0,$823F,$2800,$5800,$0800,$D000
	.dc.w	$9406,$B7BA,$97A2,$685D,$ABC7,$73C0,$03C0,$FC3F
	.dc.w	$0800,$7800,$3800,$C000,$9402,$BFBC,$9F3C,$60C3
	.dc.w	$5A3E,$79F3,$79F3,$860C,$2800,$5800,$1800,$C000
	.dc.w	$6302,$7242,$7242,$0181,$AA0C,$721E,$021E,$FC00
	.dc.w	$2000,$8000,$8000,$7000,$0100,$2180,$2180,$0000
	.dc.w	$5000,$000C,$500C,$7000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$2000,$0000,$2000
	.dc.w	$0000,$0000,$0000,$0000
base44:		* StarBase (Perspective:4 - Animation:4)
	.dc.w	17,6
	.dc.w	11,3
	.dc.w	$0000,$0001,$0001,$0000,$E000,$F000,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0003,$0003,$0003,$0000
	.dc.w	$5800,$B800,$B800,$4000,$0000,$0000,$0000,$0000
	.dc.w	$3407,$3405,$3405,$0802,$5C02,$5406,$1406,$E801
	.dc.w	$0000,$4000,$4000,$8000,$7406,$6A05,$6204,$1C03
	.dc.w	$EC06,$F40F,$040E,$F801,$0000,$A000,$2000,$C000
	.dc.w	$4BC5,$D7FC,$C3FC,$3403,$5439,$E7FD,$07FC,$F803
	.dc.w	$E000,$A000,$2000,$C000,$4B1E,$D41C,$C01C,$37E3
	.dc.w	$BF19,$FF05,$FF04,$00FB,$E000,$A000,$2000,$C000
	.dc.w	$533D,$FC3C,$F83C,$07C3,$5718,$E705,$0705,$F8FA
	.dc.w	$2000,$E000,$E000,$0000,$72C4,$FEFC,$FAFC,$0403
	.dc.w	$B469,$F3ED,$F3EC,$0C03,$2000,$E000,$E000,$0000
	.dc.w	$0805,$6004,$6004,$1C03,$5405,$E406,$0406,$F801
	.dc.w	$C000,$4000,$4000,$8000,$0800,$3C00,$3C00,$0000
	.dc.w	$0001,$0003,$0003,$4000,$8000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$0000,$4000
	.dc.w	$0000,$0000,$0000,$0000
base45:		* StarBase (Perspective:4 - Animation:5)
	.dc.w	19,6
	.dc.w	11,3
	.dc.w	$0000,$0000,$0000,$0000,$3800,$7C00,$7C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$D600,$EE00,$EE00,$1000,$0000,$0000,$0000,$0000
	.dc.w	$2081,$28C1,$28C1,$1000,$D700,$5509,$4509,$BA06
	.dc.w	$1000,$3800,$3800,$0000,$6141,$5561,$4561,$3880
	.dc.w	$BB00,$7D06,$0100,$FE0F,$2800,$E800,$E800,$1000
	.dc.w	$1DE1,$A7FF,$87FF,$6800,$552F,$39F6,$01F0,$FE0F
	.dc.w	$C000,$D000,$C000,$3800,$1F8F,$A40F,$840F,$6BF0
	.dc.w	$AE8F,$3E76,$3E10,$C1EF,$C000,$D000,$C000,$3800
	.dc.w	$0F8F,$F40F,$F40F,$0BF0,$558A,$3977,$0115,$FEEA
	.dc.w	$C000,$D000,$C000,$3800,$1D39,$E7BF,$E73F,$08C0
	.dc.w	$2D2A,$3CF7,$3CF5,$C30A,$C000,$D000,$C000,$3800
	.dc.w	$18C1,$49C1,$49C1,$3000,$550F,$3909,$0109,$FE06
	.dc.w	$3800,$3800,$3800,$0000,$1000,$3080,$3080,$0000
	.dc.w	$2806,$0006,$2806,$3800,$0000,$1000,$1000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$0000,$1000
	.dc.w	$0000,$0000,$0000,$0000
base46:		* StarBase (Perspective:4 - Animation:6)
	.dc.w	20,6
	.dc.w	11,3
	.dc.w	$0000,$0000,$0000,$0000,$1C00,$3E00,$3E00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$6B00,$7700,$7700,$0800,$0000,$0000,$0000,$0000
	.dc.w	$2808,$281C,$281C,$1000,$EB90,$AA94,$A294,$5D08
	.dc.w	$0400,$0C00,$0C00,$0000,$6814,$5434,$4434,$3808
	.dc.w	$DDB0,$BEAA,$80A2,$7F1C,$0A00,$1A00,$1A00,$0400
	.dc.w	$1470,$BC7F,$847F,$7800,$AA8E,$9CD2,$80C2,$7F35
	.dc.w	$1200,$1700,$1300,$0C00,$171C,$BC1C,$841C,$7BE3
	.dc.w	$D70F,$1F53,$1F43,$E0B4,$B200,$8700,$8300,$7C00
	.dc.w	$178F,$FC0F,$E40F,$1BF0,$AA83,$9CDF,$80DF,$7F20
	.dc.w	$B200,$8700,$8300,$7C00,$1438,$FC3F,$E43F,$1800
	.dc.w	$9682,$9E5E,$9E4E,$61B0,$1200,$1700,$1300,$0C00
	.dc.w	$101C,$401C,$401C,$3800,$AA84,$9CA4,$80A4,$7F18
	.dc.w	$0C00,$0E00,$0E00,$0000,$1000,$3808,$3808,$0000
	.dc.w	$0008,$0018,$0018,$0800,$0000,$0400,$0400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0800,$0000,$0800
	.dc.w	$0000,$0000,$0000,$0000
base47:		* StarBase (Perspective:4 - Animation:7)
	.dc.w	20,6
	.dc.w	11,3
	.dc.w	$0000,$0000,$0000,$0000,$1C00,$3E00,$3E00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$6B00,$77C0,$77C0,$0800,$0000,$0000,$0000,$0000
	.dc.w	$5001,$5003,$5003,$2000,$EBE0,$AA30,$A230,$5DC0
	.dc.w	$0200,$0600,$0600,$0000,$D802,$A802,$8802,$7001
	.dc.w	$DC30,$BED0,$8010,$7FE0,$0500,$0D00,$0D00,$0200
	.dc.w	$2071,$707F,$007F,$F800,$ABE7,$9ECF,$820F,$7DF0
	.dc.w	$0B00,$0980,$0980,$0600,$20E0,$7700,$0000,$FFFF
	.dc.w	$D7E0,$1EC8,$1E08,$E1F7,$EB00,$1980,$0980,$F600
	.dc.w	$20E0,$F700,$C000,$3FFF,$AB40,$9EE8,$82A8,$7D57
	.dc.w	$EB00,$1980,$0980,$F600,$2019,$F01F,$801F,$7800
	.dc.w	$9744,$1EEC,$1EAC,$E150,$0B00,$0980,$0980,$0600
	.dc.w	$2003,$8803,$8803,$7000,$A9C0,$9F10,$8110,$7EE0
	.dc.w	$0600,$0700,$0700,$0000,$2000,$7001,$7001,$0000
	.dc.w	$1420,$0120,$1520,$1CC0,$0000,$0200,$0200,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$08C0,$00C0,$0800
	.dc.w	$0000,$0000,$0000,$0000
base50:		* StarBase (Perspective:5 - Animation:0)
	.dc.w	17,5
	.dc.w	9,3
	.dc.w	$0000,$0001,$0001,$0000,$E000,$F000,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$2003,$2003,$0000
	.dc.w	$5000,$F800,$F800,$0000,$0000,$8000,$8000,$0000
	.dc.w	$1002,$1001,$1001,$6002,$C001,$1001,$1001,$E800
	.dc.w	$0000,$0000,$0000,$C000,$0003,$A001,$8001,$7002
	.dc.w	$E800,$5000,$1000,$E801,$8000,$2000,$2000,$C000
	.dc.w	$E236,$ABC6,$8806,$77F9,$7D8C,$9C7E,$1C02,$A3FD
	.dc.w	$6000,$A000,$2000,$C000,$6002,$A800,$8800,$7003
	.dc.w	$5800,$B002,$B002,$0801,$4000,$A000,$2000,$C000
	.dc.w	$0003,$A003,$8003,$7000,$6800,$D800,$9800,$6001
	.dc.w	$8000,$2000,$2000,$C000,$4000,$5001,$5001,$2000
	.dc.w	$6000,$2001,$2001,$C000,$4000,$4000,$4000,$8000
	.dc.w	$0000,$2000,$2000,$0000,$4000,$E000,$E000,$0000
	.dc.w	$0000,$8000,$8000,$0000
base51:		* StarBase (Perspective:5 - Animation:1)
	.dc.w	17,5
	.dc.w	9,3
	.dc.w	$0000,$0001,$0001,$0000,$E000,$F000,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000D,$000D,$000D,$0002
	.dc.w	$1000,$F800,$B800,$4000,$0000,$8000,$8000,$0000
	.dc.w	$601E,$6013,$6013,$000C,$4C00,$5C02,$0C02,$F001
	.dc.w	$C000,$4000,$4000,$8000,$2000,$B00D,$B001,$401E
	.dc.w	$EC03,$5E02,$0E02,$F001,$0000,$8000,$0000,$C000
	.dc.w	$D31F,$9C2D,$9021,$6FDE,$AC60,$4C1D,$0C00,$F3FF
	.dc.w	$C000,$A000,$2000,$C000,$D00B,$903D,$9035,$600A
	.dc.w	$1E00,$0601,$0600,$F803,$C000,$A000,$2000,$C000
	.dc.w	$2000,$B00D,$B005,$401A,$A803,$4A02,$0A02,$F001
	.dc.w	$0000,$8000,$0000,$C000,$401E,$6012,$6012,$000C
	.dc.w	$4001,$0001,$4001,$4000,$0000,$4000,$4000,$8000
	.dc.w	$000C,$000C,$000C,$0000,$0000,$0000,$0000,$4000
	.dc.w	$0000,$8000,$8000,$0000
base52:		* StarBase (Perspective:5 - Animation:2)
	.dc.w	16,5
	.dc.w	9,3
	.dc.w	$0001,$0003,$0003,$0000,$C000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0002,$0047,$0047,$0000
	.dc.w	$2000,$F002,$7002,$8000,$0000,$0000,$0000,$0000
	.dc.w	$6064,$E022,$E020,$00C7,$8B03,$AF01,$0F01,$F006
	.dc.w	$0000,$0000,$0000,$0000,$E0C5,$A142,$A100,$40E7
	.dc.w	$CD06,$AD0A,$0D08,$F207,$0000,$8000,$8000,$0000
	.dc.w	$996D,$C19C,$811C,$7EA3,$5F3B,$9F0E,$1F08,$E0F7
	.dc.w	$8000,$8000,$8000,$0000,$9126,$C1D0,$81D0,$7027
	.dc.w	$3E0A,$0C8F,$0C89,$F306,$8000,$8000,$8000,$0000
	.dc.w	$E005,$A1C4,$A1C4,$4023,$5D06,$9D0B,$1D09,$E206
	.dc.w	$0000,$8000,$8000,$0000,$4080,$60A0,$60A0,$0040
	.dc.w	$8204,$8305,$8305,$0002,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0040,$0040,$0000,$0000,$0002,$0002,$8000
	.dc.w	$0000,$0000,$0000,$0000
base53:		* StarBase (Perspective:5 - Animation:3)
	.dc.w	16,5
	.dc.w	9,2
	.dc.w	$0001,$0003,$0003,$0000,$C000,$E000,$E000,$0000
	.dc.w	$0002,$0307,$0307,$0000,$2000,$F004,$7004,$8000
	.dc.w	$6300,$7482,$7480,$0307,$80CC,$A0C8,$00C8,$F006
	.dc.w	$7481,$5782,$5480,$2307,$C006,$A125,$0121,$F0CE
	.dc.w	$131D,$B35C,$905C,$6FA3,$5E6D,$9E13,$1E11,$E1EA
	.dc.w	$1206,$BF40,$9D40,$6287,$31ED,$0133,$0133,$F0C8
	.dc.w	$7485,$5784,$5484,$2303,$5004,$9127,$1123,$E0CC
	.dc.w	$2000,$6000,$6000,$0300,$80C2,$00CA,$80CA,$8004
	.dc.w	$0000,$0300,$0300,$0000,$0000,$0004,$0004,$8000
base54:		* StarBase (Perspective:5 - Animation:4)
	.dc.w	15,5
	.dc.w	9,2
	.dc.w	$0003,$0007,$0007,$0000,$8000,$C000,$C000,$0000
	.dc.w	$0004,$080F,$080E,$0001,$4000,$E010,$E010,$0000
	.dc.w	$0801,$6405,$6400,$180F,$0078,$4068,$0068,$E010
	.dc.w	$7403,$6C05,$6400,$180F,$8010,$40D4,$00C4,$E038
	.dc.w	$497A,$DA79,$C278,$3D87,$BDFC,$3CC4,$3C44,$C3A8
	.dc.w	$500C,$FA00,$FA00,$040F,$60E4,$00DC,$00DC,$E020
	.dc.w	$740A,$7C09,$7408,$0807,$A010,$20DC,$20CC,$C030
	.dc.w	$3001,$3001,$3001,$0800,$0040,$0068,$0068,$0010
	.dc.w	$0000,$0800,$0800,$0001,$0000,$0010,$0010,$0000
base55:		* StarBase (Perspective:5 - Animation:5)
	.dc.w	16,5
	.dc.w	9,2
	.dc.w	$0001,$0003,$0003,$0000,$C000,$E000,$E000,$0000
	.dc.w	$0002,$2007,$2007,$0000,$2000,$F0C0,$70C0,$8000
	.dc.w	$3300,$1302,$1300,$6007,$80C6,$A12E,$012E,$F0C0
	.dc.w	$6001,$AC82,$8C80,$7307,$C12E,$A1EA,$012A,$F0C4
	.dc.w	$BE7D,$C87C,$887C,$5783,$5CC8,$9CDD,$1C19,$E3E6
	.dc.w	$BF86,$CC80,$CC80,$1307,$3048,$00FD,$00B9,$F146
	.dc.w	$2005,$EC84,$CC84,$3303,$512E,$91EA,$112A,$E0C4
	.dc.w	$4300,$5300,$5300,$2000,$8004,$0006,$8006,$80C0
	.dc.w	$0000,$2000,$2000,$0000,$0000,$00C0,$00C0,$8000
base56:		* StarBase (Perspective:5 - Animation:6)
	.dc.w	17,5
	.dc.w	9,3
	.dc.w	$0000,$0001,$0001,$0000,$E000,$F000,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$2003,$2003,$0000
	.dc.w	$1000,$F900,$B900,$4000,$0000,$0000,$0000,$0000
	.dc.w	$6060,$4071,$4070,$3003,$4703,$5603,$0603,$F980
	.dc.w	$0000,$8000,$8000,$0000,$3070,$2851,$0850,$7023
	.dc.w	$E483,$5542,$0442,$FB81,$8000,$8000,$8000,$0000
	.dc.w	$6DF6,$B986,$8986,$7679,$AB74,$4DF1,$0C70,$F38F
	.dc.w	$8000,$C000,$C000,$0000,$2813,$F8B0,$C890,$3063
	.dc.w	$1A40,$05C1,$05C0,$FA07,$8000,$C000,$C000,$0000
	.dc.w	$3072,$6852,$4852,$3021,$AC03,$4DC2,$0DC2,$F201
	.dc.w	$8000,$8000,$8000,$0000,$1020,$5060,$5060,$2000
	.dc.w	$4081,$4283,$4283,$0100,$0000,$0000,$0000,$0000
	.dc.w	$0000,$2000,$2000,$0000,$0000,$0100,$0100,$4000
	.dc.w	$0000,$0000,$0000,$0000
base57:		* StarBase (Perspective:5 - Animation:7)
	.dc.w	18,5
	.dc.w	9,3
	.dc.w	$0000,$0000,$0000,$0000,$7000,$F800,$F800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$2001,$2001,$0000
	.dc.w	$8600,$F600,$D600,$2800,$0000,$0000,$0000,$0000
	.dc.w	$2007,$4806,$4806,$3001,$2F00,$A900,$0900,$F600
	.dc.w	$C000,$E000,$E000,$0000,$5801,$680A,$4808,$3007
	.dc.w	$6000,$B681,$1081,$EF00,$A000,$A000,$A000,$4000
	.dc.w	$20C3,$B703,$8003,$7FFC,$4FF1,$368F,$1081,$EF7E
	.dc.w	$6000,$2000,$2000,$C000,$200D,$F00A,$C008,$3807
	.dc.w	$8A81,$1781,$1581,$EA00,$6000,$2000,$2000,$C000
	.dc.w	$1803,$680B,$480B,$3004,$4000,$3681,$0481,$FB00
	.dc.w	$A000,$A000,$A000,$4000,$1006,$1006,$1006,$2000
	.dc.w	$2F00,$0900,$2900,$2600,$4000,$C000,$C000,$0000
	.dc.w	$0000,$2000,$2000,$0000,$0600,$0600,$0600,$2000
	.dc.w	$0000,$0000,$0000,$0000
base60:		* StarBase (Perspective:6 - Animation:0)
	.dc.w	14,4
	.dc.w	7,2
	.dc.w	$0006,$000C,$000C,$0003,$0000,$8000,$8000,$0000
	.dc.w	$2002,$2009,$2009,$4006,$8000,$8010,$8010,$0020
	.dc.w	$400D,$900B,$9009,$6006,$8040,$0060,$0040,$8030
	.dc.w	$BCC2,$DF06,$9000,$6FFF,$DB20,$4728,$4008,$BF70
	.dc.w	$3000,$D006,$9006,$6009,$8020,$0028,$0008,$80F0
	.dc.w	$0004,$000B,$000B,$6004,$8010,$0050,$0050,$8020
	.dc.w	$0002,$4006,$4006,$0000,$0000,$0020,$0020,$0000
base61:		* StarBase (Perspective:6 - Animation:1)
	.dc.w	13,4
	.dc.w	7,2
	.dc.w	$000C,$0019,$0019,$0006,$0000,$0000,$0000,$0000
	.dc.w	$400B,$C09F,$C09B,$0064,$8000,$8080,$8080,$0040
	.dc.w	$80F5,$A08E,$A080,$407F,$4020,$4060,$4020,$80C0
	.dc.w	$6CCA,$30E4,$20C0,$DF3F,$F4C0,$F340,$F100,$0EE0
	.dc.w	$600A,$2064,$2060,$C09F,$40C0,$4160,$4120,$80C0
	.dc.w	$C024,$C0D0,$C0D0,$0024,$80C0,$C0A0,$C0A0,$0040
	.dc.w	$0000,$0060,$0060,$0000,$0000,$0040,$0040,$0000
base62:		* StarBase (Perspective:6 - Animation:2)
	.dc.w	13,4
	.dc.w	7,2
	.dc.w	$000C,$0019,$0019,$0006,$0000,$0000,$0000,$0000
	.dc.w	$409B,$609F,$609B,$0104,$2000,$2040,$2040,$0080
	.dc.w	$2095,$A34E,$A240,$419F,$7100,$5180,$5100,$20C0
	.dc.w	$DF4A,$83C4,$8240,$7DBF,$E6C0,$E0A0,$E020,$1FC0
	.dc.w	$C34A,$83C4,$82C0,$611F,$5080,$70E0,$5060,$2180
	.dc.w	$6104,$6000,$6004,$0184,$20C0,$3140,$3140,$0080
	.dc.w	$0000,$0100,$0100,$0000,$0000,$0080,$0080,$0000
base63:		* StarBase (Perspective:6 - Animation:3)
	.dc.w	12,4
	.dc.w	7,2
	.dc.w	$0018,$0032,$0032,$000C,$0000,$0000,$0000,$0000
	.dc.w	$4836,$483E,$4836,$0408,$1200,$1200,$1200,$0100
	.dc.w	$C82A,$B61C,$B200,$4C3E,$3A00,$2D80,$2C80,$1300
	.dc.w	$B695,$FE89,$B281,$4D7E,$CD80,$C780,$C480,$3B00
	.dc.w	$B214,$FE08,$BE00,$403E,$2C80,$3F80,$2D80,$1200
	.dc.w	$4408,$C000,$C000,$0C08,$1100,$3000,$3000,$0300
	.dc.w	$0000,$0400,$0400,$0000,$0000,$0100,$0100,$0000
base64:		* StarBase (Perspective:6 - Animation:4)
	.dc.w	11,4
	.dc.w	7,2
	.dc.w	$0030,$0064,$0064,$0018,$0000,$0000,$0000,$0000
	.dc.w	$406C,$507C,$506C,$2010,$1800,$1800,$1800,$0400
	.dc.w	$A054,$A038,$8000,$707C,$0A00,$1600,$1200,$0C00
	.dc.w	$F5AB,$A993,$8983,$767C,$B400,$9C00,$9000,$6E00
	.dc.w	$9028,$E810,$E800,$107C,$1000,$3E00,$3600,$0800
	.dc.w	$7010,$D000,$D000,$2010,$1400,$1200,$1200,$0C00
	.dc.w	$0000,$2000,$2000,$0000,$0000,$0400,$0400,$0000
base65:		* StarBase (Perspective:6 - Animation:5)
	.dc.w	13,4
	.dc.w	7,2
	.dc.w	$000C,$0019,$0019,$0006,$0000,$0000,$0000,$0000
	.dc.w	$021B,$461F,$461B,$2004,$0080,$1180,$1180,$0800
	.dc.w	$3515,$350E,$1500,$621F,$0D00,$0D00,$0500,$1880
	.dc.w	$6CEA,$A0E4,$80E0,$7F1F,$D880,$E840,$E040,$1F80
	.dc.w	$230A,$E904,$C900,$361F,$1080,$2E40,$2E40,$1180
	.dc.w	$6604,$5600,$5600,$2004,$1980,$1580,$1580,$0800
	.dc.w	$0000,$2000,$2000,$0000,$0000,$0800,$0800,$0000
base66:		* StarBase (Perspective:6 - Animation:6)
	.dc.w	13,4
	.dc.w	6,2
	.dc.w	$000C,$0019,$0019,$0006,$0000,$0000,$0000,$0000
	.dc.w	$211B,$239F,$239B,$4004,$0080,$1080,$1080,$2000
	.dc.w	$A295,$C28E,$8280,$611F,$6140,$6140,$4140,$3080
	.dc.w	$4CCA,$70C4,$10C0,$EF3F,$37C0,$A840,$0840,$F780
	.dc.w	$430A,$F204,$9200,$619F,$01C0,$3940,$3940,$4080
	.dc.w	$4104,$8380,$8384,$6004,$1080,$50C0,$50C0,$2000
base67:		* StarBase (Perspective:6 - Animation:7)
	.dc.w	14,4
	.dc.w	7,2
	.dc.w	$0006,$000C,$000C,$0003,$0000,$8000,$8000,$0000
	.dc.w	$401D,$4037,$4035,$200A,$E020,$A020,$A020,$4000
	.dc.w	$502A,$3027,$1021,$601E,$E040,$4050,$0050,$E020
	.dc.w	$2335,$EC33,$8031,$7FCE,$F370,$70D0,$3050,$CFA0
	.dc.w	$2025,$E063,$8061,$701E,$8070,$70D0,$7050,$80A0
	.dc.w	$2037,$1031,$1031,$600E,$0020,$4060,$4060,$A000
	.dc.w	$0010,$2010,$2010,$0000,$4000,$E000,$E000,$0000
base70:		* StarBase (Perspective:7 - Animation:0)
	.dc.w	11,3
	.dc.w	4,2
	.dc.w	$0028,$406C,$406C,$0010,$0400,$0400,$0400,$0000
	.dc.w	$E034,$A004,$A004,$4078,$0600,$0200,$0200,$0C00
	.dc.w	$98D2,$DFF3,$9FF3,$600C,$6600,$E200,$E200,$1C00
	.dc.w	$4030,$4028,$4028,$0010,$0400,$0400,$0400,$0000
base71:		* StarBase (Perspective:7 - Animation:1)
	.dc.w	11,3
	.dc.w	4,2
	.dc.w	$00A8,$00EC,$00EC,$0010,$0000,$0000,$0000,$0000
	.dc.w	$20F6,$2126,$2126,$40D8,$0400,$0400,$0400,$0800
	.dc.w	$6148,$BFB1,$BF21,$40DE,$0C00,$F000,$F000,$0C00
	.dc.w	$40D0,$4056,$4056,$0080,$0C00,$0C00,$0C00,$0000
base72:		* StarBase (Perspective:7 - Animation:2)
	.dc.w	10,3
	.dc.w	4,2
	.dc.w	$4050,$42D8,$42D8,$0020,$1000,$1000,$1000,$0000
	.dc.w	$82A8,$8089,$8089,$4672,$2800,$3800,$2800,$1000
	.dc.w	$E053,$A725,$A705,$40FA,$0800,$1800,$0800,$3000
	.dc.w	$4022,$4422,$4422,$0200,$0000,$0000,$0000,$1000
base73:		* StarBase (Perspective:7 - Animation:3)
	.dc.w	10,3
	.dc.w	4,2
	.dc.w	$0050,$08D8,$08D8,$0020,$0000,$0000,$0000,$0000
	.dc.w	$28A9,$3089,$3089,$4C70,$B000,$8000,$8000,$3000
	.dc.w	$7450,$B820,$B000,$4CF9,$2000,$5800,$5800,$A000
	.dc.w	$4020,$4421,$4421,$0800,$3000,$B000,$B000,$0000
base74:		* StarBase (Perspective:7 - Animation:4)
	.dc.w	9,3
	.dc.w	4,2
	.dc.w	$00A0,$21B0,$21B0,$0040,$0000,$4000,$4000,$0000
	.dc.w	$5151,$F111,$D111,$20E0,$4000,$2000,$2000,$C000
	.dc.w	$80A1,$E041,$E001,$11F0,$A000,$6000,$6000,$8000
	.dc.w	$4040,$4040,$4040,$2000,$0000,$8000,$8000,$4000
base75:		* StarBase (Perspective:7 - Animation:5)
	.dc.w	10,3
	.dc.w	4,2
	.dc.w	$0050,$40D8,$40D8,$0020,$0000,$0000,$0000,$0000
	.dc.w	$44A9,$8488,$8488,$6871,$B000,$3000,$3000,$8000
	.dc.w	$AC50,$D421,$D401,$28F8,$0000,$C000,$C000,$3000
	.dc.w	$0821,$2821,$2821,$4000,$8000,$B000,$B000,$0000
base76:		* StarBase (Perspective:7 - Animation:6)
	.dc.w	10,3
	.dc.w	4,2
	.dc.w	$0050,$40DA,$40DA,$0020,$0000,$0000,$0000,$0000
	.dc.w	$44AB,$248D,$248D,$C272,$1000,$2800,$2800,$1000
	.dc.w	$2654,$E427,$A407,$42F8,$3800,$2800,$2800,$1000
	.dc.w	$0220,$8220,$8220,$4002,$1000,$1000,$1000,$0000
base77:		* StarBase (Perspective:7 - Animation:7)
	.dc.w	11,3
	.dc.w	4,2
	.dc.w	$0028,$406E,$406E,$0010,$0000,$0000,$0000,$0000
	.dc.w	$4056,$8049,$8049,$60B6,$0C00,$0C00,$0C00,$0000
	.dc.w	$20A9,$DF1F,$9F0F,$60F0,$1000,$E000,$E000,$1C00
	.dc.w	$0090,$2090,$2090,$4006,$0000,$0C00,$0C00,$0000

	.end
