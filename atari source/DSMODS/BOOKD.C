/* DEGAS Elite Icon Definition */
#define ICON_W 0x0180
#define ICON_H 0x002C
#define ICONSIZE 0x0420
int bookd[ICONSIZE] = 
{ 0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0030, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0028, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x1F00, 0x0000, 0x0000, 
  0x0000, 0x0024, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x10C0, 0x0000, 0x0000, 
  0x0000, 0x0024, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x00C0, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x1020, 0x0000, 0x0000, 
  0x0000, 0x0022, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x00A0, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x2010, 0x0000, 0x0000, 
  0x0000, 0x0022, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0090, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x6000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x2008, 0x0000, 0x0000, 
  0x0000, 0x0022, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0190, 0x0000, 
  0x0000, 0x0000, 0x0001, 0x9000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x2008, 0x0000, 0x0000, 
  0x0000, 0x0021, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0188, 0x0000, 
  0x0000, 0x0000, 0x0006, 0x1000, 
  0x0003, 0xFF00, 0x007F, 0xC000, 
  0x0003, 0xFF00, 0x007F, 0xC000, 
  0x0003, 0xE004, 0x007F, 0xC000, 
  0x0003, 0xFF21, 0x007F, 0xC000, 
  0x0003, 0xFF00, 0x028F, 0xC000, 
  0x0003, 0xFF00, 0x0078, 0x1000, 
  0x003C, 0x00E0, 0x0380, 0x3C00, 
  0x003C, 0x00E0, 0x0380, 0x3C00, 
  0x003C, 0x2004, 0x0380, 0x3C00, 
  0x003C, 0x00E1, 0x0380, 0x3C00, 
  0x003C, 0x00E0, 0x0D88, 0x3C00, 
  0x003C, 0x00E0, 0x0380, 0x1C00, 
  0x00C0, 0x0018, 0x0C00, 0x0300, 
  0x00D0, 0x0018, 0x0C00, 0x0300, 
  0x00C0, 0x4004, 0x0C00, 0x0300, 
  0x00C0, 0x0020, 0x8C00, 0x0300, 
  0x00C0, 0x0018, 0x3288, 0x0300, 
  0x00C0, 0x0018, 0x0C00, 0x0B00, 
  0x0100, 0x0006, 0x3000, 0x0080, 
  0x0110, 0x0006, 0x3000, 0x0080, 
  0x0100, 0x4002, 0x3000, 0x0080, 
  0x0100, 0x0020, 0xB000, 0x0080, 
  0x0100, 0x0006, 0x4188, 0x0080, 
  0x0100, 0x0006, 0x3000, 0x0880, 
  0x0200, 0x0001, 0x4000, 0x0040, 
  0x0220, 0x0001, 0x4000, 0x0040, 
  0x0200, 0x4003, 0x4000, 0x0040, 
  0x0200, 0x0020, 0xC000, 0x0040, 
  0x0200, 0x0001, 0x8288, 0x0040, 
  0x0200, 0x0001, 0x4000, 0x0840, 
  0x0200, 0x0000, 0x8000, 0x0040, 
  0x0220, 0x0000, 0x8000, 0x0040, 
  0x0200, 0x4001, 0x8000, 0x0040, 
  0x0200, 0x0020, 0x8000, 0x0040, 
  0x0200, 0x0000, 0x8188, 0x0040, 
  0x0200, 0x0000, 0x8000, 0x0840, 
  0x0400, 0x0000, 0x8000, 0x0020, 
  0x0440, 0x0000, 0x8000, 0x0020, 
  0x0400, 0x8000, 0x8000, 0x0020, 
  0x0400, 0x0020, 0x8000, 0x0020, 
  0x0400, 0x0000, 0x8288, 0x0020, 
  0x0400, 0x0000, 0x8000, 0x0420, 
  0x0400, 0x0000, 0x0000, 0x0020, 
  0x0440, 0x0000, 0x0000, 0x0020, 
  0x0400, 0x8000, 0x0000, 0x0020, 
  0x0400, 0x0020, 0x0000, 0x0020, 
  0x0400, 0x0000, 0x0188, 0x0020, 
  0x0400, 0x0000, 0x0000, 0x0420, 
  0x0400, 0x0000, 0x8000, 0x0020, 
  0x0440, 0x0000, 0x8000, 0x0020, 
  0x0400, 0x8000, 0x8000, 0x0020, 
  0x0400, 0x0020, 0x8000, 0x0020, 
  0x0400, 0x0000, 0x8288, 0x0020, 
  0x0400, 0x0000, 0x8000, 0x0420, 
  0x0C00, 0x0000, 0x8000, 0x0030, 
  0x0C40, 0x0000, 0x8000, 0x0030, 
  0x0C00, 0x8000, 0x8000, 0x0030, 
  0x0C00, 0x0020, 0x0000, 0x0030, 
  0x0C00, 0x0000, 0x8188, 0x0030, 
  0x0C00, 0x0000, 0x8000, 0x0430, 
  0x0800, 0x0000, 0x8000, 0x0010, 
  0x0880, 0x0000, 0x8000, 0x0010, 
  0x0800, 0x8000, 0x8000, 0x0010, 
  0x0800, 0x0040, 0x8000, 0x0010, 
  0x0800, 0x0000, 0x8288, 0x0010, 
  0x0800, 0x0000, 0x8000, 0x0410, 
  0x0800, 0x0000, 0x8000, 0x0010, 
  0x0880, 0x0000, 0x8000, 0x0010, 
  0x0801, 0x0000, 0x8000, 0x0010, 
  0x0800, 0x0040, 0x8000, 0x0010, 
  0x0800, 0x0000, 0x8188, 0x0010, 
  0x0800, 0x0000, 0x8000, 0x0210, 
  0x0800, 0x0000, 0x8000, 0x0010, 
  0x0880, 0x0000, 0x8000, 0x0010, 
  0x0801, 0x0000, 0x8000, 0x0010, 
  0x0800, 0x0040, 0x8000, 0x0010, 
  0x0800, 0x0000, 0x8288, 0x0010, 
  0x0800, 0x0000, 0x8000, 0x0210, 
  0x1800, 0x0000, 0x8000, 0x0018, 
  0x1880, 0x0000, 0x8000, 0x0018, 
  0x1801, 0x0000, 0x8000, 0x0018, 
  0x1800, 0x0040, 0x8000, 0x0018, 
  0x1800, 0x0000, 0x8188, 0x0018, 
  0x1800, 0x0000, 0x8000, 0x0218, 
  0x1000, 0x0000, 0x8000, 0x0008, 
  0x1080, 0x0000, 0x8000, 0x0008, 
  0x1001, 0x0000, 0x8000, 0x0008, 
  0x1000, 0x0040, 0x8000, 0x0008, 
  0x1000, 0x0000, 0x8288, 0x0008, 
  0x1000, 0x0000, 0x8000, 0x0208, 
  0x1000, 0x0000, 0x8000, 0x0008, 
  0x1100, 0x0000, 0x8000, 0x0008, 
  0x1001, 0x0000, 0x8000, 0x0008, 
  0x1000, 0x0040, 0x8000, 0x0008, 
  0x1000, 0x0000, 0x8188, 0x0008, 
  0x1000, 0x0000, 0x8000, 0x0208, 
  0x1000, 0x0000, 0x8000, 0x0008, 
  0x1100, 0x0000, 0x8000, 0x0008, 
  0x1002, 0x0000, 0x8000, 0x0008, 
  0x1000, 0x0040, 0x8000, 0x0008, 
  0x1000, 0x0000, 0x8288, 0x0008, 
  0x1000, 0x0000, 0x8000, 0x0208, 
  0x3000, 0x0000, 0x8000, 0x000C, 
  0x3100, 0x0000, 0x8000, 0x000C, 
  0x3002, 0x0000, 0x8000, 0x000C, 
  0x3000, 0x0040, 0x8000, 0x000C, 
  0x3000, 0x0000, 0x8188, 0x000C, 
  0x3000, 0x0000, 0x8000, 0x010C, 
  0x3000, 0x0000, 0x8000, 0x000C, 
  0x3100, 0x0000, 0x8000, 0x000C, 
  0x3003, 0xE000, 0x8000, 0x000C, 
  0x3000, 0x0040, 0x8000, 0x000C, 
  0x3000, 0x0000, 0x8288, 0x000C, 
  0x3000, 0x0000, 0x8000, 0x010C, 
  0x2000, 0x0000, 0x8000, 0x0004, 
  0x2100, 0x0000, 0x8000, 0x0004, 
  0x2000, 0x1800, 0x8000, 0x0004, 
  0x2000, 0x0040, 0x8000, 0x0004, 
  0x2000, 0x0000, 0x8188, 0x0004, 
  0x2000, 0x0000, 0x8000, 0x0104, 
  0x2000, 0x0000, 0x8000, 0x0004, 
  0x2200, 0x0000, 0x8000, 0x0004, 
  0x2000, 0x2C00, 0x8000, 0x0004, 
  0x2000, 0x0040, 0x8000, 0x0004, 
  0x2000, 0x0000, 0x8288, 0x0004, 
  0x2000, 0x0000, 0x8000, 0x0104, 
  0x2000, 0x0000, 0x0000, 0x0004, 
  0x2200, 0x0000, 0x0000, 0x0004, 
  0x2000, 0x1E00, 0x0000, 0x0004, 
  0x2000, 0x0040, 0x0000, 0x0004, 
  0x2000, 0x0000, 0x0188, 0x0004, 
  0x2000, 0x0000, 0x0000, 0x0104, 
  0x2000, 0x0000, 0x8000, 0x0004, 
  0x2200, 0x0000, 0x8000, 0x0004, 
  0x2000, 0x0600, 0x8000, 0x0004, 
  0x2000, 0x0060, 0x8000, 0x0004, 
  0x2000, 0x0000, 0x8288, 0x0004, 
  0x2000, 0x0000, 0x8000, 0x0084, 
  0x6000, 0x0000, 0x8000, 0x0006, 
  0x6200, 0x0000, 0x8000, 0x0006, 
  0x6000, 0x0B00, 0x8000, 0x0006, 
  0x6000, 0x0010, 0x8000, 0x0006, 
  0x6000, 0x0000, 0x8188, 0x0006, 
  0x6000, 0x0000, 0x8000, 0x0086, 
  0x6000, 0x0000, 0x8000, 0x0006, 
  0x6200, 0x0000, 0x0000, 0x0006, 
  0x6000, 0x0500, 0x0000, 0x0006, 
  0x6000, 0x0038, 0x0000, 0x0006, 
  0x6000, 0x0000, 0x0288, 0x0006, 
  0x6000, 0x0000, 0x0000, 0x0086, 
  0x4000, 0x0000, 0x8000, 0x0002, 
  0x4400, 0x0000, 0x8000, 0x0002, 
  0x4000, 0x0380, 0x8000, 0x0002, 
  0x4000, 0x0018, 0x8000, 0x0002, 
  0x4000, 0x0000, 0x8188, 0x0002, 
  0x4000, 0x0000, 0x8000, 0x0082, 
  0x4000, 0x0000, 0x8000, 0x0002, 
  0x4400, 0x0000, 0x8000, 0x0002, 
  0x4000, 0x0580, 0x8000, 0x0002, 
  0x4000, 0x002C, 0x8000, 0x0002, 
  0x4000, 0x0000, 0x82D8, 0x0002, 
  0x4000, 0x0000, 0x8000, 0x0102, 
  0x4000, 0x0000, 0x8000, 0x0002, 
  0x4407, 0xFF00, 0x8000, 0x0002, 
  0x4000, 0x02C0, 0x8000, 0x0002, 
  0x4000, 0x0014, 0x8000, 0x0002, 
  0x4000, 0x0000, 0x81D0, 0x0002, 
  0x4000, 0x0000, 0x8000, 0x0282, 
  0xC000, 0x0000, 0x8000, 0x0003, 
  0xC43D, 0x55C0, 0x8000, 0x0003, 
  0xC000, 0x0140, 0x8000, 0x0003, 
  0xC000, 0x000E, 0x8000, 0x0003, 
  0xC000, 0x0000, 0x80B0, 0x0003, 
  0xC000, 0x0000, 0x8000, 0x0D03, 
  0xC007, 0xFF00, 0x807F, 0xF003, 
  0xC7E7, 0xFF30, 0x807F, 0xF003, 
  0xC007, 0xFFA0, 0x807F, 0xF003, 
  0xC007, 0xFF16, 0x807F, 0xF003, 
  0xC007, 0xFF00, 0x817F, 0xF003, 
  0xC007, 0xFF00, 0x807F, 0xFA03, 
  0xC03A, 0xAAE0, 0x83AA, 0xAE03, 
  0xC03A, 0xAAEC, 0x83AA, 0xAE03, 
  0xC03A, 0xAAF0, 0x83AA, 0xAE03, 
  0xC03A, 0xAAEA, 0x83AA, 0xAE03, 
  0xC03A, 0xAAE0, 0x80AA, 0xAE03, 
  0xC03A, 0xAAE0, 0x83AA, 0xAF83, 
  0xC155, 0x5550, 0x8555, 0x5543, 
  0xC155, 0x5552, 0x8555, 0x5543, 
  0xC155, 0x555C, 0x8555, 0x5543, 
  0xC155, 0x5556, 0x8555, 0x5543, 
  0xC155, 0x5550, 0x8355, 0x5543, 
  0xC155, 0x5550, 0x8555, 0x5543, 
  0xFFFF, 0xFFFD, 0xDFFF, 0xFFFF, 
  0xFFFF, 0xFFFD, 0xDFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xDFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xDFFF, 0xFFFF, 
  0xFFFF, 0xFFFD, 0xCFFF, 0xFFFF, 
  0xFFFF, 0xFFFD, 0xDFFF, 0xFFFF, 
  0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE, 
  0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE, 
  0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE, 
  0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE, 
  0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE, 
  0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE, 
  0x5555, 0x555D, 0xDD55, 0x5554, 
  0x5555, 0x555D, 0xDD55, 0x5554, 
  0x5555, 0x555D, 0xDD55, 0x5554, 
  0x5555, 0x555D, 0xDD55, 0x5554, 
  0x5555, 0x555D, 0xDD55, 0x5554, 
  0x5555, 0x555D, 0xDD55, 0x5554, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000, 
  0x0000, 0x0007, 0xF000, 0x0000
};

int clipf[] = 
{ 0x0003, 0xC000, 0x0004, 0x2000, 
  0x01FD, 0xBF80, 0x7F05, 0xA0FE, 
  0xD600, 0x0055, 0xBE00, 0x007B, 
  0xD5FF, 0xFFAD, 0xB000, 0x000B, 
  0xDAAA, 0xAAAD, 0xBFFF, 0xFFFB, 
  0xDFFF, 0xFFFD, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xB000, 0x000B, 
  0xD000, 0x000D, 0xBFFF, 0xFFFB, 
  0xDFFF, 0xFFF5, 0xAAAA, 0xAAAB, 
  0xD555, 0x5555, 0xFFFF, 0xFFFF, 
  0x7FFF, 0xFFFE
};

int bgmono2[0x0604] = 
{ 0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x807F, 0xFFFF, 0xFFC0, 0x4000, 
  0x8060, 0x0000, 0x00C0, 0x4000, 
  0x806F, 0xFFFF, 0xFEC0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x03B8, 0x02C0, 0x4000, 
  0x8068, 0x0CA6, 0x02C0, 0x4000, 
  0x8068, 0x10A1, 0x02C0, 0x4000, 
  0x8068, 0x28A2, 0x82C0, 0x4000, 
  0x8068, 0x54A5, 0x42C0, 0x4000, 
  0x8068, 0x4AAA, 0x42C0, 0x4000, 
  0x8068, 0x85B4, 0x22C0, 0x4000, 
  0x8068, 0x8208, 0x22C0, 0x4000, 
  0x8068, 0xFC47, 0xE2C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x806B, 0x8000, 0x02C0, 0x4000, 
  0x806A, 0x8000, 0x02C0, 0x4000, 
  0x806B, 0x8000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8069, 0x8000, 0x02C0, 0x4000, 
  0x806A, 0x4000, 0x02C0, 0x4000, 
  0x806B, 0xC000, 0x02C0, 0x4000, 
  0x806A, 0x4000, 0x02C0, 0x4000, 
  0x806B, 0xC000, 0x02C0, 0x4000, 
  0x806B, 0xC000, 0x02C0, 0x4000, 
  0x806A, 0x4000, 0x02C0, 0x4000, 
  0x806A, 0x4000, 0x02C0, 0x4000, 
  0x806A, 0x4000, 0x02C0, 0x4000, 
  0x8069, 0x8000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x8068, 0x0000, 0x02C0, 0x4000, 
  0x807F, 0xFFFF, 0xFFC0, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xAAAA, 0xAAAA, 0xAAAA, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x807F, 0xFFFF, 0xF800, 0x4000, 
  0x807F, 0xFFFF, 0xFC00, 0x4000, 
  0x807F, 0xFFFF, 0xFE00, 0x4000, 
  0x8070, 0x0000, 0x1F00, 0x4000, 
  0x8072, 0xAAAA, 0x8F80, 0x4000, 
  0x8075, 0x5555, 0x4780, 0x4000, 
  0x8072, 0xAAAA, 0xA380, 0x4000, 
  0x8075, 0x5555, 0x5380, 0x4000, 
  0x8072, 0xAAAA, 0xAB80, 0x4000, 
  0x8075, 0x5555, 0x5380, 0x4000, 
  0x8072, 0xAAAA, 0xAB80, 0x4000, 
  0x8075, 0x5555, 0x5380, 0x4000, 
  0x8072, 0xAAAA, 0xAB80, 0x4000, 
  0x8075, 0x5555, 0x5380, 0x4000, 
  0x8072, 0xAAAA, 0xAB80, 0x4000, 
  0x8075, 0x5555, 0x5380, 0x4000, 
  0x8072, 0xAAAA, 0xAB80, 0x4000, 
  0x8075, 0x5555, 0x5380, 0x4000, 
  0x8072, 0xAAAA, 0xAB80, 0x4000, 
  0x8075, 0x5555, 0x5380, 0x4000, 
  0x8072, 0xAAAA, 0xA380, 0x4000, 
  0x8075, 0x5555, 0x4780, 0x4000, 
  0x8072, 0xAAAA, 0x8F80, 0x4000, 
  0x8075, 0x5555, 0x1F00, 0x4000, 
  0x8072, 0xAAAA, 0x3E00, 0x4000, 
  0x8075, 0x0000, 0x7C00, 0x4000, 
  0x8072, 0x7FFF, 0xF800, 0x4000, 
  0x8074, 0xFFFF, 0xF000, 0x4000, 
  0x8071, 0xFFFF, 0xE000, 0x4000, 
  0x8075, 0xE000, 0x0000, 0x4000, 
  0x8071, 0xC000, 0x0000, 0x4000, 
  0x8075, 0xC000, 0x0000, 0x4000, 
  0x8071, 0xC000, 0x0000, 0x4000, 
  0x8071, 0xC000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0x8070, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xAAAA, 0xAAAA, 0xAAAA, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x3FFC, 0x0000, 0x4000, 
  0x8001, 0xE007, 0x8000, 0x4000, 
  0x8007, 0x0000, 0xE000, 0x4000, 
  0x800C, 0x0000, 0x3800, 0x4000, 
  0x8018, 0x0000, 0x0C00, 0x4000, 
  0x8030, 0x0000, 0x0600, 0x4000, 
  0x8060, 0x0000, 0x0300, 0x4000, 
  0x80C0, 0x0000, 0x0180, 0x4000, 
  0x8180, 0x0000, 0x00C0, 0x4000, 
  0x8300, 0x0000, 0x0060, 0x4000, 
  0x8200, 0x0000, 0x0030, 0x4000, 
  0x8600, 0x0000, 0x0010, 0x4000, 
  0x8400, 0x0000, 0x0018, 0x4000, 
  0x8C00, 0x0000, 0x0008, 0x4000, 
  0x8800, 0x0000, 0x0008, 0x4000, 
  0x8800, 0x0000, 0x000C, 0x4000, 
  0x9800, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x0004, 0x4000, 
  0x9000, 0x0000, 0x000C, 0x4000, 
  0x9800, 0x0000, 0x0008, 0x4000, 
  0x8800, 0x0000, 0x0008, 0x4000, 
  0x8800, 0x0000, 0x0018, 0x4000, 
  0x8C00, 0x0000, 0x0010, 0x4000, 
  0x8400, 0x0000, 0x0030, 0x4000, 
  0x8600, 0x0000, 0x0020, 0x4000, 
  0x8300, 0x0000, 0x0060, 0x4000, 
  0x8180, 0x0000, 0x00C0, 0x4000, 
  0x80C0, 0x0000, 0x0180, 0x4000, 
  0x8060, 0x0000, 0x0300, 0x4000, 
  0x8030, 0x0000, 0x0600, 0x4000, 
  0x8018, 0x0000, 0x0C00, 0x4000, 
  0x800E, 0x0000, 0x1800, 0x4000, 
  0x8003, 0x8000, 0x7000, 0x4000, 
  0x8000, 0xF003, 0xC000, 0x4000, 
  0x8000, 0x1FFE, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xAAAA, 0xAAAA, 0xAAAA, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x3FFF, 0x8000, 0x4000, 
  0x8001, 0xE000, 0xF800, 0x4000, 
  0x801F, 0x0000, 0x0F00, 0x4000, 
  0x8070, 0x0000, 0x01C0, 0x4000, 
  0x80C0, 0x0000, 0x0060, 0x4000, 
  0x8180, 0x0000, 0x0030, 0x4000, 
  0x8100, 0x0000, 0x0010, 0x4000, 
  0x8100, 0x0000, 0x0010, 0x4000, 
  0x8100, 0x0000, 0x0010, 0x4000, 
  0x8100, 0x0000, 0x0010, 0x4000, 
  0x8100, 0x0000, 0x0010, 0x4000, 
  0x8180, 0x0000, 0x0030, 0x4000, 
  0x8080, 0x0000, 0x0020, 0x4000, 
  0x80C0, 0x0000, 0x0060, 0x4000, 
  0x8070, 0x0000, 0x01C0, 0x4000, 
  0x801E, 0x0000, 0x0F00, 0x4000, 
  0x8003, 0xE000, 0xF800, 0x4000, 
  0x8000, 0x3FFF, 0x8000, 0x4000, 
  0x8000, 0x0000, 0x0F80, 0x4000, 
  0x8000, 0x0000, 0x38E0, 0x4000, 
  0x8000, 0x0000, 0x6030, 0x4000, 
  0x8000, 0x0000, 0xC018, 0x4000, 
  0x8000, 0x0000, 0x8008, 0x4000, 
  0x803E, 0x0001, 0x800C, 0x4000, 
  0x80E3, 0x8001, 0x0004, 0x4000, 
  0x8180, 0xC003, 0x0006, 0x4000, 
  0x8100, 0x4002, 0x0002, 0x4000, 
  0x8300, 0x6002, 0x0002, 0x4000, 
  0x8200, 0x2002, 0x0002, 0x4000, 
  0x8200, 0x2002, 0x0002, 0x4000, 
  0x8600, 0x3002, 0x0002, 0x4000, 
  0x8400, 0x1002, 0x0002, 0x4000, 
  0x8400, 0x1002, 0x0002, 0x4000, 
  0x8400, 0x1002, 0x0002, 0x4000, 
  0x8600, 0x3002, 0x0002, 0x4000, 
  0x8200, 0x2003, 0x0006, 0x4000, 
  0x8200, 0x2001, 0x0004, 0x4000, 
  0x8300, 0x6001, 0x800C, 0x4000, 
  0x8100, 0x4000, 0x8008, 0x4000, 
  0x8180, 0xC000, 0xC018, 0x4000, 
  0x80E3, 0x8000, 0x6030, 0x4000, 
  0x803E, 0x0000, 0x38E0, 0x4000, 
  0x8000, 0x0000, 0x0F80, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xAAAA, 0xAAAA, 0xAAAA, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x1F0E, 0x0000, 0x4000, 
  0x8000, 0x7F03, 0x8000, 0x4000, 
  0x8001, 0xFF00, 0xE000, 0x4000, 
  0x8007, 0xFF00, 0x3800, 0x4000, 
  0x801F, 0xFF00, 0x0E00, 0x4000, 
  0x807F, 0xFF00, 0x0380, 0x4000, 
  0x81FF, 0xFF00, 0x00C0, 0x4000, 
  0x81FF, 0xFF00, 0x01C0, 0x4000, 
  0x81FF, 0xFF00, 0x0740, 0x4000, 
  0x817F, 0xFF00, 0x1C40, 0x4000, 
  0x81AF, 0xFF00, 0x7040, 0x4000, 
  0x8157, 0xFF01, 0xC040, 0x4000, 
  0x81AA, 0xFF07, 0x0040, 0x4000, 
  0x8155, 0x7F1C, 0x0040, 0x4000, 
  0x81AA, 0xAFF0, 0x0040, 0x4000, 
  0x8155, 0x5580, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81AA, 0xAA00, 0x0040, 0x4000, 
  0x8155, 0x5500, 0x0040, 0x4000, 
  0x81EA, 0xAA00, 0x00C0, 0x4000, 
  0x8075, 0x5500, 0x0380, 0x4000, 
  0x801E, 0xAA00, 0x0E00, 0x4000, 
  0x8007, 0x5500, 0x3800, 0x4000, 
  0x8001, 0xEA00, 0xE000, 0x4000, 
  0x8000, 0x7503, 0x8000, 0x4000, 
  0x8000, 0x1E0E, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xAAAA, 0xAAAA, 0xAAAA, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x81FF, 0xFFC0, 0x0000, 0x4000, 
  0x83FF, 0xFFE0, 0x0000, 0x4000, 
  0x87FF, 0xFFF0, 0x0000, 0x4000, 
  0x8780, 0x00F8, 0x0000, 0x4000, 
  0x8700, 0x0078, 0x0000, 0x4000, 
  0x8700, 0x0038, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0x0000, 0x0000, 0x4000, 
  0x8700, 0xFFFF, 0xFFFC, 0x4000, 
  0x8700, 0xFFFF, 0xFFFE, 0x4000, 
  0x8700, 0xFFFF, 0xFFFE, 0x4000, 
  0x8700, 0x0000, 0x003E, 0x4000, 
  0x8700, 0x0000, 0x007C, 0x4000, 
  0x8780, 0x0000, 0x00F8, 0x4000, 
  0x87C0, 0x0000, 0x01F0, 0x4000, 
  0x83E0, 0x0000, 0x03E0, 0x4000, 
  0x81F0, 0x0000, 0x07C0, 0x4000, 
  0x80F8, 0x0000, 0x0F80, 0x4000, 
  0x807C, 0x0000, 0x1F00, 0x4000, 
  0x803E, 0x0000, 0x3E00, 0x4000, 
  0x801F, 0x0000, 0x7C00, 0x4000, 
  0x800F, 0x8000, 0xF800, 0x4000, 
  0x8007, 0xC001, 0xF000, 0x4000, 
  0x8003, 0xE003, 0xE000, 0x4000, 
  0x8001, 0xF007, 0xC000, 0x4000, 
  0x8000, 0xF80F, 0x8000, 0x4000, 
  0x8000, 0x7C1F, 0x0000, 0x4000, 
  0x8000, 0x3E3E, 0x0000, 0x4000, 
  0x8000, 0x1FFC, 0x0000, 0x4000, 
  0x8000, 0x0FF8, 0x0000, 0x4000, 
  0x8000, 0x07F0, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xAAAA, 0xAAAA, 0xAAAA, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x807F, 0xFFFF, 0xFF80, 0x4000, 
  0x8180, 0x0000, 0x0060, 0x4000, 
  0x8200, 0x0000, 0x0010, 0x4000, 
  0x8200, 0x0000, 0x0010, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8400, 0x0000, 0x0008, 0x4000, 
  0x8200, 0x0000, 0x0010, 0x4000, 
  0x8200, 0x0000, 0x0010, 0x4000, 
  0x8180, 0x0000, 0x0060, 0x4000, 
  0x807F, 0xFFFF, 0xFF80, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0x8000, 0x0000, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xAAAA, 0xAAAA, 0xAAAA, 0xC000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000, 
  0xB000, 0x0000, 0x000B, 0x4000, 
  0xB7FF, 0xFFFF, 0xFFFB, 0x4000, 
  0xB5AD, 0x0019, 0x5A0B, 0x4000, 
  0xB54D, 0x0032, 0x5C0B, 0x4000, 
  0xB48D, 0x0040, 0x580B, 0x4000, 
  0xB50D, 0x0000, 0x580B, 0x4000, 
  0xB60D, 0x3F80, 0x580B, 0x4000, 
  0xB7FC, 0xC07F, 0xDFFB, 0x4000, 
  0xB401, 0x4010, 0x200B, 0x4000, 
  0xB7FF, 0x400F, 0xDFFB, 0x4000, 
  0xB487, 0xA00C, 0x581B, 0x4000, 
  0xB50D, 0x9006, 0x582B, 0x4000, 
  0xB60B, 0xD00A, 0x584B, 0x4000, 
  0xB417, 0xC805, 0x58AB, 0x4000, 
  0xB413, 0xE403, 0x596B, 0x4000, 
  0xB413, 0xF205, 0x58CB, 0x4000, 
  0xB411, 0xF903, 0x598B, 0x4000, 
  0xB411, 0xFCC5, 0x5B0B, 0x4000, 
  0xB410, 0xFE23, 0x580B, 0x4000, 
  0xB7F0, 0x7F1D, 0xDFFB, 0x4000, 
  0xB408, 0x3FC7, 0x000B, 0x4000, 
  0xB7F8, 0x1FF3, 0xFFFB, 0x4000, 
  0xB404, 0x0FFE, 0x000B, 0x4000, 
  0xB402, 0x07FC, 0x000B, 0x4000, 
  0xB7FF, 0x03FF, 0xFFFB, 0x4000, 
  0xB400, 0xC570, 0x000B, 0x4000, 
  0xB400, 0x3F80, 0x000B, 0x4000, 
  0xB400, 0x0100, 0x000B, 0x4000, 
  0xFFFF, 0xFEFF, 0xFFFF, 0xC000, 
  0x8000, 0x02CE, 0x0000, 0x4000, 
  0x8000, 0x055F, 0x0000, 0x4000, 
  0xFFFF, 0xFD7F, 0xFFFF, 0xC000, 
  0xFFFF, 0xFA3F, 0xFFFF, 0xC000, 
  0x8000, 0x0A3F, 0x8000, 0x4000, 
  0x8000, 0x141F, 0x8000, 0x4000, 
  0x8000, 0x141F, 0x8000, 0x4000, 
  0x8000, 0x280F, 0xC000, 0x4000, 
  0x8000, 0x280F, 0xC000, 0x4000, 
  0x8000, 0x5007, 0xE000, 0x4000, 
  0x8000, 0x5007, 0xE000, 0x4000, 
  0x8000, 0xA003, 0xF000, 0x4000, 
  0xFFFF, 0xA003, 0xFFFF, 0xC000, 
  0x8001, 0x4001, 0xC000, 0x4000, 
  0x8001, 0x8003, 0x0000, 0x4000, 
  0x8000, 0xE00E, 0x0000, 0x4000, 
  0x8000, 0x1FF0, 0x0000, 0x4000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC000
};
