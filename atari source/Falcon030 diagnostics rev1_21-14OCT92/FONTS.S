*	FONTS FOR ST
*	8X8 AND 8X16
*	Differs from TOS font in using Ascii 6 for copyright character
	.globl	_dat_8x8

	.data
	.even

*	128 Ascii characters. The first byte is the top line of the first
*	character; the second byte is the top line of the second character;
*	the 128th byte is the second line of the first character, etc.
_dat_8x8:
	dc.w $18
	dc.w $3C18
	dc.w $18FF
	dc.w $3CE7
	dc.w $1D8
	dc.w $C0CC
	dc.w $F8F0
	dc.w $DB0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $78
	dc.w $3
	dc.w $C048
	dc.w $0
	dc.w $0
	dc.w $1800
	dc.w $1C00
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $600
	dc.w $6000
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $E
	dc.w $1870
	dc.w $10
	dc.w $3C
	dc.w $241C
	dc.w $38FF
	dc.w $42C3
	dc.w $3D8
	dc.w $C0CC
	dc.w $C0C0
	dc.w $DB0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $3660
	dc.w $1C07
	dc.w $E092
	dc.w $18
	dc.w $6666
	dc.w $3E66
	dc.w $3618
	dc.w $E70
	dc.w $6618
	dc.w $0
	dc.w $6
	dc.w $3C18
	dc.w $3C7E
	dc.w $C7E
	dc.w $3C7E
	dc.w $3C3C
	dc.w $0
	dc.w $C00
	dc.w $303C
	dc.w $3C18
	dc.w $7C3C
	dc.w $787E
	dc.w $7E3E
	dc.w $667E
	dc.w $666
	dc.w $6063
	dc.w $663C
	dc.w $7C3C
	dc.w $7C3C
	dc.w $7E66
	dc.w $6663
	dc.w $6666
	dc.w $7E1E
	dc.w $4078
	dc.w $800
	dc.w $C000
	dc.w $6000
	dc.w $600
	dc.w $E00
	dc.w $6018
	dc.w $660
	dc.w $3800
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $1800
	dc.w $0
	dc.w $0
	dc.w $18
	dc.w $1818
	dc.w $3018
	dc.w $66
	dc.w $24F6
	dc.w $6FFF
	dc.w $99A5
	dc.w $6F8
	dc.w $DE78
	dc.w $FEDF
	dc.w $DB0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $7F78
	dc.w $1C0E
	dc.w $7024
	dc.w $18
	dc.w $66FF
	dc.w $606C
	dc.w $1C18
	dc.w $1C38
	dc.w $3C18
	dc.w $0
	dc.w $C
	dc.w $6638
	dc.w $660C
	dc.w $1C60
	dc.w $6006
	dc.w $6666
	dc.w $1818
	dc.w $187E
	dc.w $1866
	dc.w $663C
	dc.w $6666
	dc.w $6C60
	dc.w $6060
	dc.w $6618
	dc.w $66C
	dc.w $6077
	dc.w $7666
	dc.w $6666
	dc.w $6660
	dc.w $1866
	dc.w $6663
	dc.w $6666
	dc.w $C18
	dc.w $6018
	dc.w $1C00
	dc.w $603C
	dc.w $603C
	dc.w $63C
	dc.w $183E
	dc.w $6000
	dc.w $60
	dc.w $1866
	dc.w $7C3C
	dc.w $7C3E
	dc.w $7C3E
	dc.w $7E66
	dc.w $6663
	dc.w $6666
	dc.w $7E18
	dc.w $1818
	dc.w $791C
	dc.w $C3
	dc.w $E783
	dc.w $C1FF
	dc.w $A17E
	dc.w $8CDF
	dc.w $D87F
	dc.w $D8DB
	dc.w $DB0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $7F60
	dc.w $771C
	dc.w $3848
	dc.w $18
	dc.w $6666
	dc.w $3C18
	dc.w $3818
	dc.w $1818
	dc.w $FF7E
	dc.w $7E
	dc.w $18
	dc.w $6E18
	dc.w $C18
	dc.w $3C7C
	dc.w $7C0C
	dc.w $3C3E
	dc.w $1818
	dc.w $3000
	dc.w $C0C
	dc.w $6E66
	dc.w $7C60
	dc.w $667C
	dc.w $7C60
	dc.w $7E18
	dc.w $678
	dc.w $607F
	dc.w $7E66
	dc.w $6666
	dc.w $663C
	dc.w $1866
	dc.w $666B
	dc.w $3C3C
	dc.w $1818
	dc.w $3018
	dc.w $3600
	dc.w $3006
	dc.w $7C60
	dc.w $3E66
	dc.w $3E66
	dc.w $7C38
	dc.w $66C
	dc.w $187F
	dc.w $6666
	dc.w $6666
	dc.w $6660
	dc.w $1866
	dc.w $666B
	dc.w $3C66
	dc.w $C30
	dc.w $180C
	dc.w $4F1E
	dc.w $E7
	dc.w $C383
	dc.w $C1FF
	dc.w $A17E
	dc.w $D8DE
	dc.w $FE36
	dc.w $DEFF
	dc.w $DB0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $3E7E
	dc.w $7738
	dc.w $1C92
	dc.w $18
	dc.w $66
	dc.w $630
	dc.w $6F00
	dc.w $1818
	dc.w $3C18
	dc.w $0
	dc.w $30
	dc.w $7618
	dc.w $180C
	dc.w $6C06
	dc.w $6618
	dc.w $6606
	dc.w $0
	dc.w $1800
	dc.w $1818
	dc.w $6E66
	dc.w $6660
	dc.w $6660
	dc.w $606E
	dc.w $6618
	dc.w $678
	dc.w $606B
	dc.w $7E66
	dc.w $7C66
	dc.w $7C06
	dc.w $1866
	dc.w $667F
	dc.w $3C18
	dc.w $3018
	dc.w $1818
	dc.w $6300
	dc.w $3E
	dc.w $6660
	dc.w $667E
	dc.w $1866
	dc.w $6618
	dc.w $678
	dc.w $187F
	dc.w $6666
	dc.w $6666
	dc.w $603C
	dc.w $1866
	dc.w $667F
	dc.w $1866
	dc.w $1818
	dc.w $1818
	dc.w $61C
	dc.w $24
	dc.w $66F6
	dc.w $6FFF
	dc.w $99A5
	dc.w $7006
	dc.w $1806
	dc.w $181E
	dc.w $1998
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $1C18
	dc.w $870
	dc.w $E24
	dc.w $0
	dc.w $FF
	dc.w $7C66
	dc.w $6600
	dc.w $1C38
	dc.w $6618
	dc.w $1800
	dc.w $1860
	dc.w $6618
	dc.w $3066
	dc.w $7E66
	dc.w $6630
	dc.w $660C
	dc.w $1818
	dc.w $C7E
	dc.w $3000
	dc.w $607E
	dc.w $6666
	dc.w $6C60
	dc.w $6066
	dc.w $6618
	dc.w $666C
	dc.w $6063
	dc.w $6E66
	dc.w $606C
	dc.w $6C06
	dc.w $1866
	dc.w $3C77
	dc.w $6618
	dc.w $6018
	dc.w $C18
	dc.w $0
	dc.w $66
	dc.w $6660
	dc.w $6660
	dc.w $183E
	dc.w $6618
	dc.w $66C
	dc.w $186B
	dc.w $6666
	dc.w $7C3E
	dc.w $6006
	dc.w $1866
	dc.w $3C3E
	dc.w $3C3E
	dc.w $3018
	dc.w $1818
	dc.w $18
	dc.w $24
	dc.w $3C1C
	dc.w $38FF
	dc.w $42C3
	dc.w $2006
	dc.w $1806
	dc.w $181B
	dc.w $399C
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $81E
	dc.w $1CE0
	dc.w $748
	dc.w $18
	dc.w $66
	dc.w $1846
	dc.w $3B00
	dc.w $E70
	dc.w $0
	dc.w $1800
	dc.w $1840
	dc.w $3C7E
	dc.w $7E3C
	dc.w $C3C
	dc.w $3C30
	dc.w $3C38
	dc.w $1818
	dc.w $600
	dc.w $6018
	dc.w $3E66
	dc.w $7C3C
	dc.w $787E
	dc.w $603E
	dc.w $667E
	dc.w $3C66
	dc.w $7E63
	dc.w $663C
	dc.w $6036
	dc.w $663C
	dc.w $187E
	dc.w $1863
	dc.w $6618
	dc.w $7E1E
	dc.w $678
	dc.w $FF
	dc.w $3E
	dc.w $7C3C
	dc.w $3E3C
	dc.w $1806
	dc.w $663C
	dc.w $666
	dc.w $3C63
	dc.w $663C
	dc.w $6006
	dc.w $607C
	dc.w $E3E
	dc.w $1836
	dc.w $660C
	dc.w $7E0E
	dc.w $1870
	dc.w $10
	dc.w $3C
	dc.w $1818
	dc.w $18FF
	dc.w $3CE7
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $6186
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $C0
	dc.w $392
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $3000
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $30
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $7C
	dc.w $0
	dc.w $3C00
	dc.w $0
	dc.w $0
	dc.w $6006
	dc.w $0
	dc.w $0
	dc.w $0
	dc.w $78
	dc.w $0
	dc.w $1800
	dc.w $0

; NO MONO MODE SUPPORTED ANYMORE - look in other test sources for data.

	LIST
