#define COPY 0  	/* TREE */
#define DRIVERS 4  	/* TREE */
#define PBUTTON 6  	/* OBJECT in TREE #4 */
#define DSETUP 11  	/* OBJECT in TREE #4 */
#define DEXIT 12  	/* OBJECT in TREE #4 */
#define INTRO 1  	/* TREE */
#define XFSM 10  	/* OBJECT in TREE #1 */
#define XFONT 11  	/* OBJECT in TREE #1 */
#define XSETUP 14  	/* OBJECT in TREE #1 */
#define XBOX 9  	/* OBJECT in TREE #1 */
#define XEXIT 15  	/* OBJECT in TREE #1 */
#define FSMTITLE 12  	/* OBJECT in TREE #1 */
#define FNTTITLE 13  	/* OBJECT in TREE #1 */
#define DPATH 2  	/* TREE */
#define PSETUP 9  	/* OBJECT in TREE #2 */
#define PEXIT 10  	/* OBJECT in TREE #2 */
#define PPATH 7  	/* OBJECT in TREE #2 */
#define PMETA 7  	/* OBJECT in TREE #4 */
#define PMEM 9  	/* OBJECT in TREE #4 */
#define PMETA2 8  	/* OBJECT in TREE #4 */
#define PMEM2 10  	/* OBJECT in TREE #4 */
#define FONTS 5  	/* TREE */
#define FSETUP 15  	/* OBJECT in TREE #5 */
#define FEXIT 16  	/* OBJECT in TREE #5 */
#define APPS 6  	/* TREE */
#define ASETUP 11  	/* OBJECT in TREE #6 */
#define AEXIT 12  	/* OBJECT in TREE #6 */
#define FFSM 5  	/* OBJECT in TREE #5 */
#define FSCREEN 6  	/* OBJECT in TREE #5 */
#define FNB 8  	/* OBJECT in TREE #5 */
#define FSLM 11  	/* OBJECT in TREE #5 */
#define FFX 12  	/* OBJECT in TREE #5 */
#define FFSM2 10  	/* OBJECT in TREE #5 */
#define FSCREEN2 7  	/* OBJECT in TREE #5 */
#define FNB2 9  	/* OBJECT in TREE #5 */
#define FSLM2 13  	/* OBJECT in TREE #5 */
#define FFX2 14  	/* OBJECT in TREE #5 */
#define ACPX 5  	/* OBJECT in TREE #6 */
#define AACC 7  	/* OBJECT in TREE #6 */
#define APAGE 9  	/* OBJECT in TREE #6 */
#define ACPX2 6  	/* OBJECT in TREE #6 */
#define AACC2 8  	/* OBJECT in TREE #6 */
#define APAGE2 10  	/* OBJECT in TREE #6 */
#define SUBMENU 7  	/* TREE */
#define SNONE 1  	/* OBJECT in TREE #7 */
#define SLAST 16  	/* OBJECT in TREE #7 */
#define PTITLE 5  	/* OBJECT in TREE #4 */
#define INSERT 8  	/* TREE */
#define IINSERT 5  	/* OBJECT in TREE #8 */
#define IEXIT 6  	/* OBJECT in TREE #8 */
#define ITITLE1 3  	/* OBJECT in TREE #8 */
#define ITITLE2 4  	/* OBJECT in TREE #8 */
#define COMPLETE 12  	/* TREE */
#define CEXIT 1  	/* OBJECT in TREE #12 */
#define CFNAME 4  	/* OBJECT in TREE #0 */
#define COMMENCE 9  	/* TREE */
#define ZSETUP 6  	/* OBJECT in TREE #9 */
#define ZEXIT 7  	/* OBJECT in TREE #9 */
#define EASSIGN 11  	/* TREE */
#define EASETUP 14  	/* OBJECT in TREE #11 */
#define EAEXIT 15  	/* OBJECT in TREE #11 */
#define A1 8  	/* OBJECT in TREE #11 */
#define A2 9  	/* OBJECT in TREE #11 */
#define A3 10  	/* OBJECT in TREE #11 */
#define EPATH 10  	/* TREE */
#define EPATHS 7  	/* OBJECT in TREE #10 */
#define EOK2 9  	/* OBJECT in TREE #10 */
#define EEXIT2 10  	/* OBJECT in TREE #10 */
#define EEXTEND 3  	/* TREE */
#define E1 8  	/* OBJECT in TREE #3 */
#define E2 9  	/* OBJECT in TREE #3 */
#define E3 10  	/* OBJECT in TREE #3 */
#define EOK 14  	/* OBJECT in TREE #3 */
#define EEXIT 15  	/* OBJECT in TREE #3 */
#define GDOSTST 13  	/* TREE */
#define GEXIT 10  	/* OBJECT in TREE #13 */
#define B1 11  	/* OBJECT in TREE #11 */
#define B2 12  	/* OBJECT in TREE #11 */
#define B3 13  	/* OBJECT in TREE #11 */
#define F1 11  	/* OBJECT in TREE #3 */
#define F2 12  	/* OBJECT in TREE #3 */
#define F3 13  	/* OBJECT in TREE #3 */
