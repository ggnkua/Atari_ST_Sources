/* COUNTRY.H
 *==========================================================================
 * DATE: December 12, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */
#if 0
#define TRUE	1
#define FALSE 	0
#endif

#define USA	TRUE
#define UK	FALSE
		
#define GERMAN	FALSE
#define FRENCH	FALSE

#define	SPAIN	FALSE
#define	SWEDEN	FALSE
#define ITALY	FALSE

