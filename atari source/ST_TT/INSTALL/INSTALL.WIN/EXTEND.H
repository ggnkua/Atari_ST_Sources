/* PROTOTYPES
 * ================================================================
 */
int	extend_dialog( void );
void	SetExtendWindow( void );
int	extend_handler( void );

/* GLOBALS
 * ================================================================
 */
extern char ENewFile[];
