/* PROTOTYPES
 * ================================================================
 */
int	assign_dialog( void );
void	SetAssignWindow( void );
int	assign_handler( void );

/* GLOBALS
 * ================================================================
 */
extern char ANewFile[];
