int	driver_dialog( void );
void	FillPNode( char *cptr, int count );
void	SetPrinterMenu( void );
