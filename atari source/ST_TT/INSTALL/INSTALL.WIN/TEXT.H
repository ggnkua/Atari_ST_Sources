/* FILE: TEXT.H
 * ================================================================
 */


/* FILE.C
 * ================================================================
 */
extern char alert1[];
extern char alert2[];
extern char alert3[];
extern char alert4[];
extern char alert5[];
extern char alert6[];
extern char tosalert[];
extern char diskalert[];



/* INSTALL.C
 * ================================================================
 */
extern char alert7[];
extern char alert8[];
extern char alert9[];
extern char alert10[];

extern char inserta[];
extern char insertb[];

/* MAINSTUF.C
 * ================================================================
 */
extern char alert11[];
extern char alert12[];
extern char alert14[];


extern char no_cpxfile[];
extern char no_cpxpath[];

extern char wfsm[];
extern char wfont[];
extern char wtitle[];
extern char nowin[];
extern char aexit[];
extern char arsc[];
extern char anone[];

/* GEMSKEL.C
 * ================================================================
 */
extern char alow[];
extern char bad_path[];
extern char dirmake[];
extern char bad_drive[];

 
extern char read_error[];
extern char write_error[];
extern char mem_error[];
extern char open_error[]; 
extern char no_file_error[];
 
