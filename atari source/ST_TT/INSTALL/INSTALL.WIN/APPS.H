int	apps_dialog( void );
