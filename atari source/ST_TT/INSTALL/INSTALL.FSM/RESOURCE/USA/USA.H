#define DIRS 2  	/* TREE */
#define FOLDERS 2  	/* OBJECT in TREE #2 */
#define CONFLICT 3  	/* TREE */
#define DRIVERS 4  	/* TREE */
#define DOK 5  	/* OBJECT in TREE #4 */
#define DBUTTON 3  	/* OBJECT in TREE #4 */
#define COPY 5  	/* TREE */
#define COPYFROM 2  	/* OBJECT in TREE #5 */
#define COPYTO 3  	/* OBJECT in TREE #5 */
#define CEXTEND 7  	/* TREE */
#define MASSIGN 6  	/* TREE */
#define RENAME 8  	/* TREE */
#define RNEWNAME 3  	/* OBJECT in TREE #8 */
#define ROLDNAME 1  	/* OBJECT in TREE #8 */
#define COLDNAME 1  	/* OBJECT in TREE #3 */
#define CNEWNAME 3  	/* OBJECT in TREE #3 */
#define CCOPY 4  	/* OBJECT in TREE #3 */
#define CCANCEL 5  	/* OBJECT in TREE #3 */
#define CASSIGN 9  	/* TREE */
#define EDRIVE 0  	/* TREE */
#define EPATH 1  	/* TREE */
#define EDRIVER 10  	/* TREE */
#define ECPXACC 11  	/* TREE */
#define I1TITLE 6  	/* OBJECT in TREE #0 */
#define I1BUTTON 7  	/* OBJECT in TREE #0 */
#define I1OK 1  	/* OBJECT in TREE #0 */
#define I1CANCEL 2  	/* OBJECT in TREE #0 */
#define I2TEXT 7  	/* OBJECT in TREE #1 */
#define I2OK 8  	/* OBJECT in TREE #1 */
#define I2CANCEL 9  	/* OBJECT in TREE #1 */
#define I3TITLE 6  	/* OBJECT in TREE #10 */
#define I3BUTTON 7  	/* OBJECT in TREE #10 */
#define I3OK 1  	/* OBJECT in TREE #10 */
#define I3CANCEL 2  	/* OBJECT in TREE #10 */
#define ESCREEN 12  	/* TREE */
#define I4OK 1  	/* OBJECT in TREE #12 */
#define I4CANCEL 2  	/* OBJECT in TREE #12 */
#define I4YES 7  	/* OBJECT in TREE #12 */
#define I4NO 8  	/* OBJECT in TREE #12 */
#define EPFONTS 13  	/* TREE */
#define I5OK 1  	/* OBJECT in TREE #13 */
#define I5CANCEL 2  	/* OBJECT in TREE #13 */
#define I5BUTTON 7  	/* OBJECT in TREE #13 */
#define I5TITLE 6  	/* OBJECT in TREE #13 */
#define I6TITLE 6  	/* OBJECT in TREE #11 */
#define I6OK 1  	/* OBJECT in TREE #11 */
#define I6CANCEL 2  	/* OBJECT in TREE #11 */
#define I6BUTTON 7  	/* OBJECT in TREE #11 */
#define EMETA 14  	/* TREE */
#define I7TITLE 6  	/* OBJECT in TREE #14 */
#define I7BUTTON 7  	/* OBJECT in TREE #14 */
#define I7OK 1  	/* OBJECT in TREE #14 */
#define I7CANCEL 2  	/* OBJECT in TREE #14 */
#define EASS 15  	/* TREE */
#define I8TITLE 18  	/* OBJECT in TREE #15 */
#define I8BUTTON 17  	/* OBJECT in TREE #15 */
#define I8OK 14  	/* OBJECT in TREE #15 */
#define I8CANCEL 15  	/* OBJECT in TREE #15 */
#define ENOASS 16  	/* TREE */
#define I9TITLE 13  	/* OBJECT in TREE #16 */
#define I9BUTTON 14  	/* OBJECT in TREE #16 */
#define I9OK 10  	/* OBJECT in TREE #16 */
#define I9CANCEL 11  	/* OBJECT in TREE #16 */
#define I8APATH 5  	/* OBJECT in TREE #15 */
#define I8EPATH 12  	/* OBJECT in TREE #15 */
#define I9EPATH 7  	/* OBJECT in TREE #16 */
#define I9HEADER 2  	/* OBJECT in TREE #16 */
#define EAPATH 17  	/* TREE */
#define I10TITLE 4  	/* OBJECT in TREE #17 */
#define I10BUT 5  	/* OBJECT in TREE #17 */
#define I10PATH 8  	/* OBJECT in TREE #17 */
#define I10OK 9  	/* OBJECT in TREE #17 */
#define I10CAN 10  	/* OBJECT in TREE #17 */
#define I2DRIVE 6  	/* OBJECT in TREE #1 */
#define ECPX 18  	/* TREE */
#define I11OK 5  	/* OBJECT in TREE #18 */
#define I11CAN 6  	/* OBJECT in TREE #18 */
#define I11TITLE 2  	/* OBJECT in TREE #18 */
#define EFILE 19  	/* TREE */
#define I12OK 5  	/* OBJECT in TREE #19 */
#define I12CAN 6  	/* OBJECT in TREE #19 */
#define EGDOS 20  	/* TREE */
#define EGPLUS 21  	/* TREE */
#define EFGDOS 22  	/* TREE */
#define I14OK 4  	/* OBJECT in TREE #20 */
#define I14CAN 5  	/* OBJECT in TREE #20 */
#define I15OK 4  	/* OBJECT in TREE #21 */
#define I15CAN 5  	/* OBJECT in TREE #21 */
#define I16OK 4  	/* OBJECT in TREE #22 */
#define I16CAN 5  	/* OBJECT in TREE #22 */
#define ENTRY 23  	/* TREE */
#define IFSM 6  	/* OBJECT in TREE #23 */
#define IFGDOS 7  	/* OBJECT in TREE #23 */
#define IOK 8  	/* OBJECT in TREE #23 */
#define ICANCEL 9  	/* OBJECT in TREE #23 */
#define I3HEAD 3  	/* OBJECT in TREE #10 */
#define I4HEAD 3  	/* OBJECT in TREE #12 */
#define I5HEAD 3  	/* OBJECT in TREE #13 */
#define I6HEAD 3  	/* OBJECT in TREE #11 */
#define I7HEAD 3  	/* OBJECT in TREE #14 */
#define EAFILE 24  	/* TREE */
#define I17OK 5  	/* OBJECT in TREE #24 */
#define I17CAN 6  	/* OBJECT in TREE #24 */
#define PAGEONE 25  	/* TREE */
#define I18OK 6  	/* OBJECT in TREE #25 */
#define I18CAN 7  	/* OBJECT in TREE #25 */
#define I18YES 4  	/* OBJECT in TREE #25 */
#define I18NO 5  	/* OBJECT in TREE #25 */
#define PAGETWO 26  	/* TREE */
#define I19BUTT 5  	/* OBJECT in TREE #26 */
#define I19OK 6  	/* OBJECT in TREE #26 */
#define I19CAN 7  	/* OBJECT in TREE #26 */
#define I19TITLE 4  	/* OBJECT in TREE #26 */
