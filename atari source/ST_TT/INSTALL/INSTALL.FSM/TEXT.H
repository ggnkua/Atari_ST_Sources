/* FILE: TEXT.H
 * ================================================================
 */


/* FILE.C
 * ================================================================
 */
extern char alert1[];
extern char alert2[];
extern char alert3[];
extern char alert4[];
extern char alert5[];
extern char alert6[];
extern char tosalert[];
extern char diskalert[];



/* INSTALL.C
 * ================================================================
 */
extern char alert7[];
extern char alert8[];
extern char alert9[];
extern char alert10[];

extern char *fx80text[];
extern char *nb15text[];
extern char *slmtext[];


/* MAINSTUF.C
 * ================================================================
 */
extern char alert11[];
extern char alert12[];
extern char alert14[];
extern char *iheader[];

extern char *DriveNames[];
extern char *DriverNames[];
extern char *BFontNames[];
extern char *CPXNames[];
extern char *MetaNames[];
extern char *AssNames[];
extern char *NoAssNames[];
extern char *NoAssOther[];
extern char commence[];
extern char *APathNames[];
extern char acancel[];
extern char *ECPXNames[];
extern char *DriverIndex[];
extern char *CurBStyle[];


/* GEMSKEL.C
 * ================================================================
 */
extern char alow[];


 
 
 