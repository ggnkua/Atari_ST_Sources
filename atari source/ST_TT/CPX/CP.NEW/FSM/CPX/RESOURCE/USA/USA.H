#define FSM 0  	/* TREE */
#define QUIT 18  	/* OBJECT in TREE #0 */
#define MENU 1  	/* OBJECT in TREE #0 */
#define FOUTLINE 1  	/* TREE */
#define OEXIT 26  	/* OBJECT in TREE #1 */
#define LINE0 8  	/* OBJECT in TREE #0 */
#define LINE1 9  	/* OBJECT in TREE #0 */
#define LINE2 10  	/* OBJECT in TREE #0 */
#define LINE3 11  	/* OBJECT in TREE #0 */
#define LINE4 12  	/* OBJECT in TREE #0 */
#define LINE5 13  	/* OBJECT in TREE #0 */
#define LINEBASE 7  	/* OBJECT in TREE #0 */
#define UP 14  	/* OBJECT in TREE #0 */
#define DOWN 17  	/* OBJECT in TREE #0 */
#define SLIDER 16  	/* OBJECT in TREE #0 */
#define BASE 15  	/* OBJECT in TREE #0 */
#define FOSIZES 2  	/* TREE */
#define FOEXIT 25  	/* OBJECT in TREE #2 */
#define DFTNAME 1  	/* OBJECT in TREE #2 */
#define OPLINE0 11  	/* OBJECT in TREE #2 */
#define OPLINE1 12  	/* OBJECT in TREE #2 */
#define OPLINE2 13  	/* OBJECT in TREE #2 */
#define OPLINE3 14  	/* OBJECT in TREE #2 */
#define OPLINE4 15  	/* OBJECT in TREE #2 */
#define OPLINE5 16  	/* OBJECT in TREE #2 */
#define OPTEXT 10  	/* OBJECT in TREE #2 */
#define OPUP 17  	/* OBJECT in TREE #2 */
#define OPDOWN 23  	/* OBJECT in TREE #2 */
#define OPSLIDER 20  	/* OBJECT in TREE #2 */
#define OPBASE 19  	/* OBJECT in TREE #2 */
#define ADDSIZE 18  	/* OBJECT in TREE #2 */
#define DELSIZE 21  	/* OBJECT in TREE #2 */
#define FOCANCEL 24  	/* OBJECT in TREE #2 */
#define NEWPTSIZ 3  	/* TREE */
#define NOK 10  	/* OBJECT in TREE #3 */
#define NCANCEL 9  	/* OBJECT in TREE #3 */
#define NUP 3  	/* OBJECT in TREE #3 */
#define NDOWN 4  	/* OBJECT in TREE #3 */
#define NNUM 6  	/* OBJECT in TREE #3 */
#define OCANCEL 27  	/* OBJECT in TREE #1 */
#define SYMTITLE 6  	/* OBJECT in TREE #1 */
#define SYMTEXT 7  	/* OBJECT in TREE #1 */
#define SYMFLAG 9  	/* OBJECT in TREE #1 */
#define HEBTITLE 11  	/* OBJECT in TREE #1 */
#define HEBFLAG 14  	/* OBJECT in TREE #1 */
#define HEBTEXT 12  	/* OBJECT in TREE #1 */
#define WIDTHFLG 17  	/* OBJECT in TREE #1 */
#define FSMPATH 20  	/* OBJECT in TREE #1 */
#define FSMLEFT 21  	/* OBJECT in TREE #1 */
#define FSMRIGHT 22  	/* OBJECT in TREE #1 */
#define DEFPOINT 24  	/* OBJECT in TREE #1 */
#define USEDFLT 22  	/* OBJECT in TREE #2 */
#define FONTNAME 2  	/* OBJECT in TREE #2 */
#define OLEFT 3  	/* OBJECT in TREE #2 */
#define ORIGHT 4  	/* OBJECT in TREE #2 */
#define OSAVE 19  	/* OBJECT in TREE #0 */
#define FCACHE 4  	/* TREE */
#define CUP 3  	/* OBJECT in TREE #4 */
#define CDOWN 7  	/* OBJECT in TREE #4 */
#define CSIZE 5  	/* OBJECT in TREE #4 */
#define FSMOK 20  	/* OBJECT in TREE #4 */
#define FSMCAN 21  	/* OBJECT in TREE #4 */
#define CACHEOPT 5  	/* TREE */
#define CACHEOK 12  	/* OBJECT in TREE #5 */
#define LCACHE 3  	/* OBJECT in TREE #5 */
#define MCACHE 4  	/* OBJECT in TREE #5 */
#define SCACHE 5  	/* OBJECT in TREE #5 */
#define CCACHE 6  	/* OBJECT in TREE #5 */
#define SCANMSG 6  	/* TREE */
#define MAKEWID 7  	/* TREE */
#define WIDNAME 2  	/* OBJECT in TREE #7 */
#define LOADING 8  	/* TREE */
#define BMAP 10  	/* OBJECT in TREE #5 */
#define DCACHE 11  	/* OBJECT in TREE #5 */
#define COMMAND 6  	/* OBJECT in TREE #0 */
#define BOTTOM 5  	/* OBJECT in TREE #0 */
#define BOTTOM2 2  	/* OBJECT in TREE #0 */
#define OACTIVE 3  	/* OBJECT in TREE #0 */
#define OSET 4  	/* OBJECT in TREE #0 */
#define ADD10 5  	/* OBJECT in TREE #2 */
#define ADD12 6  	/* OBJECT in TREE #2 */
#define ADD18 7  	/* OBJECT in TREE #2 */
#define ADD24 8  	/* OBJECT in TREE #2 */
#define ADD48 9  	/* OBJECT in TREE #2 */
#define SETCACHE 3  	/* OBJECT in TREE #1 */
#define MSIZE 11  	/* OBJECT in TREE #4 */
#define MUP 9  	/* OBJECT in TREE #4 */
#define MDOWN 13  	/* OBJECT in TREE #4 */
#define BSIZE 17  	/* OBJECT in TREE #4 */
#define BUP 15  	/* OBJECT in TREE #4 */
#define BDOWN 19  	/* OBJECT in TREE #4 */
