/*==========================================================================
 * FILE: TEXT.H
 *==========================================================================
 * DATE: Sept 21, 1990
 * DESCRIPTION: Country Specific Text Strings
 * COMPILER: TURBO C Version 2.0
 */
 
/* FILE: FSM.C */
extern char *command_txt[];
extern char *status_txt[];
extern char *move_txt[];
extern char *move2_txt[];
extern char *menu_items[];
extern char alert0[];
extern char alert1[];

/* FILE: BUILDWD.C */
extern char alert2[];
extern char alert3[];
extern char alert4[];
extern char alert5[];
extern char alert16[];

/* FILE: FSMIO.C */
extern char alert6[];
extern char alert7[];
extern char alert8[];
extern char alert9[];
extern char alert10[];
extern char alert11[];
extern char alert12[];

extern char msg1[];

/* FILE: OUTLINE.C */
extern char title_fsmpath[];
extern char title_symbol[];
extern char title_hebrew[];
extern char *width_text[];
extern char none_text[];
extern char sym_alert[];

/* FILE: POINTS.C */
extern char *use_default_text[];
extern char *name_text[];
extern char alert14[];
extern char alert15[];
extern char alert20[];
extern char alert23[];

/* FILE: CACHEOPTS.C */
extern char alert17[];
extern char alert18[];
extern char alert19[];


/* FILE: STATUS.C */
extern char alert21[];
extern char alert22[];
