void Do_Cache_Size( void );
int  FSM_Cache_Button( int button, WORD *msg );
long limits( long num, long min_num, long max_num );

