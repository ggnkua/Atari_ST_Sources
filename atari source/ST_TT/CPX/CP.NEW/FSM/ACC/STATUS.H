void	CacheCheck( int pointsize );
long	GetCurUsage( void );
void	CachePrompt( void );
