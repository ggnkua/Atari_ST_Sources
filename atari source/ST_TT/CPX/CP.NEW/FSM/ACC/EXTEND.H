int	parse_extend( int skip );
void	skipequal( void );
int     isdir( struct stat *s );



extern char epath[];

extern struct stat statbuf;

