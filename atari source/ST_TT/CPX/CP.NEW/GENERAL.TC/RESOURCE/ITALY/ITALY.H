#define GENERAL 0  	/* TREE */
#define LRESP 13  	/* OBJECT in TREE #0 */
#define RESPBASE 10  	/* OBJECT in TREE #0 */
#define RRESP 12  	/* OBJECT in TREE #0 */
#define KRESPONS 11  	/* OBJECT in TREE #0 */
#define LREPEAT 3  	/* OBJECT in TREE #0 */
#define KREPEAT 6  	/* OBJECT in TREE #0 */
#define REPTBASE 5  	/* OBJECT in TREE #0 */
#define RREPEAT 4  	/* OBJECT in TREE #0 */
#define M0 28  	/* OBJECT in TREE #0 */
#define M1 29  	/* OBJECT in TREE #0 */
#define M2 30  	/* OBJECT in TREE #0 */
#define M3 31  	/* OBJECT in TREE #0 */
#define M4 32  	/* OBJECT in TREE #0 */
#define TARGET2 24  	/* OBJECT in TREE #0 */
#define DOUBLE 26  	/* OBJECT in TREE #0 */
#define CLICKER 27  	/* OBJECT in TREE #0 */
#define GCANCEL 36  	/* OBJECT in TREE #0 */
#define GOK 37  	/* OBJECT in TREE #0 */
#define GSAVE 39  	/* OBJECT in TREE #0 */
#define KEYICON 22  	/* OBJECT in TREE #0 */
#define KEYCLICK 23  	/* OBJECT in TREE #0 */
#define BELLICON 18  	/* OBJECT in TREE #0 */
#define BELL 19  	/* OBJECT in TREE #0 */
#define BLK1TXT 44  	/* OBJECT in TREE #0 */
#define BLK2TXT 47  	/* OBJECT in TREE #0 */
#define BLK1BUTT 45  	/* OBJECT in TREE #0 */
#define BLK2BUTT 48  	/* OBJECT in TREE #0 */
#define BLK2 46  	/* OBJECT in TREE #0 */
#define BLK1 43  	/* OBJECT in TREE #0 */
#define STATUS 41  	/* OBJECT in TREE #0 */
#define PARTZ 1  	/* TREE */
#define VERSION 4  	/* OBJECT in TREE #1 */
#define DATE1 5  	/* OBJECT in TREE #1 */
#define STFREE 8  	/* OBJECT in TREE #1 */
#define TTFREE 10  	/* OBJECT in TREE #1 */
#define TTTOTAL 12  	/* OBJECT in TREE #1 */
#define FREETXT 9  	/* OBJECT in TREE #1 */
#define TOTALTXT 11  	/* OBJECT in TREE #1 */
#define STATOK 15  	/* OBJECT in TREE #1 */
#define DATE2 16  	/* OBJECT in TREE #1 */
