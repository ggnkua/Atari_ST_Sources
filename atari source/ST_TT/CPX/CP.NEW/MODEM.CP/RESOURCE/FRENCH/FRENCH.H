#define RS232 0  	/* TREE */
#define BAUD 3  	/* OBJECT in TREE #0 */
#define PARITY 6  	/* OBJECT in TREE #0 */
#define BITSCHAR 9  	/* OBJECT in TREE #0 */
#define STOPX 12  	/* OBJECT in TREE #0 */
#define PORT 15  	/* OBJECT in TREE #0 */
#define FLOW 19  	/* OBJECT in TREE #0 */
#define SAVE 23  	/* OBJECT in TREE #0 */
#define RS232CAN 25  	/* OBJECT in TREE #0 */
#define RS232OK 24  	/* OBJECT in TREE #0 */
