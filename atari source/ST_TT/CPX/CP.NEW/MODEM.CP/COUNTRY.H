/* COUNTRY.H
 *==========================================================================
 * DATE: April 3, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */
#define TRUE	1
#define FALSE 	0
 
#define USA	FALSE
#define UK	FALSE   /* NOt NEEDED...UK same as USA */

#define GERMAN	FALSE
#define FRENCH	FALSE

#define	SPAIN	FALSE
#define	SWEDEN	FALSE
#define ITALY	TRUE
