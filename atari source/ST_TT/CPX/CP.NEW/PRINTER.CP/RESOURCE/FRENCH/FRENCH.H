#define PRINTER 0  	/* TREE */
#define PSAVE 21  	/* OBJECT in TREE #0 */
#define PTYPE 3  	/* OBJECT in TREE #0 */
#define COLOR 6  	/* OBJECT in TREE #0 */
#define PIXLINE 9  	/* OBJECT in TREE #0 */
#define QUALITY 12  	/* OBJECT in TREE #0 */
#define PAPER 18  	/* OBJECT in TREE #0 */
#define PORT 15  	/* OBJECT in TREE #0 */
#define POK 23  	/* OBJECT in TREE #0 */
#define PCANCEL 24  	/* OBJECT in TREE #0 */
