#define FRGOK 0		/* FREE STRING */
#define FRGCAN 1		/* FREE STRING */
#define FRGSAVE 2		/* FREE STRING */
#define ITACAN 4		/* FREE STRING */
#define ITASAVE 5		/* FREE STRING */
#define ITAOK 3		/* FREE STRING */
#define SWEOK 6		/* FREE STRING */
#define SWECAN 7		/* FREE STRING */
#define SWESAVE 8		/* FREE STRING */
#define SPAOK 9		/* FREE STRING */
#define SPACAN 10		/* FREE STRING */
#define SPASAVE 11		/* FREE STRING */
#define FRAOK 12		/* FREE STRING */
#define FRACAN 13		/* FREE STRING */
#define FRASAVE 14		/* FREE STRING */
#define PARTZ 1  	/* TREE */
#define WCOLPANL 0  	/* TREE */
#define BGBOX 6  	/* OBJECT in TREE #0 */
#define BGTITLE 7  	/* OBJECT in TREE #0 */
#define BGNAME 8  	/* OBJECT in TREE #0 */
#define BGINFO 9  	/* OBJECT in TREE #0 */
#define BGDATA 10  	/* OBJECT in TREE #0 */
#define BGWORK 11  	/* OBJECT in TREE #0 */
#define BGVBAR 12  	/* OBJECT in TREE #0 */
#define BGHBAR 13  	/* OBJECT in TREE #0 */
#define BGSIZER 14  	/* OBJECT in TREE #0 */
#define TBOX 15  	/* OBJECT in TREE #0 */
#define TTITLE 16  	/* OBJECT in TREE #0 */
#define TCLOSER 17  	/* OBJECT in TREE #0 */
#define TFULLER 18  	/* OBJECT in TREE #0 */
#define TNAME 19  	/* OBJECT in TREE #0 */
#define TINFO 20  	/* OBJECT in TREE #0 */
#define TDATA 21  	/* OBJECT in TREE #0 */
#define TWORK 22  	/* OBJECT in TREE #0 */
#define TVBAR 42  	/* OBJECT in TREE #0 */
#define TUP 43  	/* OBJECT in TREE #0 */
#define TDN 44  	/* OBJECT in TREE #0 */
#define TVSLID 45  	/* OBJECT in TREE #0 */
#define TVELEV 46  	/* OBJECT in TREE #0 */
#define THBAR 47  	/* OBJECT in TREE #0 */
#define TLF 48  	/* OBJECT in TREE #0 */
#define TRT 49  	/* OBJECT in TREE #0 */
#define THSLID 50  	/* OBJECT in TREE #0 */
#define THELEV 51  	/* OBJECT in TREE #0 */
#define TSIZER 52  	/* OBJECT in TREE #0 */
#define SAVE 2  	/* OBJECT in TREE #0 */
#define OK 4  	/* OBJECT in TREE #0 */
#define CANCEL 5  	/* OBJECT in TREE #0 */
#define MODE 29  	/* OBJECT in TREE #0 */
#define BORDSLID 23  	/* OBJECT in TREE #0 */
#define BORDELEV 24  	/* OBJECT in TREE #0 */
#define TEXTSLID 25  	/* OBJECT in TREE #0 */
#define TEXTELEV 26  	/* OBJECT in TREE #0 */
#define FILLSLID 27  	/* OBJECT in TREE #0 */
#define FILLELEV 28  	/* OBJECT in TREE #0 */
#define FILL0 31  	/* OBJECT in TREE #0 */
#define FILL1 32  	/* OBJECT in TREE #0 */
#define FILL2 33  	/* OBJECT in TREE #0 */
#define FILL3 34  	/* OBJECT in TREE #0 */
#define FILL4 35  	/* OBJECT in TREE #0 */
#define FILL5 36  	/* OBJECT in TREE #0 */
#define FILL6 37  	/* OBJECT in TREE #0 */
#define FILL7 38  	/* OBJECT in TREE #0 */
#define FLOATER 53  	/* OBJECT in TREE #0 */
#define FILLS 30  	/* OBJECT in TREE #0 */
