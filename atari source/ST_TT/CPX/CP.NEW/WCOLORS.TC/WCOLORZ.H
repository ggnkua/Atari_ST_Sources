#define FRGOK 1		/* FREE STRING */
#define FRGCAN 2		/* FREE STRING */
#define FRGSAVE 3		/* FREE STRING */
#define ITACAN 38		/* FREE STRING */
#define ITASAVE 39		/* FREE STRING */
#define ITAOK 37		/* FREE STRING */
#define SWEOK 49		/* FREE STRING */
#define SWECAN 50		/* FREE STRING */
#define SWESAVE 51		/* FREE STRING */
#define SPAOK 25		/* FREE STRING */
#define SPACAN 26		/* FREE STRING */
#define SPASAVE 27		/* FREE STRING */
#define FRAOK 13		/* FREE STRING */
#define FRACAN 14		/* FREE STRING */
#define FRASAVE 15		/* FREE STRING */
#define WCOLPANL 0  	/* TREE */
#define BGBOX 6  	/* OBJECT in TREE #0 */
#define BGTITLE 7  	/* OBJECT in TREE #0 */
#define BGNAME 8  	/* OBJECT in TREE #0 */
#define BGINFO 9  	/* OBJECT in TREE #0 */
#define BGDATA 10  	/* OBJECT in TREE #0 */
#define BGWORK 11  	/* OBJECT in TREE #0 */
#define BGVBAR 12  	/* OBJECT in TREE #0 */
#define BGHBAR 13  	/* OBJECT in TREE #0 */
#define BGSIZER 14  	/* OBJECT in TREE #0 */
#define TBOX 15  	/* OBJECT in TREE #0 */
#define TTITLE 16  	/* OBJECT in TREE #0 */
#define TCLOSER 17  	/* OBJECT in TREE #0 */
#define TFULLER 18  	/* OBJECT in TREE #0 */
#define TNAME 19  	/* OBJECT in TREE #0 */
#define TINFO 20  	/* OBJECT in TREE #0 */
#define TDATA 21  	/* OBJECT in TREE #0 */
#define TWORK 22  	/* OBJECT in TREE #0 */
#define TVBAR 42  	/* OBJECT in TREE #0 */
#define TUP 43  	/* OBJECT in TREE #0 */
#define TDN 44  	/* OBJECT in TREE #0 */
#define TVSLID 45  	/* OBJECT in TREE #0 */
#define TVELEV 46  	/* OBJECT in TREE #0 */
#define THBAR 47  	/* OBJECT in TREE #0 */
#define TLF 48  	/* OBJECT in TREE #0 */
#define TRT 49  	/* OBJECT in TREE #0 */
#define THSLID 50  	/* OBJECT in TREE #0 */
#define THELEV 51  	/* OBJECT in TREE #0 */
#define TSIZER 52  	/* OBJECT in TREE #0 */
#define SAVE 2  	/* OBJECT in TREE #0 */
#define OK 4  	/* OBJECT in TREE #0 */
#define CANCEL 5  	/* OBJECT in TREE #0 */
#define MODE 29  	/* OBJECT in TREE #0 */
#define BORDSLID 23  	/* OBJECT in TREE #0 */
#define BORDELEV 24  	/* OBJECT in TREE #0 */
#define TEXTSLID 25  	/* OBJECT in TREE #0 */
#define TEXTELEV 26  	/* OBJECT in TREE #0 */
#define FILLSLID 27  	/* OBJECT in TREE #0 */
#define FILLELEV 28  	/* OBJECT in TREE #0 */
#define FILL0 31  	/* OBJECT in TREE #0 */
#define FILL1 32  	/* OBJECT in TREE #0 */
#define FILL2 33  	/* OBJECT in TREE #0 */
#define FILL3 34  	/* OBJECT in TREE #0 */
#define FILL4 35  	/* OBJECT in TREE #0 */
#define FILL5 36  	/* OBJECT in TREE #0 */
#define FILL6 37  	/* OBJECT in TREE #0 */
#define FILL7 38  	/* OBJECT in TREE #0 */
#define FLOATER 53  	/* OBJECT in TREE #0 */
#define FILLS 30  	/* OBJECT in TREE #0 */
#define ALERT 60  	/* STRING */
#define FRGWIND 4		/* FREE STRING */
#define FRGINFO 5		/* FREE STRING */
#define FRGBORD 6		/* FREE STRING */
#define FRGTEXT 7		/* FREE STRING */
#define FRGMODE 9		/* FREE STRING */
#define BORD 39  	/* OBJECT in TREE #0 */
#define TEXT 40  	/* OBJECT in TREE #0 */
#define FILL 41  	/* OBJECT in TREE #0 */
#define FRGFILL 8		/* FREE STRING */
#define FRGDOW 10		/* FREE STRING */
#define FRGINF 11		/* FREE STRING */
#define FRAWIND 16		/* FREE STRING */
#define FRAINFO 17		/* FREE STRING */
#define FRABORD 18		/* FREE STRING */
#define FRATEXT 19		/* FREE STRING */
#define FRAFILL 20		/* FREE STRING */
#define FRAMODE 21		/* FREE STRING */
#define FRADOW 22		/* FREE STRING */
#define FRAINF 23		/* FREE STRING */
#define SPAWIND 28		/* FREE STRING */
#define SPAINFO 29		/* FREE STRING */
#define SPABORD 30		/* FREE STRING */
#define SPATEXT 31		/* FREE STRING */
#define SPAFILL 32		/* FREE STRING */
#define SPAMODE 33		/* FREE STRING */
#define SPADOW 34		/* FREE STRING */
#define SPAINF 35		/* FREE STRING */
#define ITAWIND 40		/* FREE STRING */
#define ITAINFO 41		/* FREE STRING */
#define ITABORD 42		/* FREE STRING */
#define ITATEXT 43		/* FREE STRING */
#define ITAFILL 44		/* FREE STRING */
#define ITAMODE 45		/* FREE STRING */
#define ITADOW 46		/* FREE STRING */
#define ITAINF 47		/* FREE STRING */
#define SWEWIND 52		/* FREE STRING */
#define SWEINFO 53		/* FREE STRING */
#define SWEBORD 54		/* FREE STRING */
#define SWETEXT 55		/* FREE STRING */
#define SWEFILL 56		/* FREE STRING */
#define SWEMODE 57		/* FREE STRING */
#define SWEDOW 58		/* FREE STRING */
#define SWEINF 59		/* FREE STRING */
#define FRGLERT 61  	/* STRING */
#define FRALERT 62  	/* STRING */
#define SPALERT 63  	/* STRING */
#define ITALERT 64  	/* STRING */
#define SWELERT 65  	/* STRING */
