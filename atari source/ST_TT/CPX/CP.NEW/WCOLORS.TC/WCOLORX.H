#define FRGOK 14  	/* OBJECT in TREE #1 */
#define FRGCAN 15  	/* OBJECT in TREE #1 */
#define FRGSAVE 16  	/* OBJECT in TREE #1 */
#define ITACAN 48  	/* OBJECT in TREE #1 */
#define ITASAVE 49  	/* OBJECT in TREE #1 */
#define ITAOK 47  	/* OBJECT in TREE #1 */
#define SWEOK 58  	/* OBJECT in TREE #1 */
#define SWECAN 59  	/* OBJECT in TREE #1 */
#define SWESAVE 60  	/* OBJECT in TREE #1 */
#define SPAOK 36  	/* OBJECT in TREE #1 */
#define SPACAN 37  	/* OBJECT in TREE #1 */
#define SPASAVE 38  	/* OBJECT in TREE #1 */
#define FRAOK 25  	/* OBJECT in TREE #1 */
#define FRACAN 26  	/* OBJECT in TREE #1 */
#define FRASAVE 27  	/* OBJECT in TREE #1 */
#define WCOLPANL 0  	/* TREE */
#define BGBOX 6  	/* OBJECT in TREE #0 */
#define BGTITLE 7  	/* OBJECT in TREE #0 */
#define BGNAME 8  	/* OBJECT in TREE #0 */
#define BGINFO 9  	/* OBJECT in TREE #0 */
#define BGDATA 10  	/* OBJECT in TREE #0 */
#define BGWORK 11  	/* OBJECT in TREE #0 */
#define BGVBAR 12  	/* OBJECT in TREE #0 */
#define BGHBAR 13  	/* OBJECT in TREE #0 */
#define BGSIZER 14  	/* OBJECT in TREE #0 */
#define TBOX 15  	/* OBJECT in TREE #0 */
#define TTITLE 16  	/* OBJECT in TREE #0 */
#define TCLOSER 17  	/* OBJECT in TREE #0 */
#define TFULLER 18  	/* OBJECT in TREE #0 */
#define TNAME 19  	/* OBJECT in TREE #0 */
#define TINFO 20  	/* OBJECT in TREE #0 */
#define TDATA 21  	/* OBJECT in TREE #0 */
#define TWORK 22  	/* OBJECT in TREE #0 */
#define TVBAR 42  	/* OBJECT in TREE #0 */
#define TUP 43  	/* OBJECT in TREE #0 */
#define TDN 44  	/* OBJECT in TREE #0 */
#define TVSLID 45  	/* OBJECT in TREE #0 */
#define TVELEV 46  	/* OBJECT in TREE #0 */
#define THBAR 47  	/* OBJECT in TREE #0 */
#define TLF 48  	/* OBJECT in TREE #0 */
#define TRT 49  	/* OBJECT in TREE #0 */
#define THSLID 50  	/* OBJECT in TREE #0 */
#define THELEV 51  	/* OBJECT in TREE #0 */
#define TSIZER 52  	/* OBJECT in TREE #0 */
#define SAVE 2  	/* OBJECT in TREE #0 */
#define OK 4  	/* OBJECT in TREE #0 */
#define CANCEL 5  	/* OBJECT in TREE #0 */
#define MODE 29  	/* OBJECT in TREE #0 */
#define BORDSLID 23  	/* OBJECT in TREE #0 */
#define BORDELEV 24  	/* OBJECT in TREE #0 */
#define TEXTSLID 25  	/* OBJECT in TREE #0 */
#define TEXTELEV 26  	/* OBJECT in TREE #0 */
#define FILLSLID 27  	/* OBJECT in TREE #0 */
#define FILLELEV 28  	/* OBJECT in TREE #0 */
#define FILL0 31  	/* OBJECT in TREE #0 */
#define FILL1 32  	/* OBJECT in TREE #0 */
#define FILL2 33  	/* OBJECT in TREE #0 */
#define FILL3 34  	/* OBJECT in TREE #0 */
#define FILL4 35  	/* OBJECT in TREE #0 */
#define FILL5 36  	/* OBJECT in TREE #0 */
#define FILL6 37  	/* OBJECT in TREE #0 */
#define FILL7 38  	/* OBJECT in TREE #0 */
#define FLOATER 53  	/* OBJECT in TREE #0 */
#define FILLS 30  	/* OBJECT in TREE #0 */
#define ALERT 0  	/* STRING */
#define FRGWIND 17  	/* OBJECT in TREE #1 */
#define FRGINFO 18  	/* OBJECT in TREE #1 */
#define FRGBORD 19  	/* OBJECT in TREE #1 */
#define FRGTEXT 20  	/* OBJECT in TREE #1 */
#define FRGMODE 22  	/* OBJECT in TREE #1 */
#define BORD 39  	/* OBJECT in TREE #0 */
#define TEXT 40  	/* OBJECT in TREE #0 */
#define FILL 41  	/* OBJECT in TREE #0 */
#define FRGFILL 21  	/* OBJECT in TREE #1 */
#define FRAWIND 28  	/* OBJECT in TREE #1 */
#define FRAINFO 29  	/* OBJECT in TREE #1 */
#define FRABORD 30  	/* OBJECT in TREE #1 */
#define FRATEXT 31  	/* OBJECT in TREE #1 */
#define FRAFILL 32  	/* OBJECT in TREE #1 */
#define FRAMODE 33  	/* OBJECT in TREE #1 */
#define SPAWIND 39  	/* OBJECT in TREE #1 */
#define SPAINFO 40  	/* OBJECT in TREE #1 */
#define SPABORD 41  	/* OBJECT in TREE #1 */
#define SPATEXT 42  	/* OBJECT in TREE #1 */
#define SPAFILL 43  	/* OBJECT in TREE #1 */
#define SPAMODE 44  	/* OBJECT in TREE #1 */
#define ITAWIND 50  	/* OBJECT in TREE #1 */
#define ITAINFO 51  	/* OBJECT in TREE #1 */
#define ITABORD 52  	/* OBJECT in TREE #1 */
#define ITATEXT 53  	/* OBJECT in TREE #1 */
#define ITAFILL 54  	/* OBJECT in TREE #1 */
#define ITAMODE 55  	/* OBJECT in TREE #1 */
#define SWEWIND 61  	/* OBJECT in TREE #1 */
#define SWEINFO 62  	/* OBJECT in TREE #1 */
#define SWEBORD 63  	/* OBJECT in TREE #1 */
#define SWETEXT 64  	/* OBJECT in TREE #1 */
#define SWEFILL 65  	/* OBJECT in TREE #1 */
#define SWEMODE 66  	/* OBJECT in TREE #1 */
#define FRGLERT 1  	/* STRING */
#define FRALERT 2  	/* STRING */
#define SPALERT 3  	/* STRING */
#define ITALERT 4  	/* STRING */
#define SWELERT 5  	/* STRING */
#define XLATE 1  	/* TREE */
#define USAOK 3  	/* OBJECT in TREE #1 */
#define USACAN 4  	/* OBJECT in TREE #1 */
#define USASAVE 5  	/* OBJECT in TREE #1 */
#define USAWIND 6  	/* OBJECT in TREE #1 */
#define USAINFO 7  	/* OBJECT in TREE #1 */
#define USABORD 8  	/* OBJECT in TREE #1 */
#define USATEXT 9  	/* OBJECT in TREE #1 */
#define USAFILL 10  	/* OBJECT in TREE #1 */
#define USAMODE 11  	/* OBJECT in TREE #1 */
