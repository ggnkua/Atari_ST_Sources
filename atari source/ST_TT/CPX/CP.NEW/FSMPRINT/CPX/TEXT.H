/*==========================================================================
 * FILE: TEXT.H
 *==========================================================================
 * DATE: Sept 21, 1990
 * DESCRIPTION: Country Specific Text Strings
 * COMPILER: TURBO C Version 2.0
 */
 
/* FILE: MAINSTUF.C */
extern char *print_text[];
extern char *size_text[];
extern char *rez_text[];
extern char *color_text[];
extern char *port_text[];
extern char *tray_text[];
extern char rez_width[];
extern char rez_height[];
extern char rez2_width[];
extern char rez2_height[];
extern char xy1_unit[];
extern char xy2_unit[];

extern char alert0[];
extern char NoDrivers[];
extern char YesDrivers[];


/* FILE: FILEIO.C */
extern char alert1[];
extern char alert2[];
extern char alert3[];
extern char alert4[];
