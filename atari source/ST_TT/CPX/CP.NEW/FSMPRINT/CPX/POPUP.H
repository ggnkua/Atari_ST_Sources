int	 Pop_Handle( OBJECT *tree, int button, char *items[],
		     int num_items, int *default_item,
		     int font_size, int width );

