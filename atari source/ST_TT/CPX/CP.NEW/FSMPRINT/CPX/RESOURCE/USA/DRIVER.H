#define DRIVER 0  	/* TREE */
#define DOK 16  	/* OBJECT in TREE #0 */
#define DCANCEL 17  	/* OBJECT in TREE #0 */
#define DPRINT 3  	/* OBJECT in TREE #0 */
#define DPAGE 4  	/* OBJECT in TREE #0 */
#define DCOLOR 7  	/* OBJECT in TREE #0 */
#define DPORT 9  	/* OBJECT in TREE #0 */
#define DTRAY 11  	/* OBJECT in TREE #0 */
#define DDRIVER 1  	/* OBJECT in TREE #0 */
#define QTITLE 2  	/* OBJECT in TREE #0 */
#define STITLE 5  	/* OBJECT in TREE #0 */
#define CTITLE 6  	/* OBJECT in TREE #0 */
#define PTITLE 8  	/* OBJECT in TREE #0 */
#define TTITLE 10  	/* OBJECT in TREE #0 */
#define DHSIZE 13  	/* OBJECT in TREE #0 */
#define DVSIZE 15  	/* OBJECT in TREE #0 */
#define HTITLE 12  	/* OBJECT in TREE #0 */
#define VTITLE 14  	/* OBJECT in TREE #0 */
#define XYREZ 1  	/* TREE */
#define XYOK 6  	/* OBJECT in TREE #1 */
#define XYCANCEL 7  	/* OBJECT in TREE #1 */
#define SETX 4  	/* OBJECT in TREE #1 */
#define SETY 5  	/* OBJECT in TREE #1 */
#define XYUNITS 2  	/* OBJECT in TREE #1 */
