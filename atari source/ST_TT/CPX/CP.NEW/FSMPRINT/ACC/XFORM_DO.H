/* PROTOTYPES
 *======================================================================
 */
WORD    xform_do( OBJECT *tree, WORD start_field, WORD puntmsg[] );
void    SetWmCloseState( BOOLEAN flag );
BOOLEAN	CheckWmClose( void );
void	SetAccCloseState( BOOLEAN flag );
BOOLEAN CheckAccClose( void );
