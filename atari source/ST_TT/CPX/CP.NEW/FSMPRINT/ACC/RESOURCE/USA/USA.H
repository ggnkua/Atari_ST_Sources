#define PRINTER 0  	/* TREE */
#define FOK 5  	/* OBJECT in TREE #0 */
#define XMODIFY 2  	/* OBJECT in TREE #0 */
#define XROOT 1  	/* OBJECT in TREE #0 */
#define SCANMSG 1  	/* TREE */
