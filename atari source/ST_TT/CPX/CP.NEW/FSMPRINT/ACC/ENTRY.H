extern OBJECT  *tree; 
extern OBJECT  *cpxtree;
extern OBJECT  *drivetree;
extern OBJECT  *xytree;
extern OBJECT  *ad_scan;
void	Scan_Message( OBJECT *Tree, BOOLEAN flag );
