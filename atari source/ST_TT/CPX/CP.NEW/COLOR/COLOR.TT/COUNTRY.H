/* COUNTRY.H
 *==========================================================================
 * DATE: April 3, 1990
 * DESCRIPTION: COUNTRY DEFINE for ACTIVE COUNTRY
 */
#define TRUE	1
#define FALSE 	0
 
#define USA	TRUE
#define UK	FALSE		/* The UK might use the same resource, but */
						/* it needs to be compiled on its own...   */
#define FRANCE	FALSE
#define GERMANY	FALSE
#define ITALY	FALSE

#define	SPAIN	FALSE
#define	SWEDEN	FALSE


