#define COLPNL 0  	/* TREE */
#define COLSAVE 62  	/* OBJECT in TREE #0 */
#define COLOK 63  	/* OBJECT in TREE #0 */
#define COLCNCEL 64  	/* OBJECT in TREE #0 */
#define RGBBOX 1  	/* OBJECT in TREE #0 */
#define BOX0 5  	/* OBJECT in TREE #0 */
#define BOX1 6  	/* OBJECT in TREE #0 */
#define BOX2 7  	/* OBJECT in TREE #0 */
#define BOX3 8  	/* OBJECT in TREE #0 */
#define BOX4 9  	/* OBJECT in TREE #0 */
#define BOX5 10  	/* OBJECT in TREE #0 */
#define BOX6 11  	/* OBJECT in TREE #0 */
#define BOX7 12  	/* OBJECT in TREE #0 */
#define BOX8 13  	/* OBJECT in TREE #0 */
#define BOX9 14  	/* OBJECT in TREE #0 */
#define BOX10 15  	/* OBJECT in TREE #0 */
#define BOX11 16  	/* OBJECT in TREE #0 */
#define BOX12 17  	/* OBJECT in TREE #0 */
#define BOX13 18  	/* OBJECT in TREE #0 */
#define BOX14 19  	/* OBJECT in TREE #0 */
#define BOX15 20  	/* OBJECT in TREE #0 */
#define RUP 60  	/* OBJECT in TREE #0 */
#define GUP 48  	/* OBJECT in TREE #0 */
#define BUP 53  	/* OBJECT in TREE #0 */
#define RBASE 57  	/* OBJECT in TREE #0 */
#define GBASE 49  	/* OBJECT in TREE #0 */
#define BBASE 54  	/* OBJECT in TREE #0 */
#define RSLID 58  	/* OBJECT in TREE #0 */
#define GSLID 50  	/* OBJECT in TREE #0 */
#define BSLID 55  	/* OBJECT in TREE #0 */
#define RDOWN 59  	/* OBJECT in TREE #0 */
#define GDOWN 51  	/* OBJECT in TREE #0 */
#define BDOWN 56  	/* OBJECT in TREE #0 */
#define COLUP 21  	/* OBJECT in TREE #0 */
#define COLBASE 22  	/* OBJECT in TREE #0 */
#define COLSLID 23  	/* OBJECT in TREE #0 */
#define COLDOWN 24  	/* OBJECT in TREE #0 */
#define ALLBOXES 4  	/* OBJECT in TREE #0 */
#define INVRSVDO 36  	/* OBJECT in TREE #0 */
#define SETGRAY 34  	/* OBJECT in TREE #0 */
#define SETCOL 35  	/* OBJECT in TREE #0 */
#define COLRLOAD 66  	/* OBJECT in TREE #0 */
#define BNKBOX 37  	/* OBJECT in TREE #0 */
#define BNKLEFT 39  	/* OBJECT in TREE #0 */
#define BNKSLID 41  	/* OBJECT in TREE #0 */
#define BNKBASE 40  	/* OBJECT in TREE #0 */
#define BNKRIGHT 42  	/* OBJECT in TREE #0 */
#define RGBSLID 45  	/* OBJECT in TREE #0 */
#define DUOBOXES 25  	/* OBJECT in TREE #0 */
#define DUO1 27  	/* OBJECT in TREE #0 */
#define DUO0 26  	/* OBJECT in TREE #0 */
#define QTBOXES 28  	/* OBJECT in TREE #0 */
#define QUARTRO0 29  	/* OBJECT in TREE #0 */
#define QUARTRO1 30  	/* OBJECT in TREE #0 */
#define QUARTRO2 31  	/* OBJECT in TREE #0 */
#define QUARTRO3 32  	/* OBJECT in TREE #0 */
