void DoEditDevices( void );
int  Edit_Button( int button, WORD *msg );


extern int  CurHotDriver;
extern char *CurNames[];