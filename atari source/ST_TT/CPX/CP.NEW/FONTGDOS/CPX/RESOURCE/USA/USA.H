#define FONTGDOS 0  	/* TREE */
#define QUIT 18  	/* OBJECT in TREE #0 */
#define AMENU 1  	/* OBJECT in TREE #0 */
#define LINE0 8  	/* OBJECT in TREE #0 */
#define LINE1 9  	/* OBJECT in TREE #0 */
#define LINE2 10  	/* OBJECT in TREE #0 */
#define LINE3 11  	/* OBJECT in TREE #0 */
#define LINE4 12  	/* OBJECT in TREE #0 */
#define LINE5 13  	/* OBJECT in TREE #0 */
#define LINEBASE 7  	/* OBJECT in TREE #0 */
#define UP 14  	/* OBJECT in TREE #0 */
#define DOWN 17  	/* OBJECT in TREE #0 */
#define SLIDER 16  	/* OBJECT in TREE #0 */
#define BASE 15  	/* OBJECT in TREE #0 */
#define SCANMSG 1  	/* TREE */
#define INACTIVE 2  	/* TREE */
#define EDIT 3  	/* TREE */
#define IQUIT 18  	/* OBJECT in TREE #2 */
#define OLINE0 8  	/* OBJECT in TREE #2 */
#define OLINE1 9  	/* OBJECT in TREE #2 */
#define OLINE2 10  	/* OBJECT in TREE #2 */
#define OLINE3 11  	/* OBJECT in TREE #2 */
#define OLINE4 12  	/* OBJECT in TREE #2 */
#define OLINE5 13  	/* OBJECT in TREE #2 */
#define OUP 14  	/* OBJECT in TREE #2 */
#define ODOWN 17  	/* OBJECT in TREE #2 */
#define OBASE 15  	/* OBJECT in TREE #2 */
#define OSLIDE 16  	/* OBJECT in TREE #2 */
#define OLBASE 7  	/* OBJECT in TREE #2 */
#define XDEVICE 3  	/* OBJECT in TREE #0 */
#define XDRIVER 2  	/* OBJECT in TREE #0 */
#define XUP 4  	/* OBJECT in TREE #0 */
#define XDOWN 5  	/* OBJECT in TREE #0 */
#define XTRANSFR 19  	/* OBJECT in TREE #2 */
#define OXUP 5  	/* OBJECT in TREE #2 */
#define OXDOWN 6  	/* OBJECT in TREE #2 */
#define OXDEVICE 3  	/* OBJECT in TREE #2 */
#define OXDRIVER 2  	/* OBJECT in TREE #2 */
#define EEXIT 1  	/* OBJECT in TREE #3 */
#define PATH 4  	/* TREE */
#define PEXIT 8  	/* OBJECT in TREE #4 */
#define PCANCEL 7  	/* OBJECT in TREE #4 */
#define PBASE 5  	/* OBJECT in TREE #4 */
#define PRIGHT 6  	/* OBJECT in TREE #4 */
#define PLEFT 4  	/* OBJECT in TREE #4 */
#define CURUP 4  	/* OBJECT in TREE #3 */
#define CURDOWN 5  	/* OBJECT in TREE #3 */
#define CURNUM 6  	/* OBJECT in TREE #3 */
#define CURNAME 7  	/* OBJECT in TREE #3 */
#define CURROM 8  	/* OBJECT in TREE #3 */
#define CURRES 9  	/* OBJECT in TREE #3 */
#define AUP 13  	/* OBJECT in TREE #3 */
#define ADOWN 14  	/* OBJECT in TREE #3 */
#define ANUM 15  	/* OBJECT in TREE #3 */
#define ANAME 18  	/* OBJECT in TREE #3 */
#define AROM 16  	/* OBJECT in TREE #3 */
#define ARES 17  	/* OBJECT in TREE #3 */
#define EDELETE 10  	/* OBJECT in TREE #3 */
#define EADD 19  	/* OBJECT in TREE #3 */
#define ATITLE 12  	/* OBJECT in TREE #3 */
#define IMENU 1  	/* OBJECT in TREE #2 */
#define FRONT 5  	/* TREE */
#define MMENU 6  	/* TREE */
#define FPRINTER 3  	/* OBJECT in TREE #5 */
#define FDRAFT 13  	/* OBJECT in TREE #5 */
#define FFINAL 14  	/* OBJECT in TREE #5 */
#define FSAVE 18  	/* OBJECT in TREE #5 */
#define FOPTIONS 16  	/* OBJECT in TREE #5 */
#define FEXIT 17  	/* OBJECT in TREE #5 */
#define FPAPER 8  	/* OBJECT in TREE #5 */
#define FREZ 9  	/* OBJECT in TREE #5 */
#define FDPI 10  	/* OBJECT in TREE #5 */
#define FQUALITY 12  	/* OBJECT in TREE #5 */
#define MTOP 7  	/* OBJECT in TREE #6 */
#define MDRIVER 3  	/* OBJECT in TREE #6 */
#define MFONT 4  	/* OBJECT in TREE #6 */
#define MPATH 5  	/* OBJECT in TREE #6 */
#define REMOVE 19  	/* OBJECT in TREE #0 */
