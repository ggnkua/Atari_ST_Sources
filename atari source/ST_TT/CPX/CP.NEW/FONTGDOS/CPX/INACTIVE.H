void	Do_InActiveFonts( void );
int	InActive_Button( int button, WORD *msg );
void	ClearListFlags( void );
