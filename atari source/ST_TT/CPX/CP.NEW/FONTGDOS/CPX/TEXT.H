/*==========================================================================
 * FILE: TEXT.H
 *==========================================================================
 * DATE: January 17, 1991
 * DESCRIPTION: Country Specific Text Strings
 * COMPILER: TURBO C Version 2.0
 */
 
/* MAINSTUF.C */
extern char driver_null[];
extern char *amenu_text[];

/* EDIT.C */
extern char alert1[];
extern char alert2[];
extern char *DevTitles[];


/* FSMIO.C */
extern char alert3[];
extern char alert4[];
extern char alert5[];
extern char alert6[];
extern char alert7[];
extern char alert8[];
extern char AlertFull[];

extern char data_null[];
extern char *page_data[];
extern char rez_map[];
extern char rez_map2[];
extern char dpi_map[];

/* INACTIVE.C */
extern char alert9[];
extern char alert10[];
extern char alert11[];
extern char alert12[];
extern char *imenu_text[];

