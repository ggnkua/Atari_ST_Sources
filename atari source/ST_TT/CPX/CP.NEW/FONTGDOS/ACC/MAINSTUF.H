/* PROTOTYPES 
 * ===============================================================
 */

/* EXTERNS
 * ===============================================================
 */
extern OBJECT *tree; 
extern OBJECT *ad_inactive;		/* Outline Tree          */
extern OBJECT *ad_active;		/* Font GDOS tree        */
extern OBJECT *ad_path;			/* Edit Font path tree   */
extern OBJECT *ad_edit;			/* Edit Devices tree	 */
extern OBJECT *ad_scan;
extern OBJECT *ad_front;
extern OBJECT *ad_menu;

extern OBJECT *PrevTree;
