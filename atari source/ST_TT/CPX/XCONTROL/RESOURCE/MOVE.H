#define MOVECPX 0  	/* TREE */
#define ROK 24  	/* OBJECT in TREE #0 */
#define RCANCEL 25  	/* OBJECT in TREE #0 */
#define RRELOAD 23  	/* OBJECT in TREE #0 */
#define MOVETEXT 26  	/* OBJECT in TREE #0 */
#define A0 2  	/* OBJECT in TREE #0 */
#define A1 3  	/* OBJECT in TREE #0 */
#define A2 4  	/* OBJECT in TREE #0 */
#define A3 5  	/* OBJECT in TREE #0 */
#define A4 6  	/* OBJECT in TREE #0 */
#define AUP 8  	/* OBJECT in TREE #0 */
#define ASLIDER 11  	/* OBJECT in TREE #0 */
#define ABASE 10  	/* OBJECT in TREE #0 */
#define ADOWN 9  	/* OBJECT in TREE #0 */
#define ATEXT 1  	/* OBJECT in TREE #0 */
#define I0 13  	/* OBJECT in TREE #0 */
#define I1 14  	/* OBJECT in TREE #0 */
#define I2 15  	/* OBJECT in TREE #0 */
#define I3 16  	/* OBJECT in TREE #0 */
#define I4 17  	/* OBJECT in TREE #0 */
#define IUP 20  	/* OBJECT in TREE #0 */
#define ISLIDER 19  	/* OBJECT in TREE #0 */
#define IBASE 18  	/* OBJECT in TREE #0 */
#define IDOWN 21  	/* OBJECT in TREE #0 */
#define ITEXT 12  	/* OBJECT in TREE #0 */
