/* ALERT.H
 *==========================================================================
 * DATE: April 3, 1990
 * DESCRIPTION: INCLUDE.H file from RESOURCE
 */
 
 
#if USA | UK
 #include "alert\usa\usa.h" 
#endif

#if ITALY
 #include "alert\italy\italy.h" 
#endif

#if GERMAN
 #include "alert\german\german.h" 
#endif

#if FRENCH
 #include "alert\french\french.h" 
#endif

#if SPAIN
 #include "alert\spain\spain.h" 
#endif

#if SWEDEN
 #include "alert\sweden\sweden.h" 
#endif

