#define ALERTS 0  	/* TREE */
#define ACANCEL 4  	/* OBJECT in TREE #0 */
#define AOK1 2  	/* OBJECT in TREE #0 */
#define AOK2 3  	/* OBJECT in TREE #0 */
#define ALERT1 5  	/* OBJECT in TREE #0 */
#define ALERT2 6  	/* OBJECT in TREE #0 */
#define ALERT3 7  	/* OBJECT in TREE #0 */
#define ALERTICN 1  	/* OBJECT in TREE #0 */
