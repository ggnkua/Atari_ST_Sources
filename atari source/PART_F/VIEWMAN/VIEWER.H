#define MENU 0  	/* TREE */
#define QUIT 18  	/* OBJECT in TREE #0 */
#define ABOUT 9  	/* OBJECT in TREE #0 */
#define ABOUT1 1  	/* TREE */
#define AQUIT 1  	/* OBJECT in TREE #1 */
#define LOADW 36  	/* OBJECT in TREE #0 */
#define SAVEW 37  	/* OBJECT in TREE #0 */
#define CLRWRLD 22  	/* OBJECT in TREE #0 */
#define SIZEWRLD 23  	/* OBJECT in TREE #0 */
#define TILENORM 24  	/* OBJECT in TREE #0 */
#define TILEIRR 26  	/* OBJECT in TREE #0 */
#define SET2LYNX 28  	/* OBJECT in TREE #0 */
#define SET2WRLD 29  	/* OBJECT in TREE #0 */
#define TILES 2  	/* TREE */
#define WORLDSIZ 3  	/* TREE */
#define GRIDS 4  	/* TREE */
#define GRIDSET 32  	/* OBJECT in TREE #0 */
#define SIZEW 4  	/* OBJECT in TREE #3 */
#define SIZEH 5  	/* OBJECT in TREE #3 */
#define WORLDOK 2  	/* OBJECT in TREE #3 */
#define WORLDCAN 3  	/* OBJECT in TREE #3 */
#define GRIDX 6  	/* OBJECT in TREE #4 */
#define GRIDY 7  	/* OBJECT in TREE #4 */
#define GRIDW 4  	/* OBJECT in TREE #4 */
#define GRIDH 5  	/* OBJECT in TREE #4 */
#define GRIDOK 12  	/* OBJECT in TREE #4 */
#define GRIDCAN 13  	/* OBJECT in TREE #4 */
#define IRRTEXT 3  	/* OBJECT in TREE #2 */
#define IX 5  	/* OBJECT in TREE #2 */
#define IY 6  	/* OBJECT in TREE #2 */
#define ROWX 8  	/* OBJECT in TREE #2 */
#define ROWY 9  	/* OBJECT in TREE #2 */
#define COLX 11  	/* OBJECT in TREE #2 */
#define COLY 12  	/* OBJECT in TREE #2 */
#define TILEOK 13  	/* OBJECT in TREE #2 */
#define TILECAN 14  	/* OBJECT in TREE #2 */
#define CUROBJ 14  	/* OBJECT in TREE #4 */
#define GRIDTEXT 3  	/* OBJECT in TREE #4 */
#define CLRFLOOR 34  	/* OBJECT in TREE #0 */
#define LOADPAL 39  	/* OBJECT in TREE #0 */
#define SETBPATH 20  	/* OBJECT in TREE #0 */
#define LOADC 41  	/* OBJECT in TREE #0 */
#define SAVEC 42  	/* OBJECT in TREE #0 */
#define XHELP 5  	/* TREE */
#define HEXIT 3  	/* OBJECT in TREE #5 */
#define HNEXT 2  	/* OBJECT in TREE #5 */
#define HPREV 1  	/* OBJECT in TREE #5 */
#define H0 6  	/* OBJECT in TREE #5 */
#define H1 7  	/* OBJECT in TREE #5 */
#define H2 8  	/* OBJECT in TREE #5 */
#define H3 9  	/* OBJECT in TREE #5 */
#define H4 10  	/* OBJECT in TREE #5 */
#define H5 11  	/* OBJECT in TREE #5 */
#define H6 12  	/* OBJECT in TREE #5 */
#define H7 13  	/* OBJECT in TREE #5 */
#define H8 14  	/* OBJECT in TREE #5 */
#define HBASE 5  	/* OBJECT in TREE #5 */
#define GRIDOFF 11  	/* OBJECT in TREE #4 */
#define GRIDON 10  	/* OBJECT in TREE #4 */
#define GRIDBASE 9  	/* OBJECT in TREE #4 */
