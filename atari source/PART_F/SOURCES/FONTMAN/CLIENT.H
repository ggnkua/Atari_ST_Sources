extern    bool _MyAlloc();
extern    void _MyRelease();
extern    void MyNoop();
extern    char *_MyFopen();
extern    void _MyError();
extern    void _MyFclose();
extern    long _MyFseek();
extern    long _MyFread();
