/* resource file indicies for FONTMAN */

#define ABOUTIT  0	/* form/dialog */
#define AEXIT    6	/* BUTTON in tree ABOUTIT */

#define BITSEL   1	/* form/dialog */
#define FBACK    0	/* BOX in tree BITSEL */
#define BITCLOSE 2	/* BOXTEXT in tree BITSEL */
#define BITABOUT 3	/* BOXTEXT in tree BITSEL */
#define BBIGBOX  4	/* BOX in tree BITSEL */
#define FBOX     6	/* BOX in tree BITSEL */
#define FDOWN    8	/* TEXT in tree BITSEL */
#define FSLPAREN 9	/* BOX in tree BITSEL */
#define FSLIDER  10	/* BOX in tree BITSEL */
#define FNAMES   11	/* BOX in tree BITSEL */
#define FUP      13	/* TEXT in tree BITSEL */
#define FUNDO    14	/* BOXTEXT in tree BITSEL */
#define EDITDEV  15	/* BOXTEXT in tree BITSEL */
#define DEVBOX   16	/* BOX in tree BITSEL */
#define DEVNAMES 17	/* BOX in tree BITSEL */
#define DEVPAREN 19	/* BOX in tree BITSEL */
#define DEVSLID  20	/* BOX in tree BITSEL */
#define DEVDOWN  22	/* TEXT in tree BITSEL */
#define DEVUP    24	/* TEXT in tree BITSEL */
#define SIZE     25	/* TEXT in tree BITSEL */
#define DRVNAME  28	/* BOXTEXT in tree BITSEL */
#define BITRIGHT 29	/* TEXT in tree BITSEL */
#define BITLEFT  30	/* TEXT in tree BITSEL */
#define SWDRUP   31	/* TEXT in tree BITSEL */
#define SWDRDOWN 32	/* TEXT in tree BITSEL */
#define BITCACHE 34	/* BOXTEXT in tree BITSEL */
#define FOK      35	/* BOXTEXT in tree BITSEL */
#define FSWITCH  36	/* BOXTEXT in tree BITSEL */
#define BITPATH  37	/* BOXTEXT in tree BITSEL */

#define INFRF    2	/* form/dialog */

#define INFRBIT  3	/* form/dialog */

#define FSMSEL   4	/* form/dialog */
#define FSMBACK  0	/* BOX in tree FSMSEL */
#define FSMCLOSE 2	/* BOXTEXT in tree FSMSEL */
#define FSMABOUT 3	/* BOXTEXT in tree FSMSEL */
#define FBIGBOX  4	/* BOX in tree FSMSEL */
#define FSMOK    6	/* BOXTEXT in tree FSMSEL */
#define FSMUNDO  7	/* BOXTEXT in tree FSMSEL */
#define FSMBOX   8	/* BOX in tree FSMSEL */
#define FSMDOWN  10	/* TEXT in tree FSMSEL */
#define FSMPAREN 11	/* BOX in tree FSMSEL */
#define FSMSLID  12	/* BOX in tree FSMSEL */
#define FSMNAMES 13	/* BOX in tree FSMSEL */
#define PTS1     14	/* TEXT in tree FSMSEL */
#define PTS2     15	/* TEXT in tree FSMSEL */
#define PTS3     16	/* TEXT in tree FSMSEL */
#define PTS4     17	/* TEXT in tree FSMSEL */
#define PTS5     18	/* TEXT in tree FSMSEL */
#define PTS6     19	/* TEXT in tree FSMSEL */
#define PTS7     20	/* TEXT in tree FSMSEL */
#define PTS8     21	/* TEXT in tree FSMSEL */
#define PTS9     22	/* TEXT in tree FSMSEL */
#define PTS10    23	/* TEXT in tree FSMSEL */
#define PTS11    24	/* TEXT in tree FSMSEL */
#define PTS12    25	/* TEXT in tree FSMSEL */
#define PTS13    26	/* TEXT in tree FSMSEL */
#define PTS14    27	/* TEXT in tree FSMSEL */
#define PTS15    28	/* TEXT in tree FSMSEL */
#define PTS16    29	/* TEXT in tree FSMSEL */
#define FSMUP    31	/* TEXT in tree FSMSEL */
#define FSMSWIT  33	/* BOXTEXT in tree FSMSEL */
#define FSMPATH  34	/* BOXTEXT in tree FSMSEL */
#define FSMCACHE 35	/* BOXTEXT in tree FSMSEL */
#define FSMDEFS  36	/* BOXTEXT in tree FSMSEL */
#define WIDTH    37	/* BOXTEXT in tree FSMSEL */

#define SETPATH  5	/* form/dialog */
#define SETTITLE 1	/* BOXTEXT in tree SETPATH */
#define SETOK    2	/* BUTTON in tree SETPATH */
#define SETCAN   3	/* BUTTON in tree SETPATH */
#define PATH1    4	/* FTEXT in tree SETPATH */
#define PATH2    5	/* FTEXT in tree SETPATH */

#define SETCACHE 6	/* form/dialog */
#define CACHETIT 1	/* BOXTEXT in tree SETCACHE */
#define CACHEOK  2	/* BUTTON in tree SETCACHE */
#define CACHECAN 3	/* BUTTON in tree SETCACHE */
#define CACHESIZ 4	/* FTEXT in tree SETCACHE */
#define CACHETXT 7	/* TEXT in tree SETCACHE */

#define DEVEDIT  7	/* form/dialog */
#define VLEFT    4	/* TEXT in tree DEVEDIT */
#define VRIGHT   5	/* TEXT in tree DEVEDIT */
#define VTXT     6	/* BOXTEXT in tree DEVEDIT */
#define VUP      7	/* TEXT in tree DEVEDIT */
#define VDOWN    8	/* TEXT in tree DEVEDIT */
#define VRES     9	/* BOXTEXT in tree DEVEDIT */
#define VROM     10	/* BOXTEXT in tree DEVEDIT */
#define ALEFT    12	/* TEXT in tree DEVEDIT */
#define ARIGHT   13	/* TEXT in tree DEVEDIT */
#define ATXT     14	/* BOXTEXT in tree DEVEDIT */
#define AUP      15	/* TEXT in tree DEVEDIT */
#define ADOWN    16	/* TEXT in tree DEVEDIT */
#define ARES     17	/* BOXTEXT in tree DEVEDIT */
#define AROM     18	/* BOXTEXT in tree DEVEDIT */
#define DLEFT    22	/* TEXT in tree DEVEDIT */
#define DRIGHT   23	/* TEXT in tree DEVEDIT */
#define DTXT     24	/* BOXTEXT in tree DEVEDIT */
#define DRES     25	/* BOXTEXT in tree DEVEDIT */
#define DROM     26	/* BOXTEXT in tree DEVEDIT */
#define DEDITDN  28	/* BUTTON in tree DEVEDIT */
#define ADDDEV   29	/* BUTTON in tree DEVEDIT */
#define DELDEV   30	/* BUTTON in tree DEVEDIT */

#define FSMPTS   8	/* form/dialog */
#define PTSNAME  3	/* BOXTEXT in tree FSMPTS */
#define PNT1     4	/* FTEXT in tree FSMPTS */
#define PNT2     5	/* FTEXT in tree FSMPTS */
#define PNT3     6	/* FTEXT in tree FSMPTS */
#define PNT4     7	/* FTEXT in tree FSMPTS */
#define PNT5     8	/* FTEXT in tree FSMPTS */
#define PNT6     9	/* FTEXT in tree FSMPTS */
#define PNT7     10	/* FTEXT in tree FSMPTS */
#define PNT8     11	/* FTEXT in tree FSMPTS */
#define PNT9     12	/* FTEXT in tree FSMPTS */
#define PNT10    13	/* FTEXT in tree FSMPTS */
#define PTSOK    14	/* BUTTON in tree FSMPTS */
#define PTSCAN   15	/* BUTTON in tree FSMPTS */

