/* resource file indicies for FSMACC */

#define ABOUTIT  0	/* form/dialog */
#define AEXIT    5	/* BUTTON in tree ABOUTIT */

#define BITSEL   1	/* form/dialog */
#define FBACK    0	/* BOX in tree BITSEL */
#define FOK      1	/* BOXTEXT in tree BITSEL */
#define FUNDO    2	/* BOXTEXT in tree BITSEL */
#define FBOX     3	/* BOX in tree BITSEL */
#define FDOWN    5	/* TEXT in tree BITSEL */
#define FSLPAREN 6	/* BOX in tree BITSEL */
#define FSLIDER  7	/* BOX in tree BITSEL */
#define FNAMES   8	/* BOX in tree BITSEL */
#define FUP      10	/* TEXT in tree BITSEL */
#define FSWITCH  12	/* BOXTEXT in tree BITSEL */
#define EDITDEV  13	/* BOXTEXT in tree BITSEL */
#define DEVBOX   14	/* BOX in tree BITSEL */
#define DEVNAMES 15	/* BOX in tree BITSEL */
#define DEVUP    17	/* TEXT in tree BITSEL */
#define DEVPAREN 18	/* BOX in tree BITSEL */
#define DEVSLID  19	/* BOX in tree BITSEL */
#define DEVDOWN  21	/* TEXT in tree BITSEL */
#define DRVNAME  23	/* BOXTEXT in tree BITSEL */
#define BITRIGHT 24	/* BOXTEXT in tree BITSEL */
#define BITLEFT  25	/* BOXTEXT in tree BITSEL */
#define SWDRUP   26	/* BOXTEXT in tree BITSEL */
#define SWDRDOWN 27	/* BOXTEXT in tree BITSEL */
#define BITCLOSE 30	/* BOXTEXT in tree BITSEL */
#define BITABOUT 31	/* BOXTEXT in tree BITSEL */
#define SIZE     32	/* TEXT in tree BITSEL */
#define BITPATH  33	/* BOXTEXT in tree BITSEL */
#define BITCACHE 34	/* BOXTEXT in tree BITSEL */

#define INFRF    2	/* form/dialog */

#define INFRBIT  3	/* form/dialog */

#define FSMSEL   4	/* form/dialog */
#define FSMBACK  0	/* BOX in tree FSMSEL */
#define FSMOK    1	/* BOXTEXT in tree FSMSEL */
#define FSMUNDO  2	/* BOXTEXT in tree FSMSEL */
#define FSMBOX   3	/* BOX in tree FSMSEL */
#define FSMDOWN  5	/* TEXT in tree FSMSEL */
#define FSMPAREN 6	/* BOX in tree FSMSEL */
#define FSMSLID  7	/* BOX in tree FSMSEL */
#define FSMNAMES 15	/* BOX in tree FSMSEL */
#define FSMUP    17	/* TEXT in tree FSMSEL */
#define FSMSWIT  20	/* BOXTEXT in tree FSMSEL */
#define FSMCLOSE 22	/* BOXTEXT in tree FSMSEL */
#define FSMABOUT 23	/* BOXTEXT in tree FSMSEL */
#define FSMPATH  24	/* BOXTEXT in tree FSMSEL */
#define FSMCACHE 25	/* BOXTEXT in tree FSMSEL */
#define FSMDEFS  26	/* BOXTEXT in tree FSMSEL */

#define SETPATH  5	/* form/dialog */
#define SETTITLE 1	/* BOXTEXT in tree SETPATH */
#define SETOK    2	/* BUTTON in tree SETPATH */
#define SETCAN   3	/* BUTTON in tree SETPATH */
#define PATH1    4	/* FTEXT in tree SETPATH */
#define PATH2    5	/* FTEXT in tree SETPATH */

