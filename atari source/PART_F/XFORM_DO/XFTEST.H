#define DIAL 0  	/* TREE */
#define MENU 1  	/* TREE */
#define QUIT 17  	/* OBJECT in TREE #1 */
#define TEST 16  	/* OBJECT in TREE #1 */
#define EDIT1 2  	/* OBJECT in TREE #0 */
#define EDIT2 3  	/* OBJECT in TREE #0 */
#define EDIT3 4  	/* OBJECT in TREE #0 */
