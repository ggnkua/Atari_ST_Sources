/* defs.h */


#define	NULL	0L
#define	LONG	long
#define	WORD	int
#define UWORD	unsigned int
#define	BYTE	char
#define	REG	register

#define	SECTOR	LONG

#define	OFF		0
#define ON		1

#define	NO		0
#define YES		1

#define	FALSE		0
#define TRUE		1

#define	OK		0
#define	ERROR		(-1)
#define BAILOUT		(-2)

extern long gemdos();

