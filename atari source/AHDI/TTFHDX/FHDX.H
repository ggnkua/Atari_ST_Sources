#define DSKPASS 5  	/* TREE */
#define ABOUT 1  	/* TREE */
#define DSKNAMES 2  	/* TREE */
#define ABOK 3  	/* OBJECT in TREE #1 */
#define PFMT0 2  	/* OBJECT in TREE #2 */
#define PFMT1 5  	/* OBJECT in TREE #2 */
#define PFMT2 6  	/* OBJECT in TREE #2 */
#define PFMT3 7  	/* OBJECT in TREE #2 */
#define PFMT4 8  	/* OBJECT in TREE #2 */
#define PFMT5 9  	/* OBJECT in TREE #2 */
#define PFMT6 10  	/* OBJECT in TREE #2 */
#define PFMT7 11  	/* OBJECT in TREE #2 */
#define PFMT8 12  	/* OBJECT in TREE #2 */
#define PFMT9 13  	/* OBJECT in TREE #2 */
#define PFMT10 14  	/* OBJECT in TREE #2 */
#define PFMT11 15  	/* OBJECT in TREE #2 */
#define PFMT12 16  	/* OBJECT in TREE #2 */
#define PFMT13 17  	/* OBJECT in TREE #2 */
#define PFMT14 18  	/* OBJECT in TREE #2 */
#define PFOK 3  	/* OBJECT in TREE #2 */
#define PFCN 4  	/* OBJECT in TREE #2 */
#define FMTMSG 3  	/* TREE */
#define ASKXAM 10  	/* TREE */
#define XAMXAM 2  	/* OBJECT in TREE #10 */
#define XAMSAVE 3  	/* OBJECT in TREE #10 */
#define NPDEFLST 8  	/* TREE */
#define TSTRMFM 6  	/* OBJECT in TREE #8 */
#define TSTRRLL 7  	/* OBJECT in TREE #8 */
#define NPUTSTRT 3  	/* OBJECT in TREE #8 */
#define NPUTCN 4  	/* OBJECT in TREE #8 */
#define KEEPDEFS 7  	/* TREE */
#define KEEPYES 3  	/* OBJECT in TREE #7 */
#define KEEPNO 4  	/* OBJECT in TREE #7 */
#define NPCMPENT 2  	/* STRING */
#define BGHDNUM 3  	/* STRING */
#define BGCYLNUM 4  	/* STRING */
#define BGBYTNUM 5  	/* STRING */
#define BRNINMSG 4  	/* TREE */
#define PASSBOX 3  	/* OBJECT in TREE #4 */
#define NUMPASS 4  	/* OBJECT in TREE #4 */
#define RWCYL 6  	/* OBJECT in TREE #4 */
#define RWBOX 5  	/* OBJECT in TREE #4 */
#define CYLNUM 9  	/* OBJECT in TREE #4 */
#define CYLBOX 8  	/* OBJECT in TREE #4 */
#define NUMBAD 12  	/* OBJECT in TREE #4 */
#define NBADBOX 11  	/* OBJECT in TREE #4 */
#define NOMEMORY 8  	/* STRING */
#define FATREAD 6  	/* STRING */
#define FATWRITE 7  	/* STRING */
#define ROOTREAD 11  	/* STRING */
#define CYL0BAD 16  	/* STRING */
#define BSLREAD 17  	/* STRING */
#define BSLWRITE 18  	/* STRING */
#define CRUPTBSL 19  	/* STRING */
#define MANYLDEV 20  	/* STRING */
#define PART2BIG 13  	/* TREE */
#define BGPART 2  	/* OBJECT in TREE #13 */
#define CANTFORM 22  	/* STRING */
#define NOPART 14  	/* TREE */
#define NOSCHPR 2  	/* OBJECT in TREE #14 */
#define NOFMT 15  	/* TREE */
#define NOSCHFMT 2  	/* OBJECT in TREE #15 */
#define DEFFULL 23  	/* STRING */
#define AUTOBOOT 24  	/* STRING */
#define MANYBAD 26  	/* STRING */
#define DSKWRITE 14  	/* STRING */
#define CRUPTFMT 27  	/* STRING */
#define NPUTFORM 9  	/* TREE */
#define NPHDNUM 9  	/* OBJECT in TREE #9 */
#define NPCYLNUM 10  	/* OBJECT in TREE #9 */
#define NPBYTOFF 11  	/* OBJECT in TREE #9 */
#define NPUTDONE 5  	/* OBJECT in TREE #9 */
#define NPUTNXT 6  	/* OBJECT in TREE #9 */
#define EDTFORM 12  	/* TREE */
#define EDHDNUM 10  	/* OBJECT in TREE #12 */
#define EDCYLNUM 11  	/* OBJECT in TREE #12 */
#define EDBYTOFF 12  	/* OBJECT in TREE #12 */
#define EDTCN 5  	/* OBJECT in TREE #12 */
#define EDTDEL 8  	/* OBJECT in TREE #12 */
#define EDTOK 6  	/* OBJECT in TREE #12 */
#define XAMFORM 11  	/* TREE */
#define FUPAROW 12  	/* OBJECT in TREE #11 */
#define FDNAROW 15  	/* OBJECT in TREE #11 */
#define FCLSBOX 1  	/* OBJECT in TREE #11 */
#define FSVELEV 14  	/* OBJECT in TREE #11 */
#define FSVSLID 13  	/* OBJECT in TREE #11 */
#define DEFEMP 25  	/* STRING */
#define NPUTBOX 8  	/* OBJECT in TREE #9 */
#define EDTBOX 9  	/* OBJECT in TREE #12 */
#define BRNPASS 1  	/* OBJECT in TREE #5 */
#define DSKFAIL 6  	/* TREE */
#define BRNFAIL 1  	/* OBJECT in TREE #6 */
#define SCOMMAND 1  	/* STRING */
#define ENTRY0 3  	/* OBJECT in TREE #11 */
#define XAMQUIT 4  	/* OBJECT in TREE #10 */
#define ROOTBAD 13  	/* STRING */
#define BGPARTOK 5  	/* OBJECT in TREE #13 */
#define CYLIS0 15  	/* STRING */
#define NOTFMTD 0  	/* STRING */
#define BOOTREAD 9  	/* STRING */
#define NOSCHPOK 3  	/* OBJECT in TREE #14 */
#define NOSCHFOK 3  	/* OBJECT in TREE #15 */
#define DCHPASS 16  	/* TREE */
#define DCHWFAIL 17  	/* TREE */
#define DCHPOK 1  	/* OBJECT in TREE #16 */
#define DCHRFAIL 18  	/* TREE */
#define DCHDFAIL 19  	/* TREE */
#define DCHWERR 1  	/* OBJECT in TREE #17 */
#define DCHRERR 1  	/* OBJECT in TREE #18 */
#define DCHDERR 1  	/* OBJECT in TREE #19 */
#define BSLFORM 20  	/* TREE */
#define BENTRY0 3  	/* OBJECT in TREE #20 */
#define BVELEV 14  	/* OBJECT in TREE #20 */
#define BUPAROW 12  	/* OBJECT in TREE #20 */
#define BDNAROW 15  	/* OBJECT in TREE #20 */
#define BCLSBOX 1  	/* OBJECT in TREE #20 */
#define BVSLID 13  	/* OBJECT in TREE #20 */
#define PARTMSG 21  	/* TREE */
#define NODCENT 28  	/* STRING */
#define ERROK 2  	/* OBJECT in TREE #22 */
#define NOWINCAP 29  	/* STRING */
#define BOOTWRIT 10  	/* STRING */
#define ROOTWRIT 12  	/* STRING */
#define BRNPTITL 2  	/* OBJECT in TREE #5 */
#define BRNFTITL 2  	/* OBJECT in TREE #6 */
#define MENUBAR 0  	/* TREE */
#define CTRLPASS 23  	/* TREE */
#define CTRPTITL 2  	/* OBJECT in TREE #23 */
#define CTRLPOK 1  	/* OBJECT in TREE #23 */
#define DCHPTITL 2  	/* OBJECT in TREE #16 */
#define DCHWTITL 2  	/* OBJECT in TREE #17 */
#define DCHRTITL 2  	/* OBJECT in TREE #18 */
#define DCHDTITL 2  	/* OBJECT in TREE #19 */
#define CTRLFAIL 24  	/* TREE */
#define PHYSOK 5  	/* OBJECT in TREE #25 */
#define PHYSCN 13  	/* OBJECT in TREE #25 */
#define CTRFTITL 2  	/* OBJECT in TREE #24 */
#define ENTRY1 4  	/* OBJECT in TREE #11 */
#define ENTRY2 5  	/* OBJECT in TREE #11 */
#define ENTRY3 6  	/* OBJECT in TREE #11 */
#define ENTRY4 7  	/* OBJECT in TREE #11 */
#define ENTRY5 8  	/* OBJECT in TREE #11 */
#define ENTRY6 9  	/* OBJECT in TREE #11 */
#define ENTRY7 10  	/* OBJECT in TREE #11 */
#define MIDREZ 30  	/* STRING */
#define CURRMDL 2  	/* OBJECT in TREE #26 */
#define SCSIUNIT 2  	/* OBJECT in TREE #25 */
#define BENTRY1 4  	/* OBJECT in TREE #20 */
#define BENTRY2 5  	/* OBJECT in TREE #20 */
#define BENTRY3 6  	/* OBJECT in TREE #20 */
#define BENTRY4 7  	/* OBJECT in TREE #20 */
#define BENTRY5 8  	/* OBJECT in TREE #20 */
#define BENTRY6 9  	/* OBJECT in TREE #20 */
#define BENTRY7 10  	/* OBJECT in TREE #20 */
#define UNIT0 7  	/* OBJECT in TREE #25 */
#define CTRLFOK 1  	/* OBJECT in TREE #24 */
#define CURRTYPE 3  	/* OBJECT in TREE #26 */
#define MNDESK 3  	/* OBJECT in TREE #0 */
#define ABOUFHDX 8  	/* OBJECT in TREE #0 */
#define MNFILE 4  	/* OBJECT in TREE #0 */
#define FIQUIT 17  	/* OBJECT in TREE #0 */
#define MNDISK 5  	/* OBJECT in TREE #0 */
#define SELUNIT 19  	/* OBJECT in TREE #0 */
#define SELDSK 20  	/* OBJECT in TREE #0 */
#define CTRLRTST 22  	/* OBJECT in TREE #0 */
#define DCHTST 23  	/* OBJECT in TREE #0 */
#define FMTDSK 24  	/* OBJECT in TREE #0 */
#define BRNINTST 26  	/* OBJECT in TREE #0 */
#define SHIPIT 28  	/* OBJECT in TREE #0 */
#define VERNUM 4  	/* OBJECT in TREE #1 */
#define UNIT16 11  	/* OBJECT in TREE #25 */
#define UNIT8 10  	/* OBJECT in TREE #25 */
#define ERRNUM 22  	/* TREE */
#define ERRNO 4  	/* OBJECT in TREE #22 */
#define UNIT1 8  	/* OBJECT in TREE #25 */
#define CANTPART 21  	/* STRING */
#define UNITTYPE 26  	/* TREE */
#define PHYSDIAL 25  	/* TREE */
#define CTLRFOK 212  	/* OBJECT in TREE #251 */
#define CURRUNIT 1  	/* OBJECT in TREE #26 */
#define ACSIUNIT 1  	/* OBJECT in TREE #25 */
#define ACSIUNIT 1  	/* OBJECT in TREE #25 */
#define ACSIUNIT 1  	/* OBJECT in TREE #25 */
#define DEFLST 25  	/* OBJECT in TREE #0 */
#define IDEUNIT 3  	/* OBJECT in TREE #25 */
#define UNIT17 12  	/* OBJECT in TREE #25 */
#define UNIT9 9  	/* OBJECT in TREE #25 */
