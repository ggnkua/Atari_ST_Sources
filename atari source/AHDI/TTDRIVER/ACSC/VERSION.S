.macro VERSION
dc.b "Mar 17 16:36:00 PST 1989"
.endm
