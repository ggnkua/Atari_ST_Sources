/*
 * Define.h
 */
 
 
#define	REG	register
#define	BYTE	char
#define	WORD	int
#define	UWORD	unsigned int
#define	LONG	long

#define	NULL	0L

#define	OFF	0
#define ON	1

#define	NO	0
#define YES	1

#define	FALSE	0
#define TRUE	1

#define	OK	0
#define	ERROR	(-1)

