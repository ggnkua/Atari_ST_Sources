#define MENUBAR 0  	/* TREE */
#define ABOUT 1  	/* TREE */
#define PHYSDEV 27  	/* TREE */
#define LOGDEV 26  	/* TREE */
#define PICKPART 9  	/* TREE */
#define ZWARNING 19  	/* TREE */
#define DSKNAMES 3  	/* TREE */
#define FWARNING 2  	/* TREE */
#define PWARNING 7  	/* TREE */
#define PARTPNL 8  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #0 */
#define MNFILE 4  	/* OBJECT in TREE #0 */
#define MNDISK 5  	/* OBJECT in TREE #0 */
#define DEABOUT 8  	/* OBJECT in TREE #0 */
#define FIQUIT 17  	/* OBJECT in TREE #0 */
#define DIFORM 19  	/* OBJECT in TREE #0 */
#define DIPART 20  	/* OBJECT in TREE #0 */
#define DIZERO 21  	/* OBJECT in TREE #0 */
#define DIMARK 22  	/* OBJECT in TREE #0 */
#define ABOK 3  	/* OBJECT in TREE #1 */
#define UNIT0 1  	/* OBJECT in TREE #27 */
#define UNIT1 2  	/* OBJECT in TREE #27 */
#define UNIT2 3  	/* OBJECT in TREE #27 */
#define UNIT3 4  	/* OBJECT in TREE #27 */
#define UNIT4 5  	/* OBJECT in TREE #27 */
#define UNIT5 6  	/* OBJECT in TREE #27 */
#define UNIT6 7  	/* OBJECT in TREE #27 */
#define UNIT7 8  	/* OBJECT in TREE #27 */
#define PHYSOK 9  	/* OBJECT in TREE #27 */
#define PHYSCN 10  	/* OBJECT in TREE #27 */
#define CCOLON 1  	/* OBJECT in TREE #26 */
#define DCOLON 2  	/* OBJECT in TREE #26 */
#define ECOLON 4  	/* OBJECT in TREE #26 */
#define FCOLON 5  	/* OBJECT in TREE #26 */
#define GCOLON 6  	/* OBJECT in TREE #26 */
#define HCOLON 7  	/* OBJECT in TREE #26 */
#define ICOLON 8  	/* OBJECT in TREE #26 */
#define JCOLON 9  	/* OBJECT in TREE #26 */
#define KCOLON 10  	/* OBJECT in TREE #26 */
#define LCOLON 11  	/* OBJECT in TREE #26 */
#define MCOLON 12  	/* OBJECT in TREE #26 */
#define NCOLON 13  	/* OBJECT in TREE #26 */
#define OCOLON 14  	/* OBJECT in TREE #26 */
#define PCOLON 15  	/* OBJECT in TREE #26 */
#define LOGOK 16  	/* OBJECT in TREE #26 */
#define LOGCN 17  	/* OBJECT in TREE #26 */
#define PPART0 2  	/* OBJECT in TREE #9 */
#define PPART1 5  	/* OBJECT in TREE #9 */
#define PPART2 6  	/* OBJECT in TREE #9 */
#define PPART3 7  	/* OBJECT in TREE #9 */
#define PPART4 8  	/* OBJECT in TREE #9 */
#define PPART5 9  	/* OBJECT in TREE #9 */
#define PPART6 10  	/* OBJECT in TREE #9 */
#define PPART7 11  	/* OBJECT in TREE #9 */
#define PPART8 12  	/* OBJECT in TREE #9 */
#define PPART9 13  	/* OBJECT in TREE #9 */
#define PPART10 14  	/* OBJECT in TREE #9 */
#define PPART11 15  	/* OBJECT in TREE #9 */
#define PPART12 16  	/* OBJECT in TREE #9 */
#define PPART13 17  	/* OBJECT in TREE #9 */
#define PPART14 18  	/* OBJECT in TREE #9 */
#define PPOK 3  	/* OBJECT in TREE #9 */
#define PPCN 4  	/* OBJECT in TREE #9 */
#define PPEDIT 19  	/* OBJECT in TREE #9 */
#define ZWOK 4  	/* OBJECT in TREE #19 */
#define ZWCN 1  	/* OBJECT in TREE #19 */
#define PFMT0 2  	/* OBJECT in TREE #3 */
#define PFMT1 5  	/* OBJECT in TREE #3 */
#define PFMT2 6  	/* OBJECT in TREE #3 */
#define PFMT3 7  	/* OBJECT in TREE #3 */
#define PFMT4 8  	/* OBJECT in TREE #3 */
#define PFMT5 9  	/* OBJECT in TREE #3 */
#define PFMT6 10  	/* OBJECT in TREE #3 */
#define PFMT7 11  	/* OBJECT in TREE #3 */
#define PFMT8 12  	/* OBJECT in TREE #3 */
#define PFMT9 13  	/* OBJECT in TREE #3 */
#define PFMT10 14  	/* OBJECT in TREE #3 */
#define PFMT11 15  	/* OBJECT in TREE #3 */
#define PFMT12 16  	/* OBJECT in TREE #3 */
#define PFMT13 17  	/* OBJECT in TREE #3 */
#define PFMT14 18  	/* OBJECT in TREE #3 */
#define PFOK 3  	/* OBJECT in TREE #3 */
#define PFCN 4  	/* OBJECT in TREE #3 */
#define FWARNOK 4  	/* OBJECT in TREE #2 */
#define FWARNCN 1  	/* OBJECT in TREE #2 */
#define PWARNOK 4  	/* OBJECT in TREE #7 */
#define PWARNCN 1  	/* OBJECT in TREE #7 */
#define EPRESET 15  	/* OBJECT in TREE #8 */
#define EPMENU 14  	/* OBJECT in TREE #8 */
#define EPCN 11  	/* OBJECT in TREE #8 */
#define EPOK 10  	/* OBJECT in TREE #8 */
#define EP0SIZ 1  	/* OBJECT in TREE #8 */
#define EP1SIZ 12  	/* OBJECT in TREE #8 */
#define EP2SIZ 13  	/* OBJECT in TREE #8 */
#define EP3SIZ 16  	/* OBJECT in TREE #8 */
#define EP0DN 2  	/* OBJECT in TREE #8 */
#define EP1DN 4  	/* OBJECT in TREE #8 */
#define EP2DN 5  	/* OBJECT in TREE #8 */
#define EP3DN 6  	/* OBJECT in TREE #8 */
#define EP0UP 3  	/* OBJECT in TREE #8 */
#define EP1UP 7  	/* OBJECT in TREE #8 */
#define EP2UP 8  	/* OBJECT in TREE #8 */
#define EP3UP 9  	/* OBJECT in TREE #8 */
#define DMRKMSG 6  	/* TREE */
#define FMTMSG 5  	/* TREE */
#define PARTMSG 11  	/* TREE */
#define LMRKDONE 18  	/* TREE */
#define ZEROMSG 21  	/* TREE */
#define LMRKMSG 13  	/* TREE */
#define FMTFNL 4  	/* TREE */
#define FMTYES 5  	/* OBJECT in TREE #4 */
#define FMTNO 6  	/* OBJECT in TREE #4 */
#define PARTFNL 10  	/* TREE */
#define ZEROFNL 20  	/* TREE */
#define ZYES 6  	/* OBJECT in TREE #20 */
#define ZNO 7  	/* OBJECT in TREE #20 */
#define PARTYES 5  	/* OBJECT in TREE #10 */
#define PARTNO 6  	/* OBJECT in TREE #10 */
#define LMDONE 2  	/* OBJECT in TREE #18 */
#define LMRKFILE 15  	/* TREE */
#define SHIPDEV 23  	/* TREE */
#define SDEVOK 9  	/* OBJECT in TREE #23 */
#define SDEVCN 10  	/* OBJECT in TREE #23 */
#define SDEV0 1  	/* OBJECT in TREE #23 */
#define SDEV1 2  	/* OBJECT in TREE #23 */
#define SDEV2 3  	/* OBJECT in TREE #23 */
#define SDEV3 4  	/* OBJECT in TREE #23 */
#define SDEV4 5  	/* OBJECT in TREE #23 */
#define SDEV5 6  	/* OBJECT in TREE #23 */
#define SDEV6 7  	/* OBJECT in TREE #23 */
#define SDEV7 8  	/* OBJECT in TREE #23 */
#define SCOMMAND 25  	/* TREE */
#define TRNOFFOK 4  	/* OBJECT in TREE #25 */
#define SHIPFNL 24  	/* TREE */
#define SFNLOK 4  	/* OBJECT in TREE #24 */
#define SFNLCN 5  	/* OBJECT in TREE #24 */
#define DISHIP 24  	/* OBJECT in TREE #0 */
#define NOMEMORY 2  	/* STRING */
#define FATREAD 5  	/* STRING */
#define ROOTREAD 8  	/* STRING */
#define ROOTWRIT 9  	/* STRING */
#define RSRVBAD 14  	/* STRING */
#define BSLREAD 15  	/* STRING */
#define BSLWRITE 16  	/* STRING */
#define CRUPTBSL 19  	/* STRING */
#define MANYLDEV 20  	/* STRING */
#define PART2BIG 28  	/* TREE */
#define NOFMT 32  	/* TREE */
#define AUTOBOOT 21  	/* STRING */
#define MANYBAD 22  	/* STRING */
#define NEXSMEM 23  	/* STRING */
#define NOMENU 24  	/* STRING */
#define OLDFMT 25  	/* STRING */
#define MDACH 26  	/* STRING */
#define CRUPTFMT 27  	/* STRING */
#define BGPARTOK 3  	/* OBJECT in TREE #28 */
#define FATWRITE 6  	/* STRING */
#define MWARNING 12  	/* TREE */
#define BADFILE 3  	/* OBJECT in TREE #15 */
#define DELFILE 4  	/* OBJECT in TREE #15 */
#define SKIPOVER 5  	/* OBJECT in TREE #15 */
#define IGNORBAD 6  	/* OBJECT in TREE #15 */
#define MWARNOK 4  	/* OBJECT in TREE #12 */
#define MWARNCN 1  	/* OBJECT in TREE #12 */
#define DIRREAD 13  	/* STRING */
#define DIRWRITE 12  	/* STRING */
#define BADFAT 7  	/* STRING */
#define CANTDEL 28  	/* STRING */
#define KNDOFILE 2  	/* OBJECT in TREE #15 */
#define BOOTREAD 10  	/* STRING */
#define BOOTWRIT 11  	/* STRING */
#define LMRKSUB 16  	/* TREE */
#define BADSUB 3  	/* OBJECT in TREE #16 */
#define SUBDELSV 4  	/* OBJECT in TREE #16 */
#define SUBIGNOR 5  	/* OBJECT in TREE #16 */
#define SVFILES 0  	/* STRING */
#define MARKORPH 14  	/* TREE */
#define ORPHYES 4  	/* OBJECT in TREE #14 */
#define ORPHNO 5  	/* OBJECT in TREE #14 */
#define SUBDELNS 6  	/* OBJECT in TREE #16 */
#define NSFILES 1  	/* STRING */
#define NOWINCAP 3  	/* STRING */
#define NOPART 31  	/* TREE */
#define HDRWRITE 4  	/* STRING */
#define SWARNING 22  	/* TREE */
#define SWARNOK 7  	/* OBJECT in TREE #22 */
#define SWARNCN 8  	/* OBJECT in TREE #22 */
#define CANTFORM 29  	/* TREE */
#define FMTERROK 1  	/* OBJECT in TREE #29 */
#define CANTPART 30  	/* TREE */
#define PTNERROK 1  	/* OBJECT in TREE #30 */
#define WRONPARM 33  	/* TREE */
#define NODRSLOT 17  	/* TREE */
#define NODRYES 7  	/* OBJECT in TREE #17 */
#define NODRNO 8  	/* OBJECT in TREE #17 */
#define WRONOK 7  	/* OBJECT in TREE #33 */
#define NOSCHPOK 2  	/* OBJECT in TREE #31 */
#define NOSCHFOK 2  	/* OBJECT in TREE #32 */
#define SDIRREAD 17  	/* STRING */
#define SDIRWRIT 18  	/* STRING */
#define FUNIT 7  	/* OBJECT in TREE #4 */
#define PUNIT 7  	/* OBJECT in TREE #10 */
#define OLDBAD 5  	/* OBJECT in TREE #6 */
#define NEWBAD 6  	/* OBJECT in TREE #6 */
#define EPLEFT 18  	/* OBJECT in TREE #8 */
#define ORPHSEC 6  	/* OBJECT in TREE #14 */
#define ORPHCLU 7  	/* OBJECT in TREE #14 */
#define BADSEC 7  	/* OBJECT in TREE #15 */
#define BADCLU 8  	/* OBJECT in TREE #15 */
#define SUBSEC 7  	/* OBJECT in TREE #16 */
#define SUBCLU 8  	/* OBJECT in TREE #16 */
#define BADFOUND 7  	/* OBJECT in TREE #18 */
#define BADMARKD 8  	/* OBJECT in TREE #18 */
#define ZDRV 8  	/* OBJECT in TREE #20 */
#define BGPART 5  	/* OBJECT in TREE #28 */
#define FMTDEV 6  	/* OBJECT in TREE #29 */
#define PTNDEV 4  	/* OBJECT in TREE #30 */
#define NOSCHPR 4  	/* OBJECT in TREE #31 */
#define NOSCHFMT 5  	/* OBJECT in TREE #32 */
#define ABVERSN 4  	/* OBJECT in TREE #1 */
#define MDMCHNG 30  	/* STRING */
#define WRPROTCT 29  	/* STRING */
#define DMRKBOX 7  	/* OBJECT in TREE #6 */
#define DMRKBAR 8  	/* OBJECT in TREE #6 */
