#define NOMEMORY 0  	/* STRING */
#define ROOTREAD 1  	/* STRING */
#define ROOTWRIT 2  	/* STRING */
#define MANYLDEV 5  	/* STRING */
#define MENUBAR 0  	/* TREE */
#define ABOUT 1  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #0 */
#define MNFILE 4  	/* OBJECT in TREE #0 */
#define DEABOUT 7  	/* OBJECT in TREE #0 */
#define FIQUIT 16  	/* OBJECT in TREE #0 */
#define ABOK 3  	/* OBJECT in TREE #1 */
#define FIINST 17  	/* OBJECT in TREE #0 */
#define PHYSDEV 2  	/* TREE */
#define UNIT0 1  	/* OBJECT in TREE #2 */
#define UNIT1 2  	/* OBJECT in TREE #2 */
#define UNIT2 3  	/* OBJECT in TREE #2 */
#define UNIT3 4  	/* OBJECT in TREE #2 */
#define UNIT4 5  	/* OBJECT in TREE #2 */
#define UNIT5 6  	/* OBJECT in TREE #2 */
#define UNIT6 7  	/* OBJECT in TREE #2 */
#define UNIT7 8  	/* OBJECT in TREE #2 */
#define PHYSOK 9  	/* OBJECT in TREE #2 */
#define PHYSCN 10  	/* OBJECT in TREE #2 */
#define INSTFNL 3  	/* TREE */
#define INSTOK 2  	/* OBJECT in TREE #3 */
#define INSTCN 3  	/* OBJECT in TREE #3 */
#define FIUNINST 19  	/* OBJECT in TREE #0 */
#define UNSTFNL 4  	/* TREE */
#define UNSTOK 2  	/* OBJECT in TREE #4 */
#define UNSTCN 3  	/* OBJECT in TREE #4 */
#define BOOTREAD 3  	/* STRING */
#define BOOTWRIT 4  	/* STRING */
#define WRDVRERR 6  	/* STRING */
#define CRDVRERR 7  	/* STRING */
#define OPDVRERR 8  	/* STRING */
#define NODRIVER 9  	/* STRING */
#define INSTUNIT 4  	/* OBJECT in TREE #3 */
#define UNSTUNIT 4  	/* OBJECT in TREE #4 */
#define ABVERSN 5  	/* OBJECT in TREE #1 */
