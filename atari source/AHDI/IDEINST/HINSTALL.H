#define NOMEMORY 0  	/* STRING */
#define ROOTREAD 3  	/* STRING */
#define ROOTWRIT 4  	/* STRING */
#define MENUBAR 0  	/* TREE */
#define ABOUT 1  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #0 */
#define MNFILE 4  	/* OBJECT in TREE #0 */
#define DEABOUT 7  	/* OBJECT in TREE #0 */
#define FIQUIT 16  	/* OBJECT in TREE #0 */
#define ABOK 3  	/* OBJECT in TREE #1 */
#define FIINST 17  	/* OBJECT in TREE #0 */
#define INSTFNL 2  	/* TREE */
#define INSTOK 2  	/* OBJECT in TREE #2 */
#define INSTCN 3  	/* OBJECT in TREE #2 */
#define FIUNINST 19  	/* OBJECT in TREE #0 */
#define UNSTFNL 3  	/* TREE */
#define UNSTOK 2  	/* OBJECT in TREE #3 */
#define UNSTCN 3  	/* OBJECT in TREE #3 */
#define BOOTREAD 5  	/* STRING */
#define BOOTWRIT 6  	/* STRING */
#define WRDVRERR 7  	/* STRING */
#define CRDVRERR 8  	/* STRING */
#define OPDVRERR 9  	/* STRING */
#define NODRIVER 10  	/* STRING */
#define INSTDRV 4  	/* OBJECT in TREE #2 */
#define UNSTDRV 4  	/* OBJECT in TREE #3 */
#define ABVERSN 5  	/* OBJECT in TREE #1 */
#define LOGDEV 4  	/* TREE */
#define CCOLON 1  	/* OBJECT in TREE #4 */
#define DCOLON 2  	/* OBJECT in TREE #4 */
#define ECOLON 4  	/* OBJECT in TREE #4 */
#define FCOLON 5  	/* OBJECT in TREE #4 */
#define GCOLON 6  	/* OBJECT in TREE #4 */
#define HCOLON 7  	/* OBJECT in TREE #4 */
#define ICOLON 8  	/* OBJECT in TREE #4 */
#define JCOLON 9  	/* OBJECT in TREE #4 */
#define KCOLON 10  	/* OBJECT in TREE #4 */
#define LCOLON 11  	/* OBJECT in TREE #4 */
#define MCOLON 12  	/* OBJECT in TREE #4 */
#define NCOLON 13  	/* OBJECT in TREE #4 */
#define OCOLON 14  	/* OBJECT in TREE #4 */
#define PCOLON 15  	/* OBJECT in TREE #4 */
#define LOGOK 16  	/* OBJECT in TREE #4 */
#define LOGCN 17  	/* OBJECT in TREE #4 */
#define CANTINST 2  	/* STRING */
#define NOAVDRV 1  	/* STRING */
