#define NEEDBOOT 2  	/* STRING */
#define SCRPNL 0  	/* TREE */
#define SEPCN 30  	/* OBJECT in TREE #0 */
#define SEPOK 29  	/* OBJECT in TREE #0 */
#define SEP0DN 12  	/* OBJECT in TREE #0 */
#define SEP0UP 13  	/* OBJECT in TREE #0 */
#define SEP0SIZ 8  	/* OBJECT in TREE #0 */
#define SEP1SIZ 9  	/* OBJECT in TREE #0 */
#define SEP1DN 14  	/* OBJECT in TREE #0 */
#define SEP1UP 15  	/* OBJECT in TREE #0 */
#define SEP2DN 16  	/* OBJECT in TREE #0 */
#define SEP2SIZ 10  	/* OBJECT in TREE #0 */
#define SEP2UP 17  	/* OBJECT in TREE #0 */
#define SEP3SIZ 11  	/* OBJECT in TREE #0 */
#define SEP3DN 18  	/* OBJECT in TREE #0 */
#define SEP3UP 19  	/* OBJECT in TREE #0 */
#define SCRUP 23  	/* OBJECT in TREE #0 */
#define SCRDN 26  	/* OBJECT in TREE #0 */
#define SCRBAR 24  	/* OBJECT in TREE #0 */
#define SPMENU 27  	/* OBJECT in TREE #0 */
#define SCREPT 25  	/* OBJECT in TREE #0 */
#define STOLPART 1  	/* OBJECT in TREE #0 */
#define SEPLEFT 2  	/* OBJECT in TREE #0 */
#define SPARTNM0 4  	/* OBJECT in TREE #0 */
#define SPARTNM1 5  	/* OBJECT in TREE #0 */
#define SPARTNM2 6  	/* OBJECT in TREE #0 */
#define SPARTNM3 7  	/* OBJECT in TREE #0 */
#define SUNDO 28  	/* OBJECT in TREE #0 */
#define EXPPNL 1  	/* TREE */
#define PART1 8  	/* OBJECT in TREE #1 */
#define PART1MB 1  	/* OBJECT in TREE #1 */
#define PART2MB 2  	/* OBJECT in TREE #1 */
#define PART3MB 3  	/* OBJECT in TREE #1 */
#define PART4MB 5  	/* OBJECT in TREE #1 */
#define PARTXMB 4  	/* OBJECT in TREE #1 */
#define PARTYMB 6  	/* OBJECT in TREE #1 */
#define PARTZMB 7  	/* OBJECT in TREE #1 */
#define SELECT1 9  	/* OBJECT in TREE #1 */
#define SELECT2 11  	/* OBJECT in TREE #1 */
#define SELECT3 12  	/* OBJECT in TREE #1 */
#define SELECT4 13  	/* OBJECT in TREE #1 */
#define SELECT5 14  	/* OBJECT in TREE #1 */
#define SELECT6 15  	/* OBJECT in TREE #1 */
#define TOEDIT 26  	/* OBJECT in TREE #1 */
#define NOSEL 25  	/* OBJECT in TREE #1 */
#define SELOK 24  	/* OBJECT in TREE #1 */
#define EXPERT 31  	/* OBJECT in TREE #0 */
#define PART2 16  	/* OBJECT in TREE #1 */
#define PART3 17  	/* OBJECT in TREE #1 */
#define PART4 18  	/* OBJECT in TREE #1 */
#define PARTX 19  	/* OBJECT in TREE #1 */
#define PARTY 20  	/* OBJECT in TREE #1 */
#define PARTZ 21  	/* OBJECT in TREE #1 */
#define MAXLOGMS 3  	/* STRING */
#define ABOUT 2  	/* TREE */
#define LOGDEV 26  	/* TREE */
#define PICKPART 9  	/* TREE */
#define ZWARNING 19  	/* TREE */
#define DSKNAMES 4  	/* TREE */
#define FWARNING 3  	/* TREE */
#define PWARNING 8  	/* TREE */
#define ABOK 3  	/* OBJECT in TREE #2 */
#define CCOLON 1  	/* OBJECT in TREE #26 */
#define DCOLON 2  	/* OBJECT in TREE #26 */
#define ECOLON 4  	/* OBJECT in TREE #26 */
#define FCOLON 5  	/* OBJECT in TREE #26 */
#define GCOLON 6  	/* OBJECT in TREE #26 */
#define HCOLON 7  	/* OBJECT in TREE #26 */
#define ICOLON 8  	/* OBJECT in TREE #26 */
#define JCOLON 9  	/* OBJECT in TREE #26 */
#define KCOLON 10  	/* OBJECT in TREE #26 */
#define LCOLON 11  	/* OBJECT in TREE #26 */
#define MCOLON 12  	/* OBJECT in TREE #26 */
#define NCOLON 13  	/* OBJECT in TREE #26 */
#define OCOLON 14  	/* OBJECT in TREE #26 */
#define PCOLON 15  	/* OBJECT in TREE #26 */
#define LOGOK 16  	/* OBJECT in TREE #26 */
#define LOGCN 17  	/* OBJECT in TREE #26 */
#define PPART0 2  	/* OBJECT in TREE #9 */
#define PPOK 3  	/* OBJECT in TREE #9 */
#define PPCN 4  	/* OBJECT in TREE #9 */
#define PPEDIT 5  	/* OBJECT in TREE #9 */
#define ZWOK 4  	/* OBJECT in TREE #19 */
#define ZWCN 1  	/* OBJECT in TREE #19 */
#define PFMT0 2  	/* OBJECT in TREE #4 */
#define PFMT1 5  	/* OBJECT in TREE #4 */
#define PFMT2 6  	/* OBJECT in TREE #4 */
#define PFMT3 7  	/* OBJECT in TREE #4 */
#define PFMT4 8  	/* OBJECT in TREE #4 */
#define PFMT5 9  	/* OBJECT in TREE #4 */
#define PFMT6 10  	/* OBJECT in TREE #4 */
#define PFMT7 11  	/* OBJECT in TREE #4 */
#define PFMT8 12  	/* OBJECT in TREE #4 */
#define PFMT9 13  	/* OBJECT in TREE #4 */
#define PFMT10 14  	/* OBJECT in TREE #4 */
#define PFMT11 15  	/* OBJECT in TREE #4 */
#define PFMT12 16  	/* OBJECT in TREE #4 */
#define PFMT13 17  	/* OBJECT in TREE #4 */
#define PFMT14 18  	/* OBJECT in TREE #4 */
#define PFOK 3  	/* OBJECT in TREE #4 */
#define PFCN 4  	/* OBJECT in TREE #4 */
#define FWARNOK 4  	/* OBJECT in TREE #3 */
#define FWARNCN 1  	/* OBJECT in TREE #3 */
#define PWARNOK 4  	/* OBJECT in TREE #8 */
#define PWARNCN 1  	/* OBJECT in TREE #8 */
#define DMRKMSG 7  	/* TREE */
#define FMTMSG 6  	/* TREE */
#define PARTMSG 11  	/* TREE */
#define LMRKDONE 18  	/* TREE */
#define ZEROMSG 21  	/* TREE */
#define LMRKMSG 13  	/* TREE */
#define FMTFNL 5  	/* TREE */
#define FMTYES 5  	/* OBJECT in TREE #5 */
#define FMTNO 6  	/* OBJECT in TREE #5 */
#define PARTFNL 10  	/* TREE */
#define ZEROFNL 20  	/* TREE */
#define ZYES 6  	/* OBJECT in TREE #20 */
#define ZNO 7  	/* OBJECT in TREE #20 */
#define PARTYES 5  	/* OBJECT in TREE #10 */
#define PARTNO 6  	/* OBJECT in TREE #10 */
#define LMDONE 2  	/* OBJECT in TREE #18 */
#define LMRKFILE 15  	/* TREE */
#define SHIPDEV 23  	/* TREE */
#define SDEVOK 9  	/* OBJECT in TREE #23 */
#define SDEVCN 10  	/* OBJECT in TREE #23 */
#define SDEV0 1  	/* OBJECT in TREE #23 */
#define SDEV1 2  	/* OBJECT in TREE #23 */
#define SDEV2 3  	/* OBJECT in TREE #23 */
#define SDEV3 4  	/* OBJECT in TREE #23 */
#define SDEV4 5  	/* OBJECT in TREE #23 */
#define SDEV5 6  	/* OBJECT in TREE #23 */
#define SDEV6 7  	/* OBJECT in TREE #23 */
#define SDEV7 8  	/* OBJECT in TREE #23 */
#define SCOMMAND 25  	/* TREE */
#define TRNOFFOK 4  	/* OBJECT in TREE #25 */
#define SHIPFNL 24  	/* TREE */
#define SFNLOK 4  	/* OBJECT in TREE #24 */
#define SFNLCN 5  	/* OBJECT in TREE #24 */
#define NOMEMORY 7  	/* STRING */
#define FATREAD 10  	/* STRING */
#define ROOTREAD 14  	/* STRING */
#define ROOTWRIT 15  	/* STRING */
#define RSRVBAD 20  	/* STRING */
#define BSLREAD 21  	/* STRING */
#define BSLWRITE 22  	/* STRING */
#define CRUPTBSL 25  	/* STRING */
#define MANYLDEV 26  	/* STRING */
#define PART2BIG 27  	/* TREE */
#define NOFMT 31  	/* TREE */
#define AUTOBOOT 27  	/* STRING */
#define MANYBAD 30  	/* STRING */
#define NEXSMEM 31  	/* STRING */
#define NOMENU 32  	/* STRING */
#define OLDFMT 33  	/* STRING */
#define MDACH 34  	/* STRING */
#define CRUPTFMT 35  	/* STRING */
#define BGPARTOK 3  	/* OBJECT in TREE #27 */
#define FATWRITE 12  	/* STRING */
#define MWARNING 12  	/* TREE */
#define BADFILE 3  	/* OBJECT in TREE #15 */
#define DELFILE 4  	/* OBJECT in TREE #15 */
#define SKIPOVER 5  	/* OBJECT in TREE #15 */
#define IGNORBAD 6  	/* OBJECT in TREE #15 */
#define MWARNOK 4  	/* OBJECT in TREE #12 */
#define MWARNCN 1  	/* OBJECT in TREE #12 */
#define DIRREAD 19  	/* STRING */
#define DIRWRITE 18  	/* STRING */
#define BADFAT 13  	/* STRING */
#define CANTDEL 36  	/* STRING */
#define KNDOFILE 2  	/* OBJECT in TREE #15 */
#define BOOTREAD 16  	/* STRING */
#define BOOTWRIT 17  	/* STRING */
#define LMRKSUB 16  	/* TREE */
#define BADSUB 3  	/* OBJECT in TREE #16 */
#define SUBDELSV 4  	/* OBJECT in TREE #16 */
#define SUBIGNOR 5  	/* OBJECT in TREE #16 */
#define SVFILES 5  	/* STRING */
#define MARKORPH 14  	/* TREE */
#define ORPHYES 4  	/* OBJECT in TREE #14 */
#define ORPHNO 5  	/* OBJECT in TREE #14 */
#define SUBDELNS 6  	/* OBJECT in TREE #16 */
#define NSFILES 6  	/* STRING */
#define NOWINCAP 8  	/* STRING */
#define NOPART 30  	/* TREE */
#define HDRWRITE 9  	/* STRING */
#define SWARNING 22  	/* TREE */
#define SWARNOK 7  	/* OBJECT in TREE #22 */
#define SWARNCN 8  	/* OBJECT in TREE #22 */
#define CANTFORM 28  	/* TREE */
#define FMTERROK 1  	/* OBJECT in TREE #28 */
#define CANTPART 29  	/* TREE */
#define PTNERROK 1  	/* OBJECT in TREE #29 */
#define WRONPARM 32  	/* TREE */
#define NODRSLOT 17  	/* TREE */
#define NODRYES 7  	/* OBJECT in TREE #17 */
#define NODRNO 8  	/* OBJECT in TREE #17 */
#define WRONOK 7  	/* OBJECT in TREE #32 */
#define NOSCHPOK 2  	/* OBJECT in TREE #30 */
#define NOSCHFOK 2  	/* OBJECT in TREE #31 */
#define SDIRREAD 23  	/* STRING */
#define SDIRWRIT 24  	/* STRING */
#define FUNIT 7  	/* OBJECT in TREE #5 */
#define PUNIT 7  	/* OBJECT in TREE #10 */
#define OLDBAD 5  	/* OBJECT in TREE #7 */
#define NEWBAD 6  	/* OBJECT in TREE #7 */
#define ORPHSEC 6  	/* OBJECT in TREE #14 */
#define ORPHCLU 7  	/* OBJECT in TREE #14 */
#define BADSEC 7  	/* OBJECT in TREE #15 */
#define BADCLU 8  	/* OBJECT in TREE #15 */
#define SUBSEC 7  	/* OBJECT in TREE #16 */
#define SUBCLU 8  	/* OBJECT in TREE #16 */
#define BADFOUND 7  	/* OBJECT in TREE #18 */
#define BADMARKD 8  	/* OBJECT in TREE #18 */
#define ZDRV 8  	/* OBJECT in TREE #20 */
#define BGPART 5  	/* OBJECT in TREE #27 */
#define FMTDEV 6  	/* OBJECT in TREE #28 */
#define PTNDEV 4  	/* OBJECT in TREE #29 */
#define NOSCHPR 4  	/* OBJECT in TREE #30 */
#define NOSCHFMT 5  	/* OBJECT in TREE #31 */
#define ABVERSN 4  	/* OBJECT in TREE #2 */
#define MDMCHNG 38  	/* STRING */
#define WRPROTCT 37  	/* STRING */
#define DMRKBOX 7  	/* OBJECT in TREE #7 */
#define DMRKBAR 8  	/* OBJECT in TREE #7 */
#define DRVNRDY 28  	/* STRING */
#define INSTDRV 29  	/* STRING */
#define SCANMSG 33  	/* TREE */
#define PFMT15 19  	/* OBJECT in TREE #4 */
#define MAXPSIZE 4  	/* STRING */
#define NEEDINFO 11  	/* STRING */
#define NODEV 0  	/* STRING */
#define PPART1 6  	/* OBJECT in TREE #9 */
#define PPART2 8  	/* OBJECT in TREE #9 */
#define PPART3 7  	/* OBJECT in TREE #9 */
#define PPART4 9  	/* OBJECT in TREE #9 */
#define PPART5 10  	/* OBJECT in TREE #9 */
#define PPART6 11  	/* OBJECT in TREE #9 */
#define PPART7 12  	/* OBJECT in TREE #9 */
#define PPART8 14  	/* OBJECT in TREE #9 */
#define PPART9 13  	/* OBJECT in TREE #9 */
#define KEEP0 32  	/* OBJECT in TREE #0 */
#define KEEP1 20  	/* OBJECT in TREE #0 */
#define KEEP2 21  	/* OBJECT in TREE #0 */
#define KEEP3 22  	/* OBJECT in TREE #0 */
#define KEEPAS 34  	/* TREE */
#define KPASDN 3  	/* OBJECT in TREE #34 */
#define KPASUP 4  	/* OBJECT in TREE #34 */
#define KPASOK 1  	/* OBJECT in TREE #34 */
#define KPASCN 2  	/* OBJECT in TREE #34 */
#define KPASNM 6  	/* OBJECT in TREE #34 */
#define KPNUM 10  	/* OBJECT in TREE #34 */
#define DOKPMSG 1  	/* STRING */
#define MENUBAR 35  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #35 */
#define MNFILE 4  	/* OBJECT in TREE #35 */
#define MNDISK 5  	/* OBJECT in TREE #35 */
#define DEABOUT 8  	/* OBJECT in TREE #35 */
#define FIQUIT 17  	/* OBJECT in TREE #35 */
#define DIFORM 19  	/* OBJECT in TREE #35 */
#define DIPART 20  	/* OBJECT in TREE #35 */
#define DIZERO 21  	/* OBJECT in TREE #35 */
#define DIMARK 22  	/* OBJECT in TREE #35 */
#define MKORNOT 36  	/* TREE */
#define NOTMK 3  	/* OBJECT in TREE #36 */
#define YESMK 2  	/* OBJECT in TREE #36 */
#define PHYSDEV 37  	/* TREE */
#define PHYSOK 1  	/* OBJECT in TREE #37 */
#define PHYSCN 2  	/* OBJECT in TREE #37 */
#define DRVID1 6  	/* OBJECT in TREE #37 */
#define DRVID2 7  	/* OBJECT in TREE #37 */
#define DRVID3 8  	/* OBJECT in TREE #37 */
#define DRVID0 5  	/* OBJECT in TREE #37 */
#define UNIT3 13  	/* OBJECT in TREE #37 */
#define UNIT2 14  	/* OBJECT in TREE #37 */
#define BIGBOX 4  	/* OBJECT in TREE #37 */
#define UNIT1 15  	/* OBJECT in TREE #37 */
#define SLUP 11  	/* OBJECT in TREE #37 */
#define SLBOX 10  	/* OBJECT in TREE #37 */
#define SLTRK 9  	/* OBJECT in TREE #37 */
#define SLDN 12  	/* OBJECT in TREE #37 */
#define UNIT0 16  	/* OBJECT in TREE #37 */
