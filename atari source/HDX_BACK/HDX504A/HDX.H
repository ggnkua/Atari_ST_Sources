#define NEEDBOOT 1  	/* STRING */
#define SCRPNL 0  	/* TREE */
#define SEPCN 27  	/* OBJECT in TREE #0 */
#define SEPOK 26  	/* OBJECT in TREE #0 */
#define SEP0DN 12  	/* OBJECT in TREE #0 */
#define SEP0UP 13  	/* OBJECT in TREE #0 */
#define SEP0SIZ 8  	/* OBJECT in TREE #0 */
#define SEP1SIZ 9  	/* OBJECT in TREE #0 */
#define SEP1DN 14  	/* OBJECT in TREE #0 */
#define SEP1UP 15  	/* OBJECT in TREE #0 */
#define SEP2DN 16  	/* OBJECT in TREE #0 */
#define SEP2SIZ 10  	/* OBJECT in TREE #0 */
#define SEP2UP 17  	/* OBJECT in TREE #0 */
#define SEP3SIZ 11  	/* OBJECT in TREE #0 */
#define SEP3DN 18  	/* OBJECT in TREE #0 */
#define SEP3UP 19  	/* OBJECT in TREE #0 */
#define SCRUP 20  	/* OBJECT in TREE #0 */
#define SCRDN 23  	/* OBJECT in TREE #0 */
#define SCRBAR 21  	/* OBJECT in TREE #0 */
#define SPMENU 24  	/* OBJECT in TREE #0 */
#define SCREPT 22  	/* OBJECT in TREE #0 */
#define STOLPART 1  	/* OBJECT in TREE #0 */
#define SEPLEFT 2  	/* OBJECT in TREE #0 */
#define SPARTNM0 4  	/* OBJECT in TREE #0 */
#define SPARTNM1 5  	/* OBJECT in TREE #0 */
#define SPARTNM2 6  	/* OBJECT in TREE #0 */
#define SPARTNM3 7  	/* OBJECT in TREE #0 */
#define SUNDO 25  	/* OBJECT in TREE #0 */
#define EXPPNL 1  	/* TREE */
#define PART1 8  	/* OBJECT in TREE #1 */
#define PART1MB 1  	/* OBJECT in TREE #1 */
#define PART2MB 2  	/* OBJECT in TREE #1 */
#define PART3MB 3  	/* OBJECT in TREE #1 */
#define PART4MB 5  	/* OBJECT in TREE #1 */
#define PARTXMB 4  	/* OBJECT in TREE #1 */
#define PARTYMB 6  	/* OBJECT in TREE #1 */
#define PARTZMB 7  	/* OBJECT in TREE #1 */
#define SELECT1 9  	/* OBJECT in TREE #1 */
#define SELECT2 11  	/* OBJECT in TREE #1 */
#define SELECT3 12  	/* OBJECT in TREE #1 */
#define SELECT4 13  	/* OBJECT in TREE #1 */
#define SELECT5 14  	/* OBJECT in TREE #1 */
#define SELECT6 15  	/* OBJECT in TREE #1 */
#define TOEDIT 26  	/* OBJECT in TREE #1 */
#define NOSEL 25  	/* OBJECT in TREE #1 */
#define SELOK 24  	/* OBJECT in TREE #1 */
#define EXPERT 28  	/* OBJECT in TREE #0 */
#define PART2 16  	/* OBJECT in TREE #1 */
#define PART3 17  	/* OBJECT in TREE #1 */
#define PART4 18  	/* OBJECT in TREE #1 */
#define PARTX 19  	/* OBJECT in TREE #1 */
#define PARTY 20  	/* OBJECT in TREE #1 */
#define PARTZ 21  	/* OBJECT in TREE #1 */
#define MAXLOGMS 2  	/* STRING */
#define MENUBAR 2  	/* TREE */
#define ABOUT 3  	/* TREE */
#define LOGDEV 28  	/* TREE */
#define PICKPART 11  	/* TREE */
#define ZWARNING 21  	/* TREE */
#define DSKNAMES 5  	/* TREE */
#define FWARNING 4  	/* TREE */
#define PWARNING 10  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #2 */
#define MNFILE 4  	/* OBJECT in TREE #2 */
#define MNDISK 5  	/* OBJECT in TREE #2 */
#define DEABOUT 8  	/* OBJECT in TREE #2 */
#define FIQUIT 17  	/* OBJECT in TREE #2 */
#define DIFORM 19  	/* OBJECT in TREE #2 */
#define DIPART 20  	/* OBJECT in TREE #2 */
#define DIZERO 21  	/* OBJECT in TREE #2 */
#define DIMARK 22  	/* OBJECT in TREE #2 */
#define ABOK 2  	/* OBJECT in TREE #3 */
#define CCOLON 1  	/* OBJECT in TREE #28 */
#define DCOLON 2  	/* OBJECT in TREE #28 */
#define ECOLON 4  	/* OBJECT in TREE #28 */
#define FCOLON 5  	/* OBJECT in TREE #28 */
#define GCOLON 6  	/* OBJECT in TREE #28 */
#define HCOLON 7  	/* OBJECT in TREE #28 */
#define ICOLON 8  	/* OBJECT in TREE #28 */
#define JCOLON 9  	/* OBJECT in TREE #28 */
#define KCOLON 10  	/* OBJECT in TREE #28 */
#define LCOLON 11  	/* OBJECT in TREE #28 */
#define MCOLON 12  	/* OBJECT in TREE #28 */
#define NCOLON 13  	/* OBJECT in TREE #28 */
#define OCOLON 14  	/* OBJECT in TREE #28 */
#define PCOLON 15  	/* OBJECT in TREE #28 */
#define LOGOK 16  	/* OBJECT in TREE #28 */
#define LOGCN 17  	/* OBJECT in TREE #28 */
#define PPART0 2  	/* OBJECT in TREE #11 */
#define PPOK 3  	/* OBJECT in TREE #11 */
#define PPCN 4  	/* OBJECT in TREE #11 */
#define PPEDIT 5  	/* OBJECT in TREE #11 */
#define ZWOK 4  	/* OBJECT in TREE #21 */
#define ZWCN 1  	/* OBJECT in TREE #21 */
#define PFMT0 2  	/* OBJECT in TREE #5 */
#define PFMT1 5  	/* OBJECT in TREE #5 */
#define PFMT2 6  	/* OBJECT in TREE #5 */
#define PFMT3 7  	/* OBJECT in TREE #5 */
#define PFMT4 8  	/* OBJECT in TREE #5 */
#define PFMT5 9  	/* OBJECT in TREE #5 */
#define PFMT6 10  	/* OBJECT in TREE #5 */
#define PFMT7 11  	/* OBJECT in TREE #5 */
#define PFMT8 12  	/* OBJECT in TREE #5 */
#define PFMT9 13  	/* OBJECT in TREE #5 */
#define PFMT10 14  	/* OBJECT in TREE #5 */
#define PFMT11 15  	/* OBJECT in TREE #5 */
#define PFMT12 16  	/* OBJECT in TREE #5 */
#define PFMT13 17  	/* OBJECT in TREE #5 */
#define PFMT14 18  	/* OBJECT in TREE #5 */
#define PFOK 3  	/* OBJECT in TREE #5 */
#define PFCN 4  	/* OBJECT in TREE #5 */
#define FWARNOK 4  	/* OBJECT in TREE #4 */
#define FWARNCN 1  	/* OBJECT in TREE #4 */
#define PWARNOK 4  	/* OBJECT in TREE #10 */
#define PWARNCN 1  	/* OBJECT in TREE #10 */
#define DMRKMSG 9  	/* TREE */
#define FMTMSG 8  	/* TREE */
#define PARTMSG 13  	/* TREE */
#define LMRKDONE 20  	/* TREE */
#define ZEROMSG 23  	/* TREE */
#define LMRKMSG 15  	/* TREE */
#define FMTFNL 7  	/* TREE */
#define FMTYES 5  	/* OBJECT in TREE #7 */
#define FMTNO 6  	/* OBJECT in TREE #7 */
#define PARTFNL 12  	/* TREE */
#define ZEROFNL 22  	/* TREE */
#define ZYES 6  	/* OBJECT in TREE #22 */
#define ZNO 7  	/* OBJECT in TREE #22 */
#define PARTYES 5  	/* OBJECT in TREE #12 */
#define PARTNO 6  	/* OBJECT in TREE #12 */
#define LMDONE 2  	/* OBJECT in TREE #20 */
#define LMRKFILE 17  	/* TREE */
#define SHIPDEV 25  	/* TREE */
#define SDEVOK 9  	/* OBJECT in TREE #25 */
#define SDEVCN 10  	/* OBJECT in TREE #25 */
#define SDEV0 1  	/* OBJECT in TREE #25 */
#define SDEV1 2  	/* OBJECT in TREE #25 */
#define SDEV2 3  	/* OBJECT in TREE #25 */
#define SDEV3 4  	/* OBJECT in TREE #25 */
#define SDEV4 5  	/* OBJECT in TREE #25 */
#define SDEV5 6  	/* OBJECT in TREE #25 */
#define SDEV6 7  	/* OBJECT in TREE #25 */
#define SDEV7 8  	/* OBJECT in TREE #25 */
#define SCOMMAND 27  	/* TREE */
#define TRNOFFOK 4  	/* OBJECT in TREE #27 */
#define SHIPFNL 26  	/* TREE */
#define SFNLOK 4  	/* OBJECT in TREE #26 */
#define SFNLCN 5  	/* OBJECT in TREE #26 */
#define NOMEMORY 6  	/* STRING */
#define FATREAD 9  	/* STRING */
#define ROOTREAD 13  	/* STRING */
#define ROOTWRIT 14  	/* STRING */
#define RSRVBAD 19  	/* STRING */
#define BSLREAD 20  	/* STRING */
#define BSLWRITE 21  	/* STRING */
#define CRUPTBSL 24  	/* STRING */
#define MANYLDEV 25  	/* STRING */
#define PART2BIG 29  	/* TREE */
#define NOFMT 33  	/* TREE */
#define AUTOBOOT 26  	/* STRING */
#define MANYBAD 29  	/* STRING */
#define NEXSMEM 30  	/* STRING */
#define NOMENU 31  	/* STRING */
#define OLDFMT 32  	/* STRING */
#define MDACH 33  	/* STRING */
#define CRUPTFMT 34  	/* STRING */
#define BGPARTOK 3  	/* OBJECT in TREE #29 */
#define FATWRITE 11  	/* STRING */
#define MWARNING 14  	/* TREE */
#define BADFILE 3  	/* OBJECT in TREE #17 */
#define DELFILE 4  	/* OBJECT in TREE #17 */
#define SKIPOVER 5  	/* OBJECT in TREE #17 */
#define IGNORBAD 6  	/* OBJECT in TREE #17 */
#define MWARNOK 4  	/* OBJECT in TREE #14 */
#define MWARNCN 1  	/* OBJECT in TREE #14 */
#define DIRREAD 18  	/* STRING */
#define DIRWRITE 17  	/* STRING */
#define BADFAT 12  	/* STRING */
#define CANTDEL 35  	/* STRING */
#define KNDOFILE 2  	/* OBJECT in TREE #17 */
#define BOOTREAD 15  	/* STRING */
#define BOOTWRIT 16  	/* STRING */
#define LMRKSUB 18  	/* TREE */
#define BADSUB 3  	/* OBJECT in TREE #18 */
#define SUBDELSV 4  	/* OBJECT in TREE #18 */
#define SUBIGNOR 5  	/* OBJECT in TREE #18 */
#define SVFILES 4  	/* STRING */
#define MARKORPH 16  	/* TREE */
#define ORPHYES 4  	/* OBJECT in TREE #16 */
#define ORPHNO 5  	/* OBJECT in TREE #16 */
#define SUBDELNS 6  	/* OBJECT in TREE #18 */
#define NSFILES 5  	/* STRING */
#define NOWINCAP 7  	/* STRING */
#define NOPART 32  	/* TREE */
#define HDRWRITE 8  	/* STRING */
#define SWARNING 24  	/* TREE */
#define SWARNOK 7  	/* OBJECT in TREE #24 */
#define SWARNCN 8  	/* OBJECT in TREE #24 */
#define CANTFORM 30  	/* TREE */
#define FMTERROK 1  	/* OBJECT in TREE #30 */
#define CANTPART 31  	/* TREE */
#define PTNERROK 1  	/* OBJECT in TREE #31 */
#define WRONPARM 34  	/* TREE */
#define NODRSLOT 19  	/* TREE */
#define NODRYES 7  	/* OBJECT in TREE #19 */
#define NODRNO 8  	/* OBJECT in TREE #19 */
#define WRONOK 7  	/* OBJECT in TREE #34 */
#define NOSCHPOK 2  	/* OBJECT in TREE #32 */
#define NOSCHFOK 2  	/* OBJECT in TREE #33 */
#define SDIRREAD 22  	/* STRING */
#define SDIRWRIT 23  	/* STRING */
#define FUNIT 7  	/* OBJECT in TREE #7 */
#define PUNIT 7  	/* OBJECT in TREE #12 */
#define OLDBAD 5  	/* OBJECT in TREE #9 */
#define NEWBAD 6  	/* OBJECT in TREE #9 */
#define ORPHSEC 6  	/* OBJECT in TREE #16 */
#define ORPHCLU 7  	/* OBJECT in TREE #16 */
#define BADSEC 7  	/* OBJECT in TREE #17 */
#define BADCLU 8  	/* OBJECT in TREE #17 */
#define SUBSEC 7  	/* OBJECT in TREE #18 */
#define SUBCLU 8  	/* OBJECT in TREE #18 */
#define BADFOUND 7  	/* OBJECT in TREE #20 */
#define BADMARKD 8  	/* OBJECT in TREE #20 */
#define ZDRV 8  	/* OBJECT in TREE #22 */
#define BGPART 5  	/* OBJECT in TREE #29 */
#define FMTDEV 6  	/* OBJECT in TREE #30 */
#define PTNDEV 4  	/* OBJECT in TREE #31 */
#define NOSCHPR 4  	/* OBJECT in TREE #32 */
#define NOSCHFMT 5  	/* OBJECT in TREE #33 */
#define ABVERSN 3  	/* OBJECT in TREE #3 */
#define MDMCHNG 37  	/* STRING */
#define WRPROTCT 36  	/* STRING */
#define DMRKBOX 7  	/* OBJECT in TREE #9 */
#define DMRKBAR 8  	/* OBJECT in TREE #9 */
#define DRVNRDY 27  	/* STRING */
#define INSTDRV 28  	/* STRING */
#define SCANMSG 35  	/* TREE */
#define PFMT15 19  	/* OBJECT in TREE #5 */
#define MAXPSIZE 3  	/* STRING */
#define NEEDINFO 10  	/* STRING */
#define TYPEDIAL 36  	/* TREE */
#define SCSIYES 1  	/* OBJECT in TREE #36 */
#define ACSIYES 2  	/* OBJECT in TREE #36 */
#define NODEV 0  	/* STRING */
#define PPART1 6  	/* OBJECT in TREE #11 */
#define PPART2 8  	/* OBJECT in TREE #11 */
#define PPART3 7  	/* OBJECT in TREE #11 */
#define PPART4 9  	/* OBJECT in TREE #11 */
#define PPART5 10  	/* OBJECT in TREE #11 */
#define PPART6 11  	/* OBJECT in TREE #11 */
#define PPART7 12  	/* OBJECT in TREE #11 */
#define PPART8 14  	/* OBJECT in TREE #11 */
#define PPART9 13  	/* OBJECT in TREE #11 */
#define IDEYES 4  	/* OBJECT in TREE #36 */
#define MKORNOT 6  	/* TREE */
#define NOTMK 3  	/* OBJECT in TREE #6 */
#define YESMK 2  	/* OBJECT in TREE #6 */
#define PHYSDEV 37  	/* TREE */
#define PHYSOK 1  	/* OBJECT in TREE #37 */
#define PHYSCN 2  	/* OBJECT in TREE #37 */
#define DRVID1 6  	/* OBJECT in TREE #37 */
#define DRVID2 7  	/* OBJECT in TREE #37 */
#define DRVID3 8  	/* OBJECT in TREE #37 */
#define DRVID0 5  	/* OBJECT in TREE #37 */
#define UNIT3 13  	/* OBJECT in TREE #37 */
#define UNIT2 14  	/* OBJECT in TREE #37 */
#define BIGBOX 4  	/* OBJECT in TREE #37 */
#define UNIT1 15  	/* OBJECT in TREE #37 */
#define SLUP 11  	/* OBJECT in TREE #37 */
#define SLBOX 10  	/* OBJECT in TREE #37 */
#define SLTRK 9  	/* OBJECT in TREE #37 */
#define SLDN 12  	/* OBJECT in TREE #37 */
#define UNIT0 16  	/* OBJECT in TREE #37 */
