#define FWARNING 0  	/* TREE */
#define FWARNOK 10  	/* OBJECT in TREE #0 */
#define FWARNCN 9  	/* OBJECT in TREE #0 */
#define FMTMSG 2  	/* TREE */
#define PARTMSG 3  	/* TREE */
#define DMRKMSG 1  	/* TREE */
