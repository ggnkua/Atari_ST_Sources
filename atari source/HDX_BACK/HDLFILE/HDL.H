#define CNTOPEN 0  	/* STRING */
#define CNTCRTDR 1  	/* STRING */
#define WRERROR 2  	/* STRING */
#define RDERROR 3  	/* STRING */
#define CNTCRTFL 4  	/* STRING */
#define SAMENAME 0  	/* TREE */
#define COPY 2  	/* OBJECT in TREE #0 */
#define SKIP 3  	/* OBJECT in TREE #0 */
#define QUIT 4  	/* OBJECT in TREE #0 */
#define EDFNAME 5  	/* OBJECT in TREE #0 */
#define CPBOX 1  	/* TREE */
#define FNAME 6  	/* OBJECT in TREE #0 */
#define NUMFILE 3  	/* OBJECT in TREE #1 */
#define NUMDIR 4  	/* OBJECT in TREE #1 */
#define OKCP 1  	/* OBJECT in TREE #1 */
#define CANCEL 2  	/* OBJECT in TREE #1 */
#define CPDIR 7  	/* OBJECT in TREE #1 */
#define CPFILE 6  	/* OBJECT in TREE #1 */
#define NOMEMORY 5  	/* STRING */
#define HIDEBOX 5  	/* OBJECT in TREE #1 */
#define TITLE 8  	/* OBJECT in TREE #1 */
#define CNTDELF 6  	/* STRING */
#define CNTDELD 7  	/* STRING */
