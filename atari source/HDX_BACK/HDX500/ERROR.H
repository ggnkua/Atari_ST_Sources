/*	ERROR.H
 *		Define all necessary error codes.
 */
 
#define	WRTPRTD	(0x27)
#define	MDMCHGD	(0x28)
#define	DEVNRDY	(0x04)
