/*
 * mtype.h -- list machines supported by Mark Williams Company.
 *
 * Copyright (c) 1981-1987, Mark Williams Company, Chicago
 * This file and its contents may not be copied or distributed
 * without permission.
 */

#ifndef	 MTYPE_H
#define	 MTYPE_H
/*
 * Type definitions:
 */
#define M_PDP11	1		/* PDP-11 */
#define M_VAX	2		/* VAX */
#define	M_360	3		/* IBM 360 */
#define M_Z8001	4		/* Zilog 8001 (segmented) */
#define M_Z8002	5		/* Zilog 8002 (unsegmented) */
#define M_8086	6		/* Intel 8086 */
#define M_8080	7		/* Intel 8080 */
#define M_6800	8		/* Motorola 6800 */
#define M_6809	9		/* Motorola 6809 */
#define M_68000	10		/* Motorola 68000 */

#endif

/* End of mtype.h */
