/*
 * types.h -- list machine-dependent types.
 *
 * Copyright (c) 1986-1987, Mark Williams Company, Chicago
 * This file and its contents may not be copied or distributed
 * without permission.
 */

#ifndef TYPES_H
#define TYPES_H TYPES_H
typedef long size_t;
#endif

/* End of types.h */
