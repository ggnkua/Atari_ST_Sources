#define PHYSDEV 0  	/* TREE */
#define PHYSOK 1  	/* OBJECT in TREE #0 */
#define PHYSCN 2  	/* OBJECT in TREE #0 */
#define DRVID1 6  	/* OBJECT in TREE #0 */
#define DRVID2 7  	/* OBJECT in TREE #0 */
#define DRVID3 8  	/* OBJECT in TREE #0 */
#define DRVID0 5  	/* OBJECT in TREE #0 */
#define UNIT3 16  	/* OBJECT in TREE #0 */
#define UNIT2 14  	/* OBJECT in TREE #0 */
#define BIGBOX 4  	/* OBJECT in TREE #0 */
#define BUNIT 13  	/* OBJECT in TREE #0 */
#define UNIT0 17  	/* OBJECT in TREE #0 */
#define UNIT1 15  	/* OBJECT in TREE #0 */
#define SLUP 11  	/* OBJECT in TREE #0 */
#define SLBOX 10  	/* OBJECT in TREE #0 */
#define SLTRK 9  	/* OBJECT in TREE #0 */
#define SLDN 12  	/* OBJECT in TREE #0 */
