#define MENUBAR 0  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #0 */
#define MNFILE 4  	/* OBJECT in TREE #0 */
#define MNDISK 5  	/* OBJECT in TREE #0 */
#define DEABOUT 8  	/* OBJECT in TREE #0 */
#define FIQUIT 17  	/* OBJECT in TREE #0 */
#define DIFORM 19  	/* OBJECT in TREE #0 */
#define DIPART 20  	/* OBJECT in TREE #0 */
#define DIZERO 21  	/* OBJECT in TREE #0 */
#define DIMARK 22  	/* OBJECT in TREE #0 */
#define MKORNOT 1  	/* TREE */
#define NOTMK 3  	/* OBJECT in TREE #1 */
#define YESMK 2  	/* OBJECT in TREE #1 */
#define PHYSDEV 2  	/* TREE */
#define PHYSOK 1  	/* OBJECT in TREE #2 */
#define PHYSCN 2  	/* OBJECT in TREE #2 */
#define DRVID1 6  	/* OBJECT in TREE #2 */
#define DRVID2 7  	/* OBJECT in TREE #2 */
#define DRVID3 8  	/* OBJECT in TREE #2 */
#define DRVID0 5  	/* OBJECT in TREE #2 */
#define UNIT3 13  	/* OBJECT in TREE #2 */
#define UNIT2 14  	/* OBJECT in TREE #2 */
#define BIGBOX 4  	/* OBJECT in TREE #2 */
#define UNIT1 15  	/* OBJECT in TREE #2 */
#define SLUP 11  	/* OBJECT in TREE #2 */
#define SLBOX 10  	/* OBJECT in TREE #2 */
#define SLTRK 9  	/* OBJECT in TREE #2 */
#define SLDN 12  	/* OBJECT in TREE #2 */
#define UNIT0 16  	/* OBJECT in TREE #2 */
