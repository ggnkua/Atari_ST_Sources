/*  addr.h  */
/*      Addresses of all dialogue and alert boxes in resource file  */


/* Dialogue boxes */
OBJECT *scrpnl;	/* -> select box tree */
OBJECT *cnfdf;	/* -> alart box tree */
OBJECT *cnopen;	/* -> alart box tree */
OBJECT *binonly;	/* -> alart box tree */
OBJECT *needfile;	/* -> alart box tree */
OBJECT *cnrdf;	/* -> alart box tree */
OBJECT *cnopf;	/* -> alart box tree */
OBJECT *cnsdir;	/* -> alart box tree */
OBJECT *outmem;	/* -> alart box tree */
