#define SCRPNL 0  	/* TREE */
#define EXIT 1  	/* OBJECT in TREE #0 */
#define SCRDN 3  	/* OBJECT in TREE #0 */
#define SCRUP 4  	/* OBJECT in TREE #0 */
#define FILESTR 2  	/* OBJECT in TREE #0 */
#define CNFDF 0  	/* STRING */
#define CNRDF 1  	/* STRING */
#define OUTMEM 2  	/* STRING */
#define CNOPF 3  	/* STRING */
#define OKDO 7  	/* OBJECT in TREE #0 */
#define BINONLY 4  	/* STRING */
#define CNSDIR 5  	/* STRING */
#define TOLFILE 9  	/* OBJECT in TREE #0 */
#define BINARYB 11  	/* OBJECT in TREE #0 */
#define ASCIIB 12  	/* OBJECT in TREE #0 */
#define CNOPEN 6  	/* STRING */
#define NEEDFILE 7  	/* STRING */
#define SCRLF 14  	/* OBJECT in TREE #0 */
#define SCRRT 15  	/* OBJECT in TREE #0 */
