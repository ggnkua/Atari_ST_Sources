#define MENUBAR 0  	/* TREE */
#define ABOUT 1  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #0 */
#define MNFILE 4  	/* OBJECT in TREE #0 */
#define MNDISK 5  	/* OBJECT in TREE #0 */
#define DEABOUT 8  	/* OBJECT in TREE #0 */
#define FIQUIT 17  	/* OBJECT in TREE #0 */
#define DIPART 19  	/* OBJECT in TREE #0 */
#define ABOK 2  	/* OBJECT in TREE #1 */
#define PARTMSG 2  	/* TREE */
#define NOMEMORY 0  	/* STRING */
#define ROOTREAD 2  	/* STRING */
#define OLDFMT 5  	/* STRING */
#define BADFAT 1  	/* STRING */
#define ABVERSN 3  	/* OBJECT in TREE #1 */
#define MDMCHNG 6  	/* STRING */
#define DRVNRDY 3  	/* STRING */
#define INSTDRV 4  	/* STRING */
#define SCANMSG 3  	/* TREE */
#define PHYSDEV 4  	/* TREE */
#define PHYSOK 1  	/* OBJECT in TREE #4 */
#define PHYSCN 2  	/* OBJECT in TREE #4 */
#define DRVID1 6  	/* OBJECT in TREE #4 */
#define DRVID2 7  	/* OBJECT in TREE #4 */
#define DRVID3 8  	/* OBJECT in TREE #4 */
#define DRVID0 5  	/* OBJECT in TREE #4 */
#define UNIT3 13  	/* OBJECT in TREE #4 */
#define UNIT2 14  	/* OBJECT in TREE #4 */
#define BIGBOX 4  	/* OBJECT in TREE #4 */
#define UNIT1 15  	/* OBJECT in TREE #4 */
#define SLUP 11  	/* OBJECT in TREE #4 */
#define SLBOX 10  	/* OBJECT in TREE #4 */
#define SLTRK 9  	/* OBJECT in TREE #4 */
#define SLDN 12  	/* OBJECT in TREE #4 */
#define UNIT0 16  	/* OBJECT in TREE #4 */
