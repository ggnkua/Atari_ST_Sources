#define NEEDBOOT 0  	/* STRING */
#define SCRPNL 0  	/* TREE */
#define SEPCN 28  	/* OBJECT in TREE #0 */
#define SEPOK 27  	/* OBJECT in TREE #0 */
#define SEP0DN 13  	/* OBJECT in TREE #0 */
#define SEP0UP 14  	/* OBJECT in TREE #0 */
#define SEP0SIZ 9  	/* OBJECT in TREE #0 */
#define SEP1SIZ 10  	/* OBJECT in TREE #0 */
#define SEP1DN 15  	/* OBJECT in TREE #0 */
#define SEP1UP 16  	/* OBJECT in TREE #0 */
#define SEP2DN 17  	/* OBJECT in TREE #0 */
#define SEP2SIZ 11  	/* OBJECT in TREE #0 */
#define SEP2UP 18  	/* OBJECT in TREE #0 */
#define SEP3SIZ 12  	/* OBJECT in TREE #0 */
#define SEP3DN 19  	/* OBJECT in TREE #0 */
#define SEP3UP 20  	/* OBJECT in TREE #0 */
#define SCRUP 21  	/* OBJECT in TREE #0 */
#define SCRDN 24  	/* OBJECT in TREE #0 */
#define SCRBAR 22  	/* OBJECT in TREE #0 */
#define SPMENU 25  	/* OBJECT in TREE #0 */
#define SCREPT 23  	/* OBJECT in TREE #0 */
#define STOLPART 2  	/* OBJECT in TREE #0 */
#define SEPLEFT 3  	/* OBJECT in TREE #0 */
#define SPARTNM0 5  	/* OBJECT in TREE #0 */
#define SPARTNM1 6  	/* OBJECT in TREE #0 */
#define SPARTNM2 7  	/* OBJECT in TREE #0 */
#define SPARTNM3 8  	/* OBJECT in TREE #0 */
#define SUNDO 26  	/* OBJECT in TREE #0 */
#define EXPPNL 1  	/* TREE */
#define PART1 8  	/* OBJECT in TREE #1 */
#define PART1MB 1  	/* OBJECT in TREE #1 */
#define PART2MB 2  	/* OBJECT in TREE #1 */
#define PART3MB 3  	/* OBJECT in TREE #1 */
#define PART4MB 5  	/* OBJECT in TREE #1 */
#define PARTXMB 4  	/* OBJECT in TREE #1 */
#define PARTYMB 6  	/* OBJECT in TREE #1 */
#define PARTZMB 7  	/* OBJECT in TREE #1 */
#define SELECT1 9  	/* OBJECT in TREE #1 */
#define SELECT2 11  	/* OBJECT in TREE #1 */
#define SELECT3 12  	/* OBJECT in TREE #1 */
#define SELECT4 13  	/* OBJECT in TREE #1 */
#define SELECT5 14  	/* OBJECT in TREE #1 */
#define SELECT6 15  	/* OBJECT in TREE #1 */
#define TOEDIT 26  	/* OBJECT in TREE #1 */
#define NOSEL 25  	/* OBJECT in TREE #1 */
#define SELOK 24  	/* OBJECT in TREE #1 */
#define EXPERT 29  	/* OBJECT in TREE #0 */
#define PART2 16  	/* OBJECT in TREE #1 */
#define PART3 17  	/* OBJECT in TREE #1 */
#define PART4 18  	/* OBJECT in TREE #1 */
#define PARTX 19  	/* OBJECT in TREE #1 */
#define PARTY 20  	/* OBJECT in TREE #1 */
#define PARTZ 21  	/* OBJECT in TREE #1 */
#define MAXLOGMS 1  	/* STRING */
#define MENUBAR 2  	/* TREE */
#define ABOUT 3  	/* TREE */
#define PHYSDEV 28  	/* TREE */
#define LOGDEV 27  	/* TREE */
#define PICKPART 10  	/* TREE */
#define ZWARNING 20  	/* TREE */
#define DSKNAMES 5  	/* TREE */
#define FWARNING 4  	/* TREE */
#define PWARNING 9  	/* TREE */
#define MNDESK 3  	/* OBJECT in TREE #2 */
#define MNFILE 4  	/* OBJECT in TREE #2 */
#define MNDISK 5  	/* OBJECT in TREE #2 */
#define DEABOUT 8  	/* OBJECT in TREE #2 */
#define FIQUIT 17  	/* OBJECT in TREE #2 */
#define DIFORM 19  	/* OBJECT in TREE #2 */
#define DIPART 20  	/* OBJECT in TREE #2 */
#define DIZERO 21  	/* OBJECT in TREE #2 */
#define DIMARK 22  	/* OBJECT in TREE #2 */
#define ABOK 3  	/* OBJECT in TREE #3 */
#define UNIT0 1  	/* OBJECT in TREE #28 */
#define UNIT1 2  	/* OBJECT in TREE #28 */
#define UNIT2 3  	/* OBJECT in TREE #28 */
#define UNIT3 4  	/* OBJECT in TREE #28 */
#define UNIT4 5  	/* OBJECT in TREE #28 */
#define UNIT5 6  	/* OBJECT in TREE #28 */
#define UNIT6 7  	/* OBJECT in TREE #28 */
#define UNIT7 8  	/* OBJECT in TREE #28 */
#define PHYSOK 9  	/* OBJECT in TREE #28 */
#define PHYSCN 10  	/* OBJECT in TREE #28 */
#define CCOLON 1  	/* OBJECT in TREE #27 */
#define DCOLON 2  	/* OBJECT in TREE #27 */
#define ECOLON 4  	/* OBJECT in TREE #27 */
#define FCOLON 5  	/* OBJECT in TREE #27 */
#define GCOLON 6  	/* OBJECT in TREE #27 */
#define HCOLON 7  	/* OBJECT in TREE #27 */
#define ICOLON 8  	/* OBJECT in TREE #27 */
#define JCOLON 9  	/* OBJECT in TREE #27 */
#define KCOLON 10  	/* OBJECT in TREE #27 */
#define LCOLON 11  	/* OBJECT in TREE #27 */
#define MCOLON 12  	/* OBJECT in TREE #27 */
#define NCOLON 13  	/* OBJECT in TREE #27 */
#define OCOLON 14  	/* OBJECT in TREE #27 */
#define PCOLON 15  	/* OBJECT in TREE #27 */
#define LOGOK 16  	/* OBJECT in TREE #27 */
#define LOGCN 17  	/* OBJECT in TREE #27 */
#define PPART0 2  	/* OBJECT in TREE #10 */
#define PPART1 5  	/* OBJECT in TREE #10 */
#define PPART2 6  	/* OBJECT in TREE #10 */
#define PPART3 7  	/* OBJECT in TREE #10 */
#define PPART4 8  	/* OBJECT in TREE #10 */
#define PPART5 9  	/* OBJECT in TREE #10 */
#define PPART6 10  	/* OBJECT in TREE #10 */
#define PPART7 11  	/* OBJECT in TREE #10 */
#define PPART8 12  	/* OBJECT in TREE #10 */
#define PPART9 13  	/* OBJECT in TREE #10 */
#define PPART10 14  	/* OBJECT in TREE #10 */
#define PPART11 15  	/* OBJECT in TREE #10 */
#define PPART12 16  	/* OBJECT in TREE #10 */
#define PPART13 17  	/* OBJECT in TREE #10 */
#define PPART14 18  	/* OBJECT in TREE #10 */
#define PPOK 3  	/* OBJECT in TREE #10 */
#define PPCN 4  	/* OBJECT in TREE #10 */
#define PPEDIT 19  	/* OBJECT in TREE #10 */
#define ZWOK 4  	/* OBJECT in TREE #20 */
#define ZWCN 1  	/* OBJECT in TREE #20 */
#define PFMT0 2  	/* OBJECT in TREE #5 */
#define PFMT1 5  	/* OBJECT in TREE #5 */
#define PFMT2 6  	/* OBJECT in TREE #5 */
#define PFMT3 7  	/* OBJECT in TREE #5 */
#define PFMT4 8  	/* OBJECT in TREE #5 */
#define PFMT5 9  	/* OBJECT in TREE #5 */
#define PFMT6 10  	/* OBJECT in TREE #5 */
#define PFMT7 11  	/* OBJECT in TREE #5 */
#define PFMT8 12  	/* OBJECT in TREE #5 */
#define PFMT9 13  	/* OBJECT in TREE #5 */
#define PFMT10 14  	/* OBJECT in TREE #5 */
#define PFMT11 15  	/* OBJECT in TREE #5 */
#define PFMT12 16  	/* OBJECT in TREE #5 */
#define PFMT13 17  	/* OBJECT in TREE #5 */
#define PFMT14 18  	/* OBJECT in TREE #5 */
#define PFOK 3  	/* OBJECT in TREE #5 */
#define PFCN 4  	/* OBJECT in TREE #5 */
#define FWARNOK 4  	/* OBJECT in TREE #4 */
#define FWARNCN 1  	/* OBJECT in TREE #4 */
#define PWARNOK 4  	/* OBJECT in TREE #9 */
#define PWARNCN 1  	/* OBJECT in TREE #9 */
#define DMRKMSG 8  	/* TREE */
#define FMTMSG 7  	/* TREE */
#define PARTMSG 12  	/* TREE */
#define LMRKDONE 19  	/* TREE */
#define ZEROMSG 22  	/* TREE */
#define LMRKMSG 14  	/* TREE */
#define FMTFNL 6  	/* TREE */
#define FMTYES 5  	/* OBJECT in TREE #6 */
#define FMTNO 6  	/* OBJECT in TREE #6 */
#define PARTFNL 11  	/* TREE */
#define ZEROFNL 21  	/* TREE */
#define ZYES 6  	/* OBJECT in TREE #21 */
#define ZNO 7  	/* OBJECT in TREE #21 */
#define PARTYES 5  	/* OBJECT in TREE #11 */
#define PARTNO 6  	/* OBJECT in TREE #11 */
#define LMDONE 2  	/* OBJECT in TREE #19 */
#define LMRKFILE 16  	/* TREE */
#define SHIPDEV 24  	/* TREE */
#define SDEVOK 9  	/* OBJECT in TREE #24 */
#define SDEVCN 10  	/* OBJECT in TREE #24 */
#define SDEV0 1  	/* OBJECT in TREE #24 */
#define SDEV1 2  	/* OBJECT in TREE #24 */
#define SDEV2 3  	/* OBJECT in TREE #24 */
#define SDEV3 4  	/* OBJECT in TREE #24 */
#define SDEV4 5  	/* OBJECT in TREE #24 */
#define SDEV5 6  	/* OBJECT in TREE #24 */
#define SDEV6 7  	/* OBJECT in TREE #24 */
#define SDEV7 8  	/* OBJECT in TREE #24 */
#define SCOMMAND 26  	/* TREE */
#define TRNOFFOK 4  	/* OBJECT in TREE #26 */
#define SHIPFNL 25  	/* TREE */
#define SFNLOK 4  	/* OBJECT in TREE #25 */
#define SFNLCN 5  	/* OBJECT in TREE #25 */
#define DISHIP 24  	/* OBJECT in TREE #2 */
#define NOMEMORY 4  	/* STRING */
#define FATREAD 7  	/* STRING */
#define ROOTREAD 10  	/* STRING */
#define ROOTWRIT 11  	/* STRING */
#define RSRVBAD 16  	/* STRING */
#define BSLREAD 17  	/* STRING */
#define BSLWRITE 18  	/* STRING */
#define CRUPTBSL 21  	/* STRING */
#define MANYLDEV 22  	/* STRING */
#define PART2BIG 29  	/* TREE */
#define NOFMT 33  	/* TREE */
#define AUTOBOOT 23  	/* STRING */
#define MANYBAD 26  	/* STRING */
#define NEXSMEM 27  	/* STRING */
#define NOMENU 28  	/* STRING */
#define OLDFMT 29  	/* STRING */
#define MDACH 30  	/* STRING */
#define CRUPTFMT 31  	/* STRING */
#define BGPARTOK 3  	/* OBJECT in TREE #29 */
#define FATWRITE 8  	/* STRING */
#define MWARNING 13  	/* TREE */
#define BADFILE 3  	/* OBJECT in TREE #16 */
#define DELFILE 4  	/* OBJECT in TREE #16 */
#define SKIPOVER 5  	/* OBJECT in TREE #16 */
#define IGNORBAD 6  	/* OBJECT in TREE #16 */
#define MWARNOK 4  	/* OBJECT in TREE #13 */
#define MWARNCN 1  	/* OBJECT in TREE #13 */
#define DIRREAD 15  	/* STRING */
#define DIRWRITE 14  	/* STRING */
#define BADFAT 9  	/* STRING */
#define CANTDEL 32  	/* STRING */
#define KNDOFILE 2  	/* OBJECT in TREE #16 */
#define BOOTREAD 12  	/* STRING */
#define BOOTWRIT 13  	/* STRING */
#define LMRKSUB 17  	/* TREE */
#define BADSUB 3  	/* OBJECT in TREE #17 */
#define SUBDELSV 4  	/* OBJECT in TREE #17 */
#define SUBIGNOR 5  	/* OBJECT in TREE #17 */
#define SVFILES 2  	/* STRING */
#define MARKORPH 15  	/* TREE */
#define ORPHYES 4  	/* OBJECT in TREE #15 */
#define ORPHNO 5  	/* OBJECT in TREE #15 */
#define SUBDELNS 6  	/* OBJECT in TREE #17 */
#define NSFILES 3  	/* STRING */
#define NOWINCAP 5  	/* STRING */
#define NOPART 32  	/* TREE */
#define HDRWRITE 6  	/* STRING */
#define SWARNING 23  	/* TREE */
#define SWARNOK 7  	/* OBJECT in TREE #23 */
#define SWARNCN 8  	/* OBJECT in TREE #23 */
#define CANTFORM 30  	/* TREE */
#define FMTERROK 1  	/* OBJECT in TREE #30 */
#define CANTPART 31  	/* TREE */
#define PTNERROK 1  	/* OBJECT in TREE #31 */
#define WRONPARM 34  	/* TREE */
#define NODRSLOT 18  	/* TREE */
#define NODRYES 7  	/* OBJECT in TREE #18 */
#define NODRNO 8  	/* OBJECT in TREE #18 */
#define WRONOK 7  	/* OBJECT in TREE #34 */
#define NOSCHPOK 2  	/* OBJECT in TREE #32 */
#define NOSCHFOK 2  	/* OBJECT in TREE #33 */
#define SDIRREAD 19  	/* STRING */
#define SDIRWRIT 20  	/* STRING */
#define FUNIT 7  	/* OBJECT in TREE #6 */
#define PUNIT 7  	/* OBJECT in TREE #11 */
#define OLDBAD 5  	/* OBJECT in TREE #8 */
#define NEWBAD 6  	/* OBJECT in TREE #8 */
#define ORPHSEC 6  	/* OBJECT in TREE #15 */
#define ORPHCLU 7  	/* OBJECT in TREE #15 */
#define BADSEC 7  	/* OBJECT in TREE #16 */
#define BADCLU 8  	/* OBJECT in TREE #16 */
#define SUBSEC 7  	/* OBJECT in TREE #17 */
#define SUBCLU 8  	/* OBJECT in TREE #17 */
#define BADFOUND 7  	/* OBJECT in TREE #19 */
#define BADMARKD 8  	/* OBJECT in TREE #19 */
#define ZDRV 8  	/* OBJECT in TREE #21 */
#define BGPART 5  	/* OBJECT in TREE #29 */
#define FMTDEV 6  	/* OBJECT in TREE #30 */
#define PTNDEV 4  	/* OBJECT in TREE #31 */
#define NOSCHPR 4  	/* OBJECT in TREE #32 */
#define NOSCHFMT 5  	/* OBJECT in TREE #33 */
#define ABVERSN 4  	/* OBJECT in TREE #3 */
#define MDMCHNG 34  	/* STRING */
#define WRPROTCT 33  	/* STRING */
#define DMRKBOX 7  	/* OBJECT in TREE #8 */
#define DMRKBAR 8  	/* OBJECT in TREE #8 */
#define DRVNRDY 24  	/* STRING */
#define INSTDRV 25  	/* STRING */
