#define FWARNING 0  	/* TREE */
#define FWARNOK 10  	/* OBJECT in TREE #0 */
#define FWARNCN 9  	/* OBJECT in TREE #0 */
#define FMTMSG 1  	/* TREE */
#define PARTMSG 2  	/* TREE */
#define DMRKMSG 3  	/* TREE */
#define OLDBAD 5  	/* OBJECT in TREE #3 */
#define NEWBAD 6  	/* OBJECT in TREE #3 */
#define DMRKBOX 7  	/* OBJECT in TREE #3 */
#define DMRKBAR 8  	/* OBJECT in TREE #3 */
#define INSTLMSG 4  	/* TREE */
