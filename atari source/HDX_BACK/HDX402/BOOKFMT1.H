#define DMRKMSG 0  	/* TREE */
#define OLDBAD 5  	/* OBJECT in TREE #0 */
#define NEWBAD 6  	/* OBJECT in TREE #0 */
#define DMRKBOX 7  	/* OBJECT in TREE #0 */
#define DMRKBAR 8  	/* OBJECT in TREE #0 */
