/* Resource Datei Indizes f�r CKBD_RSC */

#define MAIN     0   /* Formular/Dialog */
#define M_TITLE  1   /* BOXTEXT in Baum MAIN */
#define M_COMPOSE 3   /* BUTTON in Baum MAIN */
#define M_DEADKEY 4   /* BUTTON in Baum MAIN */
#define M_EXTKEY 5   /* BUTTON in Baum MAIN */
#define M_ALTNNN 6   /* BUTTON in Baum MAIN */
#define M_SETUP  7   /* BUTTON in Baum MAIN */
#define M_LANGTITLE 8   /* BUTTON in Baum MAIN */
#define M_LANGUAGE 9   /* BOXTEXT in Baum MAIN */
#define M_TABLEACTIVE 11  /* BOXTEXT in Baum MAIN */
#define M_TABVALID 12  /* STRING in Baum MAIN */
#define M_USEDTABLE 13  /* BOXTEXT in Baum MAIN */
#define M_TABNAME 14  /* STRING in Baum MAIN */
#define M_SAVE   16  /* BUTTON in Baum MAIN */
#define M_OK     18  /* BUTTON in Baum MAIN */
#define M_ABORT  19  /* BUTTON in Baum MAIN */

#define CC_CFG   1   /* Formular/Dialog */
#define C_CMODE  2   /* STRING in Baum CC_CFG */
#define C_COMPMODE 3   /* BOXTEXT in Baum CC_CFG */
#define C_CORDER 4   /* STRING in Baum CC_CFG */
#define C_COMPORDER 5   /* BOXTEXT in Baum CC_CFG */
#define C_DELAY  6   /* STRING in Baum CC_CFG */
#define C_TIMEOUT 7   /* STRING in Baum CC_CFG */
#define C_OK     18  /* BUTTON in Baum CC_CFG */
#define C_ABORT  19  /* BUTTON in Baum CC_CFG */
#define C_CCCTITLE 20  /* BOXTEXT in Baum CC_CFG */

#define DK_CFG   2   /* Formular/Dialog */
#define D_OK     6   /* BUTTON in Baum DK_CFG */
#define D_ABORT  7   /* BUTTON in Baum DK_CFG */
#define C_DKTITLE 8   /* BOXTEXT in Baum DK_CFG */
#define C_VALIDKEYS 10  /* STRING in Baum DK_CFG */
#define C_DEADKEYS 11  /* FBOXTEXT in Baum DK_CFG */

#define IMAGES   3   /* Formular/Dialog */
#define SELBUTTON_NORM 1   /* IMAGE in Baum IMAGES */
#define SELBUTTON_SELECT 2   /* IMAGE in Baum IMAGES */
#define RADIOBUT_NORM 3   /* IMAGE in Baum IMAGES */
#define RADIOBUT_SEL 4   /* IMAGE in Baum IMAGES */
