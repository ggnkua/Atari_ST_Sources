               >PART 'KBD: Tabellen & Daten'
; DATEN FEST
clicksound:    dc.b $00,$3B,$01,$00,$02,$00,$03,$00
               dc.b $04,$00,$05,$00,$06,$00,$09,$00
               dc.b $0A,$00,$07,$FE,$08,$10,$0D,$03
               dc.b $0B,$80,$0C,$01,$FF,$00

bellsound:     dc.b $00,$34,$01,$00,$02,$00,$03,$00
               dc.b $04,$00,$05,$00,$06,$00,$07,$FE
               dc.b $08,$10,$09,$00,$0A,$00,$0B,$00
               dc.b $0C,$10,$0D,$09,$FF,$00

*
* Deadkey: welche Zeichen sind als TOT deklariert?
*
dead_default:                           ;(max 15 chars + 1 Nullterm)
               dc.b """","`","'","^","|","~",0,0
               dc.b 0,0,0,0,0,0,0,0
dead_onoff:    dc.w 1
Dead_enabletab:
               ds.b 256       ;256 bytes

*
* COMPOSED CHARACTERS - TABELLE:
*
* Format ist:
*   typedef struct {
*       char    primary;        /* erster Buchstabe plus... */
*       char    secondary;      /* ...zweiter Buchstabe */
*       char    composed;       /* ergibt _composed_ ! */
*       char    flags;          /* div. Flags, reserved! */
*   } comptab[];
*
*
* FLAGS: damit sind verschiedene Angaben m”glich
*   - order sensitiveness
*
               even
comptab:
               dc.b "++#",0   ;35
               dc.b "aa@",0   ;64
               dc.b "AA@",0
               dc.b "(([",0   ;91
               dc.b "//\",0   ;92
               dc.b "))]",0   ;93
               dc.b "(-{",0   ;123
               dc.b "/^|",0   ;124
               dc.b ")-}",0   ;125
               dc.b "DE",ORDER ;127 DELTA
               dc.b "De",ORDER
               dc.b "C,€",0   ;128
               dc.b 'u"�',0   ;129
               dc.b 'u¹�',0
               dc.b "e'‚",0   ;130
               dc.b "a^ƒ",0   ;131
               dc.b 'a"„',0   ;132
               dc.b 'a¹„',0
               dc.b "a`…",0   ;133
               dc.b "a.†",0   ;134
               dc.b "aø†",0
               dc.b "c,‡",0   ;135
               dc.b "e^ˆ",0   ;136
               dc.b 'e"‰',0   ;137
               dc.b 'e¹‰',0
               dc.b "e`Š",0   ;138
               dc.b 'i"‹',0   ;139
               dc.b 'i¹‹',0
               dc.b "i^Œ",0   ;140
               dc.b "i`�",0   ;141
               dc.b 'A"Ž',0   ;142
               dc.b 'A¹Ž',0
               dc.b "A.�",0   ;143
               dc.b "Aø�",0
               dc.b "E'�",0   ;144
               dc.b "ae‘",ORDER ;145
               dc.b "AE’",ORDER ;146
               dc.b "Ae’",ORDER
               dc.b "o^“",0   ;147
               dc.b 'o"”',0   ;148
               dc.b 'o¹”',0
               dc.b "o`•",0   ;149
               dc.b "u^–",0   ;150
               dc.b "u`—",0   ;151
               dc.b 'y"˜',0   ;152
               dc.b 'y¹˜',0
               dc.b 'O"™',0   ;153
               dc.b 'O¹™',0
               dc.b 'U"š',0   ;154
               dc.b 'U¹š',0
               dc.b "c/›",0   ;155
               dc.b "C/›",0
               dc.b "c|›",0
               dc.b "C|›",0
               dc.b "L_œ",0   ;156
               dc.b "L-œ",0
               dc.b "l-œ",0
               dc.b "l_œ",0
               dc.b "Y-�",0   ;157 Yen
               dc.b "y-�",0
               dc.b "Y=�",0
               dc.b "y=�",0
               dc.b "ssž",0   ;158 German Eszet
               dc.b "f-Ÿ",0   ;159 Florin
               dc.b "a' ",0   ;160
               dc.b "i'¡",0   ;161
               dc.b "o'¢",0   ;162
               dc.b "u'£",0   ;163
               dc.b "n~¤",0   ;164
               dc.b "N~¥",0   ;165
               dc.b "a_¦",0   ;166 a underscore (not NVDI)
               dc.b "a-¦",0
               dc.b "o_§",0   ;167 o underscore (not NVDI)
               dc.b "o-§",0
               dc.b "??¨",0   ;168
               dc.b "12«",ORDER ;171
               dc.b "14¬",ORDER ;172
               dc.b "!!­",0   ;173
               dc.b "<<®",0   ;174
               dc.b ">>¯",0   ;175
               dc.b "a~°",0   ;176
               dc.b "o~±",0   ;177
               dc.b "O/²",0   ;178
               dc.b "O|²",0
               dc.b "o/³",0   ;179
               dc.b "o|³",0
               dc.b "oe´",ORDER ;180
               dc.b "OEµ",ORDER ;181
               dc.b "Oeµ",ORDER
               dc.b "A`¶",0   ;182
               dc.b "A~·",0   ;183
               dc.b "O~¸",0   ;184
               dc.b '" ¹',0   ;185
               dc.b "` º",0   ;186
               dc.b "+ »",0   ;187
               dc.b "PP¼",0   ;188
               dc.b "pp¼",0
               dc.b "P|¼",0
               dc.b "p|¼",0
               dc.b "p/¼",0
               dc.b "P/¼",0
               dc.b "co½",0   ;189
               dc.b "CO½",0
               dc.b "ro¾",0   ;190
               dc.b "RO¾",0
               dc.b "tm¿",0   ;191
               dc.b "TM¿",0
; dc.b "ijÀ",0  ;ij ligature not defined in NVDI 3 mapping
; dc.b "IJÁ",0  ;ij ligature not defined in NVDI 3 mapping
; dc.b "IjÁ",0
;************ NVDI 3 FontMap new chars
               dc.b "A^À",0   ;192 (NOT ij)
               dc.b "A'Á",0   ;193
               dc.b "E^Â",0   ;194
               dc.b 'E"Ã',0   ;195
               dc.b 'E¹Ã',0   ;195
               dc.b "E`Ä",0   ;196
               dc.b "I^Å",0   ;197
               dc.b 'I"Æ',0   ;198
               dc.b 'I¹Æ',0   ;198
               dc.b "I`Ç",0   ;199
               dc.b "I'È",0   ;200
               dc.b "O^É",0   ;201
               dc.b "O`Ê",0   ;202
               dc.b "O'Ë",0   ;203
               dc.b "U^Ì",0   ;204
               dc.b "U`Í",0   ;205
               dc.b "U'Î",0   ;206
               dc.b ",,Ï",0   ;207
               dc.b "``Ð",0   ;208
               dc.b "''Ñ",0   ;209
               dc.b ", Ò",0   ;210
               dc.b "' Ó",0   ;211
               dc.b "< Ô",0   ;212
               dc.b "> Õ",0   ;213
               dc.b "- Ö",0   ;214 dash medium
               dc.b "_ ×",0   ;215 dash long
               dc.b "PtØ",ORDER ;216 Peseta sign
               dc.b "PTØ",ORDER
               dc.b "ptØ",ORDER
               dc.b "upÙ",ORDER ;217
               dc.b "UPÙ",ORDER
               dc.b "dnÚ",ORDER ;218
               dc.b "DNÚ",ORDER
               dc.b "rtÛ",ORDER ;219
               dc.b "RTÛ",ORDER
               dc.b "ltÜ",ORDER ;220
               dc.b "LTÜ",ORDER
               dc.b "soÝ",ORDER ;221
               dc.b "SOÝ",ORDER
               dc.b "%oÞ",0   ;222
               dc.b "%.Þ",0
;************ Normale FontMap
               dc.b "ooß",ORDER ;223
               dc.b "OOß",ORDER
               dc.b "alà",ORDER ;224 alpha
               dc.b "ALà",ORDER
               dc.b "beá",ORDER ;225 beta
               dc.b "BEá",ORDER
               dc.b "gaâ",ORDER ;226 GAMMA
               dc.b "GAâ",ORDER
               dc.b "piã",ORDER ;227 pi
               dc.b "PIã",ORDER
               dc.b "SIä",ORDER ;228 SIGMA
               dc.b "SSä",ORDER
               dc.b "siå",ORDER ;229 sigma
               dc.b "u/æ",0   ;230 my
               dc.b "u|æ",0
               dc.b "myæ",ORDER
               dc.b "MYæ",ORDER
               dc.b "taç",ORDER ;231 tau
               dc.b "TAç",ORDER
               dc.b "phè",ORDER ;232 PHI
               dc.b "PHè",ORDER
               dc.b "O-é",0   ;233 THETA
               dc.b "THé",ORDER
               dc.b "thé",ORDER
               dc.b "OMê",ORDER ;234 OMEGA
               dc.b "omê",ORDER
               dc.b "deë",ORDER ;235 delta
               dc.b "=-ð",0   ;240
               dc.b "+-ñ",0   ;241
               dc.b ">-ò",0   ;242
               dc.b ">_ò",0
               dc.b ">=ò",0
               dc.b "<-ó",0   ;243
               dc.b "<_ó",0
               dc.b "<=ó",0
               dc.b ":-ö",0   ;246
               dc.b "=~÷",0   ;247
               dc.b "o ø",0   ;248
               dc.b "* ù",0   ;249
               dc.b ". ú",0   ;250
               dc.b "v û",0   ;251
               dc.b "n ü",0   ;252
               dc.b "2 ý",0   ;253
               dc.b "3 þ",0   ;254
               dc.b "_ ÿ",0   ;255
               dc.l 0         ;total 193 Eintr„ge

COMPTABSIZE    equ (*-comptab)/4-1

MAXTABSIZE     equ 256

               if COMPTABSIZE>MAXTABSIZE
               fail 'Composetab zu lang.'
               endc

*
* Platz f�r weitere Tastaturtabellen:
*

tab_unshift:   ds.b 128
tab_shift:     ds.b 128
tab_caps:      ds.b 128
tab_compose:   ds.l MAXTABSIZE ;1 KByte sollte reichen ( 256 Kombinationen )
emstop:        dc.l 0

* Saveptr - AREA!
               ds.w 46        ; 2 aufrufe...
newarea:
               endpart
