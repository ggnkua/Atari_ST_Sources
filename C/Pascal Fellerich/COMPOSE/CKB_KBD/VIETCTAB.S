* COMPOSE-Tabelle f�r VIETCAL!
* ----------------------------
* erstellt 26.1.1992 @pf68030
*
               dc.b "A1€",0
               dc.b "A2�",0
               dc.b "A3‚",0
               dc.b "A4ƒ",0
               dc.b "A5„",0
               dc.b "A6€",0
               dc.b "A7�",0
               dc.b "A8‚",0
               dc.b "A9ƒ",0
               dc.b "A0„",0
               dc.b "AA…",0
               dc.b "…1†",0
               dc.b "…2‡",0
               dc.b "…3ˆ",0
               dc.b "…4‰",0
               dc.b "…5Š",0
               dc.b "…6†",0
               dc.b "…7‡",0
               dc.b "…8ˆ",0
               dc.b "…9‰",0
               dc.b "…0Š",0
               dc.b "AS‹",0
               dc.b "‹1Œ",0
               dc.b "‹2�",0
               dc.b "‹3Ž",0
               dc.b "‹4�",0
               dc.b "‹5�",0
               dc.b "‹6Œ",0
               dc.b "‹7�",0
               dc.b "‹8Ž",0
               dc.b "‹9�",0
               dc.b "‹0�",0
               dc.b "E1‘",0
               dc.b "E2’",0
               dc.b "E3“",0
               dc.b "E4”",0
               dc.b "E5•",0
               dc.b "E6‘",0
               dc.b "E7’",0
               dc.b "E8“",0
               dc.b "E9”",0
               dc.b "E0•",0
               dc.b "EE–",0
               dc.b "–1—",0
               dc.b "–2˜",0
               dc.b "–3™",0
               dc.b "–4š",0
               dc.b "–5›",0
               dc.b "–6—",0
               dc.b "–7˜",0
               dc.b "–8™",0
               dc.b "–9š",0
               dc.b "–0›",0
               dc.b "I1œ",0
               dc.b "I2�",0
               dc.b "I3ž",0
               dc.b "I4Ÿ",0
               dc.b "I5 ",0
               dc.b "I6œ",0
               dc.b "I7�",0
               dc.b "I8ž",0
               dc.b "I9Ÿ",0
               dc.b "I0 ",0
               dc.b "O1¡",0
               dc.b "O2¢",0
               dc.b "O3£",0
               dc.b "O4¤",0
               dc.b "O5¥",0
               dc.b "O6¡",0
               dc.b "O7¢",0
               dc.b "O8£",0
               dc.b "O9¤",0
               dc.b "O0¥",0
               dc.b "OO¦",0
               dc.b "¦1§",0
               dc.b "¦2¨",0
               dc.b "¦3©",0
               dc.b "¦4ª",0
               dc.b "¦5«",0
               dc.b "¦6§",0
               dc.b "¦7¨",0
               dc.b "¦8©",0
               dc.b "¦9ª",0
               dc.b "¦0«",0
               dc.b "U1¬",0
               dc.b "U2­",0
               dc.b "U3®",0
               dc.b "U4¯",0
               dc.b "U5°",0
               dc.b "U6¬",0
               dc.b "U7­",0
               dc.b "U8®",0
               dc.b "U9¯",0
               dc.b "U0°",0
               dc.b "Y1±",0
               dc.b "Y2²",0
               dc.b "Y3³",0
               dc.b "Y4´",0
               dc.b "Y5µ",0
               dc.b "Y6±",0
               dc.b "Y7²",0
               dc.b "Y8³",0
               dc.b "Y9´",0
               dc.b "Y0µ",0
               dc.b "\1¶",0
               dc.b "\2·",0
               dc.b "\3¸",0
               dc.b "\4¹",0
               dc.b "\5º",0
               dc.b "\6¶",0
               dc.b "\7·",0
               dc.b "\8¸",0
               dc.b "\9¹",0
               dc.b "\0º",0
               dc.b "]1»",0
               dc.b "]2¼",0
               dc.b "]3½",0
               dc.b "]4¾",0
               dc.b "]5¿",0
               dc.b "]6»",0
               dc.b "]7¼",0
               dc.b "]8½",0
               dc.b "]9¾",0
               dc.b "]0¿",0
               dc.b "a1À",0
               dc.b "a2Á",0
               dc.b "a3Â",0
               dc.b "a4Ã",0
               dc.b "a5Ä",0
               dc.b "a6À",0
               dc.b "a7Á",0
               dc.b "a8Â",0
               dc.b "a9Ã",0
               dc.b "a0Ä",0
               dc.b "aaÅ",0
               dc.b "Å1Æ",0
               dc.b "Å2Ç",0
               dc.b "Å3È",0
               dc.b "Å4É",0
               dc.b "Å5Ê",0
               dc.b "Å6Æ",0
               dc.b "Å7Ç",0
               dc.b "Å8È",0
               dc.b "Å9É",0
               dc.b "Å0Ê",0
               dc.b "asË",0
               dc.b "Ë1Ì",0
               dc.b "Ë2Í",0
               dc.b "Ë3Î",0
               dc.b "Ë4Ï",0
               dc.b "Ë5Ð",0
               dc.b "Ë6Ì",0
               dc.b "Ë7Í",0
               dc.b "Ë8Î",0
               dc.b "Ë9Ï",0
               dc.b "Ë0Ð",0
               dc.b "e1Ñ",0
               dc.b "e2Ò",0
               dc.b "e3Ó",0
               dc.b "e4Ô",0
               dc.b "e5Õ",0
               dc.b "e6Ñ",0
               dc.b "e7Ò",0
               dc.b "e8Ó",0
               dc.b "e9Ô",0
               dc.b "e0Õ",0
               dc.b "eeÖ",0
               dc.b "Ö1×",0
               dc.b "Ö2Ø",0
               dc.b "Ö3Ù",0
               dc.b "Ö4Ú",0
               dc.b "Ö5Û",0
               dc.b "Ö6×",0
               dc.b "Ö7Ø",0
               dc.b "Ö8Ù",0
               dc.b "Ö9Ú",0
               dc.b "Ö0Û",0
               dc.b "i1Ü",0
               dc.b "i2Ý",0
               dc.b "i3Þ",0
               dc.b "i4ß",0
               dc.b "i5à",0
               dc.b "i6Ü",0
               dc.b "i7Ý",0
               dc.b "i8Þ",0
               dc.b "i9ß",0
               dc.b "i0à",0
               dc.b "o1á",0
               dc.b "o2â",0
               dc.b "o3ã",0
               dc.b "o4ä",0
               dc.b "o5å",0
               dc.b "o6á",0
               dc.b "o7â",0
               dc.b "o8ã",0
               dc.b "o9ä",0
               dc.b "o0å",0
               dc.b "ooæ",0
               dc.b "æ1ç",0
               dc.b "æ2è",0
               dc.b "æ3é",0
               dc.b "æ4ê",0
               dc.b "æ5ë",0
               dc.b "æ6ç",0
               dc.b "æ7è",0
               dc.b "æ8é",0
               dc.b "æ9ê",0
               dc.b "æ0ë",0
               dc.b "u1ì",0
               dc.b "u2í",0
               dc.b "u3î",0
               dc.b "u4ï",0
               dc.b "u5ð",0
               dc.b "u6ì",0
               dc.b "u7í",0
               dc.b "u8î",0
               dc.b "u9ï",0
               dc.b "u0ð",0
               dc.b "y1ñ",0
               dc.b "y2ò",0
               dc.b "y3ó",0
               dc.b "y4ô",0
               dc.b "y5õ",0
               dc.b "y6ñ",0
               dc.b "y7ò",0
               dc.b "y8ó",0
               dc.b "y9ô",0
               dc.b "y0õ",0
               dc.b "|1ö",0
               dc.b "|2÷",0
               dc.b "|3ø",0
               dc.b "|4ù",0
               dc.b "|5ú",0
               dc.b "|6ö",0
               dc.b "|7÷",0
               dc.b "|8ø",0
               dc.b "|9ù",0
               dc.b "|0ú",0
               dc.b "}1û",0
               dc.b "}2ü",0
               dc.b "}3ý",0
               dc.b "}4þ",0
               dc.b "}5ÿ",0
               dc.b "}6û",0
               dc.b "}7ü",0
               dc.b "}8ý",0
               dc.b "}9þ",0
               dc.b "}0ÿ",0
               dc.l 0
;------------
