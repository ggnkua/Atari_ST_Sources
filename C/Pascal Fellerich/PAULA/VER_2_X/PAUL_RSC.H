/* Resource Datei Indizes f�r PAUL_RSC */

#define PAULA    0   /* Formular/Dialog */
#define WINTERPOLATE 2   /* BUTTON in Baum PAULA */
#define WBOOST   4   /* BUTTON in Baum PAULA */
#define WREPEAT  5   /* BUTTON in Baum PAULA */
#define WCOMPAT  6   /* BUTTON in Baum PAULA */
#define WSHUFFLE 7   /* BUTTON in Baum PAULA */
#define WSWAPCHANNEL 8   /* BUTTON in Baum PAULA */
#define WSAMPLE_LOW 10  /* BUTTON in Baum PAULA */
#define WSAMPLE_MED 11  /* BUTTON in Baum PAULA */
#define WSAMPLE_HI 12  /* BUTTON in Baum PAULA */
#define WCPU_SLPARENT 16  /* BOX in Baum PAULA */
#define WCPU_SLCHILD 17  /* BOX in Baum PAULA */
#define WCPU_OVERLOAD 18  /* BOX in Baum PAULA */
#define WCOUNTER 23  /* FTEXT in Baum PAULA */
#define WLOAD    26  /* ICON in Baum PAULA */
#define WSTOP    27  /* ICON in Baum PAULA */
#define WPLAY    28  /* ICON in Baum PAULA */
#define WPAUSE   29  /* ICON in Baum PAULA */
#define WREWIND  30  /* ICON in Baum PAULA */
#define WFASTFORWARD 31  /* ICON in Baum PAULA */
#define WSETUP   32  /* BOXTEXT in Baum PAULA */
#define WINFO    33  /* BOXTEXT in Baum PAULA */

#define EXTRAS   1   /* Formular/Dialog */
#define XPITCH_DOWN 3   /* BOXCHAR in Baum EXTRAS */
#define XPITCH_DATA 4   /* BOXTEXT in Baum EXTRAS */
#define XPITCH_UP 5   /* BOXCHAR in Baum EXTRAS */
#define XTRANSPOSE_DOWN 7   /* BOXCHAR in Baum EXTRAS */
#define XTRANSPOSE_DATA 8   /* BOXTEXT in Baum EXTRAS */
#define XTRANSPOSE_UP 9   /* BOXCHAR in Baum EXTRAS */
#define XSPEED_DOWN 11  /* BOXCHAR in Baum EXTRAS */
#define XSPEED_DATA 12  /* BOXTEXT in Baum EXTRAS */
#define XSPEED_UP 13  /* BOXCHAR in Baum EXTRAS */
#define XSAVE    14  /* BUTTON in Baum EXTRAS */
#define XEXIT    15  /* BUTTON in Baum EXTRAS */
#define XRESET   16  /* BUTTON in Baum EXTRAS */

#define P_INFO   2   /* Formular/Dialog */
#define I_KEYCHECK 5   /* BOX in Baum P_INFO */
#define I_OK     11  /* BUTTON in Baum P_INFO */

#define IMAGES   3   /* Formular/Dialog */
#define SELBUTTON_NORM 1   /* IMAGE in Baum IMAGES */
#define SELBUTTON_SELECT 2   /* IMAGE in Baum IMAGES */
#define RADIOBUT_NORM 3   /* IMAGE in Baum IMAGES */
#define RADIOBUT_SEL 4   /* IMAGE in Baum IMAGES */

#define IMAGESMED 4   /* Formular/Dialog */
