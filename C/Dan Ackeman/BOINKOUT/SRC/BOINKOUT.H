
#define MENU               0 	/* TREE - MENU   */
#define ABOUT_BOINK        9 	/* G_STRING in (#0) MENU */
#define M_NEW             18 	/* G_STRING in (#0) MENU */
#define M_JUMP            20 	/* G_STRING in (#0) MENU */
#define M_PAUSE           21 	/* G_STRING in (#0) MENU */
#define M_QUIT            23 	/* G_STRING in (#0) MENU */
#define M_SETCOLORS       25 	/* G_STRING in (#0) MENU */
#define M_TIMING          26 	/* G_STRING in (#0) MENU */
#define M_LOAD            27 	/* G_STRING in (#0) MENU */
#define M_LEVEL           29 	/* G_STRING in (#0) MENU */
#define M_VIEWSCORES      31 	/* G_STRING in (#0) MENU */
#define M_SOUNDSWITCH     33 	/* G_STRING in (#0) MENU */
#define M_SAVEPREF        35 	/* G_STRING in (#0) MENU */
#define M_HELP            37 	/* G_STRING in (#0) MENU */

#define ABOUT              1 	/* TREE - DIALOG */
#define RTITLE             1 	/* G_IMAGE in (#1) ABOUT */
#define R_VERSION          7 	/* G_TEXT in (#1) ABOUT */
#define R_URL              9 	/* G_TEXT in (#1) ABOUT */

#define TIMING             2 	/* TREE - DIALOG */
#define TIMING_VALUE       1 	/* G_FTEXT in (#2) TIMING */
#define B_SETTIME          5 	/* G_BUTTON in (#2) TIMING */
#define B_TIMING_CANCEL    6 	/* G_BUTTON in (#2) TIMING */

#define HIGHSCORE          3 	/* TREE - DIALOG */
#define D_ENTERNAME        3 	/* G_FTEXT in (#3) HIGHSCORE */
#define B_HIGHSCORE_OK     4 	/* G_BUTTON in (#3) HIGHSCORE */

#define SCORELIST          4 	/* TREE - DIALOG */
#define SCORETITLE         1 	/* G_TEXT in (#4) SCORELIST */
#define SCORE1             2 	/* G_TEXT in (#4) SCORELIST */
#define SCORE2             3 	/* G_TEXT in (#4) SCORELIST */
#define SCORE3             4 	/* G_TEXT in (#4) SCORELIST */
#define SCORE4             5 	/* G_TEXT in (#4) SCORELIST */
#define SCORE5             6 	/* G_TEXT in (#4) SCORELIST */
#define SCORE6             7 	/* G_TEXT in (#4) SCORELIST */
#define SCORE7             8 	/* G_TEXT in (#4) SCORELIST */
#define SCORE8             9 	/* G_TEXT in (#4) SCORELIST */
#define SCORE9            10 	/* G_TEXT in (#4) SCORELIST */
#define SCORE10           11 	/* G_TEXT in (#4) SCORELIST */

#define LOADING            5 	/* TREE - DIALOG */
#define RIMG_COUNT         2 	/* G_TEXT in (#5) LOADING */

#define ICONS              6 	/* TREE - DIALOG */
#define ICON1              1 	/* G_ICON in (#6) ICONS */

#define JUMPLEVEL          7 	/* TREE - DIALOG */
#define JUMP_GO            2 	/* G_BUTTON in (#7) JUMPLEVEL */
#define JUMP_LEVEL_NAME    6 	/* G_TEXT in (#7) JUMPLEVEL */
#define JUMP_LEVEL_NUM     7 	/* G_TEXT in (#7) JUMPLEVEL */
#define JUMP_SELECT        9 	/* G_FTEXT in (#7) JUMPLEVEL */

#define OBJCOLORS          8 	/* TREE - DIALOG */
#define DSETCOLOR          1 	/* G_BUTTON in (#8) OBJCOLORS */
#define DPADCOLOR          2 	/* G_BUTTON in (#8) OBJCOLORS */
#define DBALLCOLOR         3 	/* G_BUTTON in (#8) OBJCOLORS */
#define DBRICKCOLOR        4 	/* G_BUTTON in (#8) OBJCOLORS */
#define DPERMCOLOR         5 	/* G_BUTTON in (#8) OBJCOLORS */
#define DMAGICCOLOR        6 	/* G_BUTTON in (#8) OBJCOLORS */
#define DCOLORBOX          7 	/* G_BOX in (#8) OBJCOLORS */
#define COLOR1             8 	/* G_BOX in (#8) OBJCOLORS */
#define COLOR2             9 	/* G_BOX in (#8) OBJCOLORS */
#define COLOR3            10 	/* G_BOX in (#8) OBJCOLORS */
#define COLOR4            11 	/* G_BOX in (#8) OBJCOLORS */
#define COLOR5            12 	/* G_BOX in (#8) OBJCOLORS */
#define DSPINCOLOR        13 	/* G_BUTTON in (#8) OBJCOLORS */
#define COLOR6            14 	/* G_BOX in (#8) OBJCOLORS */
#define ALERT_NOSCOR       0 	/* STRING */
#define ALERT_CANTCREATE   1 	/* STRING */
#define ALERT_CANTFIND     2 	/* STRING */
#define ALERT_INVALID      3 	/* STRING */
