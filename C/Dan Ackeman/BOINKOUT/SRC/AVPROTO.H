#define AV_PROTOKOLL		0x4700
#define AV_SENDKEY			0x4710
#define VA_START			0x4711
#define AV_EXIT				0x4736
#define AV_STARTED			0x4738
