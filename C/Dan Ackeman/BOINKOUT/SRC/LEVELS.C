/*********************************************
	mask for puzzles
	meanings:
		0	nothing
		1	normal
		2	magic
		3	spin, 1 hit
		4	spin, 2 hit
		5	spin, 3 hit
		6	spin, 4 hit
		9   permanent
*********************************************/
char intbrickmask[][63] = {
	 1, 1, 1, 1, 1, 1, 1, 1, 1,			/* 1 */
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,

	 1, 1, 1, 1, 1, 1, 1, 1, 1,			/* 2 */
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 9, 1, 9, 1, 9, 1, 9, 1, 9,
	 1, 1, 1, 4, 1, 4, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 2, 1, 1, 1, 2, 1, 1,

	 1, 4, 1, 1, 2, 1, 1, 4, 1,			/* 3 */
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 2, 1, 0, 1, 2, 1, 1,
	 1, 2, 1, 4, 1, 4, 1, 2, 1,
	 1, 1, 1, 1, 2, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,

	 2, 2, 2, 2, 4, 2, 2, 2, 2,			/* 4 */
	 1, 1, 1, 4, 1, 4, 1, 1, 1,
	 1, 1, 4, 1, 1, 1, 4, 1, 1,
	 1, 4, 1, 1, 0, 1, 1, 4, 1,
	 1, 1, 2, 1, 9, 1, 2, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,

	 1, 1, 2, 1, 2, 1, 2, 1, 1,			/* 5 */
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 9, 1, 1, 1, 9, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 2, 1, 1, 2, 1, 2, 1, 1, 2,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 5, 1, 1, 1, 1, 1, 1, 1, 5,

	 2, 1, 1, 1, 1, 1, 1, 1, 2,			/* 6 */
	 1, 1, 1, 1, 9, 1, 1, 1, 1,
	 1, 1, 2, 1, 1, 1, 2, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 9, 1, 1, 4, 4, 4, 1, 1, 9,
	 1, 1, 1, 2, 1, 2, 1, 1, 1,
	 6, 6, 1, 1, 1, 1, 1, 6, 6,

	 1, 1, 1, 2, 2, 2, 1, 1, 1,			/* 7 */
	 1, 1, 9, 4, 4, 4, 9, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 3, 1, 1, 1, 3, 1, 1, 1, 3,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 2, 9, 1, 2, 1, 9, 2, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,

	 1, 1, 0, 2, 1, 2, 0, 1, 1,			/* 8 */
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 9, 1, 1, 9, 1, 1, 9, 1,
	 1, 1, 1, 9, 1, 9, 1, 1, 1,
	 2, 2, 2, 2, 2, 2, 2, 2, 2,
	 5, 5, 0, 5, 5, 5, 0, 5, 5,

	 1, 1, 5, 1, 2, 1, 5, 1, 1,			/* 9 */
	 1, 1, 5, 1, 1, 1, 5, 1, 1,
	 1, 1, 9, 1, 1, 1, 9, 1, 1,
	 1, 1, 9, 1, 1, 1, 9, 1, 1,
	 2, 1, 9, 1, 9, 1, 9, 1, 2,
	 1, 1, 9, 2, 1, 2, 9, 1, 1,
	 1, 1, 9, 9, 6, 9, 9, 1, 1,

	 1, 1, 2, 1, 2, 1, 2, 1, 1,			/* 10 */
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 9, 1, 1, 1, 9, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 6, 1, 1, 1, 6, 1, 1,
	 5, 1, 2, 2, 1, 2, 2, 1, 5,

	 0, 6, 0, 9, 9, 9, 9, 9, 9,			/* 11 */
	 1, 0, 6, 0, 1, 2, 1, 2, 1,
	 1, 1, 0, 6, 0, 1, 4, 1, 1,
	 1, 4, 1, 0, 6, 0, 1, 4, 1,
	 1, 1, 1, 1, 0, 6, 0, 1, 1,
	 1, 2, 1, 2, 1, 0, 6, 0, 1,
	 9, 9, 9, 9, 9, 9, 0, 6, 0,

	 1, 1, 1, 1, 5, 1, 1, 1, 1,			/* 12 */
	 1, 1, 2, 1, 9, 1, 2, 1, 1,
	 1, 1, 1, 1, 9, 1, 1, 1, 1,
	 4, 9, 9, 9, 0, 9, 9, 9, 4,
	 1, 1, 1, 1, 9, 1, 1, 1, 1,
	 1, 1, 2, 1, 9, 1, 2, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,

	 1, 2, 2, 2, 1, 2, 2, 2, 1,			/* 13 */
	 1, 4, 9, 4, 1, 4, 9, 4, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 9, 1, 1, 1, 1,
	 1, 1, 9, 1, 1, 1, 9, 1, 1,
	 1, 1, 1, 9, 9, 9, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,

	 9, 9, 9, 9, 9, 9, 9, 9, 9,			/* 14 */
	 2, 9, 2, 9, 2, 9, 2, 9, 2,
	 4, 9, 1, 9, 4, 9, 1, 9, 4,
	 2, 9, 1, 9, 1, 9, 1, 9, 2,
	 1, 9, 1, 9, 1, 9, 1, 9, 1,
	 1, 9, 1, 1, 1, 1, 1, 9, 1,
	 1, 9, 1, 1, 2, 1, 1, 9, 1,

	 5, 1, 2, 4, 1, 2, 5, 1, 2,			/* 15 */
	 1, 9, 4, 1, 9, 5, 1, 9, 4,
	 2, 4, 1, 2, 5, 1, 2, 4, 1,
	 4, 1, 9, 5, 1, 9, 4, 1, 9,
	 1, 2, 5, 1, 2, 4, 1, 2, 5,
	 9, 5, 1, 9, 4, 1, 9, 5, 1,
	 5, 1, 2, 4, 1, 2, 5, 1, 2,

	 2, 4, 1, 1, 2, 1, 1, 4, 2,			/* 16 */
	 1, 9, 1, 9, 1, 9, 1, 9, 1,
	 1, 9, 1, 9, 1, 9, 1, 9, 1,
	 1, 9, 1, 9, 1, 9, 1, 9, 1,
	 1, 9, 1, 1, 1, 1, 1, 9, 1,
	 1, 9, 2, 9, 1, 9, 2, 9, 1,
	 1, 9, 9, 9, 0, 9, 9, 9, 1,

	 9, 9, 9, 9, 0, 1, 1, 2, 2,			/* 17 */
	 2, 2, 1, 1, 0, 4, 1, 1, 2,
	 1, 1, 1, 1, 1, 1, 1, 2, 2,
	 1, 1, 9, 9, 9, 9, 9, 9, 9,
	 1, 1, 1, 1, 0, 2, 1, 2, 1,
	 2, 2, 1, 1, 0, 1, 2, 1, 2,
	 9, 9, 9, 9, 9, 9, 9, 1, 1,

	 6, 1, 6, 2, 2, 2, 6, 1, 6,			/* 18 */
	 1, 6, 1, 6, 1, 6, 1, 6, 1,
	 6, 1, 6, 1, 6, 1, 6, 1, 6,
	 1, 6, 1, 6, 1, 6, 1, 6, 1,
	 1, 1, 6, 1, 6, 1, 6, 1, 1,
	 1, 1, 1, 9, 1, 9, 1, 1, 1,
	 2, 1, 9, 1, 6, 1, 9, 1, 2,

	 2, 1, 1, 6, 1, 6, 1, 1, 2,			/* 19 */
	 1, 1, 1, 6, 9, 6, 1, 1, 1,
	 1, 1, 1, 6, 1, 6, 1, 1, 1,
	 1, 1, 1, 6, 1, 6, 1, 1, 1,
	 9, 2, 1, 4, 4, 4, 1, 2, 9,
	 1, 1, 2, 1, 1, 1, 2, 1, 1,
	 6, 9, 1, 2, 1, 2, 1, 9, 6,

	 1, 1, 1, 2, 2, 2, 1, 1, 1,			/* 20 */
	 1, 1, 9, 4, 4, 4, 9, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 2, 2, 9, 2, 2, 2, 9, 2, 2,
	 6, 6, 6, 6, 6, 6, 6, 6, 6,

	 1, 1, 0, 1, 6, 1, 0, 1, 1,			/* 21 */
	 1, 1, 1, 1, 6, 1, 1, 1, 1,
	 1, 1, 1, 1, 6, 1, 1, 1, 1,
	 1, 9, 1, 1, 9, 1, 1, 9, 1,
	 2, 2, 2, 9, 2, 9, 2, 2, 2,
	 2, 2, 2, 2, 2, 2, 2, 2, 2,
	 5, 5, 0, 5, 5, 5, 0, 5, 5,

	 1, 1, 5, 1, 1, 1, 5, 1, 1,			/* 22 */
	 1, 1, 5, 1, 1, 1, 5, 1, 1,
	 2, 2, 9, 1, 1, 1, 9, 2, 2,
	 9, 2, 9, 1, 1, 1, 9, 2, 9,
	 6, 6, 9, 1, 9, 1, 9, 6, 6,
	 4, 5, 9, 2, 1, 2, 9, 5, 4,
	 5, 3, 9, 9, 6, 9, 9, 3, 5,

	 1, 1, 1, 1, 0, 1, 1, 1, 1,			/* 23 */
	 2, 1, 1, 1, 0, 1, 1, 1, 2,
	 2, 2, 1, 1, 1, 1, 1, 2, 2,
	 1, 1, 9, 9, 9, 9, 9, 1, 1,
	 1, 1, 1, 1, 0, 1, 1, 1, 1,
	 4, 4, 2, 1, 0, 1, 2, 4, 4,
	 9, 5, 9, 5, 9, 5, 9, 5, 9,

	 1, 6, 1, 2, 9, 2, 1, 6, 1,			/* 24 */
	 1, 1, 1, 9, 9, 9, 1, 1, 1,
	 1, 1, 1, 1, 9, 1, 1, 1, 1,
	 4, 1, 1, 9, 9, 9, 1, 1, 4,
	 1, 1, 1, 1, 9, 1, 1, 1, 1,
	 1, 1, 1, 9, 9, 9, 1, 1, 1,
	 1, 6, 1, 2, 9, 2, 1, 6, 1,

	 1, 4, 2, 4, 9, 4, 2, 4, 1,			/* 25 */
	 4, 1, 4, 2, 9, 2, 4, 1, 4,
	 2, 4, 1, 4, 9, 4, 1, 4, 2,
	 9, 9, 9, 5, 5, 5, 9, 9, 9,
	 2, 4, 1, 4, 5, 4, 1, 4, 2,
	 4, 1, 4, 2, 9, 2, 4, 1, 4,
	 1, 4, 2, 4, 9, 4, 2, 4, 1,

	 9, 9, 1, 4, 9, 4, 1, 9, 9,			/* 26 */
	 4, 1, 1, 1, 9, 1, 1, 1, 4,
	 4, 1, 1, 1, 4, 1, 1, 1, 4,
	 9, 4, 1, 9, 9, 9, 1, 4, 9,
	 4, 4, 1, 1, 5, 1, 1, 4, 4,
	 2, 4, 1, 1, 1, 1, 1, 4, 2,
	 2, 9, 1, 9, 9, 9, 1, 9, 2,

	 2, 4, 4, 4, 9, 4, 4, 4, 2,			/* 27 */
	 1, 2, 1, 4, 9, 4, 1, 2, 1,
	 3, 9, 4, 2, 9, 2, 4, 9, 3,
	 1, 4, 1, 4, 9, 4, 1, 4, 1,
	 6, 6, 9, 2, 9, 2, 9, 6, 6,
	 2, 3, 9, 9, 9, 9, 9, 3, 2,
	 3, 2, 3, 2, 3, 2, 3, 2, 3,

	 2, 1, 6, 2, 1, 6, 2, 1, 5,			/* 28 */
	 6, 9, 1, 6, 9, 1, 6, 9, 1,
	 1, 6, 2, 1, 6, 2, 1, 6, 2,
	 9, 1, 6, 9, 0, 6, 9, 1, 6,
	 6, 2, 1, 6, 2, 1, 6, 2, 1,
	 1, 6, 9, 1, 6, 9, 1, 6, 9,
	 2, 5, 6, 2, 5, 6, 2, 5, 6,

	 1, 1, 1, 9, 1, 9, 1, 1, 1,			/* 29 */
	 1, 1, 9, 1, 6, 1, 9, 1, 1,
	 2, 1, 1, 1, 1, 1, 1, 1, 2,
	 9, 2, 1, 1, 1, 1, 1, 2, 9,
	 1, 9, 2, 1, 1, 1, 2, 9, 1,
	 1, 1, 9, 2, 5, 2, 9, 1, 1,
	 6, 6, 6, 9, 6, 9, 6, 6, 6,

	 2, 9, 1, 1, 0, 1, 1, 9, 2,			/* 30 */
	 9, 5, 1, 5, 1, 5, 1, 5, 9,
	 1, 5, 1, 1, 1, 1, 1, 5, 1,
	 2, 5, 1, 9, 2, 9, 1, 5, 2,
	 1, 5, 1, 1, 9, 1, 1, 5, 1,
	 6, 9, 2, 1, 1, 1, 2, 9, 6,
	 9, 6, 6, 6, 2, 6, 6, 6, 9,

	 1, 1, 1, 4, 6, 4, 1, 1, 1,			/* 31 */
	 4, 4, 9, 9, 6, 9, 9, 4, 4,
	 1, 1, 9, 5, 2, 5, 9, 1, 1,
	 1, 1, 9, 5, 1, 5, 9, 1, 1,
	 6, 6, 9, 5, 2, 5, 9, 3, 3,
	 4, 4, 9, 9, 9, 9, 9, 4, 4,
	 2, 1, 1, 1, 2, 1, 1, 1, 2,

	 6, 6, 6, 6, 6, 6, 6, 6, 6,			/* 32 */
	 6, 1, 1, 1, 1, 1, 1, 1, 6,
	 6, 1, 6, 6, 6, 6, 6, 1, 6,
	 6, 9, 6, 2, 2, 2, 6, 9, 6,
	 6, 1, 6, 6, 6, 6, 6, 1, 6,
	 6, 1, 1, 1, 9, 1, 1, 1, 6,
	 9, 6, 6, 6, 6, 6, 6, 6, 9,

	 1, 9, 1, 9, 1, 9, 1, 9, 1,			/* 33 */
	 1, 9, 1, 9, 1, 9, 1, 9, 1,
	 2, 6, 1, 1, 6, 1, 1, 6, 2,
	 9, 9, 1, 9, 9, 9, 1, 9, 9,
	 1, 1, 1, 1, 1, 1, 1, 1, 1,
	 1, 1, 1, 1, 2, 1, 1, 1, 1,
	 5, 9, 9, 9, 5, 9, 9, 9, 5,

	 1, 4, 1, 9, 2, 9, 1, 4, 1,			/* 34 */
	 1, 1, 1, 9, 5, 9, 1, 1, 1,
	 1, 9, 9, 9, 1, 9, 9, 9, 1,
	 1, 1, 2, 9, 4, 9, 2, 1, 1,
	 1, 2, 1, 9, 1, 9, 1, 2, 1,
	 9, 9, 1, 9, 2, 9, 1, 9, 9,
	 6, 6, 6, 9, 6, 9, 6, 6, 6,

	 6, 1, 9, 1, 6, 1, 9, 1, 6,			/* 35 */
	 1, 9, 9, 9, 1, 9, 9, 9, 1,
	 1, 1, 9, 1, 1, 1, 9, 1, 1,
	 1, 9, 9, 9, 1, 9, 9, 9, 1,
	 1, 1, 9, 1, 1, 1, 9, 1, 1,
	 1, 9, 9, 9, 1, 9, 9, 9, 1,
	 6, 1, 9, 1, 6, 1, 9, 1, 6,

	 0, 0, 6, 6, 0, 6, 6, 0, 0,			/* 36 */
	 0, 6, 9, 9, 6, 9, 9, 6, 0,
	 0, 6, 9, 9, 9, 9, 9, 6, 0,
	 0, 6, 9, 9, 9, 9, 9, 6, 0,
	 0, 0, 6, 9, 9, 9, 6, 0, 0,
	 0, 0, 0, 6, 9, 6, 0, 0, 0,
	 0, 0, 0, 0, 6, 0, 0, 0, 0,

	};
