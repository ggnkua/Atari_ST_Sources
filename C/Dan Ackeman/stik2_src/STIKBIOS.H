/* STiK BIOS bindings */

#ifndef _STIKBIOS_H_
#define _STIKBIOS_H_

void SBconout( int dev, int c );
long SBcostat( int dev );

#endif