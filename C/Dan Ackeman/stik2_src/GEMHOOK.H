extern void ST_GEMDOS(void);
extern void TT_GEMDOS(void);
extern void TRP5SIM(void);
extern void (*OLD_GEMDOS)(void);
extern void NET_TICK(void);
extern void (*OLD_TICK)(void);

extern int IP_SEM;