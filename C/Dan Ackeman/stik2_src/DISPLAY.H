#ifndef _DISPLAY_H_
#define _DISPLAY_H_

void disp_info( const char *fmt, ... );
#define disp_error disp_info

#endif
