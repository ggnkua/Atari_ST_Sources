#define ARBRE1 0        /* TREE */
#define CHIFFRE 2       /* OBJECT in TREE #0 */
#define ICONE 3         /* OBJECT in TREE #0 */
#define LANGUE 4        /* OBJECT in TREE #0 */
#define FINI 5          /* OBJECT in TREE #0 */
