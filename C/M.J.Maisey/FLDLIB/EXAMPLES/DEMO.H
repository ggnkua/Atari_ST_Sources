
#define	FORM1	    0

#define FM_DL2	    5
#define FM1_EXIT1	    7
#define FM1_EXIT2	    8

#define	FORM2	    1

#define FM2_OK	    3
