/* Resource Datei Indizes f�r INSTALLG */

#define FMAIN    0   /* Formular/Dialog */
#define DSPACE   2   /* TEXT in Baum FMAIN */
#define SOFTNAME 3   /* TEXT in Baum FMAIN */
#define SOFTINFO 4   /* TEXT in Baum FMAIN */
#define QUITTER  8   /* BUTTON in Baum FMAIN */
#define ACCEPTER 9   /* BUTTON in Baum FMAIN */
#define CODEVER  15  /* TEXT in Baum FMAIN */
#define DATEVER  16  /* TEXT in Baum FMAIN */
#define UNINSTALL 17  /* BUTTON in Baum FMAIN */

#define FPATH    1   /* Formular/Dialog */
#define ANNULER  1   /* BUTTON in Baum FPATH */
#define INSTALLER 2   /* BUTTON in Baum FPATH */
#define DESTINATION 6   /* FTEXT in Baum FPATH */
#define SOURCE   8   /* FTEXT in Baum FPATH */
#define PARCOURIR 9   /* BUTTON in Baum FPATH */

#define FWORK    2   /* Formular/Dialog */
#define CANCEL   1   /* BUTTON in Baum FWORK */
#define CONTINUE 2   /* BUTTON in Baum FWORK */
#define CURRPATH 5   /* FTEXT in Baum FWORK */
#define BOITEJAUGE 6   /* BOX in Baum FWORK */
#define JAUGE    7   /* BOX in Baum FWORK */
#define POURCENT 8   /* FBOXTEXT in Baum FWORK */
#define CHANGEDISK 9   /* BOXTEXT in Baum FWORK */

#define FSTART   3   /* Formular/Dialog */
#define OUI      1   /* BUTTON in Baum FSTART */
#define NON      2   /* BUTTON in Baum FSTART */
#define NAME2    4   /* TEXT in Baum FSTART */
#define EXECUTER 8   /* TEXT in Baum FSTART */

#define MESSAGES 4   /* Formular/Dialog */
#define MSG1     1   /* STRING in Baum MESSAGES */
#define MSG2     2   /* STRING in Baum MESSAGES */
#define MSG3     3   /* STRING in Baum MESSAGES */
#define MSG4     4   /* STRING in Baum MESSAGES */
#define MSG5     5   /* STRING in Baum MESSAGES */
#define MSG6     6   /* STRING in Baum MESSAGES */
#define MSG7     7   /* STRING in Baum MESSAGES */
#define MSG8     8   /* STRING in Baum MESSAGES */
#define MSG9     9   /* STRING in Baum MESSAGES */
#define MSG10    10  /* STRING in Baum MESSAGES */
#define MSG11    11  /* STRING in Baum MESSAGES */
#define MSG12    12  /* STRING in Baum MESSAGES */
#define MSG13    13  /* STRING in Baum MESSAGES */
#define MSG14    14  /* STRING in Baum MESSAGES */
#define MSG15    15  /* STRING in Baum MESSAGES */
#define MSG16    16  /* STRING in Baum MESSAGES */
#define MSG17    17  /* STRING in Baum MESSAGES */
#define MSG18    18  /* STRING in Baum MESSAGES */
#define MSG19    19  /* STRING in Baum MESSAGES */
#define MSG20    20  /* STRING in Baum MESSAGES */
#define MSG21    21  /* STRING in Baum MESSAGES */
#define MSG22    22  /* STRING in Baum MESSAGES */
#define MSG23    23  /* STRING in Baum MESSAGES */
#define MSG24    24  /* STRING in Baum MESSAGES */
#define MSG25    25  /* STRING in Baum MESSAGES */
#define MSG26    26  /* STRING in Baum MESSAGES */
#define MSG27    27  /* STRING in Baum MESSAGES */
#define MSG28    28  /* STRING in Baum MESSAGES */
#define MSG29    29  /* STRING in Baum MESSAGES */

#define FUNINST  5   /* Formular/Dialog */
#define JA       1   /* BUTTON in Baum FUNINST */
#define ABBRUCH  2   /* BUTTON in Baum FUNINST */
#define UNBOITE  6   /* BOX in Baum FUNINST */
#define UNJAUGE  7   /* BOX in Baum FUNINST */

#define BUREAU   6   /* Formular/Dialog */
#define FUNSHIP  8   /* IMAGE in Baum BUREAU */
