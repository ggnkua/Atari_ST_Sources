;
;       Winzling
;
        MOV     0,1
