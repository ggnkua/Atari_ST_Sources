start:
        SPL     move
        JMP     start
move    MOV     0, 1

