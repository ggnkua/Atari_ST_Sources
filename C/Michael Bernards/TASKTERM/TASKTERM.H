#define MAIN 0  	/* TREE */
#define RS232 1  	/* TREE */
#define SENDEN 10  	/* OBJECT in TREE #0 */
#define EMPFANG 11  	/* OBJECT in TREE #0 */
#define SETRS232 5  	/* OBJECT in TREE #0 */
#define SETTERM 6  	/* OBJECT in TREE #0 */
#define SETOTHER 7  	/* OBJECT in TREE #0 */
#define ENDE 13  	/* OBJECT in TREE #0 */
#define BAUDRIGT 20  	/* OBJECT in TREE #1 */
#define BAUDLEFT 19  	/* OBJECT in TREE #1 */
#define XONXOFF 3  	/* OBJECT in TREE #1 */
#define RTSCTS 4  	/* OBJECT in TREE #1 */
#define UNGERADE 7  	/* OBJECT in TREE #1 */
#define GERADE 8  	/* OBJECT in TREE #1 */
#define KEINE 9  	/* OBJECT in TREE #1 */
#define STOP1 14  	/* OBJECT in TREE #1 */
#define STOP15 15  	/* OBJECT in TREE #1 */
#define STOP2 16  	/* OBJECT in TREE #1 */
#define SETENDE 17  	/* OBJECT in TREE #1 */
#define TERMINAL 2  	/* TREE */
#define VOLL 4  	/* OBJECT in TREE #2 */
#define HALB 5  	/* OBJECT in TREE #2 */
#define LOKAL 6  	/* OBJECT in TREE #2 */
#define CR 9  	/* OBJECT in TREE #2 */
#define CRLF 10  	/* OBJECT in TREE #2 */
#define ASCII 13  	/* OBJECT in TREE #2 */
#define VT52 14  	/* OBJECT in TREE #2 */
#define VT100 15  	/* OBJECT in TREE #2 */
#define TERMENDE 16  	/* OBJECT in TREE #2 */
#define PROTOKOL 12  	/* OBJECT in TREE #0 */
#define MENUBAR 3  	/* TREE */
#define DESK 3  	/* OBJECT in TREE #3 */
#define DATEI 4  	/* OBJECT in TREE #3 */
#define ARBEIT 5  	/* OBJECT in TREE #3 */
#define MENURS 22  	/* OBJECT in TREE #3 */
#define MENUTERM 23  	/* OBJECT in TREE #3 */
#define MENUPROT 24  	/* OBJECT in TREE #3 */
#define MENUSONS 25  	/* OBJECT in TREE #3 */
#define MENUSEND 27  	/* OBJECT in TREE #3 */
#define MENUEMPF 28  	/* OBJECT in TREE #3 */
#define MENUVT 30  	/* OBJECT in TREE #3 */
#define ABOUT 8  	/* OBJECT in TREE #3 */
#define UEBER 4  	/* TREE */
#define BAUDRATE 18  	/* OBJECT in TREE #1 */
#define DATABITS 23  	/* OBJECT in TREE #1 */
#define BAUDTEXT 22  	/* OBJECT in TREE #1 */
#define DATA5 24  	/* OBJECT in TREE #1 */
#define DATA6 25  	/* OBJECT in TREE #1 */
#define DATA7 26  	/* OBJECT in TREE #1 */
#define DATA8 27  	/* OBJECT in TREE #1 */
#define TASKTERM 2  	/* OBJECT in TREE #0 */
#define SONSTIGE 5  	/* TREE */
#define SONENDE 2  	/* OBJECT in TREE #5 */
#define SICHERN 3  	/* OBJECT in TREE #5 */
#define LADEN 4  	/* OBJECT in TREE #5 */
#define MENULOAD 18  	/* OBJECT in TREE #3 */
#define MENUSAVE 19  	/* OBJECT in TREE #3 */
#define MENUENDE 17  	/* OBJECT in TREE #3 */
#define MODIAL 5  	/* OBJECT in TREE #5 */
#define MORESET 6  	/* OBJECT in TREE #5 */
#define MOCONNEC 7  	/* OBJECT in TREE #5 */
#define DODIAL 8  	/* OBJECT in TREE #5 */
#define NUMMERN 6  	/* TREE */
#define N1 1  	/* OBJECT in TREE #6 */
#define N2 2  	/* OBJECT in TREE #6 */
#define N3 3  	/* OBJECT in TREE #6 */
#define N4 4  	/* OBJECT in TREE #6 */
#define N5 5  	/* OBJECT in TREE #6 */
#define N6 6  	/* OBJECT in TREE #6 */
#define N7 7  	/* OBJECT in TREE #6 */
#define N8 8  	/* OBJECT in TREE #6 */
#define N9 9  	/* OBJECT in TREE #6 */
#define N10 10  	/* OBJECT in TREE #6 */
#define N11 11  	/* OBJECT in TREE #6 */
#define N12 12  	/* OBJECT in TREE #6 */
#define N13 13  	/* OBJECT in TREE #6 */
#define N14 14  	/* OBJECT in TREE #6 */
#define N15 15  	/* OBJECT in TREE #6 */
#define N16 16  	/* OBJECT in TREE #6 */
#define NAME1 17  	/* OBJECT in TREE #6 */
#define NAME2 18  	/* OBJECT in TREE #6 */
#define NAME3 19  	/* OBJECT in TREE #6 */
#define NAME12 28  	/* OBJECT in TREE #6 */
#define NAME13 29  	/* OBJECT in TREE #6 */
#define NAME14 30  	/* OBJECT in TREE #6 */
#define NAME15 31  	/* OBJECT in TREE #6 */
#define NAME16 32  	/* OBJECT in TREE #6 */
#define NAME4 20  	/* OBJECT in TREE #6 */
#define NAME5 21  	/* OBJECT in TREE #6 */
#define NAME6 22  	/* OBJECT in TREE #6 */
#define NAME7 23  	/* OBJECT in TREE #6 */
#define NAME8 24  	/* OBJECT in TREE #6 */
#define NAME9 25  	/* OBJECT in TREE #6 */
#define NAME10 26  	/* OBJECT in TREE #6 */
#define NAME11 27  	/* OBJECT in TREE #6 */
#define NUMMER1 33  	/* OBJECT in TREE #6 */
#define ABBRUCH 49  	/* OBJECT in TREE #6 */
#define NUMMER2 34  	/* OBJECT in TREE #6 */
#define NUMMER3 35  	/* OBJECT in TREE #6 */
#define NUMMER4 36  	/* OBJECT in TREE #6 */
#define NUMMER5 37  	/* OBJECT in TREE #6 */
#define NUMMER6 38  	/* OBJECT in TREE #6 */
#define NUMMER7 39  	/* OBJECT in TREE #6 */
#define NUMMER8 40  	/* OBJECT in TREE #6 */
#define NUMMER9 41  	/* OBJECT in TREE #6 */
#define NUMMER10 42  	/* OBJECT in TREE #6 */
#define NUMMER11 43  	/* OBJECT in TREE #6 */
#define NUMMER12 44  	/* OBJECT in TREE #6 */
#define NUMMER13 45  	/* OBJECT in TREE #6 */
#define NUMMER14 46  	/* OBJECT in TREE #6 */
#define NUMMER15 47  	/* OBJECT in TREE #6 */
#define NUMMER16 48  	/* OBJECT in TREE #6 */
#define FTASTEN 7  	/* TREE */
#define FT1 2  	/* OBJECT in TREE #7 */
#define FT2 3  	/* OBJECT in TREE #7 */
#define FT3 4  	/* OBJECT in TREE #7 */
#define FT4 5  	/* OBJECT in TREE #7 */
#define FT5 6  	/* OBJECT in TREE #7 */
#define FT6 7  	/* OBJECT in TREE #7 */
#define FT7 8  	/* OBJECT in TREE #7 */
#define FT8 9  	/* OBJECT in TREE #7 */
#define FT9 10  	/* OBJECT in TREE #7 */
#define FT10 11  	/* OBJECT in TREE #7 */
#define DOFTASTE 9  	/* OBJECT in TREE #5 */
#define TRANSFER 8  	/* TREE */
#define BLOCKNUM 3  	/* OBJECT in TREE #8 */
#define STATUS 5  	/* OBJECT in TREE #8 */
#define REDRAWTF 2  	/* OBJECT in TREE #8 */
#define RETRIES 4  	/* OBJECT in TREE #8 */
#define PROTO 9  	/* TREE */
#define PXMODEM 3  	/* OBJECT in TREE #9 */
#define PYMODEM 4  	/* OBJECT in TREE #9 */
#define PZMODEM 5  	/* OBJECT in TREE #9 */
#define PKERMIT 6  	/* OBJECT in TREE #9 */
#define PAUSGANG 8  	/* OBJECT in TREE #9 */
#define TIMEOUT 7  	/* OBJECT in TREE #9 */
#define BLOCKLEN 9  	/* OBJECT in TREE #9 */
#define CHKSUM 11  	/* OBJECT in TREE #9 */
#define CRC 12  	/* OBJECT in TREE #9 */
#define MULTIJA 18  	/* OBJECT in TREE #9 */
#define MULTINE 19  	/* OBJECT in TREE #9 */
#define DOBATCH 10  	/* OBJECT in TREE #5 */
#define PRIO 20  	/* OBJECT in TREE #9 */
#define PGROESSE 12  	/* OBJECT in TREE #5 */
#define PLOESCH 14  	/* OBJECT in TREE #5 */
#define BAUDAUTO 17  	/* OBJECT in TREE #5 */
#define BAUDMAN 18  	/* OBJECT in TREE #5 */
#define MSGBOX 10  	/* TREE */
#define BOXTEXT 1  	/* OBJECT in TREE #10 */
#define BLOCKGES 10  	/* OBJECT in TREE #8 */
#define UEBERSCH 1  	/* OBJECT in TREE #8 */
