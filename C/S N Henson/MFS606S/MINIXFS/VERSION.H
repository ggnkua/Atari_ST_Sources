/* Version of Minixfs */


#define MFS_MAJOR 0
#define MFS_MINOR 60
#define MFS_PLEV 6
