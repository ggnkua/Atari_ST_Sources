extern int opterr,optind;
extern char *optarg;
