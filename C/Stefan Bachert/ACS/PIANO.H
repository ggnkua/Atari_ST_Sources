/*

	This file was create with ACS 1.0 (c) Stefan Bachert 1991
	The contents is based on file: E:\ACS.DOC\PIANO\PIANO.ACS
	compiled at: Thu Jan 16 01:36:28 1992
*/


/*   STRINGS   */



/*   OBJECT TREES   */


extern OBJECT KEYS;


/*   WINDOWS   */

extern Awindow PIANO;


extern Adescr ACSdescr;

