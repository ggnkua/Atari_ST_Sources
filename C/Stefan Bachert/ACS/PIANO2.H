/*

	This file was create with ACS 1.0 (c) Stefan Bachert 1991
	The contents is based on file: E:\ACS.DOC\PIANO\PIANO2.ACS
	compiled at: Wed Jan 15 01:34:46 1992
*/


/*   STRINGS   */



/*   OBJECT TREES   */


extern OBJECT KEYS;


/*   WINDOWS   */

extern Awindow PIANO;


extern Adescr ACSdescr;

