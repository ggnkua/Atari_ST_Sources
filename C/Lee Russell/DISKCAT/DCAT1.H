
#define	FORM1	    0

#define MENU1	    0
#define TITLE	    1
#define QUIT1	    2
#define OK1	    3
#define ENTRYBOX	    4
#define ENTRY	    5
#define AADBOX	    6
#define ADD1	    7
#define AMEND1	    8
#define DELETE1	    9
#define QUERYBOX	   10
#define QUERY	   11
#define SFPBOX	   12
#define FINDSUBJ1	   13
#define FINDFOLD1	   14
#define FINDPROG1	   15
#define LISTDATA1	   16
#define FILEBOX	   17
#define FILECONTROL	   18
#define LSBOX	   19
#define LOADFILE1	   20
#define SAVEFILE1	   21
#define COPYRIGHT	   22

#define	FORM2	    1

#define ADDBOX1	    0
#define ADDBOX	    1
#define ADDTITLEBOX	    2
#define ADDDOBOX	    3
#define DISKNO2	    4
#define DISKSOURCE2	    5
#define SUBJECTCODE2	    6
#define FOLDERNAME2	    7
#define PROGRAMNAME2	    8
#define DESCRIPTION2	    9
#define RADIOBOXOUTER	   10
#define RADIOBOX	   11
#define OK2	   12
#define ABORT2	   13

#define	FORM3	    2

#define AMENDBOX1	    0
#define AMENDBOX	    1
#define AMENDRECORD	    2
#define AMENDDOBOX	    3
#define PROGRAMNAME3	    4
#define DISKNUMBER3	    5
#define DISKSOURCE3	    6
#define SUBJECTCODE3	    7
#define FOLDERNAME3	    8
#define DESCRIPTION3	    9
#define AMENDRADIOOUTER	   10
#define ABORT3	   11
#define OK3	   12

#define	FORM4	    3

#define DELETEBOX	    0
#define DELETERECORD	    1
#define DELETEDOBOX	    2
#define PROGRAMNAME4	    3
#define DELETERADIOOUTER	    4
#define ABORT4	    5
#define OK4	    6

#define	FORM5	    4

#define SUBJBOX	    0
#define FINDSUBJECT	    1
#define SUBJRADIOOUTER	    2
#define ABORT5	    3
#define OK5	    4
#define SUBJDOBOX	    5
#define SUBJECTCODE5	    6

#define	FORM6	    5

#define FOLDBOX1	    0
#define FOLDBOX	    1
#define FINDFOLDER	    2
#define FOLDDOBOX	    3
#define FOLDERNAME6	    4
#define FOLDRADIOOUTER	    5
#define ABORT6	    6
#define OK6	    7

#define	FORM7	    6

#define PROGBOX1	    0
#define PROGBOX	    1
#define FINDPROGRAM	    2
#define PROGDOBOX	    3
#define PROGRAMNAME7	    4
#define PROGRADIOOUTER	    5
#define ABORT7	    6
#define OK7	    7

#define	FORM8	    7

#define FINDBOX8	    0
#define FINDTITLE8	    1
#define OUTBOX8	    2
#define DISKNUMBER8	    3
#define SUBJECTCODE8	    4
#define DISKSOURCE8	    5
#define PROGRAMNAME8	    6
#define FOLDERNAME8	    7
#define DESCRIPTION8	    8
#define DISKNO8	    9
#define SUBJCODE8	   10
#define SOURCE8	   11
#define PROGNAME8	   12
#define FOLDNAME8	   13
#define DESCRIPT8	   14
#define SUBJDESCR8	   15
#define SLASH	   16
#define BUTTONBOX8	   17
#define NEXT	   18
#define PEXIT	   19
