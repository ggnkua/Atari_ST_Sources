
#define	FORM1	    0

#define background	    0
#define foreground	    1
#define TITLEBOX	    2
#define DOBOX	    3
#define SUBCODE	    4
#define SUBDESCR	    5
#define FILEBOX	    6
#define LOADFILE	    7
#define SAVEFILE	    8
#define EDITBOX	    9
#define EDIT	   10
#define QUIT	   11
#define OK	   12
#define COPYRIGHT	   13
