#define EINS 0  	/* TREE */
#define START 2  	/* OBJECT in TREE #0 */
#define ABBRUCH 3  	/* OBJECT in TREE #0 */
#define NORMAL 6  	/* OBJECT in TREE #0 */
#define DEGAS 7  	/* OBJECT in TREE #0 */
#define INFO 9  	/* OBJECT in TREE #0 */
