/* Resource Datei Indizes f�r DEMO */

#define MENUE1   0   /* Menuebaum */
#define ME_INFO  7   /* STRING in Baum MENUE1 */
#define ME_EDIT  16  /* STRING in Baum MENUE1 */
#define ME_QUIT  18  /* STRING in Baum MENUE1 */

#define M2MENU   1   /* Menuebaum */
#define M2_INFO  7   /* STRING in Baum M2MENU */
#define M2_QUIT  9   /* STRING in Baum M2MENU */

#define MAIN     2   /* Formular/Dialog */
#define MA_SYS   2   /* IMAGE in Baum MAIN */
#define MA_LAUF  3   /* IMAGE in Baum MAIN */
#define MA_MEM   4   /* IMAGE in Baum MAIN */
#define MA_VEK   5   /* IMAGE in Baum MAIN */
#define MA_COOK  6   /* IMAGE in Baum MAIN */
#define MA_XBRA  7   /* IMAGE in Baum MAIN */
#define MA_HD    8   /* IMAGE in Baum MAIN */
#define MA_GRAF  9   /* IMAGE in Baum MAIN */
#define MA_SGEM  10  /* IMAGE in Baum MAIN */
#define MA_WRT   11  /* IMAGE in Baum MAIN */
#define MA_POP1  15  /* BOXTEXT in Baum MAIN */
#define MA_POP2  16  /* BOXCHAR in Baum MAIN */
#define MA_LIST1 17  /* BOXTEXT in Baum MAIN */
#define MA_LIST2 18  /* BOXCHAR in Baum MAIN */
#define MA_BOX   19  /* BOX in Baum MAIN */
#define MA_UP    26  /* BOXCHAR in Baum MAIN */
#define MA_HIDE  27  /* BOX in Baum MAIN */
#define MA_SHOW  28  /* BOX in Baum MAIN */
#define MA_DN    32  /* BOXCHAR in Baum MAIN */

#define SPOPUP   3   /* Formular/Dialog */
#define SP_1     1   /* STRING in Baum SPOPUP */
#define SP_16    16  /* TEXT in Baum SPOPUP */

#define SGINFO   4   /* Formular/Dialog */

#define SEDIT    5   /* Formular/Dialog */
#define SE_Z50_100 2   /* FTEXT in Baum SEDIT */
#define SE_Z90_200 3   /* FTEXT in Baum SEDIT */
#define SE_Z99_101 4   /* FTEXT in Baum SEDIT */
#define SE_CLR   7   /* BUTTON in Baum SEDIT */

#define TOOLS    6   /* Formular/Dialog */
#define TO_SORT  1   /* BUTTON in Baum TOOLS */

#define BITS     7   /* Formular/Dialog */
#define BI_SEC   2   /* TEXT in Baum BITS */
