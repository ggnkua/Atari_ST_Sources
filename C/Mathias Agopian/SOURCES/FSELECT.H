int fileselect(char *masque, char *deflt, char *sortie, char *label);

