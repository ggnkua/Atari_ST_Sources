/* Indice du ressource pour CRSHTEST */

#define HELP_EXT 0   /* Formulaire/Dialogue */
