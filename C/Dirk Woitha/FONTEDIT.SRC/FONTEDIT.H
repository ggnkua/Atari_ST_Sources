#define FONTEDIT 0  	/* TREE */
#define ANZEIGE 8  	/* OBJECT in TREE #0 */
#define LOAD816 28  	/* OBJECT in TREE #0 */
#define LOAD88 29  	/* OBJECT in TREE #0 */
#define LOAD66 30  	/* OBJECT in TREE #0 */
#define LOADALL 31  	/* OBJECT in TREE #0 */
#define SAVE816 35  	/* OBJECT in TREE #0 */
#define SAVE88 36  	/* OBJECT in TREE #0 */
#define SAVE66 37  	/* OBJECT in TREE #0 */
#define SAVEALL 38  	/* OBJECT in TREE #0 */
#define SYS816 42  	/* OBJECT in TREE #0 */
#define SYS88 43  	/* OBJECT in TREE #0 */
#define SYS66 44  	/* OBJECT in TREE #0 */
#define SYSALL 45  	/* OBJECT in TREE #0 */
#define USE816 49  	/* OBJECT in TREE #0 */
#define USE88 50  	/* OBJECT in TREE #0 */
#define USE66 51  	/* OBJECT in TREE #0 */
#define USEALL 52  	/* OBJECT in TREE #0 */
#define USENONE 53  	/* OBJECT in TREE #0 */
#define EDIT816 57  	/* OBJECT in TREE #0 */
#define EDIT88 58  	/* OBJECT in TREE #0 */
#define EDIT66 59  	/* OBJECT in TREE #0 */
#define ESPIEGEL 61  	/* OBJECT in TREE #0 */
#define CLR 62  	/* OBJECT in TREE #0 */
#define FILL 63  	/* OBJECT in TREE #0 */
#define DREHE 64  	/* OBJECT in TREE #0 */
#define RUNTER 66  	/* OBJECT in TREE #0 */
#define HOCH 67  	/* OBJECT in TREE #0 */
#define LINKS 68  	/* OBJECT in TREE #0 */
#define RECHTS 69  	/* OBJECT in TREE #0 */
#define ASPIEGEL 70  	/* OBJECT in TREE #0 */
#define LIGHT 71  	/* OBJECT in TREE #0 */
#define INVERS 72  	/* OBJECT in TREE #0 */
#define EDITFELD 73  	/* OBJECT in TREE #0 */
#define SHOW 75  	/* OBJECT in TREE #0 */
#define ASCII 76  	/* OBJECT in TREE #0 */
#define OK 77  	/* OBJECT in TREE #0 */
#define UNDO 78  	/* OBJECT in TREE #0 */
#define AUSGANG 79  	/* OBJECT in TREE #0 */
#define FONTNAME 80  	/* OBJECT in TREE #0 */
#define SYSLOAD 0  	/* STRING */
#define TOSVERS 1  	/* STRING */
#define DERROR 2  	/* STRING */
#define NOTFOUND 3  	/* STRING */
#define NOTLANG 4  	/* STRING */
#define PROBE1 81  	/* OBJECT in TREE #0 */
#define PROBE2 82  	/* OBJECT in TREE #0 */
#define DIRK 1  	/* OBJECT in TREE #0 */
#define DIRK1 2  	/* OBJECT in TREE #0 */
#define DIRK2 3  	/* OBJECT in TREE #0 */
#define DIRK3 24  	/* OBJECT in TREE #0 */
#define DIRK4 4  	/* OBJECT in TREE #0 */
