#define TREE1 0  	/* TREE */
#define T1CSPEED 5  	/* OBJECT in TREE #0 */
#define T1SSPEED 6  	/* OBJECT in TREE #0 */
#define T1CSSPD 7  	/* OBJECT in TREE #0 */
#define T1FILTER 10  	/* OBJECT in TREE #0 */
#define T1LITRAL 9  	/* OBJECT in TREE #0 */
#define T1SEND 13  	/* OBJECT in TREE #0 */
#define T1EXIT 12  	/* OBJECT in TREE #0 */
