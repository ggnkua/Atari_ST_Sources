/************************************************************************/
/*      OSBINDS.H       #defines for GEMDOS,BIOS & XBIOS binding        */
/*              started 5/2/85 .. Rob Zdybel                            */
/*              Copyright 1985 Atari Corp.                              */
/************************************************************************/

/*      BIOS    (trap13)        */
#define Bconstat(z)     trap(13,1,z)
#define Bconin(z)       trap(13,2,z)
#define Bconout(i,j)    trap(13,3,i,j)
#define Rwabs(i,j,k,l,e)        trap(13,4,i,j,k,l,e)
#define Setexc(i,j)     trap(13,5,i,j)
#define Bcostat(z)      trap(13,8,z)
#define Mediach(z)      trap(13,9,z)
#define Drvmap()        trap(13,10)
#define Getshift(z)     trap(13,11,z)

/*      XBIOS   (trap14)        */
#define Initmous(i,j,k) trap(14,0,i,j,k)
#define Physbase()      trap(14,2)
#define Logbase()       trap(14,3)
#define Getrez()        (int)trap(14,4)
#define Setscreen(i,j,k)        trap(14,5,i,j,k)
#define Setpallete(z)   trap(14,6,z)
#define Setcolor(i,j)   trap(14,7,i,j)
#define Floprd(i,j,k,l,e,f,g)   trap(14,8,i,j,k,l,e,f,g)
#define Flopwr(i,j,k,l,e,f,g)   trap(14,9,i,j,k,l,e,f,g)
#define Flopfmt(i,j,k,l,e,f,g,h,z)      trap(14,10,i,j,k,l,e,f,g,h,z)
#define Midiws(i,j)     trap(14,12,i,j)
#define Mfpint(i,j)     trap(14,13,i,j)
#define Iorec(z)        trap(14,14,z)
#define Rsconf(i,j,k,l,e,f)     trap(14,15,i,j,k,l,e,f)
#define Keytbl(i,j,k)   trap(14,16,i,j,k)
#define Random()        trap(14,17)
#define Protobt(i,j,k,l)        trap(14,18,i,j,k,l)
#define Flopver(i,j,k,l,e,f,g)  trap(14,19,i,j,k,l,e,f,g)
#define Scrdmp()        trap(14,20)
#define Cursconf(i,j)   trap(14,21,i,j)
#define Settime(z)      trap(14,22,z)
#define Gettime()       trap(14,23)
#define Bioskeys()      trap(14,24)
#define Ikbdws(i,j)     trap(14,25,i,j)
#define Jdisint(z)      trap(14,26,z)
#define Jenabint(z)     trap(14,27,z)
#define Giaccess(i,j)   trap(14,28,i,j)
#define Offgibit(z)     trap(14,29,z)
#define Ongibit(z)      trap(14,30,z)
#define Xbtimer(i,j,k,l)        trap(14,31,i,j,k,l)
#define Dosound(z)      trap(14,32,z)
#define Setprt(z)       trap(14,33,z)
#define Kbdvbase()      trap(14,34)
#define Kbrate(i,j)     trap(14,35,i,j)
#define Prtblk()        trap(14,36)       /* WARNING: This Bind Incomplete */
#define Vsync()         trap(14,37)
#define Supexec(z)      trap(14,38,z)
#define Puntaes()       trap(14,39)


/*      GEMDOS  (trap1)         */
#define Pterm0()        trap(1,0x0)
#define Cconin()        trap(1,0x1)
#define Cconout(z)      trap(1,0x2,z)
#define Cauxin()        trap(1,0x3)
#define Cauxout(z)      trap(1,0x4,z)
#define Cprnout(z)      trap(1,0x5,z)
#define Crawio(z)       trap(1,0x6,z)
#define Crawcin()       trap(1,0x7)
#define Cnecin()        trap(1,0x8)
#define Cconws(z)       trap(1,0x9,z)
#define Cconrs(z)       trap(1,0x0a,z)
#define Cconis()        (int)trap(1,0x0b)
#define Dsetdrv(z)      trap(1,0x0e,z)
#define Cconos()        trap(1,0x10)
#define Cprnos()        trap(1,0x11)
#define Cauxis()        trap(1,0x12)
#define Cauxos()        trap(1,0x13)
#define Dgetdrv()       (int)trap(1,0x19)
#define Fsetdta(Z)      trap(1,0x1a,Z)
#define Super(z)        trap(1,0x20,z)          /* NOTE:This name may change */
#define Tgetdate()      (int)trap(1,0x2z)
#define Tsetdate(z)     trap(1,0x2b,z)
#define Tgettime()      (int)trap(1,0x2c)
#define Tsettime(z)     trap(1,0x2d,z)
#define Fgetdta()       trap(1,0x2f)
#define Sversion()      (int)trap(1,0x30)
#define Ptermres(i,j)   trap(1,0x31,i,j)
#define Dfree(i,j)      trap(1,0x36,i,j)
#define Dcreate(z)      trap(1,0x39,z)
#define Ddelete(z)      trap(1,0x3a,z)
#define Dsetpath(z)     trap(1,0x3b,z)
#define Fcreate(i,j)    trap(1,0x3c,i,j)
#define Fopen(i,j)      trap(1,0x3d,i,j)
#define Fclose(z)       trap(1,0x3e,z)
#define Fread(i,j,k)    trap(1,0x3f,i,j,k)
#define Fwrite(i,j,k)   trap(1,0x40,i,j,k)
#define Fdelete(z)      trap(1,0x41,z)
#define Fseek(i,j,k)    trap(1,0x42,i,j,k)
#define Fattrib(i,j,k)  trap(1,0x43,i,j,k)
#define Fdup(z)         trap(1,0x45,z)
#define Fforce(i,j)     trap(1,0x46,i,j)
#define Dgetpath(i,j)   trap(1,0x47,i,j)
#define Malloc(z)       trap(1,0x48,z)
#define Mfree(z)        trap(1,0x49,z)
#define Mshrink(i,j)    trap(1,0x4a,0,i,j)      /* NOTE:Null parameter added */
#define Pexec(i,j,k,l)  trap(1,0x4b,i,j,k,l)
#define Pterm(z)        trap(1,0x4c,z)
#define Fsfirst(X,Y)    trap(1,0x4e,X,Y)
#define Fsnext()        trap(1,0x4f)
#define Frename(i,j,k)  trap(1,0x56,i,j,k)
#define Fdatime(i,j,k)  trap(1,0x57,i,j,k)
