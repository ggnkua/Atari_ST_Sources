#define	ASC_NUL	0x00
#define	ASC_SOH	0x01
#define	ASC_STX	0x02
#define	ASC_ETX	0x03
#define	ASC_EOT	0x04
#define	ASC_ENQ	0x05
#define ASC_ACK 0x06
#define ASC_BEL 0x07
#define ASC_BS  0x08
#define ASC_HT  0x09
#define ASC_LF  0x0A
#define ASC_VT  0x0B
#define ASC_FF  0x0C
#define ASC_CR  0x0D
#define ASC_SO  0x0E
#define ASC_SI  0x0F

#define	ASC_DLE	0x10   /* Data Link Escape */
#define ASC_DC1 0x11   /* X-ON  */
#define ASC_XON 0x11   /* X-ON  */
#define ASC_DC2 0x12
#define ASC_DC3 0x13   /* X-OFF */
#define ASC_XOFF 0x13   /* X-OFF */
#define ASC_DC4 0x14

#define ASC_NAK 0x15
#define ASC_SYN 0x16
#define ASC_ETB 0x17
#define ASC_CAN 0x18
