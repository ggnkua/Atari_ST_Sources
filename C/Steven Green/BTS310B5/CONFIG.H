/*
 * config.h
 *
 * Enumeration of Binkley Configuration commands
 *
 */

enum {
	C_ZERO,
	C_SameRing,
	C_Answerback,
	C_Macro,
	C_Shell,
	C_Dial,
	C_Event,
	C_Zone,
	C_MaxReq,
	C_LogLevel,
	C_Baud,
	C_MaxPort,
	C_Port,
	C_ResetPort,
	C_Carrier,
	C_StatusLog,
	C_Reader,
	C_BossPhone,
	C_BossPwd,
	C_Protocol,
	C_System,
	C_Sysop,
	C_Boss,
	C_Point,
	C_Aka,
	C_Hold,
	C_DownLoads,
	C_NetFile,
	C_FirstInit,
	C_Init,
	C_Reset,
	C_Busy,
	C_Prefix,
	C_NodeList,
	C_Fax,					/* Programm to call when Fax comes in */
	C_FaxInbound,			/* Where to locate incoming faxes */
	C_AfterFax,				/* Programm to call after a fax was recieved */
	C_FaxConnect,			/* String from modem to recognize Faxconnect */
	C_BTNC,					/* BTNC format nodelist */
	C_NodeCache,
	C_Avail,
	C_OKFile,
	C_About,
	C_MailNote,
	C_Banner,
	C_UnAttended,
	C_OverWrite,
	C_ReqOnUs,
	C_LockBaud,
	C_TimeOut,
	C_NoSLO,
	C_SlowModem,
	C_SmallWindow,
	C_NoPickup,
	C_NoRequests,
	C_NetMail,
	C_Suffix,
	C_NoFullScreen,
	C_SignalHandler,
	C_AutoBaud,
	C_Gong,
	C_NoCollide,
	C_ExtrnMail,
	C_BBSNote,
	C_BBS,
	C_ScriptPath,
	C_BoxType,
	C_Include,
	C_CaptureFile,
	C_CursorCol,
	C_CursorRow,
	C_DoingMail,
	C_EnterBBS,
	C_PrivateNet,
	C_Packer,
	C_Cleanup,
	C_AfterMail,
	C_Colors,
	C_JanusBaud,
	C_ReqTemplate,
	C_KnownAvail,
	C_KnownReqList,
	C_KnownAbout,
	C_KnownInbound,
	C_KnownReqLim,
	C_KnownReqTpl,
	C_ProtAvail,
	C_ProtReqList,
	C_ProtAbout,
	C_ProtInbound,
	C_ProtReqLim,
	C_ProtReqTpl,
	C_Application,
	C_NoZones,
	C_Answer,
	C_PollTries,
	C_PollDelay,
	C_Address,
	C_Key,
	C_CurMudgeon,
	C_NoWaZOO,
	C_NoEMSI,
	C_NoRequest,
	C_NoJanus,
	C_IOS,
	C_Hold4D,
	C_ScreenBlank,
	C_Mark_Kromm,
	C_Server,
	C_ModemTrans,
	C_PreDial,
	C_PreInit,
	C_DTRHigh,
	C_Debug,
	C_NoZedZap,
	C_NoResync,
	C_NoSEAlink,
	C_FTS_0001,
	C_LineUpdate,
	C_JanusOK,
	C_TermInit,
	C_Domain,
	C_Flags,
	C_TaskNumber,
	C_MaxBytes,
	C_KnownMaxBytes,
	C_ProtMaxBytes,
	C_MaxTime,
	C_KnownMaxTime,
	C_ProtMaxTime,
	C_NoLineA,
#ifdef BIOSDISPLAY
	C_BIOSdisplay,
#endif
	C_UseColors,	
	C_IKBDclock,
	C_NoCTS,
	C_HardCTS,
	C_STlockBaud,
	C_SlowJanus,
	C_Hard38400,
	C_RSVEBoard,
	C_Rbuf,
	C_Tbuf,
	C_TZ,
	C_NiceOutbound,
	C_ReInitTime,
	C_ReadHoldTime,
	C_HoldsOnUs,
	C_SendRSP,
	C_UseCallSlots,			/* CallSlots */
	C_FDBugfix,				/* Take other Code */
#if defined(__PUREC__) || defined(__TURBOC__)
	C_CLIcommand,
#endif	
#if 0
	C_CostLog,
	C_NoWildcards,
	C_SuckerLimit,
	C_HstLs2400c,
	C_CostUnit,
#endif
	C_NLsystem,
	C_Phone,
	C_City,
	C_NLfLags,
	C_NLbaud,
	C_Tranx,
	C_LAST
} CONFIG_VALUES;

