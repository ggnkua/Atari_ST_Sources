
int dial_faxnum(char *dialstring );
int sende_fax(int fd, int tries);

