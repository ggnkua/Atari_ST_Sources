06601030301800
1Tim Oren- Professional GEM -VDI LINES & SOLIDS
2Appendix A- PROGEM09.C -Page A#
F0110030
9[...............................................]001
А/****************** Routines to set clip to a GRECT *******************/

   VOID               /* Convert x,y,w,h to upr lt x,y and lwr rt x,y */
grect_to_array(area, array)
   GRECT *area;
   WORD  *array;
   {
   *array++ = area->g_x;
   *array++ = area->g_y;
   *array++ = area->g_x + area->g_w - 1;
   *array = area->g_y + area->g_h - 1;
   }

   VOID                                 /* Set clip to specified area */
set_clip(clip_flag, s_area)
   WORD  clip_flag;
   GRECT *s_area;
   {
   WORD  pxy[4];

   grect_to_array(s_area, pxy);
   vs_clip(vdi_handle, clip_flag, pxy);
   }

А/************** Routines to set attributes before output **************/

   VOID                           /* Draw a rounded rectangle outline */
rr_perim(mode, color, type, width, pxy)
   WORD  mode, color, width, *pxy;
   {
   vswr_mode(vdi_handle, mode);
   vsl_color(vdi_handle, color);
   vsl_type(vdi_handle, type);
   vsl_width(vdi_handle, width);
   v_rbox(vdi_handle, pxy);
   vswr_mode(vdi_handle, MD_REPLACE);
   }

   VOID                                    /* Draw a polygonal figure */
pl_perim(mode, type, color, width, npts, pxy)
   WORD  mode, type, color, width, npts, *pxy;
   {
   vswr_mode(vdi_handle, mode);
   vsl_type(vdi_handle, type);
   vsl_color(vdi_handle, color);
   vsl_width(vdi_handle, width);
   v_pline(vdi_handle, npts, pxy);
   }

   VOID                               /* Draw a filled polygonal area */
pl_fill(mode, perim, color, interior, style, npts, pxy)
   WORD  mode, perim, color, interior, style, npts, *pxy;
   {
   vswr_mode(vdi_handle, mode);
   vsf_color(vdi_handle, color);
   vsf_style(vdi_handle, style);
   vsf_interior(vdi_handle, interior);
   vsf_perimeter(vdi_handle, perim);
   v_fillarea(vdi_handle, npts, pxy);
   }

   VOID                                    /* Draw a filled rectangle */
rect_fill(mode, perim, color, interior, style, pxy)
   WORD  mode, perim, color, style, interior, *pxy;
   {
   vswr_mode(vdi_handle, mode);
   vsf_color(vdi_handle, color);
   vsf_style(vdi_handle, style);
   vsf_interior(vdi_handle, interior);
   vsf_perimeter(vdi_handle, perim);
   vr_recfl(vdi_handle, pxy);
   }

