#define PROGRESS 0  	/* TREE */
#define PLINE 2  	/* OBJECT in TREE #0 */
#define PROBOX 3  	/* OBJECT in TREE #0 */
#define PROBAR 4  	/* OBJECT in TREE #0 */
#define STRINGS 1  	/* TREE */
#define P1 1  	/* OBJECT in TREE #1 */
#define P2 2  	/* OBJECT in TREE #1 */
#define PN 3  	/* OBJECT in TREE #1 */
