rs_object [ 0].ob_x     =    0;
rs_object [ 0].ob_y     =    0;
rs_object [ 0].ob_w     =   21;
rs_object [ 0].ob_h     = 2055;
rs_object [ 0].ob_flags =    0;
rs_object [ 0].ob_state =    0;
rs_object [ 0].ob_type  =   20;
rs_object [ 1].ob_x     =    7;
rs_object [ 1].ob_y     =    2;
rs_object [ 1].ob_w     =    6;
rs_object [ 1].ob_h     = 2562;
rs_object [ 1].ob_flags =    0;
rs_object [ 1].ob_state =    0;
rs_object [ 1].ob_type  =   25;
rs_object [ 2].ob_x     =    1;
rs_object [ 2].ob_y     =    0;
rs_object [ 2].ob_w     =    4;
rs_object [ 2].ob_h     =    2;
rs_object [ 2].ob_flags =    0;
rs_object [ 2].ob_state =    0;
rs_object [ 2].ob_type  =   23;
rs_object [ 3].ob_x     =    0;
rs_object [ 3].ob_y     =  514;
rs_object [ 3].ob_w     =    6;
rs_object [ 3].ob_h     = 2048;
rs_object [ 3].ob_flags =   32;
rs_object [ 3].ob_state =    0;
rs_object [ 3].ob_type  =   21;
rs_object [ 4].ob_x     =    0;
rs_object [ 4].ob_y     =    0;
rs_object [ 4].ob_w     = 1076;
rs_object [ 4].ob_h     =    8;
rs_object [ 4].ob_flags =    0;
rs_object [ 4].ob_state =    0;
rs_object [ 4].ob_type  =   20;
rs_object [ 5].ob_x     =    0;
rs_object [ 5].ob_y     =    0;
rs_object [ 5].ob_w     =   40;
rs_object [ 5].ob_h     =    8;
rs_object [ 5].ob_flags =    0;
rs_object [ 5].ob_state =    0;
rs_object [ 5].ob_type  = 1812;
rs_object [ 6].ob_x     = 1064;
rs_object [ 6].ob_y     =    0;
rs_object [ 6].ob_w     =    2;
rs_object [ 6].ob_h     =    1;
rs_object [ 6].ob_flags =   64;
rs_object [ 6].ob_state =    0;
rs_object [ 6].ob_type  = 2587;
rs_object [ 7].ob_x     = 1064;
rs_object [ 7].ob_y     = 2049;
rs_object [ 7].ob_w     =    2;
rs_object [ 7].ob_h     =    5;
rs_object [ 7].ob_flags =   64;
rs_object [ 7].ob_state =    0;
rs_object [ 7].ob_type  = 2324;
rs_object [ 8].ob_x     =    0;
rs_object [ 8].ob_y     =    1;
rs_object [ 8].ob_w     =    2;
rs_object [ 8].ob_h     =    2;
rs_object [ 8].ob_flags =   64;
rs_object [ 8].ob_state =    0;
rs_object [ 8].ob_type  = 2068;
rs_object [ 9].ob_x     = 1064;
rs_object [ 9].ob_y     =    7;
rs_object [ 9].ob_w     =    2;
rs_object [ 9].ob_h     =    1;
rs_object [ 9].ob_flags =   96;
rs_object [ 9].ob_state =    0;
rs_object [ 9].ob_type  = 1819;
rs_object [10].ob_x     =    0;
rs_object [10].ob_y     =    0;
rs_object [10].ob_w     =   39;
rs_object [10].ob_h     =    2;
rs_object [10].ob_flags =    0;
rs_object [10].ob_state =    0;
rs_object [10].ob_type  =   20;
rs_object [11].ob_x     = 1025;
rs_object [11].ob_y     = 2048;
rs_object [11].ob_w     =   36;
rs_object [11].ob_h     =    1;
rs_object [11].ob_flags =   32;
rs_object [11].ob_state =    0;
rs_object [11].ob_type  =   21;
rs_object [12].ob_x     =    0;
rs_object [12].ob_y     =    0;
rs_object [12].ob_w     = 1071;
rs_object [12].ob_h     = 2058;
rs_object [12].ob_flags =    0;
rs_object [12].ob_state =    0;
rs_object [12].ob_type  =   20;
rs_object [13].ob_x     = 1025;
rs_object [13].ob_y     =    1;
rs_object [13].ob_w     =   42;
rs_object [13].ob_h     =    7;
rs_object [13].ob_flags =    0;
rs_object [13].ob_state =    0;
rs_object [13].ob_type  = 1812;
rs_object [14].ob_x     =   44;
rs_object [14].ob_y     =    1;
rs_object [14].ob_w     =    2;
rs_object [14].ob_h     =    1;
rs_object [14].ob_flags =    0;
rs_object [14].ob_state =    0;
rs_object [14].ob_type  = 2587;
rs_object [15].ob_x     =   44;
rs_object [15].ob_y     = 2050;
rs_object [15].ob_w     =    2;
rs_object [15].ob_h     =    4;
rs_object [15].ob_flags =    0;
rs_object [15].ob_state =    0;
rs_object [15].ob_type  = 2324;
rs_object [16].ob_x     =    0;
rs_object [16].ob_y     = 2048;
rs_object [16].ob_w     =    2;
rs_object [16].ob_h     =    2;
rs_object [16].ob_flags =    0;
rs_object [16].ob_state =    0;
rs_object [16].ob_type  = 2068;
rs_object [17].ob_x     =   44;
rs_object [17].ob_y     =    7;
rs_object [17].ob_w     =    2;
rs_object [17].ob_h     =    1;
rs_object [17].ob_flags =    0;
rs_object [17].ob_state =    0;
rs_object [17].ob_type  = 1819;
rs_object [18].ob_x     = 1025;
rs_object [18].ob_y     =    9;
rs_object [18].ob_w     =    9;
rs_object [18].ob_h     =    1;
rs_object [18].ob_flags = 1541;
rs_object [18].ob_state =    0;
rs_object [18].ob_type  =   26;
rs_object [19].ob_x     =   37;
rs_object [19].ob_y     =    9;
rs_object [19].ob_w     =    9;
rs_object [19].ob_h     =    1;
rs_object [19].ob_flags = 1573;
rs_object [19].ob_state =    0;
rs_object [19].ob_type  =   26;
rs_object [20].ob_x     =    0;
rs_object [20].ob_y     =    0;
rs_object [20].ob_w     = 1090;
rs_object [20].ob_h     = 2065;
rs_object [20].ob_flags =    0;
rs_object [20].ob_state =    0;
rs_object [20].ob_type  =   20;
rs_object [21].ob_x     = 1025;
rs_object [21].ob_y     =    1;
rs_object [21].ob_w     = 1087;
rs_object [21].ob_h     =    5;
rs_object [21].ob_flags =    0;
rs_object [21].ob_state =    0;
rs_object [21].ob_type  = 1812;
rs_object [22].ob_x     = 1025;
rs_object [22].ob_y     = 2054;
rs_object [22].ob_w     =   42;
rs_object [22].ob_h     =    8;
rs_object [22].ob_flags =    0;
rs_object [22].ob_state =    0;
rs_object [22].ob_type  = 1812;
rs_object [23].ob_x     =   44;
rs_object [23].ob_y     = 2054;
rs_object [23].ob_w     =    2;
rs_object [23].ob_h     =    1;
rs_object [23].ob_flags =   64;
rs_object [23].ob_state =    0;
rs_object [23].ob_type  = 3099;
rs_object [24].ob_x     =   49;
rs_object [24].ob_y     = 2054;
rs_object [24].ob_w     =    4;
rs_object [24].ob_h     =    8;
rs_object [24].ob_flags =    0;
rs_object [24].ob_state =    0;
rs_object [24].ob_type  = 1812;
rs_object [25].ob_x     = 1077;
rs_object [25].ob_y     = 2054;
rs_object [25].ob_w     =    2;
rs_object [25].ob_h     =    1;
rs_object [25].ob_flags =   64;
rs_object [25].ob_state =    0;
rs_object [25].ob_type  = 3099;
rs_object [26].ob_x     = 1082;
rs_object [26].ob_y     = 2054;
rs_object [26].ob_w     =    4;
rs_object [26].ob_h     =    8;
rs_object [26].ob_flags =    0;
rs_object [26].ob_state =    0;
rs_object [26].ob_type  = 1812;
rs_object [27].ob_x     =   63;
rs_object [27].ob_y     = 2054;
rs_object [27].ob_w     =    2;
rs_object [27].ob_h     =    1;
rs_object [27].ob_flags =   64;
rs_object [27].ob_state =    0;
rs_object [27].ob_type  = 3099;
rs_object [28].ob_x     =   44;
rs_object [28].ob_y     =    8;
rs_object [28].ob_w     =    2;
rs_object [28].ob_h     =    5;
rs_object [28].ob_flags =   64;
rs_object [28].ob_state =    0;
rs_object [28].ob_type  = 2324;
rs_object [29].ob_x     =    0;
rs_object [29].ob_y     =    1;
rs_object [29].ob_w     =    2;
rs_object [29].ob_h     =    2;
rs_object [29].ob_flags =   64;
rs_object [29].ob_state =    0;
rs_object [29].ob_type  = 2068;
rs_object [30].ob_x     = 1077;
rs_object [30].ob_y     =    8;
rs_object [30].ob_w     =    2;
rs_object [30].ob_h     =    5;
rs_object [30].ob_flags =   64;
rs_object [30].ob_state =    0;
rs_object [30].ob_type  = 2324;
rs_object [31].ob_x     =    0;
rs_object [31].ob_y     =    1;
rs_object [31].ob_w     =    2;
rs_object [31].ob_h     =    2;
rs_object [31].ob_flags =   64;
rs_object [31].ob_state =    0;
rs_object [31].ob_type  = 2068;
rs_object [32].ob_x     =   63;
rs_object [32].ob_y     =    8;
rs_object [32].ob_w     =    2;
rs_object [32].ob_h     =    5;
rs_object [32].ob_flags =   64;
rs_object [32].ob_state =    0;
rs_object [32].ob_type  = 2324;
rs_object [33].ob_x     =    0;
rs_object [33].ob_y     =    1;
rs_object [33].ob_w     =    2;
rs_object [33].ob_h     =    2;
rs_object [33].ob_flags =   64;
rs_object [33].ob_state =    0;
rs_object [33].ob_type  = 2068;
rs_object [34].ob_x     =   44;
rs_object [34].ob_y     = 2061;
rs_object [34].ob_w     =    2;
rs_object [34].ob_h     =    1;
rs_object [34].ob_flags =   64;
rs_object [34].ob_state =    0;
rs_object [34].ob_type  = 3099;
rs_object [35].ob_x     = 1077;
rs_object [35].ob_y     = 2061;
rs_object [35].ob_w     =    2;
rs_object [35].ob_h     =    1;
rs_object [35].ob_flags =   64;
rs_object [35].ob_state =    0;
rs_object [35].ob_type  = 3099;
rs_object [36].ob_x     =   63;
rs_object [36].ob_y     = 2061;
rs_object [36].ob_w     =    2;
rs_object [36].ob_h     =    1;
rs_object [36].ob_flags =   64;
rs_object [36].ob_state =    0;
rs_object [36].ob_type  = 3099;
rs_object [37].ob_x     = 1025;
rs_object [37].ob_y     = 2063;
rs_object [37].ob_w     =    7;
rs_object [37].ob_h     =    1;
rs_object [37].ob_flags = 1537;
rs_object [37].ob_state =    0;
rs_object [37].ob_type  =  538;
rs_object [38].ob_x     =   35;
rs_object [38].ob_y     = 2063;
rs_object [38].ob_w     =    9;
rs_object [38].ob_h     =    1;
rs_object [38].ob_flags = 1541;
rs_object [38].ob_state =    0;
rs_object [38].ob_type  =   26;
rs_object [39].ob_x     = 1069;
rs_object [39].ob_y     = 2063;
rs_object [39].ob_w     =    9;
rs_object [39].ob_h     =    1;
rs_object [39].ob_flags = 1541;
rs_object [39].ob_state =    0;
rs_object [39].ob_type  =   26;
rs_object [40].ob_x     =   56;
rs_object [40].ob_y     = 2063;
rs_object [40].ob_w     =    9;
rs_object [40].ob_h     =    1;
rs_object [40].ob_flags = 1575;
rs_object [40].ob_state =    0;
rs_object [40].ob_type  =   26;
rs_object [41].ob_x     =    0;
rs_object [41].ob_y     =    0;
rs_object [41].ob_w     =   42;
rs_object [41].ob_h     =    5;
rs_object [41].ob_flags =    0;
rs_object [41].ob_state =    0;
rs_object [41].ob_type  =   20;
rs_object [42].ob_x     =    1;
rs_object [42].ob_y     = 2048;
rs_object [42].ob_w     =   40;
rs_object [42].ob_h     =    1;
rs_object [42].ob_flags =    0;
rs_object [42].ob_state =    0;
rs_object [42].ob_type  =   21;
rs_object [43].ob_x     =    1;
rs_object [43].ob_y     = 2049;
rs_object [43].ob_w     =   40;
rs_object [43].ob_h     =    1;
rs_object [43].ob_flags =    0;
rs_object [43].ob_state =    0;
rs_object [43].ob_type  =   21;
rs_object [44].ob_x     =    1;
rs_object [44].ob_y     = 2051;
rs_object [44].ob_w     =   40;
rs_object [44].ob_h     =    1;
rs_object [44].ob_flags =    0;
rs_object [44].ob_state =    0;
rs_object [44].ob_type  = 13076;
rs_object [45].ob_x     =    0;
rs_object [45].ob_y     =    0;
rs_object [45].ob_w     =    8;
rs_object [45].ob_h     =    1;
rs_object [45].ob_flags =   32;
rs_object [45].ob_state =    0;
rs_object [45].ob_type  = 13332;
