/******************************************************************************/
/*																										*/
/*          Eine handoptimierte Bibliothek f�r Pure-C und GNU-C               */
/*																										*/
/* Cookie-Konstanten - Headerdatei															*/
/*																										*/
/*	(c) 1998-2008 by Martin Els„sser @ LL													*/
/*																										*/
/*																						Tabsize: 3	*/
/******************************************************************************/

#if !defined(__ACS_COOKIES_H) && !defined(_cookie_h_)
#define __ACS_COOKIES_H
#define _cookie_h_

/* This cookie list was generated from cookie.dat (Kelly's MiNT-Setter) */
/* Some defines had had to be renamed because some cookie names containing */
/* 'non-define-able' characters. For this special characters '_' were */
/* inserted (e.g. LP/2 -> C_LP_2, UN*X -> C_UN_X) */

#define C__AFM 0x5F41464DL		/* Audio Fun Machine */
#define C__AKP 0x5F414B50L		/* Keyboard/Language Configuration */
#define C__CPU 0x5F435055L		/* Central Processor Unit Type */
#define C__FDC 0x5F464443L		/* Disk Drive Type */
#define C__FLK 0x5F464C4BL		/* File Locking Extension */
#define C__FPU 0x5F465055L		/* Floating Point Unit Type */
#define C__FRB 0x5F465242L		/* Fast Ram Buffer */
#define C__FSR 0x5F465352L		/* Patch program for serial (TOS 4.00->4.04) */
#define C__IDT 0x5F494454L		/* International Date/Time Format */
#define C__INF 0x5F494E46L		/* STEFIX Program */
#define C__JPD 0x5F4A5044L		/* Falcon030 JPEG Decoder by Brainstorm */
#define C__MCH 0x5F4D4348L		/* Machine Type */
#define C__MET 0x5F4D4554L		/* MetaDOS */
#define C__NET 0x5F4E4554L		/* GEMDOS Network Support */
#define C__MIL 0x5F4D494CL		/* Milan computer */
#define C__OOL 0x5F4F4F4CL		/* Pool Fix */
#define C__PCI 0x5f504349L		/* PCIbios */
#define C__PWR 0x5F505752L		/* Power Management unit */
#define C__SLM 0x5F534C4DL		/* SLM Driver */
#define C__SND 0x5F534E44L		/* Sound Hardware */
#define C__SWI 0x5F535749L		/* Configuration Switches */
#define C__T30 0x5F543330L		/* KAOS TOS */
#define C__VDO 0x5F56444FL		/* Video Type */
#define C_AB40 0x41423430L		/* AfterBurner040 */
#define C_AFnt 0x41466E74L		/* AES Font Loader */
#define C_AgKO 0x41674B4FL		/* AusGuck RAMdisk */
#define C_AHVR 0x41485652L		/* VRAM */
#define C_ALHP 0x414C4850L		/* Alman HP Deskjet Screendumper */
#define C_ALIC 0x414C4943L		/* Alice */
#define C_AmAN 0x416D414EL		/* A-MAN */
#define C_AMC1 0x414D4331L		/* Monitor Switchbox */
#define C_AMC2 0x414D4332L		/* PC Keyboard Driver Software */
#define C_APGM 0x4150474DL		/* Sysgem by Andreas Pietsch */
#define C_ARTS 0x41525453L		/* Screen-Artist screensaver */
#define C_AVmw 0x41566D77L		/* Virus Warning Program */
#define C_AVOJ 0x41564F4AL		/* Oliver Joppich's Anti Virus program */
#define C_BASH 0x42415348L		/* Bourne Again Shell */
#define C_BCKW 0x42434B57L		/* BackWard */
#define C_BIGS 0x42494753L		/* Big Screen */
#define C_BIOC 0x42494F43L		/* Pirosca */
#define C_BLNK 0x424C4E4BL		/* Screenblanker */
#define C_BLOW 0x424C4F57L		/* Blowup030 */
#define C_BSIM 0x4253494DL		/* Drive B Simulator */
#define C_BUG1 0x42554731L		/* Bugaboo Debugger */
#define C_CASE 0x43415345L		/* Casing Type */
#define C_CB2K 0x4342324BL		/* Claus Brod GEMDOS Bug Patch */
#define C_CBCE 0x43424345L		/* Claus Brod Critical Error Handler Patch */
#define C_CBDF 0x43424446L		/* Claus Brod Dabbel Feature */
#define C_CBHD 0x43424844L		/* Claus Brod HD Driver */
#define C_CBHY 0x43424859L		/* Claus Brod Hyper Format */
#define C_CBIT 0x43424954L		/* C'T Bus Interface Driver */
#define C_CFIX 0x43464958L		/* Console Fix */
#define C_CFsl 0x4346736CL		/* Compo FSel */
#define C_Cham 0x4368616DL		/* Chameleon */
#define C_CHAM 0x4348414DL		/* Chameleon */
#define C_CHNG 0x43484E47L		/* Changes */
#define C_CISY 0x43495359L		/* Cisystem */
#define C_CJar 0x434A6172L		/* JarXXX Program */
#define C_CKBD 0x434B4244L		/* Composed Character Deluxe Keyboard Driver */
#define C_CKJR 0x434B4A52L		/* Create Cookie Jar Program */
#define C_CLCK 0x434C434BL		/* Mega-ST Hardware clock TSR Utilities */
#define C_CLK1 0x434C4B31L		/* MEGA ST Clock Utility */
#define C_CLOK 0x434C4F4BL		/* CLOK for GMT settings (?) */
#define C_CM16 0x434D3136L		/* CyReL's M16 Versatile Installation Program */
#define C_CNTS 0x434e5453L		/* CentScreen */
#define C_COLO 0x434F4C4FL		/* Colos Mono-Colour Converter */
#define C_CPSL 0x4350534CL		/* Caps Lock Display */
#define C_CRIT 0x43524954L		/* Crypt-It */
#define C_CSMD 0x43534D44L		/* CyReL's Serial Mouse Manager */
#define C_CTCH 0x43544348L		/* Master-Module Catch.mmx */
#define C_CtCp 0x43744370L		/* CapsLock Display */
#define C_CTSF 0x43545346L		/* CTS Bug Fix */
#define C_CRAC 0x43524143L		/* Protar HD Driver */
#define C_CRIT 0x43524954L		/* Crypt-It */
#define C_cVDI 0x63564449L		/* CyReL's M-16-1280 VDI Driver */
#define C_CWCo 0x4357436FL		/* Compo FSel */
#define C_DATE 0x44415445L		/* Led Panel Date */
#define C_DATL 0x4441544CL		/* TwiLight */
#define C_DAWN 0x4441574EL		/* Before Dawn */
#define C_DBFX 0x44424658L		/* Diabalo Emulator patch fix for MiNT */
#define C_DCdd 0x44436464L		/* Double-Click Software Data Diet */
#define C_DEPI 0x44455049L		/* DeskPic */
#define C_DHST 0x44485354L		/* Document History Protocol */
#define C_DIG2 0x44494732L		/* Digiplay by Emmanuel Jaccard */
#define C_DKEY 0x444B4559L		/* Dead Key from Brainstorm */
#define C_DNTR 0x444E5452L		/* DNT ramdisk */
#define C_DPRS 0x44505253L		/* Printer Buffer */
#define C_DRIV 0x44524956L		/* Drive Edit */
#define C_DRRH 0x44525248L		/* Wodan Keyboard Layout Program */
#define C_DSSO 0x4453534FL		/* Sokrates Keyboard Driver */
#define C_DYNL 0x44594E4CL		/* Dynamic Link Library Driver */
#define C_EdDI 0x45644449L		/* EdDI by Sven&Wilfried Behne, BELA */
#define C_ENVR 0x454E5652L		/* Environment manager */
#define C_ENV$ 0x454E5624L		/* Desktop environment manager */
#define C_ETM  0x45544D20L		/* Entmauser */
#define C_EURO 0x4555524FL		/* EURO-Cookie */
#define C_EXRA 0x45585241L		/* Extra RAM Speeder Card Software */
#define C_EXTD 0x45585444L		/* TOS File Name Extender */
#define C_FALT 0x46414C54L		/* Faltoff Screen() MEGA STE bufixer */
#define C_FIX2 0x46495832L		/* FIX24 68030 -> 24 bits */
#define C_FLTP 0x464C5450L		/* FlyTop */
#define C_FLXD 0x464C5844L		/* Flexdisk */
#define C_Fose 0x466F7365L		/* Font Selector */
#define C_FOse 0x464F7365L		/* Fontselector */
#define C_FrmD 0x46726D44L		/* Form_do_it */
#define C_FSEL 0x4653454CL		/* Extended File Selector (e.g. Selectric¿,Freedom¿) */
#define C_FSER 0x46534552L		/* Fast Serial Interface Routines */
#define C_FSMC 0x46534D43L		/* Advanced GDOS */
#define C_FSmp 0x46536D70L		/* Martin Patzel File Selector */
#define C_GABI 0x47414249L		/* Gabrielle Serial Port Typewriter Emulator */
#define C_GBel 0x4742656CL		/* GemBell */
#define C_GDEV 0x47444556L		/* GNU-C Device-Driver */
#define C_GEMB 0x47454D42L		/* GE Soft HD Driver */
#define C_GENV 0x47454E56L		/* GEM Environment Setter */
#define C_GIGA 0x47494741L		/* Giga Box ST Driver */
#define C_gkCO 0x676B434FL		/* Calamus Thingy */
#define C_GMNI 0x474D4E49L		/* Gemini */
#define C_GNUC 0x474E5543L		/* GNU-C Library */
#define C_Gnva 0x476E7661L		/* Geneva Multi-tasking AES */
#define C_GOff 0x474F6666L		/* Grow/Shrinkbox off */
#define C_GSND 0x47534E44L		/* Gemsound */
#define C_GSP1 0x47535031L		/* GEM Spooler */
#define C_GSXB 0x47535842L		/* Generic sound Xbios */
#define C_GULM 0x47554C4DL		/* Gulam Shell */
#define C_HABO 0x4841424FL		/* Haboo Harddisk Cache */
#define C_HAMM 0x48414D4DL		/* Melody Maker Software */
#define C_HBFS 0x48424653L		/* BoxKite File Selector */
#define C_HcP6 0x48635036L		/* NEC P6 Hardcopy Driver */
#define C_HDDR 0x48444452L		/* HD Driver */
#define C_HDJR 0x48444A52L		/* Hushi HD Interface Driver */
#define C_HDPR 0x48445052L		/* HD Protect */
#define C_HDST 0x48445354L		/* Eickmann HD Driver */
#define C_HDSW 0x48445357L		/* High Density Switcher */
#define C_HFIX 0x48464958L		/* Handle Bug Fix */
#define C_HIDS 0x48494453L		/* High Density Disk Driver */
#define C_HMDU 0x484D4455L		/* HM2 System Memory Dump */
#define C_HMOC 0x484D4F43L		/* H!nisch Modula Object Cache */
#define C_HMRD 0x484D5244L		/* H!nisch Modula Run-Time Debugger */
#define C_HMRS 0x484D5253L		/* HM2 Run-Time System */
#define C_HPHC 0x48504843L		/* HP Deskjet Hardcopy */
#define C_HPLJ 0x48504C4AL		/* HP Laserjet Emulator */
#define C_HSnd 0x48536E64L		/* CrazySounds */
#define C_HSND 0x48534E44L		/* CrazySounds */
#define C_HWAM 0x4857414DL		/* Cookie Jar creator program */
#define C_IBMP 0x49424D50L		/* Norwegian->IBM Printer Converter */
#define C_ICFS 0x49434653L		/* Iconify Server */
#define C_IDSK 0x4944534BL		/* Icon Desk */
#define C_IMAC 0x494D4143L		/* Bootsector Guardian */
#define C_IMNE 0x494D4E45L		/* Imagine graphics card */
#define C_INSJ 0x494E534AL		/* Cookie Jar installer/extendor program */
#define C_INXR 0x494E5852L		/* Index generator */
#define C_iPRN 0x6950524EL		/* iPRN */
#define C_JAM1 0x4A414D31L		/* Butler James */
#define C_JCLK 0x4A434C4BL		/* Clocky Multiutility */
#define C_JCNB 0x4A434E42L		/* JCN Bootselector */
#define C_JCNC 0x4A434E43L		/* JCN Multi Accessory */
#define C_JCNH 0x4A434E48L		/* Hardcopy Program */
#define C_JCNT 0x4A434E54L		/* Cocteau Word Processor */
#define C_JFTP 0x4A465450L		/* SCSI driver for generic tape devices */
#define C_JINX 0x4A494E58L		/* Jinx */
#define C_JMLS 0x4A4D4C53L		/* JML Snapshot */
#define C_JSHD 0x4A534844L		/* High Density Control Program */
#define C_JUST 0x4A555354L		/* Justify */
#define C_KbEv 0x4B624576L		/* MM2 Keyboard Handling Module */
#define C_KIDI 0x4B494449L		/* RAMdisk */
#define C_KEYT 0x4B455954L		/* KEYTAB-Cookie */
#define C_KGTF 0x4B475446L		/* Tos Fix */
#define C_KyMp 0x4B794D70L		/* Keyboard Macro & Remapping Utility */
#define C_LALA 0x4C414C41L		/* Albolala BellHook Sample Player */
#define C_LAWC 0x4C415743L		/* Look-Ahead-Write-Cache */
#define C_LEDP 0x4C454450L		/* LED-Panel */
#define C_LLCR 0x4C4C4352L		/* Logilex 1st Lock */
#define C_LPCD 0x4C504344L		/* Carrier Detector */
#define C_LPJM 0x4C504A4DL		/* Joy Mouse */
#define C_LP_2 0x4C502F32L		/* LP/2 : Malloc 2 Gemdos Vector */
#define C_LTMF 0x4C544D46L		/* Let 'em Fly */
#define C_macc 0x6D616363L		/* Maccel 3 */
#define C_MADD 0x4D414444L		/* Add mem for TT */
#define C_MagC 0x4D616743L		/* Magic Dials Configuration program */
#define C_MagX 0x4D616758L		/* Mag!X */
#define C_MAST 0x4D415354L		/* Master */
#define C_MaTC 0x4D615443L		/* Matrix True Colour Graphics Card */
#define C_MCL_ 0x4D434C5FL		/* MiNT control */
#define C_McSn 0x4D63536EL		/* MacSound */
#define C_MCWR 0x4D435752L		/* Microwire DMA sound interface */
#define C_MDIA 0x4D444941L		/* Multi-Dialog */
#define C_MDSa 0x4D445361L		/* Medical Design Software's Serial Fix */
#define C_MFAC 0x4D464143L		/* Multi Accessory */
#define C_MFNT 0x4D464E54L		/* Fontloader */
#define C_MGEM 0x4D47454DL		/* MultiGEM */
#define C_MgMc 0x4D674D63L		/* MagiCMac */
#define C_MID3 0x4D494433L		/* MIDINET3 */
#define C_MIMA 0x4D494D41L		/* MIDI Manager */
#define C_MiNT 0x4D694E54L		/* Mint/MultiTOS */
#define C_MJAF 0x4D4A4146L		/* Martin Jahr */
#define C_MKHC 0x4D4B4843L		/* Hardcopy Fixer */
#define C_MkJr 0x4D6B4A72L		/* Cookie Jar creator program */
#define C_MMAC 0x4D4D4143L		/* Magic Mouse Accelerator */
#define C_MM_2 0x4D4D5F32L		/* Midimaze 2 */
#define C_MMUT 0x4D4D5554L		/* Midi Maze II Utility */
#define C_MNAM 0x4D4E414DL		/* MagiCMac Name cookie */
#define C_MOGR 0x4D4F4752L		/* GEMRAM */
#define C_MPRO 0x4D50524FL		/* Magic Pro Config CPX */
#define C_MRAM 0x4D52414DL		/* More RAM */
#define C_MSPD 0x4D535044L		/* Mouse Speeder */
#define C_MSPO 0x4D53504FL		/* Magic Spooler */
#define C_mstx 0x6D737478L		/* Mouse Tricks */
#define C_MUPF 0x4D555046L		/* Mupfel */
#define C_MWHL 0x4d57484CL		/* MWheel (Mausrad-Treiber) */
#define C_N203 0x4E323033L		/* Multi Accessory */
#define C_NCLN 0x4E434C4EL		/* NiceLine */
#define C_NERV 0x4E455256L		/* No etv_critic_alert */
#define C_NETS 0x4E455453L		/* PAM Novell Software */
#define C_NFnt 0x4E466E74L		/* Neodesk Font Loader */
#define C_NLdr 0x4E4C6472L		/* Neodesk Loader */
#define C_nAES 0x6E414553L		/* Naes, the AES for MiNT */
#define C_noCF 0x6E6F4346L		/* noSystem */
#define C_NOR5 0x4E4F5235L		/* Norwegian Keyboard Driver */
#define C_NOVA 0x4E4F5641L		/* NOVA graphics card */
#define C_NO7P 0x4E4F3750L		/* Norwegian->7 bit printer converter */
#define C_NSC1 0x4E534331L		/* N_Syscom accessory */
#define C_NTK4 0x4E544B34L		/* Falcon MOD player */
#define C_NUL_ 0x4E554C3EL		/* NUL> : System startup utility */
#define C_NVDI 0x4E564449L		/* NVDI */
#define C_OFLS 0x4F464C53L		/* Check Open Files */
#define C_OPMM 0x4F504D4DL		/* Open Helper */
#define C_OSBL 0x4F53424CL		/* Screen Blaster */
#define C_OSTT 0x4F535454L		/* OverScan TT */
#define C_OV24 0x4F563234L		/* OverScan Hardcopy Driver 24 pins */
#define C_OVDJ 0x4F56444AL		/* OverScan Hardcopy Driver HP Deskjet */
#define C_OVEP 0x4F564550L		/* OverScan Hardcopy Driver 9 pins */
#define C_OVER 0x4F564552L		/* AutoSwitch OverScan Hardware Driver */
#define C_OVFS 0x4F564653L		/* OverScan Fileselector Patch */
#define C_OVIM 0x4F56494DL		/* OverScan Hardcopy Driver */
#define C_OVLS 0x4F564C53L		/* OverScan DMC Laserbrain Patch */
#define C_OVRD 0x4F565244L		/* OverScan RamDisk */
#define C_OVUT 0x4F565554L		/* OverScan Screen Blanker */
#define C_OVWI 0x4F565749L		/* OverScan Window-Size Patch */
#define C_PAMN 0x50414D4EL		/* PAM Network Driver */
#define C_PBUG 0x50425547L		/* PeaceBug */
#define C_PDOS 0x50444F53L		/* PowerDOS */
#define C_PFIX 0x50464958L		/* PTSIN Fix */
#define C_Pinp 0x50696E70L		/* Parallel Input Port Driver */
#define C_PKSH 0x504B5348L		/* PKS-Shell */
#define C_PMMU 0x504D4D55L		/* PMMU reprogrammed */
#define C_POIS 0x504F4953L		/* Poison! */
#define C_POWM 0x504F574DL		/* PowerMouse */
#define C_PRCS 0x50524353L		/* CopySTar */
#define C_PRDS 0x50524453L		/* Peter Rohde Disk Speeder */
#define C_PRN_ 0x50524E21L		/* PRN! : WandelSZ */
#define C_PRO5 0x50524F35L		/* Resident virus check/kill/prtotect program */
#define C_PROT 0x50524F54L		/* Protos Screen Utility */
#define C_PRTD 0x50525444L		/* Print to Disk V1.10 */
#define C_PRTO 0x5052544FL		/* ST Tools */
#define C_prtr 0x70727472L		/* Atari->IBM Printer Converter */
#define C_PRTR 0x50525452L		/* Protar HD Driver */
#define C_PSSG 0x50535347L		/* Paint Shop Hardcopy vector */
#define C_PTOS 0x50544F53L		/* ROMRAM: copy TOS in TT-RAM */
#define C_QIKM 0x51494B4DL		/* Quick Mouse */
#define C_QMAC 0x514D4143L		/* Quick Mouse Driver Accessory */
#define C_QMCP 0x514D4350L		/* Chemplot Quick Mouse Driver */
#define C_QST2 0x51535432L		/* Quick ST 2 */
#define C_QST3 0x51535433L		/* Quick ST 3 */
#define C_QUAN 0x5155414EL		/* QuanTOS Multiutility */
#define C_RAIL 0x5241494CL		/* Rail Manager */
#define C_RFLX 0x52464C58L		/* AutoSwitch Driver for Reflex Graphics Card */
#define C_RFUS 0x52465553L		/* Rufus terminal program; */
#define C_RSLT 0x52534C54L		/* GengTEC VGA Monochrome/16 Colour Driver */
#define C_RSpd 0x52537064L		/* RS_SPEED (Serial Fix) */
#define C_RSVE 0x52535645L		/* RSVE Patch */
#define C_RSVF 0x52535646L		/* RS232 Version Fast (HSMODEM) */
#define C_RTOB 0x52544F42L		/* Optobell */
#define C_RTKC 0x52544B43L		/* Keyclick */
#define C_RWIN 0x5257494EL		/* RootWindow */
#define C_SAM  0x53414D20L		/* System Audio Manager */
#define C_SBKM 0x53424B4DL		/* Ring Recognition in Modem Routs */
#define C_SBTE 0x53425445L		/* Terminal Program */
#define C_SBTS 0x53425453L		/* Trap Spy */
#define C_SCAH 0x53434148L		/* Speed Cache */
#define C_SCPN 0x5343504EL		/* ScreenBlaster 3 */
#define C_SCRN 0x5343524EL		/* Screen Scroll */
#define C_SCRS 0x53435253L		/* Screen Blanker */
#define C_SCRW 0x53435257L		/* Screen Watch */
#define C_SCSI 0x53435349L		/* SCSI Driver */
#define C_SCSV 0x53435356L		/* Line Art Screensaver */
#define C_S_DR 0x535F4452L		/* CDROM SCSI driver */
#define C_SDsk 0x5344736BL		/* Softdisk */
#define C_SDWN 0x5344574EL		/* ScreenDown */
#define C_SELC 0x53454C43L		/* C-Lab File selector */
#define C_SENV 0x53454E56L		/* Set Environment */
#define C_SFA_ 0x5346415EL		/* SFA^ : Fontloader system */
#define C_SFIX 0x53464958L		/* Serial Port Fix */
#define C_SFMN 0x53464D4EL		/* SafeMenu */
#define C_SMAL 0x534D414CL		/* Small AES Icon fonts */
#define C_SMAU 0x534D4155L		/* Set Mouse Accessory */
#define C_SMon 0x534D6F6EL		/* SysMon */
#define C_SM00 0x534D3030L		/* SOTA Printer Spooler */
#define C_SM01 0x534D3031L		/* ReProK Office Management DUO */
#define C_SM02 0x534D3032L		/* ReProK International EM-NET II */
#define C_SMTT 0x534D5454L		/* SM-124 Emulator */
#define C_SNAP 0x534E4150L		/* That's Snap Accessory */
#define C_SPCK 0x5350434BL		/* RAMdisk for SPC Modula */
#define C_SPEE 0x53504545L		/* Mouse Speeder */
#define C_SPEX 0x53504558L		/* Steve's Printing Exzessory */
#define C_Spol 0x53706F6CL		/* Flexible Printer Spooler */
#define C_SSND 0x53534E44L		/* Petra */
#define C_STAT 0x53544154L		/* StaTOS */
#define C_ST_C 0x53542D43L		/* ST-C : Cache Program */
#define C_STEW 0x53544557L		/* Stewart */
#define C_STFA 0x53544641L		/* Sound treiber für atari */
#define C_STiK 0x5354694BL		/* ST Internet Kit */
#define C_STMS 0x53544D53L		/* ST Magazine Screendump */
#define C_STRX 0x53545258L		/* SAT-Trax Antenna driver */
#define C_SVGA 0x53564741L		/* Super VGA Emulator */
#define C_SWAP 0x53574150L		/* Outside */
#define C_SYMB 0x53594D42L		/* Symbol driver */
#define C_SYNL 0x53594E4CL		/* Dynamic Link Library Driver */
#define C_SYNT 0x53594E54L		/* Syntex */
#define C_SysE 0x53797345L		/* System Editor */
#define C_Syso 0x5379736FL		/* ST Sysop */
#define C_SZ_M 0x535A5F4DL		/* Dynamic Mouse Speeder */
#define C_TASS 0x54415353L		/* Turbo Assembler */
#define C_TCFS 0x54434653L		/* Turbo C File Selector */
#define C_TCRB 0x54435242L		/* Turbo Cache */
#define C_Tenv 0x54656E76L		/* Environment Set Program for Terminal */
#define C_TFIX 0x54464958L		/* TOS 1.04 fix */
#define C_THNX 0x54484E58L		/* Thinx */
#define C_TIM3 0x54494D33L		/* Time Driver */
#define C_TIM5 0x54494D35L		/* Time Driver plus Screen Blanker */
#define C_TIME 0x54494D45L		/* Led Panel Time */
#define C_TK40 0x544B3430L		/* MC68040 ToolKit */
#define C_Tmon 0x546D6F6EL		/* TempleMon */
#define C_TMon 0x544D6F6EL		/* TempleMon */
#define C_TOpW 0x544F7057L		/* Top Manager Watcher */
#define C_TPat 0x54506174L		/* Tos Patch */
#define C_TRAK 0x5452414BL		/* Track Speed */
#define C_TSEN 0x5453454EL		/* TSE Net */
#define C_TSWP 0x54535750L		/* TonySoft Write Protection */
#define C_TTTF 0x54545446L		/* Thirty Two to Twenty Four */
#define C_TWFS 0x54574653L		/* That's Write File Selector Accessory */
#define C_Typ1 0x54797031L		/* Daisywheel accessory */
#define C_UFSL 0x5546534CL		/* Extended Universal Font Selector */
#define C_UIS3 0x55495333L		/* Universal Item Selector 3 */
#define C_UKB1 0x554B4231L		/* Fastload */
#define C_UKB3 0x554B4233L		/* Fastload plus MIDI Through */
#define C_UN_X 0x554E2A58L		/* UN*X : Unixname (/->\ Converter) */
#define C_USHD 0x55534844L		/* Diskus HD driver */
#define C_USRS 0x55535253L		/* Romspeed */
#define C_USPK 0x5553504BL		/* Hard Disk Auto Parker */
#define C_UTRK 0x5554524BL		/* Ultimate Tracker */
#define C_VDLY 0x56444c59L		/* Videlity */
#define C_VECS 0x56454353L		/* Vecshow */
#define C_VeiL 0x5665694CL		/* Turbo Veille */
#define C_VFIX 0x56464958L		/* VDIFix */
#define C_VFNT 0x56464E54L		/* VdiFont */
#define C_VI_2 0x56492D32L		/* VI-2 : Videl Inside */
#define C_VIRA 0x56495241L		/* Virus Alarm */
#define C_VGAS 0x56474153L		/* VGA Simulator */
#define C_VMEM 0x564D454DL		/* Virtual Memory */
#define C_VRAM 0x5652414DL		/* Virtual Memory Management for the TT */
#define C_VREP 0x56524550L		/* Vector Guard */
#define C_VSco 0x5653636FL		/* Virus Scope */
#define C_VSCR 0x56534352L		/* Structure of Virtual Screens */
#define C_VSTM 0x5653544DL		/* MIDI Transfer */
#define C_WARP 0x57415250L		/* Warp 9 */
#define C_WBrd 0x57427264L		/* Bird's Wing */
#define C_WDOG 0x57444F47L		/* Watchdog */
#define C_WEGA 0x57454741L		/* WEGA Libraries */
#define C_WFSL 0x5746534CL		/* Window File Selector */
#define C_WICO 0x5749434FL		/* WinCom */
#define C_WINX 0x57494E58L		/* WINX */
#define C_WINZ 0x57494E5AL		/* L!ftscho!/WinzRAM RAMdisk */
#define C_WPRO 0x5750524FL		/* Write Protect */
#define C_WrAp 0x57724170L		/* WarpMouse */
#define C_XBTN 0x5842544EL		/* Mouse speeder routine from XBOOT */
#define C_XDsk 0x5844736BL		/* X-DISK ramdisk */
#define C_XFS1 0x58465331L		/* Master Module for extended TOS File System */
#define C_xFSL 0x7846534CL		/* Extended Font Selector */
#define C_XFRB 0x58465242L		/* Extended Fast Ram Buffer */
#define C_XHDI 0x58484449L		/* XHDI driver */
#define C_XKBD 0x584B4244L		/* Extended Keyboard */
#define C_XMMU 0x584D4D55L		/* TK40's interface for PMMU setting */
#define C_XMuz 0x584D757AL		/* Ultra Player */
#define C_xNet 0x784E6574L		/* xNet-ST */
#define C_XPCI 0x58504349L		/* Xbios functions for PCIbios */
#define C_xRmt 0x78526D74L		/* XREMOTE */
#define C_XSSI 0x58535349L		/* Extended Screen Saver Information */
#define C_xUFC 0x78554643L		/* Extended Universal Font Selector Configuration Program */
#define C_XWin 0x5857696EL		/* Extended Windows moudle */
#define C_zCAC 0x7A434143L		/* 680x0 Cache Control CPX */
#define C_zDCF 0x7A444346L		/* DCF-Time receiver */
#define C__FSC 0xE4465343L		/* FSC : Falcon Screen */

#define C_MACCEL 0x00AA006EL	/* MACCELL */

#endif
