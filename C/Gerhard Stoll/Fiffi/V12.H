/* Resource Datei Indizes f�r V12 */

#define CONF1    0   /* Formular/Dialog */
#define CONF1_RX_SET 2   /* STRING in Baum CONF1 */
#define CONF1_RX 3   /* FTEXT in Baum CONF1 */
#define CONF1_TX_SET 4   /* STRING in Baum CONF1 */
#define CONF1_TX 5   /* FTEXT in Baum CONF1 */
#define CONF1_LOG_SET 6   /* STRING in Baum CONF1 */
#define CONF1_LOG 7   /* FTEXT in Baum CONF1 */
#define CONF1_BUF_DOWN 11  /* FBOXTEXT in Baum CONF1 */
#define CONF1_BUF_UP 12  /* FBOXTEXT in Baum CONF1 */
#define CONF1_BUF_BOX 13  /* FBOXTEXT in Baum CONF1 */
#define CONF1_BUF 14  /* TEXT in Baum CONF1 */
#define CONF1_SORT_ON 16  /* BUTTON in Baum CONF1 */
#define CONF1_SORT_DESK 17  /* BUTTON in Baum CONF1 */
#define CONF1_LCASE_FLAG 18  /* BUTTON in Baum CONF1 */
#define CONF1_SHOW_FLAG 20  /* BUTTON in Baum CONF1 */
#define CONF1_MAGIC_FS 21  /* BUTTON in Baum CONF1 */
#define CONF1_SAVE_CONF 22  /* BUTTON in Baum CONF1 */
#define CONF1_OK 23  /* BUTTON in Baum CONF1 */
#define CONF1_CANCEL 24  /* BUTTON in Baum CONF1 */
#define CONF1_PING 25  /* BUTTON in Baum CONF1 */
#define CONF1_APPEND 26  /* BUTTON in Baum CONF1 */

#define CONF2    1   /* Formular/Dialog */
#define CONF2_OK 1   /* BUTTON in Baum CONF2 */
#define CONF2_CANCEL 2   /* BUTTON in Baum CONF2 */
#define CONF2_ICON_START 4   /* BUTTON in Baum CONF2 */
#define CONF2_ICON_CON 5   /* BUTTON in Baum CONF2 */
#define CONF2_ICON_DIS 6   /* BUTTON in Baum CONF2 */
#define CONF2_ICON_DIS2 7   /* BUTTON in Baum CONF2 */
#define CONF2_ICON_DIS1 8   /* BUTTON in Baum CONF2 */
#define CONF2_COM_DOWN 16  /* FBOXTEXT in Baum CONF2 */
#define CONF2_COM_UP 17  /* FBOXTEXT in Baum CONF2 */
#define CONF2_COM_BOX 19  /* FBOXTEXT in Baum CONF2 */
#define CONF2_COM 20  /* FTEXT in Baum CONF2 */
#define CONF2_DATA_LDOWN 23  /* FBOXTEXT in Baum CONF2 */
#define CONF2_DATA_LUP 24  /* FBOXTEXT in Baum CONF2 */
#define CONF2_DATA_L_BOX 26  /* FBOXTEXT in Baum CONF2 */
#define CONF2_DATA_L 27  /* FTEXT in Baum CONF2 */
#define CONF2_DATA_HDOWN 29  /* FBOXTEXT in Baum CONF2 */
#define CONF2_DATA_HUP 30  /* FBOXTEXT in Baum CONF2 */
#define CONF2_DATA_H_BOX 31  /* FBOXTEXT in Baum CONF2 */
#define CONF2_DATA_H 32  /* FTEXT in Baum CONF2 */
#define CONF2_TT_ASCII 36  /* BUTTON in Baum CONF2 */
#define CONF2_TT_AUTO 37  /* BUTTON in Baum CONF2 */
#define CONF2_TT_BIN 38  /* BUTTON in Baum CONF2 */
#define CONF2_TT_ASCII_A 41  /* BUTTON in Baum CONF2 */
#define CONF2_TT_BIN_A 42  /* BUTTON in Baum CONF2 */
#define CONF2_PASV_FLAG 44  /* BUTTON in Baum CONF2 */
#define CONF2_NOOP_DOWN 45  /* FBOXTEXT in Baum CONF2 */
#define CONF2_NOOP_UP 46  /* FBOXTEXT in Baum CONF2 */
#define CONF2_NOOP 47  /* BUTTON in Baum CONF2 */
#define CONF2_NOOP_BOX 48  /* FBOXTEXT in Baum CONF2 */
#define CONF2_NOOP_TIME 49  /* FTEXT in Baum CONF2 */

#define FILE_D   2   /* Formular/Dialog */
#define FILE_PATH 2   /* STRING in Baum FILE_D */
#define FILE_OLD 4   /* STRING in Baum FILE_D */
#define FILE_NEW 9   /* FTEXT in Baum FILE_D */
#define FILE_RENAME 13  /* BUTTON in Baum FILE_D */
#define FILE_RENAME_I 14  /* USERDEF in Baum FILE_D */
#define FILE_RESUME 15  /* BUTTON in Baum FILE_D */
#define FILE_RESUME_ALL 17  /* BUTTON in Baum FILE_D */
#define FILE_REPLACE 19  /* BUTTON in Baum FILE_D */
#define FILE_REPLACE_I 20  /* USERDEF in Baum FILE_D */
#define FILE_JUMPOVER 21  /* BUTTON in Baum FILE_D */
#define FILE_JUMPOVER_I 22  /* USERDEF in Baum FILE_D */
#define FILE_REPLACE_ALL 23  /* BUTTON in Baum FILE_D */
#define FILE_REPLACE_A_I 24  /* USERDEF in Baum FILE_D */
#define FILE_JUMPOVER_AL 25  /* BUTTON in Baum FILE_D */
#define FILE_JUMPOVER_AI 26  /* USERDEF in Baum FILE_D */
#define FILE_CANCEL 27  /* BUTTON in Baum FILE_D */
