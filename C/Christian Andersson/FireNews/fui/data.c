#define DATAVOID
#include <stdio.h>
#include "dialog.h"
#undef DATAVOID

/*************************************************************************************************************************/
/*** OBS *** Strings are NOT to be stored like this, but loaded from the language file!!!                      *** OBS ***/
/*************************************************************************************************************************/
static char Text[][100]={
/* 0 */  "Button 0" ,
/* 1 */  "Button 1" ,
/* 2 */  "Button 2" ,
/* 3 */  "Button 3" ,
/* 4 */  "Button 4" ,
/* 5 */  "Button 5" ,
/* 6 */  "Button 6" ,
/* 7 */  "Button 7" ,
/* 8 */  "Button 8" ,
/* 9 */  "Button 9" ,
/* 10 */ "Button 10" ,
/* 11 */ "FireSTorm Atari Center" ,
};

/*************************************************************************************************************************/
static RO_Button Buttons[]={
/*  0 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 0  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  1 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 1  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  2 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 2  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  3 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 3  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  4 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 4  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  5 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 5  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  6 */ { BUTTON_NORMAL , { 0 , 0 , 1 , 0 , 0 } , Text[ 6  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  7 */ { BUTTON_NORMAL , { 0 , 0 , 2 , 0 , 0 } , Text[ 7  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  8 */ { BUTTON_NORMAL , { 0 , 0 , 3 , 0 , 0 } , Text[ 8  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/*  9 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 9  ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
/* 10 */ { BUTTON_NORMAL , { 0 , 0 , 0 , 0 , 0 } , Text[ 10 ] , { -1 , -1 , -1 , -1 } , 0 , 0 },
};

/*************************************************************************************************************************/
static RO_ScrollBar ScrollBars[]={
/*  1 */ { 200 , 0 , 100 , 10 , SCROLLBAR_VERTICAL },
};
/*************************************************************************************************************************/
RO_Object objects[]={
/* 0  */ {"Dummy",NULL          ,NULL          ,NULL          ,RO_DIALOG   ,{0,0,0,0,0,0,0,0,0,0,0,0,0},NULL            ,0,0,0,0,0,{0,0,0,0,0,0}},
/* 1  */ {"Ob 1 ",NULL          ,&objects[ 17 ],NULL          ,RO_DIALOG   ,{0,0,0,0,0,0,0,0,0,0,1,0,0},NULL            ,4,4,0,0,0,{0,0,0,0,0,0}},
/* 2  */ {"Ob 2 ",&objects[  1 ],&objects[  3 ],&objects[ 11 ],RO_GROUP    ,{0,0,0,0,0,0,0,0,0,0,0,0,0},NULL            ,0,0,0,0,0,{0,0,0,0,0,0}},
/* 3  */ {"Ob 3 ",&objects[  2 ],&objects[  4 ],&objects[  5 ],RO_GROUP    ,{0,0,0,0,0,0,0,0,0,0,1,0,0},NULL            ,0,0,0,0,0,{0,0,0,0,0,0}},
/* 4  */ {"Ob 4 ",&objects[  3 ],NULL          ,&objects[ 16 ],RO_TEXTAREA ,{0,0,0,0,0,0,0,0,1,1,0,0,0},NULL            ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 5  */ {"Ob 5 ",&objects[  2 ],&objects[  6 ],&objects[ 18 ],RO_GROUP    ,{0,0,0,0,0,0,0,0,0,0,1,0,0},NULL            ,0,0,0,0,0,{0,0,0,0,0,0}},
/* 6  */ {"Ob 6 ",&objects[  5 ],NULL          ,&objects[  7 ],RO_BUTTON   ,{0,0,0,0,0,0,0,0,0,0,0,0,0},&Buttons[ 0 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 7  */ {"Ob 7 ",&objects[  5 ],NULL          ,&objects[  8 ],RO_BUTTON   ,{0,0,0,0,0,1,0,0,0,0,0,0,0},&Buttons[ 1 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 8  */ {"Ob 8 ",&objects[  5 ],NULL          ,&objects[  9 ],RO_BUTTON   ,{0,0,1,0,0,0,0,0,0,0,0,0,0},&Buttons[ 2 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 9  */ {"Ob 9 ",&objects[  5 ],NULL          ,&objects[ 10 ],RO_BUTTON   ,{0,0,1,1,0,0,0,0,0,0,0,0,0},&Buttons[ 3 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 10 */ {"Ob 10",&objects[  5 ],NULL          ,NULL          ,RO_BUTTON   ,{0,1,0,1,0,0,0,0,0,0,0,0,0},&Buttons[ 4 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 11 */ {"Ob 11",&objects[  1 ],&objects[ 12 ],NULL          ,RO_GROUP    ,{0,0,0,0,0,0,0,0,0,0,0,0,0},NULL            ,0,0,0,0,0,{0,0,0,0,0,0}},
/* 12 */ {"Ob 12",&objects[ 11 ],NULL          ,&objects[ 13 ],RO_BUTTON   ,{0,0,0,0,0,0,0,0,1,0,0,0,0},&Buttons[ 5 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 13 */ {"Ob 13",&objects[ 11 ],NULL          ,&objects[ 14 ],RO_BUTTON   ,{0,0,0,0,0,0,0,0,1,0,0,0,0},&Buttons[ 6 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 14 */ {"Ob 14",&objects[ 11 ],NULL          ,&objects[ 15 ],RO_BUTTON   ,{0,0,0,0,0,0,0,0,1,0,0,0,0},&Buttons[ 7 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 15 */ {"Ob 15",&objects[ 11 ],NULL          ,NULL          ,RO_BUTTON   ,{0,0,0,0,0,0,0,0,1,0,0,0,0},&Buttons[ 8 ]   ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 16 */ {"Ob 16",&objects[  3 ],NULL          ,NULL          ,RO_TEXTAREA ,{0,0,0,0,0,1,0,0,1,0,0,0,0},NULL            ,0,0,4,2,0,{0,0,0,0,0,0}},
/* 17 */ {"Ob 17",&objects[  1 ],NULL          ,&objects[  2 ],RO_STRING   ,{0,0,0,0,0,0,0,0,0,0,0,0,0},&Text[ 11 ]     ,0,0,0,0,0,{0,0,0,0,0,0}},
/* 18 */ {"Ob_18",&objects[  2 ],NULL          ,NULL          ,RO_SCROLLBAR,{0,0,0,0,1,0,0,0,0,1,0,0,0},&ScrollBars[ 0 ],0,0,4,2,0,{0,0,0,0,0,0}}
};
