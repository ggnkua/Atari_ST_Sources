/* resource set indices for GEMAMIGO */

#define GAMEWIN                            0 /* form/dialog */
#define GRID                               1 /* BOX in tree GAMEWIN */
#define CONTROL_PANEL                      2 /* IBOX in tree GAMEWIN */
#define COLOUR                             3 /* BOXTEXT in tree GAMEWIN */
#define HANDICAP                           4 /* FBOXTEXT in tree GAMEWIN */
#define SHOW_REASON                        5 /* BUTTON in tree GAMEWIN */
#define BLACK_PRISONERS                    7 /* FTEXT in tree GAMEWIN */
#define WHITE_PRISONERS                    8 /* FTEXT in tree GAMEWIN */
#define BLACK_IMAGE                        9 /* BOX in tree GAMEWIN */
#define WHITE_IMAGE                       10 /* BOX in tree GAMEWIN */
#define VARIABLE_BUTTONS                  11 /* IBOX in tree GAMEWIN */
#define COUNTING_DONE                     12 /* BUTTON in tree GAMEWIN */
#define RESIGN                            13 /* BUTTON in tree GAMEWIN */
#define NEW_GAME                          14 /* BUTTON in tree GAMEWIN */
#define PASS                              15 /* BUTTON in tree GAMEWIN */
#define DO_VIEW                           16 /* BUTTON in tree GAMEWIN */
#define DO_ABOUT                          17 /* ICON in tree GAMEWIN */

#define HANDICAP_MENU                      1 /* form/dialog */
#define NO_HANDICAP                        1 /* TEXT in tree HANDICAP_MENU */
#define MAX_HANDICAP                      10 /* TEXT in tree HANDICAP_MENU */

#define COLOUR_MENU                        2 /* form/dialog */
#define CHOOSE_BLACK                       1 /* TEXT in tree COLOUR_MENU */
#define CHOOSE_WHITE                       2 /* TEXT in tree COLOUR_MENU */

#define RESULT                             3 /* form/dialog */
#define WHITE_SCORES                       2 /* FTEXT in tree RESULT */
#define BLACK_SCORES                       4 /* FTEXT in tree RESULT */
#define WHITE_IS_WINNER                    6 /* STRING in tree RESULT */
#define BLACK_IS_WINNER                    7 /* STRING in tree RESULT */
#define NO_WINNER                          8 /* STRING in tree RESULT */

#define VIEWWIN                            4 /* form/dialog */
#define COL_HIGHLIGHT                      2 /* IBOX in tree VIEWWIN */
#define COL_LINE                           7 /* IBOX in tree VIEWWIN */
#define COL_BOARD                         12 /* IBOX in tree VIEWWIN */
#define PAT_BOARD                         17 /* IBOX in tree VIEWWIN */
#define BIG_STONE                         23 /* BUTTON in tree VIEWWIN */
#define MID_STONE                         24 /* BUTTON in tree VIEWWIN */
#define SML_STONE                         25 /* BUTTON in tree VIEWWIN */
#define VIEW_SAVE                         26 /* BUTTON in tree VIEWWIN */

#define CHOICELIST                         5 /* form/dialog */
#define CHOICESCROLLBAR                    1 /* IBOX in tree CHOICELIST */
#define CHOICE1                            6 /* BOXTEXT in tree CHOICELIST */
#define CHOICEN                           21 /* BOXTEXT in tree CHOICELIST */

#define ABOUT                              6 /* form/dialog */

#define GAMEWIN_TITLE                      0 /* Free string */

#define VIEWWIN_TITLE                      1 /* Free string */

#define NO_GAME                            2 /* Free string */

#define GAMEOVER                           3 /* Free string */

#define THINKING                           4 /* Free string */

#define CPUPASSED                          5 /* Free string */

#define COUNTUP                            6 /* Free string */

#define NO_CNF                             7 /* Alert string */

