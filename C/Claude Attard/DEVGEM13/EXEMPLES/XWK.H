void xv_opnwk (int *handle, int width, int height);
void xv_updwk (int handle, int *buffer);

