/* Indice du ressource pour DEVGEM3 */

#define MENUBAR  0   /* Arbre menu */
#define T_BUREAU 3   /* TITLE dans l'arbre MENUBAR */
#define T_FICHIER 4   /* TITLE dans l'arbre MENUBAR */
#define M_INFOS  7   /* STRING dans l'arbre MENUBAR */
#define M_POPUP  16  /* STRING dans l'arbre MENUBAR */
#define M_HIERAR 17  /* STRING dans l'arbre MENUBAR */
#define M_QUITTER 18  /* STRING dans l'arbre MENUBAR */

#define BUREAU   1   /* Formulaire/Dialogue */

#define FORMULAIRE 2   /* Formulaire/Dialogue */
#define F_POPUP  2   /* BUTTON dans l'arbre FORMULAIRE */
#define F_CONFIRME 3   /* BUTTON dans l'arbre FORMULAIRE */
#define BOX_SO   4   /* BOX dans l'arbre FORMULAIRE */
#define SOUSOPTION 6   /* STRING dans l'arbre FORMULAIRE */

#define HIERAR   3   /* Formulaire/Dialogue */

#define POPUP1   4   /* Formulaire/Dialogue */
#define DDD      4   /* STRING dans l'arbre POPUP1 */

#define POPUP2   5   /* Formulaire/Dialogue */

#define INFORMATIONS 0   /* Chaine d'alerte */

#define OP_MHIER 1   /* Chaine d'alerte */
