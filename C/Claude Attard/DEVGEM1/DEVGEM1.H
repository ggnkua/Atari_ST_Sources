/* Indice du ressource pour RUBGEM1 */

#define MENU     0   /* Arbre menu */
#define INFORMATIONS 7   /* STRING dans l'arbre MENU */
#define FORMN    16  /* STRING dans l'arbre MENU */
#define FORMW    17  /* STRING dans l'arbre MENU */
#define FENETRED 18  /* STRING dans l'arbre MENU */
#define FENETRET 19  /* STRING dans l'arbre MENU */
#define QUITTER  20  /* STRING dans l'arbre MENU */

#define BUREAU   1   /* Formulaire/Dialogue */

#define FORMULAIRE 2   /* Formulaire/Dialogue */
#define RB1      3   /* BUTTON dans l'arbre FORMULAIRE */
#define RB2      4   /* BUTTON dans l'arbre FORMULAIRE */
#define RB3      5   /* BUTTON dans l'arbre FORMULAIRE */
#define EDIT1    6   /* FTEXT dans l'arbre FORMULAIRE */
#define EDIT2    7   /* FTEXT dans l'arbre FORMULAIRE */
#define FLG      8   /* BOXCHAR dans l'arbre FORMULAIRE */
#define NBRE     9   /* BOXTEXT dans l'arbre FORMULAIRE */
#define FLD      10  /* BOXCHAR dans l'arbre FORMULAIRE */
#define BS       11  /* BUTTON dans l'arbre FORMULAIRE */
#define OK       12  /* BUTTON dans l'arbre FORMULAIRE */
#define ANNULE   13  /* BUTTON dans l'arbre FORMULAIRE */

#define FORMWIND 3   /* Formulaire/Dialogue */
#define T1       2   /* BOX dans l'arbre FORMWIND */
#define T2       3   /* BOX dans l'arbre FORMWIND */
#define T3       4   /* BOX dans l'arbre FORMWIND */
#define NFEN     7   /* BUTTON dans l'arbre FORMWIND */
#define NLIG     8   /* BUTTON dans l'arbre FORMWIND */
#define REMP     9   /* BUTTON dans l'arbre FORMWIND */
#define FW_OK    11  /* BUTTON dans l'arbre FORMWIND */

#define INFOS    0   /* Chaine d'alerte */

#define NOTWIND  1   /* Chaine d'alerte */

#define RESULT   2   /* Chaine d'alerte */
