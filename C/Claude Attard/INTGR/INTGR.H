/* Indice du ressource pour INTGR */

#define PPAL     0   /* Formulaire/Dialogue */
#define SAISIE   2   /* FTEXT dans l'arbre PPAL */
