export vq_vgdos
vq_vgdos:
  move.l #-2,d0
  trap #2
rts
