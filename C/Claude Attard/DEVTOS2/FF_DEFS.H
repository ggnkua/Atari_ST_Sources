	/* Date de la version */
#define DATEVERSION "31/07/95"
	/* Diverses */
#define max(A, B) ((A) > (B) ? (A) : (B))
#define min(A, B) ((A) < (B) ? (A) : (B))
enum {FALSE, TRUE};
#define NOT !
#define BLANK -1
#define ZERO 0
	/* Modes de recherche */
#define MLIS 0
#define MREC 1
#define MEFF 2
	/* FenИtres */
#define NB_WIND 4
#define WPARREC 0
#define WPARLIS 1
#define WLISTE 2
#define WHELP 3
	/* EvВnements */
#define EV_WFORM 100
	/* Codes clavier */
#define HELP 0x6200
#define ARUP 0x4800
#define ARDN 0x5000
#define ARLF 0x4B00
#define ARRT 0x4D00
#define SH_ARUP 0x4838
#define SH_ARDN 0x5032
#define SH_ARLF 0x4B34
#define SH_ARRT 0x4D36
#define ESC 0x011B
#define CLR 0x4700
#define RETURN 0x720D
#define ENTER 0x1C0D

