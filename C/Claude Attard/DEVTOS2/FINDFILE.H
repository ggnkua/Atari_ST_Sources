/* Indice du ressource pour FINDFILE */

#define MENUBAR  0   /* Arbre menu */
#define T_BUREAU 3   /* TITLE dans l'arbre MENUBAR */
#define T_FICHIER 4   /* TITLE dans l'arbre MENUBAR */
#define T_RECHERCHE 5   /* TITLE dans l'arbre MENUBAR */
#define M_INFOS  8   /* STRING dans l'arbre MENUBAR */
#define M_OPEN   17  /* STRING dans l'arbre MENUBAR */
#define M_PRINTL 18  /* STRING dans l'arbre MENUBAR */
#define M_AIDE   19  /* STRING dans l'arbre MENUBAR */
#define M_PREF   20  /* STRING dans l'arbre MENUBAR */
#define M_QUITTER 22  /* STRING dans l'arbre MENUBAR */
#define M_MODELIST 24  /* STRING dans l'arbre MENUBAR */
#define M_MODERECH 25  /* STRING dans l'arbre MENUBAR */
#define M_MODEEFFA 26  /* STRING dans l'arbre MENUBAR */
#define M_ASK    27  /* STRING dans l'arbre MENUBAR */
#define M_PARAMREC 29  /* STRING dans l'arbre MENUBAR */
#define M_PARAMLIS 30  /* STRING dans l'arbre MENUBAR */
#define M_CHERCHER 31  /* STRING dans l'arbre MENUBAR */

#define BUREAU   1   /* Formulaire/Dialogue */
#define B_BOX    1   /* BOX dans l'arbre BUREAU */
#define B_MODE   3   /* STRING dans l'arbre BUREAU */
#define B_CONF   5   /* STRING dans l'arbre BUREAU */
#define B_MOVE   6   /* IBOX dans l'arbre BUREAU */

#define PARAMR   2   /* Formulaire/Dialogue */
#define BOXCHEMINS 1   /* BOX dans l'arbre PARAMR */
#define C_FILTRE1 2   /* FTEXT dans l'arbre PARAMR */
#define C_FILTRE2 3   /* FTEXT dans l'arbre PARAMR */
#define C_FILTRE3 4   /* FTEXT dans l'arbre PARAMR */
#define C_RECLECT 6   /* BUTTON dans l'arbre PARAMR */
#define LECTEURS 7   /* IBOX dans l'arbre PARAMR */
#define LEC_A    8   /* BOXCHAR dans l'arbre PARAMR */
#define LEC_B    9   /* BOXCHAR dans l'arbre PARAMR */
#define LEC_C    10  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_D    11  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_E    12  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_F    13  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_G    14  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_H    15  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_I    16  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_J    17  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_K    18  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_L    19  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_M    20  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_N    21  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_O    22  /* BOXCHAR dans l'arbre PARAMR */
#define LEC_P    23  /* BOXCHAR dans l'arbre PARAMR */
#define C_TOUS   24  /* BUTTON dans l'arbre PARAMR */
#define C_AUCUN  25  /* BUTTON dans l'arbre PARAMR */
#define C_SUPC   26  /* BUTTON dans l'arbre PARAMR */
#define C_RECCHEM 28  /* BUTTON dans l'arbre PARAMR */
#define C_CHEMIN 29  /* BOXTEXT dans l'arbre PARAMR */
#define P_CHEMIN 30  /* BUTTON dans l'arbre PARAMR */
#define P_FILTRE 31  /* BUTTON dans l'arbre PARAMR */
#define P_MODIF  32  /* BUTTON dans l'arbre PARAMR */
#define BOXFILTRE 33  /* BOX dans l'arbre PARAMR */
#define F_DATES  35  /* BUTTON dans l'arbre PARAMR */
#define F_DATAVANT 36  /* BUTTON dans l'arbre PARAMR */
#define F_DATAPRES 37  /* BUTTON dans l'arbre PARAMR */
#define F_DATENTRE 38  /* BUTTON dans l'arbre PARAMR */
#define F_DAT1   39  /* FTEXT dans l'arbre PARAMR */
#define F_DAT2   40  /* FTEXT dans l'arbre PARAMR */
#define F_ARCH   42  /* BUTTON dans l'arbre PARAMR */
#define F_ARCHOUI 43  /* BUTTON dans l'arbre PARAMR */
#define F_ARCHNON 44  /* BUTTON dans l'arbre PARAMR */
#define F_ETAT   46  /* BUTTON dans l'arbre PARAMR */
#define F_ETATLEC 47  /* BUTTON dans l'arbre PARAMR */
#define F_ETATLECECR 48  /* BUTTON dans l'arbre PARAMR */
#define F_HIDE   49  /* BUTTON dans l'arbre PARAMR */
#define BOXMODIF 50  /* BOX dans l'arbre PARAMR */
#define F_MDAT   53  /* BUTTON dans l'arbre PARAMR */
#define F_MDATACT 55  /* BUTTON dans l'arbre PARAMR */
#define F_MDATFIXE 56  /* BUTTON dans l'arbre PARAMR */
#define F_MDATCHOIX 57  /* FTEXT dans l'arbre PARAMR */
#define F_MARCH  58  /* BUTTON dans l'arbre PARAMR */
#define F_MARCHOUI 60  /* BUTTON dans l'arbre PARAMR */
#define F_MARCHNON 61  /* BUTTON dans l'arbre PARAMR */
#define F_MHIDE  62  /* BUTTON dans l'arbre PARAMR */
#define F_MUNHIDEFILE 64  /* BUTTON dans l'arbre PARAMR */
#define F_MHIDEFILE 65  /* BUTTON dans l'arbre PARAMR */
#define F_METAT  66  /* BUTTON dans l'arbre PARAMR */
#define F_MLECECR 68  /* BUTTON dans l'arbre PARAMR */
#define F_MLECSEU 69  /* BUTTON dans l'arbre PARAMR */

#define PARAML   3   /* Formulaire/Dialogue */
#define PL_ARCH  1   /* BUTTON dans l'arbre PARAML */
#define PL_HIDE  2   /* BUTTON dans l'arbre PARAML */
#define PL_ETAT  3   /* BUTTON dans l'arbre PARAML */
#define PL_DATE  4   /* BUTTON dans l'arbre PARAML */
#define PL_SIZE  5   /* BUTTON dans l'arbre PARAML */
#define PL_TOUS  6   /* BUTTON dans l'arbre PARAML */
#define PL_AUCUN 7   /* BUTTON dans l'arbre PARAML */

#define TROUVE   4   /* Formulaire/Dialogue */
#define T_PATH   3   /* STRING dans l'arbre TROUVE */
#define T_NAME   4   /* FTEXT dans l'arbre TROUVE */
#define T_SIZE   5   /* TEXT dans l'arbre TROUVE */
#define T_ARCH   8   /* STRING dans l'arbre TROUVE */
#define T_FARCH  9   /* BUTTON dans l'arbre TROUVE */
#define T_HIDE   11  /* STRING dans l'arbre TROUVE */
#define T_FHIDE  12  /* BUTTON dans l'arbre TROUVE */
#define T_DATE   14  /* STRING dans l'arbre TROUVE */
#define T_DACTU  15  /* BUTTON dans l'arbre TROUVE */
#define T_ETAT   17  /* STRING dans l'arbre TROUVE */
#define T_FETAT  18  /* BUTTON dans l'arbre TROUVE */
#define T_DELETE 19  /* BUTTON dans l'arbre TROUVE */
#define T_MODIF  20  /* BUTTON dans l'arbre TROUVE */
#define T_SKIP   21  /* BUTTON dans l'arbre TROUVE */
#define T_ANN    22  /* BUTTON dans l'arbre TROUVE */

#define EFFACE   5   /* Formulaire/Dialogue */
#define E_PATH   3   /* STRING dans l'arbre EFFACE */
#define E_NAME   5   /* STRING dans l'arbre EFFACE */
#define E_DELETE 6   /* BUTTON dans l'arbre EFFACE */
#define E_SKIP   7   /* BUTTON dans l'arbre EFFACE */
#define E_ANN    8   /* BUTTON dans l'arbre EFFACE */

#define IMG_USER 6   /* Formulaire/Dialogue */
#define RBN      1   /* ICON dans l'arbre IMG_USER */
#define RBS      2   /* ICON dans l'arbre IMG_USER */
#define BCN      3   /* ICON dans l'arbre IMG_USER */
#define BCS      4   /* ICON dans l'arbre IMG_USER */

#define INFORM   7   /* Formulaire/Dialogue */
#define DATEVER  6   /* TEXT dans l'arbre INFORM */

#define REC_LECT 8   /* Formulaire/Dialogue */
#define RL_LEC   2   /* TEXT dans l'arbre REC_LECT */

#define BADDATE  0   /* Chaine d'alerte */

#define NOT_IMP  1   /* Chaine d'alerte */

#define P_REC    2   /* Chaine libre */

#define P_LIS    3   /* Chaine libre */

#define F_AIDE   4   /* Chaine libre */

#define F_LISTE  5   /* Chaine libre */

#define S_SAVELIS 6   /* Chaine libre */

#define OUI      7   /* Chaine libre */

#define NON      8   /* Chaine libre */

#define ARCHOUI  9   /* Chaine libre */

#define ARCHNON  10  /* Chaine libre */

#define MONTRER  11  /* Chaine libre */

#define CACHER   12  /* Chaine libre */

#define LECTSEUL 13  /* Chaine libre */

#define LECTECRI 14  /* Chaine libre */

#define CHOIXCHEM 15  /* Chaine libre */

#define CHOIXLIS 16  /* Chaine libre */

#define LISTE    17  /* Chaine libre */

#define RECHERCHE 18  /* Chaine libre */

#define EFFACEMENT 19  /* Chaine libre */
