/* Indice du ressource pour DEVGEM7 */

#define MENUBAR  0   /* Arbre menu */
#define T_BUREAU 3   /* TITLE dans l'arbre MENUBAR */
#define T_FICHIER 4   /* TITLE dans l'arbre MENUBAR */
#define PROPOS   7   /* STRING dans l'arbre MENUBAR */
#define OPENW    16  /* STRING dans l'arbre MENUBAR */
#define QUITTER  17  /* STRING dans l'arbre MENUBAR */

#define BUREAU   1   /* Formulaire/Dialogue */

#define INFOS    0   /* Chaine d'alerte */

#define NOTIMG   1   /* Chaine d'alerte */

#define NOTWIND  2   /* Chaine d'alerte */
