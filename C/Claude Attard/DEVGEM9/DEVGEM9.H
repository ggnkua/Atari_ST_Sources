/* Indice du ressource pour DEVGEM9 */

#define MENUBAR  0   /* Arbre menu */
#define T_BUREAU 3   /* TITLE dans l'arbre MENUBAR */
#define T_FICHIER 4   /* TITLE dans l'arbre MENUBAR */
#define PROPOS   7   /* STRING dans l'arbre MENUBAR */
#define OPENW    16  /* STRING dans l'arbre MENUBAR */
#define QUITTER  17  /* STRING dans l'arbre MENUBAR */

#define BUREAU   1   /* Formulaire/Dialogue */

#define ICONES   2   /* Formulaire/Dialogue */
#define ICD      1   /* ICON dans l'arbre ICONES */
#define ICP      2   /* ICON dans l'arbre ICONES */
#define ICF      3   /* ICON dans l'arbre ICONES */

#define INFOS    0   /* Chaine d'alerte */

#define NOTWIND  1   /* Chaine d'alerte */
