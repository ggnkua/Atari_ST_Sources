/* Indice du ressource pour DEVGEM10 */

#define MENUBAR  0   /* Arbre menu */
#define T_BUREAU 3   /* TITLE dans l'arbre MENUBAR */
#define T_FICHIER 4   /* TITLE dans l'arbre MENUBAR */
#define M_PROPOS 7   /* STRING dans l'arbre MENUBAR */
#define M_OPEN   16  /* STRING dans l'arbre MENUBAR */
#define M_QUITTER 18  /* STRING dans l'arbre MENUBAR */

#define TOOL     1   /* Formulaire/Dialogue */
#define T_REC    2   /* BUTTON dans l'arbre TOOL */
#define T_CIR    3   /* BUTTON dans l'arbre TOOL */
#define T_ELL    4   /* BUTTON dans l'arbre TOOL */

#define BUREAU   2   /* Formulaire/Dialogue */

#define INFOS    0   /* Chaine d'alerte */

#define NOTWIND  1   /* Chaine d'alerte */
