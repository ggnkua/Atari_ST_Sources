/* Indice du ressource pour DEVGEM4 */

#define DIALOG   0   /* Formulaire/Dialogue */
#define CORBEAU  3   /* BUTTON dans l'arbre DIALOG */
#define ARBRE    5   /* BUTTON dans l'arbre DIALOG */
#define BEC      8   /* BUTTON dans l'arbre DIALOG */
#define FROMAGE  10  /* BUTTON dans l'arbre DIALOG */
#define RENARD   13  /* BUTTON dans l'arbre DIALOG */
#define ODEUR    15  /* BUTTON dans l'arbre DIALOG */
#define TINT     18  /* BUTTON dans l'arbre DIALOG */
#define LANGAGE  20  /* BUTTON dans l'arbre DIALOG */
#define FIN      22  /* BUTTON dans l'arbre DIALOG */

#define POPUP    1   /* Formulaire/Dialogue */

#define BRAVO    0   /* Chaine d'alerte */

#define RATE     1   /* Chaine d'alerte */
