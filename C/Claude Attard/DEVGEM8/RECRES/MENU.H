/* Indice du ressource pour MENU */

#define MENUBAR  0   /* Arbre menu */
