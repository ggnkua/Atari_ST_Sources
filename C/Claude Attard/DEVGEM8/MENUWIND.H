/* Indice du ressource pour MENUWIND */

#define MENUBAR  0   /* Arbre menu */
#define T_BUREAU 3   /* TITLE dans l'arbre MENUBAR */
#define T_FICHIER 4   /* TITLE dans l'arbre MENUBAR */
#define M_PROPOS 7   /* STRING dans l'arbre MENUBAR */
#define M_OPEN   16  /* STRING dans l'arbre MENUBAR */
#define M_QUITTER 18  /* STRING dans l'arbre MENUBAR */

#define MENUW    1   /* Arbre menu */
#define WT_BUREAU 3   /* TITLE dans l'arbre MENUW */
#define WT_OUTILS 4   /* TITLE dans l'arbre MENUW */
#define WT_COULEURS 5   /* TITLE dans l'arbre MENUW */
#define WM_PROPOS1 8   /* STRING dans l'arbre MENUW */
#define WM_PROPOS2 10  /* STRING dans l'arbre MENUW */
#define WM_PROPOS3 11  /* STRING dans l'arbre MENUW */
#define WM_PROPOS4 12  /* STRING dans l'arbre MENUW */
#define WM_PROPOS5 13  /* STRING dans l'arbre MENUW */
#define WM_PROPOS6 14  /* STRING dans l'arbre MENUW */
#define WM_PROPOS7 15  /* STRING dans l'arbre MENUW */
#define WM_PROPOS8 16  /* STRING dans l'arbre MENUW */
#define WM_PROPOS9 17  /* STRING dans l'arbre MENUW */
#define WM_LIGNES 19  /* STRING dans l'arbre MENUW */
#define WM_TRAME 20  /* STRING dans l'arbre MENUW */
#define WM_ELLIPSE 21  /* STRING dans l'arbre MENUW */
#define WM_NOIR  23  /* STRING dans l'arbre MENUW */
#define WM_ROUGE 24  /* STRING dans l'arbre MENUW */
#define WM_VERT  25  /* STRING dans l'arbre MENUW */

#define BUREAU   2   /* Formulaire/Dialogue */

#define INFOS    0   /* Chaine d'alerte */

#define NOTWIND  1   /* Chaine d'alerte */
