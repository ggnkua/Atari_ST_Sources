#define F_OPEN 18  	/* OBJECT in TREE #0 */
#define F_HEADER 20  	/* OBJECT in TREE #0 */
#define F_CLOSE 19  	/* OBJECT in TREE #0 */
#define QUIT 22  	/* OBJECT in TREE #0 */
#define OCEAN 24  	/* OBJECT in TREE #0 */
#define PHASEDIA 25  	/* OBJECT in TREE #0 */
#define PROTOCOL 26  	/* OBJECT in TREE #0 */
#define M_FISH 28  	/* OBJECT in TREE #0 */
#define M_SHARK 29  	/* OBJECT in TREE #0 */
#define M_BAR 30  	/* OBJECT in TREE #0 */
#define M_EMPTY 31  	/* OBJECT in TREE #0 */
#define OCNPARS 33  	/* OBJECT in TREE #0 */
#define PHAPARS 34  	/* OBJECT in TREE #0 */
#define PROPARS 35  	/* OBJECT in TREE #0 */
#define NEW 37  	/* OBJECT in TREE #0 */
#define START 38  	/* OBJECT in TREE #0 */
#define ABOUT_T 2  	/* TREE */
#define STOP 39  	/* OBJECT in TREE #0 */
#define PHAPAR_T 6  	/* TREE */
#define POINTS 2  	/* OBJECT in TREE #6 */
#define FSCAL 3  	/* OBJECT in TREE #6 */
#define SSCAL 4  	/* OBJECT in TREE #6 */
#define TI_OCN 1  	/* OBJECT in TREE #5 */
#define STRING_T 5  	/* TREE */
#define PHA_OK 6  	/* OBJECT in TREE #6 */
#define TI_PRO 2  	/* OBJECT in TREE #5 */
#define CURVE 7  	/* OBJECT in TREE #6 */
#define TI_PHA 3  	/* OBJECT in TREE #5 */
#define HD_1 5  	/* OBJECT in TREE #5 */
#define IN_PRO 4  	/* OBJECT in TREE #5 */
#define HD_2 6  	/* OBJECT in TREE #5 */
#define HD_3 7  	/* OBJECT in TREE #5 */
#define HD_5 9  	/* OBJECT in TREE #5 */
#define HD_4 8  	/* OBJECT in TREE #5 */
#define PH_FISH 10  	/* OBJECT in TREE #5 */
#define PH_SHRKS 11  	/* OBJECT in TREE #5 */
#define AL_WIND 13  	/* OBJECT in TREE #5 */
#define AL_MEM 12  	/* OBJECT in TREE #5 */
#define AL_FILE 14  	/* OBJECT in TREE #5 */
#define AL_APP 15  	/* OBJECT in TREE #5 */
#define OCNPAR_T 1  	/* TREE */
#define NSHARK 4  	/* OBJECT in TREE #1 */
#define SBREED 5  	/* OBJECT in TREE #1 */
#define STARVE 6  	/* OBJECT in TREE #1 */
#define NFISH 9  	/* OBJECT in TREE #1 */
#define FBREED 10  	/* OBJECT in TREE #1 */
#define GENERAL 12  	/* OBJECT in TREE #1 */
#define XWID 13  	/* OBJECT in TREE #1 */
#define YWID 14  	/* OBJECT in TREE #1 */
#define P_OK 16  	/* OBJECT in TREE #1 */
#define FILE_T 3  	/* TREE */
#define PATH 2  	/* OBJECT in TREE #3 */
#define F_OK 4  	/* OBJECT in TREE #3 */
#define MENU_T 0  	/* TREE */
#define FILE 4  	/* OBJECT in TREE #0 */
#define DESK 3  	/* OBJECT in TREE #0 */
#define WINDOWS 5  	/* OBJECT in TREE #0 */
#define PROPAR_T 4  	/* TREE */
#define PARAMS 6  	/* OBJECT in TREE #0 */
#define PLOT 2  	/* OBJECT in TREE #4 */
#define PRO_OK 4  	/* OBJECT in TREE #4 */
#define INTERV 3  	/* OBJECT in TREE #4 */
