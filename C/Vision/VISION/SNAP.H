#ifndef __SNAP
#define __SNAP

int  snap_wimage(char *nom, int x, int y, int nx, int ny) ;
void snap(int setup) ;

#endif
