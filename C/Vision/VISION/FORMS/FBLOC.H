#ifndef __FBLOC
#define __FBLOC

void traite_pbloc(void) ;


#endif
