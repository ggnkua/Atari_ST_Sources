#ifndef __FGENERAL
#define __FGENERAL

/*************************/
/* Param‚trage g‚n‚ral : */
/* Mode d'‚criture       */
/*************************/
void traite_pgeneral(void) ;


#endif
