#ifndef __FROT
#define __FROT

#ifndef __GWINDOWS
#include "gwindows.h"
#endif

void traite_rotation(GEM_WINDOW *gwnd) ;


#endif
