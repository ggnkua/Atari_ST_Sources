#ifndef __FNEWIMG
#define __FNEWIMG

void traite_nouveau(void) ;


#endif
