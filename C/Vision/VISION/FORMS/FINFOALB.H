#ifndef __FINFOALB
#define __FINFOALB

void lstd_input(char *text, char *buf) ;
int show_infos(OBJECT *popup_categorie) ;


#endif
