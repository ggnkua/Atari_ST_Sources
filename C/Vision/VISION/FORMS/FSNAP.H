#ifndef __FSNAP
#define __FSNAP

void snap(int setup) ;


#endif
