#ifndef __FBARATIN
#define __FBARATIN

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

int        FGetBaratin(char *user, char *key) ;
void       display_baratin(void) ;
GEM_WINDOW *display_splash(void) ;

#endif
