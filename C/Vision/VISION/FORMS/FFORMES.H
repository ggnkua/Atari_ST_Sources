#ifndef __FFORMES
#define __FFORMES

void traite_pformes(void) ;


#endif
