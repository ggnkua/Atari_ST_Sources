#ifndef __FLOG
#define __FLOG

void pref_logfile(void) ;


#endif
