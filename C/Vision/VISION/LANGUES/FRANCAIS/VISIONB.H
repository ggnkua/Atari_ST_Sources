/* Indice du ressource pour VISIONB */

#define M_VISION 0   /* Arbre menu */
#define M_BARATIN 12  /* STRING dans l'arbre M_VISION */
#define M_NOUVEAU 21  /* STRING dans l'arbre M_VISION */
#define M_OUVRE  22  /* STRING dans l'arbre M_VISION */
#define M_OUVRES 23  /* STRING dans l'arbre M_VISION */
#define M_FERME  25  /* STRING dans l'arbre M_VISION */
#define M_SAUVE  26  /* STRING dans l'arbre M_VISION */
#define M_SAUVES 27  /* STRING dans l'arbre M_VISION */
#define M_BATCHCONV 29  /* STRING dans l'arbre M_VISION */
#define M_IMPRIME 31  /* STRING dans l'arbre M_VISION */
#define M_QUITTE 33  /* STRING dans l'arbre M_VISION */
#define M_UNDO   35  /* STRING dans l'arbre M_VISION */
#define M_REFAIRE 36  /* STRING dans l'arbre M_VISION */
#define M_CLEARBUF 37  /* STRING dans l'arbre M_VISION */
#define M_COUPE  39  /* STRING dans l'arbre M_VISION */
#define M_COPIE  40  /* STRING dans l'arbre M_VISION */
#define M_COLLE  41  /* STRING dans l'arbre M_VISION */
#define M_NCOLLE 42  /* STRING dans l'arbre M_VISION */
#define M_EFFACE 43  /* STRING dans l'arbre M_VISION */
#define M_SELECTIONNE 44  /* STRING dans l'arbre M_VISION */
#define M_NEGATIF 45  /* STRING dans l'arbre M_VISION */
#define M_SYMETRIE 46  /* STRING dans l'arbre M_VISION */
#define M_CATALOG 47  /* STRING dans l'arbre M_VISION */
#define M_OPOINT 49  /* STRING dans l'arbre M_VISION */
#define M_OPINCEAU 50  /* STRING dans l'arbre M_VISION */
#define M_OKLIGNE 51  /* STRING dans l'arbre M_VISION */
#define M_OCERCLE 52  /* STRING dans l'arbre M_VISION */
#define M_ODISQUE 53  /* STRING dans l'arbre M_VISION */
#define M_OPEINTURE 54  /* STRING dans l'arbre M_VISION */
#define M_OTEXTE 55  /* STRING dans l'arbre M_VISION */
#define M_OTEMP  56  /* STRING dans l'arbre M_VISION */
#define M_OPALETTE 58  /* STRING dans l'arbre M_VISION */
#define M_OTRACE 60  /* STRING dans l'arbre M_VISION */
#define M_OAEROSOL 61  /* STRING dans l'arbre M_VISION */
#define M_OLIGNE 62  /* STRING dans l'arbre M_VISION */
#define M_ORECTANGLE 63  /* STRING dans l'arbre M_VISION */
#define M_OPLAN  64  /* STRING dans l'arbre M_VISION */
#define M_OGOMME 65  /* STRING dans l'arbre M_VISION */
#define M_OLOUPE 66  /* STRING dans l'arbre M_VISION */
#define M_OTABLEAU 67  /* STRING dans l'arbre M_VISION */
#define M_OBLOC  68  /* STRING dans l'arbre M_VISION */
#define M_PLEIN  70  /* STRING dans l'arbre M_VISION */
#define M_PLEINECRAN 71  /* STRING dans l'arbre M_VISION */
#define M_INFO   73  /* STRING dans l'arbre M_VISION */
#define M_CONVERSION 74  /* STRING dans l'arbre M_VISION */
#define M_PGENERAL 76  /* STRING dans l'arbre M_VISION */
#define M_PTEXTE 77  /* STRING dans l'arbre M_VISION */
#define M_PFORMES 78  /* STRING dans l'arbre M_VISION */
#define M_PGOMME 79  /* STRING dans l'arbre M_VISION */
#define M_PREF   81  /* STRING dans l'arbre M_VISION */
#define M_PALETTE 82  /* STRING dans l'arbre M_VISION */
#define M_Z11    85  /* STRING dans l'arbre M_VISION */
#define M_Z21    86  /* STRING dans l'arbre M_VISION */
#define M_Z41    87  /* STRING dans l'arbre M_VISION */
#define M_Z81    88  /* STRING dans l'arbre M_VISION */
#define M_Z161   89  /* STRING dans l'arbre M_VISION */
#define M_TAILLE 91  /* STRING dans l'arbre M_VISION */
#define M_LDV    92  /* STRING dans l'arbre M_VISION */
#define M_MKPALETTE 93  /* STRING dans l'arbre M_VISION */
#define M_CONVOLUTION 94  /* STRING dans l'arbre M_VISION */
#define M_HISTO  95  /* STRING dans l'arbre M_VISION */

#define FORM_BARATIN 1   /* Formulaire/Dialogue */
#define VERSION  2   /* TEXT dans l'arbre FORM_BARATIN */
#define REGISTER 4   /* FTEXT dans l'arbre FORM_BARATIN */
#define BARATIN_OK 5   /* BUTTON dans l'arbre FORM_BARATIN */
#define BARATIN_IMG 6   /* USERDEF dans l'arbre FORM_BARATIN */
#define KEY      8   /* FTEXT dans l'arbre FORM_BARATIN */

#define FORM_PREF 2   /* Formulaire/Dialogue */
#define PREF_PECRAN 1   /* BOX dans l'arbre FORM_PREF */
#define PREF_QUIT 2   /* BOX dans l'arbre FORM_PREF */
#define PREF_CLIP 3   /* BOX dans l'arbre FORM_PREF */
#define PREF_WKIND 4   /* BOX dans l'arbre FORM_PREF */
#define PREF_MVISEUR 5   /* BOX dans l'arbre FORM_PREF */
#define PREF_TPECRAN 6   /* TEXT dans l'arbre FORM_PREF */
#define PREF_TQUIT 7   /* TEXT dans l'arbre FORM_PREF */
#define PREF_TCLIP 8   /* TEXT dans l'arbre FORM_PREF */
#define PREF_TWKIND 9   /* TEXT dans l'arbre FORM_PREF */
#define PREF_TMVISEUR 10  /* TEXT dans l'arbre FORM_PREF */
#define PREF_OK  11  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_SAVE 13  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_CANCEL 14  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_DSP 15  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_PATHS 16  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_CP  18  /* BOXTEXT dans l'arbre FORM_PREF */
#define PREF_DITHER 19  /* BOXTEXT dans l'arbre FORM_PREF */
#define PREF_AIDE 20  /* BOX dans l'arbre FORM_PREF */
#define PREF_TAIDE 21  /* TEXT dans l'arbre FORM_PREF */
#define PREF_LONGFNAME 23  /* BOX dans l'arbre FORM_PREF */
#define PREF_TLONGFNAME 24  /* TEXT dans l'arbre FORM_PREF */
#define PREF_DITHERAUTO 25  /* BOX dans l'arbre FORM_PREF */
#define PREF_TDITHERAUTO 26  /* TEXT dans l'arbre FORM_PREF */
#define PREF_SLDSHOW 27  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_UNDO 28  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_LANGUE 30  /* BOXTEXT dans l'arbre FORM_PREF */
#define PREF_RTZOOM 31  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_LOGFILE 32  /* BUTTON dans l'arbre FORM_PREF */
#define PREF_SPLASH 33  /* BOX dans l'arbre FORM_PREF */
#define PREF_TSPLASH 34  /* TEXT dans l'arbre FORM_PREF */
#define PREF_TOOLBAR 35  /* BOX dans l'arbre FORM_PREF */
#define PREF_TTOOLBAR 36  /* TEXT dans l'arbre FORM_PREF */

#define FORM_INFO 3   /* Formulaire/Dialogue */
#define INFO_NOM 3   /* TEXT dans l'arbre FORM_INFO */
#define INFO_RAM 5   /* TEXT dans l'arbre FORM_INFO */
#define INFO_RESOLX 6   /* FTEXT dans l'arbre FORM_INFO */
#define INFO_RESOLY 7   /* FTEXT dans l'arbre FORM_INFO */
#define INFO_TAILLE 9   /* TEXT dans l'arbre FORM_INFO */
#define INFO_UNITE 10  /* BOXTEXT dans l'arbre FORM_INFO */
#define INFO_COLORS 12  /* TEXT dans l'arbre FORM_INFO */
#define INFO_DISKACCESS 15  /* BOXTEXT dans l'arbre FORM_INFO */
#define INFO_DITHER 17  /* BOXTEXT dans l'arbre FORM_INFO */
#define INFO_COMPRESS 19  /* BOXTEXT dans l'arbre FORM_INFO */
#define INFO_IND2RASTER 21  /* BOXTEXT dans l'arbre FORM_INFO */
#define INFO_STDFORMAT 23  /* BOXTEXT dans l'arbre FORM_INFO */
#define INFO_TOTAL 25  /* BOXTEXT dans l'arbre FORM_INFO */
#define INFO_OK  26  /* BUTTON dans l'arbre FORM_INFO */
#define INFO_CANCEL 27  /* BUTTON dans l'arbre FORM_INFO */

#define FORM_TEXTE 4   /* Formulaire/Dialogue */
#define TEXTE_TNORMAL 3   /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_NORMAL 4   /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_TGRAS 5   /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_GRAS 6   /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_TFIN 7   /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FIN 8   /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_TITALIQUE 9   /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_ITALIQUE 10  /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_TSOULIGNE 11  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_SOULIGNE 12  /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_TCONTOURS 13  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_CONTOURS 14  /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_OK 16  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_CANCEL 17  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_HMOINS 18  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_HPLUS 19  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_RMOINS 21  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_RPLUS 22  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_FONT1 25  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FONT2 26  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FONT3 27  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FONT4 28  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FONT5 29  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FONT6 30  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FONT7 31  /* TEXT dans l'arbre FORM_TEXTE */
#define TEXTE_FONTBOX 32  /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_FONTVUES 33  /* BOX dans l'arbre FORM_TEXTE */
#define TEXTE_FONTPLUS 34  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_FONTMOINS 35  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_TEST 36  /* BUTTON dans l'arbre FORM_TEXTE */
#define TEXTE_NTAILLE 37  /* FTEXT dans l'arbre FORM_TEXTE */
#define TEXTE_VUE 39  /* USERDEF dans l'arbre FORM_TEXTE */
#define TEXTE_ANGLE 40  /* FTEXT dans l'arbre FORM_TEXTE */

#define FORM_GENERAL 5   /* Formulaire/Dialogue */
#define MODE_REMPLACE 3   /* BOX dans l'arbre FORM_GENERAL */
#define MODE_TRANSPARENT 4   /* BOX dans l'arbre FORM_GENERAL */
#define MODE_XOR 5   /* BOX dans l'arbre FORM_GENERAL */
#define MODE_INVTRANS 6   /* BOX dans l'arbre FORM_GENERAL */
#define MODE_TRE 7   /* TEXT dans l'arbre FORM_GENERAL */
#define MODE_TTR 8   /* TEXT dans l'arbre FORM_GENERAL */
#define MODE_TXO 9   /* TEXT dans l'arbre FORM_GENERAL */
#define MODE_TTI 10  /* TEXT dans l'arbre FORM_GENERAL */
#define GENERAL_OK 12  /* BUTTON dans l'arbre FORM_GENERAL */
#define GENERAL_CANCEL 13  /* BUTTON dans l'arbre FORM_GENERAL */
#define MASK_IN  15  /* BOX dans l'arbre FORM_GENERAL */
#define MASK_TIN 16  /* TEXT dans l'arbre FORM_GENERAL */
#define MASK_OUT 17  /* BOX dans l'arbre FORM_GENERAL */
#define MASK_TOUT 18  /* TEXT dans l'arbre FORM_GENERAL */

#define FORM_FORMES 6   /* Formulaire/Dialogue */
#define REMPLIS_MOINS 3   /* BUTTON dans l'arbre FORM_FORMES */
#define REMPLIS_PLUS 4   /* BUTTON dans l'arbre FORM_FORMES */
#define FORME_REMPLIS 5   /* USERDEF dans l'arbre FORM_FORMES */
#define EPAIS_LMOINS 9   /* BUTTON dans l'arbre FORM_FORMES */
#define EPAIS_LPLUS 10  /* BUTTON dans l'arbre FORM_FORMES */
#define MOTIF_LMOINS 12  /* BUTTON dans l'arbre FORM_FORMES */
#define MOTIF_LPLUS 13  /* BUTTON dans l'arbre FORM_FORMES */
#define ST_LMOINS 15  /* BUTTON dans l'arbre FORM_FORMES */
#define ST_LPLUS 16  /* BUTTON dans l'arbre FORM_FORMES */
#define FORM_LIGNE 17  /* USERDEF dans l'arbre FORM_FORMES */
#define ED_LMOINS 19  /* BUTTON dans l'arbre FORM_FORMES */
#define ED_LPLUS 20  /* BUTTON dans l'arbre FORM_FORMES */
#define FORME_OK 21  /* BUTTON dans l'arbre FORM_FORMES */
#define FORME_CANCEL 22  /* BUTTON dans l'arbre FORM_FORMES */
#define TYPE_PMOINS 25  /* BUTTON dans l'arbre FORM_FORMES */
#define TYPE_PPLUS 26  /* BUTTON dans l'arbre FORM_FORMES */
#define H_PMOINS 28  /* BUTTON dans l'arbre FORM_FORMES */
#define H_PPLUS  29  /* BUTTON dans l'arbre FORM_FORMES */
#define FORM_POINT 30  /* USERDEF dans l'arbre FORM_FORMES */
#define SURF_ROUND 32  /* BOX dans l'arbre FORM_FORMES */
#define SURF_PERI 33  /* BOX dans l'arbre FORM_FORMES */
#define SURF_TROUND 34  /* TEXT dans l'arbre FORM_FORMES */
#define SURF_TPERI 35  /* TEXT dans l'arbre FORM_FORMES */

#define ICONES   7   /* Formulaire/Dialogue */
#define POINT    1   /* USERDEF dans l'arbre ICONES */
#define TRACE    2   /* USERDEF dans l'arbre ICONES */
#define PINCEAU  3   /* USERDEF dans l'arbre ICONES */
#define AEROSOL  4   /* USERDEF dans l'arbre ICONES */
#define KLIGNE   5   /* USERDEF dans l'arbre ICONES */
#define LIGNE    6   /* USERDEF dans l'arbre ICONES */
#define CERCLE   7   /* USERDEF dans l'arbre ICONES */
#define RECTANGLE 8   /* USERDEF dans l'arbre ICONES */
#define DISQUE   9   /* USERDEF dans l'arbre ICONES */
#define PLAN     10  /* USERDEF dans l'arbre ICONES */
#define PEINTURE 11  /* USERDEF dans l'arbre ICONES */
#define GOMME    12  /* USERDEF dans l'arbre ICONES */
#define TEXTE    13  /* USERDEF dans l'arbre ICONES */
#define LOUPE    14  /* USERDEF dans l'arbre ICONES */
#define TEMPERATURE 15  /* USERDEF dans l'arbre ICONES */
#define TABLEAU  16  /* USERDEF dans l'arbre ICONES */
#define MAIN     17  /* USERDEF dans l'arbre ICONES */
#define BLOC     18  /* USERDEF dans l'arbre ICONES */
#define PALETTE  19  /* USERDEF dans l'arbre ICONES */
#define ZOOM_BOX 20  /* BOX dans l'arbre ICONES */
#define ZOOM_IN  21  /* BOX dans l'arbre ICONES */
#define ZOOM_VUE 22  /* BOX dans l'arbre ICONES */

#define GOMMES   8   /* Formulaire/Dialogue */
#define TYPE_GOMME 2   /* BOX dans l'arbre GOMMES */
#define GOMME_1  3   /* IMAGE dans l'arbre GOMMES */
#define GOMME_2  4   /* IMAGE dans l'arbre GOMMES */
#define GOMME_3  5   /* IMAGE dans l'arbre GOMMES */
#define GOMME_4  6   /* IMAGE dans l'arbre GOMMES */
#define GOMME_5  7   /* IMAGE dans l'arbre GOMMES */
#define GOMME_6  8   /* IMAGE dans l'arbre GOMMES */
#define GOMME_7  9   /* IMAGE dans l'arbre GOMMES */
#define GOMME_8  10  /* IMAGE dans l'arbre GOMMES */
#define GOMME_OK 11  /* BUTTON dans l'arbre GOMMES */
#define GOMME_CANCEL 12  /* BUTTON dans l'arbre GOMMES */

#define MOUSES   9   /* Formulaire/Dialogue */
#define MGOMME   1   /* ICON dans l'arbre MOUSES */
#define MLOUPE   2   /* ICON dans l'arbre MOUSES */
#define MPENCIL  3   /* ICON dans l'arbre MOUSES */
#define MPEINTURE 4   /* ICON dans l'arbre MOUSES */
#define MTEMP    5   /* ICON dans l'arbre MOUSES */
#define MVISEUR  6   /* ICON dans l'arbre MOUSES */
#define MAEROSOL 7   /* ICON dans l'arbre MOUSES */

#define INPUT_TEXT 10  /* Formulaire/Dialogue */
#define THE_TEXT1 2   /* FTEXT dans l'arbre INPUT_TEXT */
#define THE_TEXT2 3   /* FTEXT dans l'arbre INPUT_TEXT */
#define THE_TEXT3 4   /* FTEXT dans l'arbre INPUT_TEXT */
#define THE_TEXT4 5   /* FTEXT dans l'arbre INPUT_TEXT */
#define INPUT_OK 6   /* BUTTON dans l'arbre INPUT_TEXT */

#define FORM_NEW 11  /* Formulaire/Dialogue */
#define NEW_X    2   /* FBOXTEXT dans l'arbre FORM_NEW */
#define NEW_Y    3   /* FBOXTEXT dans l'arbre FORM_NEW */
#define COLOR_2  5   /* BOX dans l'arbre FORM_NEW */
#define COLOR_4  6   /* BOX dans l'arbre FORM_NEW */
#define COLOR_16 7   /* BOX dans l'arbre FORM_NEW */
#define COLOR_256 8   /* BOX dans l'arbre FORM_NEW */
#define COLOR_T2 9   /* TEXT dans l'arbre FORM_NEW */
#define COLOR_T4 10  /* TEXT dans l'arbre FORM_NEW */
#define COLOR_T16 11  /* TEXT dans l'arbre FORM_NEW */
#define COLOR_T256 12  /* TEXT dans l'arbre FORM_NEW */
#define COLOR_TRUE 13  /* BOX dans l'arbre FORM_NEW */
#define COLOR_TTRUE 14  /* TEXT dans l'arbre FORM_NEW */
#define NEW_OK   18  /* BUTTON dans l'arbre FORM_NEW */
#define NEW_NAME 19  /* FTEXT dans l'arbre FORM_NEW */
#define NEW_DPIX 21  /* FBOXTEXT dans l'arbre FORM_NEW */
#define NEW_DPIY 22  /* FBOXTEXT dans l'arbre FORM_NEW */
#define NEW_CANCEL 24  /* BUTTON dans l'arbre FORM_NEW */

#define FORM_CONVERSION 12  /* Formulaire/Dialogue */
#define CONV_ANAME 3   /* TEXT dans l'arbre FORM_CONVERSION */
#define CONV_ACOL 4   /* TEXT dans l'arbre FORM_CONVERSION */
#define CONV_S2  8   /* BUTTON dans l'arbre FORM_CONVERSION */
#define CONV_S4  9   /* BUTTON dans l'arbre FORM_CONVERSION */
#define CONV_S16 10  /* BUTTON dans l'arbre FORM_CONVERSION */
#define CONV_S256 11  /* BUTTON dans l'arbre FORM_CONVERSION */
#define CONV_OK  14  /* BUTTON dans l'arbre FORM_CONVERSION */
#define CONV_DITHERNO 17  /* BOX dans l'arbre FORM_CONVERSION */
#define CONV_DITHERMAT 18  /* BOX dans l'arbre FORM_CONVERSION */
#define CONV_TDITHERNO 19  /* STRING dans l'arbre FORM_CONVERSION */
#define CONV_TDITHERMAT 20  /* STRING dans l'arbre FORM_CONVERSION */

#define FORM_TABLEAU 13  /* Formulaire/Dialogue */
#define TAB_W    3   /* FTEXT dans l'arbre FORM_TABLEAU */
#define TAB_H    4   /* FTEXT dans l'arbre FORM_TABLEAU */

#define FORM_AEROSOL 14  /* Formulaire/Dialogue */
#define AEROSOL_DENSITE 2   /* FTEXT dans l'arbre FORM_AEROSOL */
#define AEROSOL_PUISS 3   /* FTEXT dans l'arbre FORM_AEROSOL */
#define AEROSOL_OK 4   /* BUTTON dans l'arbre FORM_AEROSOL */

#define FORM_TAILLE 15  /* Formulaire/Dialogue */
#define TAILLE_XPLUS 2   /* BUTTON dans l'arbre FORM_TAILLE */
#define TAILLE_YPLUS 3   /* BUTTON dans l'arbre FORM_TAILLE */
#define TAILLE_PCX 6   /* FTEXT dans l'arbre FORM_TAILLE */
#define TAILLE_PCY 8   /* FTEXT dans l'arbre FORM_TAILLE */
#define TAILLE_XY 9   /* TEXT dans l'arbre FORM_TAILLE */
#define TAILLE_XMOINS 10  /* BUTTON dans l'arbre FORM_TAILLE */
#define TAILLE_YMOINS 11  /* BUTTON dans l'arbre FORM_TAILLE */
#define TAILLE_TPROPOR 12  /* TEXT dans l'arbre FORM_TAILLE */
#define TAILLE_PROPOR 13  /* BOX dans l'arbre FORM_TAILLE */
#define TAILLE_OK 14  /* BUTTON dans l'arbre FORM_TAILLE */
#define TAILLE_CANCEL 15  /* BUTTON dans l'arbre FORM_TAILLE */

#define FORM_SYMETRIE 16  /* Formulaire/Dialogue */
#define SYMETRIE_Y 2   /* BOX dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_X 3   /* BOX dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_XY 4   /* BOX dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_TY 5   /* STRING dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_TX 6   /* STRING dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_TXY 7   /* STRING dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_OK 9   /* BUTTON dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_IMAGE 12  /* BOX dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_TIMAGE 13  /* TEXT dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_BLOC 14  /* BOX dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_TBLOC 15  /* TEXT dans l'arbre FORM_SYMETRIE */
#define SYMETRIE_CANCEL 17  /* BUTTON dans l'arbre FORM_SYMETRIE */

#define FORM_TCPALETTE 17  /* Formulaire/Dialogue */
#define TCPAL_LUM 1   /* BOX dans l'arbre FORM_TCPALETTE */
#define TCPAL_OK 2   /* BUTTON dans l'arbre FORM_TCPALETTE */
#define TCPAL_CANCEL 4   /* BUTTON dans l'arbre FORM_TCPALETTE */
#define TCPAL_LUMPLUS 7   /* BUTTON dans l'arbre FORM_TCPALETTE */
#define TCPAL_LUMSLIDER 9   /* BOX dans l'arbre FORM_TCPALETTE */
#define TCPAL_LUMMOINS 10  /* BUTTON dans l'arbre FORM_TCPALETTE */
#define TCPAL_COLOR 14  /* BOX dans l'arbre FORM_TCPALETTE */
#define TCPAL_RED 15  /* FTEXT dans l'arbre FORM_TCPALETTE */
#define TCPAL_GREEN 16  /* FTEXT dans l'arbre FORM_TCPALETTE */
#define TCPAL_BLUE 17  /* FTEXT dans l'arbre FORM_TCPALETTE */
#define TCPAL_PERCENT 18  /* TEXT dans l'arbre FORM_TCPALETTE */

#define FORM_ETIFF 18  /* Formulaire/Dialogue */
#define TIFF_MOTOROLA 2   /* BOX dans l'arbre FORM_ETIFF */
#define TIFF_INTEL 3   /* BOX dans l'arbre FORM_ETIFF */
#define TIFF_TMOTOROLA 4   /* STRING dans l'arbre FORM_ETIFF */
#define TIFF_TINTEL 5   /* STRING dans l'arbre FORM_ETIFF */
#define TIFF_OK  7   /* BUTTON dans l'arbre FORM_ETIFF */
#define TIFF_DELTA 10  /* BOX dans l'arbre FORM_ETIFF */
#define TIFF_NOTREAT 11  /* BOX dans l'arbre FORM_ETIFF */
#define TIFF_TNOTREAT 12  /* STRING dans l'arbre FORM_ETIFF */
#define TIFF_TDELTA 13  /* STRING dans l'arbre FORM_ETIFF */
#define TIFF_LZW 16  /* BOX dans l'arbre FORM_ETIFF */
#define TIFF_NOCOMPRESS 17  /* BOX dans l'arbre FORM_ETIFF */
#define TIFF_TNOCOMPRESS 18  /* STRING dans l'arbre FORM_ETIFF */
#define TIFF_TLZW 19  /* STRING dans l'arbre FORM_ETIFF */
#define TIFF_CANCEL 21  /* BUTTON dans l'arbre FORM_ETIFF */

#define FORM_PINCEAU 19  /* Formulaire/Dialogue */
#define PINCEAU_TMOINS 3   /* BUTTON dans l'arbre FORM_PINCEAU */
#define PINCEAU_TPLUS 4   /* BUTTON dans l'arbre FORM_PINCEAU */
#define PINCEAU_FMOINS 6   /* BUTTON dans l'arbre FORM_PINCEAU */
#define PINCEAU_FPLUS 7   /* BUTTON dans l'arbre FORM_PINCEAU */
#define PINCEAU_OK 8   /* BUTTON dans l'arbre FORM_PINCEAU */
#define PINCEAU_CANCEL 9   /* BUTTON dans l'arbre FORM_PINCEAU */

#define FORM_MKPALETTE 20  /* Formulaire/Dialogue */
#define MKPAL_BOX 2   /* USERDEF dans l'arbre FORM_MKPALETTE */
#define MKPAL_OK 3   /* BUTTON dans l'arbre FORM_MKPALETTE */
#define MKPAL_CANCEL 4   /* BUTTON dans l'arbre FORM_MKPALETTE */
#define MKPAL_PRED 5   /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_PGREEN 6   /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_PBLUE 7   /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_REDBOX 8   /* BOX dans l'arbre FORM_MKPALETTE */
#define MKPAL_RED 9   /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_GREENBOX 10  /* BOX dans l'arbre FORM_MKPALETTE */
#define MKPAL_GREEN 11  /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_BLUEBOX 12  /* BOX dans l'arbre FORM_MKPALETTE */
#define MKPAL_BLUE 13  /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_LOAD 14  /* BUTTON dans l'arbre FORM_MKPALETTE */
#define MKPAL_SAVE 15  /* BUTTON dans l'arbre FORM_MKPALETTE */
#define MKPAL_RGB 16  /* BOX dans l'arbre FORM_MKPALETTE */
#define MKPAL_TBLUE 17  /* FTEXT dans l'arbre FORM_MKPALETTE */
#define MKPAL_TGREEN 18  /* FTEXT dans l'arbre FORM_MKPALETTE */
#define MKPAL_TRED 19  /* FTEXT dans l'arbre FORM_MKPALETTE */
#define MKPAL_MRED 20  /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_MGREEN 21  /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_MBLUE 22  /* BOXCHAR dans l'arbre FORM_MKPALETTE */
#define MKPAL_CURRCOL 24  /* USERDEF dans l'arbre FORM_MKPALETTE */
#define MKPAL_START 26  /* BUTTON dans l'arbre FORM_MKPALETTE */
#define MKPAL_END 27  /* BUTTON dans l'arbre FORM_MKPALETTE */
#define MKPAL_APPLIQUE 30  /* BUTTON dans l'arbre FORM_MKPALETTE */

#define FORM_PRINT 21  /* Formulaire/Dialogue */
#define PRINT_GROUP 1   /* BOX dans l'arbre FORM_PRINT */
#define PRINT_PAGE 2   /* BOX dans l'arbre FORM_PRINT */
#define PRINT_IMAGE 3   /* BOX dans l'arbre FORM_PRINT */
#define PRINT_XPCMOINS 6   /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_YPCMOINS 7   /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_XPC 9   /* FBOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_YPC 10  /* FBOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_OK 13  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_XPCPLUS 14  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_YPCPLUS 15  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_SIZEX 16  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_SIZEY 17  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_RESOL 18  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_CANCEL 23  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_SIZEPAGEW 24  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_CONFIGPAGE 25  /* BOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_SIZEPAGEH 28  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_ID 29  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TYPE 32  /* BOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_PRINTER 34  /* BOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_CENTREY 36  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_CENTREX 37  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_R90 38  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_KEEPRATIO 39  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_TKEEPRATIO 40  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TCENTREY 41  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TCENTREX 42  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TR90 43  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_FILE 45  /* BOXTEXT dans l'arbre FORM_PRINT */

#define FORM_DSP 22  /* Formulaire/Dialogue */
#define PDSP_USE 2   /* BOX dans l'arbre FORM_DSP */
#define PDSP_TUSE 3   /* TEXT dans l'arbre FORM_DSP */
#define PDSPLOCK_WARN 5   /* BOX dans l'arbre FORM_DSP */
#define PDSPLOCK_TWARN 6   /* TEXT dans l'arbre FORM_DSP */
#define PDSPLOCK_IGNORE 7   /* BOX dans l'arbre FORM_DSP */
#define PDSPLOCK_TIGNORE 8   /* TEXT dans l'arbre FORM_DSP */
#define PDSPLOCK_FORCE 9   /* BOX dans l'arbre FORM_DSP */
#define PDSPLOCK_TFORCE 10  /* TEXT dans l'arbre FORM_DSP */
#define PDSPLOCK_CANCEL 11  /* BOX dans l'arbre FORM_DSP */
#define PDSPLOCK_TCANCEL 12  /* TEXT dans l'arbre FORM_DSP */
#define PDSP_OK  14  /* BUTTON dans l'arbre FORM_DSP */
#define PDSP_CANCEL 15  /* BUTTON dans l'arbre FORM_DSP */

#define FORM_CONVOLUTION 23  /* Formulaire/Dialogue */
#define CONVOL_BOX 4   /* BOX dans l'arbre FORM_CONVOLUTION */
#define CONVOL_SLIDER 5   /* BOX dans l'arbre FORM_CONVOLUTION */
#define CONVOL_PLUS 6   /* BUTTON dans l'arbre FORM_CONVOLUTION */
#define CONVOL_MOINS 7   /* BUTTON dans l'arbre FORM_CONVOLUTION */
#define CONVOL_INFO1 8   /* TEXT dans l'arbre FORM_CONVOLUTION */
#define CONVOL_INFOLAST 13  /* TEXT dans l'arbre FORM_CONVOLUTION */
#define CONVOL_OK 14  /* BUTTON dans l'arbre FORM_CONVOLUTION */
#define CONVOL_CANCEL 15  /* BUTTON dans l'arbre FORM_CONVOLUTION */
#define CONVOL_EDITTHIS 16  /* BUTTON dans l'arbre FORM_CONVOLUTION */
#define CONVOL_OBJIMG 18  /* BOX dans l'arbre FORM_CONVOLUTION */
#define CONVOL_TOBJIMG 19  /* TEXT dans l'arbre FORM_CONVOLUTION */
#define CONVOL_OBJSEL 20  /* BOX dans l'arbre FORM_CONVOLUTION */
#define CONVOL_TOBJSEL 21  /* TEXT dans l'arbre FORM_CONVOLUTION */
#define CONVOL_EDIT33 23  /* BUTTON dans l'arbre FORM_CONVOLUTION */
#define CONVOL_EDIT55 24  /* BUTTON dans l'arbre FORM_CONVOLUTION */
#define CONVOL_RELOAD 25  /* BUTTON dans l'arbre FORM_CONVOLUTION */

#define FORM_FILTRE33 24  /* Formulaire/Dialogue */
#define FILTRE33_NAME 4   /* FTEXT dans l'arbre FORM_FILTRE33 */
#define FILTRE33_DESCRIP 5   /* FTEXT dans l'arbre FORM_FILTRE33 */
#define FILTRE33_SAVE 6   /* BUTTON dans l'arbre FORM_FILTRE33 */
#define FILTRE33_CANCEL 7   /* BUTTON dans l'arbre FORM_FILTRE33 */
#define FILTRE33_E1 8   /* FTEXT dans l'arbre FORM_FILTRE33 */
#define FILTRE33_ELAST 16  /* FTEXT dans l'arbre FORM_FILTRE33 */

#define FORM_FILTRE55 25  /* Formulaire/Dialogue */
#define FILTRE55_NAME 4   /* FTEXT dans l'arbre FORM_FILTRE55 */
#define FILTRE55_DESCRIP 5   /* FTEXT dans l'arbre FORM_FILTRE55 */
#define FILTRE55_E1 6   /* FTEXT dans l'arbre FORM_FILTRE55 */
#define FILTRE55_ELAST 30  /* FTEXT dans l'arbre FORM_FILTRE55 */
#define FILTRE55_OK 31  /* BUTTON dans l'arbre FORM_FILTRE55 */
#define FILTRE55_CANCEL 32  /* BUTTON dans l'arbre FORM_FILTRE55 */

#define FORM_PATH 26  /* Formulaire/Dialogue */
#define PATH_IMG 3   /* FBOXTEXT dans l'arbre FORM_PATH */
#define PATH_FILTRES 5   /* FBOXTEXT dans l'arbre FORM_PATH */
#define PATH_DSP 7   /* FBOXTEXT dans l'arbre FORM_PATH */
#define PATH_OK  8   /* BUTTON dans l'arbre FORM_PATH */
#define PATH_CANCEL 9   /* BUTTON dans l'arbre FORM_PATH */
#define PATH_ALBUM 11  /* FBOXTEXT dans l'arbre FORM_PATH */
#define PATH_LANGUES 13  /* FBOXTEXT dans l'arbre FORM_PATH */
#define PATH_TEMP 15  /* FBOXTEXT dans l'arbre FORM_PATH */
#define PATH_LDV 17  /* FBOXTEXT dans l'arbre FORM_PATH */

#define FORM_ETARGA 27  /* Formulaire/Dialogue */
#define TARGA_16BITS 3   /* BOX dans l'arbre FORM_ETARGA */
#define TARGA_24BITS 4   /* BOX dans l'arbre FORM_ETARGA */
#define TARGA_T16BITS 5   /* STRING dans l'arbre FORM_ETARGA */
#define TARGA_T24BITS 6   /* STRING dans l'arbre FORM_ETARGA */
#define TARGA_FLIPFLOP 8   /* BOX dans l'arbre FORM_ETARGA */
#define TARGA_TFLIPFLOP 9   /* STRING dans l'arbre FORM_ETARGA */
#define TARGA_OK 10  /* BUTTON dans l'arbre FORM_ETARGA */
#define TARGA_CANCEL 11  /* BUTTON dans l'arbre FORM_ETARGA */

#define FORM_ALBUM 28  /* Formulaire/Dialogue */
#define ALBUM_ITEM1 1   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM2 2   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM3 3   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM4 4   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM5 5   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM6 6   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM7 7   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM8 8   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM9 9   /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_ITEM10 10  /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_PPAL 11  /* BOX dans l'arbre FORM_ALBUM */
#define ALBUM_PTPAL 12  /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_BOX 17  /* BOX dans l'arbre FORM_ALBUM */
#define ALBUM_SLIDER 18  /* BOX dans l'arbre FORM_ALBUM */
#define ALBUM_MOINS 19  /* BUTTON dans l'arbre FORM_ALBUM */
#define ALBUM_PLUS 20  /* BUTTON dans l'arbre FORM_ALBUM */
#define ALBUM_NEW 22  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_INFOIMG 23  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_IMAGE 25  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_OK 26  /* BUTTON dans l'arbre FORM_ALBUM */
#define ALBUM_OPEN 27  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_ADDIMG 28  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_INFOS 29  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_ADDFOLDER 30  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_CATEGORIE1 32  /* BOXTEXT dans l'arbre FORM_ALBUM */
#define ALBUM_CATEGORIE2 33  /* BOXTEXT dans l'arbre FORM_ALBUM */
#define ALBUM_CATEGORIE3 34  /* BOXTEXT dans l'arbre FORM_ALBUM */
#define ALBUM_NAME 35  /* TEXT dans l'arbre FORM_ALBUM */
#define ALBUM_REMOVE 36  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_CONFIG 37  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_UPDATE 38  /* USERDEF dans l'arbre FORM_ALBUM */
#define ALBUM_COMMENT 39  /* FTEXT dans l'arbre FORM_ALBUM */
#define ALBUM_WINDOW 40  /* BUTTON dans l'arbre FORM_ALBUM */
#define ALBUM_TOVSS 41  /* USERDEF dans l'arbre FORM_ALBUM */

#define FORM_NEWALBUM 29  /* Formulaire/Dialogue */
#define NEWALBUM_FOLDER 3   /* FBOXTEXT dans l'arbre FORM_NEWALBUM */
#define NEWALBUM_NAME 5   /* FTEXT dans l'arbre FORM_NEWALBUM */
#define NEWALBUM_REM1 7   /* FTEXT dans l'arbre FORM_NEWALBUM */
#define NEWALBUM_REM2 8   /* FTEXT dans l'arbre FORM_NEWALBUM */
#define NEWALBUM_OK 9   /* BUTTON dans l'arbre FORM_NEWALBUM */
#define NEWALBUM_CANCEL 10  /* BUTTON dans l'arbre FORM_NEWALBUM */

#define FORM_FIND 30  /* Formulaire/Dialogue */
#define FIND_FOLDER1 1   /* FTEXT dans l'arbre FORM_FIND */
#define FIND_FOLDER2 2   /* FTEXT dans l'arbre FORM_FIND */
#define FIND_FOLDER3 3   /* FBOXTEXT dans l'arbre FORM_FIND */
#define FIND_FOLDER4 4   /* FBOXTEXT dans l'arbre FORM_FIND */
#define FIND_RECURS 8   /* BOX dans l'arbre FORM_FIND */
#define FIND_TRECURS 11  /* TEXT dans l'arbre FORM_FIND */
#define FIND_OK  12  /* BUTTON dans l'arbre FORM_FIND */
#define FIND_CANCEL 17  /* BUTTON dans l'arbre FORM_FIND */
#define FIND_MASK1 18  /* FBOXTEXT dans l'arbre FORM_FIND */
#define FIND_MASKE1 26  /* FBOXTEXT dans l'arbre FORM_FIND */

#define FORM_ALBUMINFO 31  /* Formulaire/Dialogue */
#define ALBINF_NAME 3   /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_OK 5   /* BUTTON dans l'arbre FORM_ALBUMINFO */
#define ALBINF_REM1 6   /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_REM2 7   /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_RECORDS 9   /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_DELETED 11  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_DATE 14  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_NB1P 15  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_SIZE1P 17  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_NB2P 19  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_SIZE2P 21  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_NB4P 23  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_SIZE4P 25  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_NB8P 27  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_SIZE8P 29  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_NBTC 31  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_SIZETC 33  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_RTDEFCAT 35  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_DEFCAT 36  /* BOXTEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_RDEFCAT 37  /* BOX dans l'arbre FORM_ALBUMINFO */
#define ALBINF_RINICAT 38  /* BOX dans l'arbre FORM_ALBUMINFO */
#define ALBINF_RTINICAT 39  /* TEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_INICAT 40  /* BOXTEXT dans l'arbre FORM_ALBUMINFO */
#define ALBINF_CANCEL 41  /* BUTTON dans l'arbre FORM_ALBUMINFO */

#define FORM_ALBUMCONFIG 32  /* Formulaire/Dialogue */
#define ACONF_VISIBLEUP 3   /* BOXCHAR dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_VISIBLEBOX 4   /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_VISIBLESLD 5   /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_VISIBLEDN 6   /* BOXCHAR dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASKEDUP 8   /* BOXCHAR dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASKEDBOX 9   /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASKEDSLD 10  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASKEDDN 11  /* BOXCHAR dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_VIS2MASK 12  /* USERDEF dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASK2VIS 13  /* USERDEF dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_VISIBLE1 15  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_VISIBLE6 20  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASKED1 22  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASKED6 27  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MASKALL 28  /* BUTTON dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TMONO 31  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MONO 32  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_T4C 33  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_4C 34  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_T16C 35  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_16C 36  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_T256C 37  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_256C 38  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TTC 39  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TC 40  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_OK 43  /* BUTTON dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TART 46  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_ART 47  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TDEGAS 48  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_DEGAS 49  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TGIF 50  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_GIF 51  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TIMG 52  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_IMG 53  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TJPEG 54  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_JPEG 55  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TMAC 56  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_MAC 57  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TNEO 58  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_NEO 59  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TTARGA 60  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TARGA 61  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TTIFF 62  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TIFF 63  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TBMP 64  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_BMP 65  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_CANCEL 67  /* BUTTON dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_TSAVEINDEX 68  /* TEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_SAVEINDEX 69  /* BOX dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_SHIFTST 71  /* BOXTEXT dans l'arbre FORM_ALBUMCONFIG */
#define ACONF_SHIFTEND 73  /* BOXTEXT dans l'arbre FORM_ALBUMCONFIG */

#define FORM_BLOC 33  /* Formulaire/Dialogue */
#define BLOC_TSIMPLE 3   /* TEXT dans l'arbre FORM_BLOC */
#define BLOC_SIMPLE 4   /* BOX dans l'arbre FORM_BLOC */
#define BLOC_TLIBRE 5   /* TEXT dans l'arbre FORM_BLOC */
#define BLOC_LIBRE 6   /* BOX dans l'arbre FORM_BLOC */
#define BLOC_OK  8   /* BUTTON dans l'arbre FORM_BLOC */
#define BLOC_CANCEL 9   /* BUTTON dans l'arbre FORM_BLOC */

#define FORM_ALMIMGINFO 34  /* Formulaire/Dialogue */
#define ALMIMG_EXIST 3   /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_UPDATE 5   /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_NAME 7   /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_REM 9   /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_CATS 11  /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_FORMAT 13  /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_SIZE 15  /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_COLORS 18  /* TEXT dans l'arbre FORM_ALMIMGINFO */
#define ALMIMG_BYTESIZE 20  /* TEXT dans l'arbre FORM_ALMIMGINFO */

#define FORM_INOUT 35  /* Formulaire/Dialogue */
#define INOUT_OPEN 1   /* STRING dans l'arbre FORM_INOUT */
#define INOUT_FORMAT 3   /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_DRIVER 5   /* TEXT dans l'arbre FORM_INOUT */
#define INOUT_VERSION 7   /* TEXT dans l'arbre FORM_INOUT */
#define INOUT_IMPORT1 16  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_IMPORT2 17  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_IMPORT4 18  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_IMPORT8 19  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_IMPORT16 20  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_IMPORT24 21  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_EXPORT1 23  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_EXPORT2 24  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_EXPORT4 25  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_EXPORT8 26  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_EXPORT16 27  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_EXPORT24 28  /* BOXTEXT dans l'arbre FORM_INOUT */
#define INOUT_OK 29  /* BUTTON dans l'arbre FORM_INOUT */
#define INOUT_CANCEL 30  /* BUTTON dans l'arbre FORM_INOUT */
#define INOUT_SAVE 31  /* STRING dans l'arbre FORM_INOUT */
#define INOUT_DECOUP 32  /* BUTTON dans l'arbre FORM_INOUT */

#define FORM_HISTO 36  /* Formulaire/Dialogue */
#define HISTO_OK 6   /* BUTTON dans l'arbre FORM_HISTO */
#define HISTO_ROUGE 7   /* USERDEF dans l'arbre FORM_HISTO */
#define HISTO_VERT 8   /* USERDEF dans l'arbre FORM_HISTO */
#define HISTO_BLEU 9   /* USERDEF dans l'arbre FORM_HISTO */
#define HISTO_INDEX 10  /* USERDEF dans l'arbre FORM_HISTO */
#define HISTO_LASTINDEX 18  /* TEXT dans l'arbre FORM_HISTO */
#define HISTO_GRIS 19  /* TEXT dans l'arbre FORM_HISTO */
#define HISTO_NBCOLORS 20  /* TEXT dans l'arbre FORM_HISTO */

#define FORM_BATCHCONV 37  /* Formulaire/Dialogue */
#define BCONV_SRCPATH 3   /* BOXTEXT dans l'arbre FORM_BATCHCONV */
#define BCONV_DSTPATH 5   /* BOXTEXT dans l'arbre FORM_BATCHCONV */
#define BCONV_DSTFMT 7   /* BOXTEXT dans l'arbre FORM_BATCHCONV */
#define BCONV_OPT 8   /* BUTTON dans l'arbre FORM_BATCHCONV */
#define BCONV_PBCONV 10  /* BOXTEXT dans l'arbre FORM_BATCHCONV */
#define BCONV_OK 11  /* BUTTON dans l'arbre FORM_BATCHCONV */
#define BCONV_CANCEL 12  /* BUTTON dans l'arbre FORM_BATCHCONV */
#define BCONV_DONOTHING 14  /* BOX dans l'arbre FORM_BATCHCONV */
#define BCONV_TDONOTHING 15  /* STRING dans l'arbre FORM_BATCHCONV */
#define BCONV_REMOVESRC 16  /* BOX dans l'arbre FORM_BATCHCONV */
#define BCONV_TREMOVESRC 17  /* STRING dans l'arbre FORM_BATCHCONV */
#define BCONV_MOVESRC 18  /* BOX dans l'arbre FORM_BATCHCONV */
#define BCONV_TMOVESRC 19  /* STRING dans l'arbre FORM_BATCHCONV */
#define BCONV_MOVEDEST 20  /* BOXTEXT dans l'arbre FORM_BATCHCONV */
#define BCONV_ERASEDST 21  /* BOX dans l'arbre FORM_BATCHCONV */
#define BCONV_TERASEDST 22  /* STRING dans l'arbre FORM_BATCHCONV */

#define FORM_SLIDESHOW 38  /* Formulaire/Dialogue */
#define SLDSHOW_CANCEL 2   /* BUTTON dans l'arbre FORM_SLIDESHOW */
#define SLDSHOW_OK 3   /* BUTTON dans l'arbre FORM_SLIDESHOW */
#define SSH_TRANSITION 5   /* BOXTEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_CYCLE 6   /* BOX dans l'arbre FORM_SLIDESHOW */
#define SSH_TCYCLE 7   /* TEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_WAITMINI 8   /* FBOXTEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_CLSSCREEN 10  /* BOX dans l'arbre FORM_SLIDESHOW */
#define SSH_TCLSSCREEN 11  /* TEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_FOND 13  /* BOXTEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_SHOWNAME 14  /* BOX dans l'arbre FORM_SLIDESHOW */
#define SSH_TSHOWNAME 15  /* TEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_TAFFZOOM 16  /* TEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_TAFFREDUC 17  /* TEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_AFFZOOM 18  /* BOX dans l'arbre FORM_SLIDESHOW */
#define SSH_AFFREDUC 19  /* BOX dans l'arbre FORM_SLIDESHOW */
#define SSH_SHOWPROG 20  /* BOX dans l'arbre FORM_SLIDESHOW */
#define SSH_TSHOWPROG 21  /* TEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_TNOTIMER 22  /* TEXT dans l'arbre FORM_SLIDESHOW */
#define SSH_NOTIMER 23  /* BOX dans l'arbre FORM_SLIDESHOW */

#define FORM_SHAREWARE 39  /* Formulaire/Dialogue */
#define SHARE_WAIT 10  /* FTEXT dans l'arbre FORM_SHAREWARE */
#define SHARE_REGISTER 17  /* BUTTON dans l'arbre FORM_SHAREWARE */
#define SHARE_CANCEL 18  /* BUTTON dans l'arbre FORM_SHAREWARE */

#define FORM_UNDO 40  /* Formulaire/Dialogue */
#define UNDO_NEVER 3   /* BOX dans l'arbre FORM_UNDO */
#define UNDO_KO  4   /* BOX dans l'arbre FORM_UNDO */
#define UNDO_ALWAYS 5   /* BOX dans l'arbre FORM_UNDO */
#define UNDO_TALWAYS 6   /* TEXT dans l'arbre FORM_UNDO */
#define UNDO_TKO 7   /* TEXT dans l'arbre FORM_UNDO */
#define UNDO_TNEVER 8   /* TEXT dans l'arbre FORM_UNDO */
#define UNDO_SMART 9   /* BOX dans l'arbre FORM_UNDO */
#define UNDO_TSMART 10  /* TEXT dans l'arbre FORM_UNDO */
#define UNDO_TNBKO 11  /* FTEXT dans l'arbre FORM_UNDO */
#define UNDO_TNBNEVER 13  /* FTEXT dans l'arbre FORM_UNDO */
#define UNDO_OK  16  /* BUTTON dans l'arbre FORM_UNDO */
#define UNDO_CANCEL 17  /* BUTTON dans l'arbre FORM_UNDO */

#define FORM_ZOOMRT 41  /* Formulaire/Dialogue */
#define ZOOMRT_SCREEN 3   /* BOX dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_IMG 4   /* BOX dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_TIMG 5   /* TEXT dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_TSCREEN 6   /* STRING dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_SMART 7   /* BOX dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_TSMART 8   /* TEXT dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_OK 10  /* BUTTON dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_CANCEL 11  /* BUTTON dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_LEVEL 12  /* BOXTEXT dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_DECSIZE 14  /* BUTTON dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_INCSIZE 15  /* BUTTON dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_SIZE 17  /* TEXT dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_USEGEM 18  /* BOX dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_TUSEGEM 19  /* STRING dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_VALID 20  /* BOX dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_TVALID 21  /* STRING dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_OPTPOS 22  /* BOX dans l'arbre FORM_ZOOMRT */
#define ZOOMRT_TOPTPOS 23  /* STRING dans l'arbre FORM_ZOOMRT */

#define FORM_EJPEG 42  /* Formulaire/Dialogue */
#define JPEG_OK  2   /* BUTTON dans l'arbre FORM_EJPEG */
#define JPEG_CANCEL 3   /* BUTTON dans l'arbre FORM_EJPEG */
#define JPEG_QUALITY 4   /* FTEXT dans l'arbre FORM_EJPEG */

#define FORM_LOG 43  /* Formulaire/Dialogue */
#define LOG_ADD  2   /* BOX dans l'arbre FORM_LOG */
#define LOG_FILE 4   /* BOXTEXT dans l'arbre FORM_LOG */
#define LOG_TADD 5   /* TEXT dans l'arbre FORM_LOG */
#define LOG_OK   6   /* BUTTON dans l'arbre FORM_LOG */
#define LOG_CANCEL 7   /* BUTTON dans l'arbre FORM_LOG */

#define FORM_SNAP 44  /* Formulaire/Dialogue */
#define SNAP_SCREEN 3   /* BOX dans l'arbre FORM_SNAP */
#define SNAP_BLOC 4   /* BOX dans l'arbre FORM_SNAP */
#define SNAP_TBLOC 5   /* TEXT dans l'arbre FORM_SNAP */
#define SNAP_TSCREEN 6   /* STRING dans l'arbre FORM_SNAP */
#define SNAP_OK  8   /* BUTTON dans l'arbre FORM_SNAP */
#define SNAP_CANCEL 9   /* BUTTON dans l'arbre FORM_SNAP */
#define SNAP_MOUSE 10  /* BOX dans l'arbre FORM_SNAP */
#define SNAP_TMOUSE 11  /* STRING dans l'arbre FORM_SNAP */

#define FORM_DECOUP 45  /* Formulaire/Dialogue */
#define DECOUP_VALID 2   /* BOX dans l'arbre FORM_DECOUP */
#define DECOUP_TVALID 3   /* TEXT dans l'arbre FORM_DECOUP */
#define DECOUP_X 4   /* FTEXT dans l'arbre FORM_DECOUP */
#define DECOUP_Y 5   /* FTEXT dans l'arbre FORM_DECOUP */
#define DECOUP_OK 6   /* BUTTON dans l'arbre FORM_DECOUP */
#define DECOUP_CANCEL 7   /* BUTTON dans l'arbre FORM_DECOUP */
#define DECOUP_NUM 8   /* FTEXT dans l'arbre FORM_DECOUP */

#define FORM_EHTML 46  /* Formulaire/Dialogue */
#define EHTML_TITLE 2   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_BACK 3   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_NBLINES 4   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_NBROWS 5   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_TABSIZE 6   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_WBORDER 7   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_LPREV 8   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_LNEXT 9   /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_LPAGE 10  /* FTEXT dans l'arbre FORM_EHTML */
#define EHTML_TSHOWNAMES 11  /* STRING dans l'arbre FORM_EHTML */
#define EHTML_SHOWNAMES 12  /* BOX dans l'arbre FORM_EHTML */
#define EHTML_TLINKIMG 13  /* STRING dans l'arbre FORM_EHTML */
#define EHTML_LINKIMG 14  /* BOX dans l'arbre FORM_EHTML */
#define EHTML_SAVE 15  /* BUTTON dans l'arbre FORM_EHTML */
#define EHTML_CANCEL 16  /* BUTTON dans l'arbre FORM_EHTML */

#define FORM_IMGBROWSER 47  /* Formulaire/Dialogue */
#define IMGB_TEXT 1   /* TEXT dans l'arbre FORM_IMGBROWSER */
#define IMGB_OPEN 2   /* USERDEF dans l'arbre FORM_IMGBROWSER */
#define IMGB_PREVIOUS 3   /* USERDEF dans l'arbre FORM_IMGBROWSER */
#define IMGB_NEXT 4   /* USERDEF dans l'arbre FORM_IMGBROWSER */
#define IMGB_DELETE 5   /* USERDEF dans l'arbre FORM_IMGBROWSER */
#define IMGB_EDIT 6   /* USERDEF dans l'arbre FORM_IMGBROWSER */
#define IMGB_PRINT 7   /* USERDEF dans l'arbre FORM_IMGBROWSER */
#define IMGB_SCALE 8   /* BOXTEXT dans l'arbre FORM_IMGBROWSER */
#define IMGB_TEXT2 9   /* TEXT dans l'arbre FORM_IMGBROWSER */

#define FORM_LDV 48  /* Formulaire/Dialogue */
#define LDV_CLOSE 1   /* BUTTON dans l'arbre FORM_LDV */
#define LDV_ITEM1 3   /* TEXT dans l'arbre FORM_LDV */
#define LDV_ITEM2 4   /* TEXT dans l'arbre FORM_LDV */
#define LDV_ITEM3 5   /* TEXT dans l'arbre FORM_LDV */
#define LDV_ITEM4 6   /* TEXT dans l'arbre FORM_LDV */
#define LDV_ITEM5 7   /* TEXT dans l'arbre FORM_LDV */
#define LDV_ITEM6 8   /* TEXT dans l'arbre FORM_LDV */
#define LDV_ITEM7 9   /* TEXT dans l'arbre FORM_LDV */
#define LDV_ITEM8 10  /* TEXT dans l'arbre FORM_LDV */
#define LDV_BOX  11  /* BOX dans l'arbre FORM_LDV */
#define LDV_SLIDER 12  /* BOX dans l'arbre FORM_LDV */
#define LDV_MOINS 13  /* BUTTON dans l'arbre FORM_LDV */
#define LDV_PLUS 14  /* BUTTON dans l'arbre FORM_LDV */
#define LDV_REFRESH 15  /* BUTTON dans l'arbre FORM_LDV */
#define LDV_DETAIL 16  /* BUTTON dans l'arbre FORM_LDV */
#define LDV_LONGNAME 22  /* TEXT dans l'arbre FORM_LDV */
#define LDV_TYPE 23  /* TEXT dans l'arbre FORM_LDV */
#define LDV_VERSION 24  /* TEXT dans l'arbre FORM_LDV */
#define LDV_AUTHORS 25  /* TEXT dans l'arbre FORM_LDV */
#define LDV_DESC1 26  /* TEXT dans l'arbre FORM_LDV */
#define LDV_DESC2 27  /* TEXT dans l'arbre FORM_LDV */
#define LDV_SELECT 28  /* BUTTON dans l'arbre FORM_LDV */
#define LDV_COMPAT 29  /* BOX dans l'arbre FORM_LDV */
#define LDV_TCOMPAT 30  /* TEXT dans l'arbre FORM_LDV */

#define FORM_LDVDETAIL 49  /* Formulaire/Dialogue */
#define LDVD_CLOSE 1   /* BUTTON dans l'arbre FORM_LDVDETAIL */
#define LDVD_GROUPDET 2   /* BOX dans l'arbre FORM_LDVDETAIL */
#define LDVD_NPLANES 4   /* BOXTEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_FORMAT 6   /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_NBPLANESOUT 8   /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_SUPPORT 10  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_AFFECTPAL 11  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_RTPREVIEW 12  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_OPINPLACE 13  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_CANCEL 14  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_TFEATURES 15  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_LANGUAGES 16  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_DESC2 18  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_DESC1 19  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_AUTHORS 21  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_VERSION 23  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_TYPE 25  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_LONGNAME 27  /* TEXT dans l'arbre FORM_LDVDETAIL */
#define LDVD_FILENAME 29  /* TEXT dans l'arbre FORM_LDVDETAIL */

#define FORM_ICONS 50  /* Formulaire/Dialogue */
#define ICN_WCAT 1   /* USERDEF dans l'arbre FORM_ICONS */
#define ICN_IBROWSER 2   /* USERDEF dans l'arbre FORM_ICONS */

#define FORM_LDVAPPLY 51  /* Formulaire/Dialogue */
#define LDVA_SRC 2   /* USERDEF dans l'arbre FORM_LDVAPPLY */
#define LDVA_DST 3   /* USERDEF dans l'arbre FORM_LDVAPPLY */
#define LDVA_SEL 4   /* BOX dans l'arbre FORM_LDVAPPLY */
#define LDVA_TSEL 5   /* TEXT dans l'arbre FORM_LDVAPPLY */
#define LDVA_LIMITD1 6   /* TEXT dans l'arbre FORM_LDVAPPLY */
#define LDVA_VAL1 7   /* TEXT dans l'arbre FORM_LDVAPPLY */
#define LDVA_LIMITU1 8   /* TEXT dans l'arbre FORM_LDVAPPLY */
#define LDVA_LESS1 9   /* BUTTON dans l'arbre FORM_LDVAPPLY */
#define LDVA_BOX1 10  /* BOX dans l'arbre FORM_LDVAPPLY */
#define LDVA_SLD1 11  /* BOX dans l'arbre FORM_LDVAPPLY */
#define LDVA_PLUS1 12  /* BUTTON dans l'arbre FORM_LDVAPPLY */
#define LDVA_PARAM1 13  /* TEXT dans l'arbre FORM_LDVAPPLY */
#define LDVA_LESS2 17  /* BUTTON dans l'arbre FORM_LDVAPPLY */
#define LDVA_OK  38  /* BUTTON dans l'arbre FORM_LDVAPPLY */
#define LDVA_PREVIEW 39  /* BUTTON dans l'arbre FORM_LDVAPPLY */
#define LDVA_CANCEL 40  /* BUTTON dans l'arbre FORM_LDVAPPLY */
