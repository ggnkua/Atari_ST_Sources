/* Indice du ressource pour STD */

#define FORM_PROG 0   /* Formulaire/Dialogue */
#define PROG_DSPON 1   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TITRE1 2   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TITRE2 3   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TITRE3 4   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TOTALPC 5   /* BOX dans l'arbre FORM_PROG */
#define PROG_PC  6   /* BOX dans l'arbre FORM_PROG */
#define PROG_TPC 9   /* TEXT dans l'arbre FORM_PROG */
#define PROG_030 11  /* TEXT dans l'arbre FORM_PROG */
#define PROG_TPCTXT 12  /* TEXT dans l'arbre FORM_PROG */

#define FORM_INPUT 1   /* Formulaire/Dialogue */
#define INPUT_TITLE 1   /* TEXT dans l'arbre FORM_INPUT */
#define INPUT_TEXT 2   /* FTEXT dans l'arbre FORM_INPUT */
#define INPUT_OK 3   /* BUTTON dans l'arbre FORM_INPUT */
#define INPUT_CANCEL 4   /* BUTTON dans l'arbre FORM_INPUT */

#define FORM_MLINES 2   /* Formulaire/Dialogue */
#define MLINES_FIRSTMSG 1   /* TEXT dans l'arbre FORM_MLINES */
#define MLINES_LASTMSG 8   /* TEXT dans l'arbre FORM_MLINES */
#define MLINES_OK 9   /* BUTTON dans l'arbre FORM_MLINES */
#define MLINES_CANCEL 10  /* BUTTON dans l'arbre FORM_MLINES */
