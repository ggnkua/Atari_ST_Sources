/* Indice du ressource pour MLINES */

#define FORM_MLINES 0   /* Formulaire/Dialogue */
#define PROG_TITRE1 1   /* TEXT dans l'arbre FORM_MLINES */
#define MLINES_OK 10  /* BUTTON dans l'arbre FORM_MLINES */
#define MLINES_CANCEL 11  /* BUTTON dans l'arbre FORM_MLINES */
