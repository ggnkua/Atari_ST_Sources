/* resource set indices for TINYDEMO */

#define TREE001    0 /* menu */

#define TREE002    1 /* form/dialog */

#define TREE003    2 /* unknown form */

#define TREE004    3 /* form/dialog */

#define TREE005    4 /* form/dialog */

