; Generated by mit2mot v1.0.4 on Apr 08 2000 12:49:36

	.globl	_aes
	.globl	_vdi
	.globl	_vq_gdos
	.globl	_vq_vgdos

_aes:	move.l	4(sp), d1
	move.w	#200, d0
	trap	#2
	rts

_vdi:	move.l	4(sp), d1
	move.w	#115, d0
	trap	#2
	rts

_vq_gdos:
	move.w	#-2, d0
	trap	#2
	cmp.w	#-2, d0
	sne	d0
	ext.w	d0
	rts

_vq_vgdos:
	moveq	#-2, d0
	trap	#2
	rts
