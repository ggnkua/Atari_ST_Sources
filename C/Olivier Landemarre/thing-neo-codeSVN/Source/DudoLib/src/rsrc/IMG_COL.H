/* Resource Datei Indizes f�r IMG_COL */

#define USERIMG  0   /* Formular/Dialog */
