 /*  Resource C-Header-File v1.97 f�r ResourceMaster ab v2.06 by ARDISOFT  */

#define LANGUAGE 0  /* form/dial */
#define LANGFONT 1  /* STRING in tree LANGUAGE */
#define LANGDATE 2  /* STRING in tree LANGUAGE */
#define LANGTIME 3  /* STRING in tree LANGUAGE */
#define LANGOSVER 4  /* STRING in tree LANGUAGE */
#define LANGMGXVER 5  /* STRING in tree LANGUAGE */
#define LANGSCR1 6  /* STRING in tree LANGUAGE */
#define LANGSCR2 7  /* STRING in tree LANGUAGE */
#define LANGT2GVER 8  /* STRING in tree LANGUAGE */
#define LANGT2GMISS 9  /* STRING in tree LANGUAGE */
#define LANGCHAR 10  /* STRING in tree LANGUAGE */
#define LANGDATE1 11  /* STRING in tree LANGUAGE */
#define LANGDATE2 12  /* STRING in tree LANGUAGE */
#define LANGTIME1 13  /* STRING in tree LANGUAGE */
#define LANGVER 14  /* STRING in tree LANGUAGE */
#define LANGTVER 15  /* STRING in tree LANGUAGE */

#define MAINMENU 1  /* menu */
#define MACC 3  /* TITLE in tree MAINMENU */
#define MFILE 4  /* TITLE in tree MAINMENU */
#define MEDIT 5  /* TITLE in tree MAINMENU */
#define MINDEX 6  /* TITLE in tree MAINMENU */
#define MWINDOW 7  /* TITLE in tree MAINMENU */
#define MOPTIONS 8  /* TITLE in tree MAINMENU */
#define MTOOL 9  /* TITLE in tree MAINMENU */
#define MABOUT 12  /* STRING in tree MAINMENU */
#define MTFILE 20  /* BOX in tree MAINMENU */
#define MNEW 21  /* STRING in tree MAINMENU */
#define MOPEN 22  /* STRING in tree MAINMENU */
#define MFIND 23  /* STRING in tree MAINMENU */
#define MINFO 24  /* STRING in tree MAINMENU */
#define MCLOSE 26  /* STRING in tree MAINMENU */
#define MSHOW 27  /* STRING in tree MAINMENU */
#define MPRINT 28  /* STRING in tree MAINMENU */
#define MSAVEGROUP 29  /* STRING in tree MAINMENU */
#define MEJECT 31  /* STRING in tree MAINMENU */
#define MFORMAT 33  /* STRING in tree MAINMENU */
#define MQUIT 35  /* STRING in tree MAINMENU */
#define MCUT 37  /* STRING in tree MAINMENU */
#define MCOPY 38  /* STRING in tree MAINMENU */
#define MPASTE 39  /* STRING in tree MAINMENU */
#define MDELETE 40  /* STRING in tree MAINMENU */
#define MSELECTALL 42  /* STRING in tree MAINMENU */
#define MSELECTNONE 43  /* STRING in tree MAINMENU */
#define MTEXT 45  /* STRING in tree MAINMENU */
#define MSYMTEXT 46  /* STRING in tree MAINMENU */
#define MICONS 47  /* STRING in tree MAINMENU */
#define MSORTVICE 49  /* STRING in tree MAINMENU */
#define MSORTFOLD 50  /* STRING in tree MAINMENU */
#define MSORTNAME 51  /* STRING in tree MAINMENU */
#define MSORTSIZE 52  /* STRING in tree MAINMENU */
#define MSORTDATE 53  /* STRING in tree MAINMENU */
#define MSORTEXT 54  /* STRING in tree MAINMENU */
#define MSORTNONE 55  /* STRING in tree MAINMENU */
#define MDEFAULT 57  /* STRING in tree MAINMENU */
#define MMASK 59  /* STRING in tree MAINMENU */
#define MFONT 60  /* STRING in tree MAINMENU */
#define MSAVEINDEX 62  /* STRING in tree MAINMENU */
#define MTWINDOW 63  /* BOX in tree MAINMENU */
#define MNEXTWIN 64  /* STRING in tree MAINMENU */
#define MCLOSEWIN 65  /* STRING in tree MAINMENU */
#define MCLOSEALLWIN 66  /* STRING in tree MAINMENU */
#define MDUPWIN 67  /* STRING in tree MAINMENU */
#define MWIN1 69  /* STRING in tree MAINMENU */
#define MWIN2 70  /* STRING in tree MAINMENU */
#define MWIN3 71  /* STRING in tree MAINMENU */
#define MWIN4 72  /* STRING in tree MAINMENU */
#define MWIN5 73  /* STRING in tree MAINMENU */
#define MWIN6 74  /* STRING in tree MAINMENU */
#define MWIN7 75  /* STRING in tree MAINMENU */
#define MWIN8 76  /* STRING in tree MAINMENU */
#define MWIN9 77  /* STRING in tree MAINMENU */
#define MWIN10 78  /* STRING in tree MAINMENU */
#define MTEXTRA 79  /* BOX in tree MAINMENU */
#define MAPPL 80  /* STRING in tree MAINMENU */
#define MFUNC 81  /* STRING in tree MAINMENU */
#define MCONFIG 82  /* STRING in tree MAINMENU */
#define MHOTKEYS 84  /* STRING in tree MAINMENU */
#define MHKACTIVE 85  /* STRING in tree MAINMENU */
#define MDRIVE 87  /* STRING in tree MAINMENU */
#define MCHANGEREZ 88  /* STRING in tree MAINMENU */
#define MEDITICONS 89  /* STRING in tree MAINMENU */
#define MLOADICONS 90  /* STRING in tree MAINMENU */
#define MCONSOLE 92  /* STRING in tree MAINMENU */
#define MFONTSEL 94  /* STRING in tree MAINMENU */
#define MAUTOSAVE 96  /* STRING in tree MAINMENU */
#define MSAVECONFIG 97  /* STRING in tree MAINMENU */
#define MLOADCONFIG 98  /* STRING in tree MAINMENU */
#define MTOOLS 100  /* STRING in tree MAINMENU */
#define MTOOL1 102  /* STRING in tree MAINMENU */

#define DESKTOP 2  /* form/dial */

#define DESKAPP 3  /* form/dial */

#define ABOUT 4  /* form/dial */
#define ABLOGOHI 2  /* CICON in tree ABOUT */
#define ABLOGOLO 3  /* IMAGE in tree ABOUT */
#define ABVER 4  /* TEXT in tree ABOUT */
#define ABHELP 7  /* BUTTON in tree ABOUT */
#define ABOK 8  /* BUTTON in tree ABOUT */
#define ABINFO 9  /* BUTTON in tree ABOUT */

#define AINFO1 5  /* form/dial */
#define AIOS 3  /* STRING in tree AINFO1 */
#define AIDISPLAY 5  /* STRING in tree AINFO1 */
#define AITOS2GEM 7  /* STRING in tree AINFO1 */
#define AIHELP 21  /* BUTTON in tree AINFO1 */
#define AIOK 22  /* BUTTON in tree AINFO1 */

#define MASK 6  /* form/dial */
#define MAPATH 3  /* STRING in tree MASK */
#define MAMASK 4  /* FBOXTEXT in tree MASK */
#define MALIST 5  /* BOX in tree MASK */
#define MAUP 16  /* BUTTON in tree MASK */
#define MABOX 17  /* BOX in tree MASK */
#define MASLIDE 18  /* BUTTON in tree MASK */
#define MADOWN 19  /* BUTTON in tree MASK */
#define MAHELP 20  /* BUTTON in tree MASK */
#define MAOK 21  /* BUTTON in tree MASK */
#define MACANCEL 22  /* BUTTON in tree MASK */

#define FONT 7  /* form/dial */
#define FOTITLE 1  /* STRING in tree FONT */
#define FOSAMPLE 2  /* IBOX in tree FONT */
#define FOID 3  /* TEXT in tree FONT */
#define FOFONTS 4  /* STRING in tree FONT */
#define FOFONT 6  /* BOXTEXT in tree FONT */
#define FOFONTA 7  /* BUTTON in tree FONT */
#define FOSIZES 8  /* STRING in tree FONT */
#define FOSIZE 10  /* FBOXTEXT in tree FONT */
#define FOSIZEA 11  /* BUTTON in tree FONT */
#define FOFCOLS 12  /* STRING in tree FONT */
#define FOFCOL 14  /* IBOX in tree FONT */
#define FOBCOLS 15  /* STRING in tree FONT */
#define FOBCOL 17  /* IBOX in tree FONT */
#define FOBPATS 18  /* STRING in tree FONT */
#define FOBPAT 20  /* IBOX in tree FONT */
#define FOSATTR 21  /* IBOX in tree FONT */
#define FOATTR1 23  /* BUTTON in tree FONT */
#define FOATTR2 24  /* BUTTON in tree FONT */
#define FOATTR3 25  /* BUTTON in tree FONT */
#define FOATTR4 26  /* BUTTON in tree FONT */
#define FOATTR5 27  /* BUTTON in tree FONT */
#define FOATTR6 28  /* BUTTON in tree FONT */
#define FOATTR7 29  /* BUTTON in tree FONT */
#define FOSVIEW 30  /* IBOX in tree FONT */
#define FOVSIZE 32  /* BUTTON in tree FONT */
#define FOVDATE 33  /* BUTTON in tree FONT */
#define FOVTIME 34  /* BUTTON in tree FONT */
#define FOVFLAG 35  /* BUTTON in tree FONT */
#define FOIMGF 36  /* BUTTON in tree FONT */
#define FOIMG 37  /* TEXT in tree FONT */
#define FOHELP 38  /* BUTTON in tree FONT */
#define FOOK 39  /* BUTTON in tree FONT */
#define FOCANCEL 40  /* BUTTON in tree FONT */

#define FORMAT 8  /* form/dial */
#define FMDRIVEA 4  /* BUTTON in tree FORMAT */
#define FMDRIVEB 5  /* BUTTON in tree FORMAT */
#define FMNAME 7  /* FBOXTEXT in tree FORMAT */
#define FMFORMDD 10  /* BUTTON in tree FORMAT */
#define FMFORMHD 11  /* BUTTON in tree FORMAT */
#define FMQUICK 12  /* BUTTON in tree FORMAT */
#define FMHELP 13  /* BUTTON in tree FORMAT */
#define FMOK 14  /* BUTTON in tree FORMAT */
#define FMCANCEL 15  /* BUTTON in tree FORMAT */

#define PARAM 9  /* form/dial */
#define PATITLE 1  /* STRING in tree PARAM */
#define PATEXT 2  /* FBOXTEXT in tree PARAM */
#define PAHELP 3  /* BUTTON in tree PARAM */
#define PAOK 4  /* BUTTON in tree PARAM */
#define PACANCEL 5  /* BUTTON in tree PARAM */

#define FLINFO 10  /* form/dial */
#define FITITLE 1  /* STRING in tree FLINFO */
#define FLGENERAL 2  /* BUTTON in tree FLINFO */
#define FLPROG 3  /* BUTTON in tree FLINFO */
#define FLATTR 4  /* BUTTON in tree FLINFO */
#define FLSUB 6  /* IBOX in tree FLINFO */
#define FLSATTR 7  /* BOX in tree FLINFO */
#define FLMODE1 8  /* BUTTON in tree FLINFO */
#define FASUID 17  /* BUTTON in tree FLINFO */
#define FAUID 25  /* FBOXTEXT in tree FLINFO */
#define FAGID 27  /* FBOXTEXT in tree FLINFO */
#define FLSPROG 28  /* BOX in tree FLINFO */
#define FPFAST 30  /* BUTTON in tree FLINFO */
#define FPLALT 31  /* BUTTON in tree FLINFO */
#define FPMALT 32  /* BUTTON in tree FLINFO */
#define FPMINMEM 33  /* BUTTON in tree FLINFO */
#define FLPMEMS 34  /* STRING in tree FLINFO */
#define FLPMEM 36  /* TEXT in tree FLINFO */
#define FPSHARED 37  /* BUTTON in tree FLINFO */
#define FPMAGIC 39  /* FBOXTEXT in tree FLINFO */
#define FLSGENERAL 41  /* BOX in tree FLINFO */
#define FILABEL 43  /* FBOXTEXT in tree FLINFO */
#define FIPATH 45  /* STRING in tree FLINFO */
#define FINAME 47  /* FBOXTEXT in tree FLINFO */
#define FILINK 48  /* STRING in tree FLINFO */
#define FILINKDEST 49  /* STRING in tree FLINFO */
#define FLOFILE 50  /* IBOX in tree FLINFO */
#define FISIZE 52  /* STRING in tree FLINFO */
#define FIDATE 54  /* TEXT in tree FLINFO */
#define FITIME 56  /* TEXT in tree FLINFO */
#define FIDATETYPE 57  /* TEXT in tree FLINFO */
#define FLOFOLD 58  /* IBOX in tree FLINFO */
#define FLFILES 60  /* STRING in tree FLINFO */
#define FLFOLDERS 62  /* STRING in tree FLINFO */
#define FLOFLAG 63  /* IBOX in tree FLINFO */
#define FIFLAGRO 65  /* BUTTON in tree FLINFO */
#define FIFLAGH 66  /* BUTTON in tree FLINFO */
#define FIFLAGS 67  /* BUTTON in tree FLINFO */
#define FIFLAGA 68  /* BUTTON in tree FLINFO */
#define FLFKEYS 69  /* STRING in tree FLINFO */
#define FLFKEY 71  /* TEXT in tree FLINFO */
#define FIHOTKEYSEL 72  /* BUTTON in tree FLINFO */
#define FIHOTKEY 73  /* TEXT in tree FLINFO */
#define FIHELP 74  /* BUTTON in tree FLINFO */
#define FIOK 75  /* BUTTON in tree FLINFO */
#define FINEXT 76  /* BUTTON in tree FLINFO */
#define FICANCEL 77  /* BUTTON in tree FLINFO */

#define PAINFO 11  /* form/dial */
#define PNHELP 4  /* BUTTON in tree PAINFO */
#define PNOK 5  /* BUTTON in tree PAINFO */

#define DEVINFO 12  /* form/dial */
#define DVNAME 3  /* STRING in tree DEVINFO */
#define DVLABEL 5  /* FBOXTEXT in tree DEVINFO */
#define DVHELP 8  /* BUTTON in tree DEVINFO */
#define DVOK 9  /* BUTTON in tree DEVINFO */
#define DVNEXT 10  /* BUTTON in tree DEVINFO */
#define DVCANCEL 11  /* BUTTON in tree DEVINFO */

#define DIINFO 13  /* form/dial */
#define DITITLE 1  /* STRING in tree DIINFO */
#define DILABEL 3  /* FBOXTEXT in tree DIINFO */
#define DINAME 5  /* FBOXTEXT in tree DIINFO */
#define DIUSELABEL 6  /* BUTTON in tree DIINFO */
#define DIAUTOINSTALL 7  /* BUTTON in tree DIINFO */
#define DIBTOTAL 9  /* BOX in tree DIINFO */
#define DIBUSED 10  /* BOX in tree DIINFO */
#define DIBVALUE 11  /* STRING in tree DIINFO */
#define DIUSED 13  /* TEXT in tree DIINFO */
#define DIUSEDKB 14  /* TEXT in tree DIINFO */
#define DIFREE 16  /* TEXT in tree DIINFO */
#define DIFREEKB 17  /* TEXT in tree DIINFO */
#define DISIZE 19  /* TEXT in tree DIINFO */
#define DISIZEKB 20  /* TEXT in tree DIINFO */
#define DIHELP 21  /* BUTTON in tree DIINFO */
#define DIOK 22  /* BUTTON in tree DIINFO */
#define DINEXT 23  /* BUTTON in tree DIINFO */
#define DICANCEL 24  /* BUTTON in tree DIINFO */

#define TRASHINFO 14  /* form/dial */
#define TILABEL 3  /* FBOXTEXT in tree TRASHINFO */
#define TIHELP 6  /* BUTTON in tree TRASHINFO */
#define TIOK 7  /* BUTTON in tree TRASHINFO */
#define TINEXT 8  /* BUTTON in tree TRASHINFO */
#define TICANCEL 9  /* BUTTON in tree TRASHINFO */

#define CLIPINFO 15  /* form/dial */
#define CILABEL 3  /* FBOXTEXT in tree CLIPINFO */
#define CIPATH 5  /* FBOXTEXT in tree CLIPINFO */
#define CIHELP 7  /* BUTTON in tree CLIPINFO */
#define CIOK 8  /* BUTTON in tree CLIPINFO */
#define CINEXT 9  /* BUTTON in tree CLIPINFO */
#define CICANCEL 10  /* BUTTON in tree CLIPINFO */

#define PRTINFO 16  /* form/dial */
#define PRLABEL 3  /* FBOXTEXT in tree PRTINFO */
#define PRHELP 7  /* BUTTON in tree PRTINFO */
#define PROK 8  /* BUTTON in tree PRTINFO */
#define PRNEXT 9  /* BUTTON in tree PRTINFO */
#define PRCANCEL 10  /* BUTTON in tree PRTINFO */

#define DAPPINFO 17  /* form/dial */
#define DAGENERAL 2  /* BUTTON in tree DAPPINFO */
#define DAFILES 3  /* BUTTON in tree DAPPINFO */
#define DAOPTIONS 4  /* BUTTON in tree DAPPINFO */
#define DAENV 5  /* BUTTON in tree DAPPINFO */
#define DASUB 7  /* IBOX in tree DAPPINFO */
#define DASGENERAL 8  /* BOX in tree DAPPINFO */
#define DAILABEL 10  /* FBOXTEXT in tree DAPPINFO */
#define DAISEARCH 11  /* BUTTON in tree DAPPINFO */
#define DAINAME 12  /* TEXT in tree DAPPINFO */
#define DAISHORTS 13  /* STRING in tree DAPPINFO */
#define DAISHORT 15  /* TEXT in tree DAPPINFO */
#define DAIUSESEL 16  /* BUTTON in tree DAPPINFO */
#define DAIAPPL 19  /* BUTTON in tree DAPPINFO */
#define DAIWINDOW 20  /* BUTTON in tree DAPPINFO */
#define DAIFILE 21  /* BUTTON in tree DAPPINFO */
#define DAINONLY 24  /* BUTTON in tree DAPPINFO */
#define DAIFPATH 25  /* BUTTON in tree DAPPINFO */
#define DAIPARAM 27  /* FBOXTEXT in tree DAPPINFO */
#define DAIALWAYS 28  /* BUTTON in tree DAPPINFO */
#define DASFILES 29  /* BOX in tree DAPPINFO */
#define DAINAME3 31  /* STRING in tree DAPPINFO */
#define DAIOPEN 33  /* FBOXTEXT in tree DAPPINFO */
#define DAIINDRAG 34  /* BUTTON in tree DAPPINFO */
#define DAIVIEW 36  /* FBOXTEXT in tree DAPPINFO */
#define DAIPRINT 38  /* FBOXTEXT in tree DAPPINFO */
#define DASOPTIONS 39  /* BOX in tree DAPPINFO */
#define DAINAME2 41  /* STRING in tree DAPPINFO */
#define DAOFULL 42  /* BUTTON in tree DAPPINFO */
#define DAOAUTO 43  /* BUTTON in tree DAPPINFO */
#define DAOASKPARM 44  /* BUTTON in tree DAPPINFO */
#define DAOUNIXPATHS 45  /* BUTTON in tree DAPPINFO */
#define DAOVAPROT 46  /* BUTTON in tree DAPPINFO */
#define DAOOVERLAY 47  /* BUTTON in tree DAPPINFO */
#define DAOSINGLE 48  /* BUTTON in tree DAPPINFO */
#define DAOCONWIN 49  /* BUTTON in tree DAPPINFO */
#define DAOWAITKEY 50  /* BUTTON in tree DAPPINFO */
#define DAOMAXMEM 52  /* FBOXTEXT in tree DAPPINFO */
#define DAOALERT 55  /* FBOXTEXT in tree DAPPINFO */
#define DASENV 56  /* BOX in tree DAPPINFO */
#define DAINAME4 58  /* STRING in tree DAPPINFO */
#define DAELIST 59  /* BOX in tree DAPPINFO */
#define DAEUP 66  /* BUTTON in tree DAPPINFO */
#define DAEBOX 67  /* BOX in tree DAPPINFO */
#define DAESLIDE 68  /* BUTTON in tree DAPPINFO */
#define DAEDOWN 69  /* BUTTON in tree DAPPINFO */
#define DAEVAL 70  /* FBOXTEXT in tree DAPPINFO */
#define DAEUSE 71  /* BUTTON in tree DAPPINFO */
#define DAEEDIT 72  /* BUTTON in tree DAPPINFO */
#define DAEDELETE 73  /* BUTTON in tree DAPPINFO */
#define DAIHELP 74  /* BUTTON in tree DAPPINFO */
#define DAIOK 75  /* BUTTON in tree DAPPINFO */
#define DAIDELETE 76  /* BUTTON in tree DAPPINFO */
#define DAICANCEL 77  /* BUTTON in tree DAPPINFO */

#define SELINFO 18  /* form/dial */
#define SIPATH 3  /* STRING in tree SELINFO */
#define SIFILES 5  /* STRING in tree SELINFO */
#define SIFOLDERS 7  /* STRING in tree SELINFO */
#define SISIZE 9  /* STRING in tree SELINFO */
#define SIHELP 10  /* BUTTON in tree SELINFO */
#define SIDETAILS 11  /* BUTTON in tree SELINFO */
#define SICANCEL 12  /* BUTTON in tree SELINFO */

#define COPY 19  /* form/dial */
#define CPSOURCET 2  /* STRING in tree COPY */
#define CPSOURCE 3  /* TEXT in tree COPY */
#define CPFILES 5  /* STRING in tree COPY */
#define CPDEST 7  /* TEXT in tree COPY */
#define CPFOLDERS 9  /* STRING in tree COPY */
#define CPSIZE 11  /* STRING in tree COPY */
#define CPOPTBOX 12  /* IBOX in tree COPY */
#define CPCOPY 13  /* BUTTON in tree COPY */
#define CPLINK 14  /* BUTTON in tree COPY */
#define CPMOVE 15  /* BUTTON in tree COPY */
#define CPRENAME 16  /* BUTTON in tree COPY */
#define CPFOLLOW 17  /* BUTTON in tree COPY */
#define CPBACKUP 18  /* BUTTON in tree COPY */
#define CPHELP 19  /* BUTTON in tree COPY */
#define CPOK 20  /* BUTTON in tree COPY */
#define CPCANCEL 21  /* BUTTON in tree COPY */

#define DELETE 20  /* form/dial */
#define DLSOURCE 3  /* STRING in tree DELETE */
#define DLFILES 5  /* STRING in tree DELETE */
#define DLFOLDERS 7  /* STRING in tree DELETE */
#define DLSIZE 9  /* STRING in tree DELETE */
#define DLHELP 10  /* BUTTON in tree DELETE */
#define DLOK 11  /* BUTTON in tree DELETE */
#define DLCANCEL 12  /* BUTTON in tree DELETE */

#define RENAMEFILE 21  /* form/dial */
#define RFTITLE 2  /* STRING in tree RENAMEFILE */
#define RFSPATH 5  /* STRING in tree RENAMEFILE */
#define RFSNAME 7  /* STRING in tree RENAMEFILE */
#define RFSATTR 8  /* IBOX in tree RENAMEFILE */
#define RFSSIZE 10  /* STRING in tree RENAMEFILE */
#define RFSDATE 12  /* STRING in tree RENAMEFILE */
#define RFSTIME 14  /* STRING in tree RENAMEFILE */
#define RFDPATH 17  /* STRING in tree RENAMEFILE */
#define RFDNAME 19  /* FBOXTEXT in tree RENAMEFILE */
#define RFDATTR 20  /* IBOX in tree RENAMEFILE */
#define RFDSIZE 22  /* STRING in tree RENAMEFILE */
#define RFDDATE 24  /* STRING in tree RENAMEFILE */
#define RFDTIME 26  /* STRING in tree RENAMEFILE */
#define RFHELP 27  /* BUTTON in tree RENAMEFILE */
#define RFOK 28  /* BUTTON in tree RENAMEFILE */
#define RFALL 29  /* BUTTON in tree RENAMEFILE */
#define RFNEXT 30  /* BUTTON in tree RENAMEFILE */
#define RFCANCEL 31  /* BUTTON in tree RENAMEFILE */

#define DEFAPPL 22  /* form/dial */
#define DALOCATE 3  /* FBOXTEXT in tree DEFAPPL */
#define DALIST 4  /* BOX in tree DEFAPPL */
#define DAUP 15  /* BUTTON in tree DEFAPPL */
#define DABOX 16  /* BOX in tree DEFAPPL */
#define DASLIDE 17  /* BUTTON in tree DEFAPPL */
#define DADOWN 18  /* BUTTON in tree DEFAPPL */
#define DAHELP 19  /* BUTTON in tree DEFAPPL */
#define DAOK 20  /* BUTTON in tree DEFAPPL */
#define DANEW 21  /* BUTTON in tree DEFAPPL */
#define DAEDIT 22  /* BUTTON in tree DEFAPPL */
#define DADELETE 23  /* BUTTON in tree DEFAPPL */

#define CONFIG 23  /* form/dial */
#define CODESK 2  /* BUTTON in tree CONFIG */
#define COWIN 3  /* BUTTON in tree CONFIG */
#define COWIN2 4  /* BUTTON in tree CONFIG */
#define COPROG 5  /* BUTTON in tree CONFIG */
#define COCOPY 6  /* BUTTON in tree CONFIG */
#define COT2G 7  /* BUTTON in tree CONFIG */
#define COSUB 8  /* IBOX in tree CONFIG */
#define COSPROG 9  /* BOX in tree CONFIG */
#define COEXIT 10  /* BUTTON in tree CONFIG */
#define COTOSWAIT 11  /* BUTTON in tree CONFIG */
#define COALTEXT 12  /* BUTTON in tree CONFIG */
#define COALTCPX 13  /* BUTTON in tree CONFIG */
#define COASKACC 14  /* BUTTON in tree CONFIG */
#define COVASTART 15  /* BUTTON in tree CONFIG */
#define CODEL 16  /* BUTTON in tree CONFIG */
#define COBACKWIN 17  /* BUTTON in tree CONFIG */
#define COFFINDER 19  /* BUTTON in tree CONFIG */
#define COFINDER 20  /* TEXT in tree CONFIG */
#define COFFORMAT 21  /* BUTTON in tree CONFIG */
#define COFORMAT 22  /* TEXT in tree CONFIG */
#define COSCOPY 23  /* BOX in tree CONFIG */
#define COCDELETE 25  /* BUTTON in tree CONFIG */
#define COCCOPY 26  /* BUTTON in tree CONFIG */
#define COCREPLACE 27  /* BUTTON in tree CONFIG */
#define COBUFSIZE 29  /* FBOXTEXT in tree CONFIG */
#define COKTOSONLY 32  /* BUTTON in tree CONFIG */
#define COKFORMAT 33  /* BUTTON in tree CONFIG */
#define COKCOPY 34  /* BUTTON in tree CONFIG */
#define COKCOPYN 35  /* FBOXTEXT in tree CONFIG */
#define COKCOPYS 37  /* FBOXTEXT in tree CONFIG */
#define COKDELETE 39  /* BUTTON in tree CONFIG */
#define COKDELETEN 40  /* FBOXTEXT in tree CONFIG */
#define COFKPROG 42  /* BUTTON in tree CONFIG */
#define COKPROG 43  /* TEXT in tree CONFIG */
#define COSWIN 44  /* BOX in tree CONFIG */
#define CONOWIN 45  /* BUTTON in tree CONFIG */
#define COBSEL 46  /* BUTTON in tree CONFIG */
#define COCLOSEBOX 47  /* BUTTON in tree CONFIG */
#define CONOHSCROLL 48  /* BUTTON in tree CONFIG */
#define CORELWIN 49  /* BUTTON in tree CONFIG */
#define COAUTOSEL 50  /* BUTTON in tree CONFIG */
#define COAUTOCOMP 51  /* BUTTON in tree CONFIG */
#define COAUTOUPDATE 52  /* BUTTON in tree CONFIG */
#define COHIDDEN 53  /* BUTTON in tree CONFIG */
#define COVERT 54  /* BUTTON in tree CONFIG */
#define COTOSMODE 55  /* BUTTON in tree CONFIG */
#define COQREAD 56  /* BUTTON in tree CONFIG */
#define CONOHOTCLOSER 57  /* BUTTON in tree CONFIG */
#define COSCROLL 59  /* FBOXTEXT in tree CONFIG */
#define COSDESK 60  /* BOX in tree CONFIG */
#define COUSE3D 61  /* BUTTON in tree CONFIG */
#define COISNAP 62  /* BUTTON in tree CONFIG */
#define CORDOUBLE 63  /* BUTTON in tree CONFIG */
#define CODCOLS 64  /* STRING in tree CONFIG */
#define CODCOL 66  /* IBOX in tree CONFIG */
#define CODPATS 67  /* STRING in tree CONFIG */
#define CODPAT 69  /* IBOX in tree CONFIG */
#define COIMGUSE 71  /* BUTTON in tree CONFIG */
#define COIMGCENTER 72  /* BUTTON in tree CONFIG */
#define COIMGTRANS 73  /* BUTTON in tree CONFIG */
#define COIMGPAL 74  /* BUTTON in tree CONFIG */
#define COFIMG 75  /* BUTTON in tree CONFIG */
#define COIMG 76  /* TEXT in tree CONFIG */
#define COIMGAPPLY 77  /* BUTTON in tree CONFIG */
#define COST2G 78  /* BOX in tree CONFIG */
#define COUSET2G 79  /* BUTTON in tree CONFIG */
#define COAUTOCON 80  /* BUTTON in tree CONFIG */
#define COT2GHIST 82  /* FBOXTEXT in tree CONFIG */
#define COTBUFNONE 86  /* BUTTON in tree CONFIG */
#define COTBUFSIZE 87  /* BUTTON in tree CONFIG */
#define COTBUFTIME 88  /* BUTTON in tree CONFIG */
#define COTCOLNONE 91  /* BUTTON in tree CONFIG */
#define COTCOLVT52 92  /* BUTTON in tree CONFIG */
#define COTCOLVDI 93  /* BUTTON in tree CONFIG */
#define COBUFTIME 94  /* FBOXTEXT in tree CONFIG */
#define COTWTITLE 98  /* BOXTEXT in tree CONFIG */
#define COTWVSLIDE 99  /* BOX in tree CONFIG */
#define COTWHSLIDE 100  /* BOX in tree CONFIG */
#define COSWIN2 101  /* BOX in tree CONFIG */
#define COCASESORT 102  /* BUTTON in tree CONFIG */
#define COCASELOC 103  /* BUTTON in tree CONFIG */
#define COAUTOPLACE 104  /* BUTTON in tree CONFIG */
#define COINTERACTIVE 105  /* BUTTON in tree CONFIG */
#define COAUTOSIZEXS 106  /* STRING in tree CONFIG */
#define COAUTOSIZEX 108  /* TEXT in tree CONFIG */
#define COAUTOSIZEYS 109  /* STRING in tree CONFIG */
#define COAUTOSIZEY 111  /* TEXT in tree CONFIG */
#define COFLEFT 114  /* FBOXTEXT in tree CONFIG */
#define COFRIGHT 116  /* FBOXTEXT in tree CONFIG */
#define COFHOR 118  /* FBOXTEXT in tree CONFIG */
#define COFUPPER 120  /* FBOXTEXT in tree CONFIG */
#define COFLOWER 122  /* FBOXTEXT in tree CONFIG */
#define COFVERT 124  /* FBOXTEXT in tree CONFIG */
#define COHELP 125  /* BUTTON in tree CONFIG */
#define COOK 126  /* BUTTON in tree CONFIG */
#define COCANCEL 127  /* BUTTON in tree CONFIG */

#define CFUNC 24  /* form/dial */
#define CFSNORM 3  /* BUTTON in tree CFUNC */
#define CFSSHIFT 4  /* BUTTON in tree CFUNC */
#define CFSCTRL 5  /* BUTTON in tree CFUNC */
#define CFSALT 6  /* BUTTON in tree CFUNC */
#define CFSTOOL 7  /* BUTTON in tree CFUNC */
#define CFSUB 8  /* BOX in tree CFUNC */
#define CFLIST 9  /* IBOX in tree CFUNC */
#define CFENTRY 10  /* FBOXTEXT in tree CFUNC */
#define CFLABEL 20  /* IBOX in tree CFUNC */
#define CFHELP 31  /* BUTTON in tree CFUNC */
#define CFOK 32  /* BUTTON in tree CFUNC */
#define CFCLEAR 33  /* BUTTON in tree CFUNC */
#define CFCANCEL 34  /* BUTTON in tree CFUNC */

#define CHANGEREZ 25  /* form/dial */
#define CRREZS 2  /* STRING in tree CHANGEREZ */
#define CRREZ 4  /* TEXT in tree CHANGEREZ */
#define CRHELP 7  /* BUTTON in tree CHANGEREZ */
#define CROK 8  /* BUTTON in tree CHANGEREZ */
#define CRCANCEL 9  /* BUTTON in tree CHANGEREZ */

#define WAIT 26  /* form/dial */
#define WTEXT1 1  /* TEXT in tree WAIT */
#define WTEXT2 2  /* TEXT in tree WAIT */
#define WFBOX 3  /* BOX in tree WAIT */
#define WFSLIDE 4  /* BOX in tree WAIT */
#define WFHELP 5  /* BUTTON in tree WAIT */
#define WFCANCEL 6  /* BUTTON in tree WAIT */

#define WAITCOPY 27  /* form/dial */
#define WCTEXT 1  /* STRING in tree WAITCOPY */
#define WCFILES 3  /* TEXT in tree WAITCOPY */
#define WCSTXT 4  /* STRING in tree WAITCOPY */
#define WCSIZE 5  /* TEXT in tree WAITCOPY */
#define WCFOLDERS 7  /* TEXT in tree WAITCOPY */
#define WCNAMES 9  /* IBOX in tree WAITCOPY */
#define WCSRC 10  /* TEXT in tree WAITCOPY */
#define WCDST 11  /* TEXT in tree WAITCOPY */
#define WCDTXT 12  /* STRING in tree WAITCOPY */
#define WCBOX 13  /* BOX in tree WAITCOPY */
#define WCSLIDE 14  /* BOX in tree WAITCOPY */
#define WCHELP 15  /* BUTTON in tree WAITCOPY */
#define WCCANCEL 16  /* BUTTON in tree WAITCOPY */

#define SELAPP 28  /* form/dial */
#define SATITLE 1  /* STRING in tree SELAPP */
#define SAFILE 3  /* STRING in tree SELAPP */
#define SALIST 6  /* BOX in tree SELAPP */
#define SAUP 12  /* BUTTON in tree SELAPP */
#define SABOX 13  /* BOX in tree SELAPP */
#define SASLIDE 14  /* BUTTON in tree SELAPP */
#define SADOWN 15  /* BUTTON in tree SELAPP */
#define SAHELP 16  /* BUTTON in tree SELAPP */
#define SAOK 17  /* BUTTON in tree SELAPP */
#define SACANCEL 18  /* BUTTON in tree SELAPP */

#define GROUPINFO 29  /* form/dial */
#define GITITLE 3  /* FBOXTEXT in tree GROUPINFO */
#define GIFILE 5  /* STRING in tree GROUPINFO */
#define GIAUTOSAVE 6  /* BUTTON in tree GROUPINFO */
#define GIGETATTR 7  /* BUTTON in tree GROUPINFO */
#define GIAUTOCLOSE 8  /* BUTTON in tree GROUPINFO */
#define GIPARENT 10  /* FBOXTEXT in tree GROUPINFO */
#define GIFUNCS 11  /* STRING in tree GROUPINFO */
#define GIFUNC 13  /* TEXT in tree GROUPINFO */
#define GIHELP 14  /* BUTTON in tree GROUPINFO */
#define GIOK 15  /* BUTTON in tree GROUPINFO */
#define GICANCEL 16  /* BUTTON in tree GROUPINFO */

#define GOBINFO 30  /* form/dial */
#define GETITLE 3  /* FBOXTEXT in tree GOBINFO */
#define GEPATH 5  /* STRING in tree GOBINFO */
#define GEENTRY 7  /* FBOXTEXT in tree GOBINFO */
#define GEPARALWAYS 9  /* BUTTON in tree GOBINFO */
#define GEPARAM 10  /* FBOXTEXT in tree GOBINFO */
#define GEHELP 11  /* BUTTON in tree GOBINFO */
#define GEOK 12  /* BUTTON in tree GOBINFO */
#define GESKIP 13  /* BUTTON in tree GOBINFO */
#define GECANCEL 14  /* BUTTON in tree GOBINFO */

#define POPREZ 31  /* form/dial */

#define POPCOLOR 32  /* form/dial */

#define POPPAT 33  /* form/dial */

#define POPSHORT 34  /* form/dial */

#define POPFSHORT 35  /* form/dial */

#define POPCONTEXT 36  /* form/dial */
#define POPCOPEN 1  /* STRING in tree POPCONTEXT */
#define POPCDIROPEN 2  /* STRING in tree POPCONTEXT */
#define POPCINFO 3  /* STRING in tree POPCONTEXT */
#define POPCVIEW 5  /* STRING in tree POPCONTEXT */
#define POPCPRINT 6  /* STRING in tree POPCONTEXT */
#define POPCSENDTO 8  /* STRING in tree POPCONTEXT */
#define POPCDEL 10  /* STRING in tree POPCONTEXT */
#define POPCCOPY 12  /* STRING in tree POPCONTEXT */
#define POPCCUT 13  /* STRING in tree POPCONTEXT */
#define POPCAPPL 15  /* STRING in tree POPCONTEXT */

#define POPICONTEXT 37  /* form/dial */
#define POPICOPEN 1  /* STRING in tree POPICONTEXT */
#define POPICINFO 2  /* STRING in tree POPICONTEXT */
#define POPICEJECT 4  /* STRING in tree POPICONTEXT */
#define POPICFORMAT 6  /* STRING in tree POPICONTEXT */
#define POPICDEL 8  /* STRING in tree POPICONTEXT */

#define POPCWINDOW 38  /* form/dial */
#define POPCWNEW 1  /* STRING in tree POPCWINDOW */
#define POPCWINFO 2  /* STRING in tree POPCWINDOW */
#define POPCWEJECT 4  /* STRING in tree POPCWINDOW */
#define POPCWUPDATE 6  /* STRING in tree POPCWINDOW */
#define POPCWPASTE 8  /* STRING in tree POPCWINDOW */
#define POPCWSHOW 10  /* STRING in tree POPCWINDOW */
#define POPCWSORT 12  /* STRING in tree POPCWINDOW */
#define POPCWMASK 14  /* STRING in tree POPCWINDOW */
#define POPCWFONT 15  /* STRING in tree POPCWINDOW */
#define POPCWSAVEINDEX 17  /* STRING in tree POPCWINDOW */

#define POPCGRPWIN 39  /* form/dial */
#define POPCGNEW 1  /* STRING in tree POPCGRPWIN */
#define POPCGINFO 2  /* STRING in tree POPCGRPWIN */
#define POPCGSAVEGROUP 4  /* STRING in tree POPCGRPWIN */
#define POPCGSHOW 6  /* STRING in tree POPCGRPWIN */
#define POPCGFONT 8  /* STRING in tree POPCGRPWIN */

#define POPPMEM 40  /* form/dial */

#define POPSORT 41  /* form/dial */
#define POPSORTREV 1  /* STRING in tree POPSORT */
#define POPSORTFOLD 2  /* STRING in tree POPSORT */
#define POPSORTNAME 4  /* STRING in tree POPSORT */
#define POPSORTSIZE 5  /* STRING in tree POPSORT */
#define POPSORTDATE 6  /* STRING in tree POPSORT */
#define POPSORTEXT 7  /* STRING in tree POPSORT */
#define POPSORTNONE 8  /* STRING in tree POPSORT */

#define POPSHOW 42  /* form/dial */
#define POPSHOWTEXT 1  /* STRING in tree POPSHOW */
#define POPSHOWSYMTEXT 2  /* STRING in tree POPSHOW */
#define POPSHOWICONS 3  /* STRING in tree POPSHOW */

#define POPAUTOSIZE 43  /* form/dial */

#define ICONS 44  /* form/dial */
#define DUMMYICON 1  /* ICON in tree ICONS */
#define SDUMMYICON 2  /* ICON in tree ICONS */

#define NEWOBJ 45  /* form/dial */
#define NOFOLD 4  /* BUTTON in tree NEWOBJ */
#define NOFILE 5  /* BUTTON in tree NEWOBJ */
#define NOGROUP 6  /* BUTTON in tree NEWOBJ */
#define NOLINK 7  /* BUTTON in tree NEWOBJ */
#define NOSUB 8  /* IBOX in tree NEWOBJ */
#define NOSGROUP 9  /* BUTTON in tree NEWOBJ */
#define NGPATH 11  /* STRING in tree NEWOBJ */
#define NGFILE 14  /* FTEXT in tree NEWOBJ */
#define NGTITLE 17  /* FBOXTEXT in tree NEWOBJ */
#define NGAUTOSAVE 18  /* BUTTON in tree NEWOBJ */
#define NGICON 19  /* BUTTON in tree NEWOBJ */
#define NOSFILE 20  /* BUTTON in tree NEWOBJ */
#define NFPATH 21  /* STRING in tree NEWOBJ */
#define NFNAME 22  /* FBOXTEXT in tree NEWOBJ */
#define NOSLINK 25  /* BUTTON in tree NEWOBJ */
#define NSPATH 27  /* STRING in tree NEWOBJ */
#define NSABS 28  /* BUTTON in tree NEWOBJ */
#define NSREL 29  /* BUTTON in tree NEWOBJ */
#define NSRDESC 30  /* STRING in tree NEWOBJ */
#define NSASEL 31  /* BUTTON in tree NEWOBJ */
#define NSRDEST 32  /* FBOXTEXT in tree NEWOBJ */
#define NSADEST 33  /* TEXT in tree NEWOBJ */
#define NSNAME 35  /* FBOXTEXT in tree NEWOBJ */
#define NOHELP 36  /* BUTTON in tree NEWOBJ */
#define NOOK 37  /* BUTTON in tree NEWOBJ */
#define NOCANCEL 38  /* BUTTON in tree NEWOBJ */

#define ICONWIN 46  /* form/dial */

#define ICONDIAL 47  /* form/dial */

#define ICONPATH 48  /* form/dial */

#define ICONCON 49  /* form/dial */

#define HOTKEYS 50  /* form/dial */
#define HKLOCATE 3  /* FBOXTEXT in tree HOTKEYS */
#define HKLIST 4  /* BOX in tree HOTKEYS */
#define HKUP 15  /* BUTTON in tree HOTKEYS */
#define HKBOX 16  /* BOX in tree HOTKEYS */
#define HKSLIDE 17  /* BUTTON in tree HOTKEYS */
#define HKDOWN 18  /* BUTTON in tree HOTKEYS */
#define HKHELP 19  /* BUTTON in tree HOTKEYS */
#define HKCLOSE 20  /* BUTTON in tree HOTKEYS */
#define HKNEW 21  /* BUTTON in tree HOTKEYS */
#define HKCHANGE 22  /* BUTTON in tree HOTKEYS */
#define HKDELETE 23  /* BUTTON in tree HOTKEYS */

#define CHOOSEHOTKEY 51  /* form/dial */
