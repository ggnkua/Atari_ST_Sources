/* xdatared.c  Mon 23 May 1988 */
/* This file contains the data for the red wizard images. */


/* Image of Red Wizard Facing its front */
long rwFront[] = {
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00080008L,0x0007000FL,0x00000000L,0xE000E000L,
	0x00210021L,0x001E003FL,0xC100C100L,0xC1000000L,
	0x00010001L,0x00FF00FEL,0x82808380L,0x82800000L,
	0x00110011L,0x00EF00FEL,0x81008100L,0x81000000L,
	0x000C000CL,0x0073007FL,0x80008100L,0x81000100L,
	0x00000000L,0x003F003FL,0x00000100L,0x81008100L,
	0x00200020L,0x001F003FL,0x00000100L,0x01000100L,
	0x00000000L,0x003F003FL,0x00000100L,0x81008100L,
	0x00110011L,0x006E007FL,0x40004100L,0x8100C100L,
	0x00900090L,0x006F00FFL,0x60006100L,0x9D00FD00L,
	0x01370134L,0x00CB01FFL,0x03000000L,0xFF00FF00L,
	0x00260024L,0x03DB03FFL,0x0E000900L,0xF700FF00L,
	0x00040004L,0x07FB07FFL,0x10001100L,0xE100F100L,
	0x003C003CL,0x03C303FFL,0x00000100L,0xC100C100L,
	0x01C001C0L,0x003F01FFL,0x00000100L,0xC100C100L,
	0x00010001L,0x01FE01FFL,0x20002100L,0xC100E100L,
	0x00200020L,0x01DF01FFL,0x20002100L,0xC100E100L,
	0x00400040L,0x01BF01FFL,0x80008100L,0x6100E100L,
	0x02400240L,0x01BF03FFL,0x00000000L,0xE100E100L,
	0x00480048L,0x03B703FFL,0x10001000L,0xE000F000L,
	0x04040404L,0x03FB07FFL,0x80008000L,0x7000F000L,
	0x06F206A2L,0x005106F3L,0x88000800L,0x90009800L,
	0x007D0000L,0x007D007DL,0xE0000000L,0xE000E000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};


long rwBack[] = {
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00070007L,0x10001000L,0xE000F000L,
	0x00830083L,0x00820001L,0x0C000C00L,0xF000FC00L,
	0x014101C1L,0x01410000L,0x83008300L,0xFC007F00L,
	0x00810081L,0x00810000L,0x88008800L,0xF7007F00L,
	0x00010081L,0x00810080L,0xB200B200L,0x4C00FE00L,
	0x00000080L,0x00810081L,0x00000000L,0xFC00FC00L,
	0x00000080L,0x00800080L,0x04000400L,0xF800FC00L,
	0x00000080L,0x00810081L,0x30003000L,0xCC00FC00L,
	0x00000080L,0x00810081L,0xE600E600L,0x1800FE00L,
	0x00060086L,0x00B900BFL,0x80008000L,0x7E00FE00L,
	0x00C10001L,0x00FE00FFL,0x02000200L,0xFC00FE00L,
	0x00700090L,0x00EF00FFL,0x05000500L,0xFA00FF00L,
	0x000C008CL,0x0083008FL,0x08000800L,0xF700FF00L,
	0x00030083L,0x00800083L,0x88808880L,0x7700FF80L,
	0x00000080L,0x00830083L,0x70807080L,0x8F00FF80L,
	0x00040084L,0x00830087L,0x80008000L,0x7F80FF80L,
	0x00040084L,0x00830087L,0x04000400L,0xFB80FF80L,
	0x00010081L,0x00860087L,0x02000200L,0xFD80FF80L,
	0x00000000L,0x00870087L,0x02400240L,0xFD80FFC0L,
	0x00080008L,0x0007000FL,0x12401240L,0xED80FFC0L,
	0x00010001L,0x000E000FL,0x20202020L,0xDFC0FFE0L,
	0x00110010L,0x00090019L,0x4F604560L,0x8A00CF60L,
	0x00070000L,0x00070007L,0xBE000000L,0xBE00BE00L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};

long rwNod1[] = {
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00080008L,0x0007000FL,0x00000000L,0xE000E000L,
	0x00210021L,0x001E003FL,0xC000C000L,0xC0000000L,
	0x00010001L,0x00FF00FEL,0x81008100L,0x81000000L,
	0x00110011L,0x00EF00FEL,0x82808380L,0x82800000L,
	0x000C000CL,0x0073007FL,0x81008100L,0x81000000L,
	0x00000000L,0x003F003FL,0x00000100L,0x81008100L,
	0x00200020L,0x001F003FL,0x00000100L,0x01000100L,
	0x00000000L,0x003F003FL,0x00000100L,0x81008100L,
	0x00110011L,0x006E007FL,0x40004100L,0x8100C100L,
	0x00900090L,0x006F00FFL,0x60006100L,0x9100F100L,
	0x01370134L,0x00CB01FFL,0x00000100L,0xFD00FD00L,
	0x00260024L,0x03DB03FFL,0x0F000800L,0xF700FF00L,
	0x00040004L,0x07FB07FFL,0x1E001100L,0xEF00FF00L,
	0x003C003CL,0x03C303FFL,0x00000100L,0xE100E100L,
	0x01C001C0L,0x003F01FFL,0x00000100L,0xC100C100L,
	0x00010001L,0x01FE01FFL,0x00000100L,0xC100C100L,
	0x00200020L,0x01DF01FFL,0x20002100L,0xC100E100L,
	0x00400040L,0x01BF01FFL,0x80008100L,0x6100E100L,
	0x02400240L,0x01BF03FFL,0x00000100L,0xE100E100L,
	0x00480048L,0x03B703FFL,0x10001000L,0xE100F100L,
	0x04040404L,0x03FB07FFL,0x80008000L,0x7000F000L,
	0x06F206A2L,0x005106F3L,0x88000800L,0x90009800L,
	0x007D0000L,0x007D007DL,0xE0000000L,0xE000E000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};

long rwNod2[] = {
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00080008L,0x0007000FL,0x00000000L,0xE000E000L,
	0x00210021L,0x001E003FL,0xC000C000L,0xC0000000L,
	0x00010001L,0x00FF00FEL,0x80008000L,0x80000000L,
	0x00110011L,0x00EF00FEL,0x81008100L,0x81000000L,
	0x000C000CL,0x0073007FL,0x82808380L,0x82800000L,
	0x00000000L,0x003F003FL,0x01000100L,0x81008000L,
	0x00200020L,0x001F003FL,0x00000100L,0x01000100L,
	0x00000000L,0x003F003FL,0x00000100L,0x81008100L,
	0x00110011L,0x006E007FL,0x40004100L,0x8100C100L,
	0x00900090L,0x006F00FFL,0x20002100L,0xD100F100L,
	0x01370134L,0x00CB01FFL,0x00000100L,0xF900F900L,
	0x00260024L,0x03DB03FFL,0x0C000900L,0xF500FD00L,
	0x00040004L,0x07FB07FFL,0x0F000000L,0xFF00FF00L,
	0x003C003CL,0x03C303FFL,0x03000000L,0xE300E300L,
	0x01C001C0L,0x003F01FFL,0x00000100L,0xC100C100L,
	0x00010001L,0x01FE01FFL,0x00000100L,0xC100C100L,
	0x00200020L,0x01DF01FFL,0x20002100L,0xC100E100L,
	0x00400040L,0x01BF01FFL,0x80008100L,0x6100E100L,
	0x02400240L,0x01BF03FFL,0x00000100L,0xE100E100L,
	0x00480048L,0x03B703FFL,0x10001100L,0xE100F100L,
	0x04040404L,0x03FB07FFL,0x80008000L,0x7100F100L,
	0x06F206A2L,0x005106F3L,0x88000800L,0x90009