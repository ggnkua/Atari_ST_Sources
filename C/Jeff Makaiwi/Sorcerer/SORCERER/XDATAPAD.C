/* This file contains data for the teleport pad surfaces */


/*
 * These are the images for the teleportation target pads.
 * (4 * 4vplanes) by 17 words = 272 words
 */
long tpad1[] = {
	0x00000000L,0x00000000L,0x01F00000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x0FFE0000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x7E0F01F0L,0x00000000L,
	0xC0000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00030000L,0x00000000L,0xF0010FFEL,0x00000000L,
	0xF8000000L,0x00000000L,0x00000000L,0x00000000L,
	0x001F0000L,0x00000000L,0x81F07FFFL,0x00000000L,
	0x3F00C000L,0x00000000L,0x00000000L,0x00000000L,
	0x00FC0003L,0x00000000L,0x0FFEFFFFL,0x00000000L,
	0x07E0F800L,0x00000000L,0x00000000L,0x00000000L,
	0x07E0001FL,0x00000000L,0x7E0FFE0FL,0x01F00000L,
	0xC0FCFF00L,0x00000000L,0x00000000L,0x00000000L,
	0x3F0300FFL,0x00000000L,0xF001F001L,0x0FFE0000L,
	0xF81FFFE0L,0x00000000L,0x80000000L,0x00000000L,
	0xF81F07FFL,0x00000000L,0x81F08000L,0x7FFF0000L,
	0x3F033FFCL,0xC0000000L,0xE0000000L,0x00000000L,
	0x3F0300FFL,0x00000000L,0xF001F001L,0x0FFE0000L,
	0xF81FFFE0L,0x00000000L,0x80000000L,0x00000000L,
	0x07E0001FL,0x00000000L,0x7E0FFE0FL,0x01F00000L,
	0xC0FCFF00L,0x00000000L,0x00000000L,0x00000000L,
	0x00FC0003L,0x00000000L,0x0FFEFFFFL,0x00000000L,
	0x07E0F800L,0x00000000L,0x00000000L,0x00000000L,
	0x001F0000L,0x00000000L,0x81F07FFFL,0x00000000L,
	0x3F00C000L,0x00000000L,0x00000000L,0x00000000L,
	0x00030000L,0x00000000L,0xF0010FFEL,0x00000000L,
	0xF8000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x7E0F01F0L,0x00000000L,
	0xC0000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x0FFE0000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x01F00000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};

long tpad2[] = {
	0x00000000L,0x00000000L,0x01F00000L,0x01F00000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x0FFE0000L,0x0FFE0000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x7FFF0000L,0x7E0F0000L,
	0xC0000000L,0xC0000000L,0x00000000L,0x00000000L,
	0x00030000L,0x00030000L,0xFFFF0000L,0xF0010000L,
	0xF8000000L,0xF8000000L,0x00000000L,0x00000000L,
	0x001F0000L,0x001F0000L,0xFE0F01F0L,0x80000000L,
	0xFF000000L,0x3F000000L,0x00000000L,0x00000000L,
	0x00FF0000L,0x00FC0000L,0xF0010FFEL,0x00000000L,
	0xFFE00000L,0x07E00000L,0x00000000L,0x00000000L,
	0x07FF0000L,0x07E00000L,0x81F07FFFL,0x00000000L,
	0x3FFCC000L,0x00FC0000L,0x00000000L,0x00000000L,
	0x3FFC0003L,0x3F000000L,0x0FFEFFFFL,0x00000000L,
	0x07FFF800L,0x001F0000L,0x80000000L,0x80000000L,
	0xFFE0001FL,0xF8000000L,0x7E0FFE0FL,0x01F00000L,
	0xC0FFFF00L,0x00030000L,0xE0000000L,0xE0000000L,
	0x3FFC0003L,0x3F000000L,0x0FFEFFFFL,0x00000000L,
	0x07FFF800L,0x001F0000L,0x80000000L,0x80000000L,
	0x07FF0000L,0x07E00000L,0x81F07FFFL,0x00000000L,
	0x3FFCC000L,0x00FC0000L,0x00000000L,0x00000000L,
	0x00FF0000L,0x00FC0000L,0xF0010FFEL,0x00000000L,
	0xFFE00000L,0x07E00000L,0x00000000L,0x00000000L,
	0x001F0000L,0x001F0000L,0xFE0F01F0L,0x80000000L,
	0xFF000000L,0x3F000000L,0x00000000L,0x00000000L,
	0x00030000L,0x00030000L,0xFFFF0000L,0xF0010000L,
	0xF8000000L,0xF8000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x7FFF0000L,0x7E0F0000L,
	0xC0000000L,0xC0000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x0FFE0000L,0x0FFE0000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x01F00000L,0x01F00000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};

long tpad3[] = {
	0x00000000L,0x00000000L,0x00000000L,0x01F00000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x0FFE0000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x01F00000L,0x7FFF0000L,
	0x00000000L,0xC0000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00030000L,0x0FFE0000L,0xFFFF0000L,
	0x00000000L,0xF8000000L,0x00000000L,0x00000000L,
	0x00000000L,0x001F0000L,0x7FFF0000L,0xFE0F0000L,
	0xC0000000L,0xFF000000L,0x00000000L,0x00000000L,
	0x00030000L,0x00FF0000L,0xFFFF0000L,0xF0010000L,
	0xF8000000L,0xFFE00000L,0x00000000L,0x00000000L,
	0x001F0000L,0x07FF0000L,0xFE0F01F0L,0x80000000L,
	0xFF000000L,0x3FFC0000L,0x00000000L,0x00000000L,
	0x00FF0000L,0x3FFC0000L,0xF0010FFEL,0x00000000L,
	0xFFE00000L,0x07FF0000L,0x00000000L,0x80000000L,
	0x07FF0000L,0xFFE00000L,0x81F07FFFL,0x00000000L,
	0x3FFCC000L,0x00FF0000L,0x00000000L,0xE0000000L,
	0x00FF0000L,0x3FFC0000L,0xF0010FFEL,0x00000000L,
	0xFFE00000L,0x07FF0000L,0x00000000L,0x80000000L,
	0x001F0000L,0x07FF0000L,0xFE0F01F0L,0x80000000L,
	0xFF000000L,0x3FFC0000L,0x00000000L,0x00000000L,
	0x00030000L,0x00FF0000L,0xFFFF0000L,0xF0010000L,
	0xF8000000L,0xFFE00000L,0x00000000L,0x00000000L,
	0x00000000L,0x001F0000L,0x7FFF0000L,0xFE0F0000L,
	0xC0000000L,0xFF000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00030000L,0x0FFE0000L,0xFFFF0000L,
	0x00000000L,0xF8000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x01F00000L,0x7FFF0000L,
	0x00000000L,0xC0000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x0FFE0000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x01F00000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};

long tpad4[] = {
	0x00000000L,0x00000000L,0x01F001F0L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x0FFE0FFEL,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x7E0F7E0FL,0x01F00000L,
	0xC000C000L,0x00000000L,0x00000000L,0x00000000L,
	0x00030003L,0x00000000L,0xF001F001L,0x0FFE0000L,
	0xF800F800L,0x00000000L,0x00000000L,0x00000000L,
	0x001F001FL,0x00000000L,0x81F08000L,0x7FFF0000L,
	0x3F003F00L,0xC0000000L,0x00000000L,0x00000000L,
	0x00FC00FCL,0x00030000L,0x0FFE0000L,0xFFFF0000L,
	0x07E007E0L,0xF8000000L,0x00000000L,0x00000000L,
	0x07E007E0L,0x001F0000L,0x7FFF0000L,0xFE0F0000L,
	0xC0FC00FCL,0xFF000000L,0x00000000L,0x00000000L,
	0x3F033F00L,0x00FF0000L,0xFFFF0000L,0xF0010000L,
	0xF81F001FL,0xFFE00000L,0x80008000L,0x00000000L,
	0xF81FF800L,0x07FF0000L,0xFE0F01F0L,0x80000000L,
	0xFF030003L,0x3FFC0000L,0xE000E000L,0x00000000L,
	0x3F033F00L,0x00FF0000L,0xFFFF0000L,0xF0010000L,
	0xF81F001FL,0xFFE00000L,0x80008000L,0x00000000L,
	0x07E007E0L,0x001F0000L,0x7FFF0000L,0xFE0F0000L,
	0xC0FC00FCL,0xFF000000L,0x00000000L,0x00000000L,
	0x00FC00FCL,0x00030000L,0x0FFE0000L,0xFFFF0000L,
	0x07E007E0L,0xF8000000L,0x00000000L,0x00000000L,
	0x001F001FL,0x00000000L,0x81F08000L,0x7FFF0000L,
	0x3F003F00L,0xC0000000L,0x00000000L,0x00000000L,
	0x00030003L,0x00000000L,0xF001F001L,0x0FFE0000L,
	0xF800F800L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x7E0F7E0FL,0x01F00000L,
	0xC000C000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x0FFE0FFEL,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x01F001F0L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};

long tpad5[] = {
	0x00000000L,0x00000000L,0x000001F0L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000FFEL,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x01F07FFFL,0x00000000L,
	0x0000C000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000003L,0x00000000L,0x0FFEFFFFL,0x00000000L,
	0x0000F800L,0x00000000L,0x00000000L,0x00000000L,
	0x0000001FL,0x00000000L,0x7E0FFE0FL,0x01F00000L,
	0xC000FF00L,0x00000000L,0x00000000L,0x00000000L,
	0x000300FFL,0x00000000L,0xF001F001L,0x0FFE0000L,
	0xF800FFE0L,0x00000000L,0x00000000L,0x00000000L,
	0x001F07FFL,0x00000000L,0x81F08000L,0x7FFF0000L,
	0x3F003FFCL,0xC0000000L,0x00000000L,0x00000000L,
	0x00FC3FFCL,0x00030000L,0x0FFE0000L,0xFFFF0000L,
	0x07E007FFL,0xF8000000L,0x00008000L,0x00000000L,
	0x07E0FFE0L,0x001F0000L,0x7FFF0000L,0xFE0F0000L,
	0xC0FC00FFL,0xFF000000L,0x0000E000L,0x00000000L,
	0x00FC3FFCL,0x00030000L,0x0FFE0000L,0xFFFF0000L,
	0x07E007FFL,0xF8000000L,0x00008000L,0x00000000L,
	0x001F07FFL,0x00000000L,0x81F08000L,0x7FFF0000L,
	0x3F003FFCL,0xC0000000L,0x00000000L,0x00000000L,
	0x000300FFL,0x00000000L,0xF001F001L,0x0FFE0000L,
	0xF800FFE0L,0x00000000L,0x00000000L,0x00000000L,
	0x0000001FL,0x00000000L,0x7E0FFE0FL,0x01F00000L,
	0xC000FF00L,0x00000000L,0x00000000L,0x00000000L,
	0x00000003L,0x00000000L,0x0FFEFFFFL,0x00000000L,
	0x0000F800L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x01F07FFFL,0x00000000L,
	0x0000C000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x00000FFEL,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L,
	0x00000000L,0x00000000L,0x000001F0L,0x00000000L,
	0x00000000L,0x00000000L,0x00000000L,0x00000000L
};
