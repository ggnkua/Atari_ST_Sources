/* Prototypes for functions defined in D:\PROJLINN\LAZYREAD\LOGIN.C */
int get_login(void);
int close_login(void);
void display_login(void);
int open_login(void);
int change_password(void);
int get_ulastlogin(void);
char *get_uname(void);
int get_ucredit(int );
int get_uflag(char );
int is_uguest(void);
int has_new_mail(void);
void reset_new_mail(void);
int user_questions(void);
