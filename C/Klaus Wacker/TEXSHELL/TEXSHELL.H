#define MENU 0
#define DESKTITL 3
#define DATEI 4
#define LOKALISI 6
#define AUSFUEHR 5
#define OPTIONEN 7
#define INFO 10
#define AUSWAEHL 19
#define FSHELLIN 1
#define DATUMBEN 22
#define DATLOESH 21
#define DATKOPIE 23
#define KNOPF 4
#define DVIRETTE 26
#define AUXRETTE 25
#define SAUBER 27
#define QUIT 29
#define EDITIERE 31
#define ALTEDIT 32
#define DODVI 34
#define DOTEX 33
#define ANDERES 36
#define LOKEDITO 38
#define LOKTEX 39
#define LOKDVI 40
#define ENVEDIT 42
#define EINSTESI 44
#define TEXDVI 46
#define WARTEOPT 47
#define LATEXOPT 50
#define PLAINOPT 49
#define EIGENFMT 51
#define FSELCAP 4
#define DEUTSCHO 52
#define FSELCAPT 1
#define TTPBOX 5
#define TTPNAME 2
#define TTPARAM 5
#define TTPCAN 7
#define TTPOK 6
#define TOP 3
#define EDIT 1
#define UMBENNEN 2
#define ABBRUCH 3
#define EDITX 2
