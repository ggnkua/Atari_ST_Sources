#define MAINTREE 0  	/* TREE */
#define QUIT 25  	/* OBJECT in TREE #0 */
#define DOWN 14  	/* OBJECT in TREE #0 */
#define BASEV 12  	/* OBJECT in TREE #0 */
#define LEFT 23  	/* OBJECT in TREE #0 */
#define RIGHT 22  	/* OBJECT in TREE #0 */
#define BASEH 20  	/* OBJECT in TREE #0 */
#define SLIDEH 21  	/* OBJECT in TREE #0 */
#define UP 15  	/* OBJECT in TREE #0 */
#define SLIDEV 13  	/* OBJECT in TREE #0 */
#define POPUP 17  	/* OBJECT in TREE #0 */
