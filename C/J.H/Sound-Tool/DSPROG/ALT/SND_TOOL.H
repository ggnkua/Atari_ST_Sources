/* resource set indices for SND_TOOL */

#define FLT_SLID   0 /* form/dialog */

#define PCK_SLD    1 /* form/dialog */

#define PCK_SLID   2 /* form/dialog */

#define WRK_DIR    3 /* form/dialog */

#define SEQ_SLID   4 /* form/dialog */

#define SEQ_LST    5 /* form/dialog */

#define SEQ_EDIT   6 /* form/dialog */

#define SMP_STAT   7 /* form/dialog */
#define STN_1      6 /* FBOXTEXT in tree SMP_STAT */
#define STL_1      7 /* FBOXTEXT in tree SMP_STAT */
#define STM_1      8 /* FBOXTEXT in tree SMP_STAT */
#define STF_1      9 /* FBOXTEXT in tree SMP_STAT */
#define STN_2     10 /* FBOXTEXT in tree SMP_STAT */
#define STL_2     11 /* FBOXTEXT in tree SMP_STAT */
#define STM_2     12 /* FBOXTEXT in tree SMP_STAT */
#define STF_2     13 /* FBOXTEXT in tree SMP_STAT */
#define STN_3     14 /* FBOXTEXT in tree SMP_STAT */
#define STL_3     15 /* FBOXTEXT in tree SMP_STAT */
#define STM_3     16 /* FBOXTEXT in tree SMP_STAT */
#define STF_3     17 /* FBOXTEXT in tree SMP_STAT */
#define STN_4     18 /* FBOXTEXT in tree SMP_STAT */
#define STL_4     19 /* FBOXTEXT in tree SMP_STAT */
#define STM_4     20 /* FBOXTEXT in tree SMP_STAT */
#define STF_4     21 /* FBOXTEXT in tree SMP_STAT */
#define STN_5     22 /* FBOXTEXT in tree SMP_STAT */
#define STL_5     23 /* FBOXTEXT in tree SMP_STAT */
#define STM_5     24 /* FBOXTEXT in tree SMP_STAT */
#define STF_5     25 /* FBOXTEXT in tree SMP_STAT */
#define STAT_P    26 /* FBOXTEXT in tree SMP_STAT */
#define STAT_N    27 /* FBOXTEXT in tree SMP_STAT */

