/* Resource Datei Indizes f�r GALSHELL */

#define FORMULAR 0   /* Formular/Dialog */
#define TITEL    1   /* BOXTEXT in Baum FORMULAR */
#define GAL_NAME 2   /* FTEXT in Baum FORMULAR */
#define ATYPBTN  4   /* BUTTON in Baum FORMULAR */
#define CHMESBTN 5   /* BUTTON in Baum FORMULAR */
#define SECURBTN 6   /* BUTTON in Baum FORMULAR */
#define OPTDBTN  7   /* BUTTON in Baum FORMULAR */
#define MASTRBTN 9   /* BUTTON in Baum FORMULAR */
#define G16V8BTN 11  /* BUTTON in Baum FORMULAR */
#define G20V8BTN 12  /* BUTTON in Baum FORMULAR */
#define ABBRUCH  15  /* BUTTON in Baum FORMULAR */
#define EMPTYBTN 16  /* BUTTON in Baum FORMULAR */
#define BULKBTN  17  /* BUTTON in Baum FORMULAR */
#define READBTN  18  /* BUTTON in Baum FORMULAR */
#define VERIFBTN 19  /* BUTTON in Baum FORMULAR */
#define WRITEBTN 20  /* BUTTON in Baum FORMULAR */
#define HELPBTN  21  /* BUTTON in Baum FORMULAR */
#define BURNCBTN 22  /* BUTTON in Baum FORMULAR */
#define FILENAME 25  /* FTEXT in Baum FORMULAR */
#define OVRWRBTN 27  /* BUTTON in Baum FORMULAR */
#define EXPNDBTN 28  /* BUTTON in Baum FORMULAR */
#define EDDITBTN 30  /* BUTTON in Baum FORMULAR */
#define ASMBTN   31  /* BUTTON in Baum FORMULAR */
