/* Resource Datei Indizes f�r ASCREEN */

#define INFOFM   0   /* Formular/Dialog */
#define MIREVID  3   /* STRING in Baum INFOFM */
#define FICOPY   10  /* BUTTON in Baum INFOFM */
#define FICREDIT 15  /* BUTTON in Baum INFOFM */
#define FIOK     16  /* BUTTON in Baum INFOFM */

#define COPYFM   1   /* Formular/Dialog */

#define MAINMENU 2   /* Menuebaum */
#define MDINFO   9   /* STRING in Baum MAINMENU */
#define MFOPEN   18  /* STRING in Baum MAINMENU */
#define MFREREAD 19  /* STRING in Baum MAINMENU */
#define MFQUIT   21  /* STRING in Baum MAINMENU */
#define MWOPEN   23  /* STRING in Baum MAINMENU */
#define MWOPNPAG 24  /* STRING in Baum MAINMENU */
#define MWNEXT   25  /* STRING in Baum MAINMENU */
#define MWCLOSE  26  /* STRING in Baum MAINMENU */
#define MWSTATS  28  /* STRING in Baum MAINMENU */
#define MWHELP   30  /* STRING in Baum MAINMENU */
#define MOGEM    32  /* STRING in Baum MAINMENU */
#define MODVI    33  /* STRING in Baum MAINMENU */
#define MOFMT    34  /* STRING in Baum MAINMENU */
#define MOMEM    35  /* STRING in Baum MAINMENU */
#define MOFONTS  36  /* STRING in Baum MAINMENU */
#define MOREAD   38  /* STRING in Baum MAINMENU */
#define MOSAVE   39  /* STRING in Baum MAINMENU */

#define POPUP    3   /* Formular/Dialog */
#define PWINMENU 1   /* BOX in Baum POPUP */
#define PFWD     2   /* STRING in Baum POPUP */
#define PBACK    3   /* STRING in Baum POPUP */
#define PGOTO    4   /* STRING in Baum POPUP */
#define PSSHRINK 6   /* STRING in Baum POPUP */
#define PDSHRINK 7   /* STRING in Baum POPUP */
#define PRVMODE  8   /* STRING in Baum POPUP */
#define PLOCK    9   /* STRING in Baum POPUP */
#define PHYPER   10  /* BOX in Baum POPUP */
#define PHDEF    11  /* STRING in Baum POPUP */
#define PHNEXT   12  /* STRING in Baum POPUP */
#define PHPREV   13  /* STRING in Baum POPUP */
#define PHBACK   14  /* STRING in Baum POPUP */
#define PSLOCK   15  /* STRING in Baum POPUP */
#define PSRV     16  /* STRING in Baum POPUP */
#define PSUNLOCK 17  /* STRING in Baum POPUP */
#define PSSP     18  /* STRING in Baum POPUP */

#define FMEMORY  4   /* Formular/Dialog */
#define FMFONTS  2   /* FTEXT in Baum FMEMORY */
#define FMGLYPHS 3   /* FTEXT in Baum FMEMORY */
#define FMCACHE  4   /* FTEXT in Baum FMEMORY */
#define FMDVISIZ 5   /* FTEXT in Baum FMEMORY */
#define FMDVILIM 6   /* FTEXT in Baum FMEMORY */
#define FMCANCEL 7   /* BUTTON in Baum FMEMORY */
#define FMOK     8   /* BUTTON in Baum FMEMORY */

#define FPATHS   5   /* Formular/Dialog */
#define FPDVI    3   /* FTEXT in Baum FPATHS */
#define FPHRES   4   /* FTEXT in Baum FPATHS */
#define FPVRES   5   /* FTEXT in Baum FPATHS */
#define FPPK     6   /* FTEXT in Baum FPATHS */
#define FPPKNAME 7   /* FTEXT in Baum FPATHS */
#define FPVF     8   /* FTEXT in Baum FPATHS */
#define FPTFM    9   /* FTEXT in Baum FPATHS */
#define FPIMG    10  /* FTEXT in Baum FPATHS */
#define FPMFLIND 13  /* BOXCHAR in Baum FPATHS */
#define FPMFSTRU 15  /* BOXCHAR in Baum FPATHS */
#define FPMFNAME 17  /* FTEXT in Baum FPATHS */
#define FPCANCEL 18  /* BUTTON in Baum FPATHS */
#define FPOK     19  /* BUTTON in Baum FPATHS */

#define STRINGS  6   /* Formular/Dialog */
#define SMSGTITL 1   /* STRING in Baum STRINGS */
#define SUBANNER 2   /* STRING in Baum STRINGS */
#define SDVIFILE 3   /* STRING in Baum STRINGS */
#define SSETNAME 4   /* STRING in Baum STRINGS */
#define SE2MFNTS 5   /* STRING in Baum STRINGS */
#define SEF2SHRT 6   /* STRING in Baum STRINGS */
#define SENOPOST 7   /* STRING in Baum STRINGS */
#define SEBADPST 8   /* STRING in Baum STRINGS */
#define SEFN2LNG 9   /* STRING in Baum STRINGS */
#define SENOFNTD 10  /* STRING in Baum STRINGS */
#define SEPGSNFD 11  /* STRING in Baum STRINGS */
#define SEILLDVI 12  /* STRING in Baum STRINGS */
#define SEPOSUFL 13  /* STRING in Baum STRINGS */
#define SECHRUNP 14  /* STRING in Baum STRINGS */
#define SECHKSUM 15  /* STRING in Baum STRINGS */
#define SEPKFMT  16  /* STRING in Baum STRINGS */
#define SEPKPACK 17  /* STRING in Baum STRINGS */
#define SEFNTMIS 18  /* STRING in Baum STRINGS */
#define SEFNTSUB 19  /* STRING in Baum STRINGS */
#define SCACHINF 20  /* STRING in Baum STRINGS */
#define SEOPNMFF 21  /* STRING in Baum STRINGS */
#define SECLSMFF 22  /* STRING in Baum STRINGS */
#define SMFSHEAD 23  /* STRING in Baum STRINGS */
#define SMFSLINE 24  /* STRING in Baum STRINGS */
#define SEDVIS2L 25  /* STRING in Baum STRINGS */
#define SEDVISIG 26  /* STRING in Baum STRINGS */
#define SEIMGFNM 27  /* STRING in Baum STRINGS */
#define SEIMGNFD 28  /* STRING in Baum STRINGS */
#define SEIMGMEM 29  /* STRING in Baum STRINGS */
#define SEIMGRER 30  /* STRING in Baum STRINGS */
#define SEIMGUNC 31  /* STRING in Baum STRINGS */
#define SEIMGSRC 32  /* STRING in Baum STRINGS */
#define SEIMGVER 33  /* STRING in Baum STRINGS */
#define SEIMGCOL 34  /* STRING in Baum STRINGS */
#define SEHL2SHT 35  /* STRING in Baum STRINGS */
#define SSTITLE  36  /* STRING in Baum STRINGS */
#define SSSTMEM  37  /* STRING in Baum STRINGS */
#define SSML1    38  /* STRING in Baum STRINGS */
#define SSML2    39  /* STRING in Baum STRINGS */
#define SSML3    40  /* STRING in Baum STRINGS */
#define SSML4    41  /* STRING in Baum STRINGS */
#define SSML5    42  /* STRING in Baum STRINGS */
#define SSSTRUN  43  /* STRING in Baum STRINGS */
#define SSRL1    44  /* STRING in Baum STRINGS */
#define SSRL2    45  /* STRING in Baum STRINGS */
#define SSRL3    46  /* STRING in Baum STRINGS */
#define SSRL4    47  /* STRING in Baum STRINGS */
#define SSRL5    48  /* STRING in Baum STRINGS */
#define SSRL6    49  /* STRING in Baum STRINGS */
#define SSRL7    50  /* STRING in Baum STRINGS */
#define SSRL8    51  /* STRING in Baum STRINGS */
#define SSRL9    52  /* STRING in Baum STRINGS */
#define SENOMETA 53  /* STRING in Baum STRINGS */
#define SENOCSG  54  /* STRING in Baum STRINGS */
#define SEFLIBRD 55  /* STRING in Baum STRINGS */
#define SEFLIDIR 56  /* STRING in Baum STRINGS */
#define SEEMGFNF 57  /* STRING in Baum STRINGS */
#define SEEMGSUB 58  /* STRING in Baum STRINGS */
#define SWINDINF 59  /* STRING in Baum STRINGS */

#define FGSWITCH 7   /* Formular/Dialog */
#define FGSANIM  3   /* BOXCHAR in Baum FGSWITCH */
#define FGSMEM   5   /* BOXCHAR in Baum FGSWITCH */
#define FGSDESK  7   /* BOXCHAR in Baum FGSWITCH */
#define FGSFEEP  9   /* BOXCHAR in Baum FGSWITCH */
#define FGSRAISE 11  /* BOXCHAR in Baum FGSWITCH */
#define FGSRBUT  13  /* BOXCHAR in Baum FGSWITCH */
#define FGSFACTV 16  /* BOXCHAR in Baum FGSWITCH */
#define FGSFPNT  18  /* BOXCHAR in Baum FGSWITCH */
#define FGSFCOL  20  /* FTEXT in Baum FGSWITCH */
#define FGSBCOL  21  /* FTEXT in Baum FGSWITCH */
#define FGSCANCL 22  /* BUTTON in Baum FGSWITCH */
#define FGSOK    23  /* BUTTON in Baum FGSWITCH */

#define FGOTO    8   /* Formular/Dialog */
#define FGPAGENO 2   /* FTEXT in Baum FGOTO */
#define FGOK     3   /* BUTTON in Baum FGOTO */
#define FGCANCEL 4   /* BUTTON in Baum FGOTO */

#define CREDITFM 9   /* Formular/Dialog */

#define FFORMAT  10  /* Formular/Dialog */
#define FFLEFTM  3   /* FTEXT in Baum FFORMAT */
#define FFTOP    4   /* FTEXT in Baum FFORMAT */
#define FFPGWD   5   /* FTEXT in Baum FFORMAT */
#define FFPGHT   6   /* FTEXT in Baum FFORMAT */
#define FFCANCEL 7   /* BUTTON in Baum FFORMAT */
#define FFOK     8   /* BUTTON in Baum FFORMAT */

#define FHELP    11  /* Formular/Dialog */
#define FHOK     16  /* BUTTON in Baum FHELP */

#define FDSWITCH 12  /* Formular/Dialog */
#define FDSCCHAH 3   /* BOXCHAR in Baum FDSWITCH */
#define FDSSMART 5   /* BOXCHAR in Baum FDSWITCH */
#define FDSMAGIC 7   /* BOXCHAR in Baum FDSWITCH */
#define FDSRVMOD 9   /* BOXCHAR in Baum FDSWITCH */
#define FDSGRAPH 11  /* BOXCHAR in Baum FDSWITCH */
#define FDSVERBS 13  /* BOXCHAR in Baum FDSWITCH */
#define FDSHYPER 15  /* BOXCHAR in Baum FDSWITCH */
#define FDSSHR2  18  /* BOXCHAR in Baum FDSWITCH */
#define FDSSHR3  19  /* BOXCHAR in Baum FDSWITCH */
#define FDSLOG   24  /* BOXCHAR in Baum FDSWITCH */
#define FDSPAGET 26  /* BOXCHAR in Baum FDSWITCH */
#define FDSCANCL 28  /* BUTTON in Baum FDSWITCH */
#define FDSOK    29  /* BUTTON in Baum FDSWITCH */

#define ADVIOPEN 0   /* Alert String */

#define AMEMORY  1   /* Alert String */

#define APAGE    2   /* Alert String */

#define ALOCK    3   /* Alert String */

#define AFONTS   4   /* Alert String */

#define ASETUP   5   /* Alert String */

#define ANOTIMP  6   /* Alert String */

#define AOPTION  7   /* Alert String */

#define ASBADVAR 8   /* Alert String */

#define ASBADLN  9   /* Alert String */

#define ASETUPW  10  /* Alert String */

#define ASBADMAG 11  /* Alert String */

#define ASBADU   12  /* Alert String */

#define APDISK   13  /* Alert String */

#define APMEMORY 14  /* Alert String */

#define APANIC   15  /* Alert String */

#define ANOWIND  16  /* Alert String */

#define ACACHE   17  /* Alert String */

#define AERROR   18  /* Alert String */

#define APAGENO  19  /* Alert String */

#define ASBADGEO 20  /* Alert String */

#define ASBADSTY 21  /* Alert String */

#define ANOLOG   22  /* Alert String */

#define ASBADFOC 23  /* Alert String */

#define AOPTSTR  24  /* Alert String */
