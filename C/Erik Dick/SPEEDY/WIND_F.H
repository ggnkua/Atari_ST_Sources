int font_window_open( void );
int font_window_click(int Handle, int mouse_x, int mouse_y);
void font_window(EVENT *evnt);
