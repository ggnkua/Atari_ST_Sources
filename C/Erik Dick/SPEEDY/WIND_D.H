int demo_window_open( int font_id,char *typeface );
void demo_window(EVENT *evnt);
void handle_print(void);
