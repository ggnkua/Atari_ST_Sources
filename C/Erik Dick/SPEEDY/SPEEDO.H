void my_vqt_pairkern(int handle,int ch1,int ch2,fix31 *x,fix31 *y);
fix31 my_vst_arbpt32(int handle,fix31 point,int *char_w,int *char_h,int *cell_w,int *cell_h);