#define TITLE 0  	/* TREE */
#define BOX 1  	/* TREE */
#define DA 1  	/* OBJECT in TREE #1 */
#define SPEAKER 2  	/* OBJECT in TREE #1 */
#define QUIT 3  	/* OBJECT in TREE #1 */
#define INFORMA 7  	/* OBJECT in TREE #1 */
#define INF 2  	/* TREE */
