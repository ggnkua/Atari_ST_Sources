#define DIALOG1 0  	/* TREE */
#define DIALOG2 1  	/* TREE */
#define WHITEBOX 2  	/* TREE */
#define ALERT1 3  	/* TREE */
#define ALERT2 4  	/* TREE */
#define DRIVES 4  	/* OBJECT in TREE #0 */
#define DRV_A 5  	/* OBJECT in TREE #0 */
#define DRV_T 24  	/* OBJECT in TREE #0 */
#define DRV_ALL 25  	/* OBJECT in TREE #0 */
#define DRV_BA 26  	/* OBJECT in TREE #0 */
#define DELAY_M 28  	/* OBJECT in TREE #0 */
#define DELAY 29  	/* OBJECT in TREE #0 */
#define DELAY_P 30  	/* OBJECT in TREE #0 */
#define AKTIV1 31  	/* OBJECT in TREE #0 */
#define TITEL 32  	/* OBJECT in TREE #0 */
#define OK1 35  	/* OBJECT in TREE #0 */
#define ABBRUCH1 36  	/* OBJECT in TREE #0 */
#define SICHERN1 37  	/* OBJECT in TREE #0 */
#define SWITCH1 38  	/* OBJECT in TREE #0 */
#define CAPS_CHA 1  	/* OBJECT in TREE #1 */
#define DATE_ZER 2  	/* OBJECT in TREE #1 */
#define JAHR 3  	/* OBJECT in TREE #1 */
#define TIME_ZER 4  	/* OBJECT in TREE #1 */
#define SEK 5  	/* OBJECT in TREE #1 */
#define SP1 6  	/* OBJECT in TREE #1 */
#define CAPS 7  	/* OBJECT in TREE #1 */
#define SP2 8  	/* OBJECT in TREE #1 */
#define RW 9  	/* OBJECT in TREE #1 */
#define SP3 10  	/* OBJECT in TREE #1 */
#define LEDS 11  	/* OBJECT in TREE #1 */
#define SP4 12  	/* OBJECT in TREE #1 */
#define DATE 13  	/* OBJECT in TREE #1 */
#define SP5 14  	/* OBJECT in TREE #1 */
#define TIME 15  	/* OBJECT in TREE #1 */
#define SP6 16  	/* OBJECT in TREE #1 */
#define LUECKEN 17  	/* OBJECT in TREE #1 */
#define XLUECKEN 18  	/* OBJECT in TREE #1 */
#define L1 19  	/* OBJECT in TREE #1 */
#define D1 20  	/* OBJECT in TREE #1 */
#define P1 21  	/* OBJECT in TREE #1 */
#define M2 22  	/* OBJECT in TREE #1 */
#define D2 23  	/* OBJECT in TREE #1 */
#define P2 24  	/* OBJECT in TREE #1 */
#define FIT 26  	/* OBJECT in TREE #1 */
#define ONE 27  	/* OBJECT in TREE #1 */
#define TWO 28  	/* OBJECT in TREE #1 */
#define RUND 29  	/* OBJECT in TREE #1 */
#define SCHWARZ 30  	/* OBJECT in TREE #1 */
#define COLOR 31  	/* OBJECT in TREE #1 */
#define DIST_M 33  	/* OBJECT in TREE #1 */
#define DIST 34  	/* OBJECT in TREE #1 */
#define DIST_P 35  	/* OBJECT in TREE #1 */
#define AKTIV2 36  	/* OBJECT in TREE #1 */
#define OK2 39  	/* OBJECT in TREE #1 */
#define ABBRUCH2 40  	/* OBJECT in TREE #1 */
#define SICHERN2 41  	/* OBJECT in TREE #1 */
#define SWITCH2 42  	/* OBJECT in TREE #1 */
