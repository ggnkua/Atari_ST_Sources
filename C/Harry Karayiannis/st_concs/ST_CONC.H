/* resource file indicies for CONCENTR */

#define FRMBOARD 0	/* form/dialog */
#define PIC1     3	/* IMAGE in tree FRMBOARD */
#define PIC2     4	/* IMAGE in tree FRMBOARD */
#define PIC3     5	/* IMAGE in tree FRMBOARD */
#define PIC4     6	/* IMAGE in tree FRMBOARD */
#define PIC5     7	/* IMAGE in tree FRMBOARD */
#define PIC6     8	/* IMAGE in tree FRMBOARD */
#define PIC7     9	/* IMAGE in tree FRMBOARD */
#define PIC8     10	/* IMAGE in tree FRMBOARD */
#define PIC9     11	/* IMAGE in tree FRMBOARD */
#define PIC10    12	/* IMAGE in tree FRMBOARD */
#define PIC11    13	/* IMAGE in tree FRMBOARD */
#define PIC12    14	/* IMAGE in tree FRMBOARD */
#define PIC13    15	/* IMAGE in tree FRMBOARD */
#define PIC14    16	/* IMAGE in tree FRMBOARD */
#define PIC15    17	/* IMAGE in tree FRMBOARD */
#define PIC16    18	/* IMAGE in tree FRMBOARD */
#define PIC17    19	/* IMAGE in tree FRMBOARD */
#define PIC18    20	/* IMAGE in tree FRMBOARD */
#define PIC19    21	/* IMAGE in tree FRMBOARD */
#define PIC20    22	/* IMAGE in tree FRMBOARD */
#define PIC21    23	/* IMAGE in tree FRMBOARD */
#define PIC22    24	/* IMAGE in tree FRMBOARD */
#define PIC23    25	/* IMAGE in tree FRMBOARD */
#define PIC24    26	/* IMAGE in tree FRMBOARD */
#define PIC25    27	/* IMAGE in tree FRMBOARD */
#define PIC26    28	/* IMAGE in tree FRMBOARD */
#define PIC27    29	/* IMAGE in tree FRMBOARD */
#define PIC28    30	/* IMAGE in tree FRMBOARD */
#define PIC29    31	/* IMAGE in tree FRMBOARD */
#define PIC30    32	/* IMAGE in tree FRMBOARD */
#define PIC31    33	/* IMAGE in tree FRMBOARD */
#define PIC32    34	/* IMAGE in tree FRMBOARD */
#define PIC33    35	/* IMAGE in tree FRMBOARD */
#define PIC34    36	/* IMAGE in tree FRMBOARD */
#define PIC35    37	/* IMAGE in tree FRMBOARD */
#define PIC36    38	/* IMAGE in tree FRMBOARD */
#define PIC37    39	/* IMAGE in tree FRMBOARD */
#define PIC38    40	/* IMAGE in tree FRMBOARD */
#define PIC39    41	/* IMAGE in tree FRMBOARD */
#define PIC40    42	/* IMAGE in tree FRMBOARD */
#define PIC41    43	/* IMAGE in tree FRMBOARD */
#define PIC42    44	/* IMAGE in tree FRMBOARD */
#define PIC43    45	/* IMAGE in tree FRMBOARD */
#define PIC44    46	/* IMAGE in tree FRMBOARD */
#define PIC45    47	/* IMAGE in tree FRMBOARD */
#define PIC46    48	/* IMAGE in tree FRMBOARD */
#define PIC47    49	/* IMAGE in tree FRMBOARD */
#define PIC48    50	/* IMAGE in tree FRMBOARD */
#define PIC49    51	/* IMAGE in tree FRMBOARD */
#define PIC50    52	/* IMAGE in tree FRMBOARD */
#define PIC51    53	/* IMAGE in tree FRMBOARD */
#define PIC52    54	/* IMAGE in tree FRMBOARD */
#define PIC53    55	/* IMAGE in tree FRMBOARD */
#define PIC54    56	/* IMAGE in tree FRMBOARD */
#define PIC55    57	/* IMAGE in tree FRMBOARD */
#define PIC56    58	/* IMAGE in tree FRMBOARD */
#define PIC57    59	/* IMAGE in tree FRMBOARD */
#define PIC58    60	/* IMAGE in tree FRMBOARD */
#define PIC59    61	/* IMAGE in tree FRMBOARD */
#define PIC60    62	/* IMAGE in tree FRMBOARD */
#define PIC61    63	/* IMAGE in tree FRMBOARD */
#define PIC62    64	/* IMAGE in tree FRMBOARD */
#define PIC63    65	/* IMAGE in tree FRMBOARD */
#define PIC64    66	/* IMAGE in tree FRMBOARD */
#define PIC65    67	/* IMAGE in tree FRMBOARD */
#define PIC66    68	/* IMAGE in tree FRMBOARD */
#define PIC67    69	/* IMAGE in tree FRMBOARD */
#define PIC68    70	/* IMAGE in tree FRMBOARD */
#define PIC69    71	/* IMAGE in tree FRMBOARD */
#define PIC70    72	/* IMAGE in tree FRMBOARD */
#define PIC71    73	/* IMAGE in tree FRMBOARD */
#define PIC72    74	/* IMAGE in tree FRMBOARD */
#define PIC73    75	/* IMAGE in tree FRMBOARD */
#define PIC74    76	/* IMAGE in tree FRMBOARD */
#define PIC75    77	/* IMAGE in tree FRMBOARD */
#define PIC76    78	/* IMAGE in tree FRMBOARD */
#define PIC77    79	/* IMAGE in tree FRMBOARD */
#define PIC78    80	/* IMAGE in tree FRMBOARD */
#define PIC79    81	/* IMAGE in tree FRMBOARD */
#define PIC80    82	/* IMAGE in tree FRMBOARD */
#define PIC81    83	/* IMAGE in tree FRMBOARD */
#define PIC82    84	/* IMAGE in tree FRMBOARD */
#define PIC83    85	/* IMAGE in tree FRMBOARD */
#define PIC84    86	/* IMAGE in tree FRMBOARD */
#define PIC85    87	/* IMAGE in tree FRMBOARD */
#define PIC86    88	/* IMAGE in tree FRMBOARD */
#define PIC87    89	/* IMAGE in tree FRMBOARD */
#define PIC88    90	/* IMAGE in tree FRMBOARD */
#define PIC89    91	/* IMAGE in tree FRMBOARD */
#define PIC90    92	/* IMAGE in tree FRMBOARD */
#define PIC91    93	/* IMAGE in tree FRMBOARD */
#define PIC92    94	/* IMAGE in tree FRMBOARD */
#define PIC93    95	/* IMAGE in tree FRMBOARD */
#define PIC94    96	/* IMAGE in tree FRMBOARD */
#define PIC95    97	/* IMAGE in tree FRMBOARD */
#define PIC96    98	/* IMAGE in tree FRMBOARD */
#define PIC97    99	/* IMAGE in tree FRMBOARD */
#define PIC98    100	/* IMAGE in tree FRMBOARD */
#define PIC99    101	/* IMAGE in tree FRMBOARD */
#define PIC100   102	/* IMAGE in tree FRMBOARD */
#define PICBLANK 103	/* IMAGE in tree FRMBOARD */
#define ABOUT    104	/* BOXTEXT in tree FRMBOARD */
#define BOARD70  107	/* BOXTEXT in tree FRMBOARD */
#define BOARD80  108	/* BOXTEXT in tree FRMBOARD */
#define BOARD90  109	/* BOXTEXT in tree FRMBOARD */
#define BOARD100 110	/* BOXTEXT in tree FRMBOARD */
#define PLAYERS1 113	/* BOXTEXT in tree FRMBOARD */
#define PLAYERS2 114	/* BOXTEXT in tree FRMBOARD */
#define PLAYERS3 115	/* BOXTEXT in tree FRMBOARD */
#define PLAYERS4 116	/* BOXTEXT in tree FRMBOARD */
#define CURPLAYE 117	/* BOXTEXT in tree FRMBOARD */
#define SCORES1  118	/* BOXTEXT in tree FRMBOARD */
#define SCORES2  119	/* BOXTEXT in tree FRMBOARD */
#define SCORES3  120	/* BOXTEXT in tree FRMBOARD */
#define SCORES4  121	/* BOXTEXT in tree FRMBOARD */
#define HISCORES 122	/* BOXTEXT in tree FRMBOARD */
#define SAVEHISC 123	/* BOXTEXT in tree FRMBOARD */
#define NEWGAME  124	/* BUTTON in tree FRMBOARD */
#define QUITGAME 125	/* BUTTON in tree FRMBOARD */

#define FRMSCORE 1	/* form/dialog */
#define TOPNAM1  5	/* STRING in tree FRMSCORE */
#define TOPNAM2  6	/* STRING in tree FRMSCORE */
#define TOPNAM3  7	/* STRING in tree FRMSCORE */
#define TOPNAM4  8	/* STRING in tree FRMSCORE */
#define TOPNAM5  12	/* STRING in tree FRMSCORE */
#define TOPNAM6  13	/* STRING in tree FRMSCORE */
#define TOPNAM7  14	/* STRING in tree FRMSCORE */
#define TOPNAM8  15	/* STRING in tree FRMSCORE */
#define TOPNAM9  19	/* STRING in tree FRMSCORE */
#define TOPNAM10 20	/* STRING in tree FRMSCORE */
#define TOPNAM11 21	/* STRING in tree FRMSCORE */
#define TOPNAM12 22	/* STRING in tree FRMSCORE */
#define POINTS1  23	/* STRING in tree FRMSCORE */
#define POINTS2  24	/* STRING in tree FRMSCORE */
#define POINTS3  25	/* STRING in tree FRMSCORE */
#define POINTS4  26	/* STRING in tree FRMSCORE */
#define POINTS5  27	/* STRING in tree FRMSCORE */
#define POINTS6  28	/* STRING in tree FRMSCORE */
#define POINTS7  29	/* STRING in tree FRMSCORE */
#define POINTS8  30	/* STRING in tree FRMSCORE */
#define POINTS9  31	/* STRING in tree FRMSCORE */
#define POINTS10 32	/* STRING in tree FRMSCORE */
#define POINTS11 33	/* STRING in tree FRMSCORE */
#define POINTS12 34	/* STRING in tree FRMSCORE */

#define FRMNAMES 2	/* form/dialog */
#define NAME1    2	/* FTEXT in tree FRMNAMES */
#define NAME2    3	/* FTEXT in tree FRMNAMES */
#define NAME3    4	/* FTEXT in tree FRMNAMES */
#define NAME4    5	/* FTEXT in tree FRMNAMES */

#define FRMTOPER 3	/* form/dialog */
#define TOPSCORE 2	/* BOXTEXT in tree FRMTOPER */

#define FRMWINER 4	/* form/dialog */
#define WINNER   1	/* BOXTEXT in tree FRMWINER */

#define FRMABOUT 5	/* form/dialog */

