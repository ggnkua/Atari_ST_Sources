*
*  NEOchrome cut buffer contents (left justified):
*
*    pixels/scanline    = $0010 (bytes/scanline: $0008)
*  # scanlines (height) = $0010
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0700,$0730,$0750,$0770,$0470,$0070,$0075
*      $0077,$0057,$0027,$0007,$0507,$0707,$0704,$0777
*
*
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
	 dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
