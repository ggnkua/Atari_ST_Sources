#define TEXT 23
#define B1 28
#define B2 27
#define PRINTER 0
