/* Schalter-Definition */

typedef struct
{
	int on[16];
	int off[16];
} SWITCH;

SWITCH Runder_Knopf = {
	0x0000, 0x03c0, 0x0c30, 0x1008, 0x23c4, 0x27e4, 0x4ff2, 0x4ff2,
	0x4ff2, 0x4ff2, 0x27e4, 0x23c4, 0x1008, 0x0c30, 0x03c0, 0x0000,
	0x0000, 0x03c0, 0x0c30, 0x1008, 0x2004, 0x2004, 0x4002, 0x4002,
	0x4002, 0x4002, 0x2004, 0x2004, 0x1008, 0x0c30, 0x03c0, 0x0000
};

SWITCH Eckiger_Knopf = {
	0x0000, 0x7ffe, 0x6006, 0x500a, 0x4812, 0x4422, 0x4242, 0x4182,
	0x4182, 0x4242, 0x4422, 0x4812, 0x500a, 0x6006, 0x7ffe, 0x0000,
	0x0000, 0x7ffe, 0x4002, 0x4002, 0x4002, 0x4002, 0x4002, 0x4002, 
	0x4002, 0x4002, 0x4002, 0x4002, 0x4002, 0x4002, 0x7ffe, 0x0000
};

SWITCH Knick_Ecke = {
	0x8000, 0xc000, 0xa000, 0x9000, 0x8800, 0x8400, 0x8200, 0x8100,
	0x8080, 0x8040, 0x8020, 0x8010, 0x8008, 0x8004, 0x8002, 0xffff,
	0x8000, 0xc000, 0xa000, 0x9000, 0x8800, 0x8400, 0x8200, 0x8100,
	0x8080, 0x8040, 0x8020, 0x8010, 0x8008, 0x8004, 0x8002, 0xffff
};
