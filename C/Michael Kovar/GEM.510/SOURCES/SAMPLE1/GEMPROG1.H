/* Headerdatei f�r das GEM Beispielprogramm
 * ---------------------------------------- */

/* Typendefinition f�r das Probeprogramm
 * ------------------------------------- */
typedef struct	ext_window
{
	int	w_index;
	int	offen;
	int	x;
	int	y;
	int	w;
	int	h;
	int	w_min;
	int	h_min;
	int	x_max;
	int	y_max;
	int	w_max;
	int	h_max;
} EXT;


