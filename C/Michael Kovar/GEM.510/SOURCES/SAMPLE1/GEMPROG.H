/* resource set indices for GEMPROG */

#define MENUE      0 /* menu */
#define MNINFO     3 /* TITLE in tree MENUE */
#define MNDATEI    4 /* TITLE in tree MENUE */
#define FENSTER    5 /* TITLE in tree MENUE */
#define SYSTEM     6 /* TITLE in tree MENUE */
#define ITINFO     9 /* STRING in tree MENUE */
#define ITNEU     18 /* STRING in tree MENUE */
#define ITOEFFNE  19 /* STRING in tree MENUE */
#define ITSICHER  21 /* STRING in tree MENUE */
#define ITSICALS  22 /* STRING in tree MENUE */
#define ITAUSGAB  23 /* STRING in tree MENUE */
#define ITENDE    25 /* STRING in tree MENUE */
#define FENEU     27 /* STRING in tree MENUE */
#define FEOEFFNE  28 /* STRING in tree MENUE */
#define FETOPPEN  29 /* STRING in tree MENUE */
#define FEAKTCLO  31 /* STRING in tree MENUE */
#define FEAKTDEL  33 /* STRING in tree MENUE */
#define SYSINFO   35 /* STRING in tree MENUE */

#define DESKTOP    1 /* form/dialog */
#define BSPICON    1 /* ICON in tree DESKTOP */

#define INFODIAL   2 /* form/dialog */
#define INFOEXIT   4 /* BUTTON in tree INFODIAL */
#define INFODRAG   6 /* BOXCHAR in tree INFODIAL */

#define FECHOICE   3 /* form/dialog */
#define CHBOX      0 /* BOX in tree FECHOICE */
#define CHTITLE    1 /* BOXTEXT in tree FECHOICE */
#define CHNUMMER   2 /* FBOXTEXT in tree FECHOICE */
#define CHOKAY     3 /* BUTTON in tree FECHOICE */
#define CHABBRUC   4 /* BUTTON in tree FECHOICE */
#define FEDRAG     5 /* BOXCHAR in tree FECHOICE */

#define BUTTDIAL   4 /* form/dialog */
#define BUTTDRAG   1 /* BOXCHAR in tree BUTTDIAL */
#define BUTTUEB    2 /* BOXTEXT in tree BUTTDIAL */
#define BUTTFLAE   3 /* BOX in tree BUTTDIAL */
#define BUTTFEN1   4 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN2   5 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN3   6 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN4   7 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN5   8 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN6   9 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN7  10 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN8  11 /* BOXCHAR in tree BUTTDIAL */
#define BUTTFEN9  12 /* BOXCHAR in tree BUTTDIAL */
#define BUTTTXT1  13 /* STRING in tree BUTTDIAL */
#define BUTTTXT2  14 /* STRING in tree BUTTDIAL */
#define BUTTTXT3  15 /* STRING in tree BUTTDIAL */
#define BUTTTXT4  16 /* STRING in tree BUTTDIAL */
#define BUTTTXT5  17 /* STRING in tree BUTTDIAL */
#define BUTTTXT6  18 /* STRING in tree BUTTDIAL */
#define BUTTTXT7  19 /* STRING in tree BUTTDIAL */
#define BUTTTXT8  20 /* STRING in tree BUTTDIAL */
#define BUTTTXT9  21 /* STRING in tree BUTTDIAL */
#define BUTTCRO1  22 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO2  23 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO3  24 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO4  25 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO5  26 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO6  27 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO7  28 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO8  29 /* BOXCHAR in tree BUTTDIAL */
#define BUTTCRO9  30 /* BOXCHAR in tree BUTTDIAL */
#define BUTTOK    31 /* BUTTON in tree BUTTDIAL */
#define BUTTABBR  32 /* BUTTON in tree BUTTDIAL */

#define SYSDIAL    5 /* form/dialog */
#define SYSDRAG    1 /* BOXCHAR in tree SYSDIAL */
#define SYSTITLE   2 /* BOXTEXT in tree SYSDIAL */
#define SYSBOX     3 /* BOX in tree SYSDIAL */
#define SYSTEXT1   4 /* TEXT in tree SYSDIAL */
#define SYSNVDI    5 /* TEXT in tree SYSDIAL */
#define SYSTEXT2   6 /* TEXT in tree SYSDIAL */
#define SYSMULTI   7 /* TEXT in tree SYSDIAL */
#define SYSOK      8 /* BUTTON in tree SYSDIAL */

#define INFOZEIL   6 /* form/dialog */
#define ZEDRAG     1 /* BOXCHAR in tree INFOZEIL */
#define ZETITEL    2 /* BOXTEXT in tree INFOZEIL */
#define ZEBOX      3 /* BOX in tree INFOZEIL */
#define ZEFENUMM   4 /* FTEXT in tree INFOZEIL */
#define ZETEXT     5 /* FTEXT in tree INFOZEIL */
#define ZEOKAY     6 /* BUTTON in tree INFOZEIL */
#define ZEABBRUC   7 /* BUTTON in tree INFOZEIL */

#define LADEN      0 /* Alert string */

#define SPEICHER   1 /* Alert string */

#define DOPPEL     2 /* Alert string */

#define AUSGABE    3 /* Alert string */

