/* ----------------- ST FORMAT PINBALL PROGRAM ------- ------------------------

	Title:		PINBALL

	Module:		sprites.h

	Version:	1.1

	Author:		Warwick Grigg

	Copyright (c) Warwick Grigg 1990. All rights reserved.

----------------------------------------------------------------------------- */

#include "spritesc.h"

extern int WordPix();
extern void InitFDB();
extern struct sprite_s *OpenSprite();
extern void DrawSprite();
extern void UndrawSprite();
extern void CloseSprite();
