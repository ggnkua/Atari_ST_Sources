/* ----------------- ST FORMAT PINBALL PROGRAM ------- ------------------------

	Title:		PINBALL

	Module:		flip.h

	Version:	1.1

	Author:		Warwick Grigg

	Copyright (c) Warwick Grigg 1990. All rights reserved.

----------------------------------------------------------------------------- */
#include "flipc.h"

extern struct flipdef_s *Flip();
extern struct flipdef_s *PrepScreens();
extern void DeFlip();
