	/* 'definition'-module von array3d.c */

int array_add(int, double);
int array_mul(int, double);

int array_minimax(int, double *, double *);

void arrayxset(void), arrayyset(void);

