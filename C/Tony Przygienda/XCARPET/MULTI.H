/* 'def's' f�r MULTI.C */

void check   (int);
void uncheck (int);
void enable  (int);
void disable (int);

void multi(void);
