/* def's f�r XFILES */

int fileselect(char *,char *);
FILE *fopen_wr(char *);
void save_3d(char *);
void save_img(char *);

