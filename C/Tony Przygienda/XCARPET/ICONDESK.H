/* 'definition' for icondesk */

void init_desktop(void);

void icon_select(WORD);
void switch_icon(WORD,int);
void move_icon(WORD, WORD, WORD);
void icons_deselect(void);
