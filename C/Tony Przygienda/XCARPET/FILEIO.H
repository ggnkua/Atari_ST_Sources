/* def's f� file_io */

int inp_filename(void);
int out_filename(void);
int read_header(void);
int write_header(void);
int inp_seekdata(void);
int read_data(void);
int write_data(void);
