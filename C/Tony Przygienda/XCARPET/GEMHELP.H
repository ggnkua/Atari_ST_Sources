/* 'definition' f�r GEMHELP.C */

int hndl_dial(OBJECT *,int,int,int,int,int);
void undo_obj(OBJECT *,WORD, WORD);
void   do_obj(OBJECT *,WORD, WORD);
WORD  ask_obj(OBJECT *,WORD, WORD);

/* mouse_operations */

void hide_mouse(void),show_mouse(void);
void arrow(void),point_hand(void),bee(void);

