/* def's f�r SCANCHAR.C */

int kommentar(char **);
int ein_wort(char **,char *);
