/* Resource-Set indicies fuer COLORRSC */

#define CPULLDOW 0	/* Menuebaum */
#define CTINFO   3	/* TITLE in Baum CPULLDOW */
#define CTFILE   4	/* TITLE in Baum CPULLDOW */
#define CTFUNC   5	/* TITLE in Baum CPULLDOW */
#define CTCONST  6	/* TITLE in Baum CPULLDOW */
#define CTHELP   7	/* TITLE in Baum CPULLDOW */
#define CMINFO   10	/* STRING in Baum CPULLDOW */
#define CDATEI   19	/* STRING in Baum CPULLDOW */
#define CFUNKTIO 20	/* STRING in Baum CPULLDOW */
#define CMSAVEMO 21	/* STRING in Baum CPULLDOW */
#define CMSAVE   22	/* STRING in Baum CPULLDOW */
#define CMDRAWF  24	/* STRING in Baum CPULLDOW */
#define CHARDCOP 25	/* STRING in Baum CPULLDOW */
#define CQUIT    26	/* STRING in Baum CPULLDOW */
#define CMROTATE 28	/* STRING in Baum CPULLDOW */
#define CMVIEW   29	/* STRING in Baum CPULLDOW */
#define CMLIGHT  30	/* STRING in Baum CPULLDOW */
#define CMRESOL  31	/* STRING in Baum CPULLDOW */
#define CDARSTEL 32	/* STRING in Baum CPULLDOW */
#define CMDEGREE 33	/* STRING in Baum CPULLDOW */
#define CMRADIAN 34	/* STRING in Baum CPULLDOW */
#define CMHSTAD  36	/* STRING in Baum CPULLDOW */
#define CMHFUNC  37	/* STRING in Baum CPULLDOW */
#define CMHSPECF 38	/* STRING in Baum CPULLDOW */
#define CMHROTAT 39	/* STRING in Baum CPULLDOW */
#define CMHVIEW  41	/* STRING in Baum CPULLDOW */
#define CMHRESOL 42	/* STRING in Baum CPULLDOW */
#define CMHDRAW  43	/* STRING in Baum CPULLDOW */

#define CINFOFOR 1	/* Formula/Dialog */
#define CMYNAME  2	/* BOXTEXT in Baum CINFOFOR */

#define CRESOLUT 2	/* Formula/Dialog */
#define CXWERTE  3	/* FTEXT in Baum CRESOLUT */
#define CYWERTE  4	/* FTEXT in Baum CRESOLUT */

#define CICONS   3	/* Formula/Dialog */
#define CDESKTOP 0	/* BOX in Baum CICONS */
#define CISAVE   1	/* ICON in Baum CICONS */
#define CIINPUTF 2	/* ICON in Baum CICONS */
#define CIDRAWF  3	/* ICON in Baum CICONS */
#define CIROTATE 4	/* ICON in Baum CICONS */
#define CILIGHT  5	/* ICON in Baum CICONS */
#define CIVIEW   6	/* ICON in Baum CICONS */
#define CIRESOL  7	/* ICON in Baum CICONS */
#define CISTYLE  8	/* ICON in Baum CICONS */
#define CMEMOSTA 9	/* BOXTEXT in Baum CICONS */

#define CGRAFMOD 4	/* Formula/Dialog */
#define CRASTER  1	/* BOX in Baum CGRAFMOD */
#define CXRASTER 2	/* BOXTEXT in Baum CGRAFMOD */
#define CYRASTER 3	/* FBOXTEXT in Baum CGRAFMOD */
#define CXYRASTE 4	/* BOXTEXT in Baum CGRAFMOD */
#define CNORMALP 6	/* BOXTEXT in Baum CGRAFMOD */
#define CZENTRAL 7	/* BOXTEXT in Baum CGRAFMOD */
#define CDRAHT   10	/* BOXTEXT in Baum CGRAFMOD */
#define CHIDDEND 11	/* BOXTEXT in Baum CGRAFMOD */
#define CSUNSHIN 12	/* BOXTEXT in Baum CGRAFMOD */

#define CSTARTIN 5	/* Formula/Dialog */

#define COUTPUT  6	/* Formula/Dialog */
#define COTIMG   3	/* BOXTEXT in Baum COUTPUT */
#define COTSTAD  4	/* BOXTEXT in Baum COUTPUT */
#define COTDEGAS 5	/* BOXTEXT in Baum COUTPUT */
#define COTDOODL 6	/* BOXTEXT in Baum COUTPUT */
#define COTASCII 7	/* BOXTEXT in Baum COUTPUT */

#define CINPUTF  7	/* Formula/Dialog */
#define CFUNC1   4	/* FTEXT in Baum CINPUTF */
#define CFUNC2   5	/* FTEXT in Baum CINPUTF */
#define CXSTART  8	/* FTEXT in Baum CINPUTF */
#define CXEND    9	/* FTEXT in Baum CINPUTF */
#define CYSTART  11	/* FTEXT in Baum CINPUTF */
#define CCONSTA  13	/* FTEXT in Baum CINPUTF */
#define CCONSTB  14	/* FTEXT in Baum CINPUTF */
#define CCONSTC  15	/* FTEXT in Baum CINPUTF */

#define CDRAWFUN 8	/* Formula/Dialog */
#define CCOUNTBO 4	/* BOX in Baum CDRAWFUN */
#define CCOUNT3D 5	/* BOX in Baum CDRAWFUN */
#define CCOUNT2D 6	/* BOX in Baum CDRAWFUN */
#define CCOUNTFL 7	/* BOX in Baum CDRAWFUN */
#define CCOUNTSH 8	/* BOX in Baum CDRAWFUN */

#define CROTATIO 9	/* Formula/Dialog */
#define CZROTATE 2	/* FTEXT in Baum CROTATIO */
#define CXROTATE 3	/* FTEXT in Baum CROTATIO */

#define CVIEW    10	/* Formula/Dialog */
#define CLOOKX   2	/* FTEXT in Baum CVIEW */
#define CLOOKY   3	/* FTEXT in Baum CVIEW */
#define CLOOKZ   4	/* FTEXT in Baum CVIEW */
#define CPLANEY  10	/* FTEXT in Baum CVIEW */

#define CHFUNCT  11	/* Formula/Dialog */

#define CHROTATE 12	/* Formula/Dialog */

#define CSYSERRO 13	/* Formula/Dialog */
#define CQSYSERR 5	/* BOXTEXT in Baum CSYSERRO */

#define CSAVEFUN 14	/* Formula/Dialog */

#define CLIGHT   15	/* Formula/Dialog */
#define CLIGHTX  2	/* FTEXT in Baum CLIGHT */
#define CLIGHTY  3	/* FTEXT in Baum CLIGHT */
#define CLIGHTZ  4	/* FTEXT in Baum CLIGHT */
#define CRAHMEIN 6	/* BOXTEXT in Baum CLIGHT */
#define CRAHMAUS 7	/* BOXTEXT in Baum CLIGHT */

#define CHDRAW   16	/* Formula/Dialog */

#define CHRESOL  17	/* Formula/Dialog */

#define CHSPECF  18	/* Formula/Dialog */

#define CHPROJEK 19	/* Formula/Dialog */

#define CHSTAD   20	/* Formula/Dialog */

