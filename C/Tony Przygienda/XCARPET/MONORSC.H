/* Resource-Set indicies fuer MONORSC */

#define PULLDOWN 0	/* Menuebaum */
#define TINFO    3	/* TITLE in Baum PULLDOWN */
#define TFILE    4	/* TITLE in Baum PULLDOWN */
#define TFUNC    5	/* TITLE in Baum PULLDOWN */
#define TCONST   6	/* TITLE in Baum PULLDOWN */
#define THELP    7	/* TITLE in Baum PULLDOWN */
#define MINFO    11	/* STRING in Baum PULLDOWN */
#define DATEI    21	/* STRING in Baum PULLDOWN */
#define FUNKTION 22	/* STRING in Baum PULLDOWN */
#define MSAVEMOD 24	/* STRING in Baum PULLDOWN */
#define MSAVE    25	/* STRING in Baum PULLDOWN */
#define MDRAWF   27	/* STRING in Baum PULLDOWN */
#define HARDCOPY 28	/* STRING in Baum PULLDOWN */
#define QUIT     30	/* STRING in Baum PULLDOWN */
#define MROTATE  32	/* STRING in Baum PULLDOWN */
#define MVIEW    33	/* STRING in Baum PULLDOWN */
#define MLIGHT   34	/* STRING in Baum PULLDOWN */
#define MRESOL   36	/* STRING in Baum PULLDOWN */
#define DARSTELL 38	/* STRING in Baum PULLDOWN */
#define MDEGREE  40	/* STRING in Baum PULLDOWN */
#define MRADIANT 41	/* STRING in Baum PULLDOWN */
#define MHSTAD   43	/* STRING in Baum PULLDOWN */
#define MHFUNC   44	/* STRING in Baum PULLDOWN */
#define MHSPECF  45	/* STRING in Baum PULLDOWN */
#define MHROTATE 46	/* STRING in Baum PULLDOWN */
#define MHVIEW   47	/* STRING in Baum PULLDOWN */
#define MHRESOL  48	/* STRING in Baum PULLDOWN */
#define MHDRAW   49	/* STRING in Baum PULLDOWN */

#define INFOFORM 1	/* Formula/Dialog */
#define MYNAME   2	/* BOXTEXT in Baum INFOFORM */
#define QINFO    3	/* BOXTEXT in Baum INFOFORM */

#define INPUTFUN 2	/* Formula/Dialog */
#define QINPUTF  1	/* BUTTON in Baum INPUTFUN */
#define FUNC1    4	/* FTEXT in Baum INPUTFUN */
#define FUNC2    5	/* FTEXT in Baum INPUTFUN */
#define XSTART   8	/* FTEXT in Baum INPUTFUN */
#define XEND     9	/* FTEXT in Baum INPUTFUN */
#define YSTART   11	/* FTEXT in Baum INPUTFUN */
#define CONSTA   13	/* FTEXT in Baum INPUTFUN */
#define CONSTB   14	/* FTEXT in Baum INPUTFUN */
#define CONSTC   15	/* FTEXT in Baum INPUTFUN */

#define DRAWFUN  3	/* Formula/Dialog */
#define COUNTBOX 4	/* BOX in Baum DRAWFUN */
#define COUNT3D  5	/* BOX in Baum DRAWFUN */
#define COUNT2D  6	/* BOX in Baum DRAWFUN */
#define COUNTFL  7	/* BOX in Baum DRAWFUN */
#define COUNTSH  8	/* BOX in Baum DRAWFUN */

#define ROTATION 4	/* Formula/Dialog */
#define ZROTATE  2	/* FTEXT in Baum ROTATION */
#define XROTATE  3	/* FTEXT in Baum ROTATION */
#define QROTATE  5	/* BUTTON in Baum ROTATION */

#define VIEW     5	/* Formula/Dialog */
#define LOOKX    2	/* FTEXT in Baum VIEW */
#define LOOKY    3	/* FTEXT in Baum VIEW */
#define LOOKZ    4	/* FTEXT in Baum VIEW */
#define PLANEY   10	/* FTEXT in Baum VIEW */
#define QVIEW    15	/* BUTTON in Baum VIEW */

#define RESOLUTI 6	/* Formula/Dialog */
#define XWERTE   3	/* FTEXT in Baum RESOLUTI */
#define YWERTE   4	/* FTEXT in Baum RESOLUTI */
#define QRESOLU  6	/* BUTTON in Baum RESOLUTI */

#define HFUNCT   7	/* Formula/Dialog */
#define QHFUNC   23	/* BUTTON in Baum HFUNCT */

#define HROTATE  8	/* Formula/Dialog */
#define QHROTATE 1	/* BUTTON in Baum HROTATE */

#define SYSERROR 9	/* Formula/Dialog */
#define QSYSERR  5	/* BOXTEXT in Baum SYSERROR */

#define SAVEFUN  10	/* Formula/Dialog */

#define LIGHT    11	/* Formula/Dialog */
#define LIGHTX   4	/* FTEXT in Baum LIGHT */
#define LIGHTY   5	/* FTEXT in Baum LIGHT */
#define LIGHTZ   6	/* FTEXT in Baum LIGHT */
#define RAHMEIN  11	/* BOXTEXT in Baum LIGHT */
#define RAHMAUS  12	/* BOXTEXT in Baum LIGHT */

#define ICONS    12	/* Formula/Dialog */
#define DESKTOP  0	/* BOX in Baum ICONS */
#define ISAVE    1	/* ICON in Baum ICONS */
#define IINPUTF  2	/* ICON in Baum ICONS */
#define IDRAWF   3	/* ICON in Baum ICONS */
#define IROTATE  4	/* ICON in Baum ICONS */
#define ILIGHT   5	/* ICON in Baum ICONS */
#define IVIEW    6	/* ICON in Baum ICONS */
#define IRESOL   7	/* ICON in Baum ICONS */
#define ISTYLE   8	/* ICON in Baum ICONS */
#define MEMOSTAT 9	/* BOXTEXT in Baum ICONS */

#define GRAFMODE 13	/* Formula/Dialog */
#define RASTER   1	/* BOX in Baum GRAFMODE */
#define XRASTER  2	/* BUTTON in Baum GRAFMODE */
#define YRASTER  3	/* BUTTON in Baum GRAFMODE */
#define XYRASTER 4	/* BUTTON in Baum GRAFMODE */
#define NORMALPR 6	/* BUTTON in Baum GRAFMODE */
#define ZENTRAL  7	/* BUTTON in Baum GRAFMODE */
#define DRAHT    10	/* BUTTON in Baum GRAFMODE */
#define HIDDENDR 11	/* BUTTON in Baum GRAFMODE */
#define SUNSHINE 12	/* BUTTON in Baum GRAFMODE */

#define STARTINF 14	/* Formula/Dialog */

#define OUTPUT   15	/* Formula/Dialog */
#define OTIMG    3	/* BUTTON in Baum OUTPUT */
#define OTSTAD   4	/* BUTTON in Baum OUTPUT */
#define OTDEGAS  5	/* BUTTON in Baum OUTPUT */
#define OTDOODLE 6	/* BUTTON in Baum OUTPUT */
#define OTASCII  7	/* BUTTON in Baum OUTPUT */

#define HDRAW    16	/* Formula/Dialog */

#define HRESOL   17	/* Formula/Dialog */

#define HSPECF   18	/* Formula/Dialog */

#define HPROJEKT 19	/* Formula/Dialog */

#define HSTAD    20	/* Formula/Dialog */

