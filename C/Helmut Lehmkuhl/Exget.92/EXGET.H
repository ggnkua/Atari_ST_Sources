
void exget(char **wort, int laenge, int dfstr, int schalter);
