#define BACKUP 1  	/* TREE */
#define SRC 3  	/* OBJECT in TREE #1 */
#define DEST 4  	/* OBJECT in TREE #1 */
#define FILE 6  	/* OBJECT in TREE #1 */
#define DATE 7  	/* OBJECT in TREE #1 */
#define ALL 8  	/* OBJECT in TREE #1 */
#define VERNO 9  	/* OBJECT in TREE #1 */
#define VERYES 10  	/* OBJECT in TREE #1 */
#define CANCEL 1  	/* OBJECT in TREE #1 */
#define START 2  	/* OBJECT in TREE #1 */
#define STRT 0  	/* TREE */
#define OPERDATE 2  	/* TREE */
#define OPDATE 1  	/* OBJECT in TREE #2 */
#define OPTIME 3  	/* OBJECT in TREE #2 */
#define DOBAK 7  	/* OBJECT in TREE #2 */
#define DOCANCEL 8  	/* OBJECT in TREE #2 */
#define STRTCONT 7  	/* OBJECT in TREE #0 */
#define STRTCANC 6  	/* OBJECT in TREE #0 */
