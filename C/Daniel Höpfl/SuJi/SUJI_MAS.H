#ifndef __DH_SUJI_MAS_H_
#define __DH_SUJI_MAS_H_

int master_event(unsigned int end_if_timer);

#endif