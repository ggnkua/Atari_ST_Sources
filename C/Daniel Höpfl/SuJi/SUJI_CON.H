#ifndef __DH_SUJI_CON_H_
#define __DH_SUJI_CON_H_

void load_config (void);
void save_config (void);
void set_show (void);
void get_show (void);

#endif