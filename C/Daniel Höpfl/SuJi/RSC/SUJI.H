 /*  Resource C-Header-File v1.97 f�r ResourceMaster ab v2.06 by ARDISOFT  */

#define MASKE_DIALOG 0  /* form/dial */
#define MASKE_TITEL 1  /* STRING in tree MASKE_DIALOG */
#define MASKE_LABEL 2  /* TEXT in tree MASKE_DIALOG */
#define MASKE_EDIT 3  /* FTEXT in tree MASKE_DIALOG */
#define INHALT_LABEL 4  /* TEXT in tree MASKE_DIALOG */
#define INHALT_EDIT 5  /* FTEXT in tree MASKE_DIALOG */
#define MASKE_BIGGER 6  /* BUTTON in tree MASKE_DIALOG */
#define MB_EDIT 7  /* FTEXT in tree MASKE_DIALOG */
#define MB_BYTES 8  /* STRING in tree MASKE_DIALOG */
#define MASKE_SMALLER 9  /* BUTTON in tree MASKE_DIALOG */
#define MS_EDIT 10  /* FTEXT in tree MASKE_DIALOG */
#define MS_BYTES 11  /* STRING in tree MASKE_DIALOG */
#define MASKE_JUNGER 12  /* BUTTON in tree MASKE_DIALOG */
#define MJ_EDIT 13  /* FTEXT in tree MASKE_DIALOG */
#define MASKE_OLDER 14  /* BUTTON in tree MASKE_DIALOG */
#define MO_EDIT 15  /* FTEXT in tree MASKE_DIALOG */
#define MASKE_BS 17  /* BUTTON in tree MASKE_DIALOG */
#define INHALT_BS 18  /* BUTTON in tree MASKE_DIALOG */
#define CLOSE_LIST 19  /* IMAGE in tree MASKE_DIALOG */
#define OPEN_LIST 20  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_ABB 21  /* BUTTON in tree MASKE_DIALOG */
#define MASKE_OK 22  /* BUTTON in tree MASKE_DIALOG */
#define LIST_ROOM 23  /* IBOX in tree MASKE_DIALOG */
#define ENTRIES_BACK 24  /* IBOX in tree MASKE_DIALOG */
#define ENTRY_1 25  /* TEXT in tree MASKE_DIALOG */
#define ENTRY_2 26  /* TEXT in tree MASKE_DIALOG */
#define ENTRY_3 27  /* TEXT in tree MASKE_DIALOG */
#define ENTRY_4 28  /* TEXT in tree MASKE_DIALOG */
#define VSL_BACK 29  /* BOX in tree MASKE_DIALOG */
#define VSL_SLIDER 30  /* BOX in tree MASKE_DIALOG */
#define VSL_DOWN 31  /* BOXCHAR in tree MASKE_DIALOG */
#define VSL_UP 32  /* BOXCHAR in tree MASKE_DIALOG */
#define HSL_BACK 33  /* BOX in tree MASKE_DIALOG */
#define HSL_SLIDER 34  /* BOX in tree MASKE_DIALOG */
#define HSL_LEFT 35  /* BOXCHAR in tree MASKE_DIALOG */
#define HSL_RIGHT 36  /* BOXCHAR in tree MASKE_DIALOG */
#define LIST_KILL 37  /* BUTTON in tree MASKE_DIALOG */
#define LIST_ADD 38  /* BUTTON in tree MASKE_DIALOG */
#define SLBOX_ECKE 39  /* BOXCHAR in tree MASKE_DIALOG */
#define LIST_CHANGE 40  /* BUTTON in tree MASKE_DIALOG */
#define MASKE_INFO1 41  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_INFO2 42  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_INFO3 43  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_INFO4 44  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_INFO_FARBE 45  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_INFO_SW 46  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_HELP1 47  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_HELP2 48  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_HELP3 49  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_HELP4 50  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_HELP_FARBE 51  /* IMAGE in tree MASKE_DIALOG */
#define MASKE_HELP_SW 52  /* IMAGE in tree MASKE_DIALOG */

#define MASKE_ICONIFY 1  /* form/dial */
#define SU_ICON 1  /* IBOX in tree MASKE_ICONIFY */
#define SU_ICON1 2  /* ICON in tree MASKE_ICONIFY */
#define SU_ICON2 3  /* IMAGE in tree MASKE_ICONIFY */
#define SU_ICON3 4  /* ICON in tree MASKE_ICONIFY */
#define ICON_ZAHL 5  /* TEXT in tree MASKE_ICONIFY */

#define BUBBLE_HILFEN 2  /* form/dial */
#define HD_EDIT 1  /* STRING in tree BUBBLE_HILFEN */
#define HD_ABB 2  /* STRING in tree BUBBLE_HILFEN */
#define HD_OK 3  /* STRING in tree BUBBLE_HILFEN */
#define HD_BIGGER 4  /* STRING in tree BUBBLE_HILFEN */
#define HD_SMALLER 5  /* STRING in tree BUBBLE_HILFEN */
#define HD_JUNGER 6  /* STRING in tree BUBBLE_HILFEN */
#define HD_OLDER 7  /* STRING in tree BUBBLE_HILFEN */
#define HD_BIG_IS_SMALLM 8  /* STRING in tree BUBBLE_HILFEN */
#define HF_SORT 9  /* STRING in tree BUBBLE_HILFEN */
#define HD_BIG_IS_SMALLI 10  /* STRING in tree BUBBLE_HILFEN */
#define HD_INHALT 11  /* STRING in tree BUBBLE_HILFEN */
#define HD_HELP_BUTTON 12  /* STRING in tree BUBBLE_HILFEN */
#define HD_OPEN_LIST 13  /* STRING in tree BUBBLE_HILFEN */
#define HD_CLOSE_LIST 14  /* STRING in tree BUBBLE_HILFEN */
#define HD_LIST_ADD 15  /* STRING in tree BUBBLE_HILFEN */
#define HD_LIST_KILL 16  /* STRING in tree BUBBLE_HILFEN */
#define HD_LIST 17  /* STRING in tree BUBBLE_HILFEN */
#define HD_LIST_CHANGE 18  /* STRING in tree BUBBLE_HILFEN */

#define ASK_INHALT 3  /* form/dial */
#define AI_REMEMBER 2  /* BUTTON in tree ASK_INHALT */
#define AI_NO 3  /* BUTTON in tree ASK_INHALT */
#define AI_YES 4  /* BUTTON in tree ASK_INHALT */
#define AI_DATEINAME 5  /* STRING in tree ASK_INHALT */
#define AI_MEM 8  /* STRING in tree ASK_INHALT */
#define AI_READ 9  /* STRING in tree ASK_INHALT */

#define MAUSZEIGER 4  /* form/dial */
#define MAUS_OBJ 1  /* ICON in tree MAUSZEIGER */

#define INFO_DIALOG 5  /* form/dial */
#define INFO_VERSION 2  /* FTEXT in tree INFO_DIALOG */
#define INFO_OK 3  /* BUTTON in tree INFO_DIALOG */

#define LANGUAGE_SETTING 6  /* form/dial */
#define LS_DEZ_KOMMA 1  /* BUTTON in tree LANGUAGE_SETTING */
#define LS_DAY_MONTH 2  /* BUTTON in tree LANGUAGE_SETTING */
#define LS_DM_TRENNER 4  /* FTEXT in tree LANGUAGE_SETTING */

#define OPTION 7  /* form/dial */
#define OPTION_ABORT 6  /* BUTTON in tree OPTION */
#define OPTION_OK 7  /* BUTTON in tree OPTION */
#define SHOW_SIZE 1  /* BUTTON in tree OPTION */
#define SHOW_TIME 2  /* BUTTON in tree OPTION */
#define SHOW_DATE 3  /* BUTTON in tree OPTION */
#define SHOW_FLAGS 4  /* BUTTON in tree OPTION */
#define SHOW_ORIGIN 5  /* BUTTON in tree OPTION */
#define CLIPBORAD_NAME 10  /* BUTTON in tree OPTION */
#define CLIPBORAD_SIZE 11  /* BUTTON in tree OPTION */
#define CLIPBORAD_TIME 12  /* BUTTON in tree OPTION */
#define CLIPBORAD_DATE 13  /* BUTTON in tree OPTION */
#define CLIPBORAD_FLAGS 14  /* BUTTON in tree OPTION */
#define CLIPBORAD_ORIGIN 15  /* BUTTON in tree OPTION */
#define CLIPBORAD_ORIGIN_NAME 16  /* BUTTON in tree OPTION */

#define ERR_NO_MEM 0  /* Alert string */

#define ERR_NO_MEM2 1  /* Alert string */

#define ERR_NO_WORKST 2  /* Alert string */

#define ERR_NO_MASK 3  /* Alert string */

#define ERR_FORM_SIZE 4  /* Alert string */

#define ERR_TOO_BIG 5  /* Alert string */

#define ERR_NO_WINDOW 6  /* Alert string */

#define ASK_ONLY_ZERO 7  /* Alert string */

#define ERR_MASK_ROOM 8  /* Alert string */

#define ERR_MASK_QUOTE 9  /* Alert string */

#define ERR_MASK_KOMMA 10  /* Alert string */

#define ERR_WRONG_FONT 11  /* Alert string */

#define ERR_HAS_NO_WO 12  /* Alert string */

#define ERR_OPEN_WIND 13  /* Alert string */

#define ERR_HAS_NO_SP 14  /* Alert string */

#define ERR_AV_PS_VI 15  /* Alert string */

#define ERR_HAS_NO_QUOTE 16  /* Alert string */

#define ERR_NO_SCRAP 17  /* Alert string */

#define ERR_WRITE_SCRAP 18  /* Alert string */

#define ERR_NO_ST_GUIDE 19  /* Alert string */

#define ERR_MIN_ONE 20  /* Alert string */

#define ERR_FSEL_BOX 21  /* Alert string */

#define ERR_DEL_FILE 22  /* Alert string */

#define ASK_MEM_DEL_FILE 23  /* Alert string */

#define DIALOG_TITEL 24  /*  */

#define NAME_AV 25  /*  */

#define WINDOW_NAME 26  /*  */

#define WINDOW_NAME_W 27  /*  */

#define WINDOW_NAME_STOP 28  /*  */

#define TIT_FILE 29  /*  */

#define TIT_PATH 30  /*  */

#define TIT_SIZE 31  /*  */

#define TIT_TIME 32  /*  */

#define TIT_DATE 33  /*  */

#define TIT_ATTR 34  /*  */

#define WINDOW_INFO 35  /*  */

#define ADD_PATH_TITEL 36  /*  */

#define CHA_PATH_TITEL 37  /*  */
