#ifndef __DH_SUJI_DD_H_
#define __DH_SUJI_DD_H_

char *dragdrop(int *msg);

#endif
