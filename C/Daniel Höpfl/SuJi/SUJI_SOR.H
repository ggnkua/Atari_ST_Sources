#ifndef __DH_SUJI_SOR_H_
#define __DH_SUJI_SOR_H_

extern int sort_by;

void sortiere_neu(int by);
int my_strcmp(char *a,char *b);

extern char ___upper_char_string___[];

#define uprchar(c)	___upper_char_string___[c]

#endif