#ifndef __DH_SUJI_INH_H_
#define __DH_SUJI_INH_H_

extern int thread_id_inhalt;
extern int thread_ret;

int test_inhalt(char *maske,char *pfad,DTA *dta,int big_is_small);

#endif