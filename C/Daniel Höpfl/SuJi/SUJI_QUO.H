#ifndef __DH_SUJI_QUO_H_
#define __DH_SUJI_QUO_H_

int test_quote(FILE_INFO *par,int *qp,int *qn);
char *make_quote(FILE_INFO *par,int getrennt);
char *dequote(char *to_dequote);

#endif
