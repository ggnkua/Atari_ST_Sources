* Atari ST 512-color demo VBLANK & HBLANK *
*             by Tom Hudson               *
*    Copyright 1985 ANALOG Computing      *

.globl _go
.globl _stop
.globl _ctable
.globl _setcolor
.globl _bconstat
.globl _bconin
.globl _setpallete

vbvec: .equ $70		;VBLANK vector
hbvec: .equ $120	;HBLANK vector
keyvec: .equ $118	;keyboard vector (?)
color0: .equ $ff8240	;color register #0
color1: .equ $ff8242	;color register #1
color9: .equ $ff8252	;color register #9

.text

* Call SETUP in supervisor mode *

_go:
move.l #setup,-(sp)	;put addr on stack
move.w #38,-(sp)	;SUPER mode command
trap #14		;execute SETUP!
addq.l #6,sp		;restore stack pointer
rts			;and exit!

* Start the VBLANK & HBLANK *

setup:
move.w #$f888,color0	;background black



* Save misc. registers *

move.b $fffa09,hold1	;save...
move.b $fffa07,hold2	;altered...
move.b $fffa13,hold3	;registers
move.l hbvec,hold4	;save...
move.l keyvec,keysave	;altered...
move.l vbvec,vbsave	;vectors

* Now alter the registers! *


move.l #mykey,keyvec	;alter kbd vector
andi.b #$df,$fffa09	;mask off keyclick
andi.b #$fe,$fffa07	;mask off (?)
move.l #hblank,hbvec	;alter HBLANK vector
ori.b #$01,$fffa07	;mask on (?)
ori.b #$01,$fffa13	;mask on (?)
move.l #vblank,vbvec	;change VBLANK vector
rts			;and exit!

* Call RESTORE in supervisor mode *

_stop:
move.l #restore,-(sp)	;put addr on stack
move.w #38,-(sp)	;SUPER mode command
trap #14		;execute RESTORE!
addq.l #6,sp		;restore stack
rts			;and exit!

* Restore old HBLANK, VBLANK *

restore:
move.b hold1,$fffa09	;restore...
move.b hold2,$fffa07	;all the...
move.b hold3,$fffa13	;altered...
move.l hold4,hbvec	;registers and...
move.l keysave,keyvec	;vectors to...
move.l vbsave,vbvec	;previous values

rts			;and exit!

* Keyboard interrupt *

mykey:
move #$2500,sr		;set interrupt mask to 5,
.dc.w $4ef9		;'JMP'...
keysave: .ds.l 1	;to old vector

* My HBLANK code *

hblank:
movem.l d0-d0/a0-a0,-(sp)	;save registers
move.w cix,d0			;get color index

move.l #_ctable,a0		;get table addr.
move.l 0(a0,d0.w),color1	;move 8 words...
move.l 4(a0,d0.w),color1+4	;from table...
move.l 8(a0,d0.w),color1+8	;to system...
move.l 12(a0,d0.w),color1+12	;color registers
addi.w #16,cix			;point to next group

movem.l (sp)+,d0-d0/a0-a0	;restore registers
bclr #0,$fffa0f			;clear interrupt(?)
rte				;and return!

* My VBLANK code *

vblank:
move.b #0,$fffa1b		;???
verify:
move.b #3,$fffa21		;set HBLANK for...
cmpi.b #3,$fffa21		;every 3 scan lines!

bne verify
move.b #8,$fffa1b		;???
move.l _ctable,color1		;place the initial...
move.l _ctable+4,color1+4	;color palette...
move.l _ctable+8,color1+8	;for first color...
move.l _ctable+12,color1+12	;group!
move.w #16,cix			;reset index counter

addq.w #1,color9		;cycle color 9
.dc.w $4ef9			;"JMP"...
vbsave: .ds.l 1			;to old VBLANK!

* Miscellaneous OS calls *

_setcolor:
link a6,#-6		;create stack frame
move.w 10(a6),(sp)	;push parameters...
move.w 8(a6),-(sp)	;onto stack
move.w #7,-(sp)		;setcolor command
trap #14		;set it!
unlk a6			;undo stack frame
rts			;all done!

_bconstat:
link a6,#-4		;create stack frame
move.w 8(a6),(sp)	;device # on stack,
move.w #01,-(sp)	;status command
trap #13		;call os!
unlk a6			;undo stack frame

rts			;exit!

_bconin:
link a6,#-4		;create stack frame
move.w 8(a6),(sp)	;device # on stack,
move.w #2,-(sp)		;input command
trap #13		;call os!
unlk a6			;undo stack frame
rts			;and exit!

_setpallete:
link a6,#-6		;create stack frame

move.l 8(a6),(sp)	;palette addr on stack
move.w #6,-(sp)		;command on stack
trap #14		;call os!
unlk a6			;undo stack frame
rts			;and exit!

.data

cix: .ds.w 1		;color table index
_ctable: .ds.w 512	;512-entry color table
hold1: .ds.w 1		;hold...

hold2: .ds.w 1		;areas...
hold3: .ds.w 1		;for registers...
hold4: .ds.l 1		;and HBLANK vector
