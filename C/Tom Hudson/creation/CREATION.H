#define MENUBAR 0  	/* TREE */
#define ABOUTIT 9  	/* OBJECT in TREE #0 */
#define QUIT 24  	/* OBJECT in TREE #0 */
#define SAVETOP 20  	/* OBJECT in TREE #0 */
#define SAVEPSPC 21  	/* OBJECT in TREE #0 */
#define SAVE3D 22  	/* OBJECT in TREE #0 */
#define TOP 29  	/* OBJECT in TREE #0 */
#define PERSPEC 30  	/* OBJECT in TREE #0 */
#define PROGRESS 1  	/* TREE */
#define PHASE1 1  	/* OBJECT in TREE #1 */
#define FINAL 9  	/* OBJECT in TREE #1 */
#define PHASE8 8  	/* OBJECT in TREE #1 */
#define PHASE7 7  	/* OBJECT in TREE #1 */
#define PHASE6 6  	/* OBJECT in TREE #1 */
#define PHASE5 5  	/* OBJECT in TREE #1 */
#define PHASE4 4  	/* OBJECT in TREE #1 */
#define PHASE3 3  	/* OBJECT in TREE #1 */
#define PHASE2 2  	/* OBJECT in TREE #1 */
#define LOADDATA 18  	/* OBJECT in TREE #0 */
#define FRACTAL 26  	/* OBJECT in TREE #0 */
#define USEDATA 27  	/* OBJECT in TREE #0 */
#define MAPPART 2  	/* TREE */
#define FULL 2  	/* OBJECT in TREE #2 */
#define PART 3  	/* OBJECT in TREE #2 */
#define PARTBOX 1  	/* OBJECT in TREE #2 */
#define REALPROG 3  	/* TREE */
#define SAMPLING 1  	/* OBJECT in TREE #3 */
#define REALFINL 2  	/* OBJECT in TREE #3 */
