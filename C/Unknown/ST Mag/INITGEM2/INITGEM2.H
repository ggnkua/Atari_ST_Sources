/* Indice du ressource pour EXEMPLE */

#define MENU     0   /* Arbre menu */
#define INFOS    7   /* STRING dans l'arbre MENU */
#define FORM     16  /* STRING dans l'arbre MENU */
#define QUITTER  17  /* STRING dans l'arbre MENU */

#define FORMULAIRE 1   /* Formulaire/Dialogue */
#define RB1      2   /* BUTTON dans l'arbre FORMULAIRE */
#define RB2      3   /* BUTTON dans l'arbre FORMULAIRE */
#define RB3      4   /* BUTTON dans l'arbre FORMULAIRE */
#define EDIT     5   /* FTEXT dans l'arbre FORMULAIRE */
#define SELE     6   /* BUTTON dans l'arbre FORMULAIRE */
#define OK       7   /* BUTTON dans l'arbre FORMULAIRE */
#define ANNULE   8   /* BUTTON dans l'arbre FORMULAIRE */
