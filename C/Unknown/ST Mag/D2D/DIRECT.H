void direct2disk(void);