extern int errno;   /* defined in EXIT.C */