/*
  Resourcedatei
*/

int rsc_datei[] = {
1,380,156,380,156,156,36,156,156,836,19,1,8,0,0,0,
0,840,17509,30313,25445,8269,24942,24935,25970,8232,25385,12601,14640,8290,31008,19809,
29302,26990,8257,18176,21071,19757,17784,28769,28260,25970,32,8274,20301,13344,8192,8224,
21071,19761,8224,32,8274,20301,12832,8192,8224,21071,19763,8224,49,0,50,0,
51,0,3,52,0,49,0,50,0,51,0,52,0,85,0,121,
0,123,0,124,5,6,2,4352,0,1,2,1,0,125,0,127,
0,128,5,6,2,4352,0,1,2,1,0,129,0,131,0,132,
5,6,2,4352,0,1,2,1,0,135,0,137,0,138,5,6,
2,4352,0,1,2,1,0,139,0,141,0,142,5,6,0,4480,
0,-1,2,1,0,143,0,145,0,146,5,6,0,4480,0,-1,
2,1,0,147,0,149,0,150,5,6,0,4480,0,-1,2,1,
0,151,0,153,0,154,5,6,0,4480,0,-1,2,1,-1,1,
18,20,0,16,2,4352,0,0,39,2059,2,-1,-1,28,0,0,
0,36,1537,2560,35,1,3,-1,-1,20,0,0,255,4465,514,1026,
1825,256,4,-1,-1,28,0,0,0,72,2,3,12,1,5,-1,
-1,26,65,0,0,85,27,9,9,1,6,-1,-1,26,65,0,
0,94,27,3,9,1,7,-1,-1,26,65,0,0,103,27,5,
9,1,8,-1,-1,26,65,0,0,112,27,7,9,1,15,9,
14,25,0,0,0,4352,3,4,21,7,13,10,12,20,0,16,
255,4353,4,1,13,1029,11,-1,-1,22,65,0,0,156,9,3072,
1,3075,12,-1,-1,22,65,0,0,184,517,3072,1,3075,9,-1,
-1,22,65,0,0,212,1025,3072,1,3075,14,-1,-1,26,1,0,
0,133,785,2561,1,4,8,-1,-1,22,65,0,0,240,1538,3073,
1,3075,16,-1,-1,21,65,0,0,268,26,3,1536,1,17,-1,
-1,21,65,0,0,296,26,5,1536,1,18,-1,-1,21,65,0,
0,324,26,7,1536,1,0,-1,-1,21,97,0,0,352,26,9,
1536,1,0,380
};

