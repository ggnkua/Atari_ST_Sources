
#define	PatchLevel "0"

/*
 *
 *	The Patch Level above is to identify the version
 *	of the all the files in this directory. Given the above
 *	number I can pull up the correct version of any individual
 *	file in this directory. In all communications I will appreciate
 *	very much if you can quote this number.
 *
 *	$Author: bjsjr $
 */
