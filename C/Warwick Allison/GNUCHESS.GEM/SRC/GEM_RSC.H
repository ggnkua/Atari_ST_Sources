/* resource set indices for GEM_RSC */

#define MENUBAR                            0 /* menu */
#define FIRSTMENUTITLE                     4 /* TITLE in tree MENUBAR */
#define EDITMENUTITLE                      5 /* TITLE in tree MENUBAR */
#define LASTMENUTITLE                      6 /* TITLE in tree MENUBAR */
#define DOABOUT                            9 /* STRING in tree MENUBAR */
#define DONEW                             18 /* STRING in tree MENUBAR */
#define DOLOAD                            20 /* STRING in tree MENUBAR */
#define DOSAVE                            21 /* STRING in tree MENUBAR */
#define DOLIST                            23 /* STRING in tree MENUBAR */
#define DOQUIT                            25 /* STRING in tree MENUBAR */
#define EDITTOGGLE                        27 /* STRING in tree MENUBAR */
#define EDITWHITE                         29 /* STRING in tree MENUBAR */
#define EDITBLACK                         30 /* STRING in tree MENUBAR */
#define EDITKING                          32 /* STRING in tree MENUBAR */
#define EDITQUEEN                         33 /* STRING in tree MENUBAR */
#define EDITROOK                          34 /* STRING in tree MENUBAR */
#define EDITBISHOP                        35 /* STRING in tree MENUBAR */
#define EDITKNIGHT                        36 /* STRING in tree MENUBAR */
#define EDITPAWN                          37 /* STRING in tree MENUBAR */
#define EDITNONE                          38 /* STRING in tree MENUBAR */
#define EDITCLEAR                         40 /* STRING in tree MENUBAR */
#define HUMANVSCPU                        42 /* STRING in tree MENUBAR */
#define CPUVSHUMAN                        43 /* STRING in tree MENUBAR */
#define CPUVSCPU                          44 /* STRING in tree MENUBAR */
#define DOREVERSE                         45 /* STRING in tree MENUBAR */
#define DOLEVEL                           47 /* STRING in tree MENUBAR */
#define BACK2MOVES                        49 /* STRING in tree MENUBAR */
#define BACK1MOVE                         50 /* STRING in tree MENUBAR */
#define DOHINT                            51 /* STRING in tree MENUBAR */
#define DOCOLOUR                          53 /* STRING in tree MENUBAR */
#define DOSIZE                            54 /* STRING in tree MENUBAR */
#define DISABLEBOOK                       56 /* STRING in tree MENUBAR */
#define DORANDOM                          57 /* STRING in tree MENUBAR */
#define DOSAVECONFIG                      59 /* STRING in tree MENUBAR */

#define BOARD                              1 /* form/dialog */
#define BOARDSURROUND                      0 /* BOX in tree BOARD */
#define BOARDBORDER                        1 /* IBOX in tree BOARD */
#define C1                                 2 /* IBOX in tree BOARD */
#define R1C1                               3 /* BOX in tree BOARD */
#define R2C1                               5 /* BOX in tree BOARD */
#define C2                                19 /* IBOX in tree BOARD */
#define R1C2                              20 /* BOX in tree BOARD */

#define PIECES_MID                         2 /* form/dialog */
#define KING                               2 /* ICON in tree PIECES_MID */
#define QUEEN                              3 /* ICON in tree PIECES_MID */
#define ROOK                               4 /* ICON in tree PIECES_MID */
#define BISHOP                             5 /* ICON in tree PIECES_MID */
#define KNIGHT                             6 /* ICON in tree PIECES_MID */
#define PAWN                               7 /* ICON in tree PIECES_MID */

#define COLOUR                             3 /* form/dialog */
#define WHITEPIECE                         2 /* ICON in tree COLOUR */
#define BLACKPIECE                         3 /* ICON in tree COLOUR */
#define WHITESQUARE                        4 /* BOX in tree COLOUR */
#define BLACKSQUARE                        6 /* BOX in tree COLOUR */
#define WHITEDATACOLOUR                    8 /* IBOX in tree COLOUR */
#define WHITEMASKCOLOUR                   12 /* IBOX in tree COLOUR */
#define BLACKDATACOLOUR                   18 /* IBOX in tree COLOUR */
#define BLACKMASKCOLOUR                   22 /* IBOX in tree COLOUR */
#define WHITESQUARECOLOUR                 28 /* IBOX in tree COLOUR */
#define WHITESQUAREPATTERN                32 /* IBOX in tree COLOUR */
#define BLACKSQUARECOLOUR                 38 /* IBOX in tree COLOUR */
#define BLACKSQUAREPATTERN                42 /* IBOX in tree COLOUR */
#define CURSORBORDER                      48 /* BOX in tree COLOUR */
#define CURSORCOLOUR                      49 /* IBOX in tree COLOUR */
#define CURSORBORDERMINUS                 53 /* BOXCHAR in tree COLOUR */
#define CURSORBORDERPLUS                  54 /* BOXCHAR in tree COLOUR */
#define HIGHLIGHTBORDER                   57 /* BOX in tree COLOUR */
#define HIGHLIGHTCOLOUR                   58 /* IBOX in tree COLOUR */
#define HIGHLIGHTBORDERMINUS              62 /* BOXCHAR in tree COLOUR */
#define HIGHLIGHTBORDERPLUS               63 /* BOXCHAR in tree COLOUR */
#define SURROUNDPATTERN                   66 /* BOX in tree COLOUR */
#define BOARDBORDERBORDER                 67 /* BOX in tree COLOUR */
#define SURROUNDCOLOUR                    68 /* IBOX in tree COLOUR */
#define BOARDSURROUNDPATTERN              73 /* IBOX in tree COLOUR */
#define BOARDBORDERCOLOUR                 79 /* IBOX in tree COLOUR */
#define BOARDBORDERMINUS                  84 /* BOXCHAR in tree COLOUR */
#define BOARDBORDERPLUS                   85 /* BOXCHAR in tree COLOUR */

#define LEVEL                              4 /* form/dialog */
#define LEVEL1                             1 /* BOXTEXT in tree LEVEL */
#define LEVEL10                           10 /* BOXTEXT in tree LEVEL */

#define ABOUT                              5 /* form/dialog */
#define GUIVERSION                         7 /* FTEXT in tree ABOUT */
#define CHESSVERSION                      13 /* FTEXT in tree ABOUT */
#define CHESSPATCHLEVEL                   14 /* FTEXT in tree ABOUT */

#define BOARDICON                          6 /* form/dialog */

#define CHOICELIST                         7 /* form/dialog */
#define CHOICESCROLLBAR                    1 /* IBOX in tree CHOICELIST */
#define CHOICE1                            6 /* BOXTEXT in tree CHOICELIST */
#define CHOICEN                           21 /* BOXTEXT in tree CHOICELIST */

#define PIECES_SML                         8 /* form/dialog */

#define PIECES_LRG                         9 /* form/dialog */

#define SIZE                              10 /* form/dialog */
#define SQUARE_SML                         1 /* BOX in tree SIZE */
#define SQUARE_MID                         3 /* BOX in tree SIZE */
#define SQUARE_LRG                         5 /* BOX in tree SIZE */

#define BOOKWARN                           0 /* Alert string */

#define MATE                               1 /* Alert string */

#define ILLEGAL                            2 /* Alert string */

#define MESSAGE_F                          3 /* Alert string */

#define NOCONFIG                           4 /* Alert string */

#define COLOURWINTITLE                     5 /* Free string */

#define BOARDWINTITLE                      6 /* Free string */

#define LOADFAILED                         7 /* Alert string */

#define SAVEFAILED                         8 /* Alert string */

