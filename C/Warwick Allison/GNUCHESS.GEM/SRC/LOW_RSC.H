/* resource set indices for LOW_RSC */

#define TREE001                            0 /* menu */

#define TREE002                            1 /* form/dialog */

#define TREE003                            2 /* form/dialog */

#define TREE004                            3 /* form/dialog */

#define TREE005                            4 /* form/dialog */

#define TREE006                            5 /* form/dialog */

#define TREE007                            6 /* unknown form */

#define TREE008                            7 /* form/dialog */

#define TREE009                            8 /* form/dialog */

#define TREE010                            9 /* form/dialog */

#define TREE011                           10 /* form/dialog */

#define STR001                             0 /* Alert string */

#define STR002                             1 /* Alert string */

#define STR003                             2 /* Alert string */

#define STR004                             3 /* Alert string */

#define STR005                             4 /* Alert string */

#define STR006                             5 /* Free string */

#define STR007                             6 /* Free string */

#define STR008                             7 /* Alert string */

#define STR009                             8 /* Alert string */

