//////////////////////////////////////////////////////////////////////////////
//
//  This file is part of the Atari Machine Specific Library,
//  and is Copyright 1992 by Warwick W. Allison.
//
//  You are free to copy and modify these sources, provided you acknowledge
//  the origin by retaining this notice, and adhere to the conditions
//  described in the file COPYING.
//
//////////////////////////////////////////////////////////////////////////////

#ifndef _AMSVersion_h
#define _AMSVersion_h

const char* AMSCopyright = "Atari Machine Specific library, Copyright 1993 by Warwick W. Allison";
const char* AMSVersion = "0.9";

#endif
