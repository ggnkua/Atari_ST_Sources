#ifndef Cookie_h
#define Cookie_h

int GetCookieByNumber(int i);
int GetCookie(int i);
int GetCookieNamed(char name[4]);

#endif
