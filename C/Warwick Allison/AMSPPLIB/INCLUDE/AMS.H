// All AMS headers.

#include <amsversi.h>
#include <easyspri.h>
#include <joystick.h>
#include <oscillat.h>
#include <blockmap.h>
#include <fastcoun.h>
#include <mobilesp.h>
#include <terminat.h>
#include <doublebu.h>
#include <mousepos.h>
#include <scancode.h>
#include <timer.h>
#include <smallgra.h>
#include <fnameext.h>
#include <sound.h>
#include <soundenv.h>
