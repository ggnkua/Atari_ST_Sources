/* resource set indices for EXAMPLE */

#define MENU               0 /* menu */
#define DOABOUT            8 /* STRING in tree MENU */
#define DOFREE            17 /* STRING in tree MENU */
#define DOAUTHORS         18 /* STRING in tree MENU */
#define DOGNU             19 /* STRING in tree MENU */
#define DOQUIT            21 /* STRING in tree MENU */
#define DOVARIOUS         23 /* STRING in tree MENU */
#define DOFLYING          24 /* STRING in tree MENU */
#define DOBIGFORM         25 /* STRING in tree MENU */
#define DOSHARING         26 /* STRING in tree MENU */
#define DOFONTS           27 /* STRING in tree MENU */
#define DOCANVAS          28 /* STRING in tree MENU */
#define DOTEXTWIN         29 /* STRING in tree MENU */
#define DOCLOCK           30 /* STRING in tree MENU */

#define SHARING            1 /* form/dialog */

#define ABOUT              2 /* form/dialog */

#define CLOCK              3 /* form/dialog */
#define TIME               1 /* FTEXT in tree CLOCK */
#define DATE               2 /* FTEXT in tree CLOCK */
#define GRABBER            3 /* IBOX in tree CLOCK */

#define FREE               4 /* form/dialog */

#define AUTHORS            5 /* form/dialog */

#define GNU                6 /* form/dialog */

#define TEXTWIN            7 /* form/dialog */
#define TXTBOX             1 /* BOXTEXT in tree TEXTWIN */
#define TXTCLEAR           2 /* BUTTON in tree TEXTWIN */
#define TXTWRAP            3 /* BUTTON in tree TEXTWIN */
#define TXTVISCURC         4 /* BUTTON in tree TEXTWIN */
#define TXTUP              6 /* BOXCHAR in tree TEXTWIN */
#define TXTLEFT            7 /* BOXCHAR in tree TEXTWIN */
#define TXTRIGHT           8 /* BOXCHAR in tree TEXTWIN */
#define TXTDOWN            9 /* BOXCHAR in tree TEXTWIN */
#define TXTHOME           10 /* BOXCHAR in tree TEXTWIN */

#define VARIOUS            8 /* form/dialog */
#define PIC                2 /* IMAGE in tree VARIOUS */
#define ELLIPSE            6 /* BOXCHAR in tree VARIOUS */
#define RBUT1              7 /* BOXTEXT in tree VARIOUS */
#define LINEY              9 /* BOXCHAR in tree VARIOUS */
#define RBUT2             10 /* BUTTON in tree VARIOUS */
#define PANRACK           14 /* BOX in tree VARIOUS */
#define PANKNOB           15 /* BOX in tree VARIOUS */
#define PANLEFT           16 /* ICON in tree VARIOUS */
#define PANUP             17 /* ICON in tree VARIOUS */
#define PANRIGHT          18 /* ICON in tree VARIOUS */
#define PANDOWN           19 /* ICON in tree VARIOUS */
#define VSLIDER           24 /* IBOX in tree VARIOUS */
#define UP                25 /* BOXCHAR in tree VARIOUS */
#define VRACK             26 /* BOX in tree VARIOUS */
#define VKNOB             27 /* BOX in tree VARIOUS */
#define DOWN              28 /* BOXCHAR in tree VARIOUS */
#define HSLIDER           47 /* IBOX in tree VARIOUS */
#define LEFT              48 /* BOXCHAR in tree VARIOUS */
#define HRACK             49 /* BOX in tree VARIOUS */
#define HKNOB             50 /* BOX in tree VARIOUS */
#define RIGHT             51 /* BOXCHAR in tree VARIOUS */
#define SEL               61 /* BUTTON in tree VARIOUS */
#define SELEX             62 /* BUTTON in tree VARIOUS */
#define TE                66 /* BUTTON in tree VARIOUS */
#define TEEX              67 /* BUTTON in tree VARIOUS */
#define SELTE             68 /* BUTTON in tree VARIOUS */
#define SELEXDEF          69 /* BUTTON in tree VARIOUS */

#define POPUP              9 /* form/dialog */
#define GMT                1 /* BOXTEXT in tree POPUP */
#define QCLOCK             2 /* STRING in tree POPUP */
#define QPROG              4 /* STRING in tree POPUP */
#define DOGMJOKE           5 /* ICON in tree POPUP */

#define DESKTOP           10 /* form/dialog */
#define DESKPLANE          0 /* BOX in tree DESKTOP */
#define FILES              1 /* ICON in tree DESKTOP */
#define FILEDISPLAY        2 /* FBOXTEXT in tree DESKTOP */

#define BIGFORM           11 /* form/dialog */
#define PART0              4 /* BOXTEXT in tree BIGFORM */
#define PARTN             22 /* BOXTEXT in tree BIGFORM */
#define INACTIVE          24 /* BOX in tree BIGFORM */
#define ACTIVE            25 /* BOX in tree BIGFORM */
#define BORDERRACK        28 /* BOX in tree BIGFORM */
#define BORDERKNOB        29 /* BOXTEXT in tree BIGFORM */
#define TEXTRACK          31 /* BOX in tree BIGFORM */
#define TEXTKNOB          32 /* BOXTEXT in tree BIGFORM */
#define FILLRACK          34 /* BOX in tree BIGFORM */
#define FILLKNOB          35 /* BOXTEXT in tree BIGFORM */
#define MODEBUTTON        36 /* BOXTEXT in tree BIGFORM */
#define FILLBOX           37 /* IBOX in tree BIGFORM */
#define FILL0             38 /* BOXCHAR in tree BIGFORM */
#define FILLN             45 /* BOXCHAR in tree BIGFORM */

#define VARIOUSI          12 /* form/dialog */
#define VICGRAB            1 /* IMAGE in tree VARIOUSI */

#define SHARINGI          13 /* form/dialog */

#define BIGFORMI          14 /* form/dialog */

#define FLYING            15 /* form/dialog */
#define QFLY               3 /* BUTTON in tree FLYING */
#define FLYKNOB            5 /* BOXTEXT in tree FLYING */
#define OPAQUE             7 /* BUTTON in tree FLYING */

#define WCACTIVE          16 /* form/dialog */

#define WCINACTIVE        17 /* form/dialog */

#define FONTS             18 /* form/dialog */
#define FONTRACK           2 /* BOX in tree FONTS */
#define FONTKNOB           3 /* BOX in tree FONTS */
#define FONTMINUS          4 /* BOXCHAR in tree FONTS */
#define FONTPLUS           5 /* BOXCHAR in tree FONTS */
#define FONTNAMEBOX        6 /* BOX in tree FONTS */
#define FONTNAME0          7 /* BOXTEXT in tree FONTS */
#define FONTNAMEN         14 /* BOXTEXT in tree FONTS */
#define FONTPTPLUS10      16 /* BOXTEXT in tree FONTS */
#define FONTPTPLUS1       17 /* BOXTEXT in tree FONTS */
#define FONTPOINT         18 /* FTEXT in tree FONTS */
#define FONTPTMINUS10     19 /* BOXTEXT in tree FONTS */
#define FONTPTMINUS1      20 /* BOXTEXT in tree FONTS */
#define EXAMPLETEXT       22 /* BOXTEXT in tree FONTS */

#define FONTSI            19 /* form/dialog */

#define CANVAS            20 /* form/dialog */
#define CNVUP              2 /* BOXCHAR in tree CANVAS */
#define CNVDOWN            3 /* BOXCHAR in tree CANVAS */
#define CNVRIGHT           4 /* BOXCHAR in tree CANVAS */
#define CNVLEFT            5 /* BOXCHAR in tree CANVAS */
#define CNVRACK            6 /* BOX in tree CANVAS */
#define CNVKNOB            7 /* ICON in tree CANVAS */
#define CNVCIRCLE          9 /* ICON in tree CANVAS */
#define CNVSQUARE         10 /* ICON in tree CANVAS */
#define CNVTEXT           11 /* ICON in tree CANVAS */
#define CNVDELETE1        12 /* ICON in tree CANVAS */
#define CNVREPARM         13 /* ICON in tree CANVAS */
#define CNVHELP           14 /* ICON in tree CANVAS */
#define CNVERASE          15 /* ICON in tree CANVAS */
#define CNVREAD           16 /* ICON in tree CANVAS */
#define CNVWRITE          17 /* ICON in tree CANVAS */
#define CNVPHELP          18 /* BOXTEXT in tree CANVAS */
#define CNVPARM           19 /* FTEXT in tree CANVAS */
#define CNVBOX            21 /* BOX in tree CANVAS */
#define CNVCURSOR         22 /* IMAGE in tree CANVAS */

#define CANVASI           21 /* form/dialog */

#define CANVASHELP        22 /* free form */

#define CANVASPHELP       23 /* form/dialog */

#define TEXTWINI          24 /* form/dialog */

#define ERRWIN             0 /* Alert string */

#define CLOCKNOTE          1 /* Alert string */

#define GMJOKE             2 /* Alert string */

#define FILEPROMPT         3 /* Free string */

#define TESTF              4 /* Alert string */

