#ifndef rcs_fix_h
#define rcs_fix_h
#include <gemfast.h>
void rsc_fix(RSHDR* header, long offset, int rscw, int rsch);
#endif
