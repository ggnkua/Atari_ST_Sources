			.define buserr
			.text
buserr:		rte
	