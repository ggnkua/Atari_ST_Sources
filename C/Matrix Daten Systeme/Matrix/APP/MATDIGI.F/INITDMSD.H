extern int InitDmsd ( unsigned chip ) ;
extern bool ChangeDmsdParameter ( unsigned chip ) ;
