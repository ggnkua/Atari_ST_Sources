# define BYTESinMAP	2778

/* info : mdf_l3c0.rbt */

# include "\pc\app\xload\lcaload.h"

LCAdata mfp_3C =
{
	3030,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xa0, 0x36, 0xf3, 0xec, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xff, 0xff, 0xf7, 0xf7,
		 0xef, 0xfe, 0xff, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0x3d, 0xfe, 0xfe, 0xfe, 0xfe, 0xfe,
		 0xfe, 0xfe, 0xfd, 0xfd, 0xfd, 0xfd, 0xfb, 0xcf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xfe, 0xfb, 0xff, 0xbc, 0xff, 0xdf, 0x9f, 0xdf, 0x5f, 0x3f, 0xff, 0xff, 0x7f, 0xff, 0xef, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xbe, 0xf6, 0xfe, 0xfe, 0xfa, 0xfe,
		 0xfd, 0xbd, 0xfd, 0x7d, 0xf5, 0xcf, 0xef, 0xeb, 0xef, 0xef, 0xeb, 0xdf, 0xdf, 0xdf, 0xdf, 0xdf,
		 0xff, 0x7e, 0xdd, 0xfd, 0x7d, 0xff, 0xfd, 0xff, 0xfb, 0xfb, 0xf5, 0xfc, 0x0f, 0xff, 0xff, 0xff,
		 0xfb, 0xff, 0xf7, 0xf7, 0x7f, 0xfd, 0x7f, 0xff, 0xbe, 0xbf, 0x3f, 0xbf, 0xbf, 0x7f, 0x7f, 0x7f,
		 0x5e, 0x7f, 0xdf, 0xcf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xfb, 0xff, 0xfe, 0xef, 0x7e,
		 0x7f, 0x7f, 0x7f, 0x7f, 0xff, 0xf2, 0xfe, 0x9e, 0xfe, 0xfe, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf8, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xd7, 0xdf, 0xff,
		 0xbf, 0xef, 0xfe, 0xfe, 0xff, 0x7f, 0x7f, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xfb, 0xff,
		 0xf7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xaf, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xff, 0xff,
		 0xbf, 0xfb, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xdf, 0xbf, 0xef,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xff, 0xff, 0xfe, 0xff, 0xf7, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xee, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xf7, 0xfa, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0x7f, 0xaf, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xff, 0xfc, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf3,
		 0xfa, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xef, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xcf, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xef, 0xfe, 0xff,
		 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff,
		 0xff, 0xff, 0xfb, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xef, 0xff, 0xff, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xff, 0xff,
		 0xff, 0xfb, 0xff, 0xfe, 0x1f, 0xfc, 0x9f, 0x6f, 0xe8, 0xdf, 0xdf, 0x3f, 0xe8, 0xdf, 0x6f, 0x7f,
		 0xe3, 0xfe, 0xfa, 0xea, 0xff, 0xff, 0x7f, 0xe6, 0xff, 0xff, 0xfe, 0xfb, 0xff, 0xf7, 0xbd, 0xfd,
		 0xff, 0xff, 0x7f, 0xfa, 0xd7, 0xef, 0xbe, 0xff, 0xff, 0xff, 0xf7, 0xff, 0xff, 0xff, 0xe7, 0xff,
		 0xff, 0xee, 0xf7, 0xfe, 0xbb, 0x7e, 0xfe, 0xff, 0xff, 0x7f, 0xed, 0xff, 0xef, 0xff, 0xff, 0xfe,
		 0xdb, 0xdb, 0xfe, 0xff, 0xff, 0xaf, 0x7f, 0xfb, 0xfc, 0x3f, 0xde, 0x37, 0xb6, 0xfe, 0xff, 0xff,
		 0xff, 0xde, 0xff, 0xae, 0xff, 0xe3, 0xff, 0xe3, 0xe6, 0xff, 0xff, 0xff, 0xc7, 0xfd, 0xf7, 0xfa,
		 0xbf, 0xfe, 0xff, 0xbe, 0xfe, 0xff, 0xff, 0x7f, 0xb9, 0x7f, 0xcf, 0xff, 0x5b, 0xff, 0xfb, 0x7a,
		 0xff, 0xff, 0xff, 0xf7, 0x7f, 0xff, 0xfe, 0xff, 0xfd, 0xff, 0xfd, 0xfd, 0xff, 0xff, 0x7f, 0xfb,
		 0xff, 0xaf, 0xfe, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xf7, 0xf8, 0xbf, 0xff,
		 0xbf, 0xbf, 0xff, 0xff, 0xff, 0x7f, 0xff, 0x6f, 0xef, 0xff, 0xeb, 0xff, 0xef, 0x6a, 0xff, 0xff,
		 0xff, 0xd7, 0xfe, 0xff, 0xfe, 0x3f, 0xfe, 0x3f, 0x3f, 0xfc, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xcf,
		 0xff, 0xf3, 0xfe, 0xf3, 0xfa, 0xff, 0xff, 0xff, 0xdf, 0xff, 0xef, 0xfe, 0xff, 0xfc, 0xbf, 0x3f,
		 0xff, 0xff, 0xff, 0xff, 0xf9, 0xff, 0xef, 0x7f, 0xe1, 0xff, 0xcb, 0xc7, 0xfd, 0xff, 0xff, 0xcf,
		 0xfb, 0xfe, 0xfe, 0xff, 0xfe, 0xff, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbb, 0xef, 0xff, 0xd3,
		 0xff, 0xff, 0xfb, 0xfd, 0xff, 0xff, 0x9d, 0xff, 0xff, 0xfe, 0x3f, 0xff, 0xaf, 0x2f, 0xff, 0xd7,
		 0xdf, 0xdf, 0xd3, 0xff, 0xef, 0xff, 0xe3, 0xbf, 0xfa, 0xf7, 0xfb, 0xff, 0xfb, 0xff, 0xff, 0xff,
		 0xbe, 0xdc, 0x7f, 0xdf, 0xdf, 0xaf, 0xd7, 0xdf, 0xdf, 0xdf, 0xff, 0xef, 0xf3, 0x3f, 0x37, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0x7f, 0xcd, 0xff, 0xba, 0x75, 0xfd, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xfb, 0xef, 0xfb, 0xfa, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xfb, 0xff, 0xff, 0xbe, 0xbf,
		 0xff, 0xf7, 0xe7, 0xfb, 0xff, 0xff, 0xff, 0xf7, 0xfd, 0xef, 0xd3, 0xd7, 0xdf, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xbf, 0xfb, 0xbc, 0xfe, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf,
		 0xae, 0xfb, 0xff, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xf7, 0xaa, 0xbe, 0xfe, 0xfe,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7d, 0xaf, 0xfb, 0xfb, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xf7, 0xf7, 0xfe, 0xbd, 0xbd, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xbb, 0xaf, 0xff,
		 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0x9a, 0xbf, 0x9f, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0x7f, 0x7f, 0xaf, 0xe9, 0xeb, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd7,
		 0xf7, 0xbe, 0x7c, 0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xcf, 0xe3, 0xfa, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xef, 0xbe, 0xff, 0xbd, 0xfd, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xf9, 0xef, 0xfb, 0xef, 0xfb, 0xff, 0xfd, 0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xbe,
		 0xfb, 0xbe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xef, 0xe3, 0xdf, 0xcb, 0xfe, 0xff,
		 0xfe, 0xff, 0xfd, 0xfd, 0xbd, 0xff, 0xbe, 0x9f, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xef, 0xfb, 0xf6, 0xff, 0xff, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xd7, 0xff, 0xf2, 0x3e, 0xef,
		 0xf7, 0x3f, 0x9c, 0xef, 0xe7, 0xbf, 0xdf, 0xff, 0xcf, 0x57, 0xf3, 0xff, 0xfe, 0xeb, 0xff, 0xfb,
		 0xfb, 0xfe, 0xff, 0xff, 0xfe, 0xb9, 0xff, 0xfb, 0xbf, 0xfd, 0xff, 0xff, 0x7f, 0xfa, 0xf7, 0xef,
		 0xfb, 0xdb, 0xff, 0xff, 0xf5, 0xff, 0xff, 0xff, 0xe7, 0xff, 0xff, 0x3e, 0xf6, 0xf6, 0xef, 0x17,
		 0xf6, 0xbf, 0xff, 0x77, 0xbe, 0xff, 0xef, 0xc3, 0xff, 0xff, 0xff, 0xcb, 0xfd, 0xff, 0xff, 0xa7,
		 0xff, 0xff, 0x3e, 0xbf, 0xfc, 0xff, 0x3f, 0xef, 0xff, 0xef, 0xbf, 0xff, 0xff, 0xee, 0xf3, 0xfb,
		 0xff, 0xff, 0xf3, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xfe, 0xfe, 0xff, 0xbf, 0xfc, 0xff,
		 0xff, 0x7f, 0xfd, 0x7f, 0xaf, 0xfb, 0xfb, 0xff, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xf7, 0xff, 0xfd,
		 0xfc, 0xfd, 0xed, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xfb, 0xff, 0xaf, 0xfe, 0xff, 0xff, 0x7f,
		 0xfd, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xb8, 0xbf, 0xff, 0xff, 0xbf, 0xff, 0xff, 0xdf, 0x7f,
		 0xff, 0x7f, 0xef, 0xeb, 0xed, 0xff, 0x7f, 0xeb, 0xff, 0xff, 0xff, 0xd7, 0xff, 0xef, 0x1e, 0xbe,
		 0xff, 0xff, 0x7f, 0xfe, 0xff, 0xff, 0xbf, 0xdf, 0xff, 0xcf, 0xe3, 0xf9, 0xff, 0xff, 0xeb, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xef, 0x3e, 0xfe, 0xfd, 0xff, 0xbf, 0xfe, 0xff, 0xff, 0x7f, 0xfe, 0xff,
		 0xef, 0xe2, 0xaf, 0xfc, 0xff, 0x0f, 0xff, 0xff, 0xff, 0xc5, 0xff, 0xff, 0xfe, 0xbf, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0x77, 0xf8, 0xff, 0xef, 0xe7, 0xca, 0xff, 0xfe, 0xee, 0xfe, 0xff, 0xfd,
		 0xe7, 0xfd, 0xff, 0xfe, 0x3d, 0xfd, 0xff, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x6f, 0xfb,
		 0xf3, 0xff, 0xff, 0xef, 0xfb, 0xff, 0x7f, 0xff, 0xff, 0xef, 0x30, 0x14, 0x2e, 0x14, 0xfc, 0xbf,
		 0xbf, 0xdf, 0xdf, 0xbe, 0x5f, 0xae, 0x63, 0x92, 0xe2, 0xe3, 0xff, 0xff, 0xff, 0x7f, 0xcf, 0xff,
		 0xff, 0x3c, 0x3f, 0x1f, 0x3f, 0xf7, 0xf7, 0xff, 0x7f, 0xfe, 0xfe, 0xfb, 0xef, 0xf3, 0xf3, 0xfb,
		 0xf3, 0xbf, 0x7f, 0xff, 0xa7, 0xef, 0xff, 0xf7, 0x3e, 0xbe, 0xbe, 0x3e, 0xf6, 0xff, 0xff, 0x7f,
		 0xf6, 0xfe, 0xff, 0xef, 0xf3, 0xfb, 0xb7, 0xf3, 0xff, 0xff, 0xff, 0xe7, 0xed, 0xbf, 0xff, 0x3e,
		 0xbe, 0x3e, 0x3e, 0xfe, 0xff, 0xbf, 0xef, 0xff, 0xfe, 0xff, 0xaf, 0xe3, 0xeb, 0xeb, 0xe3, 0xff,
		 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xba, 0xbe, 0xbe, 0xbe, 0xfa, 0xff, 0xff, 0x7f, 0x5d, 0xfd,
		 0x7f, 0x6f, 0xfb, 0xdb, 0xdb, 0x7b, 0xfe, 0xff, 0xff, 0xf7, 0xef, 0xff, 0xf7, 0xdc, 0xfd, 0xdd,
		 0xdd, 0xfd, 0xff, 0xff, 0x7f, 0x7b, 0xfb, 0xfb, 0xae, 0xde, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xfd, 0xbf, 0xff, 0xff, 0xb8, 0xa7, 0x8f, 0xbf, 0xff, 0xff, 0xff, 0xff, 0x76, 0xb7, 0x7f, 0xef,
		 0xeb, 0x4b, 0xeb, 0xeb, 0xff, 0xff, 0xff, 0x57, 0x5f, 0xfd, 0xe7, 0xfe, 0xfe, 0xbf, 0xbc, 0xff,
		 0xff, 0xff, 0x7f, 0xf9, 0xff, 0xff, 0xcf, 0xe7, 0xfe, 0xff, 0xfe, 0xff, 0xfe, 0xff, 0xef, 0xff,
		 0xff, 0xff, 0xfa, 0xec, 0xfd, 0x7d, 0xdd, 0xff, 0xff, 0xff, 0x7e, 0xfe, 0x7f, 0xef, 0xc8, 0x7f,
		 0xaf, 0xcf, 0xfe, 0xff, 0xff, 0x97, 0x41, 0xff, 0xff, 0xfe, 0xbd, 0xbf, 0xbe, 0xfd, 0xff, 0xff,
		 0x7f, 0x7f, 0xfa, 0xff, 0xef, 0xc7, 0xdb, 0xdf, 0xcd, 0xff, 0xff, 0xff, 0xcd, 0x47, 0xfd, 0xf7,
		 0xfe, 0xbe, 0x6f, 0x7a, 0xfe, 0xff, 0xff, 0xff, 0xde, 0xfb, 0xff, 0x6e, 0xfb, 0xfb, 0xfb, 0xff,
		 0xff, 0xff, 0xfb, 0xf7, 0xff, 0xfd, 0xef, 0xaa, 0x77, 0x78, 0xeb, 0xfc, 0xac, 0xf9, 0x5f, 0xff,
		 0xf9, 0x7f, 0xef, 0xf3, 0x6a, 0xeb, 0xef, 0xef, 0xf7, 0xff, 0xf7, 0xd7, 0xff, 0xf7, 0x16, 0xbd,
		 0x3d, 0xfd, 0xfd, 0x7d, 0xfb, 0xff, 0xfb, 0xfb, 0xff, 0x8e, 0xfb, 0xfd, 0xb3, 0xff, 0xbf, 0x7f,
		 0xff, 0xf7, 0xff, 0xff, 0xfb, 0xbe, 0x3f, 0x3e, 0x3f, 0x23, 0x6f, 0xff, 0xef, 0xed, 0xf7, 0xff,
		 0x6f, 0xd9, 0xdb, 0xd2, 0xd3, 0xd3, 0xa7, 0xff, 0x9f, 0xbf, 0xfd, 0xff, 0xae, 0x2e, 0xb5, 0x3e,
		 0x3e, 0x76, 0xec, 0x7f, 0xfd, 0xfd, 0xff, 0xae, 0xfb, 0xf3, 0xf7, 0xf2, 0xf3, 0xf7, 0xff, 0xff,
		 0xff, 0xff, 0xf7, 0xba, 0xbe, 0x6a, 0xbf, 0x9e, 0x6a, 0xfd, 0xff, 0x7d, 0xfd, 0x7f, 0xef, 0xfb,
		 0xfb, 0xfb, 0xf9, 0xfb, 0xf6, 0xff, 0x37, 0xf7, 0xff, 0xff, 0xfc, 0xfd, 0xbd, 0xfd, 0xfd, 0xfd,
		 0xdb, 0xff, 0x7b, 0xfb, 0xff, 0xee, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xfe, 0xfc, 0xff,
		 0xf7, 0xba, 0xaf, 0x9f, 0xbf, 0xbf, 0x7f, 0xff, 0x7f, 0x5f, 0xff, 0x7f, 0x8f, 0xea, 0xeb, 0xeb,
		 0xe9, 0xcb, 0xd7, 0xff, 0xdf, 0xd7, 0xff, 0xf7, 0xbe, 0x3e, 0xfe, 0x3f, 0x3c, 0x7c, 0xfd, 0xff,
		 0xf9, 0xd9, 0xff, 0xef, 0xe3, 0xeb, 0xfb, 0xf3, 0xf3, 0xe7, 0xff, 0xf7, 0xff, 0xff, 0xef, 0x3e,
		 0xbe, 0xae, 0x1d, 0x2f, 0x7f, 0xfc, 0xff, 0xff, 0xfb, 0xff, 0xef, 0xfb, 0xf5, 0xeb, 0xe2, 0xe3,
		 0xd7, 0x7f, 0x9f, 0x9f, 0xff, 0xff, 0xbe, 0xff, 0x3d, 0x3f, 0x3e, 0xff, 0xff, 0x5f, 0xff, 0xff,
		 0xff, 0xaf, 0xfb, 0xff, 0xd3, 0xff, 0xff, 0xf7, 0xfd, 0xdf, 0x9d, 0xff, 0xff, 0xbc, 0xbf, 0xbf,
		 0x3d, 0x3e, 0x7d, 0xfa, 0x7f, 0xdd, 0xff, 0xff, 0x4f, 0xfb, 0xff, 0xf1, 0xff, 0xee, 0xd3, 0xff,
		 0xf7, 0xf7, 0xfd, 0xff, 0x7a, 0x28, 0x2c, 0x14, 0x3f, 0xbe, 0xee, 0x7f, 0xfe, 0xfd, 0x7f, 0xce,
		 0xeb, 0xe2, 0xa2, 0x73, 0xcb, 0xd7, 0x7f, 0xd3, 0x9f, 0xff, 0xfd, 0xba, 0xfd, 0x2d, 0xfd, 0xbf,
		 0xfd, 0xfa, 0x7f, 0xff, 0xfb, 0xf7, 0xef, 0xf7, 0x7f, 0xb3, 0xdf, 0xff, 0xef, 0xff, 0x63, 0xfb,
		 0xff, 0xf7, 0x7e, 0xea, 0x3f, 0xfe, 0x7b, 0x77, 0xfe, 0xff, 0xfe, 0xfc, 0xff, 0xef, 0x9b, 0xde,
		 0xd3, 0xbf, 0xdb, 0xa6, 0xff, 0xe7, 0x87, 0xff, 0xff, 0xbe, 0x34, 0x3e, 0x3c, 0x37, 0x7f, 0xfd,
		 0x7f, 0xfc, 0xfe, 0xff, 0xef, 0xf7, 0xf3, 0xf3, 0xf3, 0xf3, 0xef, 0xff, 0xef, 0xff, 0xff, 0xf7,
		 0xba, 0xbe, 0xbe, 0x3e, 0xad, 0x7e, 0xfd, 0x7f, 0x7d, 0xfd, 0x7f, 0xaf, 0x7b, 0xdb, 0xfb, 0xfa,
		 0xfb, 0xf7, 0xff, 0xd7, 0xb7, 0xfd, 0xff, 0xfc, 0xfd, 0xed, 0xad, 0xfd, 0xfd, 0xfb, 0xdf, 0xfd,
		 0xfb, 0xff, 0x6e, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xbf,
		 0xaf, 0xff, 0xb3, 0x7f, 0xff, 0x7f, 0x77, 0xff, 0x7f, 0x8f, 0xeb, 0xeb, 0xeb, 0xe9, 0xe9, 0xd7,
		 0xff, 0x57, 0xd3, 0xff, 0xff, 0x3e, 0x3c, 0xff, 0x3c, 0x3f, 0xfe, 0xfe, 0xff, 0xfc, 0xd9, 0xff,
		 0xef, 0xfb, 0xe3, 0xfe, 0xf3, 0xeb, 0xd7, 0xff, 0xe7, 0xef, 0xff, 0xed, 0x3e, 0x2f, 0xdf, 0xbf,
		 0xb5, 0x7e, 0xfe, 0x7f, 0x7c, 0xfe, 0xff, 0xef, 0xf7, 0xfc, 0xef, 0xc7, 0xef, 0xc7, 0xff, 0xef,
		 0x8f, 0xfb, 0xf7, 0x3e, 0x3f, 0x3b, 0xfe, 0xff, 0xfe, 0xff, 0x7f, 0xfe, 0xff, 0xff, 0xaf, 0xfb,
		 0xbf, 0xff, 0xcf, 0xff, 0xdf, 0xff, 0xf7, 0xdf, 0xff, 0xff, 0x3c, 0x2e, 0x1e, 0xbf, 0xbf, 0x7f,
		 0xfb, 0x7f, 0xbf, 0xdf, 0xff, 0x6f, 0xe7, 0xe3, 0xef, 0xf6, 0xe7, 0xeb, 0xff, 0xe7, 0xff, 0xfe,
		 0xff, 0xfc, 0x6e, 0x3c, 0xff, 0x9f, 0xbf, 0xbf, 0xdf, 0x78, 0xfe, 0xfd, 0xef, 0x8f, 0x6b, 0xef,
		 0x7d, 0xeb, 0xff, 0x7f, 0xcf, 0xe6, 0x9f, 0xff, 0xfc, 0xbd, 0xfd, 0xfd, 0xbd, 0xff, 0xff, 0x7f,
		 0x7a, 0xfb, 0xfb, 0xcf, 0xdf, 0xff, 0x93, 0xff, 0xfb, 0xff, 0xff, 0xeb, 0xf7, 0xfb, 0xff, 0xae,
		 0x3f, 0xf7, 0xbf, 0xbe, 0xff, 0xff, 0xff, 0x66, 0xff, 0xfd, 0xef, 0xdb, 0xda, 0x93, 0xcb, 0xfb,
		 0xff, 0xff, 0xa7, 0x37, 0xbf, 0xfd, 0xbe, 0x3e, 0x3f, 0x8e, 0xaf, 0xff, 0xff, 0xff, 0x3d, 0xfe,
		 0xf9, 0xae, 0xfb, 0xf1, 0xff, 0xfb, 0xfb, 0xfd, 0xff, 0xff, 0xe5, 0xff, 0xf7, 0xba, 0xbe, 0xbe,
		 0xbe, 0xbe, 0xfe, 0xff, 0x7f, 0xfd, 0x5d, 0x7d, 0xef, 0xf7, 0xfb, 0xfb, 0xfb, 0xfb, 0xff, 0xff,
		 0xf7, 0xf7, 0x37, 0xf7, 0xbc, 0xfd, 0xad, 0xbd, 0xfd, 0xfd, 0xff, 0xdf, 0xfb, 0xfb, 0xfb, 0xaf,
		 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xf7, 0x9a, 0xbf, 0xbf, 0xbf, 0xbf,
		 0xfb, 0xff, 0x7f, 0x7f, 0x7f, 0x7f, 0xcf, 0xeb, 0xeb, 0xea, 0xeb, 0xeb, 0xff, 0xff, 0xd7, 0xdf,
		 0xd7, 0xf7, 0x3e, 0x3f, 0x3e, 0x7c, 0xbf, 0xff, 0xbf, 0xff, 0x3c, 0xfe, 0xff, 0xef, 0xf3, 0xeb,
		 0xeb, 0xf7, 0xfb, 0xff, 0xff, 0xe7, 0xe7, 0xdb, 0xef, 0x7e, 0xbd, 0xbe, 0x7d, 0xbd, 0xf7, 0xff,
		 0x7f, 0x7c, 0xff, 0xff, 0xef, 0xfe, 0xc7, 0xf2, 0xf5, 0xfb, 0xff, 0xff, 0xef, 0xd7, 0xdf, 0xf7,
		 0xbc, 0xff, 0xff, 0xbf, 0xbf, 0xff, 0xbb, 0xff, 0x7e, 0xfd, 0xfc, 0xaf, 0xdf, 0xef, 0xdb, 0xdb,
		 0xfb, 0xff, 0xfb, 0xc7, 0xf7, 0xfb, 0xff, 0x3e, 0xbf, 0xbf, 0xbf, 0xbf, 0xff, 0xff, 0x5f, 0x7e,
		 0xfe, 0xff, 0xaf, 0xf3, 0xff, 0xff, 0xfb, 0xfb, 0x7b, 0xff, 0xcf, 0xe3, 0x5f, 0xff, 0x3a, 0xdf,
		 0xdc, 0x3f, 0xdf, 0xbf, 0xff, 0x7f, 0x2f, 0xfc, 0xfe, 0xcf, 0x73, 0xeb, 0xfe, 0xf3, 0xff, 0xff,
		 0xff, 0xf3, 0x87, 0xd5, 0xff, 0x3a, 0xb5, 0xbf, 0xfd, 0xff, 0xff, 0xfe, 0x6f, 0xff, 0x7f, 0xbf,
		 0xef, 0xf3, 0xff, 0xf7, 0xbf, 0x7f, 0xef, 0xff, 0xf3, 0xff, 0xe7, 0xff, 0x3e, 0x3f, 0x7f, 0xff,
		 0xff, 0xff, 0xe6, 0x7f, 0x7e, 0xfe, 0xee, 0xef, 0xd3, 0xfb, 0xdb, 0xff, 0xff, 0x6f, 0xff, 0x67,
		 0xe7, 0xf7, 0xff, 0x3c, 0xb7, 0xfe, 0x3f, 0xff, 0xff, 0xff, 0x7f, 0x5e, 0x7e, 0xee, 0xae, 0xf1,
		 0xf3, 0xff, 0xf3, 0xff, 0xff, 0xfb, 0xe7, 0xe3, 0xe7, 0xf7, 0xfa, 0xbf, 0xbe, 0xbe, 0xfe, 0xff,
		 0xfd, 0x7f, 0x7f, 0x7e, 0x7f, 0xef, 0xff, 0xfb, 0xfb, 0xfb, 0xff, 0xff, 0xff, 0xd7, 0xf7, 0xed,
		 0xf7, 0xec, 0xfd, 0xbd, 0xfd, 0xfd, 0x7f, 0xfb, 0xdf, 0xfd, 0x7f, 0xff, 0xef, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xf7, 0xea, 0xaf, 0xbf, 0xbf, 0xfb, 0xff, 0xbe, 0x7f,
		 0x77, 0xb7, 0x76, 0x0f, 0x7f, 0xeb, 0x6b, 0xeb, 0xff, 0xff, 0xff, 0xf7, 0xe3, 0xf7, 0xff, 0x3e,
		 0x3f, 0xbf, 0x3f, 0xff, 0x7f, 0xff, 0x7f, 0x7e, 0xf8, 0xf8, 0xef, 0xf3, 0xeb, 0xe7, 0xf2, 0xff,
		 0xf7, 0xff, 0xc7, 0xc7, 0xf7, 0xef, 0x3e, 0xbf, 0xfd, 0xfd, 0xf7, 0x7f, 0xfe, 0x7f, 0x77, 0x37,
		 0xf6, 0xef, 0xf3, 0xf3, 0xef, 0xef, 0xff, 0xe7, 0xfe, 0xc3, 0xeb, 0xe7, 0xf7, 0x36, 0xff, 0xfd,
		 0xfe, 0xfe, 0x5f, 0xff, 0x7f, 0x7b, 0x7f, 0xfe, 0xef, 0xf3, 0xdb, 0xdf, 0xff, 0xff, 0xf7, 0xff,
		 0xd7, 0xff, 0xf7, 0xff, 0x3e, 0xbf, 0x6f, 0x2f, 0xeb, 0x7f, 0xfe, 0x7f, 0x7b, 0x5c, 0xf7, 0x4f,
		 0xf3, 0xbf, 0xfb, 0xf3, 0xff, 0xc3, 0xff, 0xd7, 0xe7, 0xef, 0xff, 0xfe, 0xff, 0x7f, 0xdf, 0xff,
		 0xbf, 0xff, 0x3e, 0xf8, 0xbf, 0xff, 0xef, 0x7e, 0xff, 0xb7, 0xff, 0xff, 0x7f, 0xed, 0xc7, 0xff,
		 0xff, 0xff, 0xfe, 0xff, 0x7f, 0xff, 0xff, 0xff, 0x7b, 0x7e, 0xfa, 0xff, 0xbf, 0xef, 0xff, 0xdf,
		 0xd6, 0x7e, 0xff, 0xff, 0xe7, 0xef, 0xbe, 0xff, 0xff, 0xfe, 0x3f, 0x7e, 0x3f, 0xfe, 0x7b, 0x7f,
		 0xee, 0xf6, 0xff, 0xff, 0xef, 0xff, 0xf3, 0xf7, 0xe3, 0xff, 0xaf, 0xe7, 0xb7, 0xff, 0xff, 0xff,
		 0xdc, 0x3f, 0x77, 0x3f, 0xff, 0xff, 0xfc, 0x7e, 0xfc, 0xff, 0xff, 0xae, 0xff, 0xe3, 0xf7, 0xf3,
		 0xff, 0xf7, 0xeb, 0xe3, 0xff, 0xff, 0xf7, 0xea, 0x9f, 0xfe, 0xbe, 0xfe, 0x7f, 0xfd, 0x7d, 0xfd,
		 0xff, 0x7f, 0xcf, 0xff, 0xf7, 0xfb, 0xf7, 0xff, 0xf5, 0xd7, 0x77, 0xff, 0xff, 0xff, 0xfe, 0xbf,
		 0xfd, 0xbd, 0xfd, 0x7f, 0xfb, 0x7d, 0xfb, 0xff, 0xff, 0xaf, 0xff, 0xff, 0x7f, 0xff, 0xff, 0xff,
		 0xff, 0xbf, 0xfb, 0xff, 0xf7, 0xfa, 0xbf, 0xbb, 0xbb, 0xfb, 0x7f, 0x3f, 0x77, 0xff, 0xef, 0x5f,
		 0xcf, 0xff, 0xf3, 0xef, 0xf3, 0xff, 0xdf, 0x5f, 0xd7, 0xff, 0xff, 0xff, 0xfe, 0x3f, 0x7f, 0x3f,
		 0xff, 0xff, 0xf8, 0x7e, 0xfc, 0xff, 0xff, 0x6f, 0xff, 0xf3, 0xf7, 0xf3, 0xff, 0xdf, 0xef, 0xe7,
		 0xff, 0xff, 0xef, 0xee, 0xff, 0x7b, 0xf7, 0xfb, 0xff, 0x7b, 0xfe, 0xf8, 0xff, 0xff, 0xef, 0xff,
		 0xef, 0xf7, 0xef, 0xff, 0xef, 0xc7, 0xd7, 0xff, 0xff, 0xf7, 0xfc, 0xff, 0x7e, 0xff, 0xfe, 0xff,
		 0x7e, 0x7e, 0xfe, 0xff, 0xff, 0xef, 0xff, 0xff, 0xf7, 0xff, 0xff, 0xaf, 0xe7, 0xaf, 0xff, 0xff,
		 0xff, 0xfc, 0x3f, 0x7f, 0x3f, 0xff, 0xff, 0xfe, 0x3a, 0xfa, 0xff, 0xff, 0xcf, 0xbf, 0xf3, 0xf7,
		 0xf3, 0xff, 0xcb, 0xcf, 0xe7, 0xff, 0xff, 0xfd, 0xfe, 0xf7, 0xff, 0xff, 0xff, 0x3f, 0xfd, 0xaf,
		 0xff, 0xff, 0xff, 0xef, 0xdd, 0xdf, 0xdf, 0x5b, 0xdf, 0xbf, 0xbf, 0x3b, 0xbf, 0xbf, 0xff, 0x9c,
		 0xb9, 0xb9, 0xbd, 0xbd, 0x7d, 0x7b, 0x7b, 0x7b, 0x7b, 0xdb, 0xef, 0xe7, 0xf5, 0x75, 0xf5, 0xf5,
		 0xad, 0xeb, 0xef, 0xeb, 0xeb, 0xfd, 0xfe, 0xff, 0xfd, 0xfd, 0x7d, 0xff, 0xff, 0xfd, 0xfe, 0xfe,
		 0xfd, 0xef, 0xf5, 0xfb, 0xfb, 0xfb, 0xf7, 0xf7, 0xef, 0xef, 0xef, 0xef, 0xff, 0xfe, 0xbf, 0xbf,
		 0xbf, 0xff, 0xff, 0xff, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;