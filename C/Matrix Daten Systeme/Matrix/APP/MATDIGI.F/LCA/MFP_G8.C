# define BYTESinMAP	2778

/* info : mdf_lfgx.rbt */

/* 7 bit Grau - Modus	*/

# include "\pc\app\xload\lcaload.h"

LCAdata mfp_G8 =
{
	3030,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xa0, 0x36, 0xf3, 0xec, 0xff, 0xff, 0xdf, 0xff, 0xbf, 0xff, 0xdf, 0xff, 0xf7, 0xff,
		 0xef, 0xfe, 0xff, 0xf6, 0xff, 0xfe, 0xff, 0xfd, 0xef, 0xff, 0xfe, 0xff, 0xfe, 0xee, 0xfe, 0xfe,
		 0xfe, 0xee, 0xfd, 0xfd, 0xfd, 0xed, 0xfd, 0xcf, 0xff, 0xdf, 0xff, 0xff, 0xfd, 0xbf, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xbc, 0xb7, 0xff, 0x97, 0xbd, 0x5f, 0xbf, 0xff, 0x7f, 0x7f, 0xff, 0xef, 0xdf,
		 0xff, 0xde, 0xff, 0xdf, 0xb7, 0xff, 0xbf, 0xdf, 0xfd, 0xff, 0xbe, 0xde, 0xfe, 0xfe, 0x92, 0xfe,
		 0xe5, 0xed, 0xfd, 0xfd, 0xfd, 0xcf, 0xef, 0xcf, 0xeb, 0xef, 0xef, 0xdf, 0xdf, 0xdf, 0xdf, 0xdf,
		 0xff, 0x7e, 0x7d, 0xdd, 0xfd, 0x3f, 0xfd, 0xfe, 0xfa, 0xfb, 0xf4, 0xfa, 0x4f, 0xdf, 0xfb, 0xdf,
		 0xd9, 0xde, 0x7f, 0xbf, 0x7f, 0xf7, 0x77, 0xff, 0x9e, 0xbf, 0x2f, 0xbf, 0xbf, 0x6f, 0x5f, 0x7f,
		 0x7e, 0x7f, 0xdf, 0xef, 0xfd, 0xef, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xef, 0x7e,
		 0x7f, 0x7f, 0x6f, 0x7f, 0xdf, 0xbe, 0xfe, 0xfe, 0xfe, 0xfe, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xfc, 0xbe, 0x6f, 0x3f, 0x1f, 0x7e, 0x3e, 0x5c, 0x7d, 0x5f,
		 0xbf, 0xef, 0xcb, 0xf6, 0xfa, 0xba, 0xdb, 0x56, 0x16, 0x87, 0xf7, 0xf7, 0xff, 0xb6, 0xff, 0xff,
		 0xfb, 0xf7, 0xff, 0xff, 0x7f, 0x7f, 0xff, 0xff, 0xef, 0xdf, 0xbf, 0xff, 0xfa, 0xba, 0xf5, 0xf7,
		 0xff, 0xeb, 0xff, 0xfb, 0xbe, 0x7b, 0xae, 0xbf, 0xbf, 0x7f, 0x77, 0xf7, 0xff, 0xfe, 0xfe, 0xef,
		 0xb3, 0xfb, 0xb7, 0xff, 0xbf, 0xff, 0xff, 0xf7, 0x77, 0x6f, 0xff, 0x3e, 0x3f, 0x37, 0xbe, 0xbf,
		 0x7f, 0x5f, 0x7f, 0x7e, 0x6f, 0xfc, 0xee, 0xfb, 0xe3, 0xf3, 0xf3, 0xf3, 0xe7, 0xe7, 0xf3, 0xf7,
		 0xe7, 0xf7, 0xba, 0x3c, 0xbf, 0x7e, 0xff, 0xee, 0xf5, 0x7d, 0xfd, 0xfd, 0x7d, 0xaf, 0xf7, 0xfb,
		 0xfb, 0xfa, 0xf7, 0xef, 0xf7, 0xf7, 0xf3, 0xf5, 0xff, 0xbc, 0xbd, 0xbd, 0xbd, 0x9d, 0x7d, 0x7b,
		 0xfb, 0xfb, 0xfb, 0xfb, 0xaf, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xfd, 0xfb, 0xff, 0xff, 0xff, 0xf3,
		 0xba, 0xfb, 0xeb, 0xfb, 0xbb, 0x7b, 0x57, 0x77, 0x77, 0x7f, 0x7f, 0xef, 0x7f, 0xef, 0xf7, 0xeb,
		 0x6b, 0xd5, 0xd7, 0xd7, 0xdf, 0xdf, 0xfe, 0x3e, 0x3e, 0x3e, 0x3e, 0xbe, 0x7e, 0x7d, 0x7d, 0x7f,
		 0x7f, 0xfe, 0xcf, 0xe3, 0xeb, 0xeb, 0xe3, 0xe3, 0xc7, 0xc7, 0xe7, 0xf7, 0xe3, 0xeb, 0xbe, 0xb6,
		 0xe6, 0xb6, 0xb6, 0x76, 0x6d, 0x6d, 0x6f, 0xfb, 0xfa, 0xef, 0xe7, 0xe3, 0xeb, 0xe7, 0xef, 0xdf,
		 0xdd, 0xdf, 0xcf, 0x8f, 0xf4, 0xfe, 0xbf, 0xbf, 0xdd, 0xde, 0xff, 0xfd, 0xfd, 0xfd, 0xfc, 0xff,
		 0xef, 0xef, 0xed, 0xff, 0xff, 0xea, 0xf7, 0xf7, 0xf3, 0xb7, 0x9f, 0xff, 0x7e, 0xdd, 0xbd, 0x5d,
		 0x3f, 0x7d, 0x7e, 0x7e, 0x56, 0x7d, 0xff, 0xef, 0xfb, 0xeb, 0xe3, 0xfb, 0xfb, 0xf3, 0xf7, 0xf7,
		 0xd7, 0xf5, 0xff, 0xfe, 0xbf, 0x9f, 0x9f, 0x9e, 0x3f, 0x7c, 0xbc, 0xfd, 0xef, 0xbf, 0xef, 0xff,
		 0x77, 0xeb, 0xcb, 0xe7, 0xb7, 0x97, 0x97, 0xff, 0xff, 0xff, 0x8e, 0xff, 0xbb, 0xff, 0xff, 0xff,
		 0xff, 0x6f, 0x7f, 0x76, 0xff, 0xef, 0xf7, 0xff, 0xb7, 0xff, 0xff, 0xf7, 0xf3, 0xff, 0xe7, 0xeb,
		 0xff, 0x6e, 0x7e, 0x7a, 0x3a, 0x7f, 0x6a, 0x7f, 0x7f, 0x5d, 0xfe, 0xdd, 0xef, 0xeb, 0x7b, 0xeb,
		 0xf3, 0xbb, 0xff, 0xfe, 0xe7, 0xe7, 0xff, 0xff, 0x3c, 0x3e, 0xbf, 0xbe, 0x3e, 0x77, 0x7f, 0x7f,
		 0xf8, 0xff, 0xf9, 0xae, 0xf3, 0xe3, 0xfb, 0xfb, 0xe3, 0xe7, 0xe7, 0xf7, 0xff, 0xff, 0xf7, 0xba,
		 0x3e, 0x3f, 0xbf, 0x7e, 0x7f, 0xfd, 0xdd, 0x7d, 0x7d, 0x7d, 0xef, 0xfb, 0xfa, 0xfb, 0xf9, 0xfb,
		 0xef, 0xb7, 0xf7, 0xb7, 0xf3, 0xff, 0xbe, 0xbd, 0xad, 0xfd, 0xbd, 0x7d, 0x7b, 0x7b, 0xfb, 0xfb,
		 0xfb, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xff, 0xf7, 0x9a, 0xfb, 0xbb,
		 0xbb, 0xfb, 0x7b, 0x77, 0xf7, 0x77, 0x7f, 0x7f, 0xef, 0xf7, 0xef, 0xeb, 0xcb, 0xeb, 0xdf, 0xd7,
		 0xe7, 0xd7, 0xd7, 0xff, 0xbe, 0xbc, 0x3e, 0xbf, 0xbf, 0x7e, 0x7d, 0x7d, 0xff, 0xff, 0xdd, 0xcf,
		 0xeb, 0xe2, 0xf3, 0xfa, 0xe1, 0xc7, 0xc7, 0xc7, 0xff, 0xff, 0xed, 0x3e, 0x37, 0xb6, 0x37, 0x37,
		 0x76, 0x6d, 0x6d, 0x6f, 0xda, 0xf9, 0xef, 0xe3, 0xeb, 0xab, 0xe3, 0xeb, 0xdd, 0xdb, 0xff, 0xe6,
		 0x9b, 0xf7, 0x3e, 0xfe, 0xbe, 0xfe, 0xfe, 0xfe, 0xf9, 0xfd, 0x7b, 0xfe, 0xfe, 0xef, 0xe3, 0xfb,
		 0xeb, 0xef, 0xfa, 0xf7, 0xf7, 0xf5, 0x87, 0x97, 0xff, 0xbe, 0xbf, 0xfe, 0xbf, 0xbf, 0x7f, 0x7e,
		 0x7e, 0xfe, 0xdf, 0xdf, 0xef, 0xeb, 0xbf, 0xfe, 0xfb, 0xff, 0xf3, 0xd7, 0x57, 0xfd, 0xff, 0xff,
		 0xfe, 0xbf, 0xaf, 0xff, 0xbf, 0x3f, 0x7e, 0xfc, 0xff, 0xff, 0xdd, 0xef, 0xff, 0xff, 0x77, 0xff,
		 0xff, 0xf7, 0x97, 0x7e, 0x7f, 0x1f, 0xff, 0xfa, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f,
		 0xfe, 0xff, 0xef, 0xbf, 0xfb, 0xff, 0xbf, 0xfb, 0xf7, 0xb7, 0xff, 0x67, 0xff, 0xff, 0xfe, 0x3f,
		 0x6e, 0xfa, 0x3f, 0x7e, 0x5c, 0x77, 0x7e, 0xfe, 0xbd, 0xef, 0xff, 0xeb, 0xeb, 0xfe, 0xbb, 0xf7,
		 0xff, 0xe7, 0xe5, 0xcc, 0xff, 0xfc, 0xbf, 0x3f, 0xff, 0xbf, 0x74, 0x7f, 0x7f, 0xfc, 0x7f, 0xfc,
		 0xae, 0xff, 0xf3, 0xf3, 0xff, 0xf3, 0xc7, 0xe7, 0xe7, 0xff, 0xef, 0xf7, 0xfa, 0xff, 0x3e, 0xff,
		 0xff, 0xfc, 0xfe, 0x7d, 0x7d, 0x7d, 0x7d, 0xaf, 0xff, 0xd7, 0xfb, 0xff, 0xd7, 0xaf, 0xf7, 0xf7,
		 0xd7, 0xb7, 0xf7, 0xfe, 0xbf, 0xbd, 0xfd, 0xbf, 0x7d, 0x7b, 0x7b, 0xfb, 0xf9, 0xfb, 0xaf, 0xff,
		 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xf7, 0xfa, 0x9f, 0xfb, 0xdb, 0x9f, 0x7b,
		 0x77, 0x77, 0x37, 0x37, 0x7f, 0xaf, 0xff, 0xfb, 0xef, 0xff, 0xfb, 0xd7, 0xd7, 0x67, 0x53, 0xd7,
		 0xf7, 0xfe, 0x3f, 0x3e, 0xfe, 0x3f, 0x7e, 0x7c, 0x7d, 0xff, 0xff, 0xf9, 0xcf, 0xff, 0xe3, 0xeb,
		 0xff, 0xe3, 0xc7, 0xc5, 0xcf, 0xfd, 0xfd, 0xef, 0xfe, 0xbf, 0xa6, 0xf6, 0xbf, 0x76, 0x6d, 0xed,
		 0x7e, 0xfe, 0xfb, 0xef, 0xfe, 0xe7, 0xe3, 0xff, 0xe7, 0xcf, 0xdf, 0xf7, 0xc7, 0xdf, 0xf7, 0xfe,
		 0xff, 0xbe, 0xfe, 0xff, 0xfe, 0xfd, 0x7d, 0x7f, 0xfe, 0xbf, 0xef, 0xff, 0xff, 0xfe, 0xff, 0xff,
		 0xfe, 0xf7, 0xef, 0xc7, 0x1f, 0xff, 0xfe, 0x7f, 0xff, 0xff, 0x7f, 0xff, 0x7e, 0xf6, 0xfe, 0xbb,
		 0xfb, 0xef, 0xbf, 0xea, 0xbb, 0xbf, 0xea, 0xd3, 0xf6, 0xf5, 0xff, 0xff, 0xfb, 0xb0, 0xb6, 0xbf,
		 0xbe, 0xfc, 0x2e, 0x7e, 0x5c, 0xfd, 0xfd, 0xf9, 0xaf, 0xc3, 0xe3, 0x97, 0xeb, 0xcb, 0xf7, 0x17,
		 0x8f, 0x3e, 0xde, 0xff, 0x36, 0xbf, 0xfb, 0xfb, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xdb, 0xeb, 0xef,
		 0xbb, 0xff, 0xbd, 0xff, 0xff, 0xf7, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xb6, 0xff, 0x7f, 0x7e, 0xba,
		 0x7a, 0x7e, 0xe7, 0xfc, 0xed, 0xdd, 0xef, 0xf3, 0xfb, 0xfb, 0xf6, 0xf3, 0x77, 0xff, 0xf7, 0xb5,
		 0x1f, 0xff, 0x3e, 0x3f, 0x3f, 0x3c, 0x3f, 0x7f, 0x5d, 0x3f, 0xee, 0xfb, 0xbf, 0xee, 0xfb, 0xfb,
		 0xf3, 0xe3, 0xeb, 0xe7, 0xe7, 0xc7, 0xff, 0xff, 0xf7, 0xba, 0xbe, 0xfe, 0x3e, 0xbf, 0xfe, 0xfa,
		 0xdd, 0x7d, 0x7d, 0x7d, 0xaf, 0xfb, 0xda, 0xfb, 0xfb, 0xf6, 0xef, 0xf5, 0xf7, 0xf7, 0xf5, 0xff,
		 0xbc, 0xad, 0xad, 0xbd, 0xbd, 0x7d, 0x7b, 0x7b, 0xfb, 0xdb, 0xfb, 0xaf, 0xff, 0xff, 0xff, 0xff,
		 0xfd, 0xff, 0xff, 0xff, 0xff, 0xbd, 0xff, 0xfa, 0xfb, 0xeb, 0xfb, 0xbb, 0x7b, 0x37, 0xf7, 0x77,
		 0x7f, 0x7f, 0xef, 0xeb, 0xef, 0xf3, 0xeb, 0xff, 0xd7, 0xd7, 0xe7, 0xd7, 0xd7, 0xf3, 0x3e, 0x3e,
		 0x3e, 0x2e, 0x3f, 0x7e, 0x7c, 0x7d, 0x7f, 0xfd, 0xfd, 0xcf, 0xe7, 0xea, 0xe9, 0xfb, 0xe3, 0xc7,
		 0xc7, 0xc7, 0xfb, 0xff, 0xeb, 0xee, 0xd6, 0xf6, 0xb6, 0xb7, 0xf6, 0x6c, 0x6d, 0x6f, 0xfd, 0xfd,
		 0xef, 0xf7, 0xcb, 0xfb, 0xe3, 0xa7, 0xf7, 0xdf, 0x9f, 0xd7, 0x93, 0xf7, 0x7e, 0xbf, 0xbf, 0x7f,
		 0xfe, 0xfe, 0xff, 0xfd, 0xfb, 0xfd, 0xff, 0xef, 0xff, 0xef, 0xef, 0xff, 0xfe, 0xde, 0xf7, 0xf5,
		 0xfb, 0xdf, 0xf7, 0x7e, 0xbf, 0xaf, 0xff, 0x7f, 0x6f, 0x7f, 0x7e, 0xfe, 0xdf, 0x7f, 0xef, 0xb2,
		 0xb3, 0xf3, 0xf7, 0xbb, 0xcb, 0xf7, 0xf7, 0xdf, 0xff, 0xfb, 0xb6, 0xba, 0x3f, 0x9f, 0xfe, 0x3f,
		 0x7d, 0x7e, 0xff, 0x5f, 0x78, 0xee, 0xcb, 0xf7, 0x7b, 0xcb, 0xfb, 0xa7, 0xd7, 0xed, 0xff, 0xcf,
		 0xf7, 0xbe, 0xfb, 0xff, 0xff, 0xbf, 0x7b, 0xfe, 0xff, 0x3a, 0xfe, 0xfe, 0xef, 0xb7, 0xbf, 0xfb,
		 0xff, 0xff, 0x77, 0xf7, 0x77, 0xe7, 0xe7, 0xff, 0x7e, 0x7f, 0xbe, 0x32, 0xaf, 0x7a, 0x7f, 0x7f,
		 0x6f, 0xce, 0xdc, 0xef, 0xfb, 0xeb, 0xef, 0xf3, 0xf3, 0xe7, 0xff, 0x2e, 0xe7, 0xcd, 0xff, 0xbe,
		 0x3f, 0xbe, 0xbf, 0x3e, 0x5f, 0x6e, 0xff, 0xfe, 0x7d, 0xfe, 0xaf, 0xfb, 0xf3, 0xf3, 0xfb, 0xeb,
		 0xf7, 0xe7, 0xf7, 0xff, 0xe7, 0xff, 0xba, 0x3e, 0x7f, 0xff, 0xfe, 0x7e, 0xd9, 0x7d, 0x7d, 0x5e,
		 0x75, 0xef, 0xfb, 0xfa, 0xfa, 0xfb, 0xf7, 0xef, 0x37, 0xb6, 0xb7, 0xf7, 0xf7, 0xbc, 0xad, 0xbd,
		 0xbd, 0xbd, 0x7d, 0x5b, 0xfb, 0x7b, 0xfb, 0xfb, 0xae, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xfd, 0xff, 0xff, 0xff, 0x9a, 0xfb, 0x9b, 0xbb, 0xbb, 0x5b, 0x77, 0x77, 0xbf, 0x76, 0x7f, 0xef,
		 0xff, 0xef, 0xeb, 0xfb, 0xdb, 0xff, 0xd7, 0xd7, 0x57, 0xd3, 0xe7, 0xbe, 0x3f, 0x3e, 0xbe, 0x37,
		 0x7e, 0x5c, 0x7d, 0xf9, 0x7f, 0xf8, 0xcf, 0xfb, 0xe9, 0xe3, 0xfb, 0xe3, 0xc6, 0xc7, 0xcf, 0xff,
		 0xe7, 0xff, 0x3a, 0xb7, 0xb6, 0x26, 0xb7, 0xf6, 0x6c, 0xed, 0xfe, 0x5f, 0x7a, 0xef, 0xe2, 0xc3,
		 0xe7, 0xe1, 0xe5, 0x97, 0xdf, 0xf6, 0xdf, 0x87, 0xf5, 0xfe, 0xbe, 0xff, 0xfe, 0xfe, 0xfe, 0xff,
		 0x7d, 0x7f, 0x7e, 0xfa, 0xef, 0xef, 0xfe, 0xff, 0xef, 0xff, 0xff, 0xf7, 0xed, 0xc7, 0x87, 0xff,
		 0xbe, 0xfe, 0x7e, 0xbf, 0x7f, 0x7e, 0x7f, 0xfe, 0x7e, 0x7a, 0xfc, 0xef, 0xfb, 0xfb, 0xfb, 0xbb,
		 0xbb, 0xea, 0xd3, 0xf7, 0xe7, 0xc7, 0xef, 0x74, 0xff, 0x7f, 0xbf, 0xbf, 0x77, 0xff, 0xff, 0x7f,
		 0xde, 0xff, 0xef, 0xf7, 0xeb, 0x33, 0xf5, 0xbf, 0xef, 0xd7, 0x7f, 0x67, 0xdf, 0xff, 0x7e, 0xbd,
		 0xbf, 0xff, 0xf7, 0xff, 0x7f, 0xff, 0x7a, 0x7a, 0xfb, 0xef, 0x97, 0xbf, 0xff, 0xff, 0xfb, 0xff,
		 0xfb, 0xef, 0xa6, 0xfb, 0xff, 0x7e, 0xb7, 0xfe, 0x7e, 0x3a, 0xfe, 0x6c, 0xf5, 0xfe, 0xfd, 0xdd,
		 0xef, 0xd5, 0xf3, 0xab, 0xfb, 0xeb, 0x77, 0xe7, 0xaf, 0x9d, 0xbf, 0xff, 0x7c, 0x3f, 0x17, 0x2f,
		 0xac, 0x7f, 0x18, 0xfa, 0xff, 0xed, 0xfb, 0xae, 0xf7, 0xea, 0xf7, 0xf3, 0xf3, 0xe7, 0xf7, 0xff,
		 0xff, 0xff, 0xf7, 0xfa, 0x9e, 0x7a, 0xbf, 0xfe, 0x7e, 0x7e, 0xfd, 0x79, 0x3d, 0x7d, 0x6f, 0xfb,
		 0xfb, 0xfb, 0xf9, 0xd5, 0xb7, 0xef, 0xf7, 0xf7, 0xf7, 0xff, 0xfc, 0xad, 0xbd, 0xbd, 0xbd, 0x7d,
		 0x7b, 0x7b, 0xfb, 0xfb, 0xfb, 0xee, 0xff, 0xff, 0xfe, 0xff, 0xfc, 0xfd, 0xfb, 0xff, 0xfc, 0xbb,
		 0xf7, 0xba, 0xff, 0x7b, 0xbb, 0xbb, 0xfb, 0x37, 0x77, 0x7f, 0x3f, 0x7f, 0x8f, 0xee, 0xf7, 0xef,
		 0x77, 0xd9, 0xdd, 0xe7, 0xdf, 0xd7, 0xd5, 0xef, 0x7e, 0x2f, 0x3e, 0x3c, 0x3e, 0x7e, 0x7c, 0xf8,
		 0xff, 0xff, 0xfd, 0xef, 0xf7, 0xeb, 0xea, 0xfb, 0xe3, 0xd7, 0xd7, 0xff, 0xff, 0xff, 0xef, 0x7e,
		 0xff, 0xb6, 0xf7, 0xb6, 0x76, 0xed, 0xef, 0xfa, 0xff, 0xfd, 0xef, 0xf7, 0xf9, 0x73, 0x69, 0x67,
		 0xc7, 0x14, 0xcf, 0xff, 0x9f, 0xf7, 0x6e, 0xbf, 0x6d, 0xbf, 0xfe, 0x7e, 0x7d, 0xdf, 0x7c, 0xfe,
		 0xfb, 0xaf, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xaf, 0xe7, 0xdd, 0xff, 0x7c, 0xbe, 0xff,
		 0xbe, 0x7f, 0xff, 0x7f, 0xff, 0x7d, 0xfe, 0xff, 0x4f, 0xe7, 0xe3, 0xf7, 0xf3, 0xab, 0xd2, 0xe7,
		 0xbf, 0xe5, 0xdf, 0xeb, 0xbe, 0xbf, 0xbf, 0xaf, 0x9e, 0xaf, 0x77, 0x6e, 0xff, 0x5c, 0x79, 0xee,
		 0xeb, 0xf7, 0xf7, 0x8b, 0xe3, 0xf7, 0xe7, 0xef, 0x3f, 0xcd, 0xef, 0xfa, 0xff, 0xff, 0xbf, 0xbf,
		 0x7f, 0xdf, 0xfb, 0x7e, 0x7f, 0xfa, 0xef, 0xbf, 0xff, 0xff, 0x97, 0xbf, 0x7f, 0xff, 0xf7, 0xee,
		 0xe7, 0xff, 0x3e, 0x7f, 0x7a, 0x7f, 0xfe, 0x6f, 0xfd, 0x7f, 0xf7, 0x75, 0xfe, 0xef, 0xf2, 0xea,
		 0xfb, 0xeb, 0xfb, 0x47, 0xbf, 0xef, 0xdf, 0xa7, 0xff, 0x9e, 0x2e, 0x3e, 0xbf, 0x3f, 0x7f, 0x7e,
		 0xfe, 0xfe, 0xef, 0xde, 0xef, 0xfb, 0xf3, 0xf3, 0xfb, 0xfb, 0xf7, 0xe7, 0xf7, 0xff, 0xf3, 0xf7,
		 0x3a, 0x3f, 0xbf, 0x3e, 0xbf, 0xfe, 0x7d, 0x7d, 0x7d, 0xfd, 0x7d, 0xaf, 0xfb, 0xfb, 0xdb, 0xfa,
		 0xfb, 0xee, 0xf7, 0xf7, 0x77, 0xf7, 0xff, 0xbc, 0xbd, 0xad, 0xbd, 0xbd, 0x7d, 0xfb, 0xfb, 0xfb,
		 0x7b, 0xfb, 0xee, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xfe, 0xb9, 0xf7, 0xba, 0xfb,
		 0xb3, 0xbb, 0xfb, 0x7b, 0x77, 0x7f, 0x7f, 0x7f, 0x7f, 0x8f, 0xef, 0xed, 0xf7, 0xeb, 0xcf, 0xf7,
		 0xd7, 0xd7, 0xd7, 0xd5, 0xfd, 0x1e, 0x3e, 0x36, 0x3e, 0x3f, 0x7e, 0x7c, 0x7e, 0xfd, 0xf9, 0xfd,
		 0xef, 0xf3, 0xe9, 0xeb, 0xe3, 0xeb, 0xc7, 0xe7, 0xcf, 0xdf, 0xdf, 0xeb, 0xbe, 0xb6, 0xf6, 0xb6,
		 0xd7, 0x76, 0xed, 0xff, 0xf8, 0x7b, 0xf9, 0xef, 0x66, 0x63, 0xeb, 0xeb, 0xeb, 0xef, 0xdb, 0xf7,
		 0x9f, 0x97, 0xf7, 0x7e, 0xbe, 0x9e, 0xbe, 0xbe, 0xfe, 0xff, 0x7d, 0xff, 0x3f, 0xfb, 0xaf, 0xeb,
		 0xfe, 0xff, 0xea, 0xfe, 0xdf, 0xff, 0x2f, 0x9f, 0x95, 0xff, 0xf2, 0xff, 0xbf, 0xff, 0xbf, 0xdf,
		 0x7c, 0xbe, 0xbe, 0xfd, 0xdf, 0xcf, 0xff, 0xbb, 0xe3, 0xbf, 0xe3, 0xf3, 0xe7, 0xb7, 0xff, 0x7f,
		 0xff, 0x2e, 0xff, 0xbe, 0xff, 0xbc, 0x2f, 0xfe, 0x5d, 0xff, 0x6f, 0xfe, 0x6f, 0xfb, 0x4b, 0xf3,
		 0xeb, 0xb1, 0xf7, 0xbf, 0xef, 0xfe, 0xdf, 0xff, 0xfe, 0xb7, 0x3f, 0xbb, 0x3b, 0xff, 0x7f, 0xfe,
		 0xfa, 0xfa, 0xbf, 0x6f, 0xbb, 0x9f, 0xfb, 0xfd, 0xdb, 0xf5, 0xef, 0x77, 0xef, 0xe7, 0xff, 0x3e,
		 0xbe, 0xbf, 0x7b, 0xae, 0x7b, 0x77, 0x7c, 0xef, 0x7d, 0xbe, 0xef, 0xeb, 0xb3, 0xf3, 0xf3, 0xf3,
		 0xff, 0x67, 0xaf, 0x1f, 0xe7, 0xff, 0xbc, 0x3e, 0x3f, 0x3f, 0x3f, 0x7f, 0xff, 0xe9, 0xfe, 0x7d,
		 0xfc, 0xae, 0xf3, 0xfb, 0xfb, 0xe7, 0xfb, 0xe7, 0xff, 0xf7, 0xfd, 0xe3, 0xf7, 0x7a, 0x9f, 0xee,
		 0xbe, 0xfe, 0xfe, 0x7d, 0x7d, 0xfd, 0x7d, 0x7d, 0xaf, 0xf7, 0xf7, 0xf7, 0xd7, 0xf7, 0xf7, 0xf7,
		 0xf3, 0xf7, 0xef, 0xf7, 0xbe, 0xbd, 0xbd, 0xbd, 0xbd, 0x7d, 0xfb, 0xfb, 0xdb, 0x7b, 0xff, 0xaf,
		 0xff, 0xfe, 0xfd, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xbb, 0xbb, 0xab, 0xbb,
		 0xfb, 0x76, 0x5f, 0x7f, 0x3f, 0x77, 0xaf, 0xeb, 0xff, 0xef, 0xfb, 0xef, 0xdf, 0xd7, 0xd7, 0xdf,
		 0x76, 0xf7, 0x3e, 0x3e, 0x3e, 0x3e, 0x3f, 0x7e, 0xfd, 0x79, 0xfd, 0xff, 0xdd, 0xcf, 0xe3, 0xe2,
		 0xeb, 0xf2, 0xea, 0xc7, 0xfd, 0xef, 0xff, 0xff, 0xef, 0xae, 0x96, 0xf6, 0x76, 0xf7, 0x76, 0x6c,
		 0xfa, 0xfc, 0x9f, 0xf9, 0xef, 0xe5, 0xe7, 0xab, 0xe7, 0xeb, 0x55, 0xc7, 0xf5, 0x5f, 0xdf, 0xf3,
		 0xfe, 0xff, 0xbf, 0xfe, 0xbe, 0x7e, 0x7d, 0x7c, 0xbf, 0xf8, 0xfd, 0xef, 0xfe, 0xef, 0xfd, 0xff,
		 0xff, 0xe7, 0xa7, 0xef, 0x6b, 0xbd, 0xff, 0x7e, 0x7d, 0x9d, 0xbf, 0xbf, 0x7f, 0xfe, 0x9f, 0xfe,
		 0x7f, 0xff, 0xef, 0xab, 0xf9, 0xf3, 0xf9, 0xf3, 0xf3, 0xdb, 0xf7, 0xff, 0x77, 0xff, 0xfa, 0xbf,
		 0x9f, 0x7f, 0xbf, 0x17, 0x7f, 0x5e, 0xbe, 0xd5, 0xff, 0xaf, 0xff, 0xe3, 0xe3, 0xfa, 0xe3, 0xe7,
		 0xc6, 0xc7, 0xbe, 0xdf, 0xff, 0xbe, 0x37, 0x3f, 0xbf, 0x3f, 0x7f, 0x6e, 0x7e, 0xfb, 0xfb, 0xfe,
		 0xef, 0x9b, 0xbb, 0xdb, 0xb9, 0x9b, 0xf7, 0x67, 0xf7, 0x7f, 0xef, 0xff, 0xb6, 0xbe, 0xb7, 0xbe,
		 0xb7, 0x7f, 0x7f, 0x7d, 0xff, 0xed, 0xfd, 0xef, 0xfb, 0xf3, 0xb3, 0xfb, 0xf3, 0xe7, 0xe7, 0xb7,
		 0x9e, 0xff, 0xff, 0x3c, 0x37, 0x3e, 0xb4, 0x2f, 0x7f, 0x7e, 0x78, 0x7e, 0xfe, 0xff, 0xae, 0xe3,
		 0xfb, 0xfb, 0xf7, 0xfb, 0xf7, 0xe7, 0xe7, 0xe7, 0xdf, 0xf7, 0xda, 0x3e, 0x3f, 0xff, 0xbe, 0xfe,
		 0xfd, 0x5d, 0xf5, 0x5d, 0x7d, 0xef, 0xfb, 0xfb, 0xfb, 0xfb, 0xb7, 0xaf, 0xf7, 0xf7, 0xf7, 0xf7,
		 0xf7, 0xbc, 0xbd, 0xbd, 0xbd, 0xbd, 0x7d, 0x7b, 0xff, 0x7b, 0xfb, 0xfb, 0xef, 0xff, 0xff, 0xff,
		 0xff, 0xdf, 0xff, 0xfe, 0xff, 0xff, 0xbf, 0xf7, 0xfa, 0xbb, 0xbb, 0xbb, 0xbb, 0x7b, 0xb7, 0x7f,
		 0x5f, 0x3f, 0x6f, 0x8f, 0xff, 0xeb, 0xeb, 0xfb, 0xeb, 0xdf, 0xe7, 0xd7, 0xd7, 0xd7, 0xfd, 0xfe,
		 0x3f, 0x3e, 0xbe, 0x3f, 0x7e, 0xfc, 0x7f, 0xfe, 0xff, 0xff, 0xef, 0xfd, 0xeb, 0xeb, 0xeb, 0xeb,
		 0xd5, 0xdf, 0xe7, 0xdf, 0xff, 0xef, 0xfe, 0xb5, 0xb6, 0x36, 0xf7, 0xf6, 0xed, 0x7b, 0xff, 0xbb,
		 0xfb, 0xef, 0xef, 0xf1, 0xf1, 0xe3, 0xe9, 0xd7, 0xdf, 0xd7, 0x9f, 0xdf, 0xf7, 0xfe, 0xbe, 0xbf,
		 0xff, 0xbe, 0x7f, 0xfd, 0x7f, 0xfd, 0xff, 0xfc, 0xaf, 0xcf, 0xff, 0xff, 0xef, 0xff, 0xff, 0x9f,
		 0xf7, 0xbf, 0xad, 0xff, 0xfa, 0xfe, 0xff, 0xbf, 0xbf, 0x7d, 0xff, 0x3b, 0x5e, 0xff, 0xff, 0xcf,
		 0xff, 0xfb, 0xfb, 0xfb, 0xb3, 0xc2, 0xdf, 0xe7, 0xff, 0xff, 0xff, 0xbe, 0x3c, 0x3f, 0xbf, 0xbe,
		 0x3f, 0xfd, 0xfe, 0x7c, 0x7e, 0xfc, 0xef, 0xe3, 0xf3, 0xf3, 0xc3, 0xf7, 0x8f, 0xf7, 0x97, 0xc7,
		 0x87, 0xff, 0x1e, 0x7f, 0x7f, 0x3f, 0xff, 0xff, 0x7e, 0x7e, 0xff, 0x6e, 0xfe, 0xef, 0xfb, 0xfb,
		 0xfb, 0xfb, 0xff, 0xf7, 0xe7, 0xef, 0xff, 0xe6, 0xff, 0xbe, 0xbb, 0xbe, 0xbe, 0x7f, 0x7a, 0xfc,
		 0x7e, 0x36, 0x76, 0xfc, 0xef, 0xf3, 0xe7, 0xf7, 0xf3, 0xfb, 0xe7, 0xf7, 0xe7, 0xf7, 0xc7, 0xff,
		 0x3c, 0x3f, 0x3e, 0x3c, 0x3f, 0x7c, 0x78, 0x7e, 0x7e, 0x7e, 0xfc, 0xae, 0xfb, 0xf3, 0xf3, 0xfb,
		 0xf3, 0xe7, 0xe7, 0xe3, 0xe7, 0xe7, 0xf7, 0xba, 0x3e, 0x3f, 0xbf, 0xbe, 0xfe, 0x7d, 0x7f, 0x7e,
		 0x7f, 0x7d, 0xef, 0xf7, 0xfb, 0xfb, 0xfb, 0xfb, 0xf7, 0xd7, 0x77, 0xd7, 0xef, 0xff, 0xbe, 0xbd,
		 0xbd, 0xbd, 0xbd, 0x7d, 0xfb, 0xfd, 0xff, 0xfd, 0xff, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xbb, 0xfb, 0xfb, 0xbb, 0x7b, 0x77, 0x77, 0x27, 0xf7, 0x76,
		 0xaf, 0xeb, 0xeb, 0xeb, 0xff, 0xf3, 0xd7, 0x77, 0x63, 0x77, 0x57, 0xf7, 0x3e, 0x3e, 0x3e, 0x3e,
		 0x3e, 0x7e, 0x7d, 0x7e, 0x3e, 0x3e, 0xfc, 0xcf, 0xeb, 0xe3, 0xe3, 0xe3, 0xe3, 0xc7, 0xe7, 0xf7,
		 0xc7, 0xe7, 0xef, 0xfe, 0xb6, 0xb6, 0x36, 0x74, 0x76, 0x6c, 0x7f, 0x7e, 0xff, 0xfd, 0xef, 0xeb,
		 0xc7, 0xc7, 0xf3, 0xfb, 0xf7, 0xcf, 0x87, 0xc7, 0xff, 0xf7, 0xbe, 0xff, 0xff, 0x3f, 0xbf, 0xff,
		 0x7f, 0x7e, 0xfe, 0xfd, 0xff, 0xef, 0xef, 0xef, 0xef, 0xd3, 0xf7, 0xf7, 0xc7, 0xc7, 0xef, 0xef,
		 0xff, 0xbc, 0x7d, 0x7f, 0x3f, 0x3f, 0x7f, 0x7f, 0x7b, 0x7d, 0x3e, 0xff, 0xef, 0xf3, 0xfb, 0xfb,
		 0xf3, 0xf3, 0xfb, 0xef, 0xef, 0xe7, 0xe7, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xbf,
		 0xff, 0xff, 0xff, 0xef, 0xdf, 0xdf, 0xdf, 0xdf, 0xdf, 0xb7, 0xbf, 0xbf, 0xbf, 0xbf, 0xff, 0xbc,
		 0xbd, 0xbd, 0xbd, 0xbd, 0x7d, 0x7b, 0x3b, 0x7b, 0x7b, 0xfb, 0xef, 0xf7, 0xf5, 0xf5, 0xf5, 0xf5,
		 0xad, 0xeb, 0xef, 0xeb, 0xeb, 0xff, 0xfe, 0x7f, 0x7f, 0x7f, 0x7f, 0xff, 0xff, 0xfc, 0xfe, 0xfe,
		 0xfd, 0xef, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xef, 0xef, 0xef, 0xef, 0xfd, 0xfe, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;