# define BYTESinMAP	2778

/* info : mdf_lfg2.rbt */

/* 8 bit Grau - Modus	*/

# include "\pc\app\xload\lcaload.h"

LCAdata mfp_G8 =
{
	3030,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xa0, 0x36, 0xf3, 0xec, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xdf, 0xbf, 0xff, 0xff,
		 0xef, 0xfe, 0xff, 0xf7, 0xfe, 0xfe, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xde, 0xfe, 0xfe, 0xfe,
		 0xfe, 0xfe, 0xfd, 0xfd, 0xfd, 0xfd, 0xfd, 0xcf, 0xdf, 0x7f, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xbc, 0x9f, 0xff, 0x9f, 0xbd, 0x77, 0xef, 0xff, 0x3f, 0xff, 0xff, 0xef, 0x7b,
		 0xff, 0xff, 0xfb, 0xfd, 0xff, 0xff, 0xff, 0xbd, 0xbd, 0xff, 0xfe, 0xfe, 0xde, 0xfe, 0xfc, 0xfe,
		 0xfd, 0xed, 0x7d, 0xed, 0xfd, 0xcf, 0xef, 0xe9, 0xef, 0xef, 0xef, 0xdf, 0xcf, 0x9b, 0xdf, 0xdf,
		 0xff, 0x7e, 0x7d, 0xed, 0x7d, 0xff, 0x7d, 0xff, 0xfb, 0xfb, 0xfc, 0xfb, 0x4f, 0xff, 0xdb, 0xff,
		 0xfd, 0xdb, 0xf7, 0xff, 0x7f, 0x7f, 0xbf, 0xff, 0x9e, 0xbf, 0x2f, 0xbf, 0xbf, 0x7f, 0x7f, 0x77,
		 0x7e, 0x7f, 0xf7, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xfb, 0xfc, 0xde, 0xef, 0x7e,
		 0x7f, 0x7f, 0x5f, 0x5f, 0xff, 0xfa, 0xfe, 0xbe, 0xbe, 0xfe, 0xef, 0xdf, 0xfd, 0xdf, 0xff, 0xdf,
		 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xb4, 0xbe, 0xef, 0xbf, 0x7e, 0x3e, 0xfe, 0x7f, 0xdf, 0x7d,
		 0xfe, 0xef, 0xcb, 0xfa, 0xef, 0xcb, 0xdb, 0xf7, 0xff, 0xfd, 0x9f, 0x6d, 0xff, 0xfe, 0xff, 0xbf,
		 0x3f, 0xb7, 0xf7, 0xff, 0xff, 0x7b, 0xf6, 0x6a, 0xef, 0xff, 0xbf, 0xfb, 0xf3, 0xd7, 0xf7, 0xff,
		 0xf7, 0xe3, 0xe7, 0xff, 0x3e, 0x7b, 0xbf, 0x3f, 0xfb, 0x7a, 0xaf, 0xff, 0x6f, 0x5e, 0xbc, 0xef,
		 0xb3, 0xf7, 0xfb, 0xf3, 0xff, 0xff, 0x7f, 0x3f, 0x67, 0x8f, 0xff, 0xbe, 0x3e, 0x3e, 0xbe, 0x3f,
		 0x5d, 0xff, 0xdf, 0xfd, 0xff, 0xfe, 0xee, 0xfb, 0xf3, 0xf3, 0xfb, 0xf3, 0xe4, 0xff, 0xff, 0xff,
		 0xe5, 0xf5, 0xba, 0xfe, 0xfe, 0xbe, 0xde, 0xfe, 0xfd, 0xff, 0x7d, 0xdd, 0x7e, 0xaf, 0xfb, 0xf7,
		 0xfa, 0xfa, 0xf7, 0x17, 0xff, 0xf3, 0xf3, 0xf7, 0xfd, 0xbc, 0xbd, 0xbd, 0xfd, 0xbd, 0xfd, 0xf9,
		 0xff, 0xfb, 0x7b, 0xbb, 0xaf, 0x7f, 0xff, 0xff, 0xdf, 0xfe, 0xfe, 0xfd, 0xff, 0xfb, 0xff, 0xf7,
		 0xfa, 0x9b, 0xbb, 0xbb, 0xbb, 0x7b, 0xf7, 0x7f, 0x7f, 0x7f, 0x7f, 0xef, 0x5f, 0x7f, 0xea, 0xeb,
		 0xeb, 0xdf, 0xff, 0xdf, 0xd7, 0xd6, 0xff, 0xfe, 0x3f, 0xbc, 0xaf, 0xbf, 0x7c, 0xfc, 0xbf, 0xf9,
		 0x7d, 0xff, 0xcf, 0xff, 0xea, 0xfb, 0xfb, 0xeb, 0xd7, 0xfb, 0xff, 0xdf, 0xcf, 0xef, 0xfe, 0xf5,
		 0x37, 0xf7, 0xb7, 0xf7, 0xed, 0xff, 0xff, 0xf8, 0xfa, 0xef, 0xef, 0xe7, 0xe3, 0xef, 0xeb, 0xd5,
		 0xff, 0xff, 0xc7, 0xf3, 0xf7, 0xfe, 0x7e, 0xff, 0xde, 0xfe, 0x5f, 0xfd, 0x7f, 0x7f, 0x9c, 0xff,
		 0xef, 0xcf, 0xef, 0xef, 0xee, 0xef, 0xff, 0xff, 0xff, 0xa7, 0xbb, 0xff, 0xfe, 0xbf, 0xad, 0xbf,
		 0x3e, 0x7d, 0xff, 0xff, 0xff, 0xff, 0xff, 0x6f, 0xff, 0xa3, 0xeb, 0xbb, 0xb2, 0xe3, 0xbf, 0xf7,
		 0x5d, 0xff, 0xfd, 0x36, 0x7e, 0xff, 0x9f, 0x6f, 0x2f, 0x7d, 0x7f, 0xdf, 0xff, 0xbe, 0xef, 0xc3,
		 0xeb, 0xff, 0xff, 0xbb, 0x96, 0x47, 0x57, 0xff, 0xf7, 0xff, 0x56, 0xff, 0xfb, 0xfb, 0xff, 0x7f,
		 0x7f, 0xff, 0xff, 0x6f, 0xff, 0xef, 0x3b, 0xff, 0xbf, 0xfb, 0xff, 0x6f, 0x7f, 0xff, 0xbb, 0xeb,
		 0xfb, 0xb6, 0xbf, 0xea, 0x0f, 0xbe, 0xee, 0xf4, 0x7f, 0xa4, 0xef, 0xbe, 0xef, 0xf7, 0xf7, 0xff,
		 0xeb, 0xf7, 0x57, 0xf7, 0xe3, 0xff, 0xf7, 0xff, 0x3c, 0x3f, 0xef, 0xbf, 0x2e, 0x75, 0x7f, 0x7e,
		 0xf9, 0x5d, 0xef, 0xae, 0xf3, 0xe3, 0xff, 0xf3, 0xf3, 0xf7, 0xf7, 0xf7, 0xff, 0xef, 0xf7, 0xfa,
		 0xfe, 0xfe, 0xff, 0xbe, 0x7e, 0x7e, 0x7d, 0x7d, 0x3d, 0x75, 0xef, 0xfb, 0xf7, 0xff, 0xfb, 0xd6,
		 0xf7, 0xb7, 0xf7, 0xf7, 0xf7, 0xfd, 0xbe, 0xbd, 0xfd, 0xbf, 0xbd, 0x7d, 0x7b, 0x7b, 0xfb, 0xfb,
		 0xfb, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xfb, 0xf7, 0x9a, 0x9b, 0xfb,
		 0xef, 0xbb, 0x7b, 0x77, 0x77, 0x77, 0x3f, 0x7f, 0xef, 0xeb, 0xfb, 0x7f, 0xf3, 0xfd, 0xdf, 0x9f,
		 0xff, 0xd7, 0xd7, 0xfb, 0xbe, 0xbe, 0xfe, 0xbf, 0x3e, 0xfe, 0x78, 0xfc, 0xfe, 0x7d, 0xff, 0xcf,
		 0xe3, 0xe3, 0xff, 0xe3, 0xeb, 0xd7, 0xd7, 0xd7, 0xd3, 0xd7, 0xeb, 0xbe, 0xa6, 0xf6, 0xbf, 0xf6,
		 0x76, 0xae, 0x6d, 0x6e, 0x79, 0xfb, 0xef, 0xee, 0xef, 0xff, 0xff, 0xeb, 0xc7, 0xd7, 0xc7, 0xff,
		 0xf7, 0xf5, 0xfe, 0xfe, 0xfe, 0xfb, 0xbf, 0xfe, 0x7d, 0xfd, 0xfd, 0x7b, 0xff, 0xef, 0xfb, 0xfb,
		 0xbf, 0xfa, 0xfe, 0xdc, 0xff, 0xdd, 0xbd, 0xb3, 0xff, 0x3e, 0x3f, 0xef, 0x2f, 0xaf, 0x7f, 0x77,
		 0x7f, 0xff, 0x7f, 0xff, 0xef, 0xfb, 0xfb, 0xff, 0xeb, 0xb3, 0xeb, 0xc7, 0xef, 0xdf, 0xf7, 0xff,
		 0x36, 0xbf, 0x3b, 0x3e, 0xae, 0x1f, 0x7f, 0x7c, 0xbf, 0x7f, 0xf7, 0xef, 0xe3, 0xf7, 0xc2, 0xd3,
		 0xbf, 0xcf, 0xb7, 0x6f, 0xfe, 0xf6, 0xfd, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xff, 0xff, 0x7a,
		 0x7a, 0x77, 0xef, 0xff, 0xff, 0xff, 0xff, 0xf9, 0xfe, 0xb7, 0xf7, 0xe7, 0xf7, 0xff, 0x6e, 0x76,
		 0x7f, 0x86, 0x3e, 0xfe, 0x74, 0x7f, 0x7f, 0xfe, 0xff, 0xef, 0xfb, 0xbb, 0xf9, 0xfb, 0xbb, 0x77,
		 0xff, 0xaf, 0xa7, 0xff, 0xff, 0x9c, 0x3f, 0xb7, 0xbd, 0xb5, 0x7c, 0x6e, 0xff, 0xfe, 0x6f, 0xfc,
		 0xae, 0xe6, 0xf3, 0xf7, 0xfb, 0xf3, 0xc6, 0xe7, 0xf7, 0xff, 0xe7, 0xf7, 0xfa, 0x3e, 0xff, 0xfe,
		 0xfe, 0xfe, 0x7e, 0x5d, 0x3d, 0xfd, 0x7d, 0xaf, 0xdb, 0xdb, 0xfb, 0xfb, 0xd5, 0xf7, 0xf3, 0x77,
		 0xb7, 0xf5, 0xf3, 0xbe, 0xbd, 0xbd, 0x9d, 0xbd, 0x6d, 0x7b, 0xfb, 0xfb, 0xfb, 0xfb, 0xaf, 0xff,
		 0xfd, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xfb, 0xfb, 0xf3, 0x7a, 0xf3, 0x7b, 0xbb, 0xbb, 0xfb,
		 0x77, 0x77, 0x7f, 0x3f, 0x7f, 0xaf, 0xeb, 0xef, 0xeb, 0xeb, 0xfb, 0xd7, 0xdf, 0xd7, 0xd7, 0xdf,
		 0xf7, 0xbe, 0x3e, 0xbe, 0x3c, 0x2f, 0x7e, 0x7d, 0x7d, 0xff, 0x7f, 0xfe, 0xcf, 0xfb, 0xeb, 0xeb,
		 0xf3, 0xe3, 0xc7, 0xc7, 0xcf, 0xff, 0xe7, 0xef, 0xbe, 0xb6, 0xb6, 0xf7, 0xb7, 0x76, 0x6c, 0xed,
		 0x7e, 0xfe, 0xdb, 0xef, 0xea, 0xe3, 0xcb, 0xaf, 0xe7, 0xd7, 0xdf, 0xf7, 0xc3, 0xdf, 0xf7, 0x3e,
		 0x9a, 0x7e, 0xbf, 0xfc, 0xde, 0xfd, 0x79, 0x7f, 0x3c, 0xfd, 0xef, 0xf3, 0xff, 0xeb, 0xba, 0xfe,
		 0xf6, 0xf7, 0xef, 0xe7, 0xb5, 0xff, 0x3e, 0xff, 0xaf, 0xaf, 0x6f, 0x7f, 0x7f, 0xfe, 0xfe, 0x7f,
		 0xfd, 0x6f, 0x33, 0xeb, 0xf7, 0xfb, 0xeb, 0xfb, 0xf7, 0xf7, 0xfe, 0xf7, 0xff, 0xf2, 0xbf, 0xff,
		 0xdf, 0xbf, 0x2f, 0x7f, 0xfc, 0x5c, 0xbe, 0xde, 0xaf, 0xfb, 0xff, 0xbf, 0xff, 0xff, 0xff, 0xb7,
		 0x97, 0x67, 0xf6, 0xff, 0xae, 0xff, 0xff, 0xbf, 0xdf, 0xff, 0xff, 0xff, 0x7f, 0x7e, 0x7f, 0xef,
		 0xff, 0xfb, 0xff, 0xbb, 0xfb, 0xf7, 0xf7, 0xff, 0xa7, 0xef, 0xff, 0xbe, 0x3a, 0xfb, 0xbf, 0x3f,
		 0x7b, 0x7e, 0x7f, 0xde, 0xff, 0xff, 0xef, 0xf3, 0xfb, 0xff, 0xbb, 0xfb, 0x76, 0xff, 0x67, 0xff,
		 0xff, 0xff, 0x3e, 0xbf, 0xff, 0x3f, 0xbe, 0x7e, 0x2f, 0x6f, 0xff, 0x7d, 0xfe, 0xee, 0xeb, 0xf3,
		 0xff, 0xf3, 0xf3, 0xe7, 0xe7, 0xef, 0xff, 0xe7, 0xf3, 0xba, 0xee, 0xfe, 0xbf, 0xee, 0xfe, 0x79,
		 0xfd, 0x7d, 0x7d, 0x7d, 0xaf, 0xf7, 0xf7, 0xbf, 0xfb, 0xf7, 0xad, 0xf7, 0xf7, 0xf7, 0xef, 0xff,
		 0xbc, 0xbd, 0xfd, 0xaf, 0xad, 0x7d, 0x7b, 0x7b, 0x7b, 0x5b, 0xfb, 0xaf, 0xff, 0x7f, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xaa, 0xbb, 0xeb, 0xaf, 0xbb, 0x7b, 0x77, 0x77, 0x77,
		 0x77, 0x77, 0xef, 0xdf, 0xfb, 0xff, 0xef, 0xfb, 0xf7, 0xdf, 0xf7, 0x66, 0xdf, 0xf7, 0x3e, 0x3e,
		 0xfe, 0x7f, 0x3c, 0x7e, 0x7c, 0x7d, 0x7f, 0x7f, 0xfe, 0xcf, 0xe3, 0xe3, 0xff, 0xf9, 0xe3, 0xc7,
		 0xc7, 0xf7, 0xcd, 0xc3, 0xeb, 0xae, 0xb6, 0xf6, 0x3f, 0xb7, 0x76, 0x6d, 0x4d, 0xee, 0xfe, 0xef,
		 0xef, 0xe7, 0xe7, 0xff, 0xc3, 0xa4, 0xcf, 0xdf, 0x47, 0xf3, 0x9f, 0xf5, 0xfe, 0xde, 0xfe, 0xfd,
		 0xff, 0xde, 0xfd, 0xb9, 0x7f, 0x7b, 0xff, 0xef, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xfe, 0xf7, 0x7f,
		 0xef, 0xd7, 0xf7, 0x7e, 0x7f, 0xef, 0xaf, 0x7f, 0xff, 0x3e, 0x7e, 0xdb, 0x7e, 0xff, 0xee, 0xbb,
		 0xbb, 0xff, 0xf7, 0xbb, 0xd7, 0xf7, 0xf7, 0xb7, 0xd3, 0xeb, 0x7e, 0x7f, 0x3f, 0x9f, 0xfc, 0x5a,
		 0x5f, 0xdf, 0xbe, 0xbf, 0x3d, 0xee, 0xfb, 0xfb, 0xf3, 0x2b, 0xca, 0xff, 0xf7, 0x7f, 0xff, 0xb6,
		 0xf7, 0xee, 0xff, 0x3f, 0xfd, 0xbf, 0xff, 0xff, 0xf7, 0xef, 0xfb, 0xff, 0xef, 0xff, 0xff, 0x93,
		 0xff, 0xff, 0xb7, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xae, 0xb6, 0xfa, 0x76, 0xbf, 0x4a, 0xf6, 0xee,
		 0x77, 0xe5, 0xfd, 0xef, 0xf7, 0xb7, 0xdf, 0xf7, 0xf3, 0xf6, 0xef, 0xff, 0xbf, 0xff, 0xff, 0x3e,
		 0x3f, 0xfc, 0x3f, 0x3e, 0x7f, 0x6f, 0xfc, 0xff, 0x79, 0xef, 0xaf, 0xe3, 0xf3, 0xef, 0xf3, 0xeb,
		 0xe7, 0xe7, 0xff, 0xff, 0xdf, 0xff, 0x9a, 0x9e, 0xbe, 0x3e, 0xbf, 0xfe, 0xfd, 0x7d, 0x7d, 0x5d,
		 0x7d, 0xef, 0xfb, 0xfb, 0xfa, 0xdb, 0xf7, 0xef, 0x77, 0xf3, 0xf3, 0x77, 0xf6, 0x9c, 0xbd, 0xfd,
		 0xad, 0xad, 0x7d, 0x3b, 0xfb, 0xfb, 0xdb, 0xfb, 0xae, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xfa, 0xfb, 0xbb, 0xff, 0xbb, 0x7b, 0x77, 0x77, 0x3f, 0x7f, 0x7f, 0xef,
		 0xf7, 0xf7, 0xeb, 0xeb, 0xff, 0xf7, 0xef, 0xd7, 0xd5, 0xd3, 0xe5, 0x3e, 0x3e, 0xfe, 0x7f, 0x3f,
		 0x7e, 0xfc, 0xf8, 0xfe, 0xdd, 0xfd, 0xcf, 0xeb, 0xea, 0xff, 0xf3, 0xe3, 0xc6, 0xe7, 0xdf, 0xdd,
		 0xff, 0xff, 0xea, 0xf6, 0xf6, 0x1f, 0xb7, 0x76, 0x6d, 0xef, 0xfb, 0xfd, 0x79, 0xef, 0x69, 0xeb,
		 0xff, 0xe7, 0xe7, 0xcf, 0x9f, 0xdf, 0x9d, 0xfb, 0xf7, 0xbe, 0xbe, 0x3e, 0xff, 0xfe, 0xde, 0xfd,
		 0xff, 0xfd, 0xf7, 0xff, 0xef, 0xff, 0xff, 0xf3, 0xfb, 0xfe, 0xff, 0xd7, 0xbf, 0xdf, 0xbf, 0xf5,
		 0xb6, 0xbf, 0x3f, 0xbf, 0x7f, 0xff, 0x5e, 0xbe, 0xdf, 0x57, 0xff, 0xef, 0xe3, 0xe3, 0xb3, 0xfe,
		 0xbb, 0x73, 0xcf, 0xcf, 0xdf, 0xd6, 0xf7, 0x7c, 0xff, 0xbe, 0x7f, 0xbf, 0x3f, 0x7f, 0xbf, 0x7f,
		 0xbf, 0x36, 0xef, 0x7f, 0xcb, 0x63, 0xf7, 0xff, 0xef, 0xef, 0x7d, 0x6f, 0xcd, 0xef, 0xfe, 0xbf,
		 0xbf, 0xff, 0xff, 0xff, 0xf7, 0x7e, 0xfe, 0xfe, 0xfa, 0xef, 0xf7, 0xff, 0xff, 0xbf, 0x79, 0xff,
		 0x37, 0xe7, 0xb7, 0xef, 0xff, 0x2e, 0xbe, 0xea, 0xbf, 0x3e, 0xff, 0x7c, 0x7c, 0x3e, 0xdf, 0xde,
		 0xef, 0xfb, 0xf3, 0xfb, 0xeb, 0xbb, 0xf5, 0xe7, 0x67, 0xec, 0xaf, 0xff, 0xbc, 0x3c, 0x3f, 0x3f,
		 0xaf, 0x76, 0x6e, 0xf8, 0xff, 0xee, 0xfe, 0xae, 0xf3, 0xeb, 0xfa, 0xf3, 0xf3, 0xc7, 0xe7, 0xff,
		 0xf7, 0xef, 0xf7, 0xba, 0xbe, 0xbe, 0xbe, 0xfe, 0x7c, 0x7d, 0x7d, 0x7d, 0x7d, 0x5d, 0x6f, 0xd7,
		 0xf7, 0xdb, 0xfb, 0xd7, 0xb7, 0xef, 0x37, 0xd7, 0xf7, 0xff, 0xbc, 0xbd, 0xbd, 0xbd, 0xbd, 0x7d,
		 0x7b, 0x3b, 0xfb, 0xf9, 0xfb, 0xee, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xfd, 0xff, 0xfd, 0xff, 0xff,
		 0xf7, 0xba, 0xbb, 0xbb, 0xfb, 0xbb, 0xfb, 0x77, 0xf7, 0x76, 0x77, 0x7f, 0x8f, 0xfb, 0xff, 0xed,
		 0x73, 0xd9, 0xed, 0xf3, 0x57, 0x53, 0xd7, 0xef, 0x3e, 0x3f, 0x3e, 0x6e, 0x3f, 0x7e, 0x7c, 0xfc,
		 0x7c, 0xff, 0xfe, 0xef, 0xf3, 0xe3, 0xeb, 0xe1, 0xe3, 0xd7, 0xc7, 0xd7, 0xcf, 0xeb, 0xef, 0x7e,
		 0xb7, 0xf6, 0xb6, 0xb7, 0xf6, 0xed, 0x6c, 0xdd, 0xfe, 0xfe, 0xef, 0xc7, 0x65, 0x69, 0x2f, 0x67,
		 0xd7, 0xd6, 0x8e, 0xf3, 0xef, 0xf7, 0xfe, 0xff, 0xbe, 0xfe, 0xfe, 0x7e, 0xfd, 0xfd, 0x7e, 0xfb,
		 0xfe, 0xaf, 0xee, 0xff, 0xff, 0xfa, 0xfe, 0xff, 0xfd, 0xd7, 0xef, 0x6f, 0xff, 0xbc, 0x7f, 0xbf,
		 0x3f, 0x7f, 0x7f, 0x7f, 0x7f, 0xff, 0xbe, 0xfe, 0xcf, 0xfb, 0xfb, 0xe3, 0xf7, 0xeb, 0xc3, 0xef,
		 0xef, 0xb7, 0xef, 0xea, 0xb0, 0xeb, 0x6e, 0xb7, 0xbf, 0xaf, 0xfe, 0xfd, 0xff, 0xff, 0x3f, 0xae,
		 0xeb, 0xcb, 0xfb, 0xfb, 0xff, 0xd7, 0x97, 0xff, 0xdf, 0x77, 0xef, 0xfe, 0xbf, 0xff, 0xfb, 0xff,
		 0xff, 0x7f, 0xff, 0xfa, 0x7b, 0xd7, 0xef, 0xdf, 0xff, 0xbd, 0xff, 0xfb, 0xfd, 0xff, 0xf7, 0xff,
		 0xf7, 0xff, 0x3e, 0xbf, 0x3e, 0x2f, 0x2e, 0x7b, 0x7f, 0x5d, 0xff, 0x7d, 0xfd, 0xef, 0xb2, 0xf3,
		 0xb3, 0xf3, 0xfb, 0x6f, 0xe7, 0xaf, 0xbf, 0xdf, 0xfd, 0x9e, 0x36, 0xbf, 0xb6, 0xbf, 0x7f, 0x6c,
		 0xfe, 0xff, 0xf9, 0xff, 0xef, 0xfb, 0xeb, 0xf7, 0xeb, 0xf3, 0xe7, 0xd7, 0xff, 0xff, 0xff, 0xf7,
		 0x3a, 0xbf, 0xee, 0xfe, 0xfe, 0xfe, 0x7d, 0x7d, 0x7d, 0x3d, 0x7d, 0xaf, 0xfb, 0xd7, 0xfb, 0xfa,
		 0xf7, 0xef, 0xb7, 0xf5, 0xf7, 0xf7, 0xfd, 0xbc, 0xbd, 0x9d, 0xbd, 0xbd, 0x7d, 0x7b, 0x7b, 0xfb,
		 0xfb, 0xfb, 0xee, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xbb,
		 0xbb, 0xbb, 0xbb, 0x7b, 0x77, 0x77, 0x7f, 0x7f, 0x7f, 0x8f, 0xef, 0xff, 0xf3, 0xfb, 0xdb, 0xf7,
		 0xdf, 0xd7, 0xd3, 0xd7, 0xff, 0x3e, 0x2f, 0xbe, 0x77, 0x3e, 0x7e, 0x7c, 0xf8, 0xf9, 0xfd, 0xd9,
		 0xef, 0xf3, 0xe3, 0xf9, 0xfb, 0xe3, 0xd7, 0xd7, 0xff, 0xdf, 0xdf, 0xef, 0x9e, 0xb7, 0xb6, 0x37,
		 0xb6, 0xf6, 0x6d, 0xef, 0xba, 0xfd, 0xfb, 0xef, 0xeb, 0xb7, 0xe6, 0xe3, 0xe7, 0xf7, 0xe5, 0xd7,
		 0x97, 0xdf, 0xf5, 0xbe, 0xdc, 0x7f, 0xfe, 0xde, 0x7e, 0x7b, 0x7f, 0xfd, 0xff, 0xfd, 0xef, 0xeb,
		 0xed, 0xeb, 0xef, 0xff, 0xdf, 0xff, 0xaf, 0xdf, 0xbb, 0xff, 0xfe, 0x7f, 0xbb, 0xbf, 0x7e, 0x6f,
		 0xff, 0xfd, 0xff, 0xff, 0xfd, 0xef, 0xef, 0xfb, 0xfb, 0xb7, 0xbb, 0xe3, 0xf7, 0xfb, 0x5f, 0x7d,
		 0xff, 0x2e, 0xaf, 0x3f, 0x6f, 0xfc, 0x3e, 0xbf, 0x7f, 0xfe, 0xbf, 0xdf, 0xef, 0xfb, 0xf7, 0xe3,
		 0x63, 0x4b, 0xef, 0xff, 0xe6, 0xdf, 0xff, 0xff, 0xfe, 0xff, 0x7b, 0xbf, 0x9f, 0xdb, 0x76, 0x7a,
		 0xfe, 0xef, 0xf3, 0xef, 0xbb, 0xfd, 0xbb, 0xbf, 0xff, 0xf7, 0xe7, 0x27, 0xff, 0xff, 0xff, 0x36,
		 0x7e, 0xba, 0xff, 0xbe, 0x7e, 0x74, 0xfe, 0xfd, 0x5f, 0xff, 0xef, 0xeb, 0xeb, 0xf7, 0xaa, 0xb3,
		 0xe7, 0xa7, 0xdf, 0xff, 0xb7, 0xff, 0xbc, 0x3e, 0x3e, 0x3f, 0x3e, 0x7c, 0xfe, 0xff, 0xff, 0xff,
		 0xfd, 0xae, 0xf3, 0xf3, 0xf3, 0xf7, 0xfb, 0xc7, 0xff, 0xff, 0xff, 0xff, 0xf7, 0x7a, 0x3f, 0xff,
		 0x3e, 0xbf, 0x7e, 0x7d, 0x7d, 0x7d, 0xfd, 0x7d, 0xaf, 0xf7, 0xfb, 0xfb, 0xf9, 0xf7, 0xef, 0xf7,
		 0xf7, 0xf7, 0xef, 0xf7, 0xbe, 0x9d, 0xbd, 0xbd, 0xbd, 0x7d, 0xfb, 0xfb, 0xfb, 0x7b, 0xff, 0xaf,
		 0xff, 0xdd, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xfb, 0xfb, 0xfb, 0xbb,
		 0x7b, 0x77, 0x7f, 0x7f, 0x7f, 0x7f, 0xaf, 0xea, 0xed, 0xeb, 0xeb, 0xff, 0xd7, 0xd7, 0xd7, 0xd7,
		 0xd7, 0xf5, 0x3e, 0x3e, 0xbe, 0x3e, 0x3f, 0x6e, 0xfc, 0xff, 0xff, 0xff, 0xfc, 0xcf, 0xe3, 0xeb,
		 0xe3, 0xe3, 0xe3, 0xc7, 0xff, 0xff, 0xff, 0xf5, 0xef, 0xbe, 0xb6, 0x96, 0xb6, 0xb7, 0xf6, 0x6c,
		 0xfe, 0xfb, 0x7a, 0xfc, 0xef, 0xe7, 0xe1, 0xef, 0xeb, 0xe7, 0xd7, 0xc7, 0xff, 0x4f, 0x87, 0xf7,
		 0xfe, 0xbe, 0xfe, 0xfe, 0xfe, 0xfc, 0x7d, 0x7e, 0xfe, 0xfc, 0xfe, 0xef, 0xff, 0xff, 0xfb, 0xff,
		 0xfe, 0xff, 0xc7, 0xa7, 0xad, 0xd7, 0xff, 0x7e, 0xff, 0x3f, 0x7f, 0x7f, 0x7f, 0xff, 0x7b, 0xfe,
		 0x7f, 0xfc, 0xef, 0xfb, 0xbb, 0xfb, 0xf7, 0xfb, 0xeb, 0xff, 0xe7, 0xff, 0xe7, 0xff, 0x3a, 0xac,
		 0x7f, 0x3f, 0xaf, 0x3f, 0x7f, 0x5e, 0x78, 0x74, 0xfe, 0xaf, 0xe3, 0xff, 0xfb, 0xf3, 0xf3, 0xe7,
		 0xe6, 0xe7, 0xa7, 0xf7, 0xff, 0x7e, 0xff, 0xff, 0x7f, 0x3f, 0x7b, 0xfe, 0x7f, 0x6e, 0x7f, 0x76,
		 0xef, 0xfb, 0xd9, 0xff, 0xdb, 0xf9, 0xf5, 0xff, 0xe7, 0xa7, 0xef, 0xff, 0xb6, 0x1b, 0xbe, 0xaa,
		 0xbf, 0x7f, 0xf7, 0x67, 0x5e, 0xad, 0xfe, 0xef, 0xf6, 0xfb, 0xf7, 0xf7, 0xf3, 0xe7, 0xff, 0xe7,
		 0x57, 0xe6, 0xfe, 0x3c, 0xbf, 0x2c, 0x3f, 0x3e, 0x7f, 0x7e, 0x7e, 0x6e, 0x7d, 0xdf, 0xae, 0xf3,
		 0xf3, 0xe3, 0xf3, 0xfb, 0xf7, 0xe7, 0xe7, 0xf7, 0xe3, 0xf7, 0xfa, 0xfe, 0xbe, 0x3e, 0xff, 0xfe,
		 0x7d, 0x7d, 0x7f, 0x7d, 0x7d, 0xef, 0xfb, 0xd7, 0xfb, 0xdb, 0xd7, 0xef, 0xf7, 0xd7, 0xef, 0xff,
		 0xf7, 0xbc, 0xbd, 0xbd, 0x9d, 0xbd, 0x7d, 0xfb, 0xfb, 0xfd, 0x5f, 0xff, 0xef, 0xff, 0xff, 0xdf,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0xfc, 0xf7, 0xba, 0xbb, 0x7b, 0xbb, 0xbb, 0x7b, 0x77, 0x7f,
		 0xd7, 0xfe, 0x6e, 0x8f, 0xeb, 0xfb, 0xeb, 0xeb, 0xef, 0xdf, 0xd7, 0x77, 0xd7, 0xf7, 0xff, 0xae,
		 0x3e, 0x3e, 0x3e, 0x3e, 0x7e, 0x7c, 0x7e, 0x7e, 0x7d, 0xfe, 0xef, 0xe3, 0xe3, 0xe3, 0xe3, 0xeb,
		 0xd7, 0xe7, 0xe7, 0xf7, 0xe7, 0xef, 0xbe, 0xb6, 0x36, 0xb6, 0xf6, 0xf6, 0xed, 0x7b, 0x7f, 0x7d,
		 0xdf, 0xef, 0xff, 0xe7, 0xe3, 0xe7, 0xeb, 0xd5, 0xdf, 0xd7, 0xf7, 0xef, 0xf7, 0xfe, 0xff, 0xbf,
		 0xfe, 0xbe, 0x7e, 0xfd, 0xfd, 0x7f, 0xfe, 0xfe, 0xaf, 0xfb, 0xef, 0xf7, 0xff, 0xff, 0xff, 0xbf,
		 0xdf, 0xf7, 0xe7, 0xff, 0x3a, 0x7f, 0x7d, 0x7f, 0xbf, 0x7f, 0x7f, 0xfe, 0x7b, 0x7f, 0xff, 0xcf,
		 0xbb, 0xaa, 0xfa, 0xfb, 0xe3, 0xe3, 0xe7, 0xdf, 0xe6, 0xe5, 0xff, 0xbe, 0xff, 0xbe, 0x3e, 0xbf,
		 0x3f, 0x6f, 0xff, 0xf8, 0x79, 0xfe, 0xef, 0xf7, 0xcb, 0xc7, 0xf3, 0xe7, 0xcf, 0xef, 0xcf, 0xdf,
		 0xe5, 0xff, 0xde, 0xbf, 0x7f, 0x3f, 0x7d, 0xff, 0xfe, 0xfb, 0xfe, 0xfe, 0xbb, 0x6f, 0xff, 0xff,
		 0xfb, 0xf3, 0xfb, 0xf7, 0xff, 0xaf, 0xaf, 0xff, 0xff, 0x7e, 0xba, 0x3e, 0x3e, 0x3e, 0x7f, 0xfc,
		 0xff, 0xfe, 0x7f, 0xec, 0xef, 0xeb, 0xf3, 0xf3, 0xc3, 0xf3, 0xe7, 0xbf, 0xef, 0xff, 0x83, 0xff,
		 0x3c, 0x3e, 0x3c, 0x3c, 0x3f, 0x7e, 0xf8, 0xfe, 0xfe, 0x7d, 0xfc, 0xae, 0xf3, 0xfb, 0xf3, 0xf3,
		 0xf3, 0xe7, 0xf7, 0xeb, 0xfb, 0xe7, 0xf7, 0xba, 0xbe, 0xfe, 0xfe, 0xff, 0xfe, 0x7d, 0x7d, 0x7d,
		 0x7d, 0x7d, 0xef, 0xfb, 0xfb, 0xfb, 0xff, 0xfb, 0xf7, 0xf7, 0x57, 0xf7, 0xf7, 0xff, 0xbe, 0xbd,
		 0xbd, 0xbd, 0xbd, 0x7d, 0x7b, 0xfb, 0xfd, 0x7b, 0xfb, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd,
		 0xfb, 0xbf, 0xff, 0xbf, 0xf7, 0xba, 0xbb, 0xbb, 0xbb, 0xbb, 0x73, 0x77, 0x3f, 0x77, 0x7f, 0x7f,
		 0xaf, 0xf3, 0xef, 0xeb, 0xeb, 0xeb, 0xd7, 0xdf, 0x57, 0xd7, 0xdf, 0xff, 0x3e, 0x3e, 0xbe, 0x3e,
		 0xbe, 0x7e, 0xfd, 0xf8, 0xfe, 0xff, 0xff, 0xcf, 0xe3, 0xe3, 0xe3, 0xe3, 0xe3, 0xc7, 0xdf, 0xef,
		 0xff, 0xff, 0xef, 0x7e, 0x36, 0x36, 0x36, 0x36, 0x76, 0xec, 0xfa, 0xfe, 0xfb, 0xfb, 0xef, 0xcb,
		 0xf3, 0xfb, 0xf3, 0xfb, 0xf7, 0xef, 0xef, 0x9f, 0xdf, 0xf7, 0xbe, 0xbf, 0xff, 0xbf, 0xff, 0xff,
		 0xff, 0xfe, 0xfe, 0xfe, 0xfe, 0xef, 0xe7, 0xf7, 0xfb, 0xf7, 0xfb, 0xf7, 0x8f, 0xef, 0xaf, 0x8f,
		 0xff, 0x3c, 0x7f, 0xbf, 0x7f, 0xbf, 0x7f, 0xff, 0xff, 0xfe, 0xff, 0xf9, 0xef, 0xf3, 0xfb, 0xff,
		 0xfb, 0xff, 0xfb, 0xcf, 0xef, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0x3f, 0xfd, 0xbf,
		 0xff, 0xff, 0xff, 0xef, 0xdf, 0xdf, 0xdf, 0xdf, 0xdf, 0xb7, 0xbf, 0xbf, 0xbf, 0xbf, 0xff, 0xbc,
		 0xbd, 0xbd, 0xbd, 0xbd, 0x7d, 0x7b, 0x3b, 0x7b, 0x7b, 0xfb, 0xef, 0xf7, 0xf5, 0xf5, 0xf5, 0xf5,
		 0xad, 0xeb, 0xef, 0xeb, 0xeb, 0xff, 0xfe, 0x7f, 0x7f, 0x7f, 0x7f, 0xff, 0xff, 0xfc, 0xfe, 0xfe,
		 0xfd, 0xef, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xef, 0xef, 0xef, 0xef, 0xff, 0xfe, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;