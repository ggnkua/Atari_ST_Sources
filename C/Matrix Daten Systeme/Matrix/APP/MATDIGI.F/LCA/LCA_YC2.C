# define BYTESinMAP	1853

/* info : mdf90510.rbt */

# include "\pc\app\xload\lcaload.h"

LCAdata lca_YC =
{
	3020,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xc0, 0x79, 0xf2, 0xec, 0xff, 0xef, 0xdf, 0xff, 0xff, 0xff, 0xdf, 0xff, 0x77, 0xff,
		 0xff, 0xff, 0xff, 0x7f, 0xff, 0x9f, 0xff, 0xbf, 0xbf, 0xbf, 0xb7, 0xbf, 0xbb, 0xbf, 0xbf, 0xbf,
		 0xff, 0xf9, 0xeb, 0xff, 0xff, 0xfb, 0xfb, 0xff, 0xff, 0xfb, 0xcf, 0xfb, 0xfb, 0x7b, 0xf9, 0xf9,
		 0x7b, 0x7d, 0xff, 0x7e, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xcf, 0xff, 0x7f, 0xfa, 0xfb, 0xfb, 0x5a,
		 0xea, 0xfb, 0xcb, 0xfb, 0xfb, 0xfb, 0x9f, 0xdf, 0x9f, 0xdf, 0xdf, 0xdf, 0x97, 0xdb, 0xd7, 0xff,
		 0x7e, 0x7d, 0x7d, 0x7f, 0x3d, 0x7f, 0x7d, 0xde, 0xfd, 0xa7, 0x7f, 0xff, 0xff, 0xfc, 0xfd, 0xdf,
		 0xdf, 0x7f, 0xbf, 0xef, 0xef, 0xef, 0xef, 0xef, 0xef, 0xef, 0xef, 0xfe, 0xfd, 0xff, 0xff, 0xff,
		 0xbf, 0xfd, 0xff, 0xfd, 0xff, 0xee, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xe7, 0xf7, 0x7f, 0xff,
		 0xff, 0xff, 0xee, 0xdf, 0xef, 0xff, 0xff, 0xff, 0xc3, 0xff, 0xfa, 0xf3, 0xf1, 0xbf, 0xfc, 0xfe,
		 0xf1, 0xdf, 0xff, 0xa5, 0x5d, 0xd7, 0xdd, 0xc7, 0xee, 0xe4, 0xff, 0xfe, 0xbd, 0xd9, 0xbf, 0xbd,
		 0xbd, 0x5d, 0x3d, 0xb5, 0xd7, 0xde, 0xd8, 0xff, 0xdb, 0xf9, 0xfb, 0xed, 0xe9, 0xbf, 0x9f, 0xaf,
		 0x8f, 0xff, 0x9f, 0xdd, 0xee, 0x8f, 0xff, 0x7d, 0x79, 0x7a, 0x7c, 0x5b, 0x3a, 0xfb, 0x7a, 0xda,
		 0xef, 0x7b, 0xeb, 0x73, 0x7b, 0xdf, 0x7b, 0xf7, 0xf3, 0x77, 0xbf, 0x1f, 0x9f, 0xff, 0xff, 0xdf,
		 0xdf, 0x17, 0xdf, 0xeb, 0xf2, 0xba, 0x7b, 0xba, 0xfb, 0xba, 0xfa, 0xfa, 0x5e, 0xf7, 0xf7, 0x6f,
		 0xef, 0xf7, 0xf5, 0xb7, 0xf7, 0xff, 0xec, 0xed, 0xbd, 0xbd, 0xbd, 0xfd, 0xfd, 0xbd, 0xdd, 0xd7,
		 0xff, 0xff, 0xfe, 0xfe, 0xff, 0xff, 0xff, 0xff, 0x3d, 0xee, 0xef, 0xef, 0xe4, 0xef, 0xef, 0xef,
		 0xef, 0xeb, 0x7d, 0x7d, 0x7d, 0xef, 0x7d, 0x79, 0x3d, 0x7d, 0xfd, 0xcf, 0xc4, 0xcb, 0xe3, 0xcf,
		 0xe7, 0xeb, 0xcb, 0xf3, 0x7f, 0xde, 0x17, 0x5f, 0xdf, 0x5f, 0xdf, 0x3f, 0xbf, 0xaf, 0x7b, 0xfe,
		 0xfc, 0xd2, 0xf6, 0xf2, 0xfa, 0x7d, 0xf4, 0xdf, 0xed, 0xd6, 0x8f, 0x9f, 0xc7, 0x8a, 0xf7, 0xc6,
		 0xfe, 0xfe, 0x1d, 0xdf, 0x7f, 0x1f, 0x5c, 0xbf, 0x2f, 0xfe, 0xf7, 0xff, 0xfc, 0x6e, 0xed, 0xcc,
		 0x7d, 0xfb, 0xe9, 0xbf, 0xff, 0x6f, 0xee, 0x8b, 0xff, 0xbf, 0xdb, 0xdf, 0xff, 0xfd, 0x7f, 0xfc,
		 0x7f, 0xfc, 0xf7, 0x77, 0xff, 0xfe, 0x6f, 0xb7, 0x43, 0xcf, 0x4b, 0xf7, 0xcb, 0xfd, 0xce, 0x7e,
		 0xdf, 0x17, 0x7f, 0x3f, 0x9f, 0x5f, 0xfb, 0xff, 0xff, 0xfb, 0xd7, 0xd4, 0xfc, 0xf7, 0xf6, 0xfe,
		 0xf4, 0xf6, 0xde, 0xbf, 0xa7, 0x6f, 0xe3, 0x6f, 0xb7, 0xe7, 0xfe, 0xff, 0x3e, 0x2e, 0x4e, 0xfe,
		 0x6e, 0xbf, 0x2f, 0xff, 0xfe, 0xf7, 0xe9, 0xe9, 0xf9, 0xe9, 0x6d, 0xfd, 0xe9, 0xef, 0x3e, 0x0f,
		 0xcf, 0x6f, 0x6b, 0xcf, 0xaf, 0xff, 0xff, 0xdf, 0x71, 0x7e, 0xfc, 0xfe, 0xfe, 0x7e, 0xff, 0xff,
		 0x7d, 0xaf, 0xeb, 0xeb, 0xea, 0xe9, 0xcf, 0xf3, 0xeb, 0xeb, 0x7b, 0xde, 0xdf, 0xde, 0xcf, 0xd7,
		 0xbf, 0xdf, 0xd6, 0xf7, 0xfb, 0xf6, 0xf7, 0xf7, 0xf7, 0xf6, 0xf6, 0xf7, 0x76, 0x5f, 0xfd, 0xfb,
		 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xff, 0xf7, 0xb8, 0xbf, 0xbf, 0xbf, 0xbf, 0xbf, 0xbb, 0xbf, 0xbf,
		 0xf7, 0xf5, 0xf5, 0xe5, 0xf4, 0xf7, 0xf7, 0xf5, 0xf7, 0x3f, 0x0f, 0x1f, 0xdb, 0xbf, 0x9f, 0x0f,
		 0xff, 0xff, 0xff, 0x79, 0xfe, 0x7f, 0x7d, 0x7c, 0x7f, 0xfc, 0xff, 0xfd, 0xee, 0xd3, 0xf6, 0xda,
		 0xe7, 0xcb, 0x5b, 0xf3, 0xdf, 0x7f, 0x1f, 0x67, 0x8b, 0xdd, 0x1b, 0x3f, 0x1b, 0x7e, 0xff, 0xdb,
		 0xfa, 0xfd, 0xfc, 0xfd, 0xb8, 0xf3, 0xfc, 0xf1, 0xdf, 0xaf, 0xdf, 0x97, 0xd5, 0xb7, 0xb7, 0xc7,
		 0x9f, 0xff, 0xfe, 0x7f, 0xfc, 0xfb, 0xbf, 0x3f, 0xff, 0xff, 0xdf, 0xf7, 0xff, 0xf7, 0xbf, 0xf1,
		 0xfa, 0xf5, 0xff, 0xf7, 0xbf, 0xce, 0x85, 0x3b, 0x1d, 0x9f, 0xeb, 0xfb, 0xf7, 0xfb, 0xf5, 0x7f,
		 0x70, 0x5d, 0xbd, 0xf8, 0xf6, 0xdf, 0xff, 0xef, 0xd3, 0xff, 0xdf, 0xd9, 0x9b, 0xd7, 0xd3, 0xd3,
		 0x7f, 0xef, 0xfe, 0xff, 0xff, 0xcf, 0xcf, 0x8f, 0x9f, 0xff, 0xfb, 0xff, 0x9b, 0xbd, 0xf8, 0xfd,
		 0x5a, 0xbc, 0x7c, 0xdf, 0xa7, 0xdf, 0x37, 0x97, 0xaf, 0xaf, 0xa7, 0xa7, 0xfb, 0xfe, 0x3f, 0xbf,
		 0x3e, 0xaf, 0x7e, 0xff, 0xf7, 0x7f, 0xf7, 0xf9, 0xf9, 0xf9, 0xf9, 0xfd, 0xf5, 0xff, 0xff, 0xbd,
		 0xb6, 0xdf, 0xab, 0x2f, 0xaf, 0xc7, 0xcf, 0xaf, 0xef, 0x65, 0x7f, 0x5b, 0x7f, 0x7b, 0xfb, 0x3e,
		 0x7f, 0xd7, 0xcf, 0xdb, 0xda, 0xdb, 0xdf, 0xdb, 0xdb, 0xdb, 0xdf, 0x7f, 0xfd, 0xff, 0xef, 0xf7,
		 0xfb, 0xff, 0xef, 0xf7, 0xff, 0xa3, 0xbe, 0xee, 0xfe, 0xfe, 0xfe, 0xbe, 0xfe, 0xfe, 0xde, 0xdf,
		 0xd7, 0xe7, 0xd7, 0xd7, 0xdf, 0xdf, 0xd7, 0xff, 0x7c, 0x3c, 0xbf, 0x3e, 0x1e, 0xff, 0xfc, 0xfc,
		 0xff, 0xe7, 0xf8, 0xf0, 0xf4, 0xf5, 0xf9, 0xfd, 0xfb, 0xff, 0xbb, 0x7b, 0x5f, 0x3d, 0xaf, 0x6f,
		 0x6b, 0x4f, 0xcf, 0xff, 0xfd, 0x7c, 0xf9, 0xf9, 0x78, 0x7d, 0xfd, 0x7c, 0xfc, 0xef, 0xe7, 0xfb,
		 0xfd, 0xbd, 0xef, 0xeb, 0xef, 0xe3, 0x7f, 0x7f, 0x6e, 0xe6, 0x7e, 0x67, 0xfe, 0xf6, 0x9c, 0xff,
		 0xdb, 0xf8, 0xff, 0xfe, 0xea, 0xfe, 0xbf, 0xfb, 0xff, 0xdf, 0xef, 0xf5, 0xf7, 0xfe, 0xf7, 0xdd,
		 0xff, 0xfd, 0xef, 0x2e, 0xbf, 0xbc, 0x5c, 0xfc, 0xde, 0xff, 0x3f, 0x3f, 0xf7, 0xd9, 0xbc, 0x92,
		 0xb5, 0xe7, 0xff, 0xf6, 0xf3, 0xbd, 0xdf, 0xef, 0x67, 0x6f, 0x7f, 0xff, 0xff, 0xff, 0xf7, 0xfd,
		 0x7f, 0xff, 0xfe, 0xff, 0xf3, 0xbf, 0xdf, 0xfe, 0xef, 0xeb, 0xaa, 0xff, 0xe3, 0xef, 0xf3, 0xf3,
		 0xff, 0x7d, 0xff, 0x5f, 0x9f, 0xde, 0xfe, 0x9c, 0x9b, 0xff, 0xfb, 0xfb, 0xf0, 0x7e, 0xdb, 0xfc,
		 0xbb, 0xfc, 0x7c, 0xfc, 0x5f, 0xe6, 0xf7, 0xe7, 0xc7, 0xdd, 0xe7, 0xe7, 0xe7, 0xff, 0x8a, 0x3e,
		 0xbf, 0xbe, 0xfe, 0x3f, 0x1f, 0xbf, 0xbe, 0xf7, 0xfd, 0xfb, 0xed, 0xfc, 0xef, 0xfd, 0xed, 0xfb,
		 0x3d, 0x77, 0x6f, 0x6f, 0x77, 0x67, 0xff, 0xff, 0xf7, 0xdf, 0xb5, 0xdf, 0xbf, 0xbf, 0xff, 0xef,
		 0xef, 0xff, 0xff, 0x8f, 0x7b, 0xbb, 0xfa, 0xf9, 0xf9, 0xbb, 0xbb, 0xb5, 0x7b, 0x57, 0x7b, 0x5f,
		 0x5e, 0x5f, 0x9f, 0x97, 0x4f, 0x9f, 0xf3, 0xfc, 0xf2, 0xfb, 0xf8, 0x70, 0xfe, 0xf0, 0xfc, 0x9f,
		 0xe7, 0xd7, 0xd7, 0xd7, 0xf7, 0xc7, 0xed, 0xc7, 0xff, 0x7a, 0x2d, 0xb5, 0xbc, 0xbe, 0x3d, 0x3b,
		 0xdb, 0xbb, 0xf7, 0xf7, 0xf9, 0xb1, 0xe3, 0xf9, 0xe1, 0xf0, 0xff, 0xbf, 0xef, 0xdb, 0xce, 0x77,
		 0xff, 0xdf, 0xff, 0xff, 0xff, 0xfd, 0x7b, 0x13, 0xd8, 0x5f, 0xfb, 0xff, 0xdd, 0x7f, 0xef, 0xc3,
		 0xef, 0xdb, 0xeb, 0xfb, 0xff, 0xdf, 0xe3, 0x77, 0x1b, 0x7f, 0xbd, 0xff, 0xff, 0xff, 0xbf, 0x9f,
		 0xbf, 0xfb, 0xb0, 0xff, 0xb3, 0x71, 0xfd, 0xfe, 0xff, 0xff, 0xdf, 0x47, 0xff, 0xdf, 0x55, 0xf6,
		 0xef, 0xdf, 0x7f, 0xff, 0x3e, 0xff, 0xaf, 0x3d, 0xbd, 0x7d, 0xff, 0xff, 0xff, 0xf7, 0xf9, 0xff,
		 0xda, 0xf9, 0xeb, 0xfd, 0xdf, 0xff, 0xbf, 0x8f, 0xcf, 0xde, 0x87, 0x8f, 0xe8, 0xcd, 0xf9, 0xff,
		 0x7d, 0x5e, 0x76, 0x6b, 0x7b, 0xd8, 0x7e, 0xfe, 0xff, 0xcf, 0x62, 0xe1, 0xef, 0xea, 0xeb, 0xf7,
		 0xf3, 0xff, 0x77, 0x1d, 0x9f, 0xff, 0x7f, 0xbf, 0xdf, 0x9f, 0xff, 0xd7, 0xeb, 0xfa, 0xb2, 0xfa,
		 0xfa, 0xfa, 0xfa, 0xfe, 0xff, 0x5e, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xd7, 0xff, 0xff, 0xfe,
		 0xbd, 0xfd, 0xfd, 0xad, 0xfd, 0xed, 0xfe, 0x7f, 0xf7, 0x7f, 0xff, 0x7f, 0xff, 0xff, 0xfe, 0x7f,
		 0xff, 0xbd, 0xe2, 0xff, 0xe6, 0xe3, 0xef, 0xef, 0xed, 0xfe, 0xef, 0x71, 0xfd, 0x7f, 0x7d, 0x7d,
		 0x7d, 0x7d, 0xf7, 0x5f, 0xef, 0xf7, 0xf3, 0xc7, 0xef, 0x47, 0xcb, 0xf3, 0xff, 0x7f, 0x6f, 0x9f,
		 0x9f, 0x7f, 0xd7, 0x3f, 0x1f, 0xff, 0xbf, 0xfb, 0x75, 0x94, 0xfc, 0xfa, 0xf6, 0xf5, 0xfd, 0xff,
		 0xdf, 0xdf, 0xe7, 0xcf, 0xcf, 0xcf, 0xf7, 0xc7, 0xff, 0xff, 0x76, 0x3f, 0x1f, 0x3a, 0x7c, 0xbe,
		 0x7d, 0xff, 0xff, 0xd7, 0x67, 0x69, 0x7d, 0xf5, 0x65, 0xcb, 0xf6, 0xff, 0xbf, 0x1f, 0xcf, 0xef,
		 0xee, 0xcf, 0xdb, 0x3f, 0xff, 0xff, 0xf5, 0x7f, 0x7a, 0xfe, 0x7f, 0x7e, 0xfb, 0xcf, 0xdf, 0xaf,
		 0xe7, 0xba, 0xfe, 0xc2, 0xcb, 0xfb, 0xf3, 0xef, 0x7b, 0x9d, 0xbe, 0xff, 0x0d, 0x4f, 0xbf, 0x1f,
		 0x7f, 0xbe, 0xfb, 0xff, 0xf7, 0xff, 0xf5, 0xd6, 0xbe, 0xf6, 0xf7, 0xdf, 0xf7, 0xff, 0xff, 0x3f,
		 0xf7, 0x6d, 0xf7, 0xff, 0xff, 0xbe, 0xb6, 0xc7, 0xbf, 0x3e, 0x3b, 0xbe, 0xff, 0xfe, 0xf7, 0xd9,
		 0xe9, 0xff, 0xe7, 0xe9, 0xf1, 0xcd, 0xef, 0xbf, 0xfb, 0xcf, 0xbf, 0xcb, 0xef, 0xc7, 0xc7, 0x7f,
		 0xfd, 0xdd, 0x7c, 0xff, 0x7f, 0xfe, 0x7f, 0x5e, 0xfe, 0x7f, 0xaf, 0xeb, 0xab, 0xfe, 0xe9, 0xe9,
		 0xeb, 0xeb, 0xe9, 0x7b, 0xdd, 0xd7, 0x7f, 0xdf, 0xdf, 0xd7, 0xd7, 0xdf, 0xfe, 0xf3, 0xf7, 0xf6,
		 0xb2, 0xb7, 0xf7, 0xfe, 0xf7, 0xf7, 0xdd, 0xff, 0xfd, 0xfb, 0xff, 0xbf, 0xff, 0xff, 0xfb, 0xf7,
		 0xba, 0x5f, 0xb3, 0xbb, 0xbf, 0xff, 0xbb, 0xbf, 0xbf, 0xc7, 0xf5, 0xb9, 0xf5, 0xb5, 0xe5, 0xd9,
		 0xf5, 0xf4, 0xbf, 0xef, 0xaf, 0xcf, 0xcf, 0x0f, 0xff, 0xcf, 0xff, 0xff, 0x7d, 0x7c, 0x7d, 0x7e,
		 0x3e, 0xde, 0x7d, 0xfe, 0xbf, 0xee, 0xdc, 0x6b, 0x53, 0xf7, 0xf3, 0xd3, 0xfb, 0xf7, 0x7e, 0x3f,
		 0x5e, 0x9f, 0x77, 0x1d, 0x1f, 0x5e, 0x7f, 0xfd, 0xfb, 0x6d, 0xfa, 0xf7, 0xfe, 0xfa, 0x7c, 0xfa,
		 0xbb, 0x5f, 0x87, 0xf7, 0xbd, 0xff, 0xf5, 0xa3, 0xf3, 0xff, 0xff, 0xf6, 0xbf, 0xef, 0x3f, 0xbc,
		 0xff, 0x1f, 0xdf, 0xfe, 0xd7, 0xa5, 0xfd, 0xdf, 0xf9, 0x7d, 0xff, 0xf9, 0xdf, 0x3f, 0x9e, 0xef,
		 0xeb, 0xef, 0xff, 0x0b, 0x8f, 0xdf, 0xff, 0xf9, 0x7b, 0x7f, 0x3d, 0xfd, 0x7f, 0x4e, 0x58, 0xff,
		 0xef, 0xbb, 0xf7, 0xfb, 0xfb, 0xf7, 0xfb, 0xf3, 0xfb, 0x7f, 0xbf, 0xbd, 0xdc, 0xdd, 0xdb, 0xde,
		 0x9f, 0xad, 0xff, 0xfb, 0xf9, 0xda, 0xfe, 0xfe, 0x9e, 0xfc, 0xfc, 0xbc, 0xdf, 0xc5, 0xd7, 0xf7,
		 0xf7, 0x6f, 0xf7, 0x67, 0x77, 0xff, 0x7c, 0x7e, 0xbe, 0xbf, 0xf7, 0x3f, 0x37, 0x3f, 0x7f, 0xd7,
		 0x7b, 0x7b, 0xfd, 0xfd, 0xff, 0xf9, 0xf9, 0xf9, 0xbd, 0xae, 0xbf, 0xab, 0xa7, 0xaf, 0xef, 0xcf,
		 0xef, 0xef, 0x6d, 0x7f, 0xff, 0xf6, 0xda, 0x5f, 0x59, 0xff, 0x7e, 0xcf, 0xdf, 0xde, 0xda, 0xdb,
		 0xdb, 0xef, 0xff, 0xfb, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xff, 0xf3, 0xf3, 0xdf, 0xeb, 0xfe,
		 0xfe, 0xee, 0xee, 0xfd, 0xee, 0xbe, 0xed, 0x1e, 0xd7, 0xdf, 0xff, 0xff, 0xf7, 0x77, 0xe7, 0x77,
		 0xff, 0x7e, 0x7e, 0x3f, 0x7f, 0x7f, 0x3f, 0xff, 0x1c, 0xff, 0xf7, 0xf2, 0xfb, 0xf1, 0xf5, 0xf5,
		 0xf0, 0xf7, 0xfd, 0xbb, 0x0f, 0x6f, 0x6f, 0x5d, 0xc5, 0xef, 0xff, 0xcf, 0xfb, 0xfd, 0x7c, 0xbd,
		 0x7c, 0x7d, 0x7e, 0xfc, 0xbd, 0xfe, 0xef, 0xe7, 0xe7, 0xef, 0xe7, 0xf7, 0xfb, 0xf2, 0xf7, 0x7f,
		 0xd5, 0x2e, 0x7c, 0x5e, 0xde, 0x5f, 0x5f, 0xdf, 0xff, 0xfb, 0xff, 0xfe, 0xfe, 0xfd, 0xec, 0xf4,
		 0xf0, 0xfe, 0x5f, 0xef, 0xb7, 0xef, 0x77, 0xe6, 0x65, 0xa5, 0xe7, 0xff, 0xfe, 0x3b, 0xbf, 0xaf,
		 0xbe, 0x3c, 0x6f, 0xdf, 0xff, 0xf7, 0xbf, 0xf9, 0xfd, 0xa9, 0x95, 0xf1, 0xfd, 0xdf, 0xbf, 0xff,
		 0xff, 0xee, 0x7f, 0xef, 0x6f, 0x4f, 0xff, 0xfd, 0xfd, 0xbf, 0x7b, 0xff, 0x7b, 0x6f, 0x7b, 0xfa,
		 0xdf, 0xef, 0xff, 0xff, 0xfb, 0xeb, 0xeb, 0xad, 0xe3, 0xef, 0x7f, 0xff, 0xfd, 0xdf, 0x3f, 0x7e,
		 0xff, 0x9a, 0x7e, 0xff, 0xf3, 0xdf, 0xdc, 0xde, 0x78, 0x7f, 0xf8, 0x7a, 0xfb, 0x1d, 0xff, 0xe7,
		 0xf7, 0xf7, 0xf7, 0xc7, 0xc7, 0xff, 0xf7, 0xfa, 0xbf, 0xfe, 0xbe, 0x9e, 0xfc, 0xfa, 0xfe, 0xbf,
		 0xe7, 0xf6, 0xfd, 0xfb, 0xfd, 0xfd, 0xfc, 0xfd, 0xff, 0xbf, 0x2f, 0x6f, 0x6f, 0x6f, 0x7f, 0x6f,
		 0x6f, 0x6f, 0xff, 0xf5, 0xff, 0xbf, 0xff, 0xbf, 0xff, 0xbf, 0xff, 0x7f, 0xaf, 0xbb, 0xf5, 0xfb,
		 0xf9, 0xfb, 0xfb, 0xfb, 0xfb, 0x72, 0x5d, 0x6f, 0x5f, 0xbf, 0x5f, 0x9f, 0x7b, 0x7e, 0xff, 0xdb,
		 0xf1, 0xfe, 0xfc, 0xdf, 0xf2, 0xfd, 0xfc, 0xfd, 0x9d, 0xf7, 0xf7, 0xe7, 0xf7, 0xdf, 0xef, 0xe7,
		 0xef, 0xef, 0xbe, 0xb5, 0xff, 0xff, 0xdd, 0x3d, 0xbd, 0x7d, 0xfd, 0xf7, 0xfb, 0xf5, 0xf7, 0xff,
		 0xfd, 0xe1, 0xf9, 0xe3, 0xbf, 0xdf, 0xaf, 0xbf, 0xff, 0xef, 0xcf, 0xdf, 0xff, 0xff, 0x7d, 0x7b,
		 0xff, 0xff, 0x79, 0x7b, 0x78, 0xf9, 0xf9, 0xcf, 0xfb, 0xfb, 0xf3, 0xfb, 0xfb, 0xf7, 0xe3, 0xe7,
		 0x7f, 0xbf, 0xdf, 0x9b, 0xff, 0xdf, 0x3a, 0x9f, 0xbf, 0xf7, 0xfb, 0xdf, 0xff, 0xdf, 0xff, 0xfa,
		 0xfe, 0xff, 0xff, 0xdf, 0xbf, 0xbf, 0xbf, 0x3f, 0xbf, 0xb7, 0xbf, 0xbf, 0xff, 0xbc, 0xbd, 0xbd,
		 0xbd, 0xbd, 0xbd, 0xbd, 0x3d, 0xed, 0xf7, 0xf3, 0xfa, 0xf2, 0xfa, 0xfa, 0xf8, 0xfa, 0x7a, 0xbe,
		 0x7f, 0x5f, 0x7f, 0xdf, 0xff, 0xff, 0xdf, 0xbf, 0xff, 0xb5, 0xfc, 0xfa, 0xf8, 0x7e, 0x7f, 0xff,
		 0xfe, 0xfe, 0xef, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;