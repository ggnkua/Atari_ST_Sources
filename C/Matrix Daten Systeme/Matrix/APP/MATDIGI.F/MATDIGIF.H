extern TImage ScreenImage ;
