# include <tos.h>

/* DSP XBIOS functions (trap #14) */
#define	Dsp_DoBlock(a,b,c,d)			 xbios(96,a,b,c,d)
#define	Dsp_BlkHandShake(a,b,c,d)		 xbios(97,a,b,c,d)
#define	Dsp_BlkUnpacked(a,b,c,d)		 xbios(98,a,b,c,d)
#define	Dsp_InStream(a,b,c,d)			 xbios(99,a,b,c,d)
#define	Dsp_OutStream(a,b,c,d)			 xbios(100,a,b,c,d)
#define	Dsp_IOStream(a,b,c,d,e,f)		 xbios(101,a,b,c,d,e,f)
#define	Dsp_RemoveInterrupts(a)			 xbios(102,a)
#define	Dsp_GetWordSize()			  xbios(103)
#define	Dsp_Lock()				  xbios(104)
#define	Dsp_Unlock()				 xbios(105)
#define	Dsp_Available(a,b)			 xbios(106,a,b)
#define	Dsp_Reserve(a,b)			 xbios(107,a,b)
#define	Dsp_LoadProg(a,b,c)			 xbios(108,a,b,c)
#define	Dsp_ExecProg(a,b,c)			 xbios(109,a,b,c)
#define	Dsp_ExecBoot(a,b,c)			 xbios(110,a,b,c)
#define	Dsp_LodToBinary(a,b)			(long) xbios(111,a,b)
#define	Dsp_TriggerHC(a)			 xbios(112,a)
#define	Dsp_RequestUniqueAbility()		  xbios(113)
#define	Dsp_GetProgAbility()			  xbios(114)
#define	Dsp_FlushSubroutines()			 xbios(115)
#define	Dsp_LoadSubroutine(a,b,c)		  xbios(116,a,b,c)
#define	Dsp_InqSubrAbility(a)			  xbios(117,a)
#define	Dsp_RunSubroutine(a)			  xbios(118,a)
#define	Dsp_Hf0(a)				  xbios(119,a)
#define	Dsp_Hf1(a)				  xbios(120,a)
#define	Dsp_Hf2()				  xbios(121)
#define	Dsp_Hf3()				  xbios(122)
#define	Dsp_BlkWords(a,b,c,d)			 xbios(123,a,b,c,d)
#define	Dsp_BlkBytes(a,b,c,d)			 xbios(124,a,b,c,d)
#define	Dsp_HStat()				 xbios(125)
#define Dsp_SetVectors(a,b)			 xbios(126,a,b)
#define Dsp_MultBlocks(a,b,c,d)			 xbios(127,a,b,c,d)
