extern int  	Step ;
extern SEQUENCE Sequence ;
extern int 		border_left ;
extern int 		x_page, y_page ;
extern int		vdi_handle ;
extern bool		acc_opened ;

extern void DrawBox ( TRectangle *rect, int color ) ;

extern void mouse_on ( void ) ;
extern void mouse_off ( void ) ;

extern void repeat_pic ( void ) ;
extern void get_pic ( TGrabMode gmode, SPEED_MODE spd ) ;



