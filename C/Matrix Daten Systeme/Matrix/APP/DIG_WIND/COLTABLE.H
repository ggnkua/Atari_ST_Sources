/********************************************************************/
/* 				MatDigi Window Program - Palette Routines			*/
/*																	*/
/*------------------------------------------------------------------*/
/*	Status : 08.03.93												*/
/*																	*/
/*  WA - Matrix Daten Systeme, Talstr. 16, W-7155 Oppenweiler		*/
/*																	*/
/********************************************************************/

void set_phys_to_vdi ( int vdi_handle, int colors, int *phys_to_vdi, int *vdi_to_phys ) ;
