/********************************************************************/
/* 				MatDigi Save A File									*/
/*																	*/
/*------------------------------------------------------------------*/
/*	Status : 19.08.93												*/
/*																	*/
/*  HG - Matrix Daten Systeme, Talstr. 16, W-71570 Oppenweiler		*/
/*																	*/
/********************************************************************/

extern void save_a_file ( int wnum, RECTangle *win, POINT *vid,
						  int vfactor, int *drive ) ;
