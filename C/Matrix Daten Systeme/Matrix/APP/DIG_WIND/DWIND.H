/* Resource Datei Indizes f�r DWINDF */

#define DHELP    0   /* Formular/Dialog */
#define DH_OK    16  /* ICON in Baum DHELP */
#define DHTXT_OK 17  /* STRING in Baum DHELP */
#define BDF_HOK  18  /* BUTTON in Baum DHELP */

#define MD_POPUP 1   /* Formular/Dialog */
#define MD_SPEED 1   /* IBOX in Baum MD_POPUP */
#define PD_GEM   2   /* BUTTON in Baum MD_POPUP */
#define PD_MAXIMUM 3   /* BUTTON in Baum MD_POPUP */
#define MD_GRAB  4   /* IBOX in Baum MD_POPUP */
#define PD_OFF   5   /* BUTTON in Baum MD_POPUP */
#define PD_ON    6   /* BUTTON in Baum MD_POPUP */
#define MD_DISPLAY 7   /* IBOX in Baum MD_POPUP */
#define PD_COLOUR 8   /* BUTTON in Baum MD_POPUP */
#define PD_GREY  9   /* BUTTON in Baum MD_POPUP */
#define PD_DITHER 10  /* BUTTON in Baum MD_POPUP */
#define PD_MONO  11  /* BUTTON in Baum MD_POPUP */
#define MD_SIGNAL 12  /* IBOX in Baum MD_POPUP */
#define PD_AUTOSIGNAL 13  /* BUTTON in Baum MD_POPUP */
#define PD_SVHS  14  /* BUTTON in Baum MD_POPUP */
#define PD_CVBS  15  /* BUTTON in Baum MD_POPUP */
#define PD_BAS   16  /* BUTTON in Baum MD_POPUP */
#define MD_CHANNEL 17  /* IBOX in Baum MD_POPUP */
#define PD_AUTOCHANNEL 18  /* BUTTON in Baum MD_POPUP */
#define PD_CHAN1 19  /* BUTTON in Baum MD_POPUP */
#define PD_CHAN2 20  /* BUTTON in Baum MD_POPUP */
#define PD_CHAN3 21  /* BUTTON in Baum MD_POPUP */
#define MD_FORMAT 22  /* IBOX in Baum MD_POPUP */
#define PD_Z1    23  /* BUTTON in Baum MD_POPUP */
#define PD_Z2    24  /* BUTTON in Baum MD_POPUP */
#define PD_Z4    25  /* BUTTON in Baum MD_POPUP */
#define MD_DIGITISE 28  /* IBOX in Baum MD_POPUP */
#define PD_SINGLE 29  /* BUTTON in Baum MD_POPUP */
#define PD_MULTIPLE 30  /* BUTTON in Baum MD_POPUP */
#define MD_SAVE  31  /* IBOX in Baum MD_POPUP */
#define PD_WINDOW 32  /* BUTTON in Baum MD_POPUP */
#define PD_FULL  33  /* BUTTON in Baum MD_POPUP */

#define MD_PARAM 2   /* Formular/Dialog */
#define BX_PARAM 0   /* BOX in Baum MD_PARAM */
#define TX_DISPLAY 1   /* FBOXTEXT in Baum MD_PARAM */
#define TX_FORMAT 2   /* FBOXTEXT in Baum MD_PARAM */
#define TX_CHANNEL 3   /* FBOXTEXT in Baum MD_PARAM */
#define TX_DIGITISE 4   /* FBOXTEXT in Baum MD_PARAM */
#define BD_INFO  6   /* ICON in Baum MD_PARAM */
#define BDTXT_INFO 7   /* STRING in Baum MD_PARAM */
#define BD_QUIT  9   /* ICON in Baum MD_PARAM */
#define BDTXT_QUIT 10  /* STRING in Baum MD_PARAM */
#define BDF_INFO 11  /* BUTTON in Baum MD_PARAM */
#define BDF_QUIT 12  /* BUTTON in Baum MD_PARAM */
#define BD_SAVE  15  /* ICON in Baum MD_PARAM */
#define BDTXT_SAVE 16  /* STRING in Baum MD_PARAM */
#define BDF_SAVE 17  /* BUTTON in Baum MD_PARAM */
#define TX_GRAB  18  /* FBOXTEXT in Baum MD_PARAM */
#define TX_SPEED 19  /* FBOXTEXT in Baum MD_PARAM */
#define TX_SIGNAL 20  /* FBOXTEXT in Baum MD_PARAM */
#define TX_SAVE  21  /* FBOXTEXT in Baum MD_PARAM */
#define BD_VIDEO 23  /* ICON in Baum MD_PARAM */
#define BDTXT_VIDEO 24  /* STRING in Baum MD_PARAM */
#define BDF_VIDEO 25  /* BUTTON in Baum MD_PARAM */
#define BD_HELP  27  /* ICON in Baum MD_PARAM */
#define BDTXT_HELP 28  /* STRING in Baum MD_PARAM */
#define BD_POK   30  /* ICON in Baum MD_PARAM */
#define BDTXT_POK 31  /* STRING in Baum MD_PARAM */
#define BDF_HELP 32  /* BUTTON in Baum MD_PARAM */
#define BDF_POK  33  /* BUTTON in Baum MD_PARAM */

#define MD_INFO  3   /* Formular/Dialog */
#define ITXT_DATE 7   /* FTEXT in Baum MD_INFO */
#define ITXT_VERSION 8   /* FTEXT in Baum MD_INFO */
#define ITXT_STRAM 9   /* FTEXT in Baum MD_INFO */
#define ITXT_TTRAM 10  /* FTEXT in Baum MD_INFO */
#define ITXT_VIDEO 11  /* FTEXT in Baum MD_INFO */
#define ITXT_CPU 12  /* FTEXT in Baum MD_INFO */
#define I_OK     18  /* ICON in Baum MD_INFO */
#define ITXT_OK  19  /* STRING in Baum MD_INFO */
#define BDF_IOK  20  /* BUTTON in Baum MD_INFO */

#define MD_BORDER 4   /* Formular/Dialog */
#define ED_HEAD  2   /* FTEXT in Baum MD_BORDER */
#define ED_BORDER 3   /* FTEXT in Baum MD_BORDER */
#define B_OK     6   /* ICON in Baum MD_BORDER */
#define BTXT_OK  7   /* STRING in Baum MD_BORDER */
#define BDF_VOK  8   /* BUTTON in Baum MD_BORDER */

#define F_BUTTON 5   /* Formular/Dialog */
#define IC_SMALL 1   /* ICON in Baum F_BUTTON */
#define IC2_SMALL 2   /* ICON in Baum F_BUTTON */
#define IC_LARGE 3   /* ICON in Baum F_BUTTON */
#define IC2_LARGE 4   /* ICON in Baum F_BUTTON */

#define MD_MESG  6   /* Formular/Dialog */
#define MTXT_MESG1 2   /* FTEXT in Baum MD_MESG */
#define MTXT_MESG2 3   /* FTEXT in Baum MD_MESG */

#define AL_MEM   0   /* Alert String */

#define AL_GREY  1   /* Alert String */

#define AL_BPP   2   /* Alert String */

#define AL_SAVE  3   /* Alert String */

#define AL_OVERW 4   /* Alert String */

#define AL_EXT   5   /* Alert String */

#define AL_ERR   6   /* Alert String */

#define AL_NAME  7   /* Alert String */

#define T_NOK    8   /* Freier String */

#define T_UNLK   9   /* Freier String */

#define T_LKC    10  /* Freier String */

#define T_LKBW   11  /* Freier String */

#define T_AUTO   12  /* Freier String */

#define T_SVHS   13  /* Freier String */

#define T_FBAS   14  /* Freier String */

#define T_BAS    15  /* Freier String */

#define T_SAVE   16  /* Freier String */
