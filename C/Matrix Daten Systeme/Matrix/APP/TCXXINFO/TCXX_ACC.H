# define EDITparameter	0
# define SETparameter	1

extern int info_installed ( void ) ;
extern int tcxx_initialised ( void ) ;
