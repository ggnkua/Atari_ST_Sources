/* tc_xbios.h / MATRIX / WA / 4.10.90	*/

extern XBRAstruct xbra_xbios ;
