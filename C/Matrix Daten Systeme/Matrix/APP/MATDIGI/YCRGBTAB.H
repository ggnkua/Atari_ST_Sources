void rgb_init ( int planes ) ;