# define BYTESinMAP	2778

/* info : g:\technik\lccd\lca\test2_xn.rbt */

# include "lcaload.h"

LCAdata lca_data =
{
	3030,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xa0, 0x36, 0xf3, 0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xf7,
		 0xef, 0xf6, 0xf7, 0xf5, 0xf7, 0xf6, 0xef, 0xef, 0xec, 0xed, 0xed, 0xff, 0xee, 0xde, 0xfe, 0xfe,
		 0xfe, 0xfe, 0xbd, 0xf5, 0xfd, 0xdd, 0xff, 0xcf, 0xff, 0xff, 0xff, 0xfd, 0x7f, 0x6f, 0xff, 0xbf,
		 0xef, 0xeb, 0xff, 0xfc, 0xff, 0xdf, 0xff, 0xdf, 0xff, 0xef, 0x3f, 0xff, 0x5f, 0xff, 0xaf, 0xfe,
		 0xdf, 0xdf, 0xfe, 0x7f, 0xff, 0xff, 0xff, 0xfd, 0xf7, 0xff, 0xfa, 0xda, 0xfe, 0xee, 0xfc, 0xfe,
		 0xfd, 0xef, 0xfd, 0xfd, 0xfd, 0xcf, 0xef, 0xeb, 0xed, 0xef, 0xc3, 0xd7, 0xdb, 0xdf, 0xd7, 0xcf,
		 0xff, 0xfe, 0xfb, 0xfd, 0xf9, 0xff, 0xfd, 0xf7, 0x7d, 0xb2, 0xfb, 0xfd, 0x8f, 0xdd, 0xff, 0xff,
		 0x9f, 0xff, 0xff, 0xbf, 0xf7, 0xbf, 0xfb, 0xff, 0x0e, 0x3f, 0x3f, 0x3f, 0x2f, 0x7f, 0x7e, 0x5e,
		 0x76, 0x7e, 0xdd, 0xcf, 0x7f, 0xfe, 0x6d, 0xfe, 0x7f, 0xfd, 0xfe, 0xcd, 0xbf, 0xff, 0xee, 0xfe,
		 0xff, 0x7f, 0xff, 0xef, 0xff, 0xff, 0xbb, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xfe, 0xff,
		 0xbf, 0xff, 0xff, 0xfe, 0xfd, 0xff, 0x3e, 0x3f, 0x7f, 0x3b, 0x2b, 0x2f, 0x5e, 0xfe, 0x7f, 0xfc,
		 0xdf, 0xef, 0x73, 0xf3, 0x7b, 0xf1, 0xf3, 0xc7, 0xd7, 0xff, 0xa7, 0xff, 0xff, 0xb2, 0xff, 0xff,
		 0xbf, 0xbf, 0x5f, 0x7f, 0xff, 0x75, 0xeb, 0xff, 0xef, 0xbb, 0xff, 0xff, 0xfb, 0xd7, 0x6f, 0xf7,
		 0xff, 0x76, 0xff, 0xff, 0x3e, 0x57, 0x6b, 0x3f, 0x17, 0x7b, 0x7e, 0x7f, 0x78, 0xbf, 0xff, 0xef,
		 0xfc, 0xfa, 0xfb, 0xfb, 0xfe, 0xff, 0xf5, 0xe7, 0xb6, 0x7f, 0xff, 0x34, 0x3f, 0xf6, 0x3f, 0x3f,
		 0x7f, 0x7e, 0x7f, 0x7c, 0xfe, 0xff, 0x2e, 0xf3, 0xf3, 0xff, 0xfa, 0xf0, 0xe5, 0xe7, 0xc7, 0xe7,
		 0xfd, 0xf7, 0xfa, 0xbf, 0x3c, 0xff, 0xff, 0x7f, 0x76, 0x7d, 0x5d, 0xf1, 0x7f, 0xaf, 0xeb, 0xfb,
		 0xfa, 0xe9, 0x6b, 0xf7, 0xd3, 0xad, 0xf7, 0xfb, 0xff, 0xfe, 0xfc, 0xdd, 0xed, 0xf4, 0xd4, 0xfb,
		 0x79, 0xdb, 0xfb, 0xff, 0xaf, 0x7f, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xf9, 0xff, 0xff, 0xff, 0xf7,
		 0xba, 0xbb, 0xbb, 0xbb, 0xbb, 0x7b, 0x77, 0x77, 0x77, 0xff, 0x7f, 0xef, 0xff, 0xeb, 0xf3, 0xfe,
		 0xdf, 0xe7, 0xd5, 0x67, 0x97, 0xff, 0xff, 0x3e, 0x3f, 0x7f, 0xbc, 0x3f, 0x7e, 0x78, 0x5e, 0x3e,
		 0xfe, 0xff, 0xcf, 0xf2, 0xf3, 0xfb, 0xe2, 0xf3, 0xfd, 0xd7, 0xe7, 0xe7, 0xff, 0xed, 0xf6, 0xbb,
		 0x8b, 0xbb, 0xeb, 0xfa, 0x77, 0xf7, 0x7f, 0xff, 0xff, 0xef, 0xe3, 0xe5, 0xef, 0x63, 0xe3, 0xc7,
		 0xf7, 0xff, 0xd7, 0xff, 0xff, 0xbe, 0xde, 0xfe, 0xbc, 0x5e, 0xde, 0x7e, 0xff, 0x7f, 0xbd, 0xfb,
		 0xef, 0xfb, 0xfd, 0xfb, 0xfb, 0xba, 0xd5, 0xd7, 0x7d, 0xf3, 0xfb, 0xff, 0x3e, 0x3f, 0xbb, 0x1f,
		 0x3f, 0x7f, 0x79, 0x5f, 0x7e, 0xfc, 0xff, 0xef, 0xf3, 0xf3, 0xe5, 0xf3, 0xe3, 0xcb, 0xe4, 0xe7,
		 0xe3, 0xff, 0xff, 0x4e, 0xd7, 0xfc, 0xef, 0xfb, 0xbf, 0xff, 0x37, 0x2f, 0x7e, 0xfe, 0xef, 0xeb,
		 0x7e, 0xfb, 0xff, 0xbf, 0xf5, 0xff, 0x67, 0xc3, 0xe7, 0xff, 0xfe, 0xed, 0xfd, 0xfd, 0xf9, 0x7d,
		 0xfb, 0x67, 0x72, 0x3b, 0xfb, 0xef, 0xff, 0xff, 0xdf, 0xbf, 0x7f, 0xff, 0x7b, 0x77, 0x76, 0xf7,
		 0xff, 0xfe, 0xeb, 0xf6, 0xeb, 0xdf, 0xfe, 0xf5, 0x3f, 0x7f, 0x7d, 0xbf, 0xef, 0xdf, 0xcf, 0xdf,
		 0xde, 0xdf, 0x17, 0x7e, 0xa7, 0x97, 0xb6, 0xfb, 0xbc, 0xbf, 0xbe, 0xbf, 0x3e, 0xf7, 0xfc, 0x7f,
		 0x6e, 0x7e, 0x9e, 0xaf, 0xf6, 0xff, 0xfe, 0xff, 0xe3, 0xe7, 0xff, 0xf7, 0xe7, 0xe7, 0xf7, 0xfa,
		 0xae, 0x2e, 0xbf, 0xbe, 0xfe, 0xfd, 0xfb, 0x7d, 0xde, 0x7d, 0xaf, 0xbb, 0xfb, 0xfb, 0xdb, 0xdb,
		 0xb7, 0xfb, 0xf7, 0xf5, 0x77, 0xff, 0xbe, 0xbd, 0xad, 0xbd, 0xb5, 0x75, 0xeb, 0x3f, 0x7b, 0x7b,
		 0xfb, 0xae, 0xff, 0xfd, 0xff, 0xfd, 0xfc, 0xff, 0xfb, 0xff, 0xff, 0xfb, 0xf7, 0x58, 0xbf, 0xbf,
		 0xaf, 0xaf, 0x7f, 0xff, 0xbf, 0x7f, 0x7f, 0x7f, 0x6f, 0x6b, 0x6f, 0xef, 0x6f, 0xf3, 0x97, 0xff,
		 0xff, 0xdf, 0xd7, 0xff, 0xfe, 0x3f, 0x7c, 0xdc, 0x7f, 0xfc, 0xfc, 0xff, 0x79, 0x7e, 0xd8, 0xcf,
		 0xe8, 0xee, 0xe9, 0xeb, 0xfb, 0xd7, 0xff, 0xff, 0xe3, 0xe7, 0xed, 0xbe, 0xbd, 0xfd, 0xfd, 0xdd,
		 0xed, 0xf9, 0x9f, 0x7f, 0x7a, 0xbb, 0xef, 0xee, 0xeb, 0xfe, 0xed, 0xef, 0xdc, 0xff, 0xfe, 0xe6,
		 0xcf, 0xff, 0xfe, 0xff, 0xdf, 0xff, 0xff, 0xde, 0xff, 0xff, 0xff, 0xff, 0xf8, 0xef, 0xcb, 0xdf,
		 0xce, 0xcf, 0xde, 0x1f, 0xfb, 0xfd, 0x19, 0xb7, 0xff, 0xbe, 0xbd, 0xfd, 0xff, 0xbc, 0xff, 0xf9,
		 0xef, 0x6f, 0x5f, 0xfe, 0xef, 0xff, 0xa5, 0xff, 0xff, 0xf7, 0xbb, 0xfb, 0xff, 0xef, 0xc7, 0xfb,
		 0x3e, 0xef, 0x36, 0xbf, 0xe7, 0x3f, 0x7e, 0x3f, 0x36, 0xfc, 0x7f, 0xee, 0xf3, 0x8f, 0xa2, 0x79,
		 0xfa, 0xe7, 0xd7, 0xe7, 0xa5, 0xdd, 0xf7, 0xb2, 0xdf, 0x29, 0xff, 0xb9, 0xf5, 0x5f, 0x5a, 0x7a,
		 0xfb, 0xfb, 0xef, 0xf7, 0xff, 0xf3, 0xfd, 0x9f, 0x3f, 0xe7, 0xe7, 0xb7, 0xbf, 0xff, 0x3e, 0xff,
		 0x7e, 0xdf, 0xfb, 0xef, 0x7f, 0xee, 0x3e, 0xdc, 0xfd, 0xef, 0xff, 0xdb, 0xf7, 0x9f, 0xdb, 0xff,
		 0xa7, 0xb7, 0x87, 0xbf, 0xff, 0x3c, 0x97, 0x3d, 0xbf, 0xbf, 0x7f, 0x7e, 0x3f, 0x7c, 0xec, 0xfe,
		 0xae, 0xf3, 0xff, 0xf7, 0xfa, 0xfe, 0xe7, 0xf7, 0xe1, 0xe7, 0xdd, 0xf5, 0xba, 0xff, 0xaa, 0xff,
		 0xfc, 0x7e, 0x5d, 0x7d, 0xf5, 0x7d, 0x7d, 0xaf, 0xeb, 0xf7, 0xeb, 0xf9, 0x39, 0xef, 0xf7, 0xf7,
		 0xf7, 0xf7, 0xfd, 0xfe, 0x9c, 0xfd, 0xbc, 0xa5, 0x75, 0x6b, 0x7b, 0x3b, 0x7b, 0xbb, 0xae, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xf7, 0xb2, 0xab, 0x9f, 0xbb, 0xbf, 0x67,
		 0x77, 0x3f, 0x5f, 0x5f, 0x7f, 0xcf, 0xfb, 0xeb, 0xfb, 0x6f, 0x6e, 0xdf, 0xd6, 0xd6, 0xd7, 0xd7,
		 0xff, 0x3e, 0xfc, 0x3c, 0xbf, 0xbf, 0x7f, 0x7f, 0x7e, 0x7e, 0x7e, 0xfe, 0xcf, 0xe3, 0xeb, 0xeb,
		 0xfb, 0xef, 0xf7, 0xe7, 0xc5, 0xe7, 0xc7, 0xef, 0xfe, 0xfb, 0xbd, 0xfb, 0xfd, 0xfd, 0x6b, 0x7b,
		 0x7a, 0x3a, 0xdb, 0xef, 0xc3, 0xfe, 0xeb, 0x8f, 0xfa, 0xff, 0x53, 0xc7, 0xc3, 0xf7, 0xf7, 0x76,
		 0xfd, 0xfd, 0xde, 0xbf, 0xff, 0x7f, 0xff, 0x7a, 0x7f, 0xde, 0xaf, 0xeb, 0xce, 0xff, 0xce, 0xdf,
		 0xbf, 0x33, 0x97, 0xb7, 0x85, 0xff, 0x3e, 0xef, 0x9e, 0xbe, 0xdf, 0x7f, 0x7f, 0x5a, 0x5a, 0x78,
		 0xfe, 0x2f, 0xd3, 0xff, 0xf7, 0xeb, 0xfa, 0x53, 0xe7, 0xe3, 0xe7, 0xe7, 0xfd, 0xbe, 0x2f, 0xdc,
		 0xff, 0x7f, 0x5f, 0xfe, 0xff, 0xef, 0x6f, 0xfe, 0xef, 0xba, 0xf7, 0xff, 0xff, 0x77, 0xf7, 0xff,
		 0xff, 0xff, 0xc7, 0xff, 0xbe, 0xff, 0xbd, 0x2f, 0x7d, 0x6d, 0xfb, 0x6f, 0xfa, 0x7f, 0x4b, 0xef,
		 0xfb, 0xf7, 0xbb, 0xf3, 0x55, 0xe7, 0xff, 0xe7, 0xff, 0xe7, 0xff, 0xbe, 0x67, 0x96, 0x37, 0x5a,
		 0x77, 0x76, 0x7c, 0xd4, 0x7f, 0xfc, 0xef, 0xfb, 0xdb, 0xfb, 0xc3, 0xd7, 0xb7, 0xe7, 0xa7, 0xfb,
		 0x87, 0xfd, 0xbe, 0x3f, 0xfe, 0x3f, 0x7f, 0x7f, 0x7f, 0x3e, 0xee, 0x6f, 0xfe, 0xae, 0xfb, 0xe3,
		 0xff, 0xf3, 0xf7, 0xe7, 0xc7, 0xc7, 0xfd, 0xe3, 0xf7, 0xfa, 0xae, 0xfe, 0xae, 0xee, 0xfe, 0x7d,
		 0x7d, 0xf9, 0x7f, 0x7d, 0xef, 0xfb, 0xdb, 0xbb, 0xfb, 0xf7, 0xee, 0xf5, 0xf5, 0xff, 0xf7, 0xff,
		 0xbc, 0xff, 0xdd, 0xad, 0xb5, 0x75, 0x6b, 0xfb, 0xfb, 0x7f, 0xfb, 0xaf, 0xff, 0xfd, 0xff, 0xff,
		 0xff, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xf7, 0xea, 0xbb, 0xbf, 0x9f, 0xb7, 0x77, 0xff, 0x77, 0xff,
		 0x5f, 0x4f, 0xcf, 0xbf, 0xeb, 0xef, 0xea, 0xcb, 0xdf, 0xd6, 0xd5, 0xff, 0xd3, 0xf9, 0xfe, 0xbf,
		 0xfe, 0x1f, 0x3f, 0x7f, 0x7e, 0x7e, 0xfe, 0x7f, 0xfe, 0xef, 0xff, 0xe3, 0xff, 0xf3, 0xf3, 0xc7,
		 0xe7, 0xe7, 0xfd, 0xc7, 0xef, 0xfe, 0xbf, 0xae, 0x3d, 0x7d, 0x7d, 0x7b, 0x6e, 0xfe, 0x7f, 0xfa,
		 0xef, 0xff, 0xef, 0xca, 0xe3, 0xa7, 0xd7, 0xe7, 0xc5, 0xff, 0xe7, 0xf7, 0xfe, 0xdf, 0xbf, 0xff,
		 0x7e, 0x6c, 0xff, 0x7f, 0xf4, 0x7f, 0xfe, 0xef, 0xff, 0xef, 0xca, 0xde, 0xd6, 0x95, 0xff, 0xe5,
		 0xff, 0xa7, 0xff, 0xf6, 0x7e, 0xfc, 0x3f, 0x3f, 0x7f, 0x7a, 0xfe, 0xff, 0x7f, 0xff, 0xef, 0xff,
		 0xfb, 0xef, 0xf3, 0xb3, 0xc2, 0xe3, 0xff, 0xfb, 0xe6, 0xfb, 0xfe, 0xaf, 0x3f, 0x7f, 0xff, 0xff,
		 0xfe, 0xf7, 0x2f, 0xdf, 0x7f, 0xee, 0xbf, 0xf3, 0xf3, 0xfb, 0xff, 0xff, 0xfe, 0xff, 0xfb, 0xdf,
		 0xff, 0xfa, 0x9f, 0xfd, 0xa7, 0x3d, 0xf9, 0xff, 0x7f, 0xfc, 0x7f, 0x7f, 0xee, 0xff, 0xdf, 0xff,
		 0xd7, 0xf3, 0xff, 0xff, 0xe7, 0xfe, 0xff, 0xf7, 0xfe, 0xf7, 0xfb, 0x7f, 0x2e, 0xd3, 0xaf, 0x3f,
		 0x7a, 0xce, 0xfd, 0x6f, 0xff, 0xdb, 0xff, 0xc7, 0xd0, 0xfe, 0xff, 0xe6, 0xe7, 0xf7, 0xff, 0xee,
		 0x3f, 0x37, 0xff, 0x3f, 0xff, 0xff, 0xff, 0xdf, 0xff, 0xfe, 0xae, 0xff, 0xfb, 0xf3, 0xff, 0xf3,
		 0xef, 0xfd, 0xff, 0xf7, 0xcf, 0xf7, 0xfa, 0xdb, 0x9e, 0xbe, 0x6e, 0xef, 0xfd, 0x7f, 0xf9, 0x7d,
		 0x7d, 0xef, 0xfd, 0xfb, 0xd7, 0xb6, 0xfb, 0xf7, 0xbf, 0xeb, 0xf7, 0xf7, 0xfb, 0xfc, 0xff, 0xbd,
		 0xbd, 0xbd, 0x7d, 0xfb, 0x7f, 0xfb, 0xfb, 0xfb, 0xae, 0xff, 0xfc, 0x7e, 0xfd, 0xff, 0xbd, 0xfe,
		 0xfb, 0xff, 0xff, 0xf7, 0xfa, 0xbf, 0xbf, 0xbb, 0xfb, 0xfb, 0xf7, 0xff, 0x3b, 0x5f, 0x7f, 0xcf,
		 0xff, 0xef, 0xeb, 0xf7, 0xeb, 0x97, 0xff, 0xd3, 0xdf, 0xd6, 0xff, 0xfe, 0xbf, 0x3e, 0xff, 0xbc,
		 0x7f, 0xfc, 0x7f, 0x76, 0xd9, 0xf8, 0xef, 0xff, 0xe3, 0xf1, 0xff, 0xf9, 0xe7, 0xfb, 0x65, 0xfd,
		 0xcd, 0xed, 0xfa, 0xbf, 0xfe, 0xfb, 0xbb, 0xfb, 0xf5, 0xff, 0x7f, 0xfa, 0xbb, 0xaf, 0xff, 0x4d,
		 0xaf, 0xfe, 0xfb, 0xdf, 0xff, 0xff, 0x87, 0xdf, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xbf, 0xdd, 0xfd,
		 0xff, 0xbb, 0xf7, 0xfb, 0xef, 0xfe, 0xeb, 0xbf, 0xff, 0xeb, 0xfd, 0xfb, 0xff, 0x1f, 0x9f, 0xff,
		 0xfe, 0x3f, 0x2e, 0x3d, 0x9f, 0x5f, 0xfc, 0x4f, 0xbe, 0x9f, 0xf9, 0xcf, 0x7f, 0xfb, 0xf1, 0xb2,
		 0xfb, 0xe3, 0xff, 0xe3, 0xd7, 0xff, 0xff, 0xf2, 0xaf, 0x7f, 0xdc, 0x7f, 0x7f, 0x36, 0xee, 0xdf,
		 0xe5, 0xbe, 0xaf, 0xff, 0xf3, 0xfb, 0x7f, 0xf7, 0xe7, 0xe7, 0xdd, 0x9f, 0x49, 0xff, 0xfc, 0xbf,
		 0xbd, 0xff, 0x3f, 0x6d, 0x6e, 0x7a, 0xba, 0xff, 0xc3, 0x6f, 0xff, 0xff, 0xf7, 0xff, 0x73, 0x67,
		 0x67, 0xe7, 0x7f, 0xff, 0xff, 0xfe, 0xc7, 0x7b, 0xcb, 0x57, 0xf6, 0x7d, 0x7c, 0xf6, 0x9d, 0xdc,
		 0xaf, 0xff, 0xdb, 0x7b, 0xff, 0xc7, 0xdf, 0xa7, 0xa7, 0xdf, 0x95, 0xff, 0xcc, 0x3f, 0xb7, 0xff,
		 0x7e, 0xfe, 0xfd, 0xfe, 0xbf, 0x7d, 0xfc, 0xae, 0xff, 0xfb, 0xf7, 0xff, 0xf7, 0xff, 0xc7, 0xfd,
		 0xf9, 0xef, 0xf7, 0xfa, 0xff, 0xfe, 0xee, 0xff, 0x6e, 0xdd, 0x7d, 0x7d, 0x7d, 0x7d, 0xef, 0xff,
		 0xfa, 0xf7, 0xff, 0xd9, 0xf7, 0xf7, 0xf7, 0xf6, 0xf7, 0xff, 0xfc, 0xff, 0xbd, 0xbf, 0xbd, 0xfd,
		 0xeb, 0xdb, 0xfb, 0xfb, 0xfb, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xfb, 0xfd, 0xff, 0xff,
		 0xf7, 0xfa, 0xbf, 0xa7, 0xbb, 0x7f, 0x7f, 0x7f, 0x7f, 0x5f, 0x7f, 0x5f, 0xcf, 0xff, 0xee, 0xfb,
		 0xeb, 0xef, 0xd7, 0xde, 0xd7, 0xd5, 0x95, 0xfd, 0xfe, 0xbf, 0x3c, 0x7f, 0x67, 0xff, 0x6f, 0xfe,
		 0x7d, 0xff, 0xf8, 0xef, 0xff, 0xe2, 0xe3, 0xeb, 0xf7, 0xff, 0xef, 0xff, 0xff, 0xe7, 0xef, 0xfe,
		 0xbf, 0xff, 0xb5, 0x7d, 0xfd, 0x7b, 0x7e, 0xfc, 0x5b, 0xff, 0xaf, 0xbf, 0xef, 0xcf, 0xf5, 0xe7,
		 0xfd, 0xc5, 0xcd, 0xf7, 0xcf, 0xf7, 0xfe, 0xff, 0xbf, 0xef, 0x3f, 0x5e, 0x7e, 0xfc, 0xfc, 0xff,
		 0xfb, 0xef, 0xfe, 0xeb, 0xdb, 0x9d, 0xc3, 0xa7, 0xe5, 0xe5, 0xbd, 0xdd, 0xfd, 0xfe, 0x3f, 0xbd,
		 0xff, 0x2f, 0x7e, 0x7e, 0xfc, 0xfd, 0xff, 0xf2, 0xcf, 0xff, 0xeb, 0xfb, 0xff, 0x73, 0xe7, 0xe7,
		 0xff, 0xff, 0xef, 0xff, 0xf6, 0xff, 0xb7, 0xfc, 0xbf, 0xef, 0x7c, 0xfc, 0xfd, 0xfe, 0xfe, 0xef,
		 0x7f, 0xfb, 0xef, 0x3f, 0xe9, 0xaf, 0xa7, 0xbf, 0x67, 0xf3, 0xfd, 0xfe, 0xbf, 0xbd, 0xfd, 0xbf,
		 0xfd, 0x72, 0x7a, 0x73, 0x7b, 0xef, 0xef, 0xff, 0xff, 0xf3, 0xff, 0xdb, 0xef, 0xf6, 0xf3, 0x7b,
		 0xef, 0xff, 0xee, 0xb7, 0x3b, 0xee, 0x3f, 0x76, 0x6e, 0x75, 0x6f, 0xfd, 0xf8, 0xef, 0xff, 0xd3,
		 0xdb, 0xff, 0xd1, 0xa7, 0xa1, 0xa7, 0x97, 0x77, 0xfb, 0xfe, 0x3f, 0xbe, 0xf5, 0x3f, 0xef, 0x5d,
		 0xea, 0x3c, 0x6c, 0xfa, 0xae, 0xff, 0xfb, 0xf3, 0xfe, 0xe3, 0xfe, 0xe7, 0xf7, 0xe7, 0xe7, 0xf7,
		 0xfa, 0xff, 0xbe, 0xfe, 0xbf, 0x5c, 0xfd, 0x7d, 0xfd, 0xbd, 0x7d, 0xef, 0xff, 0xfb, 0xdb, 0xdf,
		 0xfb, 0x77, 0xf7, 0xf7, 0xf7, 0xf5, 0xff, 0xfc, 0xff, 0xfd, 0xfd, 0xff, 0x6d, 0x7b, 0x7b, 0xfb,
		 0x5b, 0xff, 0xaf, 0xff, 0xfd, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xba, 0xfb, 0xff, 0xf7, 0xfa, 0x9f,
		 0xbf, 0xef, 0x9f, 0xff, 0x9f, 0x4e, 0x7f, 0xff, 0x77, 0xcf, 0xff, 0xef, 0xeb, 0xff, 0xeb, 0xff,
		 0xd7, 0xdf, 0xdf, 0x3f, 0xf7, 0xfe, 0xbf, 0x3e, 0xff, 0x3f, 0xef, 0x5f, 0xf9, 0x7d, 0xde, 0xfd,
		 0xef, 0xff, 0xe3, 0xeb, 0xff, 0xf3, 0xff, 0xd7, 0xff, 0xc7, 0xff, 0xef, 0xfe, 0x3f, 0xfe, 0xff,
		 0x3f, 0xff, 0x7f, 0xfb, 0x79, 0xbf, 0xdd, 0xef, 0xff, 0xfb, 0xcb, 0xff, 0xf3, 0xdd, 0xd7, 0xdb,
		 0xd7, 0xde, 0xff, 0xfe, 0xff, 0xbf, 0xff, 0xbf, 0xfd, 0xfd, 0x7d, 0xfd, 0xdf, 0xfd, 0xef, 0xfe,
		 0xf9, 0xef, 0xfe, 0xfb, 0xdf, 0x9d, 0x97, 0xd7, 0xdd, 0xfd, 0xfe, 0x9f, 0xfe, 0xff, 0xbf, 0xef,
		 0xdf, 0xdd, 0x75, 0xda, 0xff, 0xcf, 0xff, 0xef, 0xfb, 0xff, 0xdb, 0xfb, 0xdf, 0xff, 0xcd, 0x5f,
		 0xff, 0xf2, 0xaf, 0xfc, 0xff, 0xbb, 0xe8, 0xff, 0xf8, 0x7f, 0x79, 0x7e, 0xae, 0xbf, 0xef, 0xeb,
		 0xfd, 0xf9, 0xff, 0xd2, 0xff, 0xd7, 0xe6, 0xef, 0xfe, 0xff, 0xf9, 0xf9, 0xf9, 0xfd, 0x77, 0xff,
		 0x7f, 0xff, 0xd7, 0xee, 0xdf, 0xfb, 0xff, 0xfd, 0xff, 0xbf, 0x8f, 0xff, 0xd3, 0xff, 0xff, 0xfe,
		 0x3f, 0xf6, 0xff, 0xfe, 0xd7, 0xff, 0xaa, 0x37, 0xf9, 0x5b, 0xef, 0xff, 0xda, 0xdf, 0xdf, 0xdd,
		 0xff, 0xf5, 0xff, 0xf7, 0xff, 0xff, 0xfe, 0x9f, 0x8f, 0xb7, 0xbf, 0xff, 0x6f, 0xff, 0x7f, 0x69,
		 0xfe, 0xae, 0xff, 0xe3, 0xfd, 0xed, 0xfb, 0xff, 0xef, 0xfb, 0xf7, 0xe7, 0xf7, 0xfa, 0xaf, 0xbe,
		 0xfe, 0xae, 0xee, 0xff, 0xf5, 0x5b, 0x7e, 0x7d, 0xef, 0xdf, 0x7b, 0xfa, 0xfb, 0xfb, 0xbf, 0xf7,
		 0xff, 0xf7, 0xf5, 0xff, 0xfc, 0xff, 0xfd, 0xbd, 0xfd, 0xdd, 0x7b, 0xfb, 0x7f, 0x7b, 0xfb, 0xae,
		 0xff, 0xff, 0xfd, 0xfd, 0xff, 0xff, 0xfe, 0xfd, 0xff, 0xfc, 0xf7, 0xfa, 0xbf, 0xbf, 0x7f, 0xbf,
		 0xdf, 0x7f, 0xf7, 0x7f, 0xf7, 0x57, 0xcf, 0xff, 0xeb, 0xcb, 0xef, 0xeb, 0xff, 0xd7, 0xfd, 0xdd,
		 0xd5, 0xff, 0xfe, 0x3f, 0xfe, 0xfc, 0xfc, 0xff, 0x4f, 0xff, 0x5f, 0x7e, 0xfe, 0xef, 0xff, 0xe9,
		 0xeb, 0xeb, 0xff, 0xff, 0xd7, 0xff, 0xe7, 0xe7, 0xef, 0xde, 0xbf, 0xee, 0x9f, 0xfd, 0xff, 0x7b,
		 0xf7, 0x7f, 0xf6, 0xf3, 0xef, 0xff, 0xf3, 0xef, 0xef, 0xcf, 0xff, 0xf7, 0xff, 0x67, 0xff, 0xff,
		 0xfe, 0xbf, 0xff, 0xfa, 0xfe, 0xff, 0x7b, 0xff, 0xff, 0xff, 0xfb, 0xaf, 0xff, 0xff, 0xff, 0xde,
		 0xef, 0x3f, 0xf7, 0xfd, 0x7f, 0x9d, 0xff, 0xfe, 0xff, 0xbf, 0xfb, 0xff, 0xff, 0x7f, 0xff, 0xbf,
		 0x5f, 0xfe, 0xaf, 0xdf, 0xfa, 0xff, 0xef, 0x7f, 0xbf, 0xf3, 0xff, 0xff, 0xa7, 0xff, 0xae, 0xbc,
		 0x7e, 0x6f, 0x37, 0x3c, 0x3f, 0x39, 0xf9, 0xbf, 0xff, 0xef, 0x6b, 0x83, 0xab, 0xf2, 0xb3, 0x67,
		 0xd7, 0xc7, 0x7f, 0xfb, 0xff, 0xb6, 0x3a, 0xbf, 0xba, 0xfe, 0x6e, 0x5d, 0x7d, 0xfd, 0x7f, 0xfa,
		 0xef, 0xf7, 0xfb, 0xf7, 0xff, 0xff, 0xff, 0xf7, 0x7f, 0x7b, 0xe7, 0xff, 0x9e, 0xbd, 0x77, 0x7d,
		 0xf8, 0x75, 0x69, 0x6b, 0xeb, 0x7f, 0xfe, 0xef, 0xf6, 0xf3, 0xfa, 0xe3, 0x7f, 0x47, 0xf7, 0xe2,
		 0xff, 0x23, 0xfd, 0x9c, 0x37, 0x9f, 0xb7, 0x2e, 0x7f, 0x7f, 0x7f, 0xdf, 0xff, 0xff, 0xae, 0xfb,
		 0xfb, 0xf7, 0xff, 0xf3, 0xff, 0xf3, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xaf, 0x2e, 0xef, 0x3e, 0xef,
		 0x7d, 0x7a, 0xff, 0x7f, 0x7d, 0x2f, 0xeb, 0xbb, 0xdb, 0xf7, 0xbb, 0xdf, 0xf7, 0xef, 0xff, 0xf7,
		 0xf7, 0xfe, 0xfc, 0xfd, 0xfd, 0xfd, 0xfd, 0xf9, 0x7b, 0xfb, 0xff, 0xfb, 0xaf, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xf7, 0xba, 0xbb, 0xbf, 0x7b, 0xab, 0xfb, 0x37, 0xd7,
		 0xd6, 0x7f, 0x3f, 0xcf, 0xfb, 0xea, 0xf3, 0xef, 0xf3, 0xdf, 0xe7, 0xdf, 0xbf, 0xd7, 0xf7, 0x9e,
		 0xff, 0x6e, 0xfe, 0x3e, 0xfc, 0x79, 0xe9, 0x99, 0xff, 0xff, 0xcf, 0xeb, 0xeb, 0xe7, 0xe9, 0xe7,
		 0xf7, 0xcd, 0xf7, 0xff, 0xff, 0xef, 0x7e, 0xbb, 0x3c, 0x3a, 0x7a, 0x7b, 0x76, 0x76, 0xf6, 0x1f,
		 0xfe, 0xef, 0xcb, 0xff, 0xc1, 0xf7, 0xf3, 0xf7, 0xc7, 0xf3, 0xfb, 0x87, 0xff, 0x7e, 0xff, 0xff,
		 0xff, 0xeb, 0xff, 0xff, 0x7f, 0xdf, 0x5f, 0xfe, 0xef, 0xfb, 0xdb, 0xef, 0xfa, 0xeb, 0xf5, 0xdf,
		 0xe7, 0xff, 0x45, 0xff, 0xae, 0xbf, 0xbe, 0x3f, 0xbf, 0x7e, 0x5c, 0x53, 0xff, 0xff, 0xff, 0xef,
		 0xfb, 0xff, 0xeb, 0xe7, 0xdf, 0xd7, 0xcf, 0xdf, 0x7f, 0xff, 0xff, 0x3e, 0x7f, 0x3f, 0x7f, 0xff,
		 0xff, 0xf9, 0x5f, 0x6f, 0xf1, 0x7f, 0xef, 0xf3, 0xfb, 0xf3, 0xb7, 0xff, 0x7f, 0xfc, 0xd7, 0xf7,
		 0xff, 0xf7, 0x3e, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xbf, 0x7f, 0x3f, 0xff, 0xbf, 0xee, 0xf3, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xf7, 0xff, 0xff, 0x3e, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0x7f, 0xbe, 0xfd, 0xff, 0xef, 0xf3, 0xf7, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xe7, 0xff, 0xfa, 0xff,
		 0x3c, 0x3f, 0x3e, 0x7f, 0xff, 0xff, 0xff, 0x3f, 0xff, 0xf9, 0xff, 0xae, 0xf3, 0xf3, 0xf3, 0xf7,
		 0xff, 0xff, 0xff, 0xf7, 0xff, 0xff, 0xf7, 0xfa, 0xbf, 0xbe, 0xbe, 0xfe, 0xff, 0xff, 0x7f, 0x77,
		 0xf9, 0x7f, 0xaf, 0xfd, 0xfb, 0xf7, 0xfb, 0xff, 0xff, 0xff, 0xd7, 0xeb, 0xff, 0xff, 0xfe, 0xfd,
		 0xbd, 0xbd, 0xdd, 0x7f, 0xfb, 0xff, 0x79, 0x7b, 0xff, 0xae, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xf7, 0xfa, 0xbf, 0xbf, 0xbb, 0xff, 0x7f, 0xff, 0x7f, 0x77, 0x77, 0x57,
		 0xaf, 0xff, 0xeb, 0xab, 0xeb, 0xff, 0xd7, 0xff, 0xf3, 0xd7, 0x57, 0xfd, 0x3e, 0x3f, 0x7e, 0xbc,
		 0xff, 0x7f, 0xff, 0xff, 0xff, 0x78, 0xfe, 0xcf, 0xf3, 0xe3, 0xfb, 0xfb, 0xff, 0xd7, 0xfb, 0xff,
		 0xf7, 0xe3, 0xef, 0x3e, 0x7d, 0x9c, 0xff, 0xfd, 0x7f, 0xba, 0x7f, 0xf6, 0xf7, 0xff, 0xef, 0xf3,
		 0x8b, 0xf7, 0xff, 0xff, 0xd7, 0xff, 0xe7, 0x9f, 0x9f, 0xff, 0x3e, 0xff, 0x7f, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0x7f, 0xff, 0xff, 0xef, 0xd3, 0xcf, 0xfb, 0xcf, 0xff, 0xaf, 0xff, 0xdf, 0xd7, 0xdf,
		 0xff, 0x3c, 0xbf, 0x9f, 0x9f, 0xff, 0xff, 0xfb, 0xff, 0x7f, 0x7f, 0xfe, 0xef, 0xf3, 0xf7, 0xf7,
		 0xfb, 0xff, 0xfb, 0xff, 0xfe, 0xe7, 0xe2, 0xff, 0xbe, 0xfe, 0xdf, 0x9f, 0xbf, 0x3f, 0x7f, 0x3d,
		 0xbf, 0xff, 0xff, 0xef, 0xdf, 0xdf, 0xdd, 0xdb, 0xdb, 0xb7, 0xb7, 0xbb, 0xbb, 0xbf, 0xff, 0xbc,
		 0xbd, 0xbd, 0x9d, 0xbc, 0x7c, 0x79, 0x7b, 0x79, 0x7b, 0xfb, 0xef, 0xd7, 0xf5, 0xf5, 0xd5, 0xd5,
		 0xad, 0xeb, 0xef, 0xaf, 0xab, 0xff, 0xfe, 0x7f, 0x7e, 0xfe, 0xff, 0xff, 0xff, 0xf5, 0xf5, 0xfe,
		 0xde, 0xef, 0xf3, 0xf7, 0xf7, 0xbb, 0xbb, 0x77, 0xe7, 0xe7, 0xef, 0xef, 0xff, 0xfe, 0xff, 0xd7,
		 0xf7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;