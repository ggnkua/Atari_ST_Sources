extern int window_to_jpeg ( char *file_name,
							char *start,
							int x, int y, int w, int h, int bpl ) ;
extern int rgb_to_jpeg ( char *file_name, char *start, int w, int h ) ;
extern int ntc_to_jpeg ( char *file_name, unsigned short *start, int w, int h ) ;
