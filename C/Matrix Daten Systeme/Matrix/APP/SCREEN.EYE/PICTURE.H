extern int WriteTiffFile ( char *filename, void *data, int w, int h ) ;
