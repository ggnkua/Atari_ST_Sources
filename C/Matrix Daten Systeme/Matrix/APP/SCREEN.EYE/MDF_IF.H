/********************************************************************/
/* 						MatDigiF Interface							*/
/*																	*/
/*------------------------------------------------------------------*/
/*	Status : 23.09.93												*/
/*																	*/
/*  HG - Matrix Daten Systeme, Talstr. 16, W-7155 Oppenweiler		*/
/*																	*/
/********************************************************************/

/* "RECTangle" and "POINT" in <global.h> */

extern int display_falcon_colour	( RECTangle *win,
									  POINT *vid ) ;
									  

