extern bool SoundInToOut ( bool on ) ;
extern bool SetVolume ( int gain, int att ) ;
