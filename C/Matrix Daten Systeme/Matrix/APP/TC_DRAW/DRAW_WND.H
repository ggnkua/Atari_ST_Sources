
extern bool open_tcdraw_window ( int argc, char *argv[] ) ;
extern bool activate_tcdraw_window ( void ) ;

extern bool init_tcdraw ( void ) ;
extern void term_tcdraw ( void ) ;
