/* text.h	/	23.3.92	/	MATRIX	/	WA	*/


# define MSGnoBackBuffer	"Kein Hintergrundpuffer verf�gbar"
# define FCTaborted			"* Funktion abgebrochen"

# define MSGreadPicName		"Bilddateiname - Lesen"
# define MSGreadFile		"Lese : %s"
# define MSGreadError		"Lesefehler"

# define MSGwritePicName	"Bilddateiname - Schreiben"
# define MSGwriteFile		"Schreibe : %s"
# define MSGwriteError		"Schreibfehler : %d"

# define MSG_TOOL_SELECT 	"Auswahlbox [ F1 ]"
# define MSG_TOOL_GENERAL 	"Allgemeine Funktionen [ F2 ]"
# define MSG_TOOL_PALET		"Palettenfunktionen [ F3 ]"
# define MSG_TOOL_VDI 		"Zeichenfunktionen [ F4 ]"
# define MSG_TOOL_FILTER 	"Bildfilterfunktionen [ F5 ]"
# define MSG_TOOL_HISTO 	"Histogrammfunktionen [ sF5 ]"
# define MSG_TOOL_RUNS		"Verlaufsfunktionen [ F6 ]"
# define MSG_TOOL_COPY		"Kopierfunktionen [ F7 ]"
# define MSG_TOOL_WINDOW	"Kopierfenster [ sF7 ]"
# define MSG_TOOL_DEMO		"Demofunktionen [ F8 ]"
# define MSG_TOOL_VIDEO		"Videofunktionen [ F9 ]"
# define MSG_TOOL_TVPAR		"MatDigi Parameter [ sF9 ]"
# define MSG_TOOL_DISK		"Diskfunktionen [ F10 ]"

# define MSG_TOOL_HELP		"Hilfe"
# define MSG_CLOSER			"Schliežbox [ ^C ]"

# define MSGcanvas			"Zeichenfl„che"
# define MSGvdiColor		"VDI Farbummer"
# define MSGredIntensity	"Rot Intensit„t"
# define MSGgreenIntensity	"Gr�n Intensit„t"
# define MSGblueIntensity	"Blau Intensit„t"

# define NOTimplemented		"* Funktion nicht implementiert"
