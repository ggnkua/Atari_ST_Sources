extern void draw_curve (  int vhandle,
						  RECTangle *rect, uword maxval,
						  uword *table, int tab_size,
						  int color ) ;
