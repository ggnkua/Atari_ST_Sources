#include <vdi.h>
#include <vdi_ext.h>

# include <global.h>

# include "fracticn.h"

byte fract_data[3*FW*FH] = {
/* line  0 */
 0x43,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00, 0x41,0x00,0x00,
 0x41,0x00,0x00, 0x41,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00, 0x3f,0x00,0x00,
 0x3f,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00,
 0x3f,0x00,0x00, 0x3e,0x00,0x00, 0x3e,0x00,0x00, 0x3e,0x00,0x00,
 0x3e,0x00,0x00, 0x3e,0x00,0x00, 0x3d,0x00,0x00, 0x3d,0x00,0x00,
 0x3d,0x00,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00, 0x3c,0x00,0x00,
 0x3c,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00, 0x3b,0x00,0x00,
/* line  1 */
 0x43,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00, 0x41,0x00,0x00,
 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00,
 0x3f,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00, 0x3e,0x00,0x00,
 0x3e,0x00,0x00, 0x3e,0x00,0x00, 0x3e,0x00,0x00, 0x3d,0x00,0x00,
 0x3d,0x00,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00, 0x3c,0x00,0x00,
 0x3c,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00, 0x3b,0x00,0x00,
/* line  2 */
 0x43,0x00,0x00, 0x43,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00,
 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00,
 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00,
 0x3f,0x00,0x00, 0x3f,0x00,0x00, 0x3e,0x00,0x00, 0x3e,0x00,0x00,
 0x3d,0x00,0x00, 0x3d,0x00,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00,
 0x3c,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00, 0x3b,0x00,0x00,
/* line  3 */
 0x44,0x00,0x00, 0x43,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00,
 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00,
 0x41,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x41,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00,
 0x40,0x00,0x00, 0x40,0x00,0x00, 0x40,0x00,0x00, 0x3f,0x00,0x00,
 0x3e,0x00,0x00, 0x3d,0x00,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00,
 0x3c,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00, 0x3b,0x00,0x00,
/* line  4 */
 0x46,0x00,0x00, 0x44,0x00,0x00, 0x43,0x00,0x00, 0x42,0x00,0x00,
 0x42,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00,
 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00,
 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00,
 0x42,0x00,0x00, 0xff,0x2a,0x00, 0x44,0x00,0x00, 0x42,0x00,0x00,
 0x42,0x00,0x00, 0x43,0x00,0x00, 0x91,0x00,0x00, 0x43,0x00,0x00,
 0x3f,0x00,0x00, 0x3e,0x00,0x00, 0x3d,0x00,0x00, 0x3d,0x00,0x00,
 0x3c,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00, 0x3b,0x00,0x00,
/* line  5 */
 0xff,0xbb,0x00, 0x46,0x00,0x00, 0x43,0x00,0x00, 0x42,0x00,0x00,
 0x42,0x00,0x00, 0x42,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00,
 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00, 0x41,0x00,0x00,
 0x41,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00, 0x43,0x00,0x00,
 0x45,0x00,0x00, 0xc6,0x00,0x00, 0x7e,0x00,0x00, 0xd4,0x00,0x00,
 0x5c,0x00,0x00, 0xd1,0x00,0x00, 0x00,0xff,0x14, 0x59,0x00,0x00,
 0x40,0x00,0x00, 0x3f,0x00,0x00, 0x3e,0x00,0x00, 0x3d,0x00,0x00,
 0x3d,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00, 0x3b,0x00,0x00,
/* line  6 */
 0x7d,0x00,0x00, 0x45,0x00,0x00, 0x43,0x00,0x00, 0x43,0x00,0x00,
 0x42,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00,
 0x42,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00,
 0x42,0x00,0x00, 0x45,0x00,0x00, 0x89,0x00,0x00, 0x5f,0x00,0x00,
 0x99,0x00,0x00, 0xd3,0x00,0x00, 0x95,0x00,0x00, 0x5c,0x00,0x00,
 0x8c,0x00,0x00, 0xcc,0x00,0x00, 0xff,0x00,0x00, 0xa3,0x00,0x00,
 0x5d,0x00,0x00, 0x44,0x00,0x00, 0x3f,0x00,0x00, 0x3f,0x00,0x00,
 0x3e,0x00,0x00, 0x3c,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00,
/* line  7 */
 0x47,0x00,0x00, 0x45,0x00,0x00, 0x44,0x00,0x00, 0x43,0x00,0x00,
 0x43,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00,
 0x42,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00,
 0x43,0x00,0x00, 0x48,0x00,0x00, 0xff,0xd5,0x00, 0x59,0x00,0x00,
 0xda,0x00,0x00, 0xef,0x00,0x00, 0x80,0x00,0x00, 0xbd,0x00,0x00,
 0x77,0x00,0x00, 0x91,0x00,0x00, 0xff,0x82,0x00, 0x5a,0x00,0x00,
 0x83,0x00,0x00, 0x6e,0x00,0x00, 0x45,0x00,0x00, 0x5b,0x00,0x00,
 0xff,0x09,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00,
/* line  8 */
 0x46,0x00,0x00, 0x45,0x00,0x00, 0x44,0x00,0x00, 0x43,0x00,0x00,
 0x43,0x00,0x00, 0x43,0x00,0x00, 0x42,0x00,0x00, 0x42,0x00,0x00,
 0x42,0x00,0x00, 0x42,0x00,0x00, 0x43,0x00,0x00, 0x43,0x00,0x00,
 0x44,0x00,0x00, 0xdb,0x00,0x00, 0xff,0x51,0x00, 0xba,0xff,0x00,
 0x81,0x00,0x00, 0xc5,0x00,0x00, 0xa0,0x00,0x00, 0xaa,0x00,0x00,
 0xe7,0x00,0x00, 0xcd,0x00,0x00, 0x76,0x00,0x00, 0x78,0x00,0x00,
 0xcb,0x00,0x00, 0xb2,0x00,0x00, 0xff,0x95,0x00, 0xca,0x00,0x00,
 0x68,0x00,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00,
/* line  9 */
 0x46,0x00,0x00, 0x45,0x00,0x00, 0x44,0x00,0x00, 0x44,0x00,0x00,
 0x43,0x00,0x00, 0x43,0x00,0x00, 0x43,0x00,0x00, 0x43,0x00,0x00,
 0x43,0x00,0x00, 0x43,0x00,0x00, 0x43,0x00,0x00, 0x45,0x00,0x00,
 0x64,0x00,0x00, 0xec,0x00,0x00, 0x7e,0x00,0x00, 0xff,0x11,0x00,
 0x8f,0x00,0x00, 0xff,0x9a,0x00, 0x5d,0x00,0x00, 0x5d,0x00,0x00,
 0xf0,0x00,0x00, 0xff,0x61,0x00, 0xff,0xc2,0x00, 0x71,0x00,0x00,
 0xff,0x47,0x00, 0xb4,0x00,0x00, 0xf5,0x00,0x00, 0xff,0x23,0x00,
 0x3f,0x00,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00,
/* line 10 */
 0x4b,0x00,0x00, 0x46,0x00,0x00, 0x45,0x00,0x00, 0x44,0x00,0x00,
 0x44,0x00,0x00, 0x43,0x00,0x00, 0x43,0x00,0x00, 0x43,0x00,0x00,
 0x43,0x00,0x00, 0x44,0x00,0x00, 0x44,0x00,0x00, 0x46,0x00,0x00,
 0x69,0x00,0x00, 0xb6,0x00,0x00, 0x81,0x00,0x00, 0x63,0x00,0x00,
 0x5e,0x00,0x00, 0x5d,0x00,0x00, 0x5b,0x00,0x00, 0x5b,0x00,0x00,
 0x5a,0x00,0x00, 0x5b,0x00,0x00, 0x9b,0x00,0x00, 0xff,0x32,0x00,
 0xcc,0x00,0x00, 0x78,0x00,0x00, 0x59,0x00,0x00, 0x5b,0x00,0x00,
 0x46,0x00,0x00, 0x3d,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00,
/* line 11 */
 0xc1,0x00,0x00, 0x48,0x00,0x00, 0x46,0x00,0x00, 0x45,0x00,0x00,
 0x44,0x00,0x00, 0x44,0x00,0x00, 0x44,0x00,0x00, 0x44,0x00,0x00,
 0x44,0x00,0x00, 0x44,0x00,0x00, 0x45,0x00,0x00, 0x46,0x00,0x00,
 0x69,0x00,0x00, 0x82,0x00,0x00, 0xff,0x0a,0x00, 0x60,0x00,0x00,
 0x5e,0x00,0x00, 0x5c,0x00,0x00, 0x5b,0x00,0x00, 0x59,0x00,0x00,
 0x59,0x00,0x00, 0x59,0x00,0x00, 0x5a,0x00,0x00, 0x5d,0x00,0x00,
 0x32,0xff,0x00, 0xff,0xf5,0x00, 0xff,0x00,0x00, 0xf2,0x00,0x00,
 0x5e,0x00,0x00, 0x3f,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00,
/* line 12 */
 0xf3,0x00,0x00, 0xb8,0x00,0x00, 0x5b,0x00,0x00, 0x46,0x00,0x00,
 0x45,0x00,0x00, 0x44,0x00,0x00, 0x44,0x00,0x00, 0x44,0x00,0x00,
 0x44,0x00,0x00, 0x45,0x00,0x00, 0x45,0x00,0x00, 0x4c,0x00,0x00,
 0xff,0xb6,0x00, 0xee,0x00,0x00, 0x63,0x00,0x00, 0x60,0x00,0x00,
 0x5f,0x00,0x00, 0x60,0x00,0x00, 0x5c,0x00,0x00, 0x59,0x00,0x00,
 0x58,0x00,0x00, 0x57,0x00,0x00, 0x58,0x00,0x00, 0x59,0x00,0x00,
 0x5f,0x00,0x00, 0x6f,0x00,0x00, 0x74,0x00,0x00, 0x90,0x00,0x00,
 0xf9,0xff,0x00, 0x42,0x00,0x00, 0x41,0x00,0x00, 0x3c,0x00,0x00,
/* line 13 */
 0xc9,0x00,0x00, 0xc1,0x00,0x00, 0xbf,0x00,0x00, 0x47,0x00,0x00,
 0x45,0x00,0x00, 0x45,0x00,0x00, 0x45,0x00,0x00, 0x45,0x00,0x00,
 0x45,0x00,0x00, 0x45,0x00,0x00, 0x46,0x00,0x00, 0x47,0x00,0x00,
 0xdf,0xff,0x00, 0xc7,0x00,0x00, 0x64,0x00,0x00, 0x62,0x00,0x00,
 0x88,0x00,0x00, 0x7b,0x00,0x00, 0xc8,0x00,0x00, 0x5a,0x00,0x00,
 0x57,0x00,0x00, 0x56,0x00,0x00, 0x56,0x00,0x00, 0x59,0x00,0x00,
 0x3f,0xff,0x00, 0xb1,0x00,0x00, 0x56,0xff,0x00, 0xff,0x53,0x00,
 0xff,0x95,0x00, 0xff,0x72,0x00, 0xff,0x07,0x00, 0x3e,0x00,0x00,
/* line 14 */
 0x55,0x00,0x00, 0x4e,0x00,0x00, 0x49,0x00,0x00, 0x47,0x00,0x00,
 0x46,0x00,0x00, 0x46,0x00,0x00, 0x45,0x00,0x00, 0x45,0x00,0x00,
 0x45,0x00,0x00, 0x46,0x00,0x00, 0x46,0x00,0x00, 0x48,0x00,0x00,
 0xb9,0x00,0x00, 0xa6,0x00,0x00, 0xff,0xbe,0x00, 0x65,0x00,0x00,
 0xb0,0x00,0x00, 0x8e,0x00,0x00, 0x74,0x00,0x00, 0xff,0x00,0x00,
 0x56,0x00,0x00, 0x55,0x00,0x00, 0x55,0x00,0x00, 0x57,0x00,0x00,
 0x5a,0x00,0x00, 0x88,0x00,0x00, 0x92,0x00,0x00, 0x8e,0x00,0x00,
 0x7d,0xff,0x00, 0xff,0x4f,0x00, 0x90,0x00,0x00, 0x3c,0x00,0x00,
/* line 15 */
 0x7a,0x00,0x00, 0x8a,0x00,0x00, 0x4d,0x00,0x00, 0x49,0x00,0x00,
 0x47,0x00,0x00, 0x46,0x00,0x00, 0x46,0x00,0x00, 0x46,0x00,0x00,
 0x46,0x00,0x00, 0x46,0x00,0x00, 0x47,0x00,0x00, 0x48,0x00,0x00,
 0x4a,0x00,0x00, 0xb3,0x00,0x00, 0xbf,0x00,0x00, 0x68,0x00,0x00,
 0x69,0x00,0x00, 0x6c,0x00,0x00, 0x91,0x00,0x00, 0xff,0x8f,0x00,
 0x54,0x00,0x00, 0x54,0x00,0x00, 0x55,0x00,0x00, 0x56,0x00,0x00,
 0x59,0x00,0x00, 0x78,0x00,0x00, 0x71,0x00,0x00, 0x76,0xff,0x00,
 0xff,0x54,0x00, 0x40,0x00,0x00, 0x3c,0x00,0x00, 0x3b,0x00,0x00,
/* line 16 */
 0x56,0x00,0x00, 0x66,0x00,0x00, 0x88,0x00,0x00, 0x00,0xff,0x61,
 0x4d,0x00,0x00, 0x49,0x00,0x00, 0x47,0x00,0x00, 0x47,0x00,0x00,
 0x47,0x00,0x00, 0x47,0x00,0x00, 0x47,0x00,0x00, 0x48,0x00,0x00,
 0x49,0x00,0x00, 0x4e,0x00,0x00, 0x69,0x00,0x00, 0x84,0x00,0x00,
 0xff,0xae,0x00, 0xa3,0x00,0x00, 0xec,0x00,0x00, 0x54,0x00,0x00,
 0x53,0x00,0x00, 0x53,0x00,0x00, 0x54,0x00,0x00, 0x56,0x00,0x00,
 0xe8,0x00,0x00, 0x6a,0x00,0x00, 0x70,0x00,0x00, 0x93,0x00,0x00,
 0x5c,0x00,0x00, 0x7a,0x00,0x00, 0x3b,0x00,0x00, 0x3a,0x00,0x00,
/* line 17 */
 0xa1,0x00,0x00, 0xff,0xc2,0x00, 0xff,0x76,0x00, 0xe0,0x00,0x00,
 0xff,0x3e,0x00, 0x83,0x00,0x00, 0x48,0x00,0x00, 0x47,0x00,0x00,
 0x47,0x00,0x00, 0x47,0x00,0x00, 0x48,0x00,0x00, 0x48,0x00,0x00,
 0x49,0x00,0x00, 0x4a,0x00,0x00, 0x4e,0x00,0x00, 0x4f,0x00,0x00,
 0x54,0x00,0x00, 0x8b,0x00,0x00, 0x51,0x00,0x00, 0x51,0x00,0x00,
 0x52,0x00,0x00, 0x52,0x00,0x00, 0x53,0x00,0x00, 0x55,0x00,0x00,
 0xff,0xa5,0x00, 0xc0,0x00,0x00, 0x7a,0x00,0x00, 0x8a,0x00,0x00,
 0x79,0x00,0x00, 0x40,0x00,0x00, 0x3b,0x00,0x00, 0x3a,0x00,0x00,
/* line 18 */
 0xff,0x9b,0x00, 0x7e,0x00,0x00, 0x6a,0x00,0x00, 0x5d,0x00,0x00,
 0x57,0x00,0x00, 0x4b,0x00,0x00, 0x49,0x00,0x00, 0x48,0x00,0x00,
 0x48,0x00,0x00, 0x48,0x00,0x00, 0x48,0x00,0x00, 0x49,0x00,0x00,
 0x49,0x00,0x00, 0x4a,0x00,0x00, 0x4b,0x00,0x00, 0x4c,0x00,0x00,
 0x4e,0x00,0x00, 0x4f,0x00,0x00, 0x4f,0x00,0x00, 0x50,0x00,0x00,
 0x51,0x00,0x00, 0x52,0x00,0x00, 0x54,0x00,0x00, 0x56,0x00,0x00,
 0x8e,0x00,0x00, 0x73,0x00,0x00, 0xed,0xff,0x00, 0xec,0x00,0x00,
 0x00,0xff,0x03, 0x3e,0x00,0x00, 0x3b,0x00,0x00, 0x39,0x00,0x00,
/* line 19 */
 0xec,0x00,0x00, 0x81,0x00,0x00, 0x66,0x00,0x00, 0x6c,0x00,0x00,
 0xac,0x00,0x00, 0x84,0x00,0x00, 0x4e,0x00,0x00, 0x4c,0x00,0x00,
 0x4a,0x00,0x00, 0x49,0x00,0x00, 0x49,0x00,0x00, 0x49,0x00,0x00,
 0x4a,0x00,0x00, 0x4a,0x00,0x00, 0x4b,0x00,0x00, 0x4c,0x00,0x00,
 0x4d,0x00,0x00, 0x4e,0x00,0x00, 0x4f,0x00,0x00, 0x50,0x00,0x00,
 0x51,0x00,0x00, 0x52,0x00,0x00, 0xbf,0x00,0x00, 0xae,0x00,0x00,
 0x7d,0x00,0x00, 0x6c,0x00,0x00, 0x7a,0xff,0x00, 0xf3,0x00,0x00,
 0xff,0xbb,0x00, 0x54,0x00,0x00, 0x7d,0x00,0x00, 0x39,0x00,0x00,
/* line 20 */
 0x51,0x00,0x00, 0x77,0x00,0x00, 0xff,0x71,0x00, 0x4b,0x00,0x00,
 0x5e,0x00,0x00, 0x66,0x00,0x00, 0xbb,0x00,0x00, 0xff,0x44,0x00,
 0x4f,0x00,0x00, 0x4b,0x00,0x00, 0x4a,0x00,0x00, 0x4a,0x00,0x00,
 0x4b,0x00,0x00, 0x4b,0x00,0x00, 0x4c,0x00,0x00, 0x4c,0x00,0x00,
 0x4d,0x00,0x00, 0x4e,0x00,0x00, 0x4f,0x00,0x00, 0x50,0x00,0x00,
 0x51,0x00,0x00, 0x53,0x00,0x00, 0xd1,0x00,0x00, 0xb5,0xff,0x00,
 0x6b,0x00,0x00, 0x76,0x00,0x00, 0x53,0x00,0x00, 0x48,0x00,0x00,
 0x98,0x00,0x00, 0x93,0x00,0x00, 0x3c,0x00,0x00, 0x39,0x00,0x00,
/* line 21 */
 0x2e,0x00,0x00, 0xff,0x88,0x00, 0x4c,0x00,0x00, 0x43,0x00,0x00,
 0x7c,0x00,0x00, 0x7b,0x00,0x00, 0x80,0x00,0x00, 0x5a,0x00,0x00,
 0x50,0x00,0x00, 0x5a,0x00,0x00, 0x4d,0x00,0x00, 0x4d,0x00,0x00,
 0x4c,0x00,0x00, 0x4c,0x00,0x00, 0x4d,0x00,0x00, 0x4d,0x00,0x00,
 0x4e,0x00,0x00, 0x4f,0x00,0x00, 0x50,0x00,0x00, 0x51,0x00,0x00,
 0x6e,0x00,0x00, 0x57,0x00,0x00, 0xff,0x16,0x00, 0x93,0x00,0x00,
 0x91,0x00,0x00, 0xaa,0x00,0x00, 0xa4,0x00,0x00, 0xff,0x76,0x00,
 0x3a,0x00,0x00, 0x39,0x00,0x00, 0x39,0x00,0x00, 0x38,0x00,0x00,
/* line 22 */
 0x2c,0x00,0x00, 0x2d,0x00,0x00, 0x30,0x00,0x00, 0xbc,0x00,0x00,
 0xf4,0x00,0x00, 0xff,0x12,0x00, 0x67,0x00,0x00, 0xff,0x1d,0x00,
 0x6d,0x00,0x00, 0x7d,0x00,0x00, 0xff,0x69,0x00, 0xdd,0x00,0x00,
 0x4e,0x00,0x00, 0x4e,0x00,0x00, 0x52,0x00,0x00, 0x4f,0x00,0x00,
 0x4f,0x00,0x00, 0x5c,0x00,0x00, 0x52,0x00,0x00, 0x56,0x00,0x00,
 0xe8,0xff,0x00, 0x64,0x00,0x00, 0xc1,0x00,0x00, 0x72,0x00,0x00,
 0xad,0x00,0x00, 0xa8,0x00,0x00, 0x5a,0x00,0x00, 0x76,0x00,0x00,
 0x39,0x00,0x00, 0x38,0x00,0x00, 0x37,0x00,0x00, 0x37,0x00,0x00,
/* line 23 */
 0x2b,0x00,0x00, 0x2c,0x00,0x00, 0x30,0x00,0x00, 0x6b,0x00,0x00,
 0x98,0x00,0x00, 0xff,0xb0,0x00, 0xb0,0x00,0x00, 0x4c,0x00,0x00,
 0x8c,0x00,0x00, 0xae,0x00,0x00, 0x63,0x00,0x00, 0xff,0x14,0x00,
 0xff,0x99,0x00, 0xa9,0x00,0x00, 0xe7,0x00,0x00, 0x53,0x00,0x00,
 0x6d,0x00,0x00, 0xff,0xf1,0x00, 0x5a,0x00,0x00, 0x6f,0x00,0x00,
 0x88,0x00,0x00, 0x6b,0x00,0x00, 0x76,0x00,0x00, 0x52,0x00,0x00,
 0xfa,0x00,0x00, 0x00,0xff,0x2d, 0x3d,0x00,0x00, 0x39,0x00,0x00,
 0x38,0x00,0x00, 0x37,0x00,0x00, 0x37,0x00,0x00, 0x37,0x00,0x00,
/* line 24 */
 0x2b,0x00,0x00, 0x2c,0x00,0x00, 0x2f,0x00,0x00, 0x36,0x00,0x00,
 0x30,0x00,0x00, 0x8d,0x00,0x00, 0x6b,0x00,0x00, 0x41,0x00,0x00,
 0xff,0xa7,0x00, 0xff,0xf2,0x00, 0x6b,0x00,0x00, 0xad,0x00,0x00,
 0x6a,0x00,0x00, 0xff,0x96,0x00, 0x61,0x00,0x00, 0x86,0x00,0x00,
 0x72,0x00,0x00, 0xa0,0x00,0x00, 0xb7,0x00,0x00, 0x68,0x00,0x00,
 0xa3,0x00,0x00, 0xff,0x36,0x00, 0xd3,0x00,0x00, 0x54,0x00,0x00,
 0x5f,0x00,0x00, 0x89,0x00,0x00, 0xf7,0x00,0x00, 0x38,0x00,0x00,
 0x37,0x00,0x00, 0x37,0x00,0x00, 0x36,0x00,0x00, 0x36,0x00,0x00,
/* line 25 */
 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2c,0x00,0x00, 0x2d,0x00,0x00,
 0x2e,0x00,0x00, 0x2e,0x00,0x00, 0x30,0x00,0x00, 0x84,0x00,0x00,
 0xff,0x59,0x00, 0xff,0x3e,0x00, 0x4f,0x00,0x00, 0x48,0x00,0x00,
 0xf6,0x00,0x00, 0xc0,0x00,0x00, 0xf6,0x00,0x00, 0xdd,0x00,0x00,
 0xac,0x00,0x00, 0xbd,0x00,0x00, 0x83,0x00,0x00, 0x4e,0x00,0x00,
 0xd6,0x00,0x00, 0xc8,0x00,0x00, 0x58,0x00,0x00, 0x3b,0x00,0x00,
 0x38,0x00,0x00, 0x39,0x00,0x00, 0x3a,0x00,0x00, 0x37,0x00,0x00,
 0x36,0x00,0x00, 0x36,0x00,0x00, 0x36,0x00,0x00, 0x36,0x00,0x00,
/* line 26 */
 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2c,0x00,0x00, 0x2c,0x00,0x00,
 0x2d,0x00,0x00, 0x2d,0x00,0x00, 0x2f,0x00,0x00, 0xdd,0x00,0x00,
 0x34,0x00,0x00, 0x33,0x00,0x00, 0x8e,0x00,0x00, 0x57,0x00,0x00,
 0xff,0x84,0x00, 0x7c,0x00,0x00, 0x59,0x00,0x00, 0x99,0x00,0x00,
 0x93,0xff,0x00, 0xff,0x17,0x00, 0x68,0x00,0x00, 0x93,0x00,0x00,
 0xff,0x0d,0x00, 0xed,0x00,0x00, 0x38,0x00,0x00, 0x37,0x00,0x00,
 0x36,0x00,0x00, 0x36,0x00,0x00, 0x36,0x00,0x00, 0x36,0x00,0x00,
 0x36,0x00,0x00, 0x36,0x00,0x00, 0x36,0x00,0x00, 0x36,0x00,0x00,
/* line 27 */
 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2c,0x00,0x00,
 0x2c,0x00,0x00, 0x2d,0x00,0x00, 0x2e,0x00,0x00, 0x2f,0x00,0x00,
 0x2f,0x00,0x00, 0x30,0x00,0x00, 0x31,0x00,0x00, 0x50,0x00,0x00,
 0x4f,0x00,0x00, 0x34,0x00,0x00, 0x35,0x00,0x00, 0x36,0x00,0x00,
 0xef,0x00,0x00, 0x39,0x00,0x00, 0x37,0x00,0x00, 0x36,0x00,0x00,
 0x3a,0x00,0x00, 0xad,0x00,0x00, 0x36,0x00,0x00, 0x35,0x00,0x00,
 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00,
 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00,
/* line 28 */
 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2c,0x00,0x00,
 0x2c,0x00,0x00, 0x2d,0x00,0x00, 0x2d,0x00,0x00, 0x2e,0x00,0x00,
 0x2e,0x00,0x00, 0x2f,0x00,0x00, 0x30,0x00,0x00, 0x31,0x00,0x00,
 0x32,0x00,0x00, 0x32,0x00,0x00, 0x32,0x00,0x00, 0x33,0x00,0x00,
 0x49,0x00,0x00, 0x35,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00,
 0x34,0x00,0x00, 0x35,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00,
 0x34,0x00,0x00, 0x34,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00,
 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00,
/* line 29 */
 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2c,0x00,0x00,
 0x2c,0x00,0x00, 0x2c,0x00,0x00, 0x2d,0x00,0x00, 0x2d,0x00,0x00,
 0x2e,0x00,0x00, 0x2e,0x00,0x00, 0x2f,0x00,0x00, 0x30,0x00,0x00,
 0x30,0x00,0x00, 0x31,0x00,0x00, 0x31,0x00,0x00, 0x32,0x00,0x00,
 0x32,0x00,0x00, 0x32,0x00,0x00, 0x33,0x00,0x00, 0x33,0x00,0x00,
 0x33,0x00,0x00, 0x33,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00,
 0x34,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00,
 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00,
/* line 30 */
 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2c,0x00,0x00,
 0x2c,0x00,0x00, 0x2c,0x00,0x00, 0x2d,0x00,0x00, 0x2d,0x00,0x00,
 0x2e,0x00,0x00, 0x2e,0x00,0x00, 0x2f,0x00,0x00, 0x2f,0x00,0x00,
 0x30,0x00,0x00, 0x30,0x00,0x00, 0x30,0x00,0x00, 0x31,0x00,0x00,
 0x31,0x00,0x00, 0x32,0x00,0x00, 0x32,0x00,0x00, 0x32,0x00,0x00,
 0x33,0x00,0x00, 0x33,0x00,0x00, 0x33,0x00,0x00, 0x33,0x00,0x00,
 0x34,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00,
 0x34,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00,
/* line 31 */
 0x2b,0x00,0x00, 0x2b,0x00,0x00, 0x2c,0x00,0x00, 0x2c,0x00,0x00,
 0x2c,0x00,0x00, 0x2d,0x00,0x00, 0x2d,0x00,0x00, 0x2d,0x00,0x00,
 0x2e,0x00,0x00, 0x2e,0x00,0x00, 0x2e,0x00,0x00, 0x2f,0x00,0x00,
 0x2f,0x00,0x00, 0x30,0x00,0x00, 0x30,0x00,0x00, 0x30,0x00,0x00,
 0x31,0x00,0x00, 0x31,0x00,0x00, 0x32,0x00,0x00, 0x32,0x00,0x00,
 0x32,0x00,0x00, 0x33,0x00,0x00, 0x33,0x00,0x00, 0x33,0x00,0x00,
 0x33,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00, 0x34,0x00,0x00,
 0x34,0x00,0x00, 0x34,0x00,0x00, 0x35,0x00,0x00, 0x35,0x00,0x00
} ;
 
MFDB fract_mfdb = { fract_data,  32, 32, 32/16, PCK_FORM, 24 } ;
