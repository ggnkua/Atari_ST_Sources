# define DEFpar -32767

extern void init_draw_cli ( void ) ;
extern int cli_file ( char *filename ) ;
extern int cli_line ( char *line ) ;
