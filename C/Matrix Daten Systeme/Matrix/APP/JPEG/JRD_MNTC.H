typedef unsigned short NTCpixel ;
extern void set_ntc_compression_size ( NTCpixel *start, int w, int h ) ;
