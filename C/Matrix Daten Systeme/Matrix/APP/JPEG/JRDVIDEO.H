extern void set_compression_window ( char *start,
							 int x, int y, int w, int h, int bpl, int bpp ) ;
