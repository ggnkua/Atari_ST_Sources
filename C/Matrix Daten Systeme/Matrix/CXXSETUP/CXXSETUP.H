/* Resource Datei Indizes f�r CXXSETUP */

#define DPALETTE 0   /* Formular/Dialog */
#define PFRAME   0   /* BOX in Baum DPALETTE */
#define PMATRIX  1   /* BOX in Baum DPALETTE */
#define PDISPSEL 2   /* BOX in Baum DPALETTE */
#define PICCOLOR 3   /* ICON in Baum DPALETTE */
#define PICCURVE 4   /* ICON in Baum DPALETTE */
#define PICRED   5   /* ICON in Baum DPALETTE */
#define PICGREEN 6   /* ICON in Baum DPALETTE */
#define PICBLUE  7   /* ICON in Baum DPALETTE */
#define CPALETTE 8   /* BOX in Baum DPALETTE */
#define RSET     10  /* BOX in Baum DPALETTE */
#define GSET     16  /* BOX in Baum DPALETTE */
#define BSET     22  /* BOX in Baum DPALETTE */
#define ISET     28  /* BOX in Baum DPALETTE */
#define PICCOPY  34  /* BOX in Baum DPALETTE */
#define PICDISK  35  /* ICON in Baum DPALETTE */
#define PICSAFE  36  /* ICON in Baum DPALETTE */
#define PICPAL   37  /* ICON in Baum DPALETTE */
#define PICSTDPAL 38  /* ICON in Baum DPALETTE */
#define PICGS    39  /* ICON in Baum DPALETTE */
#define BIGBOX   40  /* BOX in Baum DPALETTE */
#define PWINDSEL 41  /* BOX in Baum DPALETTE */
#define PICMATSC 42  /* ICON in Baum DPALETTE */
#define PICPAR   43  /* ICON in Baum DPALETTE */
#define PICCAL   44  /* ICON in Baum DPALETTE */
#define CONTTO   46  /* BOX in Baum DPALETTE */
#define CONTFROM 47  /* BOX in Baum DPALETTE */
#define DOCONT   48  /* ICON in Baum DPALETTE */

#define DIALINFO 1   /* Formular/Dialog */
#define INFOBOX  0   /* BOX in Baum DIALINFO */
#define TVERSION 4   /* STRING in Baum DIALINFO */

#define DSCREEN  2   /* Formular/Dialog */
#define SCRFRAME 0   /* BOX in Baum DSCREEN */
#define XYBOX    1   /* BOX in Baum DSCREEN */
#define MXYSET   2   /* BOX in Baum DSCREEN */
#define XDOWN    3   /* BOXCHAR in Baum DSCREEN */
#define XBAR     4   /* BOXTEXT in Baum DSCREEN */
#define XSLIDER  5   /* BOXTEXT in Baum DSCREEN */
#define XUP      6   /* BOXCHAR in Baum DSCREEN */
#define XVALUE   7   /* BOXTEXT in Baum DSCREEN */
#define MYVALUE  9   /* BOXTEXT in Baum DSCREEN */
#define YDOWN    10  /* BOXCHAR in Baum DSCREEN */
#define YBAR     11  /* BOXTEXT in Baum DSCREEN */
#define YSLIDER  12  /* BOXTEXT in Baum DSCREEN */
#define YUP      13  /* BOXCHAR in Baum DSCREEN */
#define VXYSET   14  /* BOX in Baum DSCREEN */
#define VXDOWN   15  /* BOXCHAR in Baum DSCREEN */
#define VXBAR    16  /* BOXTEXT in Baum DSCREEN */
#define VXSLIDER 17  /* BOXTEXT in Baum DSCREEN */
#define VXUP     18  /* BOXCHAR in Baum DSCREEN */
#define VXVALUE  19  /* BOXTEXT in Baum DSCREEN */
#define VYVALUE  21  /* BOXTEXT in Baum DSCREEN */
#define VYDOWN   22  /* BOXCHAR in Baum DSCREEN */
#define VYBAR    23  /* BOXTEXT in Baum DSCREEN */
#define VYSLIDER 24  /* BOXTEXT in Baum DSCREEN */
#define VYUP     25  /* BOXCHAR in Baum DSCREEN */
#define PARWSEL  26  /* BOX in Baum DSCREEN */
#define SICMATSC 27  /* ICON in Baum DSCREEN */
#define SICPAL   28  /* ICON in Baum DSCREEN */
#define SCRLIMIT 29  /* BOX in Baum DSCREEN */
#define SCRTIME  30  /* BOX in Baum DSCREEN */
#define TIMECOR  31  /* BOX in Baum DSCREEN */
#define TIMEBOT  32  /* BOX in Baum DSCREEN */
#define TIMERIG  33  /* BOX in Baum DSCREEN */
#define SCRDISP  34  /* BOX in Baum DSCREEN */
#define DISPCOR  35  /* BOX in Baum DSCREEN */
#define DISPBOT  36  /* BOX in Baum DSCREEN */
#define DISPRIG  37  /* BOX in Baum DSCREEN */
#define DISPLEF  38  /* BOX in Baum DSCREEN */
#define DISPTOP  39  /* BOX in Baum DSCREEN */
#define PARFRAME 40  /* BOX in Baum DSCREEN */
#define HFSET    41  /* BOX in Baum DSCREEN */
#define HFDOWN   42  /* BOXCHAR in Baum DSCREEN */
#define HFBAR    43  /* BOXTEXT in Baum DSCREEN */
#define HFSLIDER 44  /* BOXTEXT in Baum DSCREEN */
#define HFUP     45  /* BOXCHAR in Baum DSCREEN */
#define HFVALUE  46  /* BOXTEXT in Baum DSCREEN */
#define VFSET    47  /* BOX in Baum DSCREEN */
#define VFDOWN   48  /* BOXCHAR in Baum DSCREEN */
#define VFBAR    49  /* BOXTEXT in Baum DSCREEN */
#define VFSLIDER 50  /* BOXTEXT in Baum DSCREEN */
#define VFUP     51  /* BOXCHAR in Baum DSCREEN */
#define VFVALUE  52  /* BOXTEXT in Baum DSCREEN */
#define HPSET    53  /* BOX in Baum DSCREEN */
#define HPDOWN   54  /* BOXCHAR in Baum DSCREEN */
#define HPBAR    55  /* BOXTEXT in Baum DSCREEN */
#define HPSLIDER 56  /* BOXTEXT in Baum DSCREEN */
#define HPUP     57  /* BOXCHAR in Baum DSCREEN */
#define HPVALUE  58  /* BOXTEXT in Baum DSCREEN */
#define VPSET    59  /* BOX in Baum DSCREEN */
#define VPDOWN   60  /* BOXCHAR in Baum DSCREEN */
#define VPBAR    61  /* BOXTEXT in Baum DSCREEN */
#define VPSLIDER 62  /* BOXTEXT in Baum DSCREEN */
#define VPUP     63  /* BOXCHAR in Baum DSCREEN */
#define VPVALUE  64  /* BOXTEXT in Baum DSCREEN */
#define HSSET    65  /* BOX in Baum DSCREEN */
#define HSDOWN   66  /* BOXCHAR in Baum DSCREEN */
#define HSBAR    67  /* BOXTEXT in Baum DSCREEN */
#define HSSLIDER 68  /* BOXTEXT in Baum DSCREEN */
#define HSUP     69  /* BOXCHAR in Baum DSCREEN */
#define HSVALUE  70  /* BOXTEXT in Baum DSCREEN */
#define VSSET    71  /* BOX in Baum DSCREEN */
#define VSDOWN   72  /* BOXCHAR in Baum DSCREEN */
#define VSBAR    73  /* BOXTEXT in Baum DSCREEN */
#define VSSLIDER 74  /* BOXTEXT in Baum DSCREEN */
#define VSUP     75  /* BOXCHAR in Baum DSCREEN */
#define VSVALUE  76  /* BOXTEXT in Baum DSCREEN */
#define SCRPBOX  77  /* BOX in Baum DSCREEN */
#define ICINTERL 78  /* ICON in Baum DSCREEN */
#define ICGS     79  /* ICON in Baum DSCREEN */
#define ICVIRTU  80  /* ICON in Baum DSCREEN */
#define ICDUAL   81  /* ICON in Baum DSCREEN */
#define ICCXXREQ 82  /* ICON in Baum DSCREEN */
#define ICTSTPIC 83  /* ICON in Baum DSCREEN */
#define TXT_BRDVALUE 84  /* BUTTON in Baum DSCREEN */
#define TXT_MEMVALUE 85  /* BUTTON in Baum DSCREEN */
#define HFKHZ    86  /* FBOXTEXT in Baum DSCREEN */
#define VFHZ     87  /* FBOXTEXT in Baum DSCREEN */
#define ZOOMSET  88  /* BOX in Baum DSCREEN */
#define TXT_COLORS 94  /* FBOXTEXT in Baum DSCREEN */
#define TXT_SYNCPOL 95  /* FBOXTEXT in Baum DSCREEN */
#define TXT_GSVALUE 96  /* FBOXTEXT in Baum DSCREEN */
#define TXT_CLOCK 97  /* FBOXTEXT in Baum DSCREEN */
#define SCRCPYIC 98  /* BOX in Baum DSCREEN */
#define ICSCRDSK 99  /* ICON in Baum DSCREEN */
#define ICSCRSAF 100 /* ICON in Baum DSCREEN */
#define ICEDIT   101 /* ICON in Baum DSCREEN */
#define ICCXXSET 102 /* ICON in Baum DSCREEN */
#define ICCXXSEL 103 /* ICON in Baum DSCREEN */
#define ICRESET  104 /* ICON in Baum DSCREEN */
#define BOXNAME  105 /* FBOXTEXT in Baum DSCREEN */

#define EDITJINT 3   /* Formular/Dialog */
#define EDJIMIN  1   /* FBOXTEXT in Baum EDITJINT */
#define EDJIVAL  2   /* FBOXTEXT in Baum EDITJINT */
#define EDJIMAX  3   /* FBOXTEXT in Baum EDITJINT */
#define EDJIOK   4   /* BUTTON in Baum EDITJINT */
#define EDJIDIV  6   /* FBOXTEXT in Baum EDITJINT */

#define MESGBOX  4   /* Formular/Dialog */
#define MSGFRAME 0   /* BOX in Baum MESGBOX */
#define MSGTEXT  1   /* TEXT in Baum MESGBOX */
#define MESGOK   2   /* BOXTEXT in Baum MESGBOX */

#define DCALIB   5   /* Formular/Dialog */
#define CFRAME   0   /* BOX in Baum DCALIB */
#define CMATRIX  1   /* BOX in Baum DCALIB */
#define BXCUBE   2   /* BOX in Baum DCALIB */
#define CALPAL8  3   /* IBOX in Baum DCALIB */
#define COLCUW   4   /* BOXTEXT in Baum DCALIB */
#define COLCUBL  5   /* BOXTEXT in Baum DCALIB */
#define COLCUR   6   /* BOXTEXT in Baum DCALIB */
#define COLCUG   7   /* BOXTEXT in Baum DCALIB */
#define COLCUB   8   /* BOXTEXT in Baum DCALIB */
#define COLCUC   9   /* BOXTEXT in Baum DCALIB */
#define COLCUY   10  /* BOXTEXT in Baum DCALIB */
#define COLCUM   11  /* BOXTEXT in Baum DCALIB */
#define COLCAW   20  /* BOXTEXT in Baum DCALIB */
#define COLCABL  21  /* BOXTEXT in Baum DCALIB */
#define COLCAR   22  /* BOXTEXT in Baum DCALIB */
#define COLCAG   23  /* BOXTEXT in Baum DCALIB */
#define COLCAB   24  /* BOXTEXT in Baum DCALIB */
#define COLCAC   25  /* BOXTEXT in Baum DCALIB */
#define COLCAY   26  /* BOXTEXT in Baum DCALIB */
#define COLCAM   27  /* BOXTEXT in Baum DCALIB */
#define CICCUMINI 28  /* ICON in Baum DCALIB */
#define CICCUMAXI 29  /* ICON in Baum DCALIB */
#define BXGAMCAL 30  /* BOX in Baum DCALIB */
#define GAMSETR  31  /* BOX in Baum DCALIB */
#define GAMBRSETR 37  /* BOX in Baum DCALIB */
#define GAMSETG  43  /* BOX in Baum DCALIB */
#define GAMBRSETG 49  /* BOX in Baum DCALIB */
#define GAMSETB  55  /* BOX in Baum DCALIB */
#define GAMBRSETB 61  /* BOX in Baum DCALIB */
#define BXCBCAL  67  /* BOX in Baum DCALIB */
#define COSET    68  /* BOX in Baum DCALIB */
#define BRSET    74  /* BOX in Baum DCALIB */
#define BXCALSEL 80  /* BOX in Baum DCALIB */
#define CICGAMMA 81  /* IMAGE in Baum DCALIB */
#define CICBRCO  82  /* IMAGE in Baum DCALIB */
#define CICPALET 83  /* IMAGE in Baum DCALIB */
#define CICCUBE  84  /* IMAGE in Baum DCALIB */
#define CDISPSEL 85  /* BOX in Baum DCALIB */
#define CICCOLOR 86  /* ICON in Baum DCALIB */
#define CICCURVE 87  /* ICON in Baum DCALIB */
#define CICRED   88  /* ICON in Baum DCALIB */
#define CICGREEN 89  /* ICON in Baum DCALIB */
#define CICBLUE  90  /* ICON in Baum DCALIB */
#define CICCOPY  91  /* BOX in Baum DCALIB */
#define CICDISK  92  /* ICON in Baum DCALIB */
#define CICSAFE  93  /* ICON in Baum DCALIB */
#define CICCAL   94  /* ICON in Baum DCALIB */
#define CICMETH  95  /* ICON in Baum DCALIB */
#define CWINDSEL 96  /* BOX in Baum DCALIB */
#define CICPAR   97  /* ICON in Baum DCALIB */
#define CICPAL   98  /* ICON in Baum DCALIB */
#define BXMINMAX 99  /* BOX in Baum DCALIB */
#define CICMINI  100 /* ICON in Baum DCALIB */
#define CICMAXI  101 /* ICON in Baum DCALIB */

#define TRMENU   6   /* Menuebaum */
#define TITDESK  3   /* TITLE in Baum TRMENU */
#define TITFILE  4   /* TITLE in Baum TRMENU */
#define TITWIND  5   /* TITLE in Baum TRMENU */
#define MENINFO  8   /* STRING in Baum TRMENU */
#define MENQUIT  17  /* STRING in Baum TRMENU */
#define MENPAL   19  /* STRING in Baum TRMENU */
#define MENPAR   20  /* STRING in Baum TRMENU */
#define MENCAL   21  /* STRING in Baum TRMENU */

#define DRESTART 7   /* Formular/Dialog */
#define BURESABO 1   /* BUTTON in Baum DRESTART */
#define BUNEWRES 2   /* BUTTON in Baum DRESTART */
#define BURESET  3   /* BUTTON in Baum DRESTART */

#define TRIMAGE  8   /* Formular/Dialog */
#define ICM      1   /* ICON in Baum TRIMAGE */

#define POPUP    9   /* Formular/Dialog */
#define PUP_DUMMY 1   /* IBOX in Baum POPUP */
#define PUP_COLORS 26  /* IBOX in Baum POPUP */
