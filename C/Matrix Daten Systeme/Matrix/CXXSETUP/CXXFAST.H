extern int scale(int a, int b, int c);
extern int round_mul(int val, int multiple);

