/* testfast.h	/	10.7.91	/	MATRIX	/	WA	*/

extern TEST_TYPE test_pattern ( int i, unsigned long j, TEST_TYPE *p ) ;
