# ifndef __AESUTILS__
# include "\pc\cxxsetup\aesutils.h"
# endif

extern bool set_back_buffer_usage ( bool set ) ;
extern void save_background ( TRectangle *rect ) ;
extern void restore_background ( TRectangle *r ) ;

