extern void print_lina_fonts ( LINEA *l, VDIESC *v ) ;
extern void print_font( FONT_HDR *fbase ) ;
extern void print_fonts ( FONTS *f ) ;
extern void print_vdi_esc ( LINEA *l, VDIESC *v ) ;
extern void print_line_a ( LINEA *l ) ;
