void *vbl_xbra ( ulong magic ) ;
void *inst_vbl_rout ( void vbl_rout() ) ;
