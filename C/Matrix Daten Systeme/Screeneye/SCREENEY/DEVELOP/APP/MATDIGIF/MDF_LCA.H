typedef enum { DIGcolor, DIGyc, DIGgrey } TDigitiserMode ;
