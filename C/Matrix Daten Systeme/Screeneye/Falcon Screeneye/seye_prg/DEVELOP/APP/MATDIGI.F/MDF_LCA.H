/********************************************************************/
/*																	*/
/* 	ScreenEye Interface : digitiser logic definitions				*/
/*																	*/
/*	mdf_lca.h / 15.4.94												*/
/*																	*/
/*  (c) 1994 Matrix Daten Systeme GmbH								*/
/*		Talstr. 16, D-71570 Oppenweiler								*/
/*																	*/
/********************************************************************/


typedef enum { DIGcolor, DIGyc, DIGgrey, DIGcolor8, DIGgrey8, DIGgrey7 } TDigitiserMode ;
