# define FW	32
# define FH	32

extern MFDB fract_mfdb ;
