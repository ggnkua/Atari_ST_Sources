/* tc_dra[w].h	/ MATRIX / WA /	23.7.91		*/

# define TITEL		"MATRIX TC-DRAW"
# define VERSION	"0.2"

