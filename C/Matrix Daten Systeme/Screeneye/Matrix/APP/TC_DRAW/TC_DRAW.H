/* Resource Datei Indizes f�r TC_DRAW */

#define TR_MENU  0   /* Menuebaum */
#define TI_DESK  3   /* TITLE in Baum TR_MENU */
#define TI_FILE  4   /* TITLE in Baum TR_MENU */
#define TI_TOOLS 5   /* TITLE in Baum TR_MENU */
#define MN_INFO  8   /* STRING in Baum TR_MENU */
#define MN_LDCFG 17  /* STRING in Baum TR_MENU */
#define MN_STCFG 18  /* STRING in Baum TR_MENU */
#define MN_QUIT  20  /* STRING in Baum TR_MENU */
#define MT_SELCT 22  /* STRING in Baum TR_MENU */
#define MT_HELP  23  /* STRING in Baum TR_MENU */
#define MT_GNRAL 25  /* STRING in Baum TR_MENU */
#define MT_PALET 26  /* STRING in Baum TR_MENU */
#define MT_VDI   27  /* STRING in Baum TR_MENU */
#define MT_FILTR 28  /* STRING in Baum TR_MENU */
#define MT_HISTO 29  /* STRING in Baum TR_MENU */
#define MT_RUNS  30  /* STRING in Baum TR_MENU */
#define MT_COPY  31  /* STRING in Baum TR_MENU */
#define MT_WIND  32  /* STRING in Baum TR_MENU */
#define MT_DEMO  33  /* STRING in Baum TR_MENU */
#define MT_VIDEO 34  /* STRING in Baum TR_MENU */
#define MT_TVPAR 35  /* STRING in Baum TR_MENU */
#define MT_DISK  36  /* STRING in Baum TR_MENU */

#define TR_DRWIN 1   /* Formular/Dialog */
#define BX_DRWIN 0   /* BOX in Baum TR_DRWIN */
#define BX_CANVS 1   /* IBOX in Baum TR_DRWIN */
#define BT_FILTR 2   /* BOX in Baum TR_DRWIN */
#define CL_FILTR 3   /* BOXCHAR in Baum TR_DRWIN */
#define IC_GRAY  4   /* ICON in Baum TR_DRWIN */
#define PO_R_MSK 5   /* IBOX in Baum TR_DRWIN */
#define IC_PSIM  11  /* ICON in Baum TR_DRWIN */
#define PO_G_MSK 12  /* IBOX in Baum TR_DRWIN */
#define PO_B_MSK 18  /* IBOX in Baum TR_DRWIN */
#define TX_GS    24  /* BOXTEXT in Baum TR_DRWIN */
#define IC_INV   25  /* ICON in Baum TR_DRWIN */
#define IC_FILTR 26  /* ICON in Baum TR_DRWIN */
#define IC_MAT   27  /* ICON in Baum TR_DRWIN */
#define TX_MAT   28  /* FBOXTEXT in Baum TR_DRWIN */
#define IC_CALIB 29  /* ICON in Baum TR_DRWIN */
#define IC_BRIGH 30  /* ICON in Baum TR_DRWIN */
#define BX_MAT   31  /* BOX in Baum TR_DRWIN */
#define M00      32  /* IBOX in Baum TR_DRWIN */
#define D00      33  /* BOXTEXT in Baum TR_DRWIN */
#define V00      34  /* BOXTEXT in Baum TR_DRWIN */
#define U00      35  /* BOXTEXT in Baum TR_DRWIN */
#define M01      36  /* IBOX in Baum TR_DRWIN */
#define V01      38  /* BOXTEXT in Baum TR_DRWIN */
#define M33      64  /* IBOX in Baum TR_DRWIN */
#define D33      65  /* BOXTEXT in Baum TR_DRWIN */
#define V33      66  /* BOXTEXT in Baum TR_DRWIN */
#define U33      67  /* BOXTEXT in Baum TR_DRWIN */
#define VA_MAOFS 68  /* IBOX in Baum TR_DRWIN */
#define VA_MASCA 72  /* IBOX in Baum TR_DRWIN */
#define IC_YUV   77  /* ICON in Baum TR_DRWIN */
#define BT_SELCT 78  /* BOX in Baum TR_DRWIN */
#define CL_SELCT 79  /* BOXCHAR in Baum TR_DRWIN */
#define IT_GNRAL 81  /* ICON in Baum TR_DRWIN */
#define IT_DISK  82  /* ICON in Baum TR_DRWIN */
#define IT_HELP  83  /* ICON in Baum TR_DRWIN */
#define IT_DEMO  84  /* ICON in Baum TR_DRWIN */
#define IT_FILTR 85  /* ICON in Baum TR_DRWIN */
#define IT_PALET 86  /* ICON in Baum TR_DRWIN */
#define IT_HISTO 87  /* ICON in Baum TR_DRWIN */
#define IT_RUNS  88  /* ICON in Baum TR_DRWIN */
#define IT_VIDEO 89  /* ICON in Baum TR_DRWIN */
#define IT_VDI   90  /* ICON in Baum TR_DRWIN */
#define IT_COPY  91  /* ICON in Baum TR_DRWIN */
#define IT_WIND  92  /* ICON in Baum TR_DRWIN */
#define IT_TVPAR 93  /* ICON in Baum TR_DRWIN */
#define BT_GNRAL 94  /* BOX in Baum TR_DRWIN */
#define CL_GNRAL 95  /* BOXCHAR in Baum TR_DRWIN */
#define TX_IMODE 97  /* FBOXTEXT in Baum TR_DRWIN */
#define IC_PUZZL 98  /* ICON in Baum TR_DRWIN */
#define IC_CLIP  99  /* ICON in Baum TR_DRWIN */
#define IC_GRID  100 /* ICON in Baum TR_DRWIN */
#define PO_XGRID 101 /* IBOX in Baum TR_DRWIN */
#define PO_YGRID 107 /* IBOX in Baum TR_DRWIN */
#define BT_PALET 113 /* BOX in Baum TR_DRWIN */
#define CL_PALET 114 /* BOXCHAR in Baum TR_DRWIN */
#define BX_BICOL 115 /* BOX in Baum TR_DRWIN */
#define PO_RED   117 /* IBOX in Baum TR_DRWIN */
#define PO_GREEN 123 /* IBOX in Baum TR_DRWIN */
#define PO_BLUE  129 /* IBOX in Baum TR_DRWIN */
#define PO_VDICO 135 /* IBOX in Baum TR_DRWIN */
#define BT_VDI   141 /* BOX in Baum TR_DRWIN */
#define CL_VDI   142 /* BOXCHAR in Baum TR_DRWIN */
#define BX_PATT  144 /* BOX in Baum TR_DRWIN */
#define IC_RECT  145 /* ICON in Baum TR_DRWIN */
#define IC_FILL  146 /* ICON in Baum TR_DRWIN */
#define IC_OLINE 147 /* ICON in Baum TR_DRWIN */
#define PO_OLINE 148 /* IBOX in Baum TR_DRWIN */
#define PO_PATT  154 /* IBOX in Baum TR_DRWIN */
#define IC_ERASE 160 /* ICON in Baum TR_DRWIN */
#define IC_LINE  161 /* ICON in Baum TR_DRWIN */
#define BX_LCOL  162 /* BOX in Baum TR_DRWIN */
#define IC_TEXT  163 /* ICON in Baum TR_DRWIN */
#define BX_TCOL  164 /* BOX in Baum TR_DRWIN */
#define IC_FRECT 165 /* ICON in Baum TR_DRWIN */
#define BX_FCOL  166 /* BOX in Baum TR_DRWIN */
#define TX_EFFCT 167 /* FBOXTEXT in Baum TR_DRWIN */
#define IC_CIRCL 168 /* ICON in Baum TR_DRWIN */
#define IC_DOT   169 /* ICON in Baum TR_DRWIN */
#define TX_WMODE 170 /* FBOXTEXT in Baum TR_DRWIN */
#define ICN_CLI  171 /* ICON in Baum TR_DRWIN */
#define BT_HISTO 172 /* BOX in Baum TR_DRWIN */
#define CL_HISTO 173 /* BOXCHAR in Baum TR_DRWIN */
#define BX_HISTO 174 /* BOX in Baum TR_DRWIN */
#define TX_HMAX  175 /* FBOXTEXT in Baum TR_DRWIN */
#define IC_HRECT 176 /* ICON in Baum TR_DRWIN */
#define IC_HLINE 177 /* ICON in Baum TR_DRWIN */
#define TX_HMIN  178 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_HXMIN 179 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_HXMAX 180 /* FBOXTEXT in Baum TR_DRWIN */
#define BT_DEMO  182 /* BOX in Baum TR_DRWIN */
#define CL_DEMO  183 /* BOXCHAR in Baum TR_DRWIN */
#define IC_RDEMO 184 /* ICON in Baum TR_DRWIN */
#define IC_LDEMO 185 /* ICON in Baum TR_DRWIN */
#define IC_CNDEM 186 /* ICON in Baum TR_DRWIN */
#define IC_BDEMO 187 /* ICON in Baum TR_DRWIN */
#define IC_SHOW  188 /* ICON in Baum TR_DRWIN */
#define PO_CNDEM 190 /* IBOX in Baum TR_DRWIN */
#define PO_ERDEM 196 /* IBOX in Baum TR_DRWIN */
#define IC_PALDEMO 202 /* ICON in Baum TR_DRWIN */
#define BT_DISK  203 /* BOX in Baum TR_DRWIN */
#define CL_DISK  204 /* BOXCHAR in Baum TR_DRWIN */
#define IC_LOAD  205 /* ICON in Baum TR_DRWIN */
#define IC_STORE 206 /* ICON in Baum TR_DRWIN */
#define TX_PFORM 207 /* BOXTEXT in Baum TR_DRWIN */
#define PO_TRCOL 208 /* IBOX in Baum TR_DRWIN */
#define BT_WIND  215 /* BOX in Baum TR_DRWIN */
#define CL_WIND  216 /* BOXCHAR in Baum TR_DRWIN */
#define BX_SAVE  217 /* BOX in Baum TR_DRWIN */
#define BT_COPY  219 /* BOX in Baum TR_DRWIN */
#define CL_COPY  220 /* BOXCHAR in Baum TR_DRWIN */
#define TX_BMODE 221 /* BOXTEXT in Baum TR_DRWIN */
#define IC_LUPE  222 /* ICON in Baum TR_DRWIN */
#define TX_GRAD  223 /* BOXTEXT in Baum TR_DRWIN */
#define IC_MIRR  224 /* ICON in Baum TR_DRWIN */
#define IC_COPY  225 /* ICON in Baum TR_DRWIN */
#define IC_DTOS  226 /* ICON in Baum TR_DRWIN */
#define IC_STOD  227 /* ICON in Baum TR_DRWIN */
#define IC_TOBOX 228 /* ICON in Baum TR_DRWIN */
#define IC_FRBOX 229 /* ICON in Baum TR_DRWIN */
#define BT_RUNS  231 /* BOX in Baum TR_DRWIN */
#define CL_RUNS  232 /* BOXCHAR in Baum TR_DRWIN */
#define TX_CSPAC 233 /* BOXTEXT in Baum TR_DRWIN */
#define IC_MRUN  234 /* ICON in Baum TR_DRWIN */
#define IC_FRUN  235 /* ICON in Baum TR_DRWIN */
#define IC_CRUN  236 /* ICON in Baum TR_DRWIN */
#define IC_4RUN  237 /* ICON in Baum TR_DRWIN */
#define IC_3RUN  238 /* ICON in Baum TR_DRWIN */
#define IC_CUBE  239 /* ICON in Baum TR_DRWIN */
#define IB_CUBE  240 /* IBOX in Baum TR_DRWIN */
#define IC_FRACT 241 /* ICON in Baum TR_DRWIN */
#define IB_FRACT 242 /* IBOX in Baum TR_DRWIN */
#define IC_RBOW  243 /* ICON in Baum TR_DRWIN */
#define IB_RBOW  244 /* IBOX in Baum TR_DRWIN */
#define BT_HELP  246 /* BOX in Baum TR_DRWIN */
#define CL_HELP  247 /* BOXCHAR in Baum TR_DRWIN */
#define IB_HELP  248 /* IBOX in Baum TR_DRWIN */
#define ST_X     250 /* STRING in Baum TR_DRWIN */
#define ST_Y     251 /* STRING in Baum TR_DRWIN */
#define ST_BPP   252 /* STRING in Baum TR_DRWIN */
#define BT_VIDEO 254 /* BOX in Baum TR_DRWIN */
#define CL_VIDEO 255 /* BOXCHAR in Baum TR_DRWIN */
#define TX_VSRC  256 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_DMODE 257 /* FBOXTEXT in Baum TR_DRWIN */
#define BU_VAUTO 259 /* BOXTEXT in Baum TR_DRWIN */
#define TX_CHAN  260 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_TVSTD 261 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_SIGT  262 /* FBOXTEXT in Baum TR_DRWIN */
#define IC_VIDEO 264 /* ICON in Baum TR_DRWIN */
#define IC_VSWI  265 /* ICON in Baum TR_DRWIN */
#define TXT_VFAC 266 /* FBOXTEXT in Baum TR_DRWIN */
#define IC_SNAP  267 /* ICON in Baum TR_DRWIN */
#define IC_ZAHN  268 /* ICON in Baum TR_DRWIN */
#define BT_TVPAR 269 /* BOX in Baum TR_DRWIN */
#define CL_TVPAR 270 /* BOXCHAR in Baum TR_DRWIN */
#define TX_APER  272 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_CORI  273 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_BPSS  274 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_PREF  275 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_CTRAP 276 /* FBOXTEXT in Baum TR_DRWIN */
#define TX_AGC   277 /* FBOXTEXT in Baum TR_DRWIN */
#define PO_SENS  278 /* IBOX in Baum TR_DRWIN */
#define BU_SDEF  285 /* BOXTEXT in Baum TR_DRWIN */
#define TX_INFO  286 /* FBOXTEXT in Baum TR_DRWIN */

#define TR_INFO  2   /* Formular/Dialog */

#define TR_POPUP 3   /* Formular/Dialog */
#define PU_WMODE 1   /* IBOX in Baum TR_POPUP */
#define PU_BMODE 6   /* IBOX in Baum TR_POPUP */
#define PU_IMODE 39  /* IBOX in Baum TR_POPUP */
#define PU_EFFCT 47  /* IBOX in Baum TR_POPUP */
#define PU_GS    54  /* IBOX in Baum TR_POPUP */
#define PU_CSPAC 61  /* IBOX in Baum TR_POPUP */
#define PU_MAT   64  /* IBOX in Baum TR_POPUP */
#define PU_COLRS 74  /* IBOX in Baum TR_POPUP */
#define PU_DUMMY 91  /* IBOX in Baum TR_POPUP */
#define PU_VSRC  116 /* IBOX in Baum TR_POPUP */
#define PU_APER  119 /* IBOX in Baum TR_POPUP */
#define PU_CHAN  124 /* IBOX in Baum TR_POPUP */
#define PU_TVSTD 129 /* IBOX in Baum TR_POPUP */
#define PU_CORI  134 /* IBOX in Baum TR_POPUP */
#define PU_SENS  139 /* IBOX in Baum TR_POPUP */
#define PU_PREF  143 /* IBOX in Baum TR_POPUP */
#define PU_SIGT  146 /* IBOX in Baum TR_POPUP */
#define POB_BAS  150 /* BUTTON in Baum TR_POPUP */
#define PU_DMODE 151 /* IBOX in Baum TR_POPUP */
#define POB_COL  152 /* BUTTON in Baum TR_POPUP */
#define POB_GREY 153 /* BUTTON in Baum TR_POPUP */
#define PU_BPSS  154 /* IBOX in Baum TR_POPUP */
#define PU_CTRAP 159 /* IBOX in Baum TR_POPUP */
#define POB_TON  160 /* BUTTON in Baum TR_POPUP */
#define POB_TOFF 161 /* BUTTON in Baum TR_POPUP */
#define PU_AGC   162 /* IBOX in Baum TR_POPUP */
#define PU_MIRR  167 /* IBOX in Baum TR_POPUP */
#define PM_POINT 168 /* BUTTON in Baum TR_POPUP */
#define PM_0     169 /* BUTTON in Baum TR_POPUP */
#define PM_45    170 /* BUTTON in Baum TR_POPUP */
#define PM_90    171 /* BUTTON in Baum TR_POPUP */
#define PM_135   172 /* BUTTON in Baum TR_POPUP */
#define PU_VIDSIZE 173 /* IBOX in Baum TR_POPUP */

#define EDITJINT 4   /* Formular/Dialog */

#define MESGBOX  5   /* Formular/Dialog */

#define TR_HELP  6   /* Formular/Dialog */
#define BX_HELP  0   /* BOX in Baum TR_HELP */
#define TXT_HELPHEAD 1   /* BOXTEXT in Baum TR_HELP */
#define BUT_HELP_END 2   /* BUTTON in Baum TR_HELP */
#define BX_HELPTXTFRAME 3   /* BOX in Baum TR_HELP */
#define ST_HMIN  4   /* STRING in Baum TR_HELP */
#define ST_HMAX  16  /* STRING in Baum TR_HELP */

#define MERKER   7   /* Formular/Dialog */
#define PO_COUNT 4   /* IBOX in Baum MERKER */
#define PO_VFAC  11  /* IBOX in Baum MERKER */

#define ST_SHOW  0   /* Freier String */
