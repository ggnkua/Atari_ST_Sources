
					R
			      / . \
			    /	.	\
			  /		. 	  \
			M		.		Y
			| \		.	  /	|
			|	\	.	/	|
			|	  \ . /		|
			|		W		|
			|		|		|
			|	  . | .		|
			|	.	|	.	|
			| .		|	  .	|
			B		|		G
			  \		|	  /
				\	|	/
				  \	| /
					C

					M---------------1
			      / .			  /	|			
			    /	.			/	|		I = ( R + G + B ) / 3
			  /		.		  /		|		I(0)	 =  0
			R---------------Y		|		I(R|G|B) = 1/3
			|		.		|		|		I(M|C|Y) = 2/3
			|		.		|		|		I(1)	 =  1
			|		.		|		|
			|		.		|		|
			|		B . . . | . . . C
			|	  .			|	  /
			|	.			|	/
			| .				| /
			0---------------G

									S = 1 - min(R,G,B)/I
				   					  = 1 - 3*min(R,G,B)/(R+G+B)
				   	   R
				     .	 .
				   .	   .
			     .			 .
			   .			   .
			 Y					 M
			 |					 |
			 |		  0/1		 |
			 |					 |
			 G					 B
			   .			   .
			     .			 .
				   .	   .
				     .	 .
				       C 
					
					
										