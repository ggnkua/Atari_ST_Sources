extern char *txttab_pic_format[] ;

extern char pic_path[], fullname[] ;

extern bool save_draw_window ( int *pts ) ;
extern bool LoadNamedPicFile ( char *name, int *pts ) ;
extern bool LoadPicture ( int *pts ) ;
