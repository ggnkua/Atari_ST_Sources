extern int run_demo ( int demo, int count, int erase_set, int *pts ) ;
