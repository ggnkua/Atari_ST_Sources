extern void matrix_filter ( long *pixa, int *matrix, int dx, int dy, int bpl ) ;
