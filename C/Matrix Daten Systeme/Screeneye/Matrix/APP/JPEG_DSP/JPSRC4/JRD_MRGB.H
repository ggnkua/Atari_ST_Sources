extern void set_compression_size ( char *start, int w, int h ) ;
