extern void InterPolate555 ( TImageWindow *source, TImageWindow *destin, POINT *zoom ) ;
extern void StretchBlit ( TImageWindow *source, TImageWindow *destin ) ;
extern void BlitFullSourceWindow ( TImageWindow *source, TImageWindow *destin ) ;

