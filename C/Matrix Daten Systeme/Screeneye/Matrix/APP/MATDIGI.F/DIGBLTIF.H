extern TBlitProcedure *GetBlitDigiToWindow ( TBlitWindow *blitwind, POINT *zoom,
											 TPictureFormat format ) ;
extern void BlitDigiToWindow ( TBlitWindow *blitwind, POINT *zoom ) ;
