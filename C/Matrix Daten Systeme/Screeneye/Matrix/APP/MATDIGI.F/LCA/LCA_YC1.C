# define BYTESinMAP	1853

/* info : mdf_9u1.rbt */

# include "\pc\app\xload\lcaload.h"

LCAdata lca_YC =
{
	3020,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xc0, 0x79, 0xf2, 0xec, 0xff, 0xff, 0xef, 0xff, 0xff, 0xdf, 0xe7, 0xff, 0x77, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xbf, 0xbf, 0xbb, 0xbf, 0xbf, 0xbb, 0xbb, 0xbf, 0xbe,
		 0xff, 0xf9, 0xff, 0xff, 0xff, 0xeb, 0xe3, 0xfb, 0xff, 0xfb, 0xcf, 0xff, 0xfb, 0xf9, 0xfb, 0xff,
		 0x7b, 0xf9, 0xff, 0x7e, 0xff, 0xce, 0xff, 0x7f, 0xef, 0xcf, 0xff, 0xff, 0xfb, 0xfb, 0xfb, 0xfb,
		 0x6b, 0xfb, 0xbb, 0xfb, 0x7a, 0xfb, 0x9f, 0xdf, 0xd7, 0xdf, 0xdf, 0xdb, 0xdf, 0xdf, 0xdf, 0xff,
		 0x7e, 0x5d, 0xed, 0x7f, 0x7d, 0x5f, 0x7d, 0xee, 0xfd, 0x87, 0xff, 0xff, 0xfd, 0xfd, 0xff, 0xdf,
		 0xcf, 0x4f, 0xbf, 0xef, 0xeb, 0xef, 0xef, 0xef, 0xef, 0xef, 0xef, 0xff, 0xfd, 0xff, 0xff, 0xff,
		 0xff, 0xef, 0xff, 0xdf, 0xdd, 0xee, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xb7, 0xf7, 0xf7, 0x7f, 0xff,
		 0xff, 0xfe, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xfe, 0xa3, 0xff, 0x5c, 0xd3, 0xf9, 0xbe, 0xfe, 0xbd,
		 0xf1, 0xdf, 0xff, 0xe7, 0x4d, 0x87, 0xef, 0xe7, 0x76, 0xe5, 0xff, 0xfe, 0x3f, 0xbf, 0xbd, 0x7d,
		 0xbd, 0xbd, 0x3d, 0xf5, 0xd7, 0xde, 0xd9, 0xc9, 0xf9, 0xdd, 0xef, 0xed, 0xe9, 0xbf, 0xbf, 0xcf,
		 0xff, 0xbf, 0xef, 0x9f, 0xed, 0x8f, 0xf7, 0xfd, 0x7d, 0xfe, 0xfa, 0xdb, 0x6a, 0x79, 0x7b, 0xda,
		 0xef, 0x7b, 0xf3, 0xeb, 0xde, 0xf6, 0xf3, 0xfb, 0xf3, 0x77, 0xdf, 0x9f, 0x9f, 0xff, 0xdf, 0x9f,
		 0xbf, 0x17, 0xdf, 0xeb, 0xb3, 0xff, 0xfa, 0xfb, 0xfa, 0xfb, 0xfa, 0xfa, 0x5e, 0xf7, 0xff, 0xf3,
		 0xf7, 0xf3, 0xf3, 0xf5, 0xf7, 0xff, 0xec, 0xfd, 0xfd, 0xbd, 0xfd, 0xfd, 0xfd, 0xbd, 0xdd, 0xd7,
		 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xfe, 0x3d, 0xee, 0xff, 0xef, 0xeb, 0xef, 0xef, 0xef,
		 0xef, 0xef, 0xdd, 0xfd, 0x7f, 0x7d, 0x7d, 0xfd, 0x7d, 0x7d, 0xfd, 0xef, 0xfb, 0xf3, 0xef, 0xe7,
		 0xeb, 0xe3, 0xc7, 0xf3, 0x7f, 0xde, 0x9f, 0xcf, 0xdf, 0x3f, 0x9f, 0xcf, 0xbf, 0xaf, 0xfb, 0xf7,
		 0xf4, 0xf9, 0xf3, 0xf9, 0xfa, 0xfe, 0xf4, 0xdf, 0x9f, 0xe7, 0xc6, 0x9d, 0xf7, 0x8d, 0xd7, 0xc7,
		 0xfc, 0xfe, 0x2f, 0xff, 0x3f, 0x9f, 0xfb, 0xbf, 0x2e, 0xfe, 0xf7, 0xef, 0xe9, 0xfd, 0x65, 0xfb,
		 0xfd, 0xfd, 0xe9, 0xbf, 0xff, 0xcf, 0x5b, 0xeb, 0xdf, 0x8b, 0xeb, 0xdf, 0xff, 0xfd, 0x7f, 0x36,
		 0x3c, 0x7e, 0x77, 0xfd, 0xfe, 0xfe, 0xef, 0xca, 0xcb, 0xc3, 0xfa, 0xeb, 0xfd, 0xbd, 0xce, 0x7f,
		 0x5f, 0x17, 0x5b, 0x3f, 0x3d, 0xf8, 0xff, 0xff, 0xfd, 0xeb, 0xb4, 0x67, 0xf6, 0xf6, 0xf7, 0xdf,
		 0xfc, 0xf6, 0xdf, 0xa7, 0xff, 0xbf, 0xeb, 0x77, 0xff, 0xe7, 0xfe, 0xff, 0x3e, 0xff, 0x56, 0xb7,
		 0xab, 0xf6, 0x2f, 0xff, 0xee, 0xf7, 0xc9, 0xef, 0xed, 0x6b, 0xe7, 0xdf, 0x79, 0xef, 0x3e, 0xaf,
		 0xcf, 0xcf, 0xeb, 0xcf, 0xff, 0xff, 0xff, 0xdf, 0x65, 0x5f, 0x7d, 0xfe, 0x7e, 0xfe, 0xff, 0xff,
		 0x7d, 0xaf, 0xeb, 0xf3, 0xeb, 0xb7, 0xeb, 0xff, 0xcb, 0xeb, 0x7b, 0xce, 0xdc, 0xdf, 0xde, 0xdf,
		 0xff, 0xdf, 0xdf, 0xe7, 0xfb, 0xf7, 0xf6, 0xb7, 0xf6, 0xf6, 0xff, 0xf7, 0x76, 0x5f, 0xfd, 0xfb,
		 0xf9, 0xfb, 0xff, 0xfa, 0xff, 0xfb, 0xf7, 0x98, 0xbf, 0xbf, 0xff, 0xbb, 0xff, 0xaf, 0x9f, 0xaf,
		 0xf7, 0xf5, 0xf6, 0xa5, 0xf5, 0xf7, 0xbf, 0xf5, 0xf7, 0xbf, 0xfd, 0xef, 0x8f, 0xef, 0xef, 0xff,
		 0xff, 0xbf, 0xff, 0xf9, 0x7f, 0x7c, 0x7d, 0x7f, 0xfc, 0xff, 0xff, 0xff, 0xee, 0xf3, 0xd7, 0xeb,
		 0x7b, 0xd7, 0xff, 0xd2, 0xcf, 0x7f, 0x17, 0xdf, 0x6f, 0x55, 0xdf, 0xff, 0x0f, 0x7e, 0xff, 0xfb,
		 0xfb, 0xff, 0xfb, 0xfa, 0xff, 0x7f, 0xfc, 0xf9, 0xdf, 0xff, 0x9d, 0x7f, 0xf7, 0x9d, 0x7f, 0x87,
		 0x9b, 0xff, 0xce, 0x2f, 0xaf, 0xae, 0x1f, 0xdf, 0xff, 0xdf, 0xff, 0xf7, 0xf7, 0xf5, 0xfb, 0x7d,
		 0xfd, 0xff, 0xdf, 0xb7, 0xbf, 0xee, 0xef, 0xaf, 0x0f, 0x3f, 0xfb, 0x8e, 0x0b, 0xff, 0x75, 0x6f,
		 0xbf, 0xf9, 0xfd, 0xf7, 0x7d, 0xfa, 0xbc, 0xaf, 0xdb, 0xd7, 0x1e, 0x5b, 0xff, 0xf6, 0xff, 0xfe,
		 0x7d, 0xdf, 0xbf, 0xce, 0xbf, 0xee, 0xfb, 0xfe, 0xbd, 0xff, 0xfb, 0xda, 0xfa, 0xba, 0xfa, 0xdc,
		 0xec, 0xdb, 0xfb, 0xdf, 0xb7, 0xb7, 0xaf, 0xaf, 0xef, 0xe7, 0xfc, 0xff, 0xff, 0x3e, 0x66, 0x3e,
		 0x3f, 0x37, 0xbf, 0x2f, 0x3d, 0x75, 0xf7, 0xf0, 0xf3, 0xf1, 0xf7, 0xf9, 0xf9, 0x78, 0xf9, 0xbd,
		 0x26, 0xb7, 0xae, 0xa7, 0xef, 0xcb, 0xaf, 0xa7, 0xef, 0x75, 0x7f, 0x7f, 0x7f, 0x3b, 0x7d, 0xff,
		 0xfe, 0xf6, 0xcf, 0xdb, 0xda, 0xda, 0xdb, 0xef, 0xff, 0xff, 0xff, 0x7f, 0xf5, 0xff, 0xf7, 0xff,
		 0xef, 0xff, 0xff, 0xf7, 0xff, 0x63, 0xfe, 0xbe, 0xee, 0xfe, 0xce, 0xee, 0xed, 0xed, 0xde, 0x96,
		 0xde, 0xef, 0xd7, 0xf3, 0xe7, 0xd7, 0xd7, 0xff, 0xbe, 0xbf, 0x3f, 0x37, 0x36, 0x3c, 0xbc, 0x3e,
		 0xff, 0xe7, 0xfd, 0xfd, 0x70, 0xf5, 0xf9, 0xf9, 0x79, 0x71, 0xbb, 0x6b, 0x7f, 0xfb, 0x2d, 0xcf,
		 0xce, 0xba, 0xf6, 0xfe, 0x6d, 0xfd, 0xfd, 0xed, 0x3c, 0x78, 0xb8, 0xf7, 0xff, 0xef, 0xf3, 0xe9,
		 0xff, 0xed, 0xdf, 0xff, 0xf5, 0xdf, 0x7e, 0x1f, 0xcc, 0x7e, 0xff, 0x5e, 0x7f, 0xef, 0xfd, 0xdf,
		 0xfb, 0xf6, 0xfc, 0xf4, 0xfe, 0xbf, 0xfb, 0x7c, 0xfc, 0xdf, 0xf7, 0xe7, 0xe5, 0xff, 0xdf, 0xfb,
		 0xc7, 0xc7, 0xe7, 0x3a, 0x28, 0x94, 0xf8, 0x7f, 0x2f, 0xff, 0x2e, 0x1b, 0xb7, 0xf1, 0xf5, 0xf1,
		 0x7f, 0xf9, 0xf9, 0xcf, 0xf9, 0xbb, 0xde, 0xff, 0xdf, 0x7f, 0x6e, 0x4f, 0x4f, 0x4f, 0xff, 0xf5,
		 0xaf, 0x7f, 0xff, 0xff, 0x3e, 0x5e, 0x7e, 0xfe, 0xef, 0xab, 0xaf, 0xfe, 0xfd, 0x36, 0x6f, 0x63,
		 0xef, 0x7e, 0xf7, 0xff, 0xff, 0xf3, 0xde, 0x7e, 0x1c, 0x7e, 0xfe, 0x7b, 0xd8, 0x9a, 0xf8, 0xff,
		 0xbc, 0xfb, 0x7b, 0x7b, 0x5f, 0xc7, 0xdf, 0xf7, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0x8a, 0xbe,
		 0x9e, 0xfa, 0xbf, 0xbe, 0x6e, 0xaf, 0xbe, 0xf7, 0xfd, 0xfd, 0xfd, 0xef, 0xfd, 0xed, 0xfd, 0xfd,
		 0x3d, 0x77, 0x7f, 0x7f, 0x6f, 0x67, 0x7f, 0x6f, 0x7f, 0xdf, 0xb5, 0x9f, 0xff, 0xff, 0xff, 0xef,
		 0xff, 0xff, 0xff, 0x8f, 0xfb, 0xf8, 0xfb, 0xba, 0xfa, 0xf8, 0x79, 0xfb, 0x7b, 0x5f, 0x5f, 0x5f,
		 0x7f, 0x5b, 0x5f, 0x5f, 0x5f, 0x9f, 0xfb, 0xf0, 0xbc, 0xf2, 0xbe, 0xd9, 0xff, 0xfb, 0xff, 0x9f,
		 0xe3, 0xc5, 0xe7, 0xf3, 0xf7, 0xff, 0xf5, 0xff, 0xff, 0x6a, 0x9d, 0x7d, 0xbd, 0xb7, 0xfc, 0xff,
		 0xfc, 0xbf, 0xf7, 0xe7, 0xe7, 0xf5, 0xfd, 0xe1, 0xbf, 0xe7, 0xff, 0xbf, 0xef, 0xcf, 0x3f, 0xef,
		 0xcf, 0xcf, 0xef, 0xcf, 0xff, 0xdd, 0x39, 0xf9, 0x59, 0x5f, 0x39, 0x7e, 0x79, 0xfe, 0xef, 0xf3,
		 0xe1, 0xe3, 0xea, 0xfb, 0xf3, 0xfa, 0xb2, 0x7e, 0x1f, 0x9f, 0xcf, 0xdf, 0xb7, 0x9f, 0xef, 0x9f,
		 0xbf, 0xbb, 0xad, 0xf1, 0x73, 0xf0, 0xfd, 0xf0, 0x6f, 0x7f, 0xdf, 0xf7, 0xd5, 0xdf, 0xc4, 0xdf,
		 0xe7, 0xff, 0xfd, 0xff, 0x3a, 0xad, 0xdd, 0xfd, 0xbd, 0x3d, 0xfd, 0xff, 0xff, 0xf7, 0xd9, 0xfb,
		 0xfe, 0xfd, 0xda, 0xf9, 0xdf, 0xff, 0xbf, 0x8f, 0x9f, 0xcd, 0xff, 0x9f, 0xff, 0xff, 0xfb, 0xfb,
		 0x7d, 0x73, 0x7b, 0xf2, 0x72, 0xf8, 0xfb, 0xdf, 0xff, 0xcf, 0xfb, 0xfb, 0xe3, 0xe3, 0xf7, 0x6d,
		 0xff, 0xff, 0x76, 0x75, 0x3f, 0x9f, 0x9f, 0xbf, 0xff, 0xff, 0xff, 0xdf, 0xeb, 0xb3, 0x7a, 0xfa,
		 0xec, 0xbb, 0xfb, 0xff, 0xff, 0x5e, 0xf7, 0xf7, 0xf7, 0xf6, 0xf7, 0xef, 0xff, 0xff, 0xff, 0xbe,
		 0xfd, 0xfd, 0x9d, 0xbd, 0xbd, 0xed, 0xff, 0x7f, 0xf7, 0xff, 0xff, 0xfe, 0xbf, 0xff, 0xff, 0xff,
		 0xff, 0xbd, 0xee, 0xe7, 0xef, 0xf7, 0xde, 0xee, 0xfb, 0xff, 0xef, 0xf1, 0x7d, 0x5d, 0xfd, 0x7d,
		 0x7e, 0xfd, 0xff, 0x7f, 0xef, 0xe3, 0xc3, 0xc3, 0xf3, 0xfa, 0xef, 0xff, 0xff, 0x7f, 0xff, 0xdf,
		 0x9f, 0x9f, 0x5f, 0xff, 0xff, 0xff, 0xbf, 0xfb, 0xf0, 0xfc, 0xfc, 0xdc, 0xde, 0xf3, 0xff, 0xff,
		 0xdf, 0x9d, 0x8f, 0xc5, 0xe7, 0xd7, 0xcf, 0xfb, 0xfe, 0xff, 0x7e, 0x1d, 0x3f, 0xd8, 0xbd, 0x7e,
		 0xfc, 0xff, 0xff, 0xf7, 0xed, 0xf4, 0x7f, 0x7f, 0xfd, 0xed, 0xff, 0xff, 0xbf, 0x9f, 0x8f, 0x8f,
		 0xff, 0xaf, 0xef, 0xfb, 0xff, 0xff, 0x7d, 0xff, 0xfc, 0xfd, 0x7f, 0xbf, 0xf7, 0xdf, 0xff, 0xef,
		 0xfb, 0x45, 0xf7, 0xc7, 0xff, 0xcf, 0xf1, 0xef, 0x7a, 0xbf, 0x1f, 0xdf, 0x5f, 0xff, 0x79, 0x1f,
		 0x7f, 0xbe, 0xfb, 0xf7, 0xff, 0xe7, 0xf7, 0xff, 0xf4, 0xf6, 0xb5, 0xdf, 0xff, 0x77, 0xfe, 0x7f,
		 0x7f, 0x67, 0xf7, 0xff, 0xff, 0x36, 0x9a, 0x7e, 0xe6, 0xf6, 0x3f, 0xbf, 0xf7, 0xfe, 0xf7, 0xe9,
		 0xd9, 0x6d, 0x65, 0xff, 0xa9, 0xcd, 0xef, 0xbf, 0x8b, 0x3f, 0x0f, 0xab, 0xff, 0xff, 0xc7, 0x3f,
		 0xff, 0x7d, 0xfc, 0x7e, 0x7e, 0xfe, 0xdf, 0x7f, 0xfe, 0x3f, 0xaf, 0xe9, 0xeb, 0xf3, 0xeb, 0xff,
		 0xcf, 0xeb, 0xeb, 0x7b, 0xdd, 0xdf, 0xd5, 0xdf, 0x7f, 0xbf, 0xd7, 0xcf, 0xfe, 0xf3, 0x76, 0xf7,
		 0xf6, 0xf6, 0xb2, 0xfe, 0xf7, 0xf7, 0xdd, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xfd, 0xfb, 0xf7,
		 0xba, 0x87, 0xff, 0x6b, 0x9f, 0xbb, 0xbb, 0xbf, 0xbf, 0xc7, 0xf5, 0xe5, 0xf4, 0xf5, 0xf7, 0xd5,
		 0xf5, 0xf5, 0xbf, 0xcf, 0x2f, 0x0f, 0xaf, 0xef, 0xcf, 0xcf, 0xff, 0xff, 0x7d, 0x5c, 0x7e, 0x5c,
		 0x5d, 0x5f, 0x7e, 0xfe, 0xff, 0xee, 0xd2, 0xdf, 0x73, 0xcb, 0x5b, 0xff, 0xfb, 0xff, 0x7f, 0x1f,
		 0x3e, 0x1f, 0x5f, 0xd8, 0x1f, 0x5f, 0x7f, 0xff, 0xfb, 0xed, 0xf9, 0xf3, 0xff, 0xfe, 0xfc, 0xfa,
		 0xfb, 0xdf, 0xb7, 0x87, 0xdd, 0xbf, 0xb7, 0xdf, 0xf7, 0xff, 0xff, 0xfe, 0xef, 0xef, 0xff, 0xbf,
		 0x3f, 0x3d, 0xdf, 0xff, 0xe7, 0xdf, 0xf5, 0x7f, 0xff, 0xfd, 0xf9, 0xf9, 0xdf, 0xbf, 0xde, 0xaf,
		 0x0b, 0xfa, 0xdf, 0x07, 0x8f, 0xdf, 0xff, 0xf5, 0x7e, 0x7b, 0xfd, 0xff, 0x7d, 0x7e, 0x78, 0xff,
		 0xef, 0xdf, 0xfb, 0xda, 0xff, 0xdb, 0xf2, 0x73, 0xfb, 0x7f, 0xff, 0xcf, 0xfc, 0xef, 0xbd, 0x9e,
		 0x9f, 0xad, 0xff, 0xfb, 0x79, 0xda, 0xe9, 0xfc, 0xd8, 0xac, 0xfc, 0x7c, 0xdf, 0xa3, 0xd7, 0x97,
		 0xe7, 0xa7, 0xe7, 0xe7, 0x77, 0xfd, 0x3c, 0xbc, 0x3e, 0x3e, 0xfe, 0x3d, 0x37, 0x3f, 0x7f, 0x57,
		 0xfb, 0x7d, 0xf9, 0xf9, 0xfb, 0xf9, 0xf9, 0xf9, 0xbd, 0xae, 0xdf, 0xaf, 0x3f, 0xaf, 0xaf, 0xcb,
		 0xe7, 0xef, 0x7d, 0xbf, 0x7e, 0x77, 0x7f, 0xff, 0x7d, 0xff, 0x7e, 0xcf, 0xda, 0xdb, 0xdf, 0xdb,
		 0xdf, 0xef, 0xff, 0xfa, 0x7f, 0xff, 0xe7, 0xff, 0xef, 0xf7, 0xff, 0xff, 0xfb, 0xdf, 0xeb, 0x6d,
		 0xee, 0xbe, 0xee, 0xbe, 0x7f, 0xfe, 0xed, 0x1e, 0xef, 0xd7, 0xd2, 0x67, 0xd7, 0xd7, 0xe5, 0x73,
		 0xff, 0x7e, 0x7e, 0x3f, 0xbe, 0x3f, 0x3e, 0xdf, 0x3c, 0xff, 0xf7, 0xfd, 0xfb, 0xf5, 0xfd, 0xf1,
		 0xf4, 0xf7, 0xfd, 0xbb, 0xaf, 0x49, 0xa9, 0xe7, 0x87, 0xef, 0xff, 0xcf, 0xff, 0xed, 0xfc, 0xfc,
		 0x7d, 0x7f, 0x7c, 0xff, 0xbd, 0xfe, 0xef, 0xe7, 0xe5, 0xff, 0xfb, 0xf7, 0xfb, 0xf3, 0xf7, 0x7f,
		 0xdd, 0xd7, 0x7c, 0xcf, 0x5f, 0xdf, 0x4f, 0xdf, 0xff, 0xfb, 0xfe, 0xff, 0xf2, 0xfe, 0xf6, 0xfe,
		 0xf4, 0xfe, 0x5f, 0xeb, 0xaf, 0xcf, 0xf7, 0x6f, 0x45, 0x67, 0xe7, 0xff, 0xfe, 0xef, 0xff, 0xbf,
		 0x7f, 0x3e, 0xbc, 0xde, 0xff, 0xf7, 0xf1, 0xff, 0xff, 0xfb, 0xed, 0xf1, 0xe5, 0xff, 0xbf, 0xcf,
		 0xff, 0xfe, 0x7f, 0xcf, 0xef, 0x4f, 0xff, 0xfd, 0xdd, 0xff, 0xff, 0xff, 0x7f, 0x7e, 0x7b, 0xfa,
		 0xff, 0xef, 0xe3, 0x6f, 0xa3, 0xff, 0xf3, 0xf3, 0xb3, 0xef, 0x7f, 0x7f, 0xfb, 0x9f, 0xff, 0x9e,
		 0x97, 0x9f, 0x7e, 0xff, 0xf3, 0xfb, 0xff, 0xfc, 0xfd, 0xfe, 0xfe, 0xf8, 0xfb, 0x5d, 0xe7, 0xdf,
		 0xc3, 0xf7, 0xef, 0xf7, 0xf3, 0xfb, 0xf7, 0xba, 0xfe, 0xbf, 0x9e, 0xfe, 0xbe, 0xbb, 0xfe, 0xbf,
		 0xe7, 0xfd, 0xf7, 0xdd, 0xfd, 0xfd, 0xfb, 0xfd, 0xff, 0xbf, 0x7f, 0x2f, 0x6f, 0x7f, 0xef, 0x6f,
		 0x67, 0x6f, 0xff, 0xf5, 0xff, 0xaf, 0xff, 0xff, 0xbf, 0xff, 0xff, 0x7f, 0xaf, 0xfb, 0x3b, 0xfb,
		 0x7b, 0xbd, 0xb7, 0xfb, 0xfb, 0x72, 0x5d, 0x5f, 0x9f, 0x5f, 0x4f, 0x5d, 0x5d, 0x7f, 0xff, 0xfb,
		 0xfc, 0xfc, 0xf1, 0xf2, 0xf9, 0xff, 0xf8, 0xfd, 0x9d, 0xdf, 0xe7, 0xf7, 0xcf, 0xd7, 0xff, 0xc7,
		 0xef, 0xed, 0xfe, 0x3d, 0xb5, 0xff, 0xff, 0x7c, 0x3f, 0x7c, 0xfd, 0xf7, 0xf9, 0xf9, 0xfb, 0xf7,
		 0xf3, 0xfb, 0xfc, 0xe3, 0xbf, 0xff, 0xff, 0xdf, 0xb7, 0x9f, 0xdf, 0xef, 0xff, 0xf7, 0x7d, 0xfa,
		 0x7b, 0xff, 0xff, 0xfb, 0x7e, 0xf9, 0xf9, 0xcf, 0xf3, 0xff, 0xfb, 0xf7, 0xfb, 0xff, 0xf3, 0xe7,
		 0x7f, 0xff, 0xed, 0xbf, 0xdf, 0xbf, 0xfa, 0x9f, 0xbf, 0xf7, 0xfb, 0xdf, 0xff, 0xff, 0xff, 0xfa,
		 0xfe, 0xff, 0xff, 0xdf, 0xbb, 0xbe, 0xbf, 0xbe, 0xbf, 0xb7, 0xbf, 0xbf, 0xff, 0xbc, 0xbd, 0xbd,
		 0xbd, 0xbd, 0xbd, 0xbd, 0xbd, 0xed, 0xf7, 0xf2, 0xba, 0xf2, 0xfa, 0xfa, 0xf8, 0xfa, 0x7a, 0xbe,
		 0x7f, 0x5f, 0x7f, 0xdf, 0xff, 0xff, 0xdf, 0xbf, 0xff, 0xbd, 0xfc, 0xfa, 0xf8, 0x7e, 0x7f, 0xff,
		 0xfe, 0xfe, 0xef, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;
