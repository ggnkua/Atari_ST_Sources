# define BYTESinMAP	1853

/* ScreenEye 3020 schneller 8 bit Grau-Modus	*/

/* info : mdf_l2g0.rbt */

# include "\pc\app\xload\lcaload.h"

LCAdata lca_G8 =
{
	3020,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xc0, 0x79, 0xf2, 0xec, 0xef, 0xf7, 0xdf, 0xff, 0xff, 0xff, 0xf7, 0xff, 0x77, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0x7f, 0xff, 0xff, 0xbf, 0xb7, 0xbf, 0xbf, 0xbf, 0xbf, 0xbf, 0xbf, 0xbf,
		 0xff, 0xf9, 0xff, 0xbb, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xcf, 0x7b, 0xfb, 0x5f, 0x7d, 0xf9,
		 0xfd, 0xf9, 0xfb, 0x7f, 0xff, 0xf7, 0xfe, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xfe, 0xfb, 0xfa, 0xfb,
		 0xeb, 0xfb, 0xca, 0xfb, 0xfb, 0xfb, 0x9f, 0x9f, 0xdf, 0xdf, 0xdf, 0xd3, 0xcf, 0x9f, 0xdf, 0xff,
		 0x7e, 0x7d, 0xfd, 0xef, 0x7d, 0xff, 0xfd, 0xfa, 0xfd, 0xa7, 0xff, 0xfd, 0xef, 0xef, 0xff, 0xfe,
		 0xfd, 0xdd, 0xbf, 0xef, 0xef, 0xef, 0xef, 0xef, 0xef, 0xef, 0xef, 0xff, 0xfd, 0xdf, 0xbf, 0xdf,
		 0xbf, 0xff, 0xed, 0xff, 0xff, 0xee, 0xf7, 0xf7, 0xf7, 0xf5, 0xf7, 0xf7, 0xf6, 0xf7, 0x7f, 0xff,
		 0xff, 0xff, 0xff, 0xdf, 0xee, 0xff, 0xff, 0xff, 0xc3, 0xfa, 0xf2, 0xfe, 0xf9, 0xbd, 0xfe, 0xfb,
		 0xff, 0x9f, 0x97, 0xee, 0xef, 0x97, 0xe7, 0xd7, 0x9e, 0xfd, 0xff, 0xfe, 0xff, 0xe7, 0xff, 0xbf,
		 0xff, 0xbf, 0xff, 0xf7, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xff, 0xfd, 0xfb, 0xbf, 0xcf, 0xdc,
		 0xdf, 0xcf, 0xb7, 0x8e, 0xef, 0xdf, 0xff, 0x7d, 0x7e, 0x7f, 0x77, 0x76, 0x7f, 0x7e, 0xdf, 0xd7,
		 0xef, 0xea, 0xe2, 0xf3, 0xea, 0x73, 0x79, 0xe3, 0xfd, 0x77, 0xdf, 0x9f, 0x9f, 0xbf, 0x3f, 0x5f,
		 0x9f, 0xef, 0xdf, 0xeb, 0xfc, 0xfd, 0xf4, 0xbb, 0xfc, 0xbd, 0xfa, 0xfb, 0x5e, 0xf7, 0xb7, 0xb7,
		 0xf7, 0xf7, 0xb7, 0xd7, 0xf7, 0xff, 0xbc, 0xad, 0xbd, 0xbd, 0xbd, 0xbd, 0xfd, 0xfc, 0xfd, 0xd7,
		 0xef, 0xff, 0xfe, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xbd, 0xee, 0xfc, 0xfa, 0xe6, 0xec, 0xee, 0xee,
		 0xee, 0xef, 0xfd, 0x7d, 0xfd, 0x7d, 0x7a, 0x7d, 0x7d, 0xfd, 0xfd, 0xef, 0x7b, 0xeb, 0xe3, 0xcb,
		 0xf3, 0xfb, 0xf3, 0xcf, 0x7f, 0xde, 0x1f, 0x4f, 0x5f, 0x9f, 0xdf, 0x9f, 0x6f, 0xbf, 0xfb, 0xdc,
		 0xd8, 0xda, 0xde, 0x5d, 0xdc, 0xde, 0xb7, 0xdf, 0xc7, 0x96, 0xc7, 0xcf, 0xca, 0xc7, 0xd7, 0xcd,
		 0xfe, 0xfe, 0xfe, 0xbf, 0x7e, 0xfe, 0xfe, 0xbe, 0x7c, 0xfd, 0xf7, 0xf7, 0xf5, 0xff, 0xf4, 0xff,
		 0xf7, 0xf5, 0xe7, 0xbf, 0xef, 0xef, 0xff, 0xef, 0xeb, 0xae, 0xff, 0x3f, 0xff, 0x7d, 0xd5, 0x57,
		 0x7d, 0x7f, 0x7f, 0xff, 0xff, 0xfd, 0x6f, 0xfb, 0xe1, 0xfb, 0xcf, 0xf7, 0xfe, 0xed, 0xff, 0x7f,
		 0xbf, 0x5d, 0xfe, 0xdf, 0x5f, 0xfd, 0xf7, 0xfe, 0xff, 0x7b, 0xff, 0xdf, 0xff, 0xfe, 0xfe, 0xd6,
		 0xb7, 0xd7, 0xdf, 0xff, 0xf7, 0xf7, 0x7f, 0xef, 0xef, 0xff, 0xfb, 0xff, 0x7e, 0x3e, 0x3e, 0x7b,
		 0xb7, 0x7f, 0xfe, 0x3f, 0xee, 0x37, 0xd5, 0xf5, 0xdd, 0xf9, 0xfd, 0xed, 0xcf, 0xc1, 0x3f, 0x8f,
		 0xed, 0xaf, 0xcd, 0xeb, 0x8f, 0xff, 0xbf, 0xd7, 0x75, 0x7e, 0x7e, 0xfe, 0x7e, 0x7f, 0xfc, 0xff,
		 0x3f, 0xaf, 0xd3, 0xf3, 0xee, 0xeb, 0xeb, 0xeb, 0xeb, 0xeb, 0x7b, 0xdf, 0xbe, 0xbe, 0xb7, 0xb7,
		 0xde, 0xdf, 0xdc, 0xff, 0xfb, 0xb6, 0xf6, 0xb6, 0xf6, 0xb6, 0xf7, 0xf7, 0xf6, 0x5f, 0xff, 0xff,
		 0xff, 0xff, 0xfe, 0xff, 0xfe, 0xf9, 0xf7, 0xfa, 0xbb, 0x9b, 0xbb, 0xbb, 0xbb, 0xbf, 0x9f, 0xbf,
		 0xf7, 0xf7, 0xf7, 0xfd, 0xfd, 0x75, 0xf5, 0xf4, 0xf9, 0xbf, 0x8f, 0x8f, 0x8f, 0xcf, 0x0b, 0x0f,
		 0xff, 0xef, 0xff, 0x69, 0x7d, 0x5d, 0x7c, 0x7e, 0x7e, 0x7e, 0xfd, 0xdc, 0xee, 0x6b, 0x6b, 0x6b,
		 0x77, 0x7f, 0xfb, 0xfa, 0xd3, 0x7e, 0x17, 0x9f, 0x3f, 0x3f, 0x7f, 0x2f, 0xff, 0x1f, 0xfe, 0xfb,
		 0xfa, 0xfe, 0xfb, 0xbb, 0xf6, 0xf9, 0xff, 0xfc, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xf7, 0xf7,
		 0x87, 0xff, 0xfe, 0xff, 0x7e, 0xbf, 0xaf, 0xfd, 0xbf, 0x4f, 0xff, 0xf7, 0xf5, 0x5d, 0xfd, 0xdd,
		 0xfd, 0x7f, 0xf7, 0xfd, 0xbf, 0xdf, 0x9f, 0xaf, 0xef, 0xff, 0xfb, 0xd7, 0xcf, 0xff, 0x7d, 0x2f,
		 0xf3, 0x79, 0xfc, 0xf7, 0x77, 0x7f, 0xec, 0xef, 0xbf, 0xff, 0xff, 0xfb, 0xd7, 0xf3, 0xd3, 0xf7,
		 0x7b, 0xff, 0xff, 0xdf, 0xff, 0xdd, 0x9f, 0x9c, 0x9f, 0xff, 0xdb, 0xfe, 0xda, 0xec, 0xeb, 0xfe,
		 0xfc, 0xdc, 0xf8, 0xdf, 0xef, 0xed, 0xf7, 0xf7, 0xaf, 0x67, 0xa7, 0xcd, 0xff, 0x2e, 0x3f, 0xaf,
		 0x3e, 0xff, 0xff, 0xb7, 0x3f, 0x7e, 0xf7, 0xf9, 0xf1, 0xf9, 0xf5, 0xff, 0xff, 0xfb, 0xf9, 0xbd,
		 0xa6, 0xb7, 0x3f, 0xcf, 0xaf, 0xaf, 0xaf, 0xaf, 0xef, 0x55, 0xff, 0x72, 0x7f, 0x7f, 0x7f, 0x7f,
		 0x7f, 0xff, 0xcf, 0xdb, 0xdb, 0xda, 0xdb, 0xdf, 0xde, 0xdb, 0xdf, 0x7f, 0xfd, 0xf7, 0xff, 0xff,
		 0xef, 0xff, 0xef, 0xff, 0xff, 0xeb, 0xef, 0xee, 0xaf, 0x6e, 0xfe, 0xfe, 0x7e, 0xfe, 0xde, 0xef,
		 0xf7, 0xe5, 0xdf, 0xd7, 0xd7, 0xd7, 0xd7, 0xff, 0x3e, 0x3e, 0x3e, 0x3e, 0xfc, 0xde, 0x7f, 0x3e,
		 0xff, 0xe7, 0xf5, 0xf5, 0xf5, 0xf1, 0xff, 0xff, 0xfd, 0x73, 0xbb, 0xbb, 0xbd, 0xbd, 0xdd, 0x9d,
		 0x4f, 0x3f, 0x5f, 0xff, 0x7d, 0x7d, 0x3d, 0x7f, 0x5d, 0x7d, 0xfe, 0x79, 0xf8, 0xef, 0xeb, 0xeb,
		 0xfb, 0xef, 0xeb, 0xf3, 0xff, 0xd3, 0x7e, 0xff, 0xff, 0xef, 0xef, 0xb7, 0x97, 0x7e, 0x1e, 0xfe,
		 0xfb, 0xfe, 0xfe, 0xfa, 0xae, 0xff, 0xff, 0x7e, 0xf8, 0xdf, 0xe7, 0xe7, 0x67, 0xef, 0xff, 0xff,
		 0xef, 0xe7, 0xef, 0xbe, 0xee, 0xbe, 0x37, 0xfe, 0x3f, 0xff, 0xfe, 0x1f, 0xf7, 0xc1, 0xe5, 0x7b,
		 0xe5, 0xff, 0xf9, 0x6f, 0xdf, 0xbd, 0xee, 0xef, 0xff, 0xff, 0xcf, 0x7d, 0xff, 0x4f, 0xff, 0xfd,
		 0xff, 0xff, 0x7f, 0x7b, 0xfe, 0xfb, 0x7f, 0xfe, 0xef, 0xef, 0xaa, 0xf7, 0xbb, 0xf3, 0x6b, 0xee,
		 0xf2, 0x7f, 0x5f, 0x9f, 0xdf, 0xff, 0x97, 0x53, 0x7e, 0x97, 0xfe, 0xfb, 0xfc, 0xdc, 0xfc, 0xbe,
		 0xff, 0xfa, 0xdb, 0xff, 0x5f, 0xf7, 0xd7, 0xe7, 0xe7, 0xff, 0xf7, 0xff, 0xff, 0xff, 0x3a, 0x9f,
		 0x3e, 0xff, 0xbe, 0xbe, 0xde, 0xaf, 0xbe, 0xf7, 0xfd, 0xfb, 0xed, 0xfd, 0xfd, 0xfd, 0xef, 0xfd,
		 0x3d, 0x6f, 0x6f, 0x6f, 0x6f, 0x7f, 0x6f, 0x6f, 0x7f, 0xdf, 0xf5, 0xff, 0xbf, 0xff, 0xff, 0xff,
		 0xfb, 0xff, 0xff, 0xaf, 0xbf, 0xbb, 0xbf, 0xbb, 0xfb, 0xfe, 0xfb, 0xfb, 0x7b, 0x7f, 0xff, 0x7f,
		 0x5f, 0x5f, 0xff, 0x5f, 0x5f, 0x97, 0xfb, 0xb8, 0xf8, 0xf8, 0xfa, 0xff, 0xbf, 0xb9, 0xff, 0x9f,
		 0xc7, 0xc7, 0xd7, 0xc7, 0xfb, 0xff, 0xf7, 0xff, 0xff, 0xaa, 0xb6, 0xb6, 0xb6, 0x36, 0xfd, 0x7d,
		 0x3c, 0xbf, 0xf7, 0xf3, 0xd3, 0xf1, 0xf7, 0xd1, 0xf7, 0xfa, 0xf1, 0xbf, 0x3f, 0xbf, 0xa7, 0xbf,
		 0xcf, 0x7f, 0xff, 0x8f, 0xff, 0xfd, 0xff, 0xdf, 0x7f, 0x7f, 0xda, 0xf9, 0x79, 0x7e, 0xef, 0xf7,
		 0xf7, 0xff, 0xf3, 0xdf, 0xdf, 0xff, 0xff, 0x7b, 0xdf, 0xd5, 0x5d, 0xd5, 0xff, 0xff, 0xff, 0xf7,
		 0xbf, 0xdb, 0xfe, 0xdf, 0xbe, 0xdd, 0x7f, 0x7d, 0xba, 0xbf, 0xdf, 0x67, 0xf3, 0xc7, 0xd7, 0x7f,
		 0xc6, 0x2f, 0xff, 0xff, 0xbe, 0xaf, 0xbf, 0xbf, 0x3f, 0x3b, 0x69, 0x39, 0xff, 0xf7, 0xdf, 0x7e,
		 0xdf, 0xdd, 0xf9, 0xfb, 0xfd, 0xf9, 0xbf, 0xff, 0xaf, 0xbe, 0xaf, 0xcf, 0x8e, 0xaf, 0x8b, 0xff,
		 0x7d, 0x7f, 0x76, 0x7f, 0x7f, 0x7e, 0xfa, 0x58, 0xfc, 0xcf, 0xf2, 0xf3, 0xf3, 0xcb, 0xff, 0xd1,
		 0xf7, 0xff, 0x77, 0xdd, 0x5f, 0x57, 0xbf, 0xff, 0x9f, 0xdf, 0xff, 0xdf, 0xeb, 0xfb, 0xfb, 0xfc,
		 0xfc, 0xba, 0xfa, 0xbd, 0xfc, 0xde, 0xf7, 0xef, 0xf7, 0xf7, 0xf7, 0xb7, 0xaf, 0xf7, 0xff, 0xbc,
		 0xbd, 0xbd, 0xbd, 0xfd, 0xfd, 0xbd, 0xbd, 0x7d, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xbd, 0xfe, 0xee, 0xfe, 0xee, 0xec, 0xef, 0xe7, 0xdf, 0xee, 0x71, 0x7d, 0xbf, 0xbd, 0x79,
		 0x7d, 0x7d, 0x7d, 0xf5, 0xee, 0xeb, 0xe1, 0xe3, 0xc3, 0xff, 0xe3, 0xcb, 0xfd, 0x7f, 0x1f, 0x1f,
		 0x1f, 0x9f, 0xff, 0x9f, 0x7f, 0xff, 0xbf, 0xfb, 0xda, 0x5a, 0xd9, 0xde, 0xf4, 0xf8, 0xf5, 0xff,
		 0xdf, 0xdd, 0xcb, 0x96, 0xce, 0x87, 0xc7, 0xc7, 0xdb, 0xff, 0xfe, 0xfe, 0xfe, 0x7f, 0x3e, 0x3f,
		 0xfe, 0x3e, 0xfd, 0xf7, 0xfd, 0x7e, 0xff, 0xf5, 0x69, 0xf9, 0xef, 0xf0, 0xbd, 0x8f, 0x9f, 0xef,
		 0xfb, 0xff, 0x9f, 0xfa, 0x4f, 0xdf, 0x79, 0x77, 0xff, 0xf6, 0xff, 0xef, 0xfe, 0x6f, 0xde, 0xae,
		 0xfb, 0xfe, 0xfb, 0xeb, 0x61, 0x47, 0xef, 0xfd, 0x7f, 0xbd, 0xdf, 0xbb, 0x3f, 0x9e, 0x2e, 0x7f,
		 0xfa, 0xff, 0xfb, 0xfd, 0xee, 0xfd, 0xff, 0xf4, 0xfd, 0xf7, 0xf7, 0xdf, 0xf7, 0xfb, 0xf7, 0xff,
		 0xe7, 0xaf, 0xbf, 0xff, 0xff, 0x3e, 0xbf, 0x3f, 0x7a, 0x3f, 0x7e, 0x6b, 0x7e, 0xfe, 0xf7, 0xf9,
		 0xf9, 0xf9, 0xfd, 0xe9, 0xfb, 0xec, 0xe7, 0xbf, 0x8f, 0x8f, 0xcf, 0x8f, 0xef, 0xdf, 0xff, 0xfb,
		 0xff, 0x7d, 0x7e, 0x7f, 0x7c, 0x7e, 0xfc, 0xfe, 0xfd, 0x3f, 0xaf, 0xeb, 0xef, 0xeb, 0xef, 0xeb,
		 0xeb, 0xef, 0xab, 0x7b, 0xdd, 0xbf, 0xb6, 0xbf, 0xdf, 0xdf, 0xbf, 0xd7, 0xff, 0xf3, 0xf6, 0xf6,
		 0xf6, 0xf6, 0xf7, 0xf6, 0xfe, 0xf6, 0xdd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xf7,
		 0xfa, 0xbb, 0xbb, 0xbb, 0xbb, 0xbf, 0xbb, 0xbb, 0xbf, 0xc7, 0xf5, 0xfd, 0xf5, 0xfd, 0xf5, 0xd7,
		 0xd5, 0xf5, 0xbf, 0xaf, 0x87, 0x87, 0xaf, 0xcf, 0x9f, 0x07, 0x37, 0xff, 0xfd, 0x7c, 0x7c, 0x7c,
		 0x7c, 0x7d, 0x7d, 0xfe, 0xbd, 0xee, 0x6e, 0x6b, 0x67, 0x63, 0xf3, 0xeb, 0xf7, 0xd7, 0x7f, 0xff,
		 0x2f, 0x5f, 0xdf, 0x1f, 0xb6, 0x3f, 0x77, 0xfe, 0xfb, 0xfd, 0xfb, 0xfb, 0xfe, 0xfc, 0xfd, 0xfe,
		 0xff, 0x5f, 0xf7, 0xff, 0xfd, 0xe7, 0xc7, 0xf7, 0xd5, 0x9d, 0xff, 0x3e, 0x7f, 0xbe, 0x3f, 0x3f,
		 0xaf, 0x2f, 0xf9, 0xff, 0xd7, 0xd9, 0xdd, 0xfb, 0xfd, 0xd9, 0xfb, 0xf9, 0xff, 0xbf, 0xce, 0xef,
		 0xef, 0xff, 0xff, 0xe7, 0xcb, 0xcf, 0xff, 0x79, 0x7e, 0x6e, 0xfe, 0xff, 0xff, 0x7e, 0x7e, 0xfe,
		 0xef, 0x93, 0xb3, 0xf3, 0xff, 0xf7, 0xd7, 0xfb, 0xb3, 0x7f, 0x9f, 0xdf, 0xdf, 0xff, 0xcf, 0xdf,
		 0xdf, 0x9f, 0xff, 0xfb, 0xfc, 0xee, 0xfe, 0xff, 0xff, 0xfe, 0xde, 0xff, 0xdf, 0xa7, 0xe7, 0xe7,
		 0xff, 0xff, 0xaf, 0xf7, 0xff, 0xff, 0x3c, 0x3f, 0x3f, 0xff, 0xff, 0x7f, 0x3f, 0xff, 0x7e, 0xd7,
		 0xf9, 0xfd, 0xfd, 0xff, 0xff, 0xfd, 0xf9, 0xff, 0xbd, 0xfe, 0xbf, 0xbf, 0xff, 0xaf, 0xaf, 0xbf,
		 0xaf, 0xef, 0xfd, 0xff, 0xfe, 0xfa, 0x7f, 0x7f, 0x7f, 0x7f, 0x7f, 0xcf, 0xdb, 0xdb, 0xdb, 0xff,
		 0xdf, 0xdf, 0xdf, 0xdf, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xeb, 0x6e,
		 0xee, 0xee, 0xff, 0xfe, 0x7e, 0x7e, 0xde, 0x1e, 0xd7, 0xdf, 0xdf, 0xff, 0xd7, 0xd7, 0xdf, 0xd7,
		 0xff, 0x3e, 0x3e, 0x3e, 0xfe, 0xff, 0xbc, 0x3f, 0xff, 0xff, 0xf7, 0xf1, 0xf5, 0xf5, 0xff, 0xff,
		 0xf3, 0xf8, 0xff, 0xbb, 0x9b, 0xbd, 0xbd, 0xfd, 0x7f, 0xdf, 0x6f, 0xff, 0xff, 0x7d, 0x79, 0x15,
		 0xfd, 0xff, 0x7d, 0x7f, 0xfd, 0xff, 0xef, 0xfb, 0xe9, 0xeb, 0xff, 0xeb, 0xd9, 0xeb, 0xf3, 0x7f,
		 0x3f, 0xf7, 0xff, 0xff, 0xbf, 0xae, 0xd7, 0x96, 0xff, 0xfb, 0xfc, 0xfe, 0xfe, 0xff, 0xff, 0xfd,
		 0xfc, 0xfc, 0xdf, 0xe7, 0xe7, 0xc7, 0xff, 0xfb, 0xf7, 0xe5, 0xe7, 0xff, 0xfe, 0xbf, 0xbf, 0xff,
		 0x3f, 0xbe, 0x3e, 0xaf, 0xff, 0xf7, 0xfe, 0xfb, 0xfb, 0xff, 0xe9, 0xed, 0xf9, 0xfd, 0xbf, 0xff,
		 0xdf, 0xdf, 0xff, 0xef, 0xcf, 0xfd, 0xcf, 0xf3, 0xfd, 0x6f, 0x7f, 0xff, 0x7f, 0x7f, 0xff, 0x7f,
		 0xfe, 0xef, 0xff, 0xe3, 0xf3, 0xff, 0xeb, 0xb3, 0xf3, 0xeb, 0x7f, 0xff, 0x1f, 0x9f, 0xff, 0x5f,
		 0xdf, 0xdf, 0x5f, 0xff, 0xf3, 0xff, 0xfc, 0xf8, 0xff, 0xf8, 0xfc, 0xfc, 0xfc, 0x5d, 0xff, 0xe7,
		 0xe7, 0xff, 0xe7, 0xe7, 0xe7, 0xe7, 0xf7, 0xfa, 0xbf, 0xbe, 0xfe, 0xbf, 0xbe, 0x3f, 0xfb, 0xbe,
		 0xf7, 0xff, 0xfd, 0xfd, 0xff, 0xfb, 0xf5, 0xfd, 0xf7, 0xbf, 0xff, 0x6f, 0x6f, 0xff, 0xff, 0xbf,
		 0xff, 0xbf, 0xff, 0xf5, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xaf, 0xff, 0xbb, 0xbb,
		 0xff, 0xb7, 0xbb, 0x3b, 0xbf, 0x7b, 0xfd, 0x7b, 0x7f, 0xff, 0x5f, 0xdf, 0x8f, 0x7f, 0xdf, 0xfb,
		 0xff, 0xfa, 0xfa, 0xff, 0x70, 0xfc, 0xf0, 0xfc, 0x9f, 0xff, 0xc7, 0xc7, 0xff, 0xc7, 0xc7, 0xc7,
		 0xe7, 0xef, 0xfe, 0x3f, 0x36, 0xf6, 0xbf, 0xbb, 0x3b, 0xbb, 0xfb, 0xf7, 0xff, 0xfd, 0xfd, 0xff,
		 0xfd, 0xf1, 0xf1, 0xfd, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xef, 0xef, 0x9f, 0xcf, 0xff, 0xfd, 0x7f,
		 0x7f, 0xff, 0x7f, 0x7e, 0xfc, 0x7e, 0xfe, 0xcf, 0xff, 0xeb, 0xeb, 0xff, 0xeb, 0xdb, 0xe3, 0xeb,
		 0x7f, 0xff, 0xff, 0xff, 0xff, 0x9f, 0xdf, 0x9f, 0xcf, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xdf, 0xbf, 0xbf, 0xbf, 0xbf, 0xb7, 0xb7, 0xbf, 0xbf, 0xff, 0xbc, 0xbd, 0xbd,
		 0xbd, 0xbd, 0xbd, 0xbd, 0xbd, 0xed, 0xf7, 0xfb, 0xfa, 0xfa, 0xea, 0xea, 0xfa, 0xfa, 0x7a, 0xbf,
		 0xff, 0xdf, 0xff, 0xdf, 0xff, 0xff, 0xdf, 0xbf, 0xff, 0xfd, 0xfe, 0xfe, 0xfe, 0x7e, 0x7f, 0xff,
		 0xfe, 0xfe, 0xef, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;