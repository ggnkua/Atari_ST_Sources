# define BYTESinMAP	2778

/* info : mdf_fc4.rbt */

/* color 8 bpp : rgb 3:3:2	*/

# include "\pc\app\xload\lcaload.h"

LCAdata mfp_C8 =
{
	3030,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xa0, 0x36, 0xf3, 0xec, 0xff, 0xff, 0xff, 0xff, 0xaf, 0xff, 0xef, 0xdf, 0xd7, 0xff,
		 0xef, 0xff, 0xff, 0xf7, 0xff, 0xff, 0xff, 0xfd, 0xef, 0xfd, 0xfd, 0xff, 0xee, 0xfe, 0xfe, 0xfe,
		 0xde, 0xfe, 0xfd, 0xfd, 0xfd, 0xfd, 0xfd, 0xcf, 0xff, 0xff, 0x7f, 0xfd, 0xff, 0x7f, 0xff, 0xff,
		 0xbf, 0xff, 0xff, 0xbc, 0xbf, 0xff, 0xff, 0xfd, 0x5f, 0xbf, 0xef, 0xbf, 0x7f, 0xff, 0xaf, 0xfb,
		 0x7b, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xff, 0xbf, 0xff, 0xfa, 0xde, 0xfe, 0xfe, 0xfa, 0xfe,
		 0xfd, 0xfd, 0xed, 0x7d, 0xfd, 0xcf, 0xef, 0xef, 0xeb, 0xcf, 0xe9, 0x9d, 0xdf, 0x9f, 0xd7, 0xdf,
		 0xff, 0x7e, 0x7f, 0xfd, 0xfd, 0x7f, 0xfd, 0xfe, 0xfb, 0xf3, 0xd4, 0xfa, 0x0f, 0xff, 0xfd, 0xdd,
		 0xff, 0xff, 0x77, 0xfb, 0xff, 0xff, 0xff, 0xff, 0x9e, 0xbf, 0x3f, 0xbf, 0xbf, 0x7b, 0x7f, 0x7f,
		 0x5e, 0x7f, 0xf7, 0xef, 0xff, 0xfd, 0xff, 0x7f, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xef, 0x7e,
		 0x7f, 0x5f, 0x7f, 0x7f, 0xff, 0xfe, 0xde, 0xfe, 0xfe, 0xfe, 0xef, 0xfd, 0xff, 0xdf, 0xff, 0xdf,
		 0xbd, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xf8, 0xbf, 0x2f, 0x9e, 0xbf, 0x3f, 0xbc, 0x37, 0xd8, 0x3f,
		 0xfe, 0xef, 0xff, 0xf3, 0xcb, 0xfb, 0xf7, 0x97, 0xfe, 0xc7, 0xff, 0x6d, 0xff, 0xfe, 0xbf, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0x7f, 0x7b, 0xe6, 0xae, 0xaf, 0xff, 0xff, 0xfb, 0xdf, 0xff, 0xf7, 0xff,
		 0x36, 0xe7, 0xe5, 0xff, 0xfe, 0xff, 0xbf, 0x6f, 0x5a, 0x7b, 0xe7, 0x6f, 0x7f, 0x5e, 0xbe, 0xef,
		 0xfc, 0xfb, 0xff, 0xf7, 0xfa, 0xff, 0xfd, 0xb7, 0xe7, 0xef, 0xfd, 0xfe, 0x3f, 0x9f, 0x37, 0x3f,
		 0x77, 0xff, 0x7f, 0x9e, 0xff, 0xfe, 0xee, 0xff, 0xfb, 0xf3, 0xe3, 0xf3, 0xe7, 0xff, 0xe5, 0xff,
		 0xe7, 0xf7, 0xfa, 0xff, 0xae, 0xfe, 0x2e, 0x7f, 0xdd, 0x7f, 0x7d, 0xf5, 0x7d, 0xaf, 0xff, 0xeb,
		 0x97, 0xfb, 0xfb, 0xef, 0xff, 0xf3, 0xd7, 0xf7, 0xff, 0xfc, 0xff, 0xbc, 0xbd, 0xbd, 0x7d, 0xfb,
		 0xff, 0xfb, 0xf9, 0xbb, 0xaf, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xbf, 0xfb, 0xf9, 0xff, 0xff, 0xf7,
		 0xea, 0xbf, 0xbb, 0xbb, 0xfb, 0x6b, 0xf7, 0x7f, 0x7f, 0x57, 0x7f, 0xef, 0xff, 0xef, 0xef, 0x77,
		 0xef, 0xdf, 0xfb, 0xd7, 0xd7, 0xdf, 0xfa, 0xfe, 0xbf, 0x3c, 0x7e, 0x3c, 0x7e, 0xfc, 0xff, 0xff,
		 0x7f, 0xfe, 0xcf, 0xff, 0xf3, 0xeb, 0xe3, 0xeb, 0xd7, 0xff, 0xff, 0xff, 0xcf, 0xed, 0xfe, 0xbf,
		 0xe7, 0x96, 0xb7, 0xe6, 0xad, 0x7f, 0x5f, 0xf6, 0xfa, 0xef, 0xff, 0xef, 0x6b, 0xef, 0xe2, 0xd6,
		 0xfe, 0xf7, 0xe3, 0xe7, 0xf7, 0xfe, 0xff, 0x9e, 0xfe, 0xbe, 0x7e, 0xfd, 0x7f, 0x3f, 0x7a, 0xfe,
		 0xef, 0xff, 0xbb, 0xff, 0xfb, 0xff, 0xfe, 0xfd, 0xd7, 0xe7, 0xaf, 0xff, 0xfe, 0x1f, 0xbf, 0x3f,
		 0xff, 0x7f, 0xfd, 0xff, 0xff, 0xdf, 0xbe, 0xef, 0xff, 0xeb, 0xa1, 0xe5, 0xfb, 0x63, 0xff, 0xff,
		 0xff, 0xe7, 0xff, 0xfe, 0x7f, 0x3f, 0x37, 0xbe, 0xbf, 0xf9, 0x3f, 0xff, 0xf9, 0xff, 0xef, 0xff,
		 0xf3, 0xfa, 0xdb, 0xfd, 0xd7, 0xfe, 0xff, 0xfc, 0xfd, 0xff, 0xfa, 0xb7, 0xff, 0xef, 0xfb, 0x7f,
		 0xff, 0xe7, 0x73, 0xfa, 0xf7, 0xef, 0xff, 0xff, 0xf7, 0x7b, 0xdb, 0xff, 0x7a, 0x77, 0xe7, 0xff,
		 0xff, 0xfe, 0xff, 0x7e, 0xbf, 0x3f, 0x7a, 0xf5, 0x7f, 0x7c, 0x5e, 0xbd, 0xef, 0xfe, 0xfb, 0xff,
		 0xff, 0xfb, 0xe7, 0xfe, 0x97, 0xa5, 0x5e, 0xfb, 0xfc, 0x3f, 0xbf, 0xbe, 0xbf, 0x6c, 0xfe, 0x2f,
		 0xef, 0xff, 0xfd, 0xae, 0xff, 0xe6, 0xf3, 0xf3, 0xf3, 0xd7, 0xff, 0xe7, 0xff, 0xf7, 0xf7, 0xfa,
		 0x7f, 0x6f, 0xbf, 0xfe, 0x7e, 0xdd, 0xd7, 0xdd, 0x7e, 0x7d, 0xef, 0xff, 0xfb, 0xfb, 0xfb, 0xf7,
		 0xef, 0xff, 0xf7, 0xf7, 0xf5, 0xff, 0xfe, 0xbf, 0xbd, 0xbd, 0xbd, 0x7d, 0xfb, 0xff, 0x7b, 0xfb,
		 0xfb, 0xaf, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xf8, 0xff, 0x9b,
		 0xab, 0xbb, 0x5b, 0xf7, 0x7f, 0x3f, 0x7f, 0x6f, 0xef, 0xff, 0xef, 0xef, 0xef, 0xfb, 0xff, 0xfd,
		 0xdf, 0xd7, 0xd7, 0xff, 0xfe, 0x3f, 0x3f, 0xbf, 0x3e, 0x7e, 0xfc, 0x7f, 0xb8, 0x5f, 0xf8, 0xcf,
		 0xff, 0xe3, 0xe3, 0xe3, 0xe3, 0xc7, 0xff, 0xd3, 0xdf, 0xc3, 0xed, 0xfe, 0xbf, 0xb7, 0xb7, 0xb6,
		 0x76, 0xed, 0x7f, 0x7f, 0xfb, 0xfb, 0xef, 0xff, 0xeb, 0xcb, 0xef, 0xe7, 0x4f, 0xff, 0xe7, 0xff,
		 0xd7, 0xf5, 0xfe, 0xff, 0xfe, 0xff, 0xfc, 0xfe, 0xfd, 0x7f, 0xff, 0xff, 0xfd, 0xef, 0xff, 0xff,
		 0xee, 0xfb, 0xfe, 0xff, 0xfd, 0xf9, 0x9d, 0xbf, 0xff, 0xfe, 0x7f, 0x7e, 0x3e, 0x7e, 0xff, 0xfe,
		 0xff, 0xfd, 0x1f, 0xfe, 0xef, 0xff, 0xf7, 0xf7, 0xfb, 0xfb, 0xf3, 0xff, 0xf7, 0xff, 0xc7, 0xff,
		 0xf6, 0x9f, 0xbf, 0x3f, 0xaf, 0x1f, 0xff, 0xff, 0x5f, 0xbe, 0xff, 0xef, 0xff, 0xab, 0xf7, 0xfb,
		 0xf7, 0xdf, 0xff, 0x7f, 0xe7, 0xdf, 0xff, 0xfe, 0xbf, 0xff, 0xf7, 0xff, 0xff, 0x7f, 0xfa, 0x7f,
		 0xfe, 0xbb, 0x6f, 0xff, 0xf7, 0xff, 0xdb, 0x9f, 0xf7, 0xa7, 0xfd, 0xe3, 0xef, 0xff, 0xfe, 0x7f,
		 0x7f, 0xbe, 0x7b, 0x7f, 0xde, 0x5f, 0x7e, 0xce, 0xdd, 0xef, 0xfd, 0xfb, 0xfa, 0xff, 0xfb, 0xf7,
		 0xbf, 0xe7, 0xe3, 0xbe, 0xff, 0xfc, 0xbf, 0x3f, 0xb7, 0x3e, 0x7e, 0xfd, 0x7d, 0x7c, 0xde, 0xf9,
		 0xae, 0xff, 0xfb, 0xe3, 0xf3, 0xf3, 0xe7, 0xff, 0xe5, 0xe7, 0xff, 0xf7, 0xfa, 0xff, 0x9e, 0x7e,
		 0xaf, 0x6c, 0x7d, 0x7d, 0x5d, 0x7d, 0x7d, 0xaf, 0xff, 0xfb, 0xf7, 0xfb, 0xbb, 0xaf, 0xf7, 0x6f,
		 0xb7, 0xf7, 0xf3, 0xfe, 0xbf, 0xbd, 0xbd, 0xbd, 0x7d, 0xfb, 0x7b, 0xfb, 0x7b, 0xbb, 0xaf, 0xff,
		 0xff, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xf9, 0xff, 0xff, 0xf7, 0xfa, 0xbf, 0xbb, 0xbb, 0xfb, 0x7b,
		 0x77, 0x7f, 0x77, 0x7f, 0x7f, 0xaf, 0xff, 0xfb, 0xfb, 0xeb, 0xf7, 0xff, 0xd7, 0x66, 0xd7, 0xd3,
		 0xf7, 0xfe, 0xbf, 0x3c, 0x3e, 0x2e, 0x7e, 0xf8, 0xff, 0x7f, 0xfe, 0xff, 0xcf, 0xff, 0xeb, 0xe3,
		 0xe3, 0xeb, 0xc7, 0xff, 0xff, 0xc5, 0xff, 0xef, 0xfe, 0x3f, 0x77, 0xb6, 0xf6, 0x76, 0xef, 0x7f,
		 0xfe, 0xfa, 0xdb, 0xef, 0xff, 0xe3, 0xeb, 0xe7, 0xeb, 0xef, 0xdf, 0xc2, 0x87, 0xcb, 0xf7, 0xfe,
		 0xff, 0xbf, 0xdf, 0xbe, 0xff, 0x7f, 0x7c, 0x7e, 0xfe, 0xfb, 0xef, 0xff, 0xef, 0xe7, 0xfe, 0xef,
		 0xdf, 0xe5, 0xc7, 0x8b, 0x3f, 0xff, 0xfe, 0x9f, 0x3d, 0x7d, 0xbf, 0xed, 0xfe, 0xff, 0x7b, 0xde,
		 0xfb, 0xef, 0xff, 0xab, 0xb3, 0xfb, 0xa3, 0xf3, 0xff, 0xff, 0xe3, 0x7f, 0xfe, 0xf0, 0xbf, 0xbf,
		 0x3e, 0xbf, 0x1f, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xaf, 0xff, 0xfb, 0xc7, 0xfb, 0xff, 0x6f, 0xef,
		 0xff, 0x5a, 0x7e, 0xfb, 0xfe, 0x7f, 0xf5, 0xdf, 0xfb, 0xff, 0xff, 0xfe, 0xff, 0xfb, 0xfb, 0xef,
		 0xff, 0xf7, 0xfd, 0xfb, 0xfb, 0xff, 0xef, 0xff, 0xff, 0xbf, 0xff, 0xfe, 0xa7, 0x5e, 0xbf, 0x3a,
		 0xea, 0xfe, 0xee, 0xfd, 0xff, 0xfd, 0xef, 0xff, 0xdb, 0x7b, 0xef, 0xeb, 0x77, 0xef, 0xff, 0xbf,
		 0x1d, 0xfd, 0xfe, 0x7f, 0x37, 0xbf, 0xbf, 0x7f, 0xfc, 0xbe, 0xe9, 0x9d, 0xfc, 0xee, 0xff, 0xe6,
		 0xf3, 0xf3, 0xf2, 0xe7, 0xef, 0xfb, 0xff, 0xff, 0xf3, 0xfa, 0xdf, 0xbe, 0x7e, 0xff, 0x5c, 0xfa,
		 0xdd, 0x3f, 0xf5, 0x7d, 0xaf, 0xdf, 0xfb, 0xfb, 0xf9, 0xf7, 0xb7, 0xf7, 0xff, 0xf6, 0xf7, 0xff,
		 0xfc, 0xbf, 0xfd, 0xbd, 0xad, 0x7d, 0xdb, 0x7b, 0xbb, 0x7b, 0xfb, 0xaf, 0xfe, 0xff, 0xff, 0xff,
		 0xff, 0xfd, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xf8, 0xbf, 0xbf, 0xbb, 0xbb, 0xfb, 0x77, 0x3f, 0x7f,
		 0x7f, 0x7f, 0xef, 0xff, 0xef, 0xe9, 0xeb, 0xfb, 0x9f, 0xdf, 0xd7, 0xd7, 0xdb, 0xff, 0xfe, 0x3f,
		 0x3f, 0x3e, 0x3e, 0x7e, 0xfc, 0xfe, 0xfd, 0xff, 0xff, 0xcf, 0xff, 0xf3, 0xe3, 0xe3, 0xe1, 0xd7,
		 0xed, 0xd7, 0xfb, 0xdf, 0xed, 0xfe, 0x7f, 0xbd, 0xb6, 0xb6, 0x66, 0xed, 0xfa, 0xf9, 0xff, 0xda,
		 0xef, 0xff, 0xe7, 0xc7, 0xe7, 0xe7, 0xc7, 0xeb, 0x7f, 0x97, 0xdf, 0xf7, 0xfe, 0xdf, 0xfe, 0xff,
		 0xfe, 0x7e, 0xbd, 0x3a, 0xfb, 0xfb, 0xdf, 0xef, 0xff, 0xde, 0xfb, 0xfe, 0xff, 0xff, 0xaf, 0x9d,
		 0xdd, 0xbd, 0xf7, 0xfe, 0x7f, 0x3f, 0x6f, 0x7f, 0xff, 0xbf, 0x7e, 0xdf, 0xdf, 0xf9, 0xee, 0xbf,
		 0xe7, 0xb9, 0xfb, 0xfa, 0xd3, 0xef, 0xf7, 0xff, 0xdf, 0xef, 0xe8, 0xbf, 0x5f, 0xbe, 0xfa, 0x37,
		 0xfe, 0xff, 0xff, 0x5f, 0x3f, 0xae, 0xbf, 0xab, 0xcb, 0xda, 0xfb, 0xf7, 0x7f, 0x7e, 0xff, 0xef,
		 0xef, 0x7e, 0x7d, 0xbd, 0xbf, 0x8f, 0xff, 0x7f, 0xfa, 0x7b, 0xfa, 0xfa, 0xef, 0xfb, 0xf5, 0xf7,
		 0xf9, 0xff, 0xf6, 0x67, 0xff, 0xa7, 0xf3, 0xff, 0xbe, 0xbf, 0x2e, 0x7a, 0xbe, 0x7a, 0x7d, 0xfe,
		 0x7f, 0x6e, 0xdd, 0xef, 0xd7, 0xcb, 0xe3, 0xfb, 0xb3, 0x7f, 0xa7, 0x3f, 0xa6, 0xaf, 0xff, 0xfe,
		 0x7f, 0x3f, 0xa6, 0x3f, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xfc, 0xaf, 0xff, 0xf7, 0xf3, 0xe7, 0xeb,
		 0xc6, 0xff, 0xff, 0xff, 0xd7, 0xff, 0xba, 0xbe, 0xbe, 0xbe, 0xee, 0xde, 0x7a, 0xfd, 0x5f, 0x5d,
		 0x76, 0xef, 0xfb, 0xfb, 0xfb, 0xf7, 0xf7, 0xf7, 0xf7, 0xbf, 0xf7, 0xef, 0xf7, 0xbc, 0xbd, 0xfd,
		 0xbd, 0xbd, 0x7d, 0xfb, 0xdb, 0xfb, 0x5b, 0xfb, 0xae, 0xff, 0xfd, 0xff, 0xfc, 0xff, 0xfd, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xba, 0xbf, 0xbf, 0xbb, 0xbb, 0xfb, 0x77, 0xff, 0x3f, 0x7f, 0x1f, 0xef,
		 0xeb, 0xeb, 0xeb, 0xef, 0xfb, 0x97, 0xd7, 0xfd, 0xd6, 0xdf, 0xe7, 0x7e, 0x3e, 0xbf, 0x3e, 0x3f,
		 0x7e, 0xfc, 0xff, 0xdf, 0xff, 0xff, 0xcf, 0xfb, 0xf3, 0xe7, 0xf3, 0xe3, 0xc7, 0xff, 0xff, 0xff,
		 0xcf, 0xff, 0xfa, 0x7c, 0x3d, 0xf6, 0xb7, 0xf6, 0x6c, 0xfe, 0x7f, 0xfe, 0x7a, 0xef, 0xcf, 0xe7,
		 0xcb, 0xcf, 0xe5, 0x97, 0xe7, 0xff, 0xc7, 0xf7, 0xf6, 0xfe, 0xff, 0xfe, 0x6b, 0xff, 0xde, 0x7b,
		 0xfe, 0x7f, 0x7c, 0xbb, 0xef, 0xcf, 0xdf, 0xea, 0xe9, 0xfd, 0xfe, 0xe7, 0xfd, 0xe5, 0xaf, 0xf7,
		 0xbe, 0x7f, 0xff, 0xbe, 0x7f, 0x7e, 0xfd, 0xff, 0xff, 0xff, 0xfe, 0xee, 0xf7, 0xf7, 0xff, 0xd7,
		 0xfb, 0xeb, 0xff, 0xff, 0xff, 0xf7, 0xef, 0xfe, 0x97, 0x7f, 0xfe, 0xdf, 0x3f, 0x7f, 0x5e, 0x7f,
		 0xfe, 0xd7, 0xef, 0xff, 0xbb, 0xcb, 0x7f, 0x7b, 0xef, 0xe7, 0xef, 0xe6, 0xdf, 0xff, 0xfe, 0xbf,
		 0xad, 0xdf, 0xbf, 0xfb, 0x7e, 0xfa, 0x3a, 0xfe, 0xfb, 0xef, 0xff, 0x7b, 0xd7, 0xff, 0xff, 0xf7,
		 0xe7, 0x77, 0xe7, 0xef, 0xff, 0xfe, 0x6f, 0x2f, 0xfe, 0xbf, 0x7f, 0xf4, 0x6d, 0xed, 0xf5, 0xff,
		 0xef, 0xff, 0xd7, 0xe3, 0xff, 0xf3, 0xe7, 0xbf, 0x0f, 0x5f, 0xbd, 0xff, 0xfc, 0x7f, 0x3e, 0xfe,
		 0x3f, 0x7e, 0xfe, 0xbf, 0xfe, 0xdf, 0xdd, 0xae, 0xff, 0xf7, 0xf3, 0xff, 0xfb, 0xc7, 0xdf, 0xf7,
		 0xff, 0xff, 0xf7, 0xfa, 0xdf, 0xbe, 0xfe, 0xff, 0x7e, 0x7d, 0x7d, 0x5e, 0x3d, 0x7d, 0xaf, 0xff,
		 0xfb, 0xcb, 0xff, 0xf7, 0xef, 0xf7, 0xef, 0xf7, 0xf7, 0xfb, 0xfe, 0xbf, 0xfd, 0xfc, 0xbf, 0x7d,
		 0xfb, 0x7b, 0x7b, 0x7b, 0xfb, 0xee, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff,
		 0xf7, 0xfa, 0xbf, 0xbf, 0xcb, 0xbf, 0x7b, 0x77, 0x7f, 0x3f, 0xf7, 0x7e, 0x8f, 0xff, 0xef, 0xeb,
		 0xff, 0xfb, 0xd7, 0xd7, 0xdf, 0x67, 0xd7, 0xf7, 0xfe, 0xbf, 0xbf, 0xfe, 0x2f, 0x7e, 0xfc, 0x7f,
		 0x79, 0xfd, 0xfd, 0xef, 0xff, 0xfb, 0xe7, 0xff, 0xe3, 0xc7, 0xff, 0xcf, 0xcf, 0xff, 0xef, 0xfe,
		 0xaf, 0x3d, 0xf6, 0xbf, 0xd6, 0xec, 0xff, 0xfa, 0xfc, 0xf9, 0xef, 0xff, 0xf9, 0xcb, 0xff, 0xc7,
		 0xd7, 0x7f, 0x8f, 0xf6, 0x9f, 0xf7, 0xfe, 0x3f, 0xff, 0xff, 0xff, 0xff, 0x7d, 0xfe, 0x5f, 0xff,
		 0xfe, 0xaf, 0xff, 0xd3, 0xeb, 0xfe, 0xef, 0xfe, 0xe7, 0xbf, 0xef, 0x9f, 0xff, 0xfe, 0x3f, 0xff,
		 0xfe, 0x7f, 0x7e, 0x7f, 0xfe, 0xdf, 0xfe, 0xff, 0xaf, 0xff, 0xb3, 0xff, 0xff, 0xbb, 0xeb, 0xe7,
		 0xfe, 0xf7, 0xed, 0xff, 0xfe, 0xdb, 0x2f, 0xfa, 0x7f, 0x1e, 0xff, 0x5f, 0x3e, 0xfe, 0xf7, 0xef,
		 0x7f, 0xe2, 0xc2, 0x63, 0xcb, 0xe7, 0x7f, 0xc7, 0xc6, 0xfe, 0xff, 0xfe, 0xff, 0x59, 0xdf, 0xbd,
		 0x7f, 0xfe, 0x7f, 0x7b, 0xff, 0xdf, 0xef, 0xff, 0xf3, 0xfb, 0xf3, 0xd7, 0xf7, 0x7f, 0xb7, 0xef,
		 0xff, 0xff, 0xfe, 0x3b, 0x3f, 0x3e, 0x3f, 0x7f, 0xff, 0x7f, 0x7e, 0xfd, 0xff, 0xef, 0xbf, 0xdf,
		 0xf3, 0xdf, 0xf2, 0xe7, 0xff, 0xa7, 0xcf, 0xff, 0xff, 0xfe, 0x37, 0x37, 0x3d, 0x3f, 0x7e, 0xfe,
		 0x7f, 0x7e, 0xfe, 0xff, 0xef, 0xff, 0xff, 0xf3, 0xff, 0xf3, 0xf7, 0xff, 0xe7, 0xe7, 0xff, 0xf5,
		 0xfa, 0xbf, 0x7e, 0xaf, 0xae, 0xde, 0xfd, 0x7f, 0xfd, 0xfd, 0x7f, 0xaf, 0xff, 0xfb, 0xb7, 0xfb,
		 0xdb, 0xaf, 0xff, 0xf7, 0xf7, 0xff, 0xff, 0xfc, 0xaf, 0xbd, 0xad, 0xfd, 0x7d, 0xfb, 0x5f, 0x7b,
		 0xff, 0xff, 0xee, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xf7, 0xfa, 0xbf,
		 0xbf, 0xbb, 0xbf, 0x7b, 0xf7, 0x7f, 0xff, 0xf7, 0x7f, 0x8f, 0xff, 0xeb, 0xeb, 0xeb, 0xeb, 0xdf,
		 0xfe, 0xd7, 0x67, 0xff, 0xff, 0xfe, 0x3f, 0x3f, 0x3e, 0xbf, 0x5e, 0xfc, 0xff, 0xfd, 0xd9, 0xff,
		 0xef, 0xff, 0xe9, 0xe3, 0xea, 0xe5, 0xd7, 0xff, 0xff, 0xff, 0xff, 0xef, 0xfe, 0xbf, 0x3d, 0xb6,
		 0x3d, 0xf6, 0xed, 0xff, 0x79, 0xfb, 0xff, 0xef, 0xff, 0xef, 0xe3, 0xef, 0xfb, 0xd7, 0xff, 0xdf,
		 0xdf, 0xff, 0xf7, 0xfe, 0xdf, 0xbe, 0xff, 0xfe, 0x7f, 0xfd, 0xbf, 0xfd, 0xff, 0xff, 0xef, 0xff,
		 0xdb, 0xf3, 0xdb, 0xea, 0xff, 0xff, 0xaf, 0x97, 0xff, 0xff, 0xfe, 0xbf, 0x6b, 0xbd, 0xff, 0x7e,
		 0xff, 0xff, 0xbf, 0xfb, 0xff, 0xef, 0x7f, 0xf3, 0xfa, 0xf2, 0xff, 0xc3, 0x7f, 0xfd, 0xff, 0xff,
		 0xff, 0xfe, 0xfb, 0x7f, 0x9e, 0x7f, 0x3e, 0x6f, 0x3f, 0x7c, 0xde, 0xff, 0x6f, 0xff, 0xb1, 0x4b,
		 0xfb, 0xcb, 0xe7, 0xf7, 0x87, 0xd7, 0xff, 0xff, 0xbe, 0xfd, 0xfd, 0xbf, 0xb1, 0x7f, 0x7e, 0x7e,
		 0x6f, 0xff, 0xff, 0xef, 0xf7, 0xf3, 0xff, 0xfb, 0x95, 0xf7, 0xf7, 0xef, 0xef, 0xff, 0xff, 0x7e,
		 0x2f, 0xaf, 0x76, 0x3f, 0x7e, 0x77, 0xf6, 0xfc, 0xfe, 0xff, 0xef, 0xdb, 0x5f, 0xe7, 0xd7, 0xe3,
		 0xe7, 0x77, 0xd7, 0xf7, 0xff, 0xff, 0xfc, 0x3f, 0x3f, 0x7e, 0x3e, 0x7e, 0x7e, 0x6e, 0x7c, 0xfc,
		 0xff, 0xae, 0xff, 0xff, 0xf3, 0xf7, 0xf3, 0xf7, 0xe7, 0xe7, 0xe7, 0xff, 0xf7, 0xba, 0xfe, 0xbe,
		 0xfe, 0xba, 0xfe, 0xfd, 0x5f, 0x5d, 0xfd, 0x7f, 0xaf, 0xfb, 0xfb, 0xfa, 0xfb, 0xe9, 0xef, 0xef,
		 0xef, 0xef, 0xfd, 0xf7, 0xbe, 0x9d, 0xfd, 0x9d, 0xfd, 0x7c, 0x7b, 0xff, 0xff, 0xff, 0xff, 0xaf,
		 0xff, 0x7f, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xbf, 0xbf, 0xbb, 0xbf,
		 0x7b, 0xf7, 0xf6, 0xf6, 0xf6, 0x7f, 0xaf, 0xeb, 0xef, 0xeb, 0xef, 0xeb, 0xdf, 0x5f, 0x53, 0x57,
		 0xff, 0xf7, 0xbe, 0x3f, 0x3e, 0xbe, 0xbf, 0x7e, 0x7c, 0x7e, 0x5e, 0xfe, 0xff, 0xcf, 0xe7, 0xfb,
		 0xe3, 0xfb, 0xe5, 0xd7, 0xd7, 0xe7, 0xe5, 0xfb, 0xef, 0xfe, 0xbd, 0x3c, 0xb6, 0x3d, 0xd6, 0x6d,
		 0x7e, 0x7f, 0xff, 0xff, 0xef, 0xff, 0xef, 0xcb, 0xf9, 0xfa, 0xd6, 0xf7, 0xef, 0xef, 0xff, 0xf7,
		 0xfe, 0xff, 0xfe, 0xfd, 0xfd, 0x7f, 0x7d, 0xff, 0xde, 0xfe, 0xff, 0xef, 0xdf, 0xda, 0xeb, 0xdf,
		 0xeb, 0xff, 0xe7, 0xe7, 0xf7, 0xff, 0xff, 0x7e, 0xbf, 0xbe, 0xff, 0xee, 0x7e, 0x7f, 0x7f, 0x7d,
		 0xff, 0xff, 0xef, 0xfb, 0xf3, 0xe7, 0xbf, 0xfd, 0xe3, 0xc7, 0xe7, 0xe7, 0xff, 0xff, 0x3a, 0xbf,
		 0x7f, 0xfe, 0x2f, 0x3f, 0x3f, 0xff, 0xdf, 0xbf, 0xff, 0xcf, 0xf3, 0xab, 0x8a, 0xfd, 0xfb, 0x47,
		 0xef, 0xfe, 0x7f, 0xff, 0xff, 0x3e, 0xad, 0xfd, 0xff, 0xfd, 0x7f, 0xfe, 0xfa, 0xff, 0xff, 0xff,
		 0xef, 0x93, 0xbb, 0xbf, 0xbf, 0xbb, 0xb7, 0xf7, 0xff, 0xff, 0xff, 0xff, 0x3e, 0x77, 0xbe, 0x3e,
		 0x3e, 0x7e, 0x7f, 0xf5, 0xff, 0xdf, 0xff, 0xef, 0xd3, 0xc7, 0xe7, 0xd3, 0xeb, 0x67, 0xaf, 0xff,
		 0xff, 0xff, 0xff, 0x3c, 0x7f, 0x3f, 0xee, 0xbc, 0x7f, 0xde, 0xfe, 0xff, 0xff, 0xef, 0xae, 0xf3,
		 0xf7, 0xf3, 0xff, 0xf3, 0xf7, 0xd7, 0xff, 0xff, 0xff, 0xf7, 0xda, 0xbf, 0xbe, 0xbe, 0x7e, 0x7f,
		 0x7d, 0xde, 0xd7, 0xdf, 0x7f, 0xef, 0xff, 0xfb, 0xeb, 0xfb, 0xf7, 0xef, 0xef, 0xff, 0xff, 0xff,
		 0xf7, 0xec, 0xbd, 0xdd, 0xbc, 0xbd, 0x7d, 0x7b, 0xfb, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff,
		 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xfa, 0xbf, 0xbf, 0xbb, 0xbf, 0x7b, 0x77, 0xff,
		 0xbf, 0xbf, 0x7f, 0x8f, 0xff, 0xeb, 0xeb, 0xeb, 0xeb, 0xd7, 0xd7, 0xff, 0xff, 0xff, 0xff, 0x3e,
		 0xbf, 0x3f, 0xfe, 0x3f, 0x7e, 0x7c, 0xfd, 0xff, 0xff, 0xff, 0xef, 0xf3, 0xfb, 0xe3, 0xff, 0xe3,
		 0xd7, 0xcf, 0xff, 0xff, 0xff, 0xef, 0x3e, 0xbf, 0x3d, 0xf6, 0xbd, 0xf6, 0x6d, 0xf8, 0xff, 0xff,
		 0xff, 0xef, 0xf3, 0xfb, 0xeb, 0xef, 0xe5, 0xf7, 0xc7, 0xff, 0xff, 0xff, 0xf7, 0x3e, 0xff, 0xff,
		 0xff, 0xfe, 0x7e, 0x7f, 0xfc, 0xff, 0xff, 0xff, 0xef, 0xf3, 0xdf, 0xfb, 0xdf, 0xff, 0xdf, 0xa5,
		 0xff, 0xff, 0xff, 0xff, 0x3e, 0xff, 0xbf, 0x3d, 0x7f, 0x6e, 0x7f, 0xfe, 0xff, 0xff, 0xff, 0xcf,
		 0xf3, 0xff, 0xe7, 0xf3, 0xbb, 0xe3, 0xe7, 0xff, 0xff, 0xff, 0xff, 0xfe, 0x7f, 0x3f, 0xbf, 0xbf,
		 0xbf, 0x7d, 0xf8, 0xff, 0xbf, 0xff, 0xef, 0xff, 0xf7, 0xf3, 0xeb, 0xf3, 0xbf, 0xc7, 0xff, 0xff,
		 0xfe, 0xff, 0xfe, 0x7f, 0xff, 0xbf, 0x3f, 0xff, 0x7f, 0xff, 0xef, 0xff, 0xbf, 0xef, 0xff, 0xf7,
		 0xff, 0xfb, 0xfb, 0xff, 0xf7, 0xbf, 0xbf, 0xff, 0xff, 0x3e, 0x7e, 0xff, 0xbf, 0xbf, 0xff, 0x5f,
		 0xfe, 0xff, 0xff, 0xff, 0xef, 0xf3, 0xf7, 0xff, 0xfb, 0xf3, 0xff, 0xe7, 0xff, 0xff, 0xff, 0xff,
		 0x3c, 0x7f, 0x3f, 0xbf, 0x3f, 0xfe, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xae, 0xe3, 0xf7, 0xf3, 0xfb,
		 0xfb, 0xff, 0xf7, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xfe, 0xbe, 0xfe, 0x7e, 0xff, 0x7f, 0xff, 0xff,
		 0xf7, 0x7f, 0xcf, 0xfb, 0xf7, 0xeb, 0xfb, 0xfb, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xbe, 0xbd,
		 0xfd, 0xbc, 0xbd, 0x7d, 0x7b, 0xfb, 0xff, 0xff, 0xff, 0xaf, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xf7, 0xba, 0xbb, 0xbb, 0xbb, 0xbb, 0x7b, 0xff, 0xfe, 0xff, 0xff, 0x5f,
		 0xaf, 0xf3, 0xeb, 0xeb, 0xeb, 0xef, 0xd7, 0xd3, 0xff, 0xff, 0xff, 0xff, 0x7e, 0x3c, 0x3f, 0x7f,
		 0x3f, 0x7e, 0xf8, 0xff, 0xff, 0xff, 0xff, 0xcf, 0xfb, 0xf3, 0xf3, 0xf7, 0xeb, 0xc7, 0xff, 0xff,
		 0xff, 0xff, 0xed, 0xbe, 0xfb, 0xfb, 0x7b, 0xbb, 0x76, 0xfa, 0xfe, 0xff, 0xff, 0xff, 0xef, 0xf7,
		 0xef, 0xef, 0xf7, 0xf3, 0xcf, 0xef, 0xff, 0xff, 0xff, 0xf7, 0x7e, 0xff, 0xfe, 0x7e, 0xbf, 0xff,
		 0xfe, 0xfe, 0xff, 0xff, 0xdf, 0xef, 0xfb, 0xff, 0xff, 0xf7, 0xff, 0x87, 0xef, 0xff, 0xff, 0xff,
		 0xff, 0xbc, 0x3f, 0x3f, 0x7f, 0xff, 0x7e, 0xfa, 0xff, 0xff, 0xff, 0xff, 0xef, 0xb7, 0xf3, 0xf3,
		 0xf7, 0xfb, 0xe3, 0xbf, 0xff, 0xff, 0xff, 0xfd, 0xfe, 0xf7, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xbf,
		 0xff, 0xff, 0xff, 0xef, 0xdf, 0xdf, 0x5f, 0xdf, 0xdf, 0xbf, 0xbf, 0xbf, 0xbf, 0xbf, 0xff, 0xbc,
		 0xbd, 0xbd, 0xbd, 0xbd, 0x7d, 0x7b, 0x3b, 0x7b, 0x7b, 0xdb, 0xef, 0xe7, 0xf5, 0xf5, 0xf5, 0xd5,
		 0xad, 0xeb, 0xef, 0xeb, 0xeb, 0xf9, 0xfe, 0x7f, 0x7d, 0x7d, 0x7d, 0xff, 0xff, 0xfc, 0xfe, 0xfe,
		 0xfd, 0xef, 0xe7, 0xd7, 0xd7, 0xd7, 0xf7, 0xf7, 0xef, 0xef, 0xef, 0xef, 0xff, 0xfe, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;