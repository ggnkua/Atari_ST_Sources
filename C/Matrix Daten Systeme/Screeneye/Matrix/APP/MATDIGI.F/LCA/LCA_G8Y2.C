# define BYTESinMAP	1853

/* ScreenEye 3020 schneller 8 bit Grau-Modus, x:y = 2,4:2	*/

/* info : mdf_l2g1.rbt */

# include "\pc\app\xload\lcaload.h"

LCAdata lca_G8y2 =
{
	3020,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xc0, 0x79, 0xf2, 0x6c, 0x6b, 0x6b, 0x7b, 0x6b, 0x7b, 0x7b, 0x7f, 0xfb, 0x77, 0x96,
		 0x97, 0x17, 0x17, 0x17, 0x97, 0xb7, 0x97, 0xbf, 0xb7, 0xb7, 0xbf, 0xbf, 0xbf, 0xb7, 0xbb, 0xbe,
		 0xfb, 0xb9, 0xff, 0xfb, 0xe7, 0xff, 0xff, 0xeb, 0xcf, 0xce, 0xcf, 0x7b, 0xfb, 0xdb, 0xdb, 0xf9,
		 0xfa, 0x79, 0xff, 0x7f, 0xed, 0xf6, 0xf2, 0x6f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0x7a, 0xfb,
		 0xfb, 0xfb, 0xca, 0xfb, 0xfb, 0xfb, 0x1f, 0xdf, 0xdd, 0x9f, 0xdf, 0xdf, 0xcf, 0x8f, 0xdf, 0xff,
		 0x7e, 0x3d, 0xed, 0xff, 0x39, 0xff, 0xfd, 0xbe, 0xf5, 0x87, 0x6f, 0xfd, 0xfd, 0xec, 0xef, 0xfd,
		 0xfd, 0x6e, 0xbf, 0xe5, 0xef, 0xeb, 0xef, 0xee, 0xef, 0xe7, 0xef, 0xfe, 0xfd, 0xdf, 0xff, 0xff,
		 0xff, 0xbf, 0xef, 0xf3, 0xed, 0xee, 0xf7, 0xf5, 0xf4, 0xf5, 0xd5, 0xf7, 0xf7, 0xf6, 0x7e, 0xff,
		 0xff, 0xff, 0xfb, 0xfb, 0xfb, 0xef, 0xff, 0xff, 0xc3, 0xf2, 0xb1, 0xfe, 0x28, 0xba, 0xbb, 0x70,
		 0x7f, 0x9e, 0x6f, 0xf2, 0xef, 0x95, 0x87, 0x3f, 0xe7, 0x5a, 0xfe, 0x6e, 0xff, 0xff, 0xef, 0xbf,
		 0xee, 0x69, 0xfd, 0xdd, 0xf7, 0xfd, 0x7f, 0xf7, 0xfc, 0xff, 0xf7, 0xe8, 0xff, 0xbd, 0xcb, 0xef,
		 0x9c, 0xef, 0xfd, 0xbd, 0x8d, 0xf5, 0xf7, 0x3d, 0xfe, 0x7e, 0xef, 0x5f, 0xff, 0x79, 0xfa, 0xfb,
		 0xee, 0xe3, 0xe1, 0xf3, 0xfb, 0xf2, 0xf7, 0xf3, 0xed, 0x77, 0x9e, 0x9f, 0x14, 0x9c, 0xdd, 0xa4,
		 0x1c, 0xfd, 0xcd, 0xeb, 0xfa, 0xfb, 0xfc, 0xfb, 0xfa, 0xf2, 0xfa, 0xfa, 0x5e, 0xb7, 0xae, 0xb7,
		 0xb6, 0xd7, 0xb7, 0xb7, 0xf6, 0xf9, 0xbc, 0xbd, 0xad, 0xbd, 0xe9, 0xec, 0xfd, 0xf9, 0xfd, 0xd7,
		 0x7f, 0x7f, 0xff, 0xfe, 0x7f, 0x3f, 0xff, 0xdf, 0xbd, 0xfe, 0xea, 0xfe, 0xe6, 0xee, 0xec, 0xea,
		 0xec, 0xea, 0xbd, 0x7f, 0xbf, 0x5d, 0x3d, 0x6d, 0x7d, 0x7d, 0xbd, 0xcf, 0xa3, 0xab, 0xa1, 0xab,
		 0xab, 0xb7, 0xa3, 0x8f, 0x7f, 0x1e, 0x13, 0x5b, 0x0b, 0x0e, 0x3b, 0x9b, 0x7d, 0xbe, 0x7b, 0xd0,
		 0xda, 0xda, 0xda, 0x9a, 0xef, 0xe8, 0xef, 0xdd, 0xe7, 0xdf, 0xc3, 0xdf, 0xdf, 0xfd, 0x87, 0xcf,
		 0xef, 0x3e, 0xff, 0xbf, 0xfe, 0xfe, 0xfe, 0x3f, 0x5f, 0xfd, 0xd7, 0xe9, 0x75, 0xff, 0xfc, 0xfd,
		 0xf7, 0xf1, 0xd7, 0xbd, 0x8d, 0x0f, 0xff, 0xcf, 0x8b, 0xbe, 0x8b, 0x7f, 0xff, 0x71, 0x44, 0x75,
		 0x55, 0x7d, 0xdd, 0x7d, 0xfe, 0x2f, 0xae, 0xf3, 0xeb, 0xcb, 0xf0, 0xe3, 0xfe, 0xc1, 0xf3, 0x75,
		 0x1b, 0x29, 0xf8, 0xdf, 0x1d, 0x7c, 0x17, 0x9f, 0xfb, 0x7b, 0xfb, 0xfb, 0x7b, 0xfb, 0xff, 0xd2,
		 0xb0, 0x70, 0x5f, 0xff, 0xff, 0xf7, 0xf7, 0xff, 0x2b, 0xb7, 0xe7, 0xff, 0xbe, 0x7e, 0x1a, 0xab,
		 0x76, 0x76, 0x1e, 0x36, 0xdf, 0xf7, 0xfd, 0x7d, 0xfd, 0xbf, 0xfd, 0xed, 0xa9, 0xe9, 0x3b, 0x2f,
		 0xcf, 0xef, 0x2f, 0x2d, 0x0d, 0xcb, 0xf7, 0xdf, 0x31, 0x73, 0x7c, 0x56, 0xf6, 0x72, 0x72, 0xd4,
		 0x77, 0xaf, 0xe9, 0xf7, 0xed, 0xd7, 0xee, 0xeb, 0xee, 0xe9, 0x7b, 0xb7, 0xd7, 0xbf, 0xdf, 0xde,
		 0xdf, 0xdf, 0xdf, 0xe2, 0xfb, 0xf6, 0xf6, 0xe6, 0xe6, 0xf6, 0xf7, 0xf6, 0x76, 0x5f, 0xff, 0xfb,
		 0xfe, 0xff, 0xff, 0xfb, 0x78, 0x7f, 0xf7, 0x8a, 0xdb, 0x9b, 0xab, 0xdb, 0x9b, 0xb7, 0xb3, 0xb3,
		 0xf7, 0xb7, 0xf5, 0xfd, 0xf5, 0xf5, 0xf5, 0xf7, 0xf5, 0x3f, 0xcf, 0xae, 0x8e, 0x8c, 0xee, 0x8e,
		 0xfe, 0x3e, 0xfe, 0x79, 0x7a, 0x58, 0x78, 0x54, 0x7b, 0xfa, 0xd9, 0xf9, 0x6e, 0x7f, 0x63, 0x6b,
		 0x6a, 0x7b, 0xeb, 0x9f, 0x97, 0x77, 0x7e, 0x5e, 0x37, 0x3f, 0x5f, 0xbf, 0x7f, 0x5e, 0xf7, 0xfb,
		 0xf5, 0x7b, 0xfb, 0xfb, 0xfb, 0xfd, 0xf7, 0xbc, 0x5f, 0xd7, 0xf5, 0xfd, 0xff, 0xfb, 0xd3, 0x93,
		 0x83, 0xf7, 0x8e, 0xbe, 0x7f, 0x7f, 0x3f, 0xff, 0xff, 0x2f, 0x7c, 0xc7, 0xe3, 0x97, 0x1d, 0x75,
		 0x78, 0x3f, 0xf7, 0xf1, 0x3b, 0x8b, 0x2b, 0xaf, 0xd7, 0xd5, 0xeb, 0x3f, 0xbb, 0xcb, 0xdd, 0xf8,
		 0x25, 0x6a, 0x7f, 0x75, 0xf5, 0xdd, 0x79, 0xef, 0xef, 0xef, 0xfb, 0xed, 0xef, 0x4f, 0xcf, 0xcf,
		 0x7f, 0xbb, 0xdd, 0x7f, 0xef, 0xfd, 0xff, 0xfa, 0xff, 0xfe, 0xfb, 0xf9, 0xf8, 0xfb, 0xea, 0xfe,
		 0xb8, 0xbb, 0xfa, 0xde, 0xfb, 0x75, 0xf7, 0xef, 0x6f, 0x27, 0x9f, 0xbd, 0xef, 0x7e, 0xb6, 0x34,
		 0x3d, 0x27, 0xbe, 0xf7, 0xf6, 0x7f, 0xe7, 0xd1, 0xd9, 0xdd, 0xd1, 0xd9, 0x54, 0xdf, 0xd7, 0xbd,
		 0xaa, 0xbf, 0x3f, 0xaf, 0xb7, 0xbf, 0xff, 0xbf, 0xee, 0xf5, 0xfe, 0x7a, 0x5f, 0x7f, 0x77, 0xfb,
		 0x7f, 0xbf, 0xcf, 0xdb, 0xdb, 0x9a, 0xdb, 0xdb, 0x9e, 0x9b, 0x9b, 0x7f, 0xfd, 0xf9, 0xfd, 0xfb,
		 0xe9, 0xf5, 0xff, 0xf7, 0xff, 0xeb, 0xae, 0xee, 0xef, 0xee, 0xef, 0xfe, 0xee, 0xce, 0xde, 0xd7,
		 0xf7, 0x97, 0xef, 0xe1, 0xdd, 0x5b, 0x5f, 0xef, 0xbc, 0x2a, 0x3a, 0xba, 0xba, 0xae, 0x58, 0xfa,
		 0xf2, 0xe7, 0xe1, 0xb1, 0xb5, 0xe1, 0xf1, 0xdd, 0xe9, 0x6e, 0xbb, 0x8f, 0xad, 0xb5, 0xa9, 0xad,
		 0xcd, 0x1b, 0x1f, 0xd3, 0x5d, 0xaf, 0x3c, 0xfd, 0xed, 0x2d, 0xbc, 0xff, 0xf9, 0xef, 0xfb, 0xef,
		 0xcb, 0xaf, 0xef, 0xff, 0xbf, 0xff, 0x7f, 0x1f, 0xfd, 0xef, 0xdf, 0xdf, 0x7f, 0x7f, 0xf6, 0xde,
		 0xfb, 0xb8, 0xfd, 0xfe, 0x38, 0xbc, 0xf2, 0xbf, 0xfb, 0xde, 0xd6, 0xd6, 0xe7, 0xf5, 0xd6, 0xf7,
		 0xdf, 0xff, 0xef, 0xb6, 0xaa, 0x96, 0x7f, 0x0e, 0x7e, 0xff, 0xe8, 0x0a, 0xf7, 0x65, 0xe1, 0xf3,
		 0xc5, 0xed, 0xd3, 0xff, 0xef, 0xbd, 0xbf, 0xef, 0xff, 0xbf, 0xff, 0x5f, 0x4e, 0x4f, 0xf7, 0xfd,
		 0xfd, 0xf7, 0xff, 0x7f, 0xf7, 0x3e, 0x7c, 0xfc, 0xef, 0xf2, 0xee, 0xf7, 0x22, 0xe9, 0x6d, 0x63,
		 0xe1, 0x7d, 0x8f, 0xcd, 0xdf, 0x1d, 0xff, 0xfb, 0x9c, 0x96, 0xb6, 0xfb, 0xda, 0xd8, 0xbc, 0xfe,
		 0xfe, 0xf3, 0x77, 0xfb, 0x1f, 0x77, 0xd7, 0x67, 0x6f, 0x03, 0x3f, 0xff, 0x5f, 0xff, 0x7a, 0xaf,
		 0x7e, 0xdf, 0x3e, 0xbf, 0x9e, 0xae, 0xbc, 0xb7, 0xad, 0xfd, 0xdd, 0xfd, 0xfd, 0xdd, 0xed, 0xfd,
		 0x3d, 0x6f, 0x6f, 0x6f, 0x6a, 0x6e, 0x6b, 0x7f, 0x7f, 0xde, 0xf5, 0xb7, 0x9f, 0xff, 0xdf, 0xff,
		 0xbf, 0xff, 0xff, 0xaf, 0xbb, 0xbf, 0xbe, 0xb9, 0xb7, 0xbf, 0xba, 0x3b, 0x7b, 0x5f, 0x6f, 0x5f,
		 0x9f, 0x5f, 0xfe, 0x45, 0x5d, 0x9d, 0xf3, 0xce, 0xc8, 0xe8, 0xe2, 0xe2, 0xef, 0xeb, 0xef, 0x9f,
		 0xd7, 0x56, 0xd7, 0x52, 0x43, 0xfb, 0x5e, 0x5b, 0xff, 0x3a, 0xf7, 0xb6, 0xb6, 0x37, 0xf7, 0x3d,
		 0x3c, 0x3f, 0x77, 0xf1, 0xd5, 0xf8, 0xf3, 0xe5, 0xff, 0xe1, 0xf1, 0xbf, 0xbf, 0xef, 0xef, 0x97,
		 0xf7, 0xfb, 0xcf, 0x8f, 0xf7, 0xfd, 0xdd, 0xff, 0x5d, 0x7d, 0xff, 0x5b, 0x58, 0xfe, 0xef, 0xeb,
		 0xda, 0xee, 0xeb, 0xab, 0xef, 0xee, 0xae, 0x7d, 0xd6, 0x1f, 0x5d, 0x5f, 0x79, 0x7f, 0x7d, 0x7f,
		 0xaf, 0xcb, 0xbe, 0x3f, 0xf0, 0xbe, 0x8b, 0xf8, 0xfe, 0x72, 0x5f, 0x6f, 0x57, 0xe7, 0xd3, 0xbb,
		 0xa7, 0xeb, 0x4f, 0xfd, 0xfe, 0xbe, 0x7f, 0xbf, 0x2f, 0x3d, 0x45, 0x5d, 0xdf, 0xf7, 0x77, 0xff,
		 0xc3, 0xfb, 0xc9, 0xd0, 0xfd, 0xfd, 0xbf, 0x9f, 0xaf, 0xde, 0xdf, 0xc7, 0x8f, 0xa9, 0xaf, 0xfd,
		 0x5d, 0x55, 0xb6, 0x7e, 0x6f, 0x7a, 0xf9, 0xaa, 0xde, 0xce, 0xe3, 0x73, 0xe3, 0x6b, 0xef, 0x7b,
		 0xd6, 0xe7, 0x77, 0x98, 0x5d, 0x8d, 0xdf, 0xfd, 0x9c, 0xdc, 0x5d, 0xdd, 0xeb, 0xfc, 0xfa, 0xbb,
		 0x7c, 0xba, 0xf2, 0xbd, 0xfb, 0xde, 0xb7, 0xef, 0xf7, 0xf7, 0xf6, 0xf7, 0xaf, 0xf6, 0xff, 0xbc,
		 0xbd, 0x89, 0x9d, 0xf9, 0xed, 0xbd, 0xb9, 0x79, 0xf7, 0x9f, 0xff, 0xfe, 0xff, 0xef, 0xff, 0xff,
		 0xff, 0xbd, 0xfa, 0xee, 0xfe, 0xee, 0xe2, 0xee, 0xec, 0xee, 0xef, 0xc1, 0xfd, 0xff, 0x7d, 0x3d,
		 0x79, 0x7d, 0x3d, 0xfd, 0xce, 0xa3, 0xa3, 0xc7, 0x83, 0x8f, 0xab, 0x8b, 0xb7, 0x7f, 0x5f, 0x1b,
		 0x1d, 0x9f, 0x75, 0xdd, 0x7d, 0x3d, 0xbd, 0xfb, 0xda, 0x1a, 0xde, 0xde, 0xec, 0xe0, 0xe7, 0xbd,
		 0xdd, 0xc1, 0xcd, 0xdc, 0xd6, 0xc7, 0xc7, 0xdf, 0xcb, 0xff, 0xbe, 0xfe, 0xee, 0xbe, 0x2e, 0x1f,
		 0x8e, 0x5f, 0xef, 0xd7, 0xff, 0xff, 0x7d, 0xf5, 0x71, 0xc9, 0xe5, 0xfb, 0xbd, 0xff, 0x97, 0x8f,
		 0xbb, 0x37, 0xcf, 0x3f, 0x1f, 0xdf, 0x25, 0x7d, 0xfd, 0xf6, 0xfd, 0x7d, 0x7c, 0xed, 0xdc, 0x2e,
		 0xc3, 0xf5, 0xb4, 0xc6, 0x73, 0x4f, 0xff, 0xce, 0x7f, 0xdd, 0xd7, 0xdd, 0x3f, 0x1f, 0x7d, 0xfd,
		 0xff, 0xef, 0xfb, 0xff, 0xfb, 0xff, 0xd5, 0xf2, 0xf8, 0xf3, 0x70, 0xdf, 0xf7, 0xff, 0xff, 0x4f,
		 0xe7, 0xe7, 0xff, 0xe3, 0xff, 0xbe, 0xae, 0xbb, 0x7a, 0x3e, 0x27, 0xdf, 0x7e, 0xef, 0xf7, 0xff,
		 0xdb, 0xdb, 0xeb, 0x2d, 0xf9, 0xef, 0xaa, 0xbb, 0xaf, 0xcd, 0xcf, 0x9f, 0xcf, 0xbd, 0xff, 0x9d,
		 0xff, 0x79, 0x74, 0x76, 0xb4, 0x7c, 0xfe, 0xf3, 0xf5, 0x7e, 0xaf, 0xe9, 0xca, 0xe9, 0xec, 0xa9,
		 0xe9, 0xeb, 0xef, 0x7b, 0xcd, 0xdf, 0xdf, 0xc7, 0xc7, 0xdf, 0xcf, 0xd7, 0xee, 0xf3, 0x76, 0xe6,
		 0xe6, 0x77, 0xf7, 0xf6, 0x77, 0xf6, 0xdd, 0x7f, 0xff, 0xff, 0xfb, 0xff, 0xfe, 0x7b, 0xfb, 0xf7,
		 0xe2, 0xfb, 0x7b, 0xab, 0xaf, 0x7b, 0xbb, 0xff, 0x93, 0xc7, 0xf7, 0xfb, 0xf5, 0xe7, 0xd5, 0xd5,
		 0xf4, 0xdf, 0x3f, 0x8f, 0x86, 0x8e, 0xd2, 0x0e, 0x9c, 0x3e, 0xf4, 0xfe, 0x7d, 0x2d, 0x75, 0x94,
		 0x4e, 0x5a, 0xf9, 0xf9, 0xb9, 0xee, 0x6f, 0x6e, 0x61, 0xd6, 0xfb, 0xeb, 0xfd, 0xdf, 0x76, 0x5f,
		 0x55, 0x17, 0xbf, 0x1d, 0x3f, 0x3f, 0x75, 0xfd, 0xdb, 0xfa, 0xfa, 0xfa, 0xfd, 0xf8, 0xfd, 0xfb,
		 0xfb, 0x5e, 0xff, 0xff, 0xed, 0xaf, 0xf7, 0xd7, 0x7d, 0xbd, 0xf7, 0xb6, 0xbf, 0x7f, 0x5e, 0x2f,
		 0xae, 0xfc, 0xff, 0x5f, 0xd7, 0xf9, 0xf1, 0xf5, 0x5a, 0xf1, 0xf3, 0xf7, 0x77, 0xbb, 0x3d, 0xba,
		 0x23, 0xd9, 0x8e, 0x2f, 0x8b, 0xf3, 0xcb, 0x7d, 0x7d, 0x39, 0x7c, 0x7f, 0x78, 0x7f, 0xf8, 0x77,
		 0xaf, 0xfb, 0xfb, 0xf2, 0x63, 0xc1, 0xe1, 0x82, 0xb2, 0x7f, 0x7f, 0x7f, 0x5e, 0x9f, 0x9f, 0x9f,
		 0x9b, 0x9d, 0xff, 0xdb, 0xba, 0x7a, 0xfe, 0xf9, 0x18, 0xda, 0xd8, 0x74, 0xdf, 0xc1, 0xe5, 0xe6,
		 0xf3, 0xa6, 0xd7, 0x07, 0xe7, 0xef, 0x3c, 0x3f, 0x24, 0x3e, 0x3f, 0x3c, 0x3f, 0xdf, 0x7f, 0x87,
		 0xfd, 0xdd, 0xdd, 0xd1, 0xd9, 0x59, 0xc9, 0xdf, 0xbd, 0xaa, 0x2f, 0xbb, 0xef, 0xab, 0xbb, 0xaf,
		 0xaf, 0xef, 0xfd, 0xfe, 0xfe, 0xfa, 0xfe, 0xfe, 0xd5, 0xfe, 0x7f, 0x4f, 0xdb, 0x9b, 0xdb, 0xdb,
		 0xdf, 0xcf, 0xde, 0xdb, 0x7f, 0xff, 0xff, 0xf3, 0xfd, 0xfd, 0xfd, 0xed, 0xf7, 0xdc, 0xeb, 0xee,
		 0xae, 0xee, 0x6d, 0xed, 0xef, 0xfd, 0xed, 0x1e, 0xff, 0xff, 0xdd, 0x57, 0x53, 0x5b, 0x97, 0xf7,
		 0xff, 0x3c, 0x3a, 0x3a, 0x52, 0x1b, 0x1b, 0x18, 0x3a, 0xf8, 0xf7, 0xb1, 0x50, 0xb5, 0xed, 0xe1,
		 0xe9, 0xb1, 0xe9, 0xbb, 0x9b, 0xa9, 0xbd, 0xcd, 0xdf, 0xef, 0xbf, 0xfb, 0xd6, 0x75, 0xdd, 0x7c,
		 0x7d, 0x7c, 0x3d, 0xbd, 0xff, 0xfd, 0xef, 0xdf, 0xef, 0xea, 0xe3, 0xab, 0xe3, 0xfe, 0xe3, 0x7d,
		 0xfd, 0xff, 0xff, 0x1f, 0x3f, 0x1f, 0xef, 0x17, 0xdf, 0xf3, 0xf2, 0xfd, 0xbe, 0xbe, 0xac, 0xfe,
		 0xfe, 0xeb, 0xdd, 0x6e, 0x55, 0xc4, 0xed, 0xd5, 0xd6, 0x57, 0xdf, 0xeb, 0xb8, 0xaf, 0xa6, 0xfe,
		 0x96, 0xb8, 0x1f, 0xb2, 0xbf, 0x67, 0x31, 0xa3, 0xe1, 0x6e, 0xf1, 0xf2, 0xed, 0xf3, 0xbd, 0xef,
		 0x9f, 0x8f, 0x37, 0x0d, 0x1f, 0xaf, 0x9d, 0xf7, 0xfd, 0x7b, 0x7f, 0xbf, 0x7f, 0x7e, 0x7f, 0x4e,
		 0xd7, 0xef, 0xef, 0xe3, 0x6b, 0xff, 0x63, 0x2b, 0xfb, 0xf9, 0x7f, 0xdf, 0x8b, 0x9f, 0xfb, 0x1e,
		 0xba, 0x9e, 0xbf, 0xbf, 0xf3, 0x70, 0xf0, 0x70, 0xfb, 0x7c, 0x75, 0xf8, 0xf9, 0x1d, 0x77, 0xe3,
		 0xf7, 0x7b, 0x67, 0xf3, 0x73, 0xf3, 0xf7, 0xba, 0xfe, 0x3e, 0xdf, 0xbf, 0xbe, 0xfe, 0xbc, 0xbe,
		 0xf7, 0xfc, 0xfd, 0xdd, 0xfe, 0xfc, 0xfd, 0xfd, 0xfa, 0xbf, 0x6f, 0x67, 0x6f, 0x6f, 0x7e, 0x77,
		 0xef, 0x66, 0xff, 0xf5, 0xb7, 0xff, 0xff, 0xff, 0xb7, 0xff, 0xff, 0x7f, 0xaf, 0xbb, 0xb9, 0xbb,
		 0xbd, 0xfb, 0xf9, 0xfb, 0xbb, 0x7b, 0x7d, 0x4f, 0x5f, 0xff, 0x5d, 0x4f, 0x5f, 0x4e, 0xdd, 0xf3,
		 0xc8, 0xea, 0xe8, 0xe3, 0xec, 0xe2, 0xe3, 0xaf, 0x9f, 0xc7, 0x86, 0x97, 0xbf, 0x87, 0x8f, 0x5f,
		 0x9f, 0xef, 0x6e, 0x36, 0xb6, 0xf6, 0x3d, 0x7d, 0xfd, 0x3d, 0x7f, 0xf7, 0xe4, 0xf5, 0xf1, 0xf7,
		 0xf1, 0xf5, 0xe7, 0xe0, 0xbf, 0xef, 0xbf, 0xaf, 0xbf, 0xcf, 0xaf, 0xcf, 0xcf, 0xff, 0xfd, 0x7c,
		 0xfd, 0xfd, 0x79, 0xf8, 0x78, 0x78, 0x7c, 0xcf, 0xe3, 0xfb, 0xef, 0xed, 0xc3, 0xf7, 0xe3, 0xff,
		 0x77, 0x9f, 0xff, 0x5f, 0x7b, 0x5f, 0x5f, 0x8f, 0x7b, 0xdf, 0xcb, 0x7e, 0xfe, 0xff, 0x7a, 0x7a,
		 0xfa, 0x6f, 0xff, 0x5f, 0xb3, 0xb7, 0xbf, 0xb7, 0x3f, 0xbf, 0xbf, 0xb7, 0xfb, 0xbc, 0x1d, 0x3d,
		 0x3d, 0x9d, 0x1d, 0x3d, 0x9d, 0xed, 0xd7, 0xf9, 0xf8, 0xfa, 0xea, 0xfa, 0xfa, 0xfa, 0x7a, 0xbe,
		 0xf7, 0xdf, 0xff, 0xdf, 0xff, 0xff, 0xdf, 0xbf, 0xff, 0xb5, 0xf8, 0xf8, 0xf8, 0x78, 0x79, 0xf9,
		 0xf8, 0xf8, 0xef, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff
	}
} ;