# define BYTESinMAP	1853

/* info : mdf_9u0.rbt */

# include "\pc\app\xload\lcaload.h"

LCAdata lca_YC =
{
	3020,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xc0, 0x79, 0xf2, 0xec, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xff, 0x77, 0xff,
		 0xff, 0x7f, 0xff, 0xff, 0x7f, 0xff, 0xff, 0xbf, 0xb7, 0xbf, 0xbf, 0xbf, 0xbf, 0xb7, 0xbf, 0xbf,
		 0xff, 0xf9, 0xff, 0xfb, 0xff, 0xef, 0xf7, 0xff, 0xaf, 0xff, 0xcf, 0xfb, 0xfa, 0xfb, 0xfb, 0xfb,
		 0xfe, 0x7d, 0xfb, 0x7e, 0xfd, 0xfb, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xfb, 0xfa, 0xfb,
		 0xeb, 0xfb, 0xfb, 0xfb, 0xfb, 0xfa, 0x1f, 0x9f, 0xdf, 0xdf, 0xdf, 0x97, 0xdf, 0xdf, 0xdf, 0xff,
		 0x7e, 0xfd, 0xfd, 0xff, 0xdd, 0xff, 0x7d, 0xda, 0xfd, 0x87, 0xff, 0xfd, 0xff, 0xfd, 0xfd, 0xdf,
		 0xff, 0x6e, 0xbf, 0xef, 0xef, 0xef, 0xef, 0xef, 0xeb, 0xef, 0xee, 0xfe, 0xfd, 0xbf, 0xbf, 0xff,
		 0xff, 0xff, 0xbf, 0xff, 0xfd, 0xee, 0xf7, 0xf7, 0xf7, 0xf5, 0xf7, 0xf7, 0xf7, 0xb5, 0x7f, 0xff,
		 0xff, 0xff, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xfe, 0xe3, 0xfd, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff,
		 0xf2, 0xdf, 0x6d, 0xfa, 0x7f, 0xfe, 0xef, 0xff, 0xff, 0xfd, 0xff, 0xfe, 0xfd, 0xfd, 0xff, 0x7f,
		 0xfd, 0xff, 0xf7, 0xe5, 0xd7, 0xfe, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xef, 0xff, 0xbf, 0xaf, 0xff,
		 0xff, 0xff, 0xef, 0xff, 0xf9, 0xbf, 0xf7, 0x7d, 0xd9, 0xfb, 0xff, 0xff, 0xea, 0xff, 0xdf, 0xdb,
		 0xef, 0xf3, 0xff, 0xff, 0xff, 0xf7, 0xff, 0xff, 0xff, 0x77, 0x9f, 0xff, 0xff, 0xff, 0xcf, 0xff,
		 0xf7, 0x7f, 0xdf, 0xeb, 0xbb, 0xbf, 0xaf, 0xff, 0xfa, 0xff, 0xb7, 0xfa, 0x5e, 0xb7, 0xfe, 0xff,
		 0xff, 0xf7, 0xff, 0xff, 0xb7, 0xff, 0xfc, 0xfd, 0xfd, 0xff, 0xff, 0xfd, 0xff, 0xbf, 0xdd, 0xd7,
		 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0x3d, 0xee, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff,
		 0xef, 0xef, 0xfd, 0xfd, 0xff, 0xff, 0x7f, 0xfd, 0xfb, 0x7f, 0xfd, 0xef, 0xf3, 0xff, 0xff, 0xff,
		 0xeb, 0xff, 0xff, 0xc3, 0x7f, 0x9e, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xef, 0xaf, 0xbf, 0xfb, 0xfe,
		 0xff, 0xff, 0xff, 0x79, 0xff, 0xff, 0xf4, 0xdf, 0xd7, 0xff, 0xff, 0xff, 0x77, 0xfc, 0xff, 0xc7,
		 0xff, 0xfe, 0xde, 0xff, 0xff, 0xbf, 0xff, 0xff, 0x3f, 0xfe, 0xf7, 0xf7, 0xff, 0xfe, 0xff, 0xfb,
		 0xff, 0x7f, 0xe9, 0xbf, 0x9f, 0xff, 0xff, 0xfb, 0xdb, 0xfe, 0xff, 0xdf, 0xff, 0xed, 0xf4, 0xff,
		 0xff, 0x7f, 0xff, 0xff, 0xff, 0xde, 0xef, 0xfb, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xce, 0x7f,
		 0x5f, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xf4, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xf6, 0xdf, 0xe5, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7b, 0xff, 0xff, 0x3e, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xfe, 0xf7, 0xe9, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xef, 0x3e, 0xef,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xdb, 0x75, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0x7d, 0xaf, 0xeb, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xeb, 0x7b, 0xde, 0xf7, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xdf, 0xf7, 0xfb, 0xf6, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0x76, 0x5f, 0xfd, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xb8, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xbf,
		 0xf7, 0xf7, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xbf, 0x9f, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0x79, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xbd, 0xee, 0xcb, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xdf, 0x7f, 0x57, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xef, 0x7f, 0xff, 0xfb,
		 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0x71, 0xdf, 0x97, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0x99, 0xff, 0xbe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xf7, 0xf3, 0xef, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xf7, 0xbf, 0xf6, 0xff, 0xff, 0xfa, 0xff, 0xff, 0xe7, 0xff, 0xff, 0xf5, 0xef,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xbf, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x57, 0xd3,
		 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xde, 0x9d, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xbf, 0xbe, 0xbc, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xac, 0xa6, 0xff, 0xfe, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0x7f, 0xff, 0x7f, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xbd,
		 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xab, 0xaf, 0xeb, 0xf5, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7b,
		 0x7f, 0xff, 0xcf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xdf, 0x7f, 0xfd, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xe3, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbe, 0xfe, 0xde, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xff, 0xd7, 0xd7, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff,
		 0xff, 0xe7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf3, 0x7e, 0xbb, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xdf, 0xcf, 0xfb, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0x77, 0xf4, 0xef, 0xff, 0xff,
		 0xff, 0xdd, 0xff, 0xff, 0xfb, 0xe3, 0x7f, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xbf, 0x87, 0xdf,
		 0xfb, 0xff, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xde, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xf3, 0xff, 0xef, 0xea, 0xdb, 0xff, 0x7f, 0xff, 0xff, 0xb7, 0x3f, 0x9f, 0xd7, 0xff, 0xff, 0xff,
		 0xfa, 0xff, 0xde, 0xbb, 0xd9, 0xbd, 0xff, 0xff, 0xff, 0x5f, 0xff, 0x7e, 0x5f, 0xc7, 0xff, 0xfd,
		 0xff, 0xff, 0xff, 0xfe, 0xff, 0x7f, 0x77, 0xfe, 0xef, 0x7f, 0x7f, 0xff, 0x77, 0xff, 0xff, 0xea,
		 0xff, 0x7d, 0xff, 0xff, 0xff, 0xbf, 0xfe, 0xff, 0x2e, 0xfe, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xfd,
		 0xff, 0xff, 0x7d, 0xbb, 0x5f, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xf7, 0xff, 0xff, 0xda, 0xff,
		 0xff, 0xff, 0xfe, 0xff, 0x3f, 0xdf, 0xbe, 0xf7, 0xff, 0xff, 0xff, 0xfd, 0xff, 0x6f, 0xfb, 0xfd,
		 0x3d, 0xff, 0xff, 0xff, 0x7f, 0xff, 0x7f, 0x6f, 0x67, 0xdf, 0xd5, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0x8f, 0xff, 0xff, 0xfd, 0xfb, 0xff, 0xff, 0xfb, 0x3b, 0x7b, 0xff, 0xff, 0xfe,
		 0x7f, 0xff, 0xff, 0x7f, 0x9f, 0x9d, 0xfb, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xf2, 0xfd, 0x9f,
		 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xdf, 0xef, 0xff, 0xfa, 0xff, 0xff, 0x7f, 0xff, 0xff, 0x6f,
		 0x4d, 0xaf, 0xf7, 0xff, 0xff, 0xff, 0xfb, 0xff, 0xff, 0xf1, 0xfb, 0xbf, 0xff, 0xff, 0xff, 0xdf,
		 0xff, 0xff, 0xff, 0x5f, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xdf, 0xdb, 0x76, 0xef, 0xff,
		 0xff, 0xff, 0xf7, 0xff, 0xff, 0xdf, 0xf7, 0x77, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xff, 0x7f, 0xbf,
		 0xbd, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbb, 0xff, 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0x8b, 0xf7, 0xfd, 0xfe, 0xff, 0xff, 0xff, 0xff, 0x3f, 0xff, 0xfd, 0xfd, 0xf7, 0xff, 0xff,
		 0xff, 0xff, 0xef, 0xf9, 0xfe, 0xff, 0xbf, 0xff, 0xfa, 0xff, 0xff, 0xff, 0xcf, 0xbe, 0xbf, 0xfb,
		 0xed, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xfe, 0xfb, 0xfb, 0xcf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xc3, 0xff, 0x77, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0x7f, 0xdf, 0xeb, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xfa, 0xba, 0xfb, 0x5e, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xb7, 0xf7, 0xff, 0xfe,
		 0xfd, 0xef, 0xff, 0xff, 0xbf, 0xbd, 0xbd, 0x7d, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xbd, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xde, 0xef, 0xef, 0xf1, 0xff, 0xff, 0xff, 0xff,
		 0x7f, 0xf5, 0xfe, 0x7d, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xfb, 0xff, 0x7f, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0x3f, 0x3f, 0x7f, 0xbf, 0xfb, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xfd, 0x75, 0xb7,
		 0xdf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0x97, 0x9f, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xbf,
		 0xbf, 0xff, 0xed, 0xf7, 0xef, 0xff, 0xff, 0xff, 0x7f, 0xfb, 0x62, 0xe5, 0xbf, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xdf, 0xdf, 0xbf, 0xff, 0xf9, 0xff, 0xff, 0xff, 0xff, 0x7f, 0x7f, 0xff, 0xff, 0xef,
		 0xff, 0xbf, 0xff, 0xff, 0xff, 0x73, 0xef, 0xfe, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0x9f, 0x7f,
		 0xfe, 0xff, 0xeb, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xde, 0x75, 0xb7, 0xdf, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xf7, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xfe, 0xff, 0xff, 0xf7, 0xef,
		 0x7f, 0xff, 0xff, 0xff, 0xf3, 0xcf, 0xef, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xff, 0x8f, 0xff, 0xff,
		 0xff, 0xfd, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xfe, 0xff, 0x7f, 0xaf, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xef, 0xeb, 0xdf, 0x7b, 0xfd, 0xfb, 0xff, 0xff, 0xff, 0xdf, 0xdf, 0xef, 0xef, 0xf3, 0xf7, 0xff,
		 0xff, 0xff, 0xff, 0xfe, 0xf7, 0xf7, 0xdd, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7,
		 0xfa, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbb, 0xff, 0xbf, 0xc7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd9,
		 0xf5, 0xff, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xfb, 0xff, 0xfd, 0xff, 0xff, 0xff,
		 0xff, 0xdf, 0xff, 0xff, 0xff, 0xee, 0xff, 0xff, 0xff, 0xff, 0xff, 0xd3, 0xff, 0xff, 0x7e, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0x1f, 0x7e, 0xfd, 0xf9, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 0xfb,
		 0xf7, 0x5f, 0xff, 0xff, 0xff, 0xff, 0xff, 0x87, 0xff, 0xfd, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xd7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xca, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0xeb, 0xdd, 0xff, 0x79, 0xde, 0xcf, 0xff, 0xff, 0xff, 0x7f, 0x7d, 0xff,
		 0xef, 0xd3, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xfb, 0x5f, 0x7f, 0x9f, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xdd, 0xef, 0xff, 0xfb, 0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe8, 0x7e, 0xdf, 0xa7, 0xff, 0xff,
		 0xff, 0xff, 0xff, 0xe7, 0x2b, 0xff, 0x3c, 0xf7, 0xff, 0xff, 0xff, 0xff, 0x3f, 0x3f, 0x7e, 0xd7,
		 0xf9, 0xff, 0xff, 0xff, 0xff, 0x7f, 0xf1, 0xf9, 0xbd, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xaf,
		 0xa7, 0xef, 0xfd, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 0x7f, 0x7f, 0xcf, 0xde, 0xff, 0xff, 0xff,
		 0xff, 0xff, 0xdf, 0xdf, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf, 0xeb, 0xff,
		 0xff, 0xff, 0xff, 0xff, 0x7f, 0xfe, 0xfe, 0x1e, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0xd7, 0xd5,
		 0xfd, 0x3e, 0xff, 0xff, 0xff, 0xff, 0xff, 0x3f, 0x3f, 0xfe, 0xf7, 0xf9, 0xff, 0xff, 0xff, 0xff,
		 0xfe, 0xf9, 0xf9, 0xbb, 0xcf, 0xff, 0xff, 0xff, 0xff, 0xff, 0x4b, 0x9f, 0xff, 0x7d, 0xfe, 0xff,
		 0xff, 0xff, 0xff, 0x7f, 0x7e, 0xf9, 0xef, 0xf3, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfb, 0xdd, 0x7f,
		 0x9f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xdf, 0x76, 0xff, 0xfb, 0xfc, 0xff, 0xff, 0xff, 0xff, 0xff,
		 0xfe, 0xfe, 0x9f, 0xe7, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xef, 0xff, 0xfe, 0xff, 0xff, 0xff,
		 0xbf, 0x3e, 0x3e, 0x6e, 0xff, 0xf7, 0xff, 0xff, 0xff, 0xff, 0xeb, 0x69, 0xe1, 0xf5, 0xbf, 0xff,
		 0xff, 0xfe, 0xff, 0xcf, 0xcf, 0xfd, 0xef, 0xf1, 0xfd, 0xff, 0xff, 0xff, 0x7f, 0x7e, 0xfe, 0x6f,
		 0xfe, 0xef, 0xfd, 0xff, 0xff, 0xff, 0xf3, 0xb3, 0xb1, 0xf7, 0x7f, 0xff, 0xfd, 0xff, 0xff, 0x9f,
		 0x9f, 0x97, 0xdf, 0xff, 0xf3, 0xdf, 0xff, 0xdf, 0xff, 0xfd, 0xfc, 0xfc, 0xfc, 0x5d, 0xff, 0xff,
		 0xff, 0xff, 0xf7, 0xe7, 0xe7, 0xe7, 0xf7, 0xfa, 0xff, 0xff, 0xff, 0xff, 0xbe, 0xbf, 0xbb, 0xbf,
		 0xe7, 0xff, 0xff, 0xff, 0xff, 0xfd, 0xf5, 0xf5, 0xfb, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xef, 0xbf,
		 0xbf, 0xef, 0xff, 0xf5, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7b, 0xaf, 0xff, 0xff, 0xff,
		 0x7f, 0xbd, 0xbb, 0xbb, 0xb7, 0x73, 0xfd, 0xff, 0xff, 0xff, 0x5f, 0xdd, 0xdf, 0xdf, 0xff, 0xfb,
		 0xff, 0x7f, 0xff, 0xff, 0xfa, 0xf0, 0xf0, 0xf9, 0x9d, 0xff, 0xff, 0xff, 0xff, 0xcf, 0xc7, 0xc3,
		 0xf7, 0xed, 0xfe, 0xff, 0xff, 0xff, 0x7f, 0xbc, 0xbb, 0x3b, 0xfa, 0xf7, 0xbf, 0xbf, 0xff, 0xff,
		 0xf7, 0xe1, 0xf3, 0xf9, 0xbf, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xff, 0xaf, 0xcf, 0xf7, 0xfd, 0xff,
		 0xff, 0xff, 0xff, 0xfa, 0xfd, 0x7f, 0xff, 0xcf, 0xff, 0xff, 0xff, 0xff, 0xf7, 0xff, 0xf3, 0xf9,
		 0x7f, 0xff, 0xff, 0xff, 0xff, 0xdf, 0x7f, 0x1f, 0xbf, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xfa,
		 0xfe, 0xff, 0xff, 0xdf, 0xbf, 0xbf, 0xbe, 0xbf, 0xbf, 0xb7, 0xbf, 0xbf, 0xff, 0xbc, 0xbd, 0xbd,
		 0xbd, 0xbd, 0xbd, 0xbd, 0xbd, 0xfd, 0xf7, 0xf3, 0xfa, 0xf2, 0xfa, 0xfa, 0xf8, 0xfa, 0xfa, 0xbe,
		 0x7f, 0x5f, 0x7f, 0xdf, 0xff, 0xff, 0xdf, 0xbf, 0xff, 0xfd, 0xf8, 0xfa, 0xf8, 0x7e, 0x7f, 0xff,
		 0xfe, 0xde, 0xef, 0xff, 0xff, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;