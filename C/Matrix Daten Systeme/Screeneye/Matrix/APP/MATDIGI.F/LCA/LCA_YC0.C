# define BYTESinMAP	1853

/* info : mdf_9u0.rbt */

# include "\pc\app\xload\lcaload.h"

LCAdata lca_YC =
{
	3020,
	BYTESinMAP,
	{
		 0xff, 0x04, 0xc0, 0x79, 0xf2, 0xec, 0xff, 0xf7, 0xff, 0xfb, 0xff, 0xef, 0xff, 0xff, 0x77, 0xff,
		 0xff, 0x7f, 0x6f, 0xff, 0xff, 0xbf, 0xff, 0xbf, 0xbf, 0xbf, 0xbf, 0x3f, 0xb7, 0xbf, 0xbf, 0xbe,
		 0xff, 0xf9, 0xff, 0xbf, 0xbf, 0xfb, 0xd7, 0xdb, 0xdb, 0xff, 0xcf, 0xfb, 0xfb, 0xfb, 0xff, 0xdb,
		 0xff, 0x7d, 0xff, 0x7f, 0xdd, 0xdf, 0xdf, 0xff, 0xff, 0xef, 0xff, 0xff, 0xff, 0xeb, 0xfb, 0xfb,
		 0x2b, 0xeb, 0xfa, 0xdb, 0x7b, 0xdb, 0x9f, 0xdf, 0xdf, 0xdf, 0xdf, 0xdf, 0xdf, 0xcf, 0xcf, 0xff,
		 0x7e, 0x7d, 0x7d, 0xdf, 0xbe, 0xff, 0xfd, 0x3e, 0xf5, 0x87, 0xff, 0x7f, 0xff, 0xff, 0xff, 0xff,
		 0x7f, 0xdf, 0xbf, 0xef, 0xeb, 0xef, 0xef, 0xeb, 0xef, 0xeb, 0xef, 0xff, 0xbd, 0xff, 0xff, 0xdf,
		 0xff, 0xfb, 0xff, 0xff, 0xff, 0xee, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xf6, 0x7f, 0xff,
		 0xfd, 0xfe, 0xf6, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xd3, 0xff, 0x51, 0xb3, 0xf3, 0xf8, 0xb8, 0xf3,
		 0xbf, 0xdf, 0xff, 0xd6, 0x5f, 0xf7, 0xa4, 0xaf, 0xfd, 0x5d, 0xff, 0xfe, 0xbf, 0xf3, 0xbf, 0xfd,
		 0xf7, 0x5f, 0xf3, 0xd7, 0xf7, 0xdf, 0xdb, 0xdf, 0xdf, 0xbf, 0xdd, 0xff, 0xff, 0xbf, 0xfd, 0x9f,
		 0xcf, 0x9f, 0xbf, 0xff, 0xef, 0xcb, 0xf7, 0xdd, 0x7f, 0x7f, 0x7e, 0xfa, 0xe5, 0x7f, 0x7e, 0xfe,
		 0xef, 0xfd, 0x79, 0xf3, 0x73, 0xe3, 0xe3, 0xf1, 0xf2, 0x75, 0xff, 0x3f, 0x9f, 0x3f, 0x9f, 0x97,
		 0x9f, 0xbf, 0xdf, 0x6b, 0xff, 0xb2, 0xba, 0xfa, 0xba, 0xba, 0xfe, 0xfc, 0x5e, 0xff, 0xf7, 0x77,
		 0xf7, 0xed, 0x5f, 0xd7, 0xf2, 0xfb, 0xfc, 0xff, 0xfd, 0xfd, 0xed, 0xff, 0xfe, 0xfe, 0xff, 0xd7,
		 0xff, 0xbf, 0xff, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xbd, 0xfe, 0xef, 0xef, 0xef, 0xdf, 0xfe, 0xee,
		 0xee, 0xee, 0xf5, 0x7f, 0x7d, 0x3d, 0x7d, 0x3d, 0x7d, 0x7b, 0xfe, 0xef, 0xff, 0xc3, 0xe3, 0xe3,
		 0xf3, 0xf3, 0xe3, 0xf3, 0x7f, 0xfe, 0xdf, 0x97, 0x9f, 0x1f, 0x1f, 0x8f, 0x8f, 0xaf, 0x7b, 0xff,
		 0xf4, 0xf0, 0xf8, 0xaf, 0xef, 0xe8, 0xec, 0xdf, 0xff, 0xcf, 0xc7, 0xcf, 0xfd, 0xfb, 0x85, 0xc6,
		 0xfe, 0xfe, 0x1f, 0x1a, 0xfe, 0xbe, 0xff, 0xff, 0xff, 0xfc, 0xb7, 0xff, 0xed, 0xee, 0xfd, 0xff,
		 0x7f, 0xf7, 0x5e, 0xbf, 0xff, 0xcf, 0xcf, 0xef, 0xdf, 0xcf, 0xbb, 0xbf, 0xfb, 0xfd, 0xff, 0xbc,
		 0x5d, 0x3d, 0x7c, 0xfc, 0x37, 0xff, 0xef, 0xf6, 0xa6, 0xfb, 0xfe, 0xbf, 0xfb, 0xb3, 0xcf, 0x7f,
		 0xff, 0xdf, 0xde, 0xd7, 0xf7, 0xbf, 0x9b, 0xfb, 0xf9, 0xeb, 0xf7, 0xd7, 0xf6, 0xf6, 0x9f, 0xf5,
		 0xec, 0xf7, 0xdf, 0xef, 0xff, 0x73, 0xfb, 0xff, 0xf7, 0xe7, 0xef, 0xff, 0x7e, 0x77, 0xbe, 0xfe,
		 0xeb, 0xbe, 0xf7, 0xfb, 0xde, 0xf7, 0xef, 0xa4, 0xc5, 0xad, 0xb7, 0x6b, 0x7f, 0xef, 0x3f, 0xff,
		 0xcf, 0xe7, 0xe7, 0xbf, 0xd7, 0xbb, 0xf7, 0xdf, 0xf5, 0x7e, 0x7e, 0xff, 0xff, 0x7f, 0xff, 0xbf,
		 0x5d, 0xaf, 0xef, 0xef, 0xef, 0xee, 0xdf, 0xea, 0xab, 0xef, 0x7b, 0xce, 0xbf, 0xdf, 0xdf, 0xf5,
		 0xdf, 0xdf, 0xdf, 0xf7, 0xfb, 0x76, 0xf6, 0xf6, 0xf6, 0xf6, 0xf7, 0xf7, 0x76, 0x5f, 0xfb, 0xfd,
		 0xfd, 0xff, 0xfd, 0xbf, 0xff, 0xff, 0xf7, 0xb8, 0xbf, 0xbb, 0xbb, 0xbf, 0x9f, 0xbf, 0xbf, 0xbf,
		 0x77, 0xf7, 0xbd, 0xe9, 0xf7, 0xf7, 0xf5, 0x75, 0xf5, 0xbf, 0xaf, 0xeb, 0x1f, 0xcf, 0x3f, 0xaf,
		 0xff, 0x3b, 0xff, 0xf9, 0x7f, 0x7f, 0xff, 0x7d, 0xff, 0xfc, 0xff, 0xff, 0xee, 0xcf, 0x7b, 0x7b,
		 0xdf, 0xdf, 0xe7, 0xdd, 0xdf, 0x7e, 0xdf, 0xdf, 0xaf, 0x99, 0x7f, 0xd6, 0xf9, 0x7f, 0xff, 0xfb,
		 0xfe, 0x7e, 0x7d, 0xfc, 0xf6, 0xbe, 0x7c, 0xf3, 0xdf, 0xbf, 0xf5, 0xf7, 0xbd, 0x97, 0xef, 0xa3,
		 0x95, 0xff, 0xfe, 0xbf, 0xbf, 0xfe, 0xbe, 0x7e, 0x3f, 0xff, 0xff, 0xf7, 0xfd, 0xdd, 0xfb, 0xf9,
		 0x7f, 0xdd, 0xf9, 0xb7, 0xbf, 0xce, 0x07, 0xb7, 0x8a, 0x17, 0xd7, 0xe7, 0xdf, 0xff, 0x79, 0x7e,
		 0xd5, 0x7b, 0x68, 0x7d, 0xf5, 0x5e, 0xfe, 0xef, 0xdf, 0xbb, 0xd6, 0xd3, 0xdb, 0xff, 0xd7, 0xd3,
		 0x7f, 0xdf, 0xfa, 0xbf, 0x9f, 0xbf, 0xfd, 0xdb, 0x8f, 0xfe, 0x9b, 0xdf, 0xf9, 0x9d, 0xfc, 0xfd,
		 0xda, 0xfe, 0xb8, 0xdf, 0xaf, 0xd7, 0xaf, 0x23, 0xb7, 0xef, 0xaf, 0x06, 0xff, 0x3e, 0x3f, 0xf6,
		 0x3f, 0xbf, 0x3e, 0x7f, 0x2f, 0x7f, 0xf7, 0xf9, 0xf9, 0x7f, 0xf9, 0xfb, 0xf1, 0xfd, 0xf9, 0xbd,
		 0xa6, 0xaf, 0xab, 0xa7, 0xaf, 0x2a, 0xaf, 0xbf, 0xee, 0x75, 0x7f, 0x7f, 0x7f, 0x7f, 0x7f, 0x7f,
		 0x7b, 0xff, 0xcf, 0xdf, 0xde, 0xda, 0xdf, 0xde, 0xdf, 0xdd, 0xdb, 0x7f, 0xe5, 0xff, 0xff, 0xff,
		 0xfb, 0xff, 0xff, 0xff, 0xff, 0xe3, 0xfe, 0xfe, 0xfe, 0xfe, 0xfe, 0xfe, 0xfe, 0xde, 0xde, 0xd7,
		 0xd3, 0xd7, 0x96, 0xd7, 0xd7, 0xd3, 0xdf, 0xfd, 0x3e, 0x3f, 0xbe, 0xff, 0x3c, 0x3e, 0xbc, 0x7f,
		 0xfe, 0xe7, 0xf1, 0xf4, 0xfd, 0xfb, 0xf5, 0xf1, 0xf3, 0x7b, 0xbb, 0xfd, 0x2f, 0x7f, 0xfb, 0x8f,
		 0x4f, 0xdf, 0x0f, 0xff, 0x7d, 0xf9, 0xe9, 0xfd, 0xb8, 0x7c, 0x7f, 0x3f, 0xd8, 0xaf, 0xff, 0xff,
		 0xcf, 0xfd, 0xe3, 0xfe, 0xfb, 0xf1, 0x7f, 0x37, 0x7f, 0xf6, 0xb6, 0xdf, 0x5f, 0xbe, 0x8f, 0xde,
		 0xfb, 0x78, 0xbe, 0xfe, 0xef, 0xbc, 0x7e, 0xed, 0xf8, 0xdf, 0xe7, 0xcf, 0xf7, 0xef, 0x8f, 0xcf,
		 0xf7, 0xef, 0xe7, 0x38, 0x1f, 0x14, 0x14, 0x98, 0xff, 0xbf, 0xff, 0xbf, 0xd7, 0x91, 0xf5, 0xd1,
		 0xb5, 0xfb, 0xff, 0xbb, 0xf7, 0xbd, 0xdf, 0xee, 0x6b, 0xeb, 0x6f, 0xff, 0x5f, 0x4f, 0xfe, 0xfd,
		 0xff, 0x7b, 0xff, 0xfb, 0xde, 0x7f, 0x7f, 0xfe, 0xef, 0x67, 0xe7, 0xfe, 0x77, 0xeb, 0xff, 0xfa,
		 0xe3, 0x7d, 0xef, 0xdf, 0xff, 0xde, 0xbf, 0xfe, 0xbd, 0x96, 0xfe, 0xfb, 0xf0, 0xd8, 0xfa, 0xbc,
		 0x3e, 0xff, 0xfd, 0xf3, 0x5f, 0xe3, 0xc7, 0xf7, 0xe3, 0xcf, 0xff, 0xf7, 0xff, 0xff, 0xba, 0xbe,
		 0x1e, 0x9b, 0xbe, 0xfe, 0xaf, 0x6c, 0xbf, 0xf7, 0xfd, 0xfd, 0xfd, 0xfd, 0x7d, 0xef, 0xfd, 0xfc,
		 0x3d, 0x7f, 0x77, 0x6f, 0x7b, 0x6f, 0xff, 0x7f, 0x6f, 0xdf, 0xb5, 0xff, 0xdf, 0xff, 0xbf, 0xdf,
		 0xff, 0xff, 0xff, 0x8f, 0xf9, 0xf9, 0xbf, 0xfb, 0xfb, 0xff, 0xfb, 0xfb, 0x7b, 0x57, 0x4f, 0x76,
		 0x5f, 0x4b, 0xff, 0x5f, 0x5f, 0x87, 0xfb, 0xfc, 0xb8, 0xfc, 0xf8, 0xfc, 0xff, 0xba, 0xff, 0x9f,
		 0xe7, 0xd7, 0xe7, 0xd3, 0xe7, 0xff, 0xcf, 0xef, 0xff, 0x7e, 0xbd, 0x3c, 0xb7, 0xbc, 0xfd, 0x7f,
		 0x3e, 0xbd, 0xf7, 0xe7, 0xf7, 0xf9, 0xe7, 0xe3, 0x7f, 0xfd, 0xfd, 0xbf, 0xdf, 0xff, 0x7f, 0xff,
		 0xff, 0xf7, 0x6f, 0xff, 0xff, 0xfd, 0xd9, 0xfb, 0xdd, 0xf9, 0xf9, 0xff, 0xfe, 0x7b, 0xef, 0xf3,
		 0x8a, 0xfe, 0xfb, 0xba, 0xfd, 0xf6, 0xff, 0x77, 0x8f, 0xbd, 0xff, 0xbf, 0xbd, 0xff, 0xdf, 0xfe,
		 0xb7, 0xfb, 0x50, 0x70, 0xbb, 0x60, 0xd0, 0xfd, 0x5c, 0xfb, 0xdd, 0xd7, 0x47, 0xac, 0xc7, 0xd7,
		 0xe7, 0xc7, 0x9f, 0xff, 0x3e, 0x3f, 0xff, 0x2d, 0x37, 0xbf, 0xbf, 0xfd, 0xf9, 0xf7, 0x79, 0xf9,
		 0xfd, 0xf8, 0xfb, 0xd9, 0xed, 0xff, 0xbf, 0x9b, 0x8f, 0xcf, 0x8e, 0xdb, 0xcb, 0xef, 0xbb, 0xff,
		 0x7d, 0x7f, 0x7e, 0x7a, 0x36, 0x5f, 0x7f, 0xf3, 0xd9, 0xcf, 0xeb, 0x61, 0xe3, 0xf1, 0x7b, 0xf3,
		 0xf1, 0xff, 0x77, 0x7d, 0x1f, 0x9f, 0x1f, 0xbf, 0xbf, 0x9f, 0xff, 0xdf, 0xeb, 0x7a, 0xf2, 0xfb,
		 0xba, 0xfa, 0xfb, 0xfa, 0xfa, 0x5e, 0xf7, 0xf7, 0xf5, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0xff, 0xfe,
		 0xdd, 0xbd, 0xfd, 0xfd, 0xbd, 0xff, 0xfd, 0x7d, 0xf7, 0xff, 0xfe, 0xff, 0x7f, 0xff, 0xff, 0xff,
		 0xff, 0xbd, 0xe6, 0xef, 0xe7, 0xef, 0xef, 0xfd, 0xee, 0xef, 0xed, 0x31, 0x7d, 0x7d, 0x7d, 0x7d,
		 0x7d, 0x75, 0x3d, 0x7d, 0xef, 0xfd, 0xcf, 0xf3, 0xff, 0x47, 0xfd, 0xf3, 0xcf, 0x7f, 0x6f, 0xff,
		 0x1f, 0x77, 0xcf, 0x7f, 0x97, 0xef, 0xbf, 0xfb, 0xf6, 0xf7, 0x74, 0xf4, 0xf6, 0xf4, 0xfe, 0xbf,
		 0xdf, 0xdd, 0xc7, 0x47, 0xdf, 0xcf, 0xe7, 0xd7, 0xdf, 0xff, 0x3e, 0xdc, 0xbd, 0x3f, 0x3e, 0x3e,
		 0xaf, 0x7e, 0xee, 0xf7, 0x6d, 0x68, 0xe7, 0x66, 0xec, 0xe1, 0x7d, 0xff, 0xbf, 0xef, 0x7f, 0x1f,
		 0xf7, 0x8f, 0xbf, 0xc7, 0xfb, 0xff, 0xfd, 0xfc, 0xfd, 0xf7, 0xdd, 0xbe, 0x5f, 0xfe, 0xdf, 0xaf,
		 0xcf, 0xc5, 0xaa, 0xc2, 0xff, 0xf3, 0xe3, 0xf5, 0x73, 0x5f, 0x5b, 0xff, 0x5e, 0xcf, 0x8f, 0x13,
		 0x9e, 0xbf, 0xfb, 0xf6, 0xf6, 0xf5, 0xfe, 0xfe, 0xfe, 0xfc, 0x7e, 0x5f, 0xa7, 0xef, 0xf7, 0x3b,
		 0xff, 0x77, 0xe7, 0xee, 0xff, 0xfe, 0x76, 0x3e, 0x76, 0x3e, 0x2f, 0x3f, 0x37, 0xff, 0x37, 0xc5,
		 0xed, 0xc1, 0x7d, 0xfd, 0xfd, 0xd9, 0xfd, 0xbf, 0xef, 0xa7, 0xcd, 0x43, 0xad, 0xcf, 0xcf, 0xef,
		 0xff, 0xfd, 0xff, 0x7c, 0x7f, 0x7e, 0x7e, 0x5e, 0x7e, 0x7e, 0xaf, 0xf3, 0xeb, 0xcb, 0xeb, 0xef,
		 0xff, 0xf3, 0xf9, 0x7b, 0xbd, 0xdf, 0xcf, 0xde, 0xdf, 0x5e, 0xdf, 0xbb, 0xf7, 0xf3, 0x76, 0xf7,
		 0xf6, 0xf7, 0xf7, 0xfb, 0xff, 0xfe, 0xdd, 0xff, 0xfd, 0xff, 0xfb, 0xff, 0xff, 0xff, 0xff, 0xf7,
		 0xba, 0xab, 0x9f, 0xa7, 0xa7, 0xaf, 0xb3, 0x73, 0xbb, 0xc7, 0xf7, 0xe5, 0xf9, 0xf5, 0xf7, 0xff,
		 0xf9, 0xfd, 0xbf, 0xcb, 0xcf, 0x2f, 0x8f, 0xcf, 0xcd, 0x3f, 0x07, 0xfb, 0x7d, 0x7c, 0x7f, 0x7f,
		 0x7d, 0x7d, 0xdc, 0x7d, 0xfe, 0x6e, 0x73, 0xf3, 0xd3, 0xcb, 0xdb, 0xbb, 0xbf, 0xba, 0x7f, 0x9f,
		 0x2f, 0x1f, 0x6f, 0x9f, 0x9b, 0x7f, 0xbd, 0xff, 0xfb, 0xff, 0xf0, 0xfc, 0xff, 0xff, 0xfe, 0xfc,
		 0xfd, 0x5f, 0xfd, 0xf7, 0x85, 0x9f, 0xb7, 0xd7, 0x57, 0xf5, 0xff, 0xfa, 0x3f, 0xaf, 0xbd, 0xbd,
		 0x3f, 0x2f, 0xbd, 0xef, 0xe7, 0xff, 0xdb, 0xfd, 0x5b, 0xbf, 0xf9, 0xf8, 0xf9, 0x3f, 0x1f, 0x0f,
		 0xe7, 0xc6, 0xff, 0xcf, 0xfb, 0xff, 0xff, 0x7d, 0x15, 0xfd, 0x6e, 0xfe, 0x7f, 0xdc, 0xff, 0xff,
		 0xef, 0xfb, 0xdb, 0xde, 0xff, 0xdf, 0xdb, 0xfd, 0xff, 0x7f, 0x9f, 0xff, 0xff, 0xff, 0xfd, 0xbd,
		 0xff, 0xff, 0xff, 0xbb, 0xf9, 0xcf, 0xdf, 0xdf, 0xff, 0xf9, 0xff, 0xff, 0xdf, 0xc7, 0xb7, 0xbf,
		 0xff, 0xbf, 0x3f, 0x7f, 0x7f, 0xff, 0xbc, 0xae, 0x7f, 0x3f, 0xff, 0xdf, 0xff, 0xef, 0x6f, 0xd7,
		 0xfb, 0xf9, 0xfd, 0xf9, 0xff, 0xf3, 0xff, 0xff, 0xbc, 0xae, 0xaf, 0xaf, 0x2f, 0xf7, 0xaf, 0xfb,
		 0xff, 0xef, 0x3d, 0xff, 0x7e, 0x3b, 0xff, 0x5f, 0xff, 0xfb, 0x7f, 0xcf, 0xde, 0xdb, 0xdb, 0xda,
		 0xdb, 0xdf, 0xdb, 0xff, 0x7f, 0xff, 0xef, 0xff, 0xf7, 0xeb, 0xef, 0xff, 0xff, 0xdf, 0xeb, 0xfe,
		 0xae, 0xfe, 0xef, 0xee, 0x7e, 0x7e, 0xff, 0x1e, 0xd7, 0xde, 0xd7, 0xfb, 0xdf, 0xd6, 0xdf, 0xff,
		 0xff, 0x7e, 0x3e, 0xfc, 0x3e, 0xbf, 0x3f, 0x7e, 0xfe, 0xff, 0xf7, 0xfd, 0xf9, 0xf7, 0x79, 0xfd,
		 0xf1, 0xfb, 0xff, 0xbb, 0x2f, 0xff, 0x2d, 0x47, 0xed, 0xad, 0x3f, 0xff, 0xff, 0x7d, 0xf8, 0xfd,
		 0x7c, 0x6c, 0xff, 0xf8, 0xf8, 0xff, 0xef, 0xf7, 0xaf, 0xe7, 0xe3, 0xdb, 0xf7, 0xf7, 0xdf, 0x7f,
		 0x1d, 0xfe, 0xd7, 0x96, 0xde, 0x4f, 0x7f, 0xfe, 0xff, 0xf3, 0xfa, 0xbc, 0xff, 0xfc, 0xfe, 0xbc,
		 0xf9, 0x7f, 0xdf, 0xef, 0xe7, 0xff, 0xe7, 0xf7, 0xc7, 0xef, 0xfd, 0xff, 0xfe, 0xd7, 0xbf, 0xaf,
		 0xff, 0x2f, 0x3f, 0xbf, 0xfe, 0xf7, 0xff, 0xff, 0xfd, 0xfd, 0xff, 0xf1, 0xb9, 0xe1, 0xbf, 0xff,
		 0xff, 0x7e, 0xef, 0x7f, 0xcf, 0xed, 0x4f, 0xf7, 0xfd, 0xff, 0xef, 0x7f, 0xfb, 0x5f, 0xfa, 0x7a,
		 0xff, 0xef, 0xfd, 0xf3, 0xbf, 0x7b, 0xab, 0xf7, 0xf3, 0xf3, 0x7f, 0xff, 0x9d, 0xff, 0xda, 0x3f,
		 0xde, 0x9f, 0x9f, 0xfe, 0xf3, 0xff, 0xf8, 0xfa, 0xfa, 0xfd, 0xfa, 0xfe, 0xf8, 0x5d, 0xff, 0xe7,
		 0xf7, 0xf7, 0xf7, 0xef, 0xef, 0xf7, 0xf7, 0xfa, 0xbf, 0x7e, 0x7f, 0xbf, 0xfe, 0xbe, 0xbb, 0xbe,
		 0xe7, 0xff, 0xfb, 0xfd, 0xfd, 0xfd, 0xfd, 0xfb, 0xfd, 0xbf, 0xff, 0x6f, 0x6f, 0x6f, 0x7f, 0xef,
		 0x6f, 0x67, 0xff, 0xf5, 0xbf, 0xff, 0xef, 0xff, 0xff, 0xbf, 0xff, 0x7f, 0xaf, 0x7f, 0xbb, 0xb7,
		 0xbb, 0xfb, 0xff, 0xf7, 0xfb, 0x7b, 0xfd, 0x9f, 0x5f, 0x5f, 0x5f, 0x9f, 0x5b, 0x5f, 0xdf, 0xfb,
		 0xff, 0xfc, 0xfc, 0xfc, 0xf2, 0xf9, 0xfb, 0xfc, 0x9f, 0xff, 0xe7, 0xe7, 0xe7, 0xcf, 0xd7, 0xdf,
		 0xd7, 0xed, 0xfe, 0xff, 0x3b, 0x37, 0x7b, 0xff, 0x7c, 0x3e, 0xfd, 0xf7, 0xff, 0xf7, 0xf1, 0xf9,
		 0xfd, 0xfb, 0xfd, 0xf9, 0xbf, 0xff, 0xbf, 0x7f, 0xff, 0xff, 0xdf, 0xef, 0xcf, 0xfb, 0xfd, 0xff,
		 0xff, 0xfd, 0xff, 0xff, 0xfb, 0x7e, 0xf9, 0xcf, 0xff, 0xf3, 0xcf, 0xff, 0xff, 0xfb, 0xff, 0xf9,
		 0x7f, 0xff, 0x9f, 0xef, 0x7f, 0xff, 0xbf, 0xfe, 0x9f, 0xff, 0xfb, 0x5f, 0xff, 0xff, 0xff, 0xff,
		 0xfe, 0xff, 0xff, 0xdf, 0xbf, 0xb7, 0xbe, 0xbf, 0xbf, 0xb7, 0xbf, 0xbf, 0xff, 0xbc, 0x9d, 0xbd,
		 0xb9, 0xbd, 0xbd, 0xbd, 0xbd, 0xed, 0xf7, 0xb3, 0xfa, 0xf2, 0xfa, 0xfa, 0xf8, 0xfa, 0x7a, 0xbe,
		 0xbf, 0x7f, 0x7f, 0xff, 0xff, 0xff, 0xdf, 0xbf, 0xff, 0xfd, 0x2c, 0xfa, 0x78, 0x7e, 0x7f, 0xff,
		 0xfe, 0xfe, 0xef, 0xff, 0xf3, 0xff, 0xf3, 0xef, 0xff, 0xff, 0xff, 0xff, 0xff
	}
} ;