/********************************************************************/
/* 				MatDigi Window Program - Version Constants			*/
/*																	*/
/*------------------------------------------------------------------*/
/*	Status : 24.09.93												*/
/*																	*/
/*  HG - Matrix Daten Systeme, Talstr. 16, W-7155 Oppenweiler		*/
/*																	*/
/********************************************************************/

# define MDF_VERSION "0.1ž"

