# \pc\app\matdigi.f\digiblit.h
# \PC\APP\MATDIGI.F\digiblix.h
# \pc\app\matdigi.f\digitise.h
# \PC\APP\MATDIGI.F\digitisx.h
# \pc\app\matdigi.f\film.h
# \PC\APP\MATDIGI.F\filmx.h
# \pc\app\matdigi.f\i2c_hdg.h
# \pc\app\matdigi.f\initdmsd.h
# \pc\app\matdigi.f\mdf_if.h
# \pc\app\matdigi.f\mdf_lca.h
# \PC\APP\MATDIGI.F\mdf_lcax.h
# \pc\app\matdigi.f\screyeif.h
# \pc\app\matdigi.f\scryiacc.h
# \PC\APP\MATDIGI.F\stretch.h
# \pc\app\matdigi.f\yc.h
# \PC\APP\SCREEN.EYE\digiwind.h
# \PC\APP\SCREEN.EYE\mdf_if.h
# \PC\APP\SCREEN.EYE\mdf_vers.h
# \PC\APP\SCREEN.EYE\menus.h
# \pc\app\screen.eye\palette.h
# \PC\APP\SCREEN.EYE\picture.h
# \PC\APP\SCREEN.EYE\scrneye.h
# \PC\APP\SCREEN.EYE\scrn_eye.h
# \PC\APP\SCREEN.EYE\sound.h
# \PC\APP\SCREEN.EYE\tool_bar.h
# \pc\cxxsetup\aesutils.h
# \pc\cxxsetup\dialog.h
# \pc\matlib\cookie.h
# \pc\matlib\errdef.h
# \pc\matlib\error.h
# \pc\matlib\fast.h
# \pc\matlib\global.h
# \pc\matlib\picfiles.h
# \pc\matlib\popup.h
# \pc\matlib\readcook.h
