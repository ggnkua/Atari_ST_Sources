/* Resource Datei Indizes f�r SCRN_EYE */

#define DHELP    0   /* Formular/Dialog */
#define BDF_HOK  14  /* BUTTON in Baum DHELP */

#define MD_POPUP 1   /* Formular/Dialog */
#define _MD_DISPLAY 1   /* IBOX in Baum MD_POPUP */
#define _PD_COLOUR 2   /* BUTTON in Baum MD_POPUP */
#define _PD_GREY 3   /* BUTTON in Baum MD_POPUP */
#define _PD_DITHER 4   /* BUTTON in Baum MD_POPUP */
#define _PD_MONO 5   /* BUTTON in Baum MD_POPUP */
#define MD_CHANNEL 6   /* IBOX in Baum MD_POPUP */
#define PD_AUTOCHANNEL 7   /* BUTTON in Baum MD_POPUP */
#define PD_CHAN1 8   /* BUTTON in Baum MD_POPUP */
#define PD_CHAN2 9   /* BUTTON in Baum MD_POPUP */
#define PD_CHAN3 10  /* BUTTON in Baum MD_POPUP */
#define MD_PAL_MODE 11  /* IBOX in Baum MD_POPUP */
#define PD_PAL_RGB 12  /* BUTTON in Baum MD_POPUP */
#define PD_PAL_YUV 13  /* BUTTON in Baum MD_POPUP */
#define PD_PAL_GREY 14  /* BUTTON in Baum MD_POPUP */
#define MD_SIGNAL 15  /* IBOX in Baum MD_POPUP */
#define PD_AUTOSIGNAL 16  /* BUTTON in Baum MD_POPUP */
#define PD_SVHS  17  /* BUTTON in Baum MD_POPUP */
#define PD_CVBS  18  /* BUTTON in Baum MD_POPUP */
#define PD_BAS   19  /* BUTTON in Baum MD_POPUP */
#define MD_STANDARD 20  /* IBOX in Baum MD_POPUP */
#define PD_AUTO  21  /* BUTTON in Baum MD_POPUP */
#define PD_PAL   22  /* BUTTON in Baum MD_POPUP */
#define PD_NTSC  23  /* BUTTON in Baum MD_POPUP */
#define PD_SECAM 24  /* BUTTON in Baum MD_POPUP */
#define MD_ZOOMPAR 25  /* IBOX in Baum MD_POPUP */
#define PD_Z1    26  /* BUTTON in Baum MD_POPUP */
#define PD_Z2    27  /* BUTTON in Baum MD_POPUP */
#define PD_Z4    28  /* BUTTON in Baum MD_POPUP */

#define MD_PARAM 2   /* Formular/Dialog */
#define BX_PARAM 0   /* BOX in Baum MD_PARAM */
#define TX_PAL_MODE 1   /* FBOXTEXT in Baum MD_PARAM */
#define TX_CHANNEL 2   /* FBOXTEXT in Baum MD_PARAM */
#define TX_STANDARD 3   /* FBOXTEXT in Baum MD_PARAM */
#define TX_SIGNAL 5   /* FBOXTEXT in Baum MD_PARAM */
#define TX_ZOOMPAR 6   /* FBOXTEXT in Baum MD_PARAM */
#define BDF_QUIT 7   /* BUTTON in Baum MD_PARAM */
#define BDF_INFO 8   /* BUTTON in Baum MD_PARAM */
#define BDF_VIDEO 9   /* BUTTON in Baum MD_PARAM */
#define BDF_HELP 10  /* BUTTON in Baum MD_PARAM */
#define BDF_POK  11  /* BUTTON in Baum MD_PARAM */

#define MD_INFO  3   /* Formular/Dialog */
#define ITXT_DATE 7   /* FTEXT in Baum MD_INFO */
#define ITXT_VERSION 8   /* FTEXT in Baum MD_INFO */
#define ITXT_STRAM 9   /* FTEXT in Baum MD_INFO */
#define ITXT_TTRAM 10  /* FTEXT in Baum MD_INFO */
#define ITXT_VIDEO 11  /* FTEXT in Baum MD_INFO */
#define ITXT_CPU 12  /* FTEXT in Baum MD_INFO */
#define BDF_IOK  17  /* BUTTON in Baum MD_INFO */

#define MD_BORDER 4   /* Formular/Dialog */
#define ED_HEAD  2   /* FTEXT in Baum MD_BORDER */
#define ED_BORDER 3   /* FTEXT in Baum MD_BORDER */
#define BDF_VOK  5   /* BUTTON in Baum MD_BORDER */

#define MD_MESG  5   /* Formular/Dialog */
#define MTXT_MESG1 2   /* FTEXT in Baum MD_MESG */
#define MTXT_MESG2 3   /* FTEXT in Baum MD_MESG */

#define DHELP_HG 6   /* Formular/Dialog */

#define TRTOOLS  7   /* Formular/Dialog */
#define TOOLSBOX 0   /* BOX in Baum TRTOOLS */
#define ILEFT    1   /* ICON in Baum TRTOOLS */
#define ISTOP    2   /* ICON in Baum TRTOOLS */
#define IRIGHT   3   /* ICON in Baum TRTOOLS */
#define IRECORD  4   /* ICON in Baum TRTOOLS */
#define ITRASH   5   /* ICON in Baum TRTOOLS */
#define IFILM    6   /* ICON in Baum TRTOOLS */
#define IS_DISK  10  /* ICON in Baum TRTOOLS */
#define IS_RD_DISK1 11  /* ICON in Baum TRTOOLS */
#define IS_WR_DISK1 12  /* ICON in Baum TRTOOLS */
#define IS_CAMERA 13  /* ICON in Baum TRTOOLS */
#define IS_TOOLS_OFF 15  /* ICON in Baum TRTOOLS */

#define TRTOOLS16 8   /* Formular/Dialog */
#define BX_TOOLFRAME 0   /* BOX in Baum TRTOOLS16 */
#define IS_LEFT2 1   /* ICON in Baum TRTOOLS16 */
#define IS_LEFT  2   /* ICON in Baum TRTOOLS16 */
#define IS_STOP  3   /* ICON in Baum TRTOOLS16 */
#define IS_PAUSE 4   /* ICON in Baum TRTOOLS16 */
#define IS_RIGHT 5   /* ICON in Baum TRTOOLS16 */
#define IS_RIGHT2 6   /* ICON in Baum TRTOOLS16 */
#define IS_TV    7   /* ICON in Baum TRTOOLS16 */
#define IS_LIVE_BOX 8   /* BOX in Baum TRTOOLS16 */
#define IS_FILM  9   /* ICON in Baum TRTOOLS16 */
#define IS_REWIND 10  /* ICON in Baum TRTOOLS16 */
#define IS_LSTEP 11  /* ICON in Baum TRTOOLS16 */
#define IS_RECORD 12  /* ICON in Baum TRTOOLS16 */
#define IS_SOUND 13  /* ICON in Baum TRTOOLS16 */
#define IS_RSTEP 14  /* ICON in Baum TRTOOLS16 */
#define IS_WIND  15  /* ICON in Baum TRTOOLS16 */
#define IS_PHOTO 16  /* ICON in Baum TRTOOLS16 */
#define IS_WR_DISK 17  /* ICON in Baum TRTOOLS16 */
#define IS_RD_DISK 18  /* ICON in Baum TRTOOLS16 */
#define IS_TRASH 19  /* ICON in Baum TRTOOLS16 */
#define IS_DISPLAY 20  /* ICON in Baum TRTOOLS16 */
#define TX_NAME  21  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_VOLUME 22  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_PARAM 23  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_MIN   24  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_COUNT 25  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_MAX   26  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_ZOOM  27  /* ICON in Baum TRTOOLS16 */
#define TX_ZOOM  28  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_M     29  /* ICON in Baum TRTOOLS16 */
#define TX_MESG  30  /* BOXTEXT in Baum TRTOOLS16 */
#define TX_CLOSE 31  /* BOXTEXT in Baum TRTOOLS16 */
#define IS_PHOTO_MAX 32  /* ICON in Baum TRTOOLS16 */
#define TX_PARAM 33  /* BOXTEXT in Baum TRTOOLS16 */

#define AL_MEM   0   /* Alert String */

#define AL_GREY  1   /* Alert String */

#define AL_BPP   2   /* Alert String */

#define AL_SAVE  3   /* Alert String */

#define AL_OVERW 4   /* Alert String */

#define AL_EXT   5   /* Alert String */

#define AL_ERR   6   /* Alert String */

#define AL_NAME  7   /* Alert String */

#define AL_SDNINST 8   /* Alert String */

#define AL_SDILVER 9   /* Alert String */

#define AL_NOT16BPP 10  /* Alert String */

#define T_NOK    11  /* Freier String */

#define T_UNLK   12  /* Freier String */

#define T_LKC    13  /* Freier String */

#define T_LKBW   14  /* Freier String */

#define T_AUTO   15  /* Freier String */

#define T_SVHS   16  /* Freier String */

#define T_FBAS   17  /* Freier String */

#define T_BAS    18  /* Freier String */

#define T_SAVE   19  /* Freier String */
