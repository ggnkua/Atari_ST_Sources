extern int jpeg_to_window ( char *file_name,
							char *start,
							int x, int y, int w, int h, int bpl ) ;
extern int jpeg_to_ntc_window ( char *file_name,
							unsigned short *start,
							int x, int y, int w, int h, int bpl ) ;
