extern void set_decompress_window ( char *start,
							 int x, int y, int w, int h, int bpl ) ;
