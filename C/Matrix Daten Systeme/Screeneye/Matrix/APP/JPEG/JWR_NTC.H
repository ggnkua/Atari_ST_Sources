extern void set_ntc_decompress_window ( unsigned short *start,
							 int x, int y, int w, int h, int bpl ) ;
