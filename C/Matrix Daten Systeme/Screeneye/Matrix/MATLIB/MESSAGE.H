# define error(text) 		{ printf ( text ) ; return ( FALSE ) ; }
# define warning(text) 		printf ( text ) 
# define message(text) 		printf ( text ) 
# define message1(text,p1) 	printf ( text, p1 ) 
# define message2(text,p1,p2) \
							printf ( text, p1, p2 ) 
# define message4(text,p1,p2,p3,p4) \
							printf ( text, p1, p2, p3, p4 ) 
# define message5(text,p1,p2,p3,p4,p5) \
							printf ( text, p1, p2, p3, p4, p5 ) 

