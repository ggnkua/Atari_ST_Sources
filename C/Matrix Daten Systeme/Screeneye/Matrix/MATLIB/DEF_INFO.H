	{ /*"		  1         2         3         4         5         6    "*/
	  /*"1234567890123456789012345678901234567890123456789012345678901234"*/
		0x12345678L, 0x87654321L, "SCRNSLCT",
		1,
		"",
		1024,
		640, 480, 8, DEFinit,
		DEFstring,
		DEFstring,
		"Version 2.1",
		DEFstring,
		0,0,	/* Zoom X,Y */		
		NO_CXX_IX, 0, 0,
		0, 0, 0, 0, 0xff, 0,
		SYNCdef,
		8, 120, 50,
		8, 22, 2,
		FALSE,
		FALSE, 0, 0,
		NULL,		/* PicAddr == use default addresses	*/
		NULL,		
		NULL,
		NULL,		
		NULL,
		NOinit,
		DEFstring,
		NULL,
		NULL,
		1,
		2048, /* kB */
		NULL,
		NULL,
		NULL,
		NULL,
		NULL,
		NULL,
		256,
		FALSE,
		0,
		FALSE,
		0,
		NULL, NULL,
		NULL,
		NULL,
		0,
		0,
		0,
		0,
		{ 0, 0, 0, 0, 0, 0 },
		DEFAULT_CURSOR,
		0x0F,		/* zoom switch kbshift flags	*/
		0x00,		/* CursorRegister	*/
		MASTER,		/* SlaveNumber		*/
		FALSE,		/* InstallGDOS		*/
		NULL,		/* VdiFunctions		*/
		TRUE,		/* FastPageRam		*/
		0,			/* NightControl		*/
		0,			/* InterruptNumber	*/
		
		'C',		/* SysDrive			*/

		{ 0 }		/* Reserved			*/
	} ;
