#ifndef rsc_gobj_h
#define rsc_gobj_h
#include <gemfast.h>
void* rsc_gobj(RSHDR *rsc, long offset, int re_gtype, int re_gindex);
#endif
