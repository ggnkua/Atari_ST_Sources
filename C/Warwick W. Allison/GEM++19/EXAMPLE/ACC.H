/* resource set indices for ACC */

#define MENU               0 /* menu */
#define DOOPEN             7 /* STRING in tree MENU */
#define DOQUIT            16 /* STRING in tree MENU */

#define SAYHELLO           1 /* form/dialog */

#define ACCNAME            0 /* Free string */

