#ifndef bool_h
#define bool_h

typedef int bool;

const bool TRUE=1;
const bool FALSE=0;

#endif
