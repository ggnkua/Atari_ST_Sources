/* 
The contents of this file are hereby released to the public domain.
                                   -- Rahul Dhesi 1987/02/08
*/

/* Functions defined by Booz */

int readdir ();
int rd_zooh ();
int rd_dir ();
int oozext ();
char *itoa ();

/* Standard functions */

char *malloc ();
int close ();
int creat ();
int open ();
int read ();
int unlink ();
int write ();
long lseek ();
unsigned int strlen ();
