ACTIVATOR setmw_a[] = {{MV_SBKG, mvol_scale},
												 {LV_SBKG, lvol_scale},
												 {RV_SBKG, rvol_scale},
												 {TR_SBKG, treb_scale},
												 {BA_SBKG, bass_scale},
												 {MVOL_SLD, mvol_scale},
												 {LVOL_SLD, lvol_scale},
												 {RVOL_SLD, rvol_scale},
												 {TRB_SLD, treb_scale},
												 {BASS_SLD, bass_scale}
												 };

DIALOG setmw_dia = {SET_MW, "Microwire-Einstellungen", 0, 10, NULL, setmw_a, 0, 0, -1, ""};

