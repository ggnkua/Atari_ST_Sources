/* resource set indices for SND_TOOL */

#define WRK_DIR    0 /* form/dialog */

#define SEQ_LST    1 /* form/dialog */

#define SEQ_EDIT   2 /* form/dialog */

#define SMP_STAT   3 /* form/dialog */
#define STN_1      6 /* FBOXTEXT in tree SMP_STAT */
#define STL_1      7 /* FBOXTEXT in tree SMP_STAT */
#define STM_1      8 /* FBOXTEXT in tree SMP_STAT */
#define STF_1      9 /* FBOXTEXT in tree SMP_STAT */
#define STN_2     10 /* FBOXTEXT in tree SMP_STAT */
#define STL_2     11 /* FBOXTEXT in tree SMP_STAT */
#define STM_2     12 /* FBOXTEXT in tree SMP_STAT */
#define STF_2     13 /* FBOXTEXT in tree SMP_STAT */
#define STN_3     14 /* FBOXTEXT in tree SMP_STAT */
#define STL_3     15 /* FBOXTEXT in tree SMP_STAT */
#define STM_3     16 /* FBOXTEXT in tree SMP_STAT */
#define STF_3     17 /* FBOXTEXT in tree SMP_STAT */
#define STN_4     18 /* FBOXTEXT in tree SMP_STAT */
#define STL_4     19 /* FBOXTEXT in tree SMP_STAT */
#define STM_4     20 /* FBOXTEXT in tree SMP_STAT */
#define STF_4     21 /* FBOXTEXT in tree SMP_STAT */
#define STN_5     22 /* FBOXTEXT in tree SMP_STAT */
#define STL_5     23 /* FBOXTEXT in tree SMP_STAT */
#define STM_5     24 /* FBOXTEXT in tree SMP_STAT */
#define STF_5     25 /* FBOXTEXT in tree SMP_STAT */
#define STAT_P    26 /* FBOXTEXT in tree SMP_STAT */
#define STAT_N    27 /* FBOXTEXT in tree SMP_STAT */

#define MENUE      4 /* menu */
#define WHATABOU  11 /* STRING in tree MENUE */
#define SMPLOAD   20 /* STRING in tree MENUE */
#define SMPSAVE   21 /* STRING in tree MENUE */
#define SAVE_AVR  22 /* STRING in tree MENUE */
#define DODIR     24 /* STRING in tree MENUE */
#define DOSTATIS  26 /* STRING in tree MENUE */
#define PRGEXIT   28 /* STRING in tree MENUE */
#define CHGLOUD   30 /* STRING in tree MENUE */
#define DOFILT    31 /* STRING in tree MENUE */
#define DOOVSM    32 /* STRING in tree MENUE */
#define DOPACK    33 /* STRING in tree MENUE */
#define DOINVERT  34 /* STRING in tree MENUE */
#define DOPLAY    36 /* STRING in tree MENUE */
#define SETFILT   38 /* Calls the DHFT-Setting dialog */
#define SETOVSM   39 /* STRING in tree MENUE */
#define SETPACK   40 /* STRING in tree MENUE */
#define SETPLAY   41 /* STRING in tree MENUE */
#define SETMWIRE  42 /* STRING in tree MENUE */
#define SAVEOPT   44 /* STRING in tree MENUE */

