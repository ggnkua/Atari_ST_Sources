; resource set indices for SND_TOOL
;
TREE003  equ 0 ; unknown form

TREE006  equ 1 ; unknown form

TREE008  equ 2 ; unknown form

TREE009  equ 3 ; form/dialog

TREE010  equ 4 ; form/dialog

TREE011  equ 5 ; form/dialog

TREE012  equ 6 ; form/dialog

TREE013  equ 7 ; form/dialog

TREE014  equ 8 ; unknown form

TREE015  equ 9 ; form/dialog

TREE016  equ 10 ; form/dialog

TREE017  equ 11 ; form/dialog

