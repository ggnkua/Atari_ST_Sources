DIALOG env_dia = {SET_ENV, "Environment", 0, 0, NULL, NULL, 0, SMP_EXT, -1, ""};
