								.DATA
								
SC_INIT:        DC.L $00,$01000000,$02000000,$03000000
                DC.L $04000000,$05000000,$06000000,$0700FF00
                DC.L $08000000,$09000000,$0A000000,$0B000000
                DC.L $0C000000,$0D000000

; *******************************
; * Sound data (STE-Sounddaten) *
; *******************************
SND_DATA:       DC.W $080E,$0909,$0A03,0
                DC.W $080E,$0909,$0A06,0
                DC.W $080E,$0909,$0A07,0
                DC.W $080E,$0909,$0A08,0
                DC.W $080E,$0909,$0A08,0
                DC.W $080E,$090A,$0A02,0
                DC.W $080E,$090A,$0A06,0
                DC.W $080E,$090A,$0A07,0
                DC.W $080E,$090A,$0A08,0
                DC.W $080E,$090A,$0A09,0
                DC.W $080E,$090A,$0A09,0
                DC.W $080E,$090A,$0A09,0
                DC.W $080E,$090B,$0A03,0
                DC.W $080E,$090B,$0A07,0
                DC.W $080E,$090B,$0A08,0
                DC.W $080E,$090B,$0A09,0
                DC.W $080E,$090B,$0A09,0
                DC.W $080E,$090B,$0A0A,0
                DC.W $080E,$090B,$0A0A,0
                DC.W $080E,$090B,$0A0A,0
                DC.W $080E,$090B,$0A0A,0
                DC.W $080E,$090C,$0A00,0
                DC.W $080E,$090C,$0A00,0
                DC.W $080E,$090C,$0A00,0
                DC.W $080E,$090C,$0A07,0
                DC.W $080E,$090C,$0A07,0
                DC.W $080E,$090C,$0A08,0
                DC.W $080E,$090C,$0A08,0
                DC.W $080E,$090C,$0A09,0
                DC.W $080E,$090C,$0A0A,0
                DC.W $080E,$090C,$0A0A,0
                DC.W $080E,$090C,$0A0A,0
                DC.W $080E,$090C,$0A0A,0
                DC.W $080E,$090C,$0A0B,0
                DC.W $080E,$090C,$0A0B,0
                DC.W $080E,$090C,$0A0B,0
                DC.W $080E,$090D,$0A00,0
                DC.W $080E,$090D,$0A00,0
                DC.W $080E,$090D,$0A00,0
                DC.W $080E,$090D,$0A07,0
                DC.W $080E,$090D,$0A07,0
                DC.W $080E,$090D,$0A07,0
                DC.W $080E,$090D,$0A09,0
                DC.W $080E,$090D,$0A09,0
                DC.W $080E,$090D,$0A09,0
                DC.W $080E,$090D,$0A0A,0
                DC.W $080E,$090D,$0A0A,0
                DC.W $080E,$090D,$0A0A,0
                DC.W $080E,$090D,$0A0B,0
                DC.W $080E,$090D,$0A0B,0
                DC.W $080E,$090D,$0A0B,0
                DC.W $080F,$0900,$0A00,0
                DC.W $080F,$0900,$0A00,0
                DC.W $080F,$0900,$0A00,0
                DC.W $080F,$0907,$0A00,0
                DC.W $080F,$0907,$0A00,0
                DC.W $080F,$0909,$0A00,0
                DC.W $080F,$0909,$0A00,0
                DC.W $080F,$0909,$0A00,0
                DC.W $080F,$090A,$0A00,0
                DC.W $080F,$090A,$0A00,0
                DC.W $080F,$090A,$0A09,0
                DC.W $080F,$090B,$0A00,0
                DC.W $080F,$090B,$0A00,0
                DC.W $080F,$090B,$0A00,0
                DC.W $080F,$090B,$0A0A,0
                DC.W $080F,$090B,$0A0A,0
                DC.W $080F,$090C,$0A00,0
                DC.W $080F,$090C,$0A00,0
                DC.W $080F,$090C,$0A09,0
                DC.W $080F,$090C,$0A09,0
                DC.W $080F,$090C,$0A0A,0
                DC.W $080F,$090C,$0A0A,0
                DC.W $080F,$090C,$0A0A,0
                DC.W $080F,$090C,$0A0B,0
                DC.W $080F,$090C,$0A0B,0
                DC.W $080F,$090C,$0A0B,0
                DC.W $080F,$090C,$0A0C,0
                DC.W $080F,$090C,$0A0C,0
                DC.W $080F,$090C,$0A0C,0
                DC.W $080F,$090D,$0A00,0
                DC.W $080F,$090D,$0A00,0
                DC.W $080F,$090D,$0A00,0
                DC.W $080F,$090D,$0A00,0
                DC.W $080F,$090D,$0A00,0
                DC.W $080F,$090D,$0A00,0
                DC.W $080F,$090D,$0A00,0
                DC.W $080F,$090D,$0A0B,0
                DC.W $080F,$090D,$0A0B,0
                DC.W $080F,$090D,$0A0B,0
                DC.W $080F,$090D,$0A0B,0
                DC.W $080F,$090D,$0A0B,0
                DC.W $080F,$090D,$0A0B,0
                DC.W $080F,$090D,$0A0B,0
                DC.W $080F,$090D,$0A0C,0
                DC.W $080F,$090D,$0A0C,0
                DC.W $080F,$090D,$0A0C,0
                DC.W $080F,$090D,$0A0C,0
                DC.W $080F,$090D,$0A0C,0
                DC.W $080F,$090D,$0A0C,0
                DC.W $080F,$090D,$0A0D,0
                DC.W $080F,$090D,$0A0D,0
                DC.W $080F,$090D,$0A0D,0
                DC.W $080F,$090D,$0A0D,0
                DC.W $080F,$090D,$0A0D,0
                DC.W $080F,$090D,$0A0D,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A00,0
                DC.W $080F,$090E,$0A0C,0
                DC.W $080F,$090E,$0A0C,0
                DC.W $080F,$090E,$0A0C,0
                DC.W $080F,$090E,$0A0C,0
                DC.W $080F,$090E,$0A0C,0
                DC.W $080F,$090E,$0A0C,0
                DC.W $080F,$090E,$0A0D,0
                DC.W $080F,$090E,$0A0D,0
                DC.W $080F,$090E,$0A0D,0
                DC.W $080F,$090E,$0A0D,0
                DC.W $080F,$090E,$0A0D,0
                DC.W $080F,$090E,$0A0D,0
                DC.W $080F,$090E,$0A0D,0

                DC.W $0800,$0900,$0A00,0
                DC.W $0802,$0900,$0A00,0
                DC.W $0802,$0901,$0A00,0
                DC.W $0803,$0901,$0A00,0
                DC.W $0804,$0901,$0A00,0
                DC.W $0805,$0901,$0A00,0
                DC.W $0806,$0900,$0A00,0
                DC.W $0806,$0901,$0A00,0
                DC.W $0806,$0903,$0A00,0
                DC.W $0807,$0901,$0A00,0
                DC.W $0807,$0902,$0A00,0
                DC.W $0807,$0903,$0A01,0
                DC.W $0807,$0904,$0A01,0
                DC.W $0808,$0901,$0A00,0
                DC.W $0808,$0902,$0A00,0
                DC.W $0808,$0903,$0A01,0
                DC.W $0808,$0904,$0A01,0
                DC.W $0809,$0900,$0A00,0
                DC.W $0809,$0901,$0A00,0
                DC.W $0809,$0903,$0A00,0
                DC.W $0809,$0904,$0A00,0
                DC.W $0809,$0905,$0A00,0
                DC.W $0809,$0905,$0A01,0
                DC.W $0809,$0905,$0A03,0
                DC.W $0809,$0906,$0A02,0
                DC.W $0809,$0906,$0A03,0
                DC.W $080A,$0901,$0A00,0
                DC.W $080A,$0903,$0A00,0
                DC.W $080A,$0903,$0A01,0
                DC.W $080A,$0905,$0A00,0
                DC.W $080A,$0905,$0A02,0
                DC.W $080A,$0905,$0A03,0
                DC.W $080A,$0906,$0A02,0
                DC.W $080A,$0907,$0A00,0
                DC.W $080A,$0907,$0A02,0
                DC.W $080B,$0901,$0A00,0
                DC.W $080B,$0903,$0A00,0
                DC.W $080B,$0903,$0A01,0
                DC.W $080B,$0904,$0A01,0
                DC.W $080B,$0905,$0A01,0
                DC.W $080B,$0905,$0A03,0
                DC.W $080B,$0906,$0A02,0
                DC.W $080B,$0906,$0A03,0
                DC.W $080B,$0907,$0A02,0
                DC.W $080B,$0907,$0A04,0
                DC.W $080B,$0908,$0A00,0
                DC.W $080B,$0908,$0A01,0
                DC.W $080B,$0908,$0A03,0
                DC.W $080B,$0908,$0A04,0
                DC.W $080B,$0908,$0A05,0
                DC.W $080B,$0909,$0A01,0
                DC.W $080B,$0909,$0A03,0
                DC.W $080B,$0909,$0A04,0
                DC.W $080C,$0902,$0A00,0
                DC.W $080C,$0902,$0A01,0
                DC.W $080C,$0904,$0A01,0
                DC.W $080C,$0905,$0A01,0
                DC.W $080C,$0905,$0A03,0
                DC.W $080C,$0906,$0A02,0
                DC.W $080C,$0907,$0A00,0
                DC.W $080C,$0907,$0A02,0
                DC.W $080C,$0907,$0A04,0
                DC.W $080C,$0907,$0A05,0
                DC.W $080C,$0908,$0A02,0
                DC.W $080C,$0908,$0A04,0
                DC.W $080C,$0908,$0A05,0
                DC.W $080C,$0909,$0A00,0
                DC.W $080C,$0909,$0A02,0
                DC.W $080C,$0909,$0A04,0
                DC.W $080C,$0909,$0A05,0
                DC.W $080C,$0909,$0A06,0
                DC.W $080C,$0909,$0A07,0
                DC.W $080C,$0909,$0A07,0
                DC.W $080C,$090A,$0A00,0
                DC.W $080C,$090A,$0A03,0
                DC.W $080D,$0902,$0A00,0
                DC.W $080D,$0903,$0A01,0
                DC.W $080D,$0905,$0A00,0
                DC.W $080D,$0905,$0A02,0
                DC.W $080D,$0906,$0A01,0
                DC.W $080D,$0907,$0A00,0
                DC.W $080D,$0907,$0A02,0
                DC.W $080D,$0907,$0A04,0
                DC.W $080D,$0907,$0A05,0
                DC.W $080D,$0908,$0A02,0
                DC.W $080D,$0908,$0A04,0
                DC.W $080D,$0909,$0A00,0
                DC.W $080D,$0909,$0A01,0
                DC.W $080D,$0909,$0A04,0
                DC.W $080D,$0909,$0A05,0
                DC.W $080D,$0909,$0A06,0
                DC.W $080D,$0909,$0A07,0
                DC.W $080D,$090A,$0A00,0
                DC.W $080D,$090A,$0A00,0
                DC.W $080D,$090A,$0A03,0
                DC.W $080D,$090A,$0A05,0
                DC.W $080D,$090A,$0A06,0
                DC.W $080D,$090A,$0A07,0
                DC.W $080D,$090A,$0A08,0
                DC.W $080D,$090A,$0A08,0
                DC.W $080D,$090A,$0A08,0
                DC.W $080D,$090B,$0A01,0
                DC.W $080D,$090B,$0A04,0
                DC.W $080D,$090B,$0A06,0
                DC.W $080D,$090B,$0A07,0
                DC.W $080D,$090B,$0A07,0
                DC.W $080D,$090B,$0A08,0
                DC.W $080D,$090B,$0A08,0
                DC.W $080D,$090B,$0A09,0
                DC.W $080D,$090B,$0A09,0
                DC.W $080D,$090B,$0A09,0
                DC.W $080D,$090B,$0A0A,0
                DC.W $080D,$090B,$0A0A,0
                DC.W $080D,$090B,$0A0A,0
                DC.W $080D,$090B,$0A0A,0
                DC.W $080D,$090B,$0A0A,0
                DC.W $080D,$090C,$0A02,0
                DC.W $080D,$090C,$0A05,0
                DC.W $080D,$090C,$0A06,0
                DC.W $080E,$0900,$0A00,0
                DC.W $080E,$0903,$0A01,0
                DC.W $080E,$0905,$0A02,0
                DC.W $080E,$0906,$0A02,0
                DC.W $080E,$0907,$0A02,0
                DC.W $080E,$0907,$0A05,0
                DC.W $080E,$0908,$0A01,0
                DC.W $080E,$0908,$0A05,0
                DC.W $080E,$0909,$0A00,0
