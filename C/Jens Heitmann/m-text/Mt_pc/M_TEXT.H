/*************************************/
/* M_TEXT.RSC - Include-File for C   */
/*************************************/

#define TXT_MENU 0      /* MENU-Tree */
#define MN_INFO 14        /* G_STRING-Object in Tree TXT_MENU */
#define MN_TLOAD 23       /* G_STRING-Object in Tree TXT_MENU */
#define MN_TSAVE 24       /* G_STRING-Object in Tree TXT_MENU */
#define MN_TSVAS 25       /* G_STRING-Object in Tree TXT_MENU */
#define MN_TPRNT 27       /* G_STRING-Object in Tree TXT_MENU */
#define MN_PLOAD 29       /* G_STRING-Object in Tree TXT_MENU */
#define MN_LLOAD 30       /* G_STRING-Object in Tree TXT_MENU */
#define MN_FKILL 32       /* G_STRING-Object in Tree TXT_MENU */
#define MN_DFMT 33        /* G_STRING-Object in Tree TXT_MENU */
#define MN_EXIT 35        /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLANF 37       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLEND 38       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLUMK 39       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLCPY 41       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLMOV 42       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLHID 43       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLCUT 44       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLPST 45       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLDEL 47       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLLOD 49       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLSAV 50       /* G_STRING-Object in Tree TXT_MENU */
#define MN_REPL 52        /* G_STRING-Object in Tree TXT_MENU */
#define MN_AGAIN 53       /* G_STRING-Object in Tree TXT_MENU */
#define MN_GOTO 54        /* G_STRING-Object in Tree TXT_MENU */
#define MN_CALC 56        /* G_STRING-Object in Tree TXT_MENU */
#define MN_RULER 58       /* G_STRING-Object in Tree TXT_MENU */
#define MN_RLNEW 59       /* G_STRING-Object in Tree TXT_MENU */
#define MN_RLDEL 60       /* G_STRING-Object in Tree TXT_MENU */
#define MN_TINFO 62       /* G_STRING-Object in Tree TXT_MENU */
#define MN_NOTE 63        /* G_STRING-Object in Tree TXT_MENU */
#define MN_NOTSH 64       /* G_STRING-Object in Tree TXT_MENU */
#define MN_KFUSS 66       /* G_STRING-Object in Tree TXT_MENU */
#define MN_FNOTE 67       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BOLD 69        /* G_STRING-Object in Tree TXT_MENU */
#define MN_ITALC 70       /* G_STRING-Object in Tree TXT_MENU */
#define MN_UNDER 71       /* G_STRING-Object in Tree TXT_MENU */
#define MN_LIGHT 72       /* G_STRING-Object in Tree TXT_MENU */
#define MN_OUTL 73        /* G_STRING-Object in Tree TXT_MENU */
#define MN_SUBS 74        /* G_STRING-Object in Tree TXT_MENU */
#define MN_SUPER 75       /* G_STRING-Object in Tree TXT_MENU */
#define MN_SONDR 77       /* G_STRING-Object in Tree TXT_MENU */
#define MN_INDEX 79       /* G_STRING-Object in Tree TXT_MENU */
#define MN_INHLT 80       /* G_STRING-Object in Tree TXT_MENU */
#define MN_PLATZ 81       /* G_STRING-Object in Tree TXT_MENU */
#define MN_DATE 82        /* G_STRING-Object in Tree TXT_MENU */
#define MN_TIME 83        /* G_STRING-Object in Tree TXT_MENU */
#define MN_CFONT 85       /* G_STRING-Object in Tree TXT_MENU */
#define MN_CPFNT 86       /* G_STRING-Object in Tree TXT_MENU */
#define MN_PAINT 88       /* G_STRING-Object in Tree TXT_MENU */
#define MN_KILLP 90       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BRIEF 92       /* G_STRING-Object in Tree TXT_MENU */
#define MN_EDIT 93        /* G_STRING-Object in Tree TXT_MENU */
#define MN_TRENN 95       /* G_STRING-Object in Tree TXT_MENU */
#define MN_LEFT 97        /* G_STRING-Object in Tree TXT_MENU */
#define MN_RIGHT 98       /* G_STRING-Object in Tree TXT_MENU */
#define MN_CENTR 99       /* G_STRING-Object in Tree TXT_MENU */
#define MN_BLOCK 100      /* G_STRING-Object in Tree TXT_MENU */
#define MN_FORMT 102      /* G_STRING-Object in Tree TXT_MENU */
#define MN_EINR 104       /* G_STRING-Object in Tree TXT_MENU */
#define MN_FLOSK 106      /* G_STRING-Object in Tree TXT_MENU */
#define MN_FTAST 107      /* G_STRING-Object in Tree TXT_MENU */
#define MN_LAYO 109       /* G_STRING-Object in Tree TXT_MENU */
#define MN_LEXON 111      /* G_STRING-Object in Tree TXT_MENU */
#define MN_LXBEA 112      /* G_STRING-Object in Tree TXT_MENU */
#define MN_LXLOD 114      /* G_STRING-Object in Tree TXT_MENU */
#define MN_LXSAV 115      /* G_STRING-Object in Tree TXT_MENU */
#define MN_FLXLD 116      /* G_STRING-Object in Tree TXT_MENU */
#define MN_FLXSV 117      /* G_STRING-Object in Tree TXT_MENU */
#define MN_HCONT 127      /* G_STRING-Object in Tree TXT_MENU */
#define MN_HALT 128       /* G_STRING-Object in Tree TXT_MENU */

#define TXT_INFO 1      /* DIALOG-Tree */
#define TI_LINE1 4        /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE2 5        /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE3 6        /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE4 7        /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE5 8        /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE6 9        /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE7 10       /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE8 11       /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINE9 12       /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_LINEA 13       /* G_FTEXT-Object in Tree TXT_INFO */
#define PASS_SWT 16       /* G_BOX-Object in Tree TXT_INFO */
#define TI_BEAR1 17       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR2 18       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR3 19       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR4 20       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR5 21       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR6 22       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR7 23       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR8 24       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEAR9 25       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEARA 26       /* G_STRING-Object in Tree TXT_INFO */
#define TI_BEARE 27       /* G_FTEXT-Object in Tree TXT_INFO */
#define TI_OK 29          /* G_BUTTON-Object in Tree TXT_INFO */
#define EINZ_SWT 31       /* G_BOX-Object in Tree TXT_INFO */

#define GOTO 2          /* DIALOG-Tree */
#define LINE_NUM 3        /* G_FTEXT-Object in Tree GOTO */
#define GOTO_OK 4         /* G_BUTTON-Object in Tree GOTO */
#define PAGE_NUM 5        /* G_FTEXT-Object in Tree GOTO */

#define SONDER_Z 3      /* DIALOG-Tree */
#define LINE1 3           /* G_STRING-Object in Tree SONDER_Z */
#define LINE2 4           /* G_STRING-Object in Tree SONDER_Z */
#define LINE3 5           /* G_STRING-Object in Tree SONDER_Z */
#define LINE4 6           /* G_STRING-Object in Tree SONDER_Z */
#define LINE5 7           /* G_STRING-Object in Tree SONDER_Z */
#define LINE6 8           /* G_STRING-Object in Tree SONDER_Z */
#define LINE7 9           /* G_STRING-Object in Tree SONDER_Z */
#define LINE8 10          /* G_STRING-Object in Tree SONDER_Z */
#define LINE9 11          /* G_STRING-Object in Tree SONDER_Z */
#define LINEA 12          /* G_STRING-Object in Tree SONDER_Z */
#define SOND_EDT 13       /* G_FBOXTEXT-Object in Tree SONDER_Z */
#define SONDR_OK 14       /* G_BUTTON-Object in Tree SONDER_Z */
#define SOND_CAN 15       /* G_BUTTON-Object in Tree SONDER_Z */

#define SET_FONT 4      /* DIALOG-Tree */
#define FONT_S 3          /* G_BUTTON-Object in Tree SET_FONT */
#define FONT_1B 4         /* G_BOXTEXT-Object in Tree SET_FONT */
#define FONT_2B 5         /* G_BOXTEXT-Object in Tree SET_FONT */
#define FONT_3B 6         /* G_BOXTEXT-Object in Tree SET_FONT */
#define FONT_4B 7         /* G_BOXTEXT-Object in Tree SET_FONT */
#define FONT_OK 8         /* G_BUTTON-Object in Tree SET_FONT */
#define GRT_DWN 9         /* G_BOXCHAR-Object in Tree SET_FONT */
#define GRT_UP 10         /* G_BOXCHAR-Object in Tree SET_FONT */
#define TST_FLD 11        /* G_BOX-Object in Tree SET_FONT */
#define FONT_CNC 12       /* G_BUTTON-Object in Tree SET_FONT */

#define M_PAINT 5       /* DIALOG-Tree */
#define MP_LINE 3         /* G_IMAGE-Object in Tree M_PAINT */
#define MP_CIRCL 4        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_PBCIR 5        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_BOX 6          /* G_IMAGE-Object in Tree M_PAINT */
#define MP_PBBOX 7        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_PCIRC 8        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_PBOX 9         /* G_IMAGE-Object in Tree M_PAINT */
#define MP_ARC 10         /* G_IMAGE-Object in Tree M_PAINT */
#define MP_PARC 11        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_ELLI 12        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_PBELL 13       /* G_IMAGE-Object in Tree M_PAINT */
#define MP_PELLI 14       /* G_IMAGE-Object in Tree M_PAINT */
#define MP_BACK 15        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_FILL 16        /* G_IMAGE-Object in Tree M_PAINT */
#define MP_FUNC 17        /* G_IMAGE-Object in Tree M_PAINT */

#define PRT_FONT 6      /* DIALOG-Tree */
#define P_FONT1 3         /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT2 4         /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT3 5         /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT4 6         /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT5 7         /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT6 8         /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT7 9         /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT8 10        /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONT9 11        /* G_BUTTON-Object in Tree PRT_FONT */
#define P_FONTA 12        /* G_BUTTON-Object in Tree PRT_FONT */
#define PF_CANC 13        /* G_BUTTON-Object in Tree PRT_FONT */

#define TEXT_FMT 7      /* DIALOG-Tree */
#define TX_AUTO 3         /* G_BUTTON-Object in Tree TEXT_FMT */
#define TX_PARAG 4        /* G_BUTTON-Object in Tree TEXT_FMT */
#define TX_BLOCK 5        /* G_BUTTON-Object in Tree TEXT_FMT */
#define TX_FULLF 6        /* G_BUTTON-Object in Tree TEXT_FMT */
#define TX_FMTOK 7        /* G_BUTTON-Object in Tree TEXT_FMT */
#define TX_FMTAB 8        /* G_BUTTON-Object in Tree TEXT_FMT */

#define EINRUECK 8      /* DIALOG-Tree */
#define EINR_NUM 3        /* G_FTEXT-Object in Tree EINRUECK */
#define EINR_STD 5        /* G_BUTTON-Object in Tree EINRUECK */
#define EINR_OK 6         /* G_BUTTON-Object in Tree EINRUECK */
#define EINR_AB 7         /* G_BUTTON-Object in Tree EINRUECK */

#define FIND_REP 9      /* DIALOG-Tree */
#define WILD_CHR 3        /* G_FTEXT-Object in Tree FIND_REP */
#define WILD_STR 4        /* G_FTEXT-Object in Tree FIND_REP */
#define FIND_STR 5        /* G_FTEXT-Object in Tree FIND_REP */
#define REPL_STR 6        /* G_FTEXT-Object in Tree FIND_REP */
#define SR_COMP 7         /* G_BUTTON-Object in Tree FIND_REP */
#define SR_BEGIN 9        /* G_BUTTON-Object in Tree FIND_REP */
#define SR_END 10         /* G_BUTTON-Object in Tree FIND_REP */
#define SR_CURSR 11       /* G_BUTTON-Object in Tree FIND_REP */
#define SR_CRDWN 13       /* G_BOXCHAR-Object in Tree FIND_REP */
#define SR_CRUP 14        /* G_BOXCHAR-Object in Tree FIND_REP */
#define S_START 15        /* G_BUTTON-Object in Tree FIND_REP */
#define R_START 16        /* G_BUTTON-Object in Tree FIND_REP */
#define SR_CANC 17        /* G_BUTTON-Object in Tree FIND_REP */
#define ONE_TIME 21       /* G_BUTTON-Object in Tree FIND_REP */
#define ALL_REP 22        /* G_BUTTON-Object in Tree FIND_REP */
#define ASK_REP 23        /* G_BUTTON-Object in Tree FIND_REP */
#define TXT_SRCH 25       /* G_BUTTON-Object in Tree FIND_REP */
#define BLK_SRCH 26       /* G_BUTTON-Object in Tree FIND_REP */

#define NEW_RULR 10     /* DIALOG-Tree */
#define ST_12CPI 4        /* G_BUTTON-Object in Tree NEW_RULR */
#define ST_10CPI 5        /* G_BUTTON-Object in Tree NEW_RULR */
#define ST_17CPI 6        /* G_BUTTON-Object in Tree NEW_RULR */
#define ST_05CPI 7        /* G_BUTTON-Object in Tree NEW_RULR */
#define ST_PROP 8         /* G_BUTTON-Object in Tree NEW_RULR */
#define TAB_WDTH 10       /* G_FTEXT-Object in Tree NEW_RULR */
#define TAB_JMP 13        /* G_BUTTON-Object in Tree NEW_RULR */
#define TAB_SPC 14        /* G_BUTTON-Object in Tree NEW_RULR */
#define SET_RTAB 15       /* G_STRING-Object in Tree NEW_RULR */
#define RULR_LEN 16       /* G_FTEXT-Object in Tree NEW_RULR */
#define RULR_UP 17        /* G_BOXCHAR-Object in Tree NEW_RULR */
#define RULR_DWN 18       /* G_BOXCHAR-Object in Tree NEW_RULR */
#define LSPC_UP 20        /* G_BOXCHAR-Object in Tree NEW_RULR */
#define LSPC_DWN 21       /* G_BOXCHAR-Object in Tree NEW_RULR */
#define LINE_SPC 23       /* G_BUTTON-Object in Tree NEW_RULR */
#define COLUMNS 24        /* G_BUTTON-Object in Tree NEW_RULR */
#define COL_DWN 25        /* G_BOXCHAR-Object in Tree NEW_RULR */
#define COL_UP 26         /* G_BOXCHAR-Object in Tree NEW_RULR */
#define RULR_CNC 27       /* G_BUTTON-Object in Tree NEW_RULR */
#define RULR_OK 28        /* G_BUTTON-Object in Tree NEW_RULR */
#define SET_RLEN 30       /* G_STRING-Object in Tree NEW_RULR */

#define CALC 11         /* DIALOG-Tree */
#define INS_CALC 11       /* G_BOXTEXT-Object in Tree CALC */

#define BACKGRND 12     /* DIALOG-Tree */
#define F1 1              /* G_BOX-Object in Tree BACKGRND */
#define F1_TXT 3          /* G_TEXT-Object in Tree BACKGRND */
#define F1_BUT 4          /* G_IBOX-Object in Tree BACKGRND */
#define F2 5              /* G_BOX-Object in Tree BACKGRND */
#define F2_TXT 7          /* G_TEXT-Object in Tree BACKGRND */
#define F2_BUT 8          /* G_IBOX-Object in Tree BACKGRND */
#define F3 9              /* G_BOX-Object in Tree BACKGRND */
#define F3_TXT 11         /* G_TEXT-Object in Tree BACKGRND */
#define F4 13             /* G_BOX-Object in Tree BACKGRND */
#define F5 17             /* G_BOX-Object in Tree BACKGRND */
#define F6 21             /* G_BOX-Object in Tree BACKGRND */
#define F7 25             /* G_BOX-Object in Tree BACKGRND */
#define F8 29             /* G_BOX-Object in Tree BACKGRND */
#define F9 33             /* G_BOX-Object in Tree BACKGRND */
#define F10 37            /* G_BOX-Object in Tree BACKGRND */

#define KOPFFUSS 13     /* DIALOG-Tree */
#define KF_G 1            /* G_BUTTON-Object in Tree KOPFFUSS */
#define G_KF_L 3          /* G_STRING-Object in Tree KOPFFUSS */
#define G_LFT_1 4         /* G_FTEXT-Object in Tree KOPFFUSS */
#define G_LFT_2 5         /* G_FTEXT-Object in Tree KOPFFUSS */
#define G_KF_M 6          /* G_STRING-Object in Tree KOPFFUSS */
#define G_MID_1 7         /* G_FTEXT-Object in Tree KOPFFUSS */
#define G_MID_2 8         /* G_FTEXT-Object in Tree KOPFFUSS */
#define G_KF_R 9          /* G_STRING-Object in Tree KOPFFUSS */
#define G_RGT_1 10        /* G_FTEXT-Object in Tree KOPFFUSS */
#define G_RGT_2 11        /* G_FTEXT-Object in Tree KOPFFUSS */
#define KF_OK 12          /* G_BUTTON-Object in Tree KOPFFUSS */
#define KF_U 13           /* G_BUTTON-Object in Tree KOPFFUSS */
#define U_KF_L 15         /* G_STRING-Object in Tree KOPFFUSS */
#define U_LFT_1 16        /* G_FTEXT-Object in Tree KOPFFUSS */
#define U_LFT_2 17        /* G_FTEXT-Object in Tree KOPFFUSS */
#define U_KF_M 18         /* G_STRING-Object in Tree KOPFFUSS */
#define U_MID_1 19        /* G_FTEXT-Object in Tree KOPFFUSS */
#define U_MID_2 20        /* G_FTEXT-Object in Tree KOPFFUSS */
#define U_KF_R 21         /* G_STRING-Object in Tree KOPFFUSS */
#define U_RGT_1 22        /* G_FTEXT-Object in Tree KOPFFUSS */
#define U_RGT_2 23        /* G_FTEXT-Object in Tree KOPFFUSS */
#define SWTCH_KF 24       /* G_BUTTON-Object in Tree KOPFFUSS */

#define FLOSKEL 14      /* DIALOG-Tree */
#define FLSK_L1 3         /* G_FTEXT-Object in Tree FLOSKEL */
#define FLSK_L2 4         /* G_FTEXT-Object in Tree FLOSKEL */
#define FLSK_L3 5         /* G_FTEXT-Object in Tree FLOSKEL */
#define FLSK_L4 6         /* G_FTEXT-Object in Tree FLOSKEL */
#define FLSK_L5 7         /* G_FTEXT-Object in Tree FLOSKEL */
#define FLSK_F1 8         /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F2 9         /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F3 10        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F4 11        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F5 12        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F6 13        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F7 14        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F8 15        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F9 16        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_F10 17       /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_OK 19        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_LD 20        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_SV 21        /* G_BUTTON-Object in Tree FLOSKEL */
#define FLSK_CNC 22       /* G_BUTTON-Object in Tree FLOSKEL */

#define FUNKTION 15     /* DIALOG-Tree */

#define LOAD_INF 16     /* DIALOG-Tree */
#define LOADFILE 2        /* G_STRING-Object in Tree LOAD_INF */
#define DOING 3           /* G_STRING-Object in Tree LOAD_INF */
#define FILE2 4           /* G_STRING-Object in Tree LOAD_INF */

#define PRT_MENU 17     /* DIALOG-Tree */
#define TO_PRINT 11       /* G_BUTTON-Object in Tree PRT_MENU */
#define TO_FILE 12        /* G_BUTTON-Object in Tree PRT_MENU */
#define SAVE_INH 14       /* G_BUTTON-Object in Tree PRT_MENU */
#define NO_INHLT 15       /* G_BUTTON-Object in Tree PRT_MENU */
#define SAVE_IDX 17       /* G_BUTTON-Object in Tree PRT_MENU */
#define NO_INDEX 18       /* G_BUTTON-Object in Tree PRT_MENU */
#define PRT_PICS 20       /* G_BUTTON-Object in Tree PRT_MENU */
#define NO_PICS 21        /* G_BUTTON-Object in Tree PRT_MENU */
#define DO_MAIL 23        /* G_BUTTON-Object in Tree PRT_MENU */
#define NO_MAIL 24        /* G_BUTTON-Object in Tree PRT_MENU */
#define PRT_DRFT 26       /* G_BUTTON-Object in Tree PRT_MENU */
#define PRT_QUAL 27       /* G_BUTTON-Object in Tree PRT_MENU */
#define PRT_TEXT 29       /* G_BUTTON-Object in Tree PRT_MENU */
#define PRT_BLK 30        /* G_BUTTON-Object in Tree PRT_MENU */
#define DO_PRT 36         /* G_BUTTON-Object in Tree PRT_MENU */
#define PRT_CANC 37       /* G_BUTTON-Object in Tree PRT_MENU */

#define DISK_FMT 18     /* DIALOG-Tree */
#define DRIVE_A 6         /* G_BOXCHAR-Object in Tree DISK_FMT */
#define DRIVE_B 7         /* G_BOXCHAR-Object in Tree DISK_FMT */
#define NORM_FMT 10       /* G_BUTTON-Object in Tree DISK_FMT */
#define EXT_FORM 11       /* G_BUTTON-Object in Tree DISK_FMT */
#define ONE_SIDE 13       /* G_BOXCHAR-Object in Tree DISK_FMT */
#define TWO_SIDE 14       /* G_BOXCHAR-Object in Tree DISK_FMT */
#define EXT_BKG 15        /* G_IBOX-Object in Tree DISK_FMT */
#define RED_NORM 16       /* G_BOX-Object in Tree DISK_FMT */
#define TRK_DWN 17        /* G_BOXCHAR-Object in Tree DISK_FMT */
#define TRK 18            /* G_BUTTON-Object in Tree DISK_FMT */
#define TRK_UP 19         /* G_BOXCHAR-Object in Tree DISK_FMT */
#define SEK_UP 20         /* G_BOXCHAR-Object in Tree DISK_FMT */
#define SEKTOR 21         /* G_BUTTON-Object in Tree DISK_FMT */
#define SEK_DWN 22        /* G_BOXCHAR-Object in Tree DISK_FMT */
#define FMT_BYTE 25       /* G_TEXT-Object in Tree DISK_FMT */
#define FMT_CANC 26       /* G_BUTTON-Object in Tree DISK_FMT */
#define DO_FORMT 27       /* G_BUTTON-Object in Tree DISK_FMT */

#define PRG_INFO 19     /* DIALOG-Tree */
#define FILE_1 11         /* G_STRING-Object in Tree PRG_INFO */
#define FILE_2 13         /* G_STRING-Object in Tree PRG_INFO */
#define SIZE_1 20         /* G_STRING-Object in Tree PRG_INFO */
#define SIZE_2 22         /* G_STRING-Object in Tree PRG_INFO */
#define LINES_1 29        /* G_STRING-Object in Tree PRG_INFO */
#define LINES_2 31        /* G_STRING-Object in Tree PRG_INFO */
#define WORDS_1 38        /* G_STRING-Object in Tree PRG_INFO */
#define WORDS_2 40        /* G_STRING-Object in Tree PRG_INFO */
#define FREE_MEM 45       /* G_STRING-Object in Tree PRG_INFO */
#define ALL_MEM 46        /* G_STRING-Object in Tree PRG_INFO */

#define FILE_TYP 20     /* DIALOG-Tree */
#define MT_UNCMP 3        /* G_BUTTON-Object in Tree FILE_TYP */
#define MT_COMP 4         /* G_BUTTON-Object in Tree FILE_TYP */
#define TYP_ABBR 7        /* G_BUTTON-Object in Tree FILE_TYP */

#define NOTE_DIA 21     /* DIALOG-Tree */
#define NOTE_SW 3         /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LINE1 4         /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LINE2 5         /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LINE3 6         /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LINE4 7         /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LINE5 8         /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LINE6 9         /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LINE7 10        /* G_FTEXT-Object in Tree NOTE_DIA */
#define N_LOCK 12         /* G_BOX-Object in Tree NOTE_DIA */
#define N_KILL 13         /* G_BUTTON-Object in Tree NOTE_DIA */
#define N_OK 14           /* G_BUTTON-Object in Tree NOTE_DIA */
#define N_CANC 15         /* G_BUTTON-Object in Tree NOTE_DIA */

#define SHOWNOTE 22     /* DIALOG-Tree */
#define SN_SHOW 2         /* G_BUTTON-Object in Tree SHOWNOTE */
#define SN_JMP 3          /* G_BUTTON-Object in Tree SHOWNOTE */
#define SN_BKG 4          /* G_BOX-Object in Tree SHOWNOTE */
#define SN_LINE1 5        /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE2 6        /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE3 7        /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE4 8        /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE5 9        /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE6 10       /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE7 11       /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE8 12       /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINE9 13       /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINEA 14       /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINEB 15       /* G_STRING-Object in Tree SHOWNOTE */
#define SN_LINEC 16       /* G_STRING-Object in Tree SHOWNOTE */
#define SN_DOWN 17        /* G_BOXCHAR-Object in Tree SHOWNOTE */
#define SN_UP 18          /* G_BOXCHAR-Object in Tree SHOWNOTE */
#define SN_SLDB 19        /* G_BOX-Object in Tree SHOWNOTE */
#define SN_SLD 20         /* G_BOX-Object in Tree SHOWNOTE */
#define SN_CANC 21        /* G_BUTTON-Object in Tree SHOWNOTE */

#define DFMTINFO 23     /* DIALOG-Tree */
#define DFMT_SB 3         /* G_BOX-Object in Tree DFMTINFO */
#define DFMT_SLD 4        /* G_BOX-Object in Tree DFMTINFO */
#define DFMT_ST 5         /* G_TEXT-Object in Tree DFMTINFO */
