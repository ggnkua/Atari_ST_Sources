/* Array used in compress-routine */

int dt[256] = {0x1,
               0x2,
               0x3,
               0x4,
               0x5,
               0x6,
               0x7,
               0x8,
               0xA,
               0xB,
               0xC,
               0xD,
               0xE,
               0xF,
               0x10,
               0x14,
               0x15,
               0x16,
               0x17,
               0x18,
               0x1A,
               0x1B,
               0x1C,
               0x1D,
               0x1E,
               0x1F,
               0x20,
               0x28,
               0x2A,
               0x2B,
               0x2C,
               0x2D,
               0x2E,
               0x2F,
               0x30,
               0x34,
               0x35,
               0x36,
               0x37,
               0x38,
               0x3A,
               0x3B,
               0x3C,
               0x3D,
               0x3E,
               0x3F,
               0x40,
               0x50,
               0x54,
               0x55,
               0x56,
               0x57,
               0x58,
               0x5A,
               0x5B,
               0x5C,
               0x5D,
               0x5E,
               0x5F,
               0x60,
               0x68,
               0x6A,
               0x6B,
               0x6C,
               0x6D,
               0x6E,
               0x6F,
               0x70,
               0x74,
               0x75,
               0x76,
               0x77,
               0x78,
               0x7A,
               0x7B,
               0x7C,
               0x7D,
               0x7E,
               0x7F,
               0x80,
               0xA0,
               0xA8,
               0xAA,
               0xAB,
               0xAC,
               0xAD,
               0xAE,
               0xAF,
               0xB0,
               0xB4,
               0xB5,
               0xB6,
               0xB7,
               0xB8,
               0xBA,
               0xBB,
               0xBC,
               0xBD,
               0xBE,
               0xBF,
               0xC0,
               0xD0,
               0xD4,
               0xD5,
               0xD6,
               0xD7,
               0xD8,
               0xDA,
               0xDB,
               0xDC,
               0xDD,
               0xDE,
               0xDF,
               0xE0,
               0xE8,
               0xEA,
               0xEB,
               0xEC,
               0xED,
               0xEE,
               0xEF,
               0xF0,
               0xF4,
               0xF5,
               0xF6,
               0xF7,
               0xF8,
               0xFA,
               0xFB,
               0xFC,
               0xFD,
               0xFE,
               0xFF,
               0x100,
               0x140,
               0x150,
               0x154,
               0x155,
               0x156,
               0x157,
               0x158,
               0x15A,
               0x15B,
               0x15C,
               0x15D,
               0x15E,
               0x15F,
               0x160,
               0x168,
               0x16A,
               0x16B,
               0x16C,
               0x16D,
               0x16E,
               0x16F,
               0x170,
               0x174,
               0x175,
               0x176,
               0x177,
               0x178,
               0x17A,
               0x17B,
               0x17C,
               0x17D,
               0x17E,
               0x17F,
               0x180,
               0x1A0,
               0x1A8,
               0x1AA,
               0x1AB,
               0x1AC,
               0x1AD,
               0x1AE,
               0x1AF,
               0x1B0,
               0x1B4,
               0x1B5,
               0x1B6,
               0x1B7,
               0x1B8,
               0x1BA,
               0x1BB,
               0x1BC,
               0x1BD,
               0x1BE,
               0x1BF,
               0x1C0,
               0x1D0,
               0x1D4,
               0x1D5,
               0x1D6,
               0x1D7,
               0x1D8,
               0x1DA,
               0x1DB,
               0x1DC,
               0x1DD,
               0x1DE,
               0x1DF,
               0x1E0,
               0x1E8,
               0x1EA,
               0x1EB,
               0x1EC,
               0x1ED,
               0x1EE,
               0x1EF,
               0x1F0,
               0x1F4,
               0x1F5,
               0x1F6,
               0x1F7,
               0x1F8,
               0x1FA,
               0x1FB,
               0x1FC,
               0x1FD,
               0x1FE,
               0x1FF,
               0x200,
               0x280,
               0x2A0,
               0x2A8,
               0x2AA,
               0x2AB,
               0x2AC,
               0x2AD,
               0x2AE,
               0x2AF,
               0x2B0,
               0x2B4,
               0x2B5,
               0x2B6,
               0x2B7,
               0x2B8,
               0x2BA,
               0x2BB,
               0x2BC,
               0x2BD,
               0x2BE,
               0x2BF,
               0x2C0,
               0x2D0,
               0x2D4,
               0x2D5,
               0x2D6,
               0x2D7,
               0x2D8,
               0x2DA,
               0x2DB,
               0x2DC,
               0x2DD,
               0x2DE,
               0x2DF};
