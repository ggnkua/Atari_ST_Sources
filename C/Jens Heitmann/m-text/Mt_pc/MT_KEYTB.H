#define ALT_NUM 131
int alt_tab[] = {  0,   0,   0,   0,   0,   0,   0,   0,
									 0,  	0,   0,   0,   0,   0,   0,   0,
								 'Q', 'W', 'E', 'R', 'T', 'Z', 'U', 'I',
								 'O', 'P',   0,   0,   0,   0, 'A', 'S',
								 'D', 'F', 'G', 'H', 'J', 'K', 'L',   0,
								   0,   0,   0,   0, 'Y', 'X', 'C', 'V',
								 'B', 'N', 'M', ',', '.', '-', 	 0,   0,
									 0,   0,   0,   0,   0,   0,   0,   0,
									 0,   0,   0,   0,   0,   0,   0,   0,
									 0,   0,   0,   0,   0, '-', '+',   0,
									 0,   0,   0,   0,   0,   0,   0,   0,
								   0,   0,   0,   0,   0,   0,   0,   0,
								 '<',   0,   0, '(', ')', '/', '*',	'7',
								 '8', '9', '4', '5', '6', '1', '2', '3',
								 '0', '.',   0,   0,   0,   0,   0,   0,
								 '1', '2', '3', '4', '5', '6', '7', '8',
								 '9', '0', 'ž'};

#define CNTRL_NUM 114
int cntrl_tab[] = {  0,   0, '1', '2', '3', '4', '5', '6',
									 '7', '8', '9', '0', 'ž',0x27,   0,   0,
									 'Q', 'W', 'E', 'R', 'T', 'Z', 'U', 'I',
									 'O', 'P', 'š', '+',   0,   0, 'A', 'S',
									 'D', 'F', 'G', 'H', 'J', 'K', 'L', '™',
									 'Ž', '#',   0, '~', 'Y', 'X', 'C', 'V',
									 'B', 'N', 'M', ',', '.', '-', 	 0,   0,
										 0,   0,   0,   0,   0,   0,   0,   0,
										 0,   0,   0,   0,   0,   0,   0,   0,
										 0,   0, '-',   0,   0,   0, '+',   0,
										 0,   0,   0,   0,   0,   0,   0,   0,
									   0,   0,   0,   0,   0,   0,   0,   0,
									 '<',   0,   0, '(', ')', '/', '*',	'7',
									 '8', '9', '4', '5', '6', '1', '2', '3',
									 '0', '.'};
