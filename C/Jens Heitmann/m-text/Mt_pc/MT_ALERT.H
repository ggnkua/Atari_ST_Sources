#define DFMT_ATT "[3][ACHTUNG!|Formatieren l”scht alle |Daten einer Diskette!][ OK | Abbruch ]"

#define DFMT_DRV 43
#define DFMT_INS "[1][Zu formatierende Diskette |in Laufwerk X einlegen! ][ OK | Abbruch ]"

#define DFREE_BY 13
#define DFREE "[1][Disk hat 9999999 Bytes |freien Speicherplatz. ][ OK ]"

#define DELASK_1 "[2][\40"
#define DELASK_2 "\40 l”schen?             "
#define DELASK_3 "][ JA | NEIN | ABBRUCH ]"

#define ONLY_4 "[3][Nur maximal 4 Texte |gleichzeitig m”glich !][ OK ]"

#define NEW_ASK "[2][Dieser Text existiert |nicht, soll er neu |erstellt werden?][ JA | NEIN ]"
