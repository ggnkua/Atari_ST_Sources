/*************************************/
/* VDI_FONT.RSC - Include-File for C */
/*************************************/

#define FONTEDIT 0      /* DIALOG-Tree */
#define FL1 1             /* G_STRING-Object in Tree FONTEDIT */
#define F_BKG 2           /* G_BOX-Object in Tree FONTEDIT */
#define FL2 3             /* G_STRING-Object in Tree FONTEDIT */
#define C_BKG 4           /* G_BOX-Object in Tree FONTEDIT */
#define FL3 7             /* G_STRING-Object in Tree FONTEDIT */
#define FL4 8             /* G_STRING-Object in Tree FONTEDIT */
#define FL5 9             /* G_STRING-Object in Tree FONTEDIT */
#define FL6 10            /* G_STRING-Object in Tree FONTEDIT */
#define FL7 11            /* G_STRING-Object in Tree FONTEDIT */
#define FLA 12            /* G_STRING-Object in Tree FONTEDIT */
#define FL8 13            /* G_STRING-Object in Tree FONTEDIT */
#define FLB 14            /* G_STRING-Object in Tree FONTEDIT */
#define FL9 15            /* G_STRING-Object in Tree FONTEDIT */
#define FLC 16            /* G_STRING-Object in Tree FONTEDIT */
#define FLD 17            /* G_STRING-Object in Tree FONTEDIT */
#define FLE 18            /* G_STRING-Object in Tree FONTEDIT */
#define FLF 19            /* G_STRING-Object in Tree FONTEDIT */
#define FLG 20            /* G_STRING-Object in Tree FONTEDIT */
#define MARKER 21         /* G_IBOX-Object in Tree FONTEDIT */
#define SCL_BKG 22        /* G_BOX-Object in Tree FONTEDIT */
#define LINE_BKG 23       /* G_BOX-Object in Tree FONTEDIT */
#define DEF_BKG 24        /* G_BOX-Object in Tree FONTEDIT */
#define TOP 28            /* G_BOXTEXT-Object in Tree FONTEDIT */
#define ASCENT 29         /* G_BOXTEXT-Object in Tree FONTEDIT */
#define FONTNAME 30       /* G_STRING-Object in Tree FONTEDIT */
#define HALF 31           /* G_BOXTEXT-Object in Tree FONTEDIT */
#define BASE 32           /* G_BOXTEXT-Object in Tree FONTEDIT */
#define NAM_BKG 33        /* G_BOX-Object in Tree FONTEDIT */
#define CHAR_DEF 34       /* G_STRING-Object in Tree FONTEDIT */
#define SCL_LFT 35        /* G_BOX-Object in Tree FONTEDIT */
#define SCL 36            /* G_BOX-Object in Tree FONTEDIT */
#define SCL_RGT 37        /* G_BOX-Object in Tree FONTEDIT */
#define DESCENT 38        /* G_BOXTEXT-Object in Tree FONTEDIT */
#define BOTTOM 39         /* G_BOXTEXT-Object in Tree FONTEDIT */
#define UP 40             /* G_BOXCHAR-Object in Tree FONTEDIT */
#define DOWN 41           /* G_BOXCHAR-Object in Tree FONTEDIT */
#define LEFT 42           /* G_BOXCHAR-Object in Tree FONTEDIT */
#define RIGHT 43          /* G_BOXCHAR-Object in Tree FONTEDIT */

#define FE_MENU 1       /* MENU-Tree */
#define FE_ABOUT 9        /* G_STRING-Object in Tree FE_MENU */
#define NEW_FONT 18       /* G_STRING-Object in Tree FE_MENU */
#define LOADFONT 19       /* G_STRING-Object in Tree FE_MENU */
#define SAVEFONT 20       /* G_STRING-Object in Tree FE_MENU */
#define F_OK 22           /* G_STRING-Object in Tree FE_MENU */
#define C_HFLIP 24        /* G_STRING-Object in Tree FE_MENU */
#define C_VFLIP 25        /* G_STRING-Object in Tree FE_MENU */
#define HLF_HIGH 26       /* G_STRING-Object in Tree FE_MENU */
#define DOP_HIGH 27       /* G_STRING-Object in Tree FE_MENU */
#define HLF_WDTH 28       /* G_STRING-Object in Tree FE_MENU */
#define DOP_WDTH 29       /* G_STRING-Object in Tree FE_MENU */
#define C_UP 31           /* G_STRING-Object in Tree FE_MENU */
#define C_DWN 32          /* G_STRING-Object in Tree FE_MENU */
#define C_LFT 33          /* G_STRING-Object in Tree FE_MENU */
#define C_RGT 34          /* G_STRING-Object in Tree FE_MENU */
#define C_COPY 36         /* G_STRING-Object in Tree FE_MENU */
#define C_PASTE 37        /* G_STRING-Object in Tree FE_MENU */
#define C_CLEAR 38        /* G_STRING-Object in Tree FE_MENU */
#define F_UNDO 39         /* G_STRING-Object in Tree FE_MENU */
#define F_SHOW 40         /* G_STRING-Object in Tree FE_MENU */
#define AS_INTEL 42       /* G_STRING-Object in Tree FE_MENU */
#define AS_MOTOR 43       /* G_STRING-Object in Tree FE_MENU */

#define FE_INFO 2       /* DIALOG-Tree */

#define ED_FNAME 3      /* DIALOG-Tree */
#define ED_FN 2           /* G_FTEXT-Object in Tree ED_FNAME */

#define SHW_FLD 4       /* DIALOG-Tree */
#define SHW_NAM 3         /* G_STRING-Object in Tree SHW_FLD */
#define SHW_DEF 5         /* G_STRING-Object in Tree SHW_FLD */
#define SHW_WIND 6        /* G_BOX-Object in Tree SHW_FLD */
#define SHW_PARA 7        /* G_BOX-Object in Tree SHW_FLD */
#define SHW_TG 11         /* G_TEXT-Object in Tree SHW_FLD */
#define SHW_CBKG 12       /* G_BOX-Object in Tree SHW_FLD */
#define C_1 13            /* G_TEXT-Object in Tree SHW_FLD */
#define C_2 14            /* G_TEXT-Object in Tree SHW_FLD */
#define C_3 15            /* G_TEXT-Object in Tree SHW_FLD */
#define C_4 16            /* G_TEXT-Object in Tree SHW_FLD */
#define C_5 17            /* G_TEXT-Object in Tree SHW_FLD */
#define C_6 18            /* G_TEXT-Object in Tree SHW_FLD */
#define BOLD 19           /* G_BUTTON-Object in Tree SHW_FLD */
#define LIGHT 20          /* G_BUTTON-Object in Tree SHW_FLD */
#define ITALIC 21         /* G_BUTTON-Object in Tree SHW_FLD */
#define UNDERL 22         /* G_BUTTON-Object in Tree SHW_FLD */
#define OUTL 23           /* G_BUTTON-Object in Tree SHW_FLD */
#define C_8 24            /* G_TEXT-Object in Tree SHW_FLD */
#define TG_UP 25          /* G_BUTTON-Object in Tree SHW_FLD */
#define TG_DWN 26         /* G_BUTTON-Object in Tree SHW_FLD */
#define SHW_UP 27         /* G_TEXT-Object in Tree SHW_FLD */
#define UL_UP 28          /* G_BUTTON-Object in Tree SHW_FLD */
#define UL_DWN 29         /* G_BUTTON-Object in Tree SHW_FLD */
#define C_9 30            /* G_TEXT-Object in Tree SHW_FLD */
#define KR_UP 31          /* G_BUTTON-Object in Tree SHW_FLD */
#define KR_DWN 32         /* G_BUTTON-Object in Tree SHW_FLD */
#define SHW_DWN 33        /* G_TEXT-Object in Tree SHW_FLD */
#define C_A 34            /* G_TEXT-Object in Tree SHW_FLD */
#define C_B 35            /* G_TEXT-Object in Tree SHW_FLD */
#define SHW_END 36        /* G_BUTTON-Object in Tree SHW_FLD */
#define C_7 37            /* G_TEXT-Object in Tree SHW_FLD */
#define SHW_INFO 40       /* G_BOX-Object in Tree SHW_FLD */
#define CH_INFO 41        /* G_BUTTON-Object in Tree SHW_FLD */
#define SHW_DEZ 43        /* G_STRING-Object in Tree SHW_FLD */
#define SHW_HEX 45        /* G_STRING-Object in Tree SHW_FLD */
#define SHW_HGHT 48       /* G_STRING-Object in Tree SHW_FLD */
#define SHW_WDTH 49       /* G_STRING-Object in Tree SHW_FLD */
