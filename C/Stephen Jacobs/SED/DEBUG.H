#define PASS(msgstring)/* printf(msgstring), printf ("\n")*/

/* This debug header was added by Stephen Jacobs, and isn't part of GNU
*sed.  It may be hacked omitted or replaced at will.  The only other 
*thing I've done is fix a compiler dependency and an inappropriate declaration,
*which are marked in the source files with my initials, SAJ.
*/
