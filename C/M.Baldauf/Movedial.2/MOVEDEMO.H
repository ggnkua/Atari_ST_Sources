#define DIALOG 0  	/* TREE */
#define DIALOGDR 1  	/* OBJECT in TREE #0 */
#define DIALOGOK 7  	/* OBJECT in TREE #0 */
#define DIALOGON 11  	/* OBJECT in TREE #0 */
#define DIALOGOF 12  	/* OBJECT in TREE #0 */
#define DIALOGT1 8  	/* OBJECT in TREE #0 */
#define DIALOGT2 9  	/* OBJECT in TREE #0 */
#define POPUP 1  	/* TREE */
#define INFODIAL 2  	/* TREE */
#define POPQUIT 3  	/* OBJECT in TREE #1 */
#define POPMOVE 1  	/* OBJECT in TREE #1 */
#define POPPOPUP 2  	/* OBJECT in TREE #1 */
#define POPSTAND 5  	/* OBJECT in TREE #1 */
#define POPPIE 3  	/* TREE */
