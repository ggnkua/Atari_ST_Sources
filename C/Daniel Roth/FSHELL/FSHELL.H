#define MITGEM 41
#define COMLIN 42
#define UMBENNEN 2
#define EDITX 2
#define EDIT 1
#define ABBRUCH 3
#define FSHELLIN 1
#define KNOPF 21
#define TOP 3
#define MENU 0
#define INFO 10
#define INSTALL 19
#define AUSWAEHL 21
#define DATLOESH 23
#define DATUMBEN 24
#define EINSTESI 26
#define QUIT 28
#define EDITIERE 30
#define KOMPILIE 31
#define ERSTELLT 33
#define LINKEN 32
#define ANDERES 35
#define LOKEDITO 37
#define LOKCOMPI 38
#define LOKLINKE 39
