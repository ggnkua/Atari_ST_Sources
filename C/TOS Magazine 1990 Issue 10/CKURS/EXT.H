/*      EXT.H

        Extended library definitions

        Copyright (C) Borland International 1990
        All Rights Reserved.
*/


#if !defined( __EXT )
#define __EXT

int         kbhit( void );
int         getch( void );

#endif
