#define FORMAT1 0  	/* TREE */
#define FORMAT2 1  	/* TREE */
#define FMTDRV 3  	/* OBJECT in TREE #0 */
#define FMTLABEL 4  	/* OBJECT in TREE #0 */
#define FMTEXIT 6  	/* OBJECT in TREE #0 */
#define FMTBEG 7  	/* OBJECT in TREE #0 */
#define FMTEINS 8  	/* OBJECT in TREE #0 */
#define FMTZWEI 9  	/* OBJECT in TREE #0 */
#define FMTBAHN 2  	/* OBJECT in TREE #1 */
#define FMTSLID 3  	/* OBJECT in TREE #1 */
