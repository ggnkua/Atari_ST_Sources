#define TEXTMENU 0  	/* TREE */
#define TEXTDEMO 8  	/* OBJECT in TREE #0 */
#define TEXTQUIT 17  	/* OBJECT in TREE #0 */
#define LINEATTR 1  	/* TREE */
#define LINWIDTH 7  	/* OBJECT in TREE #1 */
#define LINEOK 13  	/* OBJECT in TREE #1 */
#define LINECAN 14  	/* OBJECT in TREE #1 */
#define LINELEAD 8  	/* OBJECT in TREE #1 */
#define HORALIGN 10  	/* OBJECT in TREE #1 */
#define VRTALIGN 11  	/* OBJECT in TREE #1 */
#define ROTATION 12  	/* OBJECT in TREE #1 */
#define ERASEWIN 21  	/* OBJECT in TREE #0 */
#define DISPXPOS 5  	/* OBJECT in TREE #1 */
#define DISPYPOS 6  	/* OBJECT in TREE #1 */
#define JUSTFLAG 9  	/* OBJECT in TREE #1 */
#define DISPCHAR 19  	/* OBJECT in TREE #0 */
#define CHARATTR 2  	/* TREE */
#define FONTID 4  	/* OBJECT in TREE #2 */
#define POINTSIZ 5  	/* OBJECT in TREE #2 */
#define PIXFLAG 6  	/* OBJECT in TREE #2 */
#define EFFECTS 7  	/* OBJECT in TREE #2 */
#define COLOR 8  	/* OBJECT in TREE #2 */
#define BACKCOLR 9  	/* OBJECT in TREE #2 */
#define CHAROK 10  	/* OBJECT in TREE #2 */
#define CHARCAN 11  	/* OBJECT in TREE #2 */
#define TEXTLINE 3  	/* OBJECT in TREE #1 */
#define DISPLINE 20  	/* OBJECT in TREE #0 */
#define ABOUTDMO 3  	/* TREE */
#define ABOUTOK 4  	/* OBJECT in TREE #3 */
