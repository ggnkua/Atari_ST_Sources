int	din_x[]={
	/* DIN A */
	841,594,420,297,210,148,105,74,52,
	/* DIN B */
	1000,707,500,353,250,176,125,88,62,
	/* DIN C */
	917,648,458,325,229,162,114,81,57,
	/* DIN D */
	771,545,385,272,192,136,96,68,48
};

int din_y[]={
	/* DIN A */
	1189,841,594,420,297,210,148,105,74,
	/* DIN B */
	1414,1000,707,500,353,250,176,125,88,
	/* DIN C */
	1297,917,648,458,324,229,162,114,81,
	/* DIN D */
	1090,771,545,385,272,192,136,96,68
};

