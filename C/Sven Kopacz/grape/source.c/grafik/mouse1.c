/* Mouse definition block */
/* Ebene einf�gen */
int mouse1[] =
{	0x0008,0x0008,0x0002,0x0000,0x0001,
/* Mask data */
	0x0000,0x0100,0x0100,0x0100,
	0x0100,0x0100,0x0100,0x0920,
	0x0920,0x0100,0x0100,0x0100,
	0x0100,0x0100,0x0100,0x0000,
/* Cursor data */
	0x0000,0x0280,0x0280,0x0280,
	0x0280,0x1290,0x1AB0,0x16D0,
	0x16D0,0x1AB0,0x1290,0x0280,
	0x0280,0x0280,0x0280,0x0000
};

/* Mouse definition block */ 
/* Nicht hier-Kreuz */ 
int mouse2[] = 
{ 0x0008,0x0008,0x0002,0x0000,0x0001, 
/* Mask data */ 
  0x4002,0xA005,0x500A,0x2814, 
  0x1428,0x0A50,0x05A0,0x0240, 
  0x0240,0x05A0,0x0A50,0x1428, 
  0x2814,0x500A,0xA005,0x4002, 
/* Cursor data */ 
  0x0000,0x4002,0x2004,0x1008, 
  0x0810,0x0420,0x0240,0x0180, 
  0x0180,0x0240,0x0420,0x0810, 
  0x1008,0x2004,0x4002,0x0000 
}; 

/* Mouse definition block */ 
/* Flache Hand */ 
int mouse3[] = 
{ 0x0008,0x0008,0x0001,0x0000,0x0001, 
/* Mask data */ 
  0x0300,0x1FB0,0x3FF8,0x3FFC, 
  0x7FFE,0xFFFE,0xFFFE,0x7FFF, 
  0x7FFF,0xFFFF,0xFFFF,0x7FFF, 
  0x3FFF,0x0FFF,0x01FF,0x003F, 
/* Cursor data */ 
  0x0300,0x1CB0,0x2448,0x2224, 
  0x7112,0x9882,0x8402,0x4201, 
  0x7001,0x9801,0x8401,0x4000, 
  0x3000,0x0E00,0x01C0,0x0030 
}; 
