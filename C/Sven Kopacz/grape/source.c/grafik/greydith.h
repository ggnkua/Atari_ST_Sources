extern unsigned int r_mul_table[256], g_mul_table[256], b_mul_table[256];