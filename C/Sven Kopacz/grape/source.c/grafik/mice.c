/* Mausform m_stift */
int m_stift[] = 
{
 0x0000, 0x000F, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x001E, 0x003F, 0x007F, 0x00FF, 
 0x01FF, 0x03FE, 0x07FC, 0x0FF8, 
 0x1FF0, 0x3FE0, 0x3FC0, 0x7F80, 
 0x7F00, 0xFE00, 0xF800, 0xE000, 
  /* Cursor data */
 0x000A, 0x0015, 0x002A, 0x0055, 
 0x00AA, 0x0154, 0x02A8, 0x0550, 
 0x0AA0, 0x1540, 0x1280, 0x2100, 
 0x2600, 0x7800, 0x6000, 0x8000, 
 };

/* Mausform m_fill */
int m_fill[] = 
{
 0x0000, 0x000F, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x00C0, 0x03E0, 0x07F0, 0x0FF8, 
 0x1FFC, 0x3DFE, 0x7FFF, 0x7FFF, 
 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFDFE, 0xF838, 0xE000, 0xE000, 
  /* Cursor data */
 0x0000, 0x00C0, 0x0320, 0x0430, 
 0x0C28, 0x1C24, 0x3742, 0x2F41, 
 0x5F81, 0x5F01, 0x7E02, 0xF9C6, 
 0xF838, 0xE000, 0x8000, 0x8000, 
 };

/* Mausform m_figur */
int m_figur[] = 
{
 0x0007, 0x0007, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0380, 0x0380, 0x0380, 0x0380, 
 0x0380, 0x0380, 0xFFFE, 0xFFFE, 
 0xFFFE, 0x0380, 0x0380, 0x0380, 
 0x0380, 0x0380, 0x0380, 0x0000, 
  /* Cursor data */
 0x0000, 0x0100, 0x0100, 0x0100, 
 0x0100, 0x0100, 0x0100, 0x7EFC, 
 0x0100, 0x0100, 0x0100, 0x0100, 
 0x0100, 0x0100, 0x0000, 0x0000, 
 };

/* Mausform m_stempel */
int m_stempel[] = 
{
 0x0007, 0x0007, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x03C0, 0x07E0, 0x07E0, 0x07E0, 
 0x07E0, 0x07E0, 0x07E0, 0x03C0, 
 0x1FF8, 0x3FFC, 0x7FFE, 0x7FFE, 
 0x7FFE, 0x7FFE, 0x3FFC, 0x0000, 
  /* Cursor data */
 0x0000, 0x0180, 0x0240, 0x0240, 
 0x0240, 0x0240, 0x0180, 0x0180, 
 0x0180, 0x0E70, 0x1008, 0x2004, 
 0x2004, 0x1FF8, 0x0000, 0x0000, 
 };

/* Mausform m_rahmen */
int m_rahmen[] = 
{
 0x0001, 0x0001, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xFFFF, 0xFFFF, 0xC003, 0xC003, 
 0xC003, 0xC003, 0xC003, 0xC003, 
 0xC003, 0xC003, 0xC003, 0xFFFF, 
 0xFFFF, 0x0000, 0x0000, 0x0000, 
  /* Cursor data */
 0x0000, 0x6DB6, 0x4002, 0x0000, 
 0x4002, 0x4002, 0x0000, 0x4002, 
 0x4002, 0x0000, 0x4002, 0x6DB6, 
 0x0000, 0x0000, 0x0000, 0x0000, 
 };

/* Mausform m_stick */
int m_stick[] = 
{
 0x0002, 0x000D, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x001E, 0x003F, 0x007F, 0x00FF, 
 0x01FE, 0x03FC, 0x07F8, 0x0FF0, 
 0x1FE0, 0x3FC0, 0x7F80, 0xFF00, 
 0xFE00, 0xFC00, 0x7800, 0x3000, 
  /* Cursor data */
 0x000E, 0x0017, 0x002F, 0x005E, 
 0x00BC, 0x0178, 0x02F0, 0x05E0, 
 0x0FC0, 0x1380, 0x2100, 0x5200, 
 0x4C00, 0x4800, 0x3000, 0x0000, 
 };

/* Mausform m_slasso */
int m_slasso[] = 
{
 0x0008, 0x0007, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xFFFF, 0xFFFF, 0xC003, 0xC003, 
 0xC003, 0xC183, 0xC183, 0xC663, 
 0xC663, 0xC183, 0xC183, 0xC003, 
 0xC003, 0xC003, 0xFFFF, 0xFFFF, 
  /* Cursor data */
 0xFFFF, 0x8001, 0x8001, 0x8001, 
 0x8001, 0x8081, 0x8101, 0x8441, 
 0x8221, 0x8081, 0x8101, 0x8001, 
 0x8001, 0x8001, 0x8001, 0xFFFF, 
 };

/* Mausform m_zoom_in */
int m_zoom_in[] = 
{
 0x0005, 0x0006, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x0E00, 0x3F80, 0x7FC0, 
 0x71C0, 0xE0E0, 0xE0E0, 0xE0E0, 
 0x71C0, 0x7FE0, 0x3FF0, 0x0EF8, 
 0x007C, 0x003E, 0x001E, 0x000C, 
  /* Cursor data */
 0x0000, 0x0000, 0x0E00, 0x3180, 
 0x2080, 0x4040, 0x4040, 0x4040, 
 0x2080, 0x3180, 0x0E60, 0x0070, 
 0x0038, 0x001C, 0x000C, 0x0000, 
 };

/* Mausform m_zoom_out */
int m_zoom_out[] = 
{
 0x0005, 0x0006, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x0000, 0x0E3E, 0x1F7F, 
 0x3FBE, 0x7FC0, 0x7FC0, 0x7FC0, 
 0x3F80, 0x1FE0, 0x0EF0, 0x00F8, 
 0x007C, 0x003E, 0x001E, 0x000C, 
  /* Cursor data */
 0x0000, 0x0000, 0x0000, 0x0E3E, 
 0x1100, 0x2080, 0x2080, 0x2080, 
 0x1100, 0x0E80, 0x0060, 0x0070, 
 0x0038, 0x001C, 0x000C, 0x0000, 
 };

/* Mausform m_cross */
int m_cross[] = 
{
 0x0008, 0x0008, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xE007, 0xF00F, 0xF81F, 0x7C3E, 
 0x3E7C, 0x1FF8, 0x0FF0, 0x07E0, 
 0x07E0, 0x0FF0, 0x1FF8, 0x3E7C, 
 0x7C3E, 0xF81F, 0xF00F, 0xE007, 
  /* Cursor data */
 0x0000, 0x6006, 0x700E, 0x381C, 
 0x1C38, 0x0E70, 0x07E0, 0x03C0, 
 0x03C0, 0x07E0, 0x0E70, 0x1C38, 
 0x381C, 0x700E, 0x6006, 0x0000, 
 };

/* Mausform m_insert */
int m_insert[] = 
{
 0x0007, 0x0008, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0200, 0x07C0, 0xC7C3, 0xE7C7, 
 0xF7CF, 0xFFDF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0xFFFF, 0xF7EF, 
 0xE7E7, 0xC7E3, 0x07E0, 0x0240, 
  /* Cursor data */
 0x0000, 0x0240, 0x0240, 0xC243, 
 0xA245, 0x9249, 0x8A51, 0x8661, 
 0x8661, 0x8A51, 0x9249, 0xA245, 
 0xC243, 0x0240, 0x0240, 0x0000, 
 };

/* Mausform m_plane */
int m_plane[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xFF00, 0xFFC0, 0xFFC0, 0xFFE0, 
 0xFFF0, 0xFFF0, 0xFFF0, 0xFFF0, 
 0xFFF0, 0xFFF0, 0xFFF0, 0xFFF0, 
 0xFFF0, 0xFFF0, 0xFFF0, 0x0000, 
  /* Cursor data */
 0xFF00, 0x8180, 0x8140, 0x8120, 
 0x81F0, 0x8010, 0x8010, 0x8010, 
 0x8010, 0x8010, 0x8010, 0x8010, 
 0x8010, 0x8010, 0xFFF0, 0x0000, 
 };

/* Mausform o_undo_1 */
int o_undo_1[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x0000, 0x0820, 0x1C70, 
 0x3EF8, 0x3EF8, 0x3EF8, 0x3EF8, 
 0x3EF8, 0x3FF8, 0x3FF8, 0x1FF0, 
 0x0FE0, 0x07C0, 0x0000, 0x0000, 
  /* Cursor data */
 0x0000, 0x0000, 0x0000, 0x0820, 
 0x1C70, 0x1C70, 0x1C70, 0x1C70, 
 0x1C70, 0x1C70, 0x1FF0, 0x0FE0, 
 0x07C0, 0x0000, 0x0000, 0x0000, 
 };

/* Mausform o_undo_2 */
int o_undo_2[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x0000, 0x07F0, 0x0FF8, 
 0x1FFC, 0x3FF8, 0x3FF0, 0x3E00, 
 0x3FF0, 0x3FF8, 0x1FFC, 0x0FF8, 
 0x07F0, 0x0000, 0x0000, 0x0000, 
  /* Cursor data */
 0x0000, 0x0000, 0x0000, 0x07F0, 
 0x0808, 0x13F0, 0x1400, 0x1400, 
 0x1400, 0x13F0, 0x0808, 0x07F0, 
 0x0000, 0x0000, 0x0000, 0x0000, 
 };

/* Mausform o_undo_3 */
int o_undo_3[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x0000, 0x07C0, 0x0FE0, 
 0x1FF0, 0x3FF8, 0x3FF8, 0x3EF8, 
 0x3EF8, 0x3EF8, 0x3EF8, 0x3EF8, 
 0x1C70, 0x0820, 0x0000, 0x0000, 
  /* Cursor data */
 0x0000, 0x0000, 0x0000, 0x07C0, 
 0x0820, 0x1390, 0x1450, 0x1450, 
 0x1450, 0x1450, 0x1450, 0x1450, 
 0x0820, 0x0000, 0x0000, 0x0000, 
 };

/* Mausform o_undo_4 */
int o_undo_4[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x0000, 0x0FE0, 0x1FF0, 
 0x3FF8, 0x1FFC, 0x0FFC, 0x007C, 
 0x0FFC, 0x1FFC, 0x3FF8, 0x1FF0, 
 0x0FE0, 0x0000, 0x0000, 0x0000, 
  /* Cursor data */
 0x0000, 0x0000, 0x0000, 0x0FE0, 
 0x1010, 0x0FC8, 0x0028, 0x0028, 
 0x0028, 0x0FC8, 0x1010, 0x0FE0, 
 0x0000, 0x0000, 0x0000, 0x0000, 
 };

/* Mausform m_alldir */
int m_alldir[] = 
{
 0x0007, 0x0008, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07E0, 0x0FF0, 0x0FF0, 0x0FF0, 
 0x7FFE, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0xFFFF, 0x7FFE, 
 0x0FF0, 0x0FF0, 0x0FF0, 0x07E0, 
  /* Cursor data */
 0x0180, 0x0240, 0x0420, 0x0660, 
 0x0240, 0x324C, 0x5E7A, 0x8001, 
 0x8001, 0x5E7A, 0x324C, 0x0240, 
 0x0660, 0x0420, 0x0240, 0x0180, 
 };

/* Mausform m_updn */
int m_updn[] = 
{
 0x0007, 0x0008, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x03C0, 0x07E0, 0x0FF0, 
 0x1FF8, 0x1FF8, 0x0FF0, 0x07E0, 
 0x07E0, 0x0FF0, 0x1FF8, 0x1FF8, 
 0x0FF0, 0x07E0, 0x03C0, 0x0180, 
  /* Cursor data */
 0x0000, 0x0180, 0x0240, 0x0420, 
 0x0810, 0x0E70, 0x0240, 0x0240, 
 0x0240, 0x0240, 0x0E70, 0x0810, 
 0x0420, 0x0240, 0x0180, 0x0000, 
 };

/* Mausform m_lfrt */
int m_lfrt[] = 
{
 0x0007, 0x0008, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x0000, 0x0000, 0x1818, 
 0x3C3C, 0x7FFE, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0x7FFE, 0x3C3C, 
 0x1818, 0x0000, 0x0000, 0x0000, 
  /* Cursor data */
 0x0000, 0x0000, 0x0000, 0x0000, 
 0x1818, 0x2814, 0x4FF2, 0x8001, 
 0x8001, 0x4FF2, 0x2814, 0x1818, 
 0x0000, 0x0000, 0x0000, 0x0000, 
 };

/* Mausform m_dia1 */
int m_dia1[] = 
{
 0x0007, 0x0008, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x01FE, 0x01FE, 0x01FE, 
 0x01FE, 0x03FE, 0x07FE, 0x7FFE, 
 0x7FFE, 0x7FE0, 0x7FC0, 0x7F80, 
 0x7F80, 0x7F80, 0x7F80, 0x0000, 
  /* Cursor data */
 0x0000, 0x0000, 0x00FC, 0x0084, 
 0x0044, 0x0084, 0x0114, 0x022C, 
 0x3440, 0x2880, 0x2100, 0x2200, 
 0x2100, 0x3F00, 0x0000, 0x0000, 
 };

/* Mausform m_dia2 */
int m_dia2[] = 
{
 0x0007, 0x0008, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0000, 0x7F80, 0x7F80, 0x7F80, 
 0x7F80, 0x7FC0, 0x7FE0, 0x7FFE, 
 0x7FFE, 0x07FE, 0x03FE, 0x01FE, 
 0x01FE, 0x01FE, 0x01FE, 0x0000, 
  /* Cursor data */
 0x0000, 0x0000, 0x3F00, 0x2100, 
 0x2200, 0x2100, 0x2880, 0x3440, 
 0x022C, 0x0114, 0x0084, 0x0044, 
 0x0084, 0x00FC, 0x0000, 0x0000, 
 };

/* Mausform m_undo_1 */
int m_undo_1[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xFF00, 0xFFC0, 0xFFF8, 0xFFFE, 
 0xFFFE, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0x07FF, 0x07FF, 
  /* Cursor data */
 0xFF00, 0x8180, 0x8178, 0x812C, 
 0x81EA, 0x8029, 0x802F, 0x8021, 
 0x8021, 0x8021, 0x8021, 0x8021, 
 0x8021, 0xFFE1, 0x0401, 0x07FF, 
 };

/* Mausform m_undo_2 */
int m_undo_2[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xFF00, 0xFFC0, 0xFFF8, 0xFFFE, 
 0xFFFE, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0x07FF, 0x07FF, 
  /* Cursor data */
 0xFF00, 0x8180, 0x8378, 0x812C, 
 0x85EA, 0x8029, 0x800F, 0x8421, 
 0x8001, 0x8021, 0x8401, 0x8021, 
 0x8001, 0xFEA1, 0x0401, 0x07FF, 
 };

/* Mausform m_undo_3 */
int m_undo_3[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xFF00, 0xFFC0, 0xFFF8, 0xFFFE, 
 0xFFFE, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0x07FF, 0x07FF, 
  /* Cursor data */
 0xFF00, 0x8180, 0x8578, 0x800C, 
 0x852A, 0x8009, 0x840F, 0x8021, 
 0x8401, 0x8001, 0x8421, 0x8001, 
 0x8401, 0xFD21, 0x0401, 0x07FF, 
 };

/* Mausform m_undo_4 */
int m_undo_4[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0xFF00, 0xFFC0, 0xFFF8, 0xFFFE, 
 0xFFFE, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
 0xFFFF, 0xFFFF, 0x07FF, 0x07FF, 
  /* Cursor data */
 0xFF00, 0x8180, 0x87F8, 0x840C, 
 0x840A, 0x8409, 0x840F, 0x8401, 
 0x8401, 0x8401, 0x8401, 0x8401, 
 0x8401, 0xFC01, 0x0401, 0x07FF, 
 };

/* Mausform m_click1 */
int m_click1[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0200, 0x0100, 0x0080, 0x0080, 
 0x0100, 0x0FE0, 0x1FF0, 0x1FF0, 
 0x1FF0, 0x1FF0, 0x1FF0, 0x1FF0, 
 0x1FF0, 0x1FF0, 0x1FF0, 0x0FE0, 
  /* Cursor data */
 0x0200, 0x0100, 0x0080, 0x0080, 
 0x0100, 0x0FE0, 0x1110, 0x1110, 
 0x1110, 0x1FF0, 0x1010, 0x1010, 
 0x1010, 0x1010, 0x1010, 0x0FE0, 
 };

/* Mausform m_click2 */
int m_click2[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x0200, 0x0100, 0x0080, 0x0080, 
 0x0100, 0x0FE0, 0x1FF0, 0x1FF0, 
 0x1FF0, 0x1FF0, 0x1FF0, 0x1FF0, 
 0x1FF0, 0x1FF0, 0x1FF0, 0x0FE0, 
  /* Cursor data */
 0x0200, 0x0100, 0x0080, 0x0080, 
 0x0100, 0x0FE0, 0x1F10, 0x1F10, 
 0x1F10, 0x1FF0, 0x1010, 0x1010, 
 0x1010, 0x1010, 0x1010, 0x0FE0, 
 };

/* Mausform m_pipe */
int m_pipe[] = 
{
 0x0000, 0x000F, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x001F, 0x003F, 0x003F, 0x01FF, 
 0x00FF, 0x01FE, 0x03F8, 0x07F8, 
 0x0FE8, 0x1FC0, 0x3F80, 0x7F00, 
 0x7E00, 0xFC00, 0xF800, 0xE000, 
  /* Cursor data */
 0x000E, 0x0013, 0x0017, 0x01BF, 
 0x00FE, 0x00F8, 0x0130, 0x0238, 
 0x0448, 0x0880, 0x1100, 0x2200, 
 0x4400, 0x4800, 0x7000, 0x8000, 
 };

/* Mausform T1 */
int T1[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x1930, 0x2108, 0x4104, 
 0x4104, 0x8102, 0x8102, 0x8102, 
 0x8002, 0x8002, 0x4004, 0x4004, 
 0x2008, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T2 */
int T2[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21C8, 0x41C4, 
 0x4184, 0x8182, 0x8102, 0x8102, 
 0x8002, 0x8002, 0x4004, 0x4004, 
 0x2008, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T3 */
int T3[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41F4, 
 0x41E4, 0x81C2, 0x8182, 0x8102, 
 0x8002, 0x8002, 0x4004, 0x4004, 
 0x2008, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T4 */
int T4[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81F2, 0x81C2, 0x8102, 
 0x8002, 0x8002, 0x4004, 0x4004, 
 0x2008, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T5 */
int T5[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x8002, 0x8002, 0x4004, 0x4004, 
 0x2008, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T6 */
int T6[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x80FE, 0x803E, 0x400C, 0x4004, 
 0x2008, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T7 */
int T7[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x80FE, 0x807E, 0x403C, 0x401C, 
 0x2008, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T8 */
int T8[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x80FE, 0x80FE, 0x407C, 0x407C, 
 0x2038, 0x1830, 0x07C0, 0x0000, 
 };

/* Mausform T9 */
int T9[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x81FE, 0x81FE, 0x41FC, 0x41FC, 
 0x21F8, 0x19F0, 0x07C0, 0x0000, 
 };

/* Mausform TA */
int TA[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x83FE, 0x83FE, 0x47FC, 0x47FC, 
 0x2FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

/* Mausform TB */
int TB[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x83FE, 0x87FE, 0x4FFC, 0x5FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

/* Mausform TC */
int TC[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0x81FE, 
 0x87FE, 0x9FFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

/* Mausform TD */
int TD[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0x81FE, 0x81FE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

/* Mausform TE */
int TE[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x41FC, 
 0x41FC, 0xF1FE, 0xFDFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

/* Mausform TF */
int TF[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x21F8, 0x71FC, 
 0x79FC, 0xFDFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

/* Mausform TG */
int TG[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x19F0, 0x39F8, 0x79FC, 
 0x7DFC, 0xFDFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

/* Mausform TH */
int TH[] = 
{
 0x0000, 0x0000, 0x0001, 0x0000, 0x0001,
 /* Mask data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
  /* Cursor data */
 0x07C0, 0x1FF0, 0x3FF8, 0x7FFC, 
 0x7FFC, 0xFFFE, 0xFFFE, 0xFFFE, 
 0xFFFE, 0xFFFE, 0x7FFC, 0x7FFC, 
 0x3FF8, 0x1FF0, 0x07C0, 0x0000, 
 };

