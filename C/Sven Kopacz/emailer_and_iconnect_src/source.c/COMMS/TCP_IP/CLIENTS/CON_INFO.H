/* Resource Datei Indizes f�r CON_INFO */

#define MAIN             0   /* Formular/Dialog */
#define POPIP            8   /* STRING in Baum MAIN */
#define SMTPIP           9   /* STRING in Baum MAIN */
#define NEWSIP           10  /* STRING in Baum MAIN */
#define TIMEIP           11  /* STRING in Baum MAIN */
#define EMAIL            12  /* STRING in Baum MAIN */
#define REAL             13  /* STRING in Baum MAIN */
#define ICONVERS         15  /* TEXT in Baum MAIN */
#define LOCIP            18  /* STRING in Baum MAIN */
#define REMIP            20  /* STRING in Baum MAIN */
#define DNSIP            22  /* STRING in Baum MAIN */
#define TIME             23  /* TEXT in Baum MAIN */
#define BRCVD            25  /* TEXT in Baum MAIN */
#define BSENT            26  /* TEXT in Baum MAIN */
#define CONN_MSG         31  /* STRING in Baum MAIN */
#define ICOMAX           35  /* USERDEF in Baum MAIN */

#define STRINGS          1   /* Formular/Dialog */
#define UNKNOWN          1   /* STRING in Baum STRINGS */
