void	ed_cur_sel(WINDOW *win);
void	earrowed(WINDOW *win, int *pbuf);
void	evslid(WINDOW *win, int *pbuf);
int		store_buf(EDIT_OB *edob);

