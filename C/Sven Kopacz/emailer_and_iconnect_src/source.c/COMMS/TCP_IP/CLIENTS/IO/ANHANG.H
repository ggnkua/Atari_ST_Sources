extern int gemscript;
extern WINDOW anh_win;

extern void extract_atx(MAIL_ATX *atx, int save_show);
extern void anhang_win(void);
extern void do_anh_double(int ob);
extern int gemscript_init(void);
extern void anhang_message(int *pbuf);
extern OBJECT *create_anhang_rsc(MAIL_ATX *atx);

