void	process_gs_request(int *pbuf);
void process_gs_command(int *pbuf);
