extern load_img(MFDB *mf, char *path);
