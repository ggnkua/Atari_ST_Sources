/* Resource Datei Indizes f�r EMAILER */

#define MENU             0   /* Menuebaum */
#define IO               3   /* TITLE in Baum MENU */
#define MINFO            12  /* STRING in Baum MENU */
#define MNEW             21  /* STRING in Baum MENU */
#define MOPEN            23  /* STRING in Baum MENU */
#define MMERGE           24  /* STRING in Baum MENU */
#define MCLOSE           25  /* STRING in Baum MENU */
#define MSAVE            27  /* STRING in Baum MENU */
#define MSAVEAS          28  /* STRING in Baum MENU */
#define MQUIT            30  /* STRING in Baum MENU */
#define MUNDO            32  /* STRING in Baum MENU */
#define MCUT             34  /* STRING in Baum MENU */
#define MCOPY            35  /* STRING in Baum MENU */
#define MPASTE           36  /* STRING in Baum MENU */
#define MQUOTE           38  /* STRING in Baum MENU */
#define MALL             40  /* STRING in Baum MENU */
#define MSEARCH          42  /* STRING in Baum MENU */
#define MSAGAIN          43  /* STRING in Baum MENU */
#define MVALLE           45  /* STRING in Baum MENU */
#define MVSNDSNT         47  /* STRING in Baum MENU */
#define MVSND            48  /* STRING in Baum MENU */
#define MVSNT            49  /* STRING in Baum MENU */
#define MVNEWRED         51  /* STRING in Baum MENU */
#define MVRED            52  /* STRING in Baum MENU */
#define MVNEW            53  /* STRING in Baum MENU */
#define MVFROM           55  /* STRING in Baum MENU */
#define MVSUBJ           56  /* STRING in Baum MENU */
#define MVDATE           57  /* STRING in Baum MENU */
#define MWCYCLE          59  /* STRING in Baum MENU */
#define MWANHANG         60  /* STRING in Baum MENU */
#define MALTFONT         61  /* STRING in Baum MENU */
#define MMNEW            63  /* STRING in Baum MENU */
#define MANSWER          65  /* STRING in Baum MENU */
#define MWEITER          66  /* STRING in Baum MENU */
#define MCOMMENT         67  /* STRING in Baum MENU */
#define MEDIT            69  /* STRING in Baum MENU */
#define MNOCHMAL         70  /* STRING in Baum MENU */
#define MJETZT           71  /* STRING in Baum MENU */
#define MDELAY           72  /* STRING in Baum MENU */
#define MSORT            74  /* STRING in Baum MENU */
#define MORDBYFIL        75  /* STRING in Baum MENU */
#define MKILL            76  /* STRING in Baum MENU */
#define MINTEREST        78  /* STRING in Baum MENU */
#define MORGFILE         80  /* STRING in Baum MENU */
#define MORIGINAL        81  /* STRING in Baum MENU */
#define MEXCHANGE        83  /* STRING in Baum MENU */
#define MFULLSEARCH      85  /* STRING in Baum MENU */
#define MADRBOOK         87  /* STRING in Baum MENU */
#define MGROUPS          88  /* STRING in Baum MENU */
#define MFOLDER          89  /* STRING in Baum MENU */
#define MFILTERS         90  /* STRING in Baum MENU */
#define MCLEANUP         92  /* STRING in Baum MENU */
#define MIMPORT          93  /* STRING in Baum MENU */
#define MDBCHECK         94  /* STRING in Baum MENU */
#define MANZEIGE         96  /* STRING in Baum MENU */
#define MFARBEN          97  /* STRING in Baum MENU */
#define MDBASEOPT        98  /* STRING in Baum MENU */
#define MINTERNET        100 /* STRING in Baum MENU */
#define MSIG             101 /* STRING in Baum MENU */
#define MADRESSES        102 /* STRING in Baum MENU */

#define INFOTREE         1   /* Formular/Dialog */
#define USERNAME         2   /* TEXT in Baum INFOTREE */
#define USERFIRMA        3   /* TEXT in Baum INFOTREE */
#define INFOK            9   /* BUTTON in Baum INFOTREE */
#define ASH_URL          10  /* TEXT in Baum INFOTREE */
#define SCROLLINF        11  /* USERDEF in Baum INFOTREE */
#define INFOME           12  /* STRING in Baum INFOTREE */
#define INFODATE         13  /* STRING in Baum INFOTREE */
#define INFOVERSION      14  /* STRING in Baum INFOTREE */
#define INFOAUTOR        15  /* STRING in Baum INFOTREE */

#define READ             2   /* Formular/Dialog */
#define SUCHEN           1   /* BUTTON in Baum READ */
#define ISUCHEN          2   /* USERDEF in Baum READ */
#define ORDNEN           3   /* BUTTON in Baum READ */
#define IORDNEN          4   /* USERDEF in Baum READ */
#define LOESCHEN         5   /* BUTTON in Baum READ */
#define ILOESCHEN        6   /* USERDEF in Baum READ */
#define ANTWORT          7   /* BUTTON in Baum READ */
#define IANTWORT         8   /* USERDEF in Baum READ */
#define BEITRAG          9   /* BUTTON in Baum READ */
#define IBEITRAG         10  /* USERDEF in Baum READ */
#define NEU              11  /* BUTTON in Baum READ */
#define INEU             12  /* USERDEF in Baum READ */
#define POPUP            13  /* BUTTON in Baum READ */
#define IPOPUP           14  /* USERDEF in Baum READ */
#define ALISTE           15  /* IBOX in Baum READ */
#define FLISTE           16  /* IBOX in Baum READ */
#define LISTE            17  /* USERDEF in Baum READ */
#define ABSWIDTH         18  /* BOXTEXT in Baum READ */
#define ABSSORT          19  /* IMAGE in Baum READ */
#define BTRWIDTH         20  /* BOXTEXT in Baum READ */
#define BTRSORT          21  /* IMAGE in Baum READ */
#define DATWIDTH         22  /* BOXTEXT in Baum READ */
#define DATSORT          23  /* IMAGE in Baum READ */
#define BAR              24  /* BOX in Baum READ */
#define SLIDE            25  /* BOX in Baum READ */
#define UP               26  /* BOXCHAR in Baum READ */
#define DOWN             27  /* BOXCHAR in Baum READ */
#define FTEXT            28  /* IBOX in Baum READ */
#define KOPF             29  /* BOX in Baum READ */
#define ANHANG           30  /* USERDEF in Baum READ */
#define ANZANHANG        31  /* TEXT in Baum READ */
#define ROSE             33  /* USERDEF in Baum READ */
#define ABSENDER         35  /* BOXTEXT in Baum READ */
#define PUT_ADR          36  /* USERDEF in Baum READ */
#define SHOWORG          37  /* USERDEF in Baum READ */
#define BETREFF          39  /* BOXTEXT in Baum READ */
#define SWAP_IGN_CRLF    40  /* USERDEF in Baum READ */
#define TEXT             41  /* USERDEF in Baum READ */
#define LINKS            42  /* BOXTEXT in Baum READ */
#define RECHTS           43  /* BOXTEXT in Baum READ */
#define TEILER           44  /* BOXTEXT in Baum READ */

#define LISTPOPUP        3   /* Formular/Dialog */

#define COL2POPUP        4   /* Formular/Dialog */

#define COL4POPUP        5   /* Formular/Dialog */

#define COL8POPUP        6   /* Formular/Dialog */

#define EDITOR           7   /* Formular/Dialog */
#define HEADFRAME        1   /* IBOX in Baum EDITOR */
#define EHEAD            2   /* USERDEF in Baum EDITOR */
#define TO               3   /* BUTTON in Baum EDITOR */
#define ITO              4   /* USERDEF in Baum EDITOR */
#define ETO              5   /* FTEXT in Baum EDITOR */
#define HIDEFRAME        6   /* IBOX in Baum EDITOR */
#define CC               7   /* BUTTON in Baum EDITOR */
#define ICC              8   /* USERDEF in Baum EDITOR */
#define ESUBJECT         9   /* FTEXT in Baum EDITOR */
#define BCC              10  /* BUTTON in Baum EDITOR */
#define IBCC             11  /* USERDEF in Baum EDITOR */
#define ECC              12  /* FTEXT in Baum EDITOR */
#define EBCC             14  /* FTEXT in Baum EDITOR */
#define EDSAVE           15  /* BUTTON in Baum EDITOR */
#define IEDSAVE          16  /* USERDEF in Baum EDITOR */
#define EDSEND           17  /* BUTTON in Baum EDITOR */
#define IEDSEND          18  /* USERDEF in Baum EDITOR */
#define EDKILL           19  /* BUTTON in Baum EDITOR */
#define IEDKILL          20  /* USERDEF in Baum EDITOR */
#define CRVIS            21  /* USERDEF in Baum EDITOR */
#define EDSIG            22  /* USERDEF in Baum EDITOR */
#define EDANHANG         23  /* USERDEF in Baum EDITOR */
#define EDREPLYTO        24  /* USERDEF in Baum EDITOR */
#define EDFRAME          25  /* IBOX in Baum EDITOR */
#define FEDFRAME         26  /* IBOX in Baum EDITOR */
#define UEDITOR          27  /* USERDEF in Baum EDITOR */

#define EDANHPOP         8   /* Formular/Dialog */

#define SET_FARBE        9   /* Formular/Dialog */
#define IBACKCOL         15  /* USERDEF in Baum SET_FARBE */
#define INEWCOL          16  /* USERDEF in Baum SET_FARBE */
#define IREDCOL          17  /* USERDEF in Baum SET_FARBE */
#define ISNTCOL          18  /* USERDEF in Baum SET_FARBE */
#define ISNDCOL          19  /* USERDEF in Baum SET_FARBE */
#define MBACKCOL         20  /* USERDEF in Baum SET_FARBE */
#define MTEXTCOL         21  /* USERDEF in Baum SET_FARBE */
#define MQUOTECOL        22  /* USERDEF in Baum SET_FARBE */
#define EBACKCOL         23  /* USERDEF in Baum SET_FARBE */
#define ETEXTCOL         24  /* USERDEF in Baum SET_FARBE */
#define IGRPCOL          26  /* USERDEF in Baum SET_FARBE */
#define EURLCOL          28  /* USERDEF in Baum SET_FARBE */
#define ESABBRUCH        33  /* BUTTON in Baum SET_FARBE */
#define ESOK             34  /* BUTTON in Baum SET_FARBE */
#define KILLPATT         35  /* BUTTON in Baum SET_FARBE */

#define SET_ANZEIGE      10  /* Formular/Dialog */
#define ANZHEAD          3   /* FTEXT in Baum SET_ANZEIGE */
#define IGNORE_CRLF      5   /* BUTTON in Baum SET_ANZEIGE */
#define ANZMSGTAB        7   /* FTEXT in Baum SET_ANZEIGE */
#define USE_REAL_SMILE   8   /* BUTTON in Baum SET_ANZEIGE */
#define ALL_TEXT         11  /* BUTTON in Baum SET_ANZEIGE */
#define ANZABBRUCH       17  /* BUTTON in Baum SET_ANZEIGE */
#define ANZOK            18  /* BUTTON in Baum SET_ANZEIGE */
#define CUTPERSNUM       22  /* FTEXT in Baum SET_ANZEIGE */
#define CUTOEFFNUM       23  /* FTEXT in Baum SET_ANZEIGE */
#define CUTPERS          24  /* BUTTON in Baum SET_ANZEIGE */
#define CUTOEFF          25  /* BUTTON in Baum SET_ANZEIGE */
#define ANZEDTAB         26  /* FTEXT in Baum SET_ANZEIGE */

#define SET_INTERNET     11  /* Formular/Dialog */
#define ISABBRUCH        1   /* BUTTON in Baum SET_INTERNET */
#define ISOK             2   /* BUTTON in Baum SET_INTERNET */
#define ESAUTOTAUSCH     5   /* BUTTON in Baum SET_INTERNET */
#define ESAUTOICON       6   /* BUTTON in Baum SET_INTERNET */
#define ESAUTODIAL       7   /* BUTTON in Baum SET_INTERNET */
#define ESSHOWINFO       8   /* BUTTON in Baum SET_INTERNET */
#define ESPLLSIZE        11  /* FTEXT in Baum SET_INTERNET */
#define ESPLLREQUEST     13  /* BUTTON in Baum SET_INTERNET */
#define ESERVERDEL       15  /* BUTTON in Baum SET_INTERNET */
#define ESNEWSNEW        18  /* BUTTON in Baum SET_INTERNET */
#define ESNEWSNUM        19  /* FTEXT in Baum SET_INTERNET */
#define ESDAYS           22  /* FTEXT in Baum SET_INTERNET */
#define ENOMSGID         24  /* BUTTON in Baum SET_INTERNET */

#define SET_SIG          12  /* Formular/Dialog */
#define SIGFRAME         2   /* IBOX in Baum SET_SIG */
#define SIGEDITOR        4   /* USERDEF in Baum SET_SIG */
#define SIG1             5   /* BUTTON in Baum SET_SIG */
#define SIG2             6   /* BUTTON in Baum SET_SIG */
#define SIG3             7   /* BUTTON in Baum SET_SIG */
#define SIGVIS           8   /* USERDEF in Baum SET_SIG */

#define SET_DBASE        13  /* Formular/Dialog */
#define SDB_COMM         11  /* USERDEF in Baum SET_DBASE */
#define SDB_SINGLE       20  /* USERDEF in Baum SET_DBASE */
#define SDMODESWITCH     21  /* BUTTON in Baum SET_DBASE */
#define SDAUTOIMPORT     28  /* BUTTON in Baum SET_DBASE */
#define SDBABBRUCH       40  /* BUTTON in Baum SET_DBASE */
#define SDBOK            41  /* BUTTON in Baum SET_DBASE */

#define SET_ADRESSES     14  /* Formular/Dialog */
#define PERM_REPLY       4   /* BUTTON in Baum SET_ADRESSES */
#define PERM_REPLY_ADR   5   /* FTEXT in Baum SET_ADRESSES */
#define PERM_NEWS        7   /* BUTTON in Baum SET_ADRESSES */
#define USE_FAKE_ABS     12  /* BUTTON in Baum SET_ADRESSES */
#define FAKE_ADR         14  /* FTEXT in Baum SET_ADRESSES */
#define ADRABBRUCH       19  /* BUTTON in Baum SET_ADRESSES */
#define ADROK            20  /* BUTTON in Baum SET_ADRESSES */

#define ADRESSEN         15  /* Formular/Dialog */
#define ADRNAME          1   /* FTEXT in Baum ADRESSEN */
#define ADRFRAME         3   /* BOX in Baum ADRESSEN */
#define IADR1            4   /* USERDEF in Baum ADRESSEN */
#define ADR1             5   /* TEXT in Baum ADRESSEN */
#define IADR2            6   /* USERDEF in Baum ADRESSEN */
#define ADR2             7   /* TEXT in Baum ADRESSEN */
#define IADRLAST         26  /* USERDEF in Baum ADRESSEN */
#define ADRLAST          27  /* TEXT in Baum ADRESSEN */
#define ADRBAR           28  /* BOX in Baum ADRESSEN */
#define ADRSLIDE         29  /* BOX in Baum ADRESSEN */
#define ADRUP            30  /* BOXCHAR in Baum ADRESSEN */
#define ADRDOWN          31  /* BOXCHAR in Baum ADRESSEN */
#define ADRTITEL         32  /* TEXT in Baum ADRESSEN */
#define ADRDEL           34  /* BUTTON in Baum ADRESSEN */
#define IADRDEL          35  /* USERDEF in Baum ADRESSEN */
#define ADRRENAME        36  /* BUTTON in Baum ADRESSEN */
#define IADRRENAME       37  /* USERDEF in Baum ADRESSEN */
#define ADRADR           39  /* FTEXT in Baum ADRESSEN */
#define ADRBUTFRAME      42  /* BOX in Baum ADRESSEN */
#define ADRWRITETO       43  /* BUTTON in Baum ADRESSEN */
#define IADRWRITETO      44  /* USERDEF in Baum ADRESSEN */
#define ADRNEU           45  /* BUTTON in Baum ADRESSEN */
#define IADRNEU          46  /* USERDEF in Baum ADRESSEN */

#define GRUPPEN          16  /* Formular/Dialog */
#define GRPNAME          2   /* FTEXT in Baum GRUPPEN */
#define GRPFRAME         4   /* BOX in Baum GRUPPEN */
#define IGRP1            5   /* USERDEF in Baum GRUPPEN */
#define GRP1             6   /* TEXT in Baum GRUPPEN */
#define IGRP2            7   /* USERDEF in Baum GRUPPEN */
#define GRP2             8   /* TEXT in Baum GRUPPEN */
#define IGRPLAST         39  /* USERDEF in Baum GRUPPEN */
#define GRPLAST          40  /* TEXT in Baum GRUPPEN */
#define GRPBAR           41  /* BOX in Baum GRUPPEN */
#define GRPSLIDE         42  /* BOX in Baum GRUPPEN */
#define GRPUP            43  /* BOXCHAR in Baum GRUPPEN */
#define GRPDOWN          44  /* BOXCHAR in Baum GRUPPEN */
#define GRPTITEL         45  /* TEXT in Baum GRUPPEN */
#define GRP_ABOONLY      47  /* BUTTON in Baum GRUPPEN */

#define ORDNER           17  /* Formular/Dialog */
#define FLDNAME          2   /* FTEXT in Baum ORDNER */
#define FLDFRAME         4   /* BOX in Baum ORDNER */
#define FLD1             5   /* TEXT in Baum ORDNER */
#define FLD2             6   /* TEXT in Baum ORDNER */
#define FLDLAST          15  /* TEXT in Baum ORDNER */
#define FLDBAR           16  /* BOX in Baum ORDNER */
#define FLDSLIDE         17  /* BOX in Baum ORDNER */
#define FLDUP            18  /* BOXCHAR in Baum ORDNER */
#define FLDDOWN          19  /* BOXCHAR in Baum ORDNER */
#define ORDTITEL         20  /* TEXT in Baum ORDNER */
#define FLDDEL           22  /* BUTTON in Baum ORDNER */
#define IFLDDEL          23  /* USERDEF in Baum ORDNER */
#define FLDRENAME        24  /* BUTTON in Baum ORDNER */
#define IFLDRENAME       25  /* USERDEF in Baum ORDNER */
#define FLDNEU           26  /* BUTTON in Baum ORDNER */
#define IFLDNEU          27  /* USERDEF in Baum ORDNER */
#define FLD_IGNORE       28  /* BUTTON in Baum ORDNER */

#define FILTER           18  /* Formular/Dialog */
#define FILFRAME         2   /* BOX in Baum FILTER */
#define IFIL1            3   /* USERDEF in Baum FILTER */
#define ZT1              4   /* TEXT in Baum FILTER */
#define FIL1             5   /* TEXT in Baum FILTER */
#define ZT2              6   /* TEXT in Baum FILTER */
#define IIFIL1           7   /* USERDEF in Baum FILTER */
#define TFIL1            8   /* TEXT in Baum FILTER */
#define IFIL2            9   /* USERDEF in Baum FILTER */
#define FIL2             11  /* TEXT in Baum FILTER */
#define IFILLAST         57  /* USERDEF in Baum FILTER */
#define FILLAST          59  /* TEXT in Baum FILTER */
#define IIFILLAST        61  /* USERDEF in Baum FILTER */
#define TFILLAST         62  /* TEXT in Baum FILTER */
#define FILBAR           63  /* BOX in Baum FILTER */
#define FILSLIDE         64  /* BOX in Baum FILTER */
#define FILUP            65  /* BOXCHAR in Baum FILTER */
#define FILDOWN          66  /* BOXCHAR in Baum FILTER */
#define FILTITEL         67  /* TEXT in Baum FILTER */
#define FILDEL           69  /* BUTTON in Baum FILTER */
#define IFILDEL          70  /* USERDEF in Baum FILTER */
#define FILRENAME        71  /* BUTTON in Baum FILTER */
#define IFILRENAME       72  /* USERDEF in Baum FILTER */
#define FILNEU           73  /* BUTTON in Baum FILTER */
#define IFILNEU          74  /* USERDEF in Baum FILTER */
#define FILEDFRAME       75  /* IBOX in Baum FILTER */
#define FILPOP1          76  /* BUTTON in Baum FILTER */
#define IFILPOP1         77  /* USERDEF in Baum FILTER */
#define FILTEXT          80  /* FTEXT in Baum FILTER */
#define FILPOP2          82  /* BUTTON in Baum FILTER */
#define IFILPOP2         83  /* USERDEF in Baum FILTER */
#define FILPOP3          84  /* BUTTON in Baum FILTER */
#define ONLINE_FIL       85  /* BUTTON in Baum FILTER */

#define POPVORL          19  /* Formular/Dialog */

#define SIGPOP           20  /* Formular/Dialog */

#define FIL1POPUP        21  /* Formular/Dialog */

#define FIL2POPUP        22  /* Formular/Dialog */

#define FIL3POPUP        23  /* Formular/Dialog */

#define DBSEARCH         24  /* Formular/Dialog */
#define DBSNDSNT         3   /* BUTTON in Baum DBSEARCH */
#define DBNEWRED         4   /* BUTTON in Baum DBSEARCH */
#define DBPOPBOX         6   /* BOX in Baum DBSEARCH */
#define DBPOP1           7   /* BUTTON in Baum DBSEARCH */
#define IDBPOP1          8   /* USERDEF in Baum DBSEARCH */
#define DBPOP2           9   /* BUTTON in Baum DBSEARCH */
#define DBTEXT1          14  /* FTEXT in Baum DBSEARCH */
#define DBTEXT2          16  /* FTEXT in Baum DBSEARCH */
#define DBTEXT3          18  /* FTEXT in Baum DBSEARCH */
#define DBTEXT4          20  /* FTEXT in Baum DBSEARCH */
#define DBPOP3           22  /* BUTTON in Baum DBSEARCH */
#define DBTEXT5          23  /* FTEXT in Baum DBSEARCH */
#define DBPOP4           25  /* BUTTON in Baum DBSEARCH */
#define DBTEXT6          26  /* FTEXT in Baum DBSEARCH */
#define DPDATPOP         28  /* BUTTON in Baum DBSEARCH */
#define DBANHANG         29  /* BUTTON in Baum DBSEARCH */
#define DBABBRUCH        31  /* BUTTON in Baum DBSEARCH */
#define DBSTART          32  /* BUTTON in Baum DBSEARCH */
#define IDBSTART         33  /* USERDEF in Baum DBSEARCH */

#define DBPOPUP1         25  /* Formular/Dialog */

#define DBPOPUP2         26  /* Formular/Dialog */

#define SEARCH           27  /* Formular/Dialog */
#define SEARCHSTRING     1   /* FTEXT in Baum SEARCH */
#define SEGRKL           3   /* BUTTON in Baum SEARCH */
#define SEABBRUCH        4   /* BUTTON in Baum SEARCH */
#define SEOK             5   /* BUTTON in Baum SEARCH */

#define WEITERLEITEN     28  /* Formular/Dialog */
#define WTO              2   /* BUTTON in Baum WEITERLEITEN */
#define IWTO             3   /* USERDEF in Baum WEITERLEITEN */
#define EWTO             4   /* FTEXT in Baum WEITERLEITEN */
#define WTRABBRUCH       5   /* BUTTON in Baum WEITERLEITEN */
#define WTROK            6   /* BUTTON in Baum WEITERLEITEN */

#define REPLYTO          29  /* Formular/Dialog */
#define EREPLYTO         2   /* FTEXT in Baum REPLYTO */
#define ERTABBRUCH       3   /* BUTTON in Baum REPLYTO */
#define ERTOK            4   /* BUTTON in Baum REPLYTO */

#define AUFRAEUMEN       30  /* Formular/Dialog */
#define AFKILL           3   /* BUTTON in Baum AUFRAEUMEN */
#define AFTEMP           4   /* BUTTON in Baum AUFRAEUMEN */
#define AFPERS           10  /* BUTTON in Baum AUFRAEUMEN */
#define AFPERSDAT        11  /* FTEXT in Baum AUFRAEUMEN */
#define AFDEL            13  /* BUTTON in Baum AUFRAEUMEN */
#define AFMOVE           14  /* BUTTON in Baum AUFRAEUMEN */
#define AFORD            15  /* BUTTON in Baum AUFRAEUMEN */
#define AFORDDAT         16  /* FTEXT in Baum AUFRAEUMEN */
#define AFOM             17  /* BUTTON in Baum AUFRAEUMEN */
#define AFOMDAT          18  /* FTEXT in Baum AUFRAEUMEN */
#define AFPERSPOP        22  /* BUTTON in Baum AUFRAEUMEN */
#define AFORDPOP         23  /* BUTTON in Baum AUFRAEUMEN */
#define AFOMPOP          24  /* BUTTON in Baum AUFRAEUMEN */
#define AFABBRUCH        28  /* BUTTON in Baum AUFRAEUMEN */
#define AFSTART          29  /* BUTTON in Baum AUFRAEUMEN */

#define AFDATPOP         31  /* Formular/Dialog */

#define MATXPOPUP        32  /* Formular/Dialog */

#define SCROLLPOP        33  /* Formular/Dialog */
#define SPT1             1   /* STRING in Baum SCROLLPOP */
#define SPTLAST          16  /* STRING in Baum SCROLLPOP */
#define SPBAR            17  /* BOX in Baum SCROLLPOP */
#define SPSLIDE          18  /* BOX in Baum SCROLLPOP */
#define SPUP             19  /* BOXCHAR in Baum SCROLLPOP */
#define SPDOWN           20  /* BOXCHAR in Baum SCROLLPOP */

#define ONLINE           34  /* Formular/Dialog */
#define CONFRAME         2   /* BOX in Baum ONLINE */
#define CONPROCESS       3   /* BOX in Baum ONLINE */
#define CONSTATUS        5   /* TEXT in Baum ONLINE */
#define CONCANCEL        6   /* BUTTON in Baum ONLINE */
#define CONACTION        8   /* TEXT in Baum ONLINE */

#define PM_LIST          35  /* Formular/Dialog */
#define PMLFRAME         3   /* BOX in Baum PM_LIST */
#define I1PML1           4   /* USERDEF in Baum PM_LIST */
#define I2PML1           5   /* USERDEF in Baum PM_LIST */
#define PML1             6   /* TEXT in Baum PM_LIST */
#define PMLINF1          7   /* USERDEF in Baum PM_LIST */
#define I1PML2           8   /* USERDEF in Baum PM_LIST */
#define I1PMLLAST        40  /* USERDEF in Baum PM_LIST */
#define PMLINFLAST       43  /* USERDEF in Baum PM_LIST */
#define PMLBAR           44  /* BOX in Baum PM_LIST */
#define PMLSLIDE         45  /* BOX in Baum PM_LIST */
#define PMLUP            46  /* BOXCHAR in Baum PM_LIST */
#define PMLDOWN          47  /* BOXCHAR in Baum PM_LIST */
#define PMLTITEL         48  /* TEXT in Baum PM_LIST */
#define PMLOK            53  /* BUTTON in Baum PM_LIST */

#define PREVONLINE       36  /* Formular/Dialog */
#define POLSHOWLIST      6   /* BUTTON in Baum PREVONLINE */
#define POLABBRUCH       8   /* BUTTON in Baum PREVONLINE */
#define POLSTART         9   /* BUTTON in Baum PREVONLINE */
#define IPOLSTART        10  /* USERDEF in Baum PREVONLINE */
#define POL_OM           13  /* BUTTON in Baum PREVONLINE */
#define POL_PM           14  /* BUTTON in Baum PREVONLINE */

#define TAKECC           37  /* Formular/Dialog */
#define CCABSONLY        1   /* BUTTON in Baum TAKECC */
#define CCBOTH           2   /* BUTTON in Baum TAKECC */

#define L_ANHANG         38  /* Formular/Dialog */
#define IASHOW           1   /* USERDEF in Baum L_ANHANG */
#define IASAVE           2   /* USERDEF in Baum L_ANHANG */
#define ANH_FRAME        3   /* IBOX in Baum L_ANHANG */
#define A_STR            4   /* TEXT in Baum L_ANHANG */
#define A_ICO            5   /* USERDEF in Baum L_ANHANG */

#define DRAG             39  /* Formular/Dialog */

#define AUFR_ANIM        40  /* Formular/Dialog */
#define TONNE            2   /* USERDEF in Baum AUFR_ANIM */
#define BL1              3   /* USERDEF in Baum AUFR_ANIM */
#define BL2              4   /* USERDEF in Baum AUFR_ANIM */
#define BL3              5   /* USERDEF in Baum AUFR_ANIM */
#define BL0              6   /* USERDEF in Baum AUFR_ANIM */

#define DOWNLOADS        41  /* Formular/Dialog */
#define NEW_PM           4   /* STRING in Baum DOWNLOADS */
#define ORD_PM           6   /* STRING in Baum DOWNLOADS */
#define NEW_OM           11  /* STRING in Baum DOWNLOADS */
#define ORD_OM           13  /* STRING in Baum DOWNLOADS */

#define IMPORTING        42  /* Formular/Dialog */
#define IM_TITEL         2   /* STRING in Baum IMPORTING */
#define IMP_PATH         5   /* TEXT in Baum IMPORTING */
#define IMP_NUM          6   /* TEXT in Baum IMPORTING */
#define LED_1            10  /* USERDEF in Baum IMPORTING */
#define LED_2            11  /* USERDEF in Baum IMPORTING */
#define LED_3            12  /* USERDEF in Baum IMPORTING */

#define CHECKDBASE       43  /* Formular/Dialog */
#define CDBTITEL         3   /* STRING in Baum CHECKDBASE */
#define CDBCOUNT         5   /* TEXT in Baum CHECKDBASE */
#define CDBICON          6   /* USERDEF in Baum CHECKDBASE */

#define SPECFUNC         44  /* Formular/Dialog */
#define MAKENEWRED       6   /* BUTTON in Baum SPECFUNC */
#define SPECCLOSE        10  /* BUTTON in Baum SPECFUNC */

#define IMPORT_ERR       45  /* Formular/Dialog */
#define IERR_FILE        4   /* STRING in Baum IMPORT_ERR */
#define IERR_MEM1        5   /* STRING in Baum IMPORT_ERR */
#define IERR_MEM2        6   /* STRING in Baum IMPORT_ERR */
#define IERR_OK          11  /* BUTTON in Baum IMPORT_ERR */

#define STICICON         46  /* Formular/Dialog */
#define SMALLICON        1   /* USERDEF in Baum STICICON */
#define BIGICON          2   /* USERDEF in Baum STICICON */

#define VORLAGE          47  /* Formular/Dialog */
#define MINPOP           1   /* BUTTON in Baum VORLAGE */
#define ABSLEN           2   /* BOXTEXT in Baum VORLAGE */
#define BTRLEN           3   /* BOXTEXT in Baum VORLAGE */
#define DATLEN           4   /* BOXTEXT in Baum VORLAGE */
#define IN               5   /* BUTTON in Baum VORLAGE */
#define IIN              6   /* USERDEF in Baum VORLAGE */
#define CRIND            7   /* IMAGE in Baum VORLAGE */
#define TABIND           8   /* IMAGE in Baum VORLAGE */
#define AUFSTEIGEND      9   /* IMAGE in Baum VORLAGE */
#define ABSTEIGEND       10  /* IMAGE in Baum VORLAGE */
#define IADR_SINGLE      11  /* USERDEF in Baum VORLAGE */
#define IADR_MULTI       12  /* USERDEF in Baum VORLAGE */
#define GRP_ABO          13  /* USERDEF in Baum VORLAGE */
#define GRP_NON          14  /* USERDEF in Baum VORLAGE */
#define HIDDEN           15  /* STRING in Baum VORLAGE */
#define IT_P11           16  /* STRING in Baum VORLAGE */
#define IT_P12           17  /* STRING in Baum VORLAGE */
#define IT_P13           18  /* STRING in Baum VORLAGE */
#define LISTICONFRAME    19  /* IBOX in Baum VORLAGE */
#define VSND16           20  /* USERDEF in Baum VORLAGE */
#define VSNT             21  /* USERDEF in Baum VORLAGE */
#define VNEW             22  /* USERDEF in Baum VORLAGE */
#define VRED             23  /* USERDEF in Baum VORLAGE */
#define VUKN             24  /* USERDEF in Baum VORLAGE */
#define VBAK             25  /* USERDEF in Baum VORLAGE */
#define VFLD             26  /* USERDEF in Baum VORLAGE */
#define VGRP             27  /* USERDEF in Baum VORLAGE */
#define VSND12           29  /* USERDEF in Baum VORLAGE */
#define VSND8            38  /* USERDEF in Baum VORLAGE */
#define VGRP8            45  /* USERDEF in Baum VORLAGE */
#define VGSD8            46  /* USERDEF in Baum VORLAGE */
#define IC_NGET          48  /* USERDEF in Baum VORLAGE */
#define IC_ONORD         49  /* USERDEF in Baum VORLAGE */
#define IC_OFFORD        50  /* USERDEF in Baum VORLAGE */
#define IT_SA1           52  /* STRING in Baum VORLAGE */
#define IT_SA2           53  /* STRING in Baum VORLAGE */
#define IT_P21           56  /* STRING in Baum VORLAGE */
#define IT_P22           57  /* STRING in Baum VORLAGE */
#define IC_ABSENDER      59  /* USERDEF in Baum VORLAGE */
#define IC_EMPFAENGER    60  /* USERDEF in Baum VORLAGE */
#define IC_BETREFF       61  /* USERDEF in Baum VORLAGE */
#define GRP_ABO_RED      62  /* USERDEF in Baum VORLAGE */
#define GRP_SW_SEL       63  /* ICON in Baum VORLAGE */
#define ESWHEADSEL       64  /* ICON in Baum VORLAGE */
#define CRSWVISSEL       65  /* ICON in Baum VORLAGE */
#define SIGSWVISSEL      66  /* ICON in Baum VORLAGE */
#define GRP_SW_UNSEL     67  /* ICON in Baum VORLAGE */
#define ESWHEADUNSEL     68  /* ICON in Baum VORLAGE */
#define SIGSWVISUNSEL    69  /* ICON in Baum VORLAGE */
#define CRSWVISUNSEL     70  /* ICON in Baum VORLAGE */
#define ED_SW_SIG        71  /* ICON in Baum VORLAGE */
#define ED_SW_NOSIG      72  /* ICON in Baum VORLAGE */
#define IAPLUS           73  /* USERDEF in Baum VORLAGE */
#define IAKILL           74  /* USERDEF in Baum VORLAGE */
#define ED_NOREPLY       75  /* ICON in Baum VORLAGE */
#define ED_REPLY         76  /* ICON in Baum VORLAGE */
#define ANHFRAME         77  /* IBOX in Baum VORLAGE */
#define VANH16           78  /* USERDEF in Baum VORLAGE */
#define VANH12           79  /* USERDEF in Baum VORLAGE */
#define VANH8            80  /* USERDEF in Baum VORLAGE */
#define AWDFRAME         81  /* IBOX in Baum VORLAGE */
#define VAWD16           82  /* USERDEF in Baum VORLAGE */
#define VAWD12           83  /* USERDEF in Baum VORLAGE */
#define VAWD8            84  /* USERDEF in Baum VORLAGE */
#define SMILEFRAME       85  /* IBOX in Baum VORLAGE */
#define ISMILE16         86  /* USERDEF in Baum VORLAGE */
#define ISMILE12         90  /* USERDEF in Baum VORLAGE */
#define ISMILE8          94  /* USERDEF in Baum VORLAGE */
#define ITRFRAME         98  /* IBOX in Baum VORLAGE */
#define ITR16            99  /* USERDEF in Baum VORLAGE */
#define ITR12            100 /* USERDEF in Baum VORLAGE */
#define ITR8             101 /* USERDEF in Baum VORLAGE */

#define FALERT           48  /* Formular/Dialog */
#define FAST1            1   /* STRING in Baum FALERT */
#define FAST2            2   /* STRING in Baum FALERT */
#define FAST3            3   /* STRING in Baum FALERT */
#define FAST4            4   /* STRING in Baum FALERT */
#define FAST5            5   /* STRING in Baum FALERT */
#define FABT1            6   /* BUTTON in Baum FALERT */
#define FABT2            7   /* BUTTON in Baum FALERT */
#define FABT3            8   /* BUTTON in Baum FALERT */
#define FAIC1            9   /* USERDEF in Baum FALERT */
#define FAIC2            10  /* USERDEF in Baum FALERT */
#define FAIC3            11  /* USERDEF in Baum FALERT */

#define STRINGS          49  /* Formular/Dialog */
#define NOMEM            1   /* STRING in Baum STRINGS */
#define NOOPEN           2   /* STRING in Baum STRINGS */
#define READERR          3   /* STRING in Baum STRINGS */
#define CREATEERR        4   /* STRING in Baum STRINGS */
#define NO_MAILMEM       5   /* STRING in Baum STRINGS */
#define NO_MAILBODY      6   /* STRING in Baum STRINGS */
#define DEFDEL           7   /* STRING in Baum STRINGS */
#define DELETE_ERR       8   /* STRING in Baum STRINGS */
#define RENAME_ERR       9   /* STRING in Baum STRINGS */
#define NOSORT           10  /* STRING in Baum STRINGS */
#define FLD_NONAME       11  /* STRING in Baum STRINGS */
#define FLD_DELETE       12  /* STRING in Baum STRINGS */
#define ADR_NONAME       13  /* STRING in Baum STRINGS */
#define ADR_NOADR        14  /* STRING in Baum STRINGS */
#define NO_ADDRMEM       15  /* STRING in Baum STRINGS */
#define ADDROPEN_ERR     16  /* STRING in Baum STRINGS */
#define ADDRMAKE_ERR     17  /* STRING in Baum STRINGS */
#define ADR_EALREADY     18  /* STRING in Baum STRINGS */
#define ADR_NOALIAS      19  /* STRING in Baum STRINGS */
#define ADR_REKURS       20  /* STRING in Baum STRINGS */
#define ADR_NOEMAIL      21  /* STRING in Baum STRINGS */
#define GRP_NOFILE       22  /* STRING in Baum STRINGS */
#define GRPOPEN_ERR      23  /* STRING in Baum STRINGS */
#define GRPMAKE_ERR      24  /* STRING in Baum STRINGS */
#define NO_GRPMEM        25  /* STRING in Baum STRINGS */
#define SIGTOOLONG       26  /* STRING in Baum STRINGS */
#define FILTEROPEN_ERR   27  /* STRING in Baum STRINGS */
#define FILTERMAKE_ERR   28  /* STRING in Baum STRINGS */
#define NO_FILMEM        29  /* STRING in Baum STRINGS */
#define FIL_NOTEXT       30  /* STRING in Baum STRINGS */
#define ATX_SAVE_AS      31  /* STRING in Baum STRINGS */
#define ATX_SAVE         32  /* STRING in Baum STRINGS */
#define ATX_SHOW         33  /* STRING in Baum STRINGS */
#define GRP_DELETE       34  /* STRING in Baum STRINGS */
#define ATX_DEL          35  /* STRING in Baum STRINGS */
#define AFKILLSURE       36  /* STRING in Baum STRINGS */
#define AFDELSURE        37  /* STRING in Baum STRINGS */
#define EDMAXANHANG      38  /* STRING in Baum STRINGS */
#define ATX_OPEN         39  /* STRING in Baum STRINGS */
#define EMPTYFILE        40  /* STRING in Baum STRINGS */
#define NORCP            41  /* STRING in Baum STRINGS */
#define NOCNT            42  /* STRING in Baum STRINGS */
#define EDCLOSE          43  /* STRING in Baum STRINGS */
#define EDVERWERF        44  /* STRING in Baum STRINGS */
#define EDKILLED         45  /* STRING in Baum STRINGS */
#define MERGE_OPEN       46  /* STRING in Baum STRINGS */
#define FILE_OPEN        47  /* STRING in Baum STRINGS */
#define FILE_SAVE_AS     48  /* STRING in Baum STRINGS */
#define OL1              49  /* STRING in Baum STRINGS */
#define OL5              50  /* STRING in Baum STRINGS */
#define OL3              51  /* STRING in Baum STRINGS */
#define OL7              52  /* STRING in Baum STRINGS */
#define OL8              53  /* STRING in Baum STRINGS */
#define OL9              54  /* STRING in Baum STRINGS */
#define OL2              55  /* STRING in Baum STRINGS */
#define OL4              56  /* STRING in Baum STRINGS */
#define OL6              57  /* STRING in Baum STRINGS */
#define NO_DESKSTART     58  /* STRING in Baum STRINGS */
#define UPS_ICONNECT     59  /* STRING in Baum STRINGS */
#define A1               60  /* STRING in Baum STRINGS */
#define A2               61  /* STRING in Baum STRINGS */
#define OLD_ICONNECT     62  /* STRING in Baum STRINGS */
#define NO_ICONNECT      63  /* STRING in Baum STRINGS */
#define NOSERVICE        64  /* STRING in Baum STRINGS */
#define NOEMAIL          65  /* STRING in Baum STRINGS */
#define OL4B             66  /* STRING in Baum STRINGS */
#define ERRPOPUSER       67  /* STRING in Baum STRINGS */
#define ERRPOPPASS       68  /* STRING in Baum STRINGS */
#define NOPOPUSER        69  /* STRING in Baum STRINGS */
#define NOBINARY         70  /* STRING in Baum STRINGS */
#define MUCHQUOTE        71  /* STRING in Baum STRINGS */
#define GETGRPLIST       72  /* STRING in Baum STRINGS */
#define NOGSDDEL         73  /* STRING in Baum STRINGS */
#define NOFILTMEM        74  /* STRING in Baum STRINGS */
#define SENDNOW          75  /* STRING in Baum STRINGS */
#define REALQUIT         76  /* STRING in Baum STRINGS */
#define ONLINE_ERROR     77  /* STRING in Baum STRINGS */
#define ONLINEREALQUIT   78  /* STRING in Baum STRINGS */
#define NO_DO_ONLINE     79  /* STRING in Baum STRINGS */
#define WRONG_DATE       80  /* STRING in Baum STRINGS */
#define FILE_EXIST       81  /* STRING in Baum STRINGS */
#define ED_CUT_MIN       82  /* STRING in Baum STRINGS */
#define REALKILLPATT     83  /* STRING in Baum STRINGS */
#define ORD_BY_FIL       84  /* STRING in Baum STRINGS */
#define NO_ALT_FONT      85  /* STRING in Baum STRINGS */
#define REALDBMODE       86  /* STRING in Baum STRINGS */
#define REALSFMODE       87  /* STRING in Baum STRINGS */
#define IM_INDIZ         88  /* STRING in Baum STRINGS */
#define IM_EXTRA         89  /* STRING in Baum STRINGS */
#define NOIMPORT         90  /* STRING in Baum STRINGS */
#define NOWIMPORT        91  /* STRING in Baum STRINGS */
#define SORTSNDSNT       92  /* STRING in Baum STRINGS */
#define NOFILESHOW       93  /* STRING in Baum STRINGS */
#define OL1_1            94  /* STRING in Baum STRINGS */
#define NODBCHECK        95  /* STRING in Baum STRINGS */
#define DOSPECFUNC       96  /* STRING in Baum STRINGS */
#define DBASECHECK       97  /* STRING in Baum STRINGS */
#define DBCHECKTXT       98  /* STRING in Baum STRINGS */
#define DBREPAIRTXT      99  /* STRING in Baum STRINGS */
#define DBCOK            100 /* STRING in Baum STRINGS */
#define DBCBAD           101 /* STRING in Baum STRINGS */
#define DBREPOK          102 /* STRING in Baum STRINGS */
#define DBREPBAD         103 /* STRING in Baum STRINGS */
#define DBNOREP          104 /* STRING in Baum STRINGS */
#define NOATADDRESS      105 /* STRING in Baum STRINGS */
#define DBL_FILTER       106 /* STRING in Baum STRINGS */
#define ORD_ERR_DEL      107 /* STRING in Baum STRINGS */
#define MAILSTOSEND      108 /* STRING in Baum STRINGS */
#define SHORTTOTAL       109 /* STRING in Baum STRINGS */

#define NEW_SIG_ALERT    50  /* Formular/Dialog */
#define NEW_SIG_HIDE     8   /* BUTTON in Baum NEW_SIG_ALERT */
#define SIGHIDEOK        9   /* BUTTON in Baum NEW_SIG_ALERT */
