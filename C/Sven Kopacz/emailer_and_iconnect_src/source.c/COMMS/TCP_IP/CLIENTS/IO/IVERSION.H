#define EMAILER_VERSION "V2.3i"
/* rechtsb�ndig, f�nf Zeichen */