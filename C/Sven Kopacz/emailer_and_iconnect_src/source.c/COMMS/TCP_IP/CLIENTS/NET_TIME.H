/* Resource Datei Indizes f�r NET_TIME */

#define MAIN             0   /* Formular/Dialog */
#define FRAME            1   /* IBOX in Baum MAIN */
#define GMT							 2
#define DATE             3   /* TEXT in Baum MAIN */
#define TIME             4   /* TEXT in Baum MAIN */

#define STRINGS          1   /* Formular/Dialog */
#define A1               1   /* STRING in Baum STRINGS */
#define A2               2   /* STRING in Baum STRINGS */
#define A5               3   /* STRING in Baum STRINGS */
#define A3               4   /* STRING in Baum STRINGS */
#define A4               5   /* STRING in Baum STRINGS */
#define A6               6   /* STRING in Baum STRINGS */

#define STICICON         2   /* Formular/Dialog */
#define SMALLICON        1   /* USERDEF in Baum STICICON */
#define BIGICON          2   /* USERDEF in Baum STICICON */
