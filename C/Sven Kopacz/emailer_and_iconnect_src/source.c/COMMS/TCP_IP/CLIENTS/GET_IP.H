/* Resource Datei Indizes f�r GET_IP */

#define MAIN             0   /* Formular/Dialog */
#define RESOLVE          2   /* BUTTON in Baum MAIN */
#define HOST             5   /* FTEXT in Baum MAIN */
#define IP               6   /* TEXT in Baum MAIN */
#define COPY             8   /* USERDEF in Baum MAIN */

#define STRINGS          1   /* Formular/Dialog */
#define A1               1   /* STRING in Baum STRINGS */
#define A2               2   /* STRING in Baum STRINGS */
#define A3               3   /* STRING in Baum STRINGS */
#define A4               4   /* STRING in Baum STRINGS */
#define A5               5   /* STRING in Baum STRINGS */
#define A6               6   /* STRING in Baum STRINGS */
#define A7               7   /* STRING in Baum STRINGS */
