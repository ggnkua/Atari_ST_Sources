extern long	low_ready(void);
extern long	low_read(long count, void *buf);
extern long	low_write(long count, void *buf);
