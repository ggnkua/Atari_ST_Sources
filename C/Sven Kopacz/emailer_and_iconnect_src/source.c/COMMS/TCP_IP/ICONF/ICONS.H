/* Resource Datei Indizes f�r ICONS */

#define ICONS            0   /* Formular/Dialog */
