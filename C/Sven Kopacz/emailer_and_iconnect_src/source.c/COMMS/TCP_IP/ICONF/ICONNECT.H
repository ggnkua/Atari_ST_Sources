/* Resource Datei Indizes f�r ICONNECT */

#define INTRO            0   /* Formular/Dialog */
#define SETPOP           2   /* BUTTON in Baum INTRO */
#define MAINCONNECT      3   /* BUTTON in Baum INTRO */
#define MAINCANCEL       4   /* BUTTON in Baum INTRO */
#define MAINDATE         7   /* TEXT in Baum INTRO */
#define MAINVERSION      8   /* TEXT in Baum INTRO */

#define CONNECT          1   /* Formular/Dialog */
#define CONICON1         2   /* USERDEF in Baum CONNECT */
#define CONICON2         3   /* USERDEF in Baum CONNECT */
#define CONICON3         4   /* USERDEF in Baum CONNECT */
#define CONICONLAST      5   /* USERDEF in Baum CONNECT */
#define CONSTATUS        7   /* TEXT in Baum CONNECT */
#define CONCMD           9   /* TEXT in Baum CONNECT */
#define CONCANCEL        10  /* BUTTON in Baum CONNECT */
#define CONDRAWFRAME     11  /* BOX in Baum CONNECT */
#define CONFRAME         12  /* BOX in Baum CONNECT */
#define CONPROCESS       13  /* BOX in Baum CONNECT */
#define CONN_MESSAGE     14  /* TEXT in Baum CONNECT */

#define LOCALIP          2   /* Formular/Dialog */
#define IPTEXT           1   /* FTEXT in Baum LOCALIP */
#define IPOK             2   /* BUTTON in Baum LOCALIP */
#define IPCANCEL         3   /* BUTTON in Baum LOCALIP */
#define INFOBUT          4   /* USERDEF in Baum LOCALIP */

#define USERENTRY        3   /* Formular/Dialog */
#define USERTITEL        3   /* TEXT in Baum USERENTRY */
#define USERINP          4   /* FTEXT in Baum USERENTRY */
#define USEROK           5   /* BUTTON in Baum USERENTRY */
#define USERCANCEL       6   /* BUTTON in Baum USERENTRY */

#define ONLINE           4   /* Formular/Dialog */
#define ONLINEFRAME      1   /* IBOX in Baum ONLINE */
#define ONLINETIME       4   /* TEXT in Baum ONLINE */
#define ONLINECLOSE      6   /* BUTTON in Baum ONLINE */
#define ONLINENAME       7   /* TEXT in Baum ONLINE */
#define LOCAL_IP         8   /* TEXT in Baum ONLINE */
#define ULED             9   /* IMAGE in Baum ONLINE */

#define SETUPPOP         5   /* Formular/Dialog */

#define STATIKA          6   /* Formular/Dialog */
#define STAT_OPEN        1   /* STRING in Baum STATIKA */
#define STAT_RUN         2   /* STRING in Baum STATIKA */
#define STAT_SOCKET      3   /* STRING in Baum STATIKA */
#define STAT_PPP         4   /* STRING in Baum STATIKA */
#define STAT_SLIP        5   /* STRING in Baum STATIKA */
#define STAT_HANG_UP     6   /* STRING in Baum STATIKA */
#define STAT_WAITING     7   /* STRING in Baum STATIKA */
#define STAT_GET_IP      8   /* STRING in Baum STATIKA */
#define STAT_MODEM       9   /* STRING in Baum STATIKA */
#define STAT_DIAL        10  /* STRING in Baum STATIKA */
#define STAT_BUSY        11  /* STRING in Baum STATIKA */
#define STAT_MAC         12  /* STRING in Baum STATIKA */
#define STAT_DNS_WAIT    13  /* STRING in Baum STATIKA */

#define ERRREP           7   /* Formular/Dialog */
#define ERRCANCEL        11  /* BUTTON in Baum ERRREP */
#define ERR1             12  /* STRING in Baum ERRREP */
#define ERR2             13  /* STRING in Baum ERRREP */
#define ERR3             14  /* STRING in Baum ERRREP */
#define ERR4             15  /* STRING in Baum ERRREP */
#define ERR5             16  /* STRING in Baum ERRREP */
#define ERR6             17  /* STRING in Baum ERRREP */
#define ERR7             18  /* STRING in Baum ERRREP */
#define ERR8             19  /* STRING in Baum ERRREP */
#define ERR9             20  /* STRING in Baum ERRREP */

#define LOGOFF           8   /* Formular/Dialog */
#define CONOFFCMD        1   /* TEXT in Baum LOGOFF */
#define CONOFFCANCEL     2   /* BUTTON in Baum LOGOFF */
#define EXIT_SEL_OB      3   /* USERDEF in Baum LOGOFF */
#define LOGOFFSTRING     4   /* TEXT in Baum LOGOFF */

#define STRINGS          9   /* Formular/Dialog */
#define SYES             1   /* STRING in Baum STRINGS */
#define SNO              2   /* STRING in Baum STRINGS */
#define A1               3   /* STRING in Baum STRINGS */
#define A2               4   /* STRING in Baum STRINGS */
#define A3               5   /* STRING in Baum STRINGS */
#define A4               6   /* STRING in Baum STRINGS */
#define A5               7   /* STRING in Baum STRINGS */
#define A6               8   /* STRING in Baum STRINGS */
#define A7               9   /* STRING in Baum STRINGS */
#define A8               10  /* STRING in Baum STRINGS */
#define A9               11  /* STRING in Baum STRINGS */
#define A10              12  /* STRING in Baum STRINGS */
#define A11              13  /* STRING in Baum STRINGS */
#define A12              14  /* STRING in Baum STRINGS */
#define A13              15  /* STRING in Baum STRINGS */
#define STAT_NETCLOSE    16  /* STRING in Baum STRINGS */
#define STAT_LOGOFFSCR   17  /* STRING in Baum STRINGS */
#define STAT_HANGUP      18  /* STRING in Baum STRINGS */
#define A14              19  /* STRING in Baum STRINGS */
#define A15              20  /* STRING in Baum STRINGS */
#define A16              21  /* STRING in Baum STRINGS */
#define A17              22  /* STRING in Baum STRINGS */
#define A18              23  /* STRING in Baum STRINGS */
#define A19              24  /* STRING in Baum STRINGS */
#define NOAUTOSTIP       25  /* STRING in Baum STRINGS */
#define NOAPPSTIP        26  /* STRING in Baum STRINGS */
#define NOMACSTIP        27  /* STRING in Baum STRINGS */
#define MACHANGUP        28  /* STRING in Baum STRINGS */
#define NOSTIPINIT       29  /* STRING in Baum STRINGS */
#define NOPREEMPTIVE     30  /* STRING in Baum STRINGS */

#define STICICON         10  /* Formular/Dialog */
#define SMALLICON        1   /* USERDEF in Baum STICICON */
#define BIGICON          2   /* USERDEF in Baum STICICON */

#define USERPASS         11  /* Formular/Dialog */
#define USERINPUT        1   /* FTEXT in Baum USERPASS */
#define PASSINPUT        2   /* FTEXT in Baum USERPASS */
#define ENTRYCANCEL      3   /* BUTTON in Baum USERPASS */
#define ENTRYOK          4   /* BUTTON in Baum USERPASS */
#define ICON1            8   /* USERDEF in Baum USERPASS */
#define ICON2            9   /* USERDEF in Baum USERPASS */
