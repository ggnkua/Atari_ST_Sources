/* Resource Datei Indizes f�r DESKICON */

#define ICONS            0   /* Formular/Dialog */
