/* Resource Datei Indizes f�r TEMPICON */

#define TEMP             0   /* Formular/Dialog */
