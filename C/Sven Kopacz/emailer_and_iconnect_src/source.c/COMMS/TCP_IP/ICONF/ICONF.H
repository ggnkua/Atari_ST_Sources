/* Resource Datei Indizes f�r ICONF */

#define MAIN             0   /* Formular/Dialog */
#define MAINQUIT         2   /* BUTTON in Baum MAIN */
#define INFOBUT2         3   /* TEXT in Baum MAIN */
#define PROFI_MODE       4   /* BUTTON in Baum MAIN */
#define MAINSAVE         5   /* BUTTON in Baum MAIN */
#define COPYBUT          6   /* USERDEF in Baum MAIN */
#define SETPOP           7   /* BUTTON in Baum MAIN */
#define SETRENAME        8   /* BUTTON in Baum MAIN */
#define SETDELETE        9   /* BUTTON in Baum MAIN */
#define SETNEW           10  /* BUTTON in Baum MAIN */
#define RICOPARENT       11  /* IBOX in Baum MAIN */
#define RICOBAR          12  /* BOX in Baum MAIN */
#define RICOSLIDE        13  /* BOXCHAR in Baum MAIN */
#define RICODOWN         14  /* BOXCHAR in Baum MAIN */
#define RICOUP           15  /* BOXCHAR in Baum MAIN */
#define RICOLIST         16  /* BOX in Baum MAIN */
#define RICO1            17  /* USERDEF in Baum MAIN */
#define RICOLOGIN        19  /* USERDEF in Baum MAIN */
#define RICOLOGOUT       20  /* USERDEF in Baum MAIN */
#define RICOLAST         21  /* USERDEF in Baum MAIN */
#define OPTFRAME         22  /* BOX in Baum MAIN */
#define SCRIPTBOX        23  /* BOX in Baum MAIN */
#define SCRIPTBAR        24  /* BOX in Baum MAIN */
#define SCRIPTSLIDE      25  /* BOXCHAR in Baum MAIN */
#define SCRIPTL1         26  /* BUTTON in Baum MAIN */
#define SCRIPTL2         29  /* BUTTON in Baum MAIN */
#define SCRIPTL3         32  /* BUTTON in Baum MAIN */
#define SCRIPTL4         35  /* BUTTON in Baum MAIN */
#define SCRIPTL5         38  /* BUTTON in Baum MAIN */
#define SCRIPTL6         41  /* BUTTON in Baum MAIN */
#define SCRIPTL7         44  /* BUTTON in Baum MAIN */
#define SCRIPTLL         47  /* BUTTON in Baum MAIN */
#define SCRIPTLLAST      49  /* BUTTON in Baum MAIN */
#define SCRIPTUP         50  /* BOXCHAR in Baum MAIN */
#define SCRIPTDOWN       51  /* BOXCHAR in Baum MAIN */
#define SCRIPTWAIT       53  /* FTEXT in Baum MAIN */
#define SCRIPTRESTART    54  /* FTEXT in Baum MAIN */
#define INFOBUT          56  /* USERDEF in Baum MAIN */
#define OUTFRAME1        57  /* BOX in Baum MAIN */
#define DNSIP            58  /* FTEXT in Baum MAIN */
#define DNSINITDELAY     59  /* FTEXT in Baum MAIN */
#define QUERYTO          62  /* FTEXT in Baum MAIN */
#define QUERYRT          63  /* FTEXT in Baum MAIN */
#define CACHE            64  /* BUTTON in Baum MAIN */
#define CACHESIZE        65  /* FTEXT in Baum MAIN */
#define PPPAUTHUSER      70  /* BUTTON in Baum MAIN */
#define PPPAUTHPASS      71  /* BUTTON in Baum MAIN */
#define PPPUSERSET       72  /* TEXT in Baum MAIN */
#define PPPPASSSET       73  /* TEXT in Baum MAIN */
#define PHONE_NR         78  /* FTEXT in Baum MAIN */
#define DIALTYPE         79  /* BUTTON in Baum MAIN */
#define REDIAL_WAIT      81  /* FTEXT in Baum MAIN */
#define LOCAL_IP         83  /* FTEXT in Baum MAIN */
#define CONF_RETRY       87  /* FTEXT in Baum MAIN */
#define CONF_TO          89  /* FTEXT in Baum MAIN */
#define TERM_RETRY       90  /* FTEXT in Baum MAIN */
#define TERM_TO          91  /* FTEXT in Baum MAIN */
#define NAK_ACK          92  /* FTEXT in Baum MAIN */
#define LCP_ECHO         93  /* FTEXT in Baum MAIN */
#define MODLINE1         95  /* STRING in Baum MAIN */
#define MODP1            96  /* BUTTON in Baum MAIN */
#define MODDOWN1         97  /* STRING in Baum MAIN */
#define MODP2            98  /* BUTTON in Baum MAIN */
#define MODP3            100 /* BUTTON in Baum MAIN */
#define MODP4            102 /* BUTTON in Baum MAIN */
#define MODP5            104 /* BUTTON in Baum MAIN */
#define MODP6            106 /* BUTTON in Baum MAIN */
#define MODEMINIT        107 /* FTEXT in Baum MAIN */
#define HANGDTR          109 /* BUTTON in Baum MAIN */
#define HANGCMD          110 /* BUTTON in Baum MAIN */
#define HANGESC          111 /* FTEXT in Baum MAIN */
#define HANGPAUSE        112 /* FTEXT in Baum MAIN */
#define HANGAT           113 /* FTEXT in Baum MAIN */
#define VIA_MAC          115 /* BUTTON in Baum MAIN */
#define EMAIL            124 /* FTEXT in Baum MAIN */
#define REALNAME         126 /* FTEXT in Baum MAIN */
#define POPIP            128 /* FTEXT in Baum MAIN */
#define SERVPOPUSER      130 /* FTEXT in Baum MAIN */
#define SERVPOPPASS      132 /* FTEXT in Baum MAIN */
#define SMTPIP           134 /* FTEXT in Baum MAIN */
#define NEWSIP           136 /* FTEXT in Baum MAIN */
#define SERVNNTPUSER     138 /* FTEXT in Baum MAIN */
#define SERVNNTPPASS     140 /* FTEXT in Baum MAIN */
#define TIMEIP           142 /* FTEXT in Baum MAIN */
#define ETCENV           145 /* BUTTON in Baum MAIN */
#define PATHOB           146 /* TEXT in Baum MAIN */
#define PATHSELECT       147 /* BUTTON in Baum MAIN */
#define ETCPATH          148 /* BUTTON in Baum MAIN */
#define ENVOB            149 /* FTEXT in Baum MAIN */
#define MINPORT          152 /* FTEXT in Baum MAIN */
#define MAXPORT          153 /* FTEXT in Baum MAIN */
#define MAXLOG           154 /* FTEXT in Baum MAIN */
#define MAX_UDP          158 /* FTEXT in Baum MAIN */
#define CONN_TO          161 /* FTEXT in Baum MAIN */
#define TRANS_TO         163 /* FTEXT in Baum MAIN */
#define DEFAULT_RCV_WIN  164 /* FTEXT in Baum MAIN */
#define PREC_RAISE       165 /* BUTTON in Baum MAIN */
#define DEFAULT_SND_WIN  166 /* FTEXT in Baum MAIN */
#define SEND_AHEAD       167 /* BUTTON in Baum MAIN */
#define IN_QUEUE_TO      169 /* FTEXT in Baum MAIN */
#define IPTOS            170 /* FTEXT in Baum MAIN */
#define PREC             171 /* FTEXT in Baum MAIN */
#define TTL              172 /* FTEXT in Baum MAIN */
#define MTU              173 /* FTEXT in Baum MAIN */
#define PROXYFRAME       175 /* BOX in Baum MAIN */
#define SERVPOP          177 /* BUTTON in Baum MAIN */
#define SERVCHANGE       178 /* BUTTON in Baum MAIN */
#define PROXYIP          181 /* FTEXT in Baum MAIN */
#define PROXYPORT        182 /* FTEXT in Baum MAIN */
#define PNOT1            184 /* FTEXT in Baum MAIN */
#define PNOT2            185 /* FTEXT in Baum MAIN */
#define PNOT3            186 /* FTEXT in Baum MAIN */
#define PNOT4            187 /* FTEXT in Baum MAIN */
#define PNOT5            188 /* FTEXT in Baum MAIN */
#define PNOT6            189 /* FTEXT in Baum MAIN */
#define MAINSIZE         195 /* IBOX in Baum MAIN */

#define ICONS            1   /* Formular/Dialog */
#define ICO1             1   /* USERDEF in Baum ICONS */
#define ICOMAX           12  /* USERDEF in Baum ICONS */

#define SETNAME          2   /* Formular/Dialog */
#define SETENTRY         1   /* FTEXT in Baum SETNAME */
#define SETTEXT          2   /* STRING in Baum SETNAME */
#define NEWNAMEOK        4   /* BUTTON in Baum SETNAME */
#define NEWNAMECANCEL    5   /* BUTTON in Baum SETNAME */
#define NI1              6   /* STRING in Baum SETNAME */
#define NI2              7   /* STRING in Baum SETNAME */
#define NI3              8   /* STRING in Baum SETNAME */

#define SETPROXY         3   /* Formular/Dialog */
#define NEWSERVICE       1   /* FTEXT in Baum SETPROXY */
#define NEWSOK           4   /* BUTTON in Baum SETPROXY */
#define NEWSCANCEL       5   /* BUTTON in Baum SETPROXY */

#define SCRIPTPOP        4   /* Formular/Dialog */

#define MODPOPUP         5   /* Formular/Dialog */

#define SCRIPTS          6   /* Formular/Dialog */
#define STYPL1           3   /* BUTTON in Baum SCRIPTS */
#define STYPL2           6   /* BUTTON in Baum SCRIPTS */

#define PROXYPOP         7   /* Formular/Dialog */

#define SETUPPOP         8   /* Formular/Dialog */

#define INFOTREE         9   /* Formular/Dialog */
#define INFOVERSION      10  /* STRING in Baum INFOTREE */
#define INFOK            11  /* BUTTON in Baum INFOTREE */
#define INFODATE         12  /* STRING in Baum INFOTREE */
#define USERNAME         14  /* TEXT in Baum INFOTREE */
#define USERFIRMA        15  /* TEXT in Baum INFOTREE */

#define ENTERPASS        10  /* Formular/Dialog */
#define PASSINPUT        2   /* FTEXT in Baum ENTERPASS */
#define ENTRYCANCEL      3   /* BUTTON in Baum ENTERPASS */
#define ENTRYOK          4   /* BUTTON in Baum ENTERPASS */
#define ICON3            5   /* USERDEF in Baum ENTERPASS */

#define ENTERUSER        11  /* Formular/Dialog */
#define USERINPUT        2   /* FTEXT in Baum ENTERUSER */
#define USERINCANCEL     3   /* BUTTON in Baum ENTERUSER */
#define USERINOK         4   /* BUTTON in Baum ENTERUSER */
#define ICON1            5   /* USERDEF in Baum ENTERUSER */
#define TONLINEMODE      6   /* BUTTON in Baum ENTERUSER */
#define TOFRAME          7   /* IBOX in Baum ENTERUSER */
#define TOKENNUNG        8   /* FTEXT in Baum ENTERUSER */
#define TONUMMER         9   /* FTEXT in Baum ENTERUSER */
#define TOMITBENUTZER    10  /* FTEXT in Baum ENTERUSER */
#define ICON2            11  /* USERDEF in Baum ENTERUSER */

#define STRINGS          12  /* Formular/Dialog */
#define NEWSET1          1   /* STRING in Baum STRINGS */
#define NEWSET2          2   /* STRING in Baum STRINGS */
#define INREQ1           3   /* STRING in Baum STRINGS */
#define INREQ2           4   /* STRING in Baum STRINGS */
#define PPPSET1          5   /* STRING in Baum STRINGS */
#define PPPSET2          6   /* STRING in Baum STRINGS */
#define LOGINSTRING      7   /* STRING in Baum STRINGS */
#define LOGOUTSTRING     8   /* STRING in Baum STRINGS */
#define ETCOPEN          9   /* STRING in Baum STRINGS */
#define A1               10  /* STRING in Baum STRINGS */
#define A2               11  /* STRING in Baum STRINGS */
#define A4               12  /* STRING in Baum STRINGS */
#define A5               13  /* STRING in Baum STRINGS */
#define A6               14  /* STRING in Baum STRINGS */
#define A7               15  /* STRING in Baum STRINGS */
#define A8               16  /* STRING in Baum STRINGS */
#define A9               17  /* STRING in Baum STRINGS */
#define A10              18  /* STRING in Baum STRINGS */
#define A11              19  /* STRING in Baum STRINGS */
#define NSI1             20  /* STRING in Baum STRINGS */
#define NSI2             21  /* STRING in Baum STRINGS */
#define NSI3             22  /* STRING in Baum STRINGS */
#define CSI1             23  /* STRING in Baum STRINGS */
#define CSI3             24  /* STRING in Baum STRINGS */

#define DIALPOP          13  /* Formular/Dialog */
