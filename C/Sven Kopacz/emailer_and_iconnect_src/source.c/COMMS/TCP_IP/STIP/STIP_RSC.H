/* Resource Datei Indizes f�r STIP_RSC */

#define MENU             0   /* Menuebaum */
#define RSM_ABOUT        7   /* STRING in Baum MENU */
#define RSM_QUIT         16  /* STRING in Baum MENU */

#define NUM_STRINGS 0
#define NUM_IMAGES 0
#define NUM_BB 0
#define NUM_IB 0
#define NUM_TI 0
#define NUM_OBS 17
#define NUM_TREE 1

#include <aes.h>

void    objc_init( void );
extern  OBJECT *TREE[];

/* RSC2CSRC */