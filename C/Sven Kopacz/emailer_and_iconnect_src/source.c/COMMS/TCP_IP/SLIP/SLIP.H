/* Resource Datei Indizes f�r SLIP */

#define DIAL             0   /* Formular/Dialog */
#define IP               1   /* FTEXT in Baum DIAL */
#define SLIP             2   /* BUTTON in Baum DIAL */
#define QUIT             3   /* BUTTON in Baum DIAL */
#define ONLINE           4   /* TEXT in Baum DIAL */

#define SERIAL           1   /* Formular/Dialog */
#define IB1              1   /* IBOX in Baum SERIAL */
#define P1               8   /* BUTTON in Baum SERIAL */
#define P2               9   /* BUTTON in Baum SERIAL */
#define P3               10  /* BUTTON in Baum SERIAL */
#define P4               11  /* BUTTON in Baum SERIAL */
#define P5               12  /* BUTTON in Baum SERIAL */
#define P6               13  /* BUTTON in Baum SERIAL */
#define SLIP_SEL         20  /* BUTTON in Baum SERIAL */
#define PPP_SEL          21  /* BUTTON in Baum SERIAL */
#define IB2              23  /* IBOX in Baum SERIAL */
#define ALT1             24  /* FTEXT in Baum SERIAL */
#define CR1              25  /* BUTTON in Baum SERIAL */
#define ALT2             26  /* FTEXT in Baum SERIAL */
#define CR2              27  /* BUTTON in Baum SERIAL */
#define ALT3             28  /* FTEXT in Baum SERIAL */
#define CR3              29  /* BUTTON in Baum SERIAL */
#define LOAD             31  /* BUTTON in Baum SERIAL */
#define SAVE             32  /* BUTTON in Baum SERIAL */
#define OK               33  /* BUTTON in Baum SERIAL */
#define CANCEL           34  /* BUTTON in Baum SERIAL */
#define IB3              35  /* IBOX in Baum SERIAL */
#define DNS              37  /* FTEXT in Baum SERIAL */
#define LOCAL            38  /* FTEXT in Baum SERIAL */
#define DEBUG            39  /* BOXTEXT in Baum SERIAL */
#define AUTHUSER         41  /* FTEXT in Baum SERIAL */
#define AUTHPASS         43  /* FTEXT in Baum SERIAL */

#define POPUP            2   /* Formular/Dialog */

#define ERRREP           3   /* Formular/Dialog */
#define ERRCANCEL        11  /* BUTTON in Baum ERRREP */
#define ERR1             12  /* STRING in Baum ERRREP */
#define ERR2             13  /* STRING in Baum ERRREP */
#define ERR3             14  /* STRING in Baum ERRREP */
#define ERR4             15  /* STRING in Baum ERRREP */
#define ERR5             16  /* STRING in Baum ERRREP */
#define ERR6             17  /* STRING in Baum ERRREP */
#define ERR7             18  /* STRING in Baum ERRREP */
#define ERR8             19  /* STRING in Baum ERRREP */
#define ERR9             20  /* STRING in Baum ERRREP */
