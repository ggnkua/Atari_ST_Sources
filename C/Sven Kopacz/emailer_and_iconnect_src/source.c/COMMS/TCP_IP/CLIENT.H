/* Resource Datei Indizes f�r CLIENT */

#define DIAL             0   /* Formular/Dialog */
#define CONNECT          1   /* BUTTON in Baum DIAL */
#define SEND             2   /* BUTTON in Baum DIAL */
#define QUIT             3   /* BUTTON in Baum DIAL */
#define STATUS           5   /* TEXT in Baum DIAL */
#define CIP              6   /* FTEXT in Baum DIAL */
#define CPORT            7   /* FTEXT in Baum DIAL */
#define CMSG             8   /* FTEXT in Baum DIAL */
#define CRMSG            10  /* TEXT in Baum DIAL */
#define CCLOSE           11  /* BUTTON in Baum DIAL */
#define CRMSG2           12  /* TEXT in Baum DIAL */
#define CRMSG3           13  /* TEXT in Baum DIAL */
#define LISTEN           14  /* BUTTON in Baum DIAL */
#define CLOCAL           15  /* FTEXT in Baum DIAL */
#define BIND             16  /* BUTTON in Baum DIAL */
#define LIP              18  /* TEXT in Baum DIAL */
