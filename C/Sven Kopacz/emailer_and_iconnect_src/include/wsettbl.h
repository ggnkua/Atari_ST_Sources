/* Setzt die Werte f�r die Tasten */

#define	NOTUSED 69

char *curtable[]=
{
"UP",
" PgUp",
"- (Z)",
"LEFT",
"    ",
"RIGHT",
"+ (Z)",
" END ",
"DOWN"
};

char *g_keytable[]=
{
" ESC ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  ž  ",
"  \'  ",
"BKSPC",
" TAB ",
"  Q  ",
"  W  ",
"  E  ",
"  R  ",
"  T  ",
"  Z  ",
"  U  ",
"  I  ",
"  O  ",
"  P  ",
"  š  ",
"  +  ",
" RET ",
"CNTRL",
"  A  ",
"  S  ",
"  D  ",
"  F  ",
"  G  ",
"  H  ",
"  J  ",
"  K  ",
"  L  ",
"  ™  ",
"  Ž  ",
"  #  ",
"LShft",
"  ~  ",
"  Y  ",
"  X  ",
"  C  ",
"  V  ",
"  B  ",
"  N  ",
"  M  ",
"  ,  ",
"  .  ",
"  -  ",
"RShft",
" Sys ",
" ALT ",
"SPACE",
"CLock",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"keine",
"     ",
" CLR ",
"  \x1  ",
" PgUp",
"- (Z)",
"  \x4  ",
"     ",
"  \x3  ",
"+ (Z)",
" END ",
"  \x2  ",
"PgDwn",
" INS ",
" DEL ",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"     ",
"     ",
"  <  ",
" UNDO",
" HELP",
"( (Z)",
") (Z)",
"/ (Z)",
"* (Z)",
"7 (Z)",
"8 (Z)",
"9 (Z)",
"4 (Z)",
"5 (Z)",
"6 (Z)",
"1 (Z)",
"2 (Z)",
"3 (Z)",
"0 (Z)",
". (Z)",
"ENTER",
"  \x4  ",
"  \x3  ",
"     ",
"     ",
" CLR ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  ž  ",
"  \'  ",
"     "
};

char *us_keytable[]=
{
" ESC ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  -  ",
"  =  ",
"BKSPC",
" TAB ",
"  Q  ",
"  W  ",
"  E  ",
"  R  ",
"  T  ",
"  Y  ",
"  U  ",
"  I  ",
"  O  ",
"  P  ",
"  [  ",
"  ]  ",
" RET ",
"CNTRL",
"  A  ",
"  S  ",
"  D  ",
"  F  ",
"  G  ",
"  H  ",
"  J  ",
"  K  ",
"  L  ",
"  ;  ",
"  \'  ",
"  \`  ",
"LShft",
"  \\  ",
"  Z  ",
"  X  ",
"  C  ",
"  V  ",
"  B  ",
"  N  ",
"  M  ",
"  ,  ",
"  .  ",
"  /  ",
"RShft",
" Sys ",
" ALT ",
"SPACE",
"CLock",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"keine",
"     ",
" CLR ",
"  \x1  ",
" PgUp",
"- (Z)",
"  \x4  ",
"     ",
"  \x3  ",
"+ (Z)",
" END ",
"  \x2  ",
"PgDwn",
" INS ",
" DEL ",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"     ",
"     ",
"     ",
" UNDO",
" HELP",
"( (Z)",
") (Z)",
"/ (Z)",
"* (Z)",
"7 (Z)",
"8 (Z)",
"9 (Z)",
"4 (Z)",
"5 (Z)",
"6 (Z)",
"1 (Z)",
"2 (Z)",
"3 (Z)",
"0 (Z)",
". (Z)",
"ENTER",
"  \x4  ",
"  \x3  ",
"     ",
"     ",
" CLR ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  -  ",
"  =  ",
"     "
};

char *e_keytable[]=
{
" ESC ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  -  ",
"  =  ",
"BKSPC",
" TAB ",
"  Q  ",
"  W  ",
"  E  ",
"  R  ",
"  T  ",
"  Y  ",
"  U  ",
"  I  ",
"  O  ",
"  P  ",
"  [  ",
"  ]  ",
" RET ",
"CNTRL",
"  A  ",
"  S  ",
"  D  ",
"  F  ",
"  G  ",
"  H  ",
"  J  ",
"  K  ",
"  L  ",
"  ;  ",
"  \'  ",
"  \`  ",
"LShft",
"  #  ",
"  Z  ",
"  X  ",
"  C  ",
"  V  ",
"  B  ",
"  N  ",
"  M  ",
"  ,  ",
"  .  ",
"  /  ",
"RShft",
" Sys ",
" ALT ",
"SPACE",
"CLock",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"keine",
"     ",
" CLR ",
"  \x1  ",
" PgUp",
"- (Z)",
"  \x4  ",
"     ",
"  \x3  ",
"+ (Z)",
" END ",
"  \x2  ",
"PgDwn",
" INS ",
" DEL ",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"     ",
"     ",
"  \\  ",
" UNDO",
" HELP",
"( (Z)",
") (Z)",
"/ (Z)",
"* (Z)",
"7 (Z)",
"8 (Z)",
"9 (Z)",
"4 (Z)",
"5 (Z)",
"6 (Z)",
"1 (Z)",
"2 (Z)",
"3 (Z)",
"0 (Z)",
". (Z)",
"ENTER",
"  \x4  ",
"  \x3  ",
"     ",
"     ",
" CLR ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  -  ",
"  =  ",
"     "
};

char *f_keytable[]=
{
" ESC ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  )  ",
"  -  ",
"BKSPC",
" TAB ",
"  A  ",
"  Z  ",
"  E  ",
"  R  ",
"  T  ",
"  Y  ",
"  U  ",
"  I  ",
"  O  ",
"  P  ",
"  [  ",
"  ]  ",
" RET ",
"CNTRL",
"  Q  ",
"  S  ",
"  D  ",
"  F  ",
"  G  ",
"  H  ",
"  J  ",
"  K  ",
"  L  ",
"  M  ",
"  \\  ",
"  \`  ",
"LShft",
"  @  ",
"  W  ",
"  X  ",
"  C  ",
"  V  ",
"  B  ",
"  N  ",
"  ,  ",
"  ;  ",
"  :  ",
"  =  ",
"RShft",
" Sys ",
" ALT ",
"SPACE",
"CLock",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"keine",
"     ",
" CLR ",
"  \x1  ",
" PgUp",
"- (Z)",
"  \x4  ",
"     ",
"  \x3  ",
"+ (Z)",
" END ",
"  \x2  ",
"PgDwn",
" INS ",
" DEL ",
" F 1 ",
" F 2 ",
" F 3 ",
" F 4 ",
" F 5 ",
" F 6 ",
" F 7 ",
" F 8 ",
" F 9 ",
" F10 ",
"     ",
"     ",
"  <  ",
" UNDO",
" HELP",
"( (Z)",
") (Z)",
"/ (Z)",
"* (Z)",
"7 (Z)",
"8 (Z)",
"9 (Z)",
"4 (Z)",
"5 (Z)",
"6 (Z)",
"1 (Z)",
"2 (Z)",
"3 (Z)",
"0 (Z)",
". (Z)",
"ENTER",
"  \x4  ",
"  \x3  ",
"     ",
"     ",
" CLR ",
"  1  ",
"  2  ",
"  3  ",
"  4  ",
"  5  ",
"  6  ",
"  7  ",
"  8  ",
"  9  ",
"  0  ",
"  )  ",
"  -  ",
"     "
};


