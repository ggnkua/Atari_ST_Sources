/*
 * C version of 'D:\PROJECTS\DXED\DXED1.RSC'
 */

unsigned char DXEDRSC[] = {
	0,0,51,40,50,240,50,240,49,48,14,138,0,36,14,138,49,48,
	123,136,3,4,0,25,0,2,0,0,0,32,0,0,0,0,123,236,
	65,114,114,97,110,103,101,32,118,111,105,99,101,115,32,105,110,32,
	118,111,105,99,101,32,98,97,110,107,0,78,69,87,86,79,73,67,
	69,48,51,0,78,69,87,86,79,73,67,69,48,52,0,78,69,87,
	86,79,73,67,69,48,53,0,78,69,87,86,79,73,67,69,48,54,
	0,78,69,87,86,79,73,67,69,48,55,0,78,69,87,86,79,73,
	67,69,48,56,0,78,69,87,86,79,73,67,69,48,57,0,78,69,
	87,86,79,73,67,69,49,48,0,78,69,87,86,79,73,67,69,49,
	49,0,78,69,87,86,79,73,67,69,49,50,0,78,69,87,86,79,
	73,67,69,49,51,0,78,69,87,86,79,73,67,69,49,52,0,78,
	69,87,86,79,73,67,69,49,53,0,78,69,87,86,79,73,67,69,
	49,54,0,78,69,87,86,79,73,67,69,49,55,0,78,69,87,86,
	79,73,67,69,49,56,0,78,69,87,86,79,73,67,69,49,57,0,
	78,69,87,86,79,73,67,69,50,48,0,78,69,87,86,79,73,67,
	69,50,51,0,78,69,87,86,79,73,67,69,50,52,0,78,69,87,
	86,79,73,67,69,50,53,0,78,69,87,86,79,73,67,69,50,54,
	0,78,69,87,86,79,73,67,69,50,55,0,78,69,87,86,79,73,
	67,69,50,56,0,78,69,87,86,79,73,67,69,50,57,0,78,69,
	87,86,79,73,67,69,51,49,0,78,69,87,86,79,73,67,69,51,
	50,0,78,69,87,86,79,73,67,69,48,50,0,78,69,87,86,79,
	73,67,69,50,50,0,78,69,87,86,79,73,67,69,48,49,0,78,
	69,87,86,79,73,67,69,50,49,0,78,69,87,86,79,73,67,69,
	51,48,0,83,65,86,69,0,76,79,65,68,32,66,65,78,75,0,
	69,120,105,116,0,76,79,65,68,32,86,79,73,67,69,0,85,115,
	101,32,76,111,97,100,32,118,111,105,99,101,32,98,121,0,102,105,
	114,115,116,32,99,108,105,99,107,32,111,110,32,97,110,0,101,110,
	116,114,121,32,105,110,32,116,97,98,108,101,32,116,111,0,98,101,
	32,114,101,112,108,97,99,101,100,44,32,116,104,101,110,0,99,108,
	105,99,107,32,111,110,32,108,111,97,100,0,118,111,105,99,101,46,
	0,49,0,75,69,89,66,79,65,82,68,32,76,69,86,69,76,47,
	82,65,84,69,32,83,67,65,76,73,78,71,32,79,80,69,82,0,
	65,84,79,82,0,48,48,0,48,48,0,76,83,66,80,0,76,83,
	76,68,0,76,83,82,68,0,76,83,82,67,0,76,83,76,67,0,
	75,66,82,83,0,69,88,73,84,0,67,65,78,67,69,76,0,48,
	48,48,48,0,48,48,0,48,48,48,48,0,48,48,48,48,0,48,
	48,0,48,48,0,48,48,0,48,48,0,79,83,67,73,76,65,84,
	79,82,32,70,82,69,81,85,69,78,67,89,32,70,79,82,32,79,
	80,69,82,65,84,79,82,0,49,0,67,79,65,82,83,69,0,70,
	73,78,69,0,68,69,84,85,78,69,0,77,79,68,69,0,69,88,
	73,84,0,67,65,78,67,69,76,0,48,48,48,48,48,48,48,48,
	0,79,80,45,49,0,79,80,45,50,0,79,80,45,51,0,79,80,
	45,52,0,79,80,45,53,0,79,80,45,54,0,79,78,0,79,78,
	0,79,78,0,79,78,0,79,78,0,79,78,0,79,75,0,67,65,
	78,67,69,76,0,0,83,101,108,101,99,116,0,79,112,101,114,97,
	116,111,114,0,69,110,97,98,108,101,0,79,112,101,114,97,116,111,
	114,0,79,75,0,67,97,110,99,101,108,0,69,71,82,49,0,69,
	71,82,50,0,69,71,82,51,0,69,71,82,52,0,69,71,76,52,
	0,69,71,76,51,0,69,71,76,50,0,69,71,76,49,0,0,48,
	48,0,48,48,0,48,48,0,48,48,0,48,48,0,48,48,0,48,
	48,0,48,48,0,69,100,105,116,32,69,110,118,101,108,111,112,101,
	32,102,111,114,32,79,80,58,0,49,0,49,0,50,0,51,0,52,
	0,56,0,55,0,54,0,53,0,57,0,49,48,0,49,49,0,49,
	50,0,49,54,0,49,53,0,49,52,0,49,51,0,83,101,116,32,
	77,105,100,105,32,67,104,97,110,110,101,108,0,48,48,0,83,80,
	69,69,68,0,48,48,0,48,48,0,48,48,0,48,48,0,48,48,
	0,79,75,0,67,65,78,67,69,76,0,68,69,80,84,72,0,68,
	69,76,65,89,0,80,73,84,67,72,0,68,69,80,84,72,0,65,
	77,80,76,73,0,83,89,78,67,0,75,69,89,0,87,65,86,69,
	0,87,65,86,69,0,76,70,79,0,80,77,83,0,76,70,79,32,
	80,114,97,109,101,116,101,114,115,0,48,48,0,48,48,0,69,71,
	32,66,73,65,83,0,65,77,80,76,73,84,85,68,69,0,80,73,
	84,67,72,0,83,69,78,83,73,84,73,86,73,84,89,0,65,83,
	83,73,71,78,0,65,83,83,73,71,78,77,69,78,84,83,0,79,
	75,0,67,65,78,67,69,76,0,65,70,84,69,82,32,84,79,85,
	67,72,0,65,70,84,69,82,32,84,79,85,67,72,32,80,65,82,
	65,77,69,84,69,82,83,0,79,75,0,83,84,82,73,78,71,32,
	32,32,32,105,0,83,84,82,73,78,71,32,32,32,32,105,0,83,
	84,82,73,78,71,32,32,32,32,105,0,83,84,82,73,78,71,32,
	32,32,32,105,0,83,84,82,73,78,71,32,32,32,32,105,0,83,
	84,82,73,78,71,32,32,32,32,105,0,83,84,82,73,78,71,32,
	32,32,32,105,0,83,84,82,73,78,71,32,32,32,32,105,0,83,
	84,82,73,78,71,32,32,32,32,105,0,83,84,82,73,78,71,105,
	105,105,105,105,0,32,32,32,32,32,32,32,66,79,88,84,69,88,
	84,32,32,32,32,32,32,0,0,67,97,110,99,101,108,0,32,68,
	101,115,107,32,0,32,70,105,108,101,32,0,32,32,77,105,100,105,
	32,0,32,32,69,100,105,116,32,32,0,32,69,68,45,79,80,32,
	32,0,32,69,68,45,77,79,68,32,0,32,69,68,45,80,69,82,
	0,32,80,108,97,121,32,0,32,32,65,98,111,117,116,32,68,88,
	45,69,100,105,116,32,32,32,32,32,0,45,45,45,45,45,45,45,
	45,45,45,45,45,45,45,45,45,45,45,45,45,0,32,32,68,101,
	115,107,32,65,99,99,101,115,115,111,114,121,32,49,32,32,0,32,
	32,68,101,115,107,32,65,99,99,101,115,115,111,114,121,32,50,32,
	32,0,32,32,68,101,115,107,32,65,99,99,101,115,115,111,114,121,
	32,51,32,32,0,32,32,68,101,115,107,32,65,99,99,101,115,115,
	111,114,121,32,52,32,32,0,32,32,68,101,115,107,32,65,99,99,
	101,115,115,111,114,121,32,53,32,32,0,32,32,68,101,115,107,32,
	65,99,99,101,115,115,111,114,121,32,54,32,32,0,32,32,79,112,
	101,110,32,0,32,32,78,101,119,32,0,45,45,45,45,45,45,45,
	45,45,45,45,45,45,45,45,45,0,32,32,83,97,118,101,32,66,
	97,110,107,32,0,32,32,65,114,114,97,110,103,101,32,0,45,45,
	45,45,45,80,114,105,110,116,45,45,45,45,45,45,0,32,32,80,
	97,116,99,104,32,68,97,116,97,0,32,32,80,97,116,99,104,32,
	67,97,116,97,108,111,103,32,0,45,45,45,45,45,45,45,45,45,
	45,45,45,45,45,45,45,0,32,32,81,117,105,116,32,0,32,32,
	83,101,110,100,32,66,97,110,107,32,32,32,32,32,0,32,32,83,
	101,116,32,77,105,100,105,32,67,104,32,32,32,0,32,32,83,101,
	116,32,80,97,116,99,104,32,35,32,32,32,0,32,32,69,100,105,
	116,32,86,111,105,99,101,32,0,32,32,83,97,118,101,32,86,111,
	105,99,101,32,0,32,32,69,110,118,101,108,111,112,101,32,32,32,
	0,32,32,83,99,97,108,105,110,103,0,32,32,70,114,101,113,117,
	101,110,99,121,32,0,32,32,83,101,110,115,105,116,105,118,105,116,
	121,32,0,32,32,79,112,101,114,97,116,111,114,32,0,32,32,80,
	105,116,99,104,32,69,110,118,101,108,111,112,101,32,0,32,32,76,
	70,79,32,0,32,32,65,108,103,111,114,121,116,104,109,0,32,32,
	79,116,104,101,114,32,0,32,32,80,111,114,116,97,109,101,110,116,
	111,32,0,32,32,80,105,116,99,104,32,66,101,110,100,32,0,32,
	32,77,111,100,117,108,97,116,105,111,110,32,87,104,101,101,108,0,
	32,32,70,111,111,116,32,67,111,110,116,114,111,108,32,0,32,32,
	65,102,116,101,114,32,84,111,117,99,104,0,32,32,66,114,101,97,
	116,104,32,67,111,110,116,114,111,108,0,32,32,79,116,104,101,114,
	32,0,32,32,80,108,97,121,32,83,99,97,108,101,115,0,32,32,
	77,117,115,105,99,32,83,116,117,100,105,111,32,83,78,71,32,0,
	45,45,45,45,45,83,101,113,117,101,110,99,101,114,45,45,45,45,
	45,0,32,32,82,101,99,111,114,100,32,32,32,32,32,0,32,32,
	80,108,97,121,98,97,99,107,32,32,32,0,79,75,0,67,97,110,
	99,101,108,0,69,71,82,49,0,69,71,82,50,0,69,71,82,51,
	0,69,71,82,52,0,69,71,76,52,0,69,71,76,51,0,69,71,
	76,50,0,69,71,76,49,0,80,105,116,99,104,32,69,110,118,101,
	108,111,112,101,32,71,101,110,101,114,97,116,111,114,32,80,97,114,
	97,109,101,116,101,114,115,0,48,48,0,48,48,0,48,48,0,48,
	48,0,48,48,0,48,48,0,48,48,0,48,48,0,48,48,0,48,
	48,0,69,71,32,66,73,65,83,0,65,77,80,76,73,84,85,68,
	69,0,80,73,84,67,72,0,83,69,78,83,73,84,73,86,73,84,
	89,0,65,83,83,73,71,78,0,65,83,83,73,71,78,77,69,78,
	84,83,0,79,75,0,67,65,78,67,69,76,0,66,82,69,65,84,
	72,32,67,79,78,84,82,79,76,32,80,65,82,65,77,69,84,69,
	82,83,0,66,82,69,65,84,72,32,67,79,78,84,82,79,76,0,
	48,48,0,48,48,0,48,48,0,77,79,68,85,76,65,84,73,79,
	78,32,83,69,78,83,73,84,73,86,73,84,89,0,49,0,86,69,
	76,32,83,69,78,83,0,65,77,32,83,69,78,83,0,79,85,84,
	32,76,69,86,0,69,88,73,84,0,67,65,78,67,69,76,0,84,
	104,105,115,32,112,114,111,103,114,97,109,32,105,115,32,102,111,114,
	32,101,100,105,116,105,110,103,32,118,111,105,99,101,115,0,66,121,
	32,74,105,109,32,80,97,116,99,104,101,108,108,0,79,110,32,116,
	104,101,32,89,97,109,97,104,97,32,84,88,45,50,47,56,45,49,
	54,32,70,77,32,116,111,110,101,0,71,101,110,101,114,97,116,111,
	114,46,32,32,73,116,32,109,97,121,32,98,101,32,116,104,97,116,
	32,105,116,32,119,105,108,108,0,119,111,114,107,32,119,105,116,104,
	32,116,104,101,32,68,88,45,55,44,32,98,117,116,32,73,32,100,
	111,110,39,116,32,111,119,110,0,111,110,101,46,32,32,84,104,105,
	115,32,105,115,32,97,32,112,117,98,108,105,99,32,68,79,77,65,
	73,78,32,112,114,111,45,0,103,114,97,109,44,32,98,117,116,32,
	105,102,32,121,111,117,32,108,105,107,101,32,105,116,32,116,104,101,
	32,97,117,116,104,111,114,0,119,111,117,108,100,32,97,112,114,101,
	97,116,105,97,116,101,32,121,111,117,32,115,101,110,100,105,110,103,
	32,109,111,114,101,0,98,101,101,114,32,109,111,110,101,121,46,32,
	32,84,104,97,110,107,32,89,111,117,0,79,75,0,83,97,110,116,
	97,32,66,97,114,98,97,114,97,44,32,67,65,32,57,51,49,49,
	49,0,53,51,51,32,83,97,110,32,66,108,97,115,32,80,108,0,
	74,105,109,32,80,97,116,99,104,101,108,108,0,84,104,105,115,32,
	115,111,102,116,119,97,114,101,32,119,114,105,116,116,101,110,32,117,
	115,105,110,103,0,77,101,103,97,109,97,120,32,86,101,114,32,49,
	46,49,32,67,32,99,111,109,112,105,108,101,114,0,68,88,45,69,
	68,32,32,118,101,114,32,48,46,48,48,0,80,105,116,99,104,32,
	66,101,110,100,32,80,97,114,97,109,101,116,101,114,115,0,48,48,
	0,48,48,0,83,116,101,112,0,82,97,110,103,101,0,79,75,0,
	67,65,78,67,69,76,0,79,70,70,0,79,83,67,0,75,69,89,
	83,89,78,67,0,77,105,115,99,105,108,97,110,101,111,117,115,32,
	80,97,114,97,109,101,116,101,114,115,0,48,48,0,48,48,0,48,
	48,0,70,69,69,68,66,65,67,75,0,65,76,71,79,82,73,84,
	72,77,0,84,82,65,78,83,80,79,83,69,0,79,75,0,67,65,
	78,67,69,76,0,95,95,95,95,95,95,95,95,95,95,0,86,79,
	73,67,69,32,78,65,77,69,58,95,95,95,95,95,95,95,95,95,
	95,0,88,88,88,88,88,88,88,88,88,88,0,69,100,105,116,32,
	70,114,111,109,32,66,117,108,107,32,70,105,108,101,0,69,100,105,
	116,32,102,114,111,109,32,68,88,45,55,0,67,114,101,97,116,32,
	110,101,119,32,118,111,105,99,101,0,83,101,108,101,99,116,32,69,
	100,105,116,32,70,117,110,99,116,105,111,110,0,83,101,108,101,99,
	116,32,80,97,116,99,104,32,78,117,109,98,101,114,58,0,48,48,
	0,79,75,0,67,65,78,67,69,76,0,48,48,0,48,48,0,65,
	77,80,76,73,84,85,68,69,0,80,73,84,67,72,0,69,71,32,
	66,73,65,83,0,83,69,78,83,73,84,73,86,73,84,89,0,65,
	83,83,73,71,78,0,65,83,83,73,71,78,77,69,78,84,83,0,
	79,75,0,67,65,78,67,69,76,0,77,79,68,85,76,65,84,73,
	79,78,32,87,72,69,69,76,32,80,65,82,65,77,69,84,69,82,
	83,0,70,79,79,84,32,67,79,78,84,82,79,76,0,83,101,108,
	101,99,116,32,83,111,117,114,99,101,32,116,111,32,83,97,118,101,
	32,70,114,111,109,0,83,97,118,101,32,70,114,111,109,32,68,88,
	45,55,0,83,97,118,101,32,70,114,111,109,32,66,117,102,102,101,
	114,115,0,67,97,110,99,101,108,0,67,65,78,67,69,76,0,79,
	75,0,48,48,0,80,79,76,89,0,77,73,83,67,73,76,65,78,
	69,79,85,83,32,80,69,82,70,79,82,77,65,78,67,69,0,80,
	65,82,65,77,69,84,69,82,83,0,77,111,110,111,0,80,111,108,
	121,32,47,0,77,97,115,32,84,117,110,101,0,0,48,48,48,0,
	77,97,115,32,76,101,118,101,108,0,48,48,0,84,73,77,69,0,
	80,79,82,84,65,77,69,78,84,79,0,80,79,82,84,65,77,69,
	78,84,79,47,71,76,73,83,83,65,78,68,79,0,80,79,82,84,
	65,77,69,78,84,79,32,77,79,68,69,0,82,69,84,65,73,78,
	0,67,65,78,67,69,76,0,79,75,0,80,79,82,84,65,77,69,
	78,84,79,32,80,65,82,65,77,69,84,69,82,83,0,83,99,97,
	108,101,115,32,67,111,110,102,105,103,117,114,101,32,77,101,110,117,
	0,67,0,67,35,0,68,0,68,35,0,69,0,70,0,70,35,0,
	71,0,71,35,0,65,0,65,35,0,66,0,83,101,108,101,99,116,
	32,119,104,105,99,104,32,110,111,116,101,115,32,116,111,32,112,108,
	97,121,0,78,117,109,32,79,99,116,97,118,101,115,0,80,108,97,
	121,0,67,97,110,99,101,108,0,79,75,0,84,101,109,112,111,0,
	86,101,108,111,99,105,116,121,0,83,116,97,114,116,32,78,111,116,
	101,0,48,49,0,67,67,99,99,100,0,48,48,48,0,48,48,48,
	0,85,115,101,32,114,105,103,104,116,32,109,111,117,115,101,32,98,
	117,116,116,111,110,32,116,111,32,115,116,111,112,0,48,48,0,48,
	48,0,69,71,32,66,73,65,83,0,65,77,80,76,73,84,85,68,
	69,0,80,73,84,67,72,0,83,69,78,83,73,84,73,86,73,84,
	89,0,65,83,83,73,71,78,0,65,83,83,73,71,78,77,69,78,
	84,83,0,79,75,0,70,79,79,84,32,67,79,78,84,82,79,76,
	32,80,65,82,65,77,69,84,69,82,83,0,70,79,79,84,32,67,
	79,78,84,82,79,76,0,67,65,78,67,69,76,0,0,0,0,0,
	0,0,255,0,0,0,129,0,127,192,159,240,64,64,144,16,94,64,
	151,144,80,64,148,16,94,64,151,144,66,64,148,144,94,64,151,144,
	64,64,144,16,127,192,159,240,0,32,129,0,0,16,129,0,0,8,
	255,0,0,4,1,0,0,2,1,0,0,1,1,0,0,0,129,0,
	0,0,65,0,0,0,33,0,127,192,31,240,64,64,16,16,78,64,
	16,144,82,64,18,144,68,64,19,144,72,64,16,144,94,64,16,16,
	64,64,16,16,127,192,31,240,4,0,1,0,4,0,1,0,4,0,
	1,0,127,192,31,240,64,64,16,16,68,64,19,144,68,64,16,144,
	68,64,17,16,68,64,16,144,68,64,19,144,64,64,16,16,127,192,
	31,240,4,0,1,0,4,0,1,0,4,0,1,0,7,255,255,0,
	0,0,0,0,0,0,0,0,0,0,0,0,127,192,31,240,64,64,
	16,16,94,64,23,144,80,64,20,16,94,64,23,144,66,64,20,144,
	94,64,23,144,64,64,16,16,127,192,31,240,0,32,1,0,0,16,
	1,0,0,8,1,0,0,4,1,0,0,2,1,0,0,1,1,0,
	0,0,129,0,7,248,65,0,4,8,33,0,127,200,31,240,64,72,
	16,16,78,72,16,144,82,72,18,144,68,72,19,144,72,72,16,144,
	94,72,16,16,64,72,16,16,127,200,31,240,4,8,1,0,7,248,
	1,0,4,0,1,0,127,192,31,240,64,64,16,16,68,64,19,144,
	68,64,16,144,68,64,17,16,68,64,16,144,68,64,19,144,64,64,
	16,16,127,192,31,240,4,0,1,0,4,0,1,0,4,0,1,0,
	7,255,255,0,0,0,0,0,0,0,0,0,0,0,255,0,0,0,
	0,0,129,0,127,192,63,224,159,240,64,64,32,32,144,16,78,64,
	33,32,151,144,82,64,37,32,148,16,68,64,39,32,151,144,72,64,
	33,32,148,144,94,64,32,32,151,144,64,64,32,32,144,16,127,192,
	63,224,159,240,4,0,2,0,129,0,4,0,2,0,129,0,4,0,
	2,0,129,0,4,0,2,0,129,0,4,0,2,0,129,0,4,0,
	2,0,129,0,4,0,2,0,129,0,4,0,2,0,129,0,4,0,
	2,0,129,0,127,192,63,224,159,240,64,64,32,32,144,16,68,64,
	39,32,151,144,68,64,33,32,148,16,68,64,34,32,151,144,68,64,
	33,32,144,144,68,64,39,32,151,144,64,64,32,32,144,16,127,192,
	63,224,159,240,4,0,2,0,129,0,4,0,2,0,255,0,4,0,
	2,0,1,0,4,0,2,0,1,0,7,255,255,255,255,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,1,255,0,0,1,1,0,0,1,1,0,127,193,
	31,240,64,65,16,16,78,65,23,144,66,65,20,16,68,65,23,144,
	66,65,20,144,78,65,23,144,64,65,16,16,127,193,31,240,4,1,
	1,0,4,1,1,0,4,1,1,0,127,193,31,240,64,65,16,16,
	78,65,23,144,82,65,20,16,68,65,23,144,72,65,16,144,94,65,
	23,144,64,65,16,16,127,193,31,240,4,1,1,0,4,1,1,0,
	4,1,1,0,127,193,31,240,64,65,16,16,68,65,16,144,68,65,
	18,144,68,65,19,144,68,65,16,144,68,65,16,16,64,65,16,16,
	127,193,31,240,4,1,1,0,4,1,255,0,4,0,1,0,7,255,
	255,0,0,0,0,0,0,0,0,0,0,0,15,224,0,0,0,0,
	0,0,0,0,0,0,8,32,127,192,63,224,31,240,15,248,7,252,
	11,254,64,64,32,32,16,16,8,8,4,4,10,2,68,64,39,32,
	19,144,8,8,5,228,10,242,68,64,41,32,16,144,8,72,5,4,
	10,130,68,64,34,32,17,16,9,72,5,228,10,242,68,64,36,32,
	16,144,9,200,4,36,10,146,68,64,47,32,19,144,8,72,5,228,
	10,242,64,64,32,32,16,16,8,8,4,4,10,2,127,192,63,224,
	31,240,15,248,7,252,11,254,4,0,2,0,1,0,0,128,0,64,
	8,32,4,0,2,0,1,0,0,128,0,64,8,32,4,0,2,0,
	1,0,0,128,0,64,15,224,4,0,2,0,1,0,0,128,0,64,
	0,32,7,255,255,255,255,255,255,255,255,255,255,224,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,127,192,0,0,0,0,64,64,0,0,
	0,0,78,64,0,0,0,0,66,64,0,0,0,0,68,64,0,0,
	0,0,66,64,0,0,0,0,78,64,0,0,0,0,64,64,0,0,
	0,0,127,192,0,0,0,0,4,0,0,0,0,0,4,0,0,0,
	0,0,4,0,0,0,0,0,4,0,0,0,0,0,4,0,0,0,
	0,0,4,0,0,0,0,0,4,0,0,0,0,0,4,0,0,0,
	0,0,127,192,63,224,0,0,64,64,32,32,0,0,78,64,47,32,
	0,0,82,64,40,32,0,0,68,64,47,32,0,0,72,64,41,32,
	0,0,94,64,47,32,0,0,64,64,32,32,0,0,127,192,63,224,
	0,0,4,0,2,16,0,0,4,0,2,8,0,0,4,0,2,4,
	0,0,4,0,2,2,0,0,4,0,2,1,0,0,4,0,2,0,
	128,0,4,0,2,0,64,0,4,0,2,0,32,0,127,192,63,224,
	31,240,64,64,32,32,16,16,68,64,33,32,23,144,68,64,37,32,
	20,16,68,64,39,32,23,144,68,64,33,32,16,144,68,64,33,32,
	23,144,64,64,32,32,16,16,127,192,63,224,31,240,4,0,2,0,
	1,0,4,0,2,0,1,0,4,0,2,0,1,0,4,0,2,0,
	1,0,7,255,255,255,255,0,0,0,0,0,0,0,0,1,254,0,
	0,0,0,1,2,0,0,0,0,1,63,224,0,0,0,1,32,32,
	0,0,0,1,47,32,0,0,0,1,40,32,0,0,0,1,47,32,
	0,0,0,1,33,32,0,0,0,1,47,32,0,0,0,1,32,32,
	0,0,0,1,63,224,0,0,0,1,2,0,0,0,0,1,2,0,
	0,0,0,1,254,0,0,0,0,0,2,0,0,0,0,0,2,0,
	0,0,0,0,2,0,0,0,0,0,2,0,0,0,0,0,2,0,
	0,0,127,192,63,224,0,0,64,64,32,32,0,0,78,64,33,32,
	0,0,82,64,37,32,0,0,68,64,39,32,0,0,72,64,33,32,
	0,0,94,64,33,32,0,0,64,64,32,32,0,0,127,192,63,224,
	0,0,4,0,2,0,0,0,4,0,2,0,0,0,4,0,2,0,
	0,0,4,0,2,0,0,0,4,0,2,0,0,0,4,0,2,0,
	0,0,4,0,2,0,0,0,4,0,2,0,0,0,127,192,63,224,
	31,240,64,64,32,32,16,16,68,64,39,32,23,144,68,64,33,32,
	20,16,68,64,34,32,23,144,68,64,33,32,20,144,68,64,39,32,
	23,144,64,64,32,32,16,16,127,192,63,224,31,240,4,0,2,0,
	1,0,4,0,2,0,1,0,4,0,2,0,1,0,4,0,2,0,
	1,0,7,255,255,255,255,0,0,0,0,0,0,0,0,0,0,0,
	255,0,0,0,0,0,0,0,129,0,0,0,0,0,0,0,159,240,
	0,0,0,0,0,0,144,16,0,0,0,0,0,0,151,144,0,0,
	0,0,0,0,148,16,0,0,0,0,0,0,151,144,0,0,0,0,
	0,0,144,144,0,0,0,0,0,0,151,144,0,0,0,0,0,0,
	144,16,0,0,0,0,0,0,159,240,0,0,0,0,0,0,129,0,
	0,0,0,0,0,0,255,0,0,0,0,0,0,0,1,0,0,0,
	0,0,0,0,1,0,0,0,0,0,0,0,1,0,0,0,0,0,
	0,0,31,240,0,0,0,0,0,0,16,16,0,0,0,0,0,0,
	16,16,0,0,0,0,0,0,16,144,0,0,0,0,0,0,18,144,
	0,0,0,0,0,0,19,144,0,0,0,0,0,0,16,144,0,0,
	0,0,0,0,16,16,0,0,0,0,0,0,31,240,0,0,0,0,
	0,0,1,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,
	1,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,1,0,
	0,0,0,0,0,0,1,0,0,0,0,0,0,0,1,0,0,0,
	0,0,0,0,1,0,0,0,127,192,63,224,31,240,15,248,64,64,
	32,32,16,16,8,8,68,64,39,32,19,144,11,200,68,64,41,32,
	16,144,10,8,68,64,34,32,17,16,11,200,68,64,36,32,16,144,
	10,72,68,64,47,32,19,144,11,200,64,64,32,32,16,16,8,8,
	127,192,63,224,31,240,15,248,4,0,2,0,1,0,0,128,4,0,
	2,0,1,0,0,128,4,0,2,0,1,0,0,128,4,0,2,0,
	1,0,0,128,7,255,255,255,255,255,255,128,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,63,128,
	0,0,0,0,0,0,32,128,0,0,0,0,31,240,47,248,0,0,
	0,0,16,16,40,8,0,0,0,0,16,16,43,200,0,0,0,0,
	16,144,42,8,0,0,0,0,18,144,43,200,0,0,0,0,19,144,
	42,72,0,0,0,0,16,144,43,200,0,0,0,0,16,16,40,8,
	0,0,0,0,31,240,47,248,0,0,0,0,1,0,32,128,0,0,
	0,0,1,0,63,128,0,0,0,0,1,0,0,128,0,0,0,0,
	1,0,0,128,0,0,0,0,1,0,0,128,0,0,0,0,1,0,
	0,128,0,0,0,0,1,0,0,128,0,0,0,0,1,0,0,128,
	127,192,63,224,31,240,15,248,64,64,32,32,16,16,8,8,68,64,
	39,32,19,144,11,200,68,64,41,32,16,144,10,8,68,64,34,32,
	17,16,11,200,68,64,36,32,16,144,8,72,68,64,47,32,19,144,
	11,200,64,64,32,32,16,16,8,8,127,192,63,224,31,240,15,248,
	4,0,2,0,1,0,0,128,4,0,2,0,1,0,0,128,4,0,
	2,0,1,0,0,128,4,0,2,0,1,0,0,128,7,255,255,255,
	255,255,255,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,127,128,0,0,0,0,0,0,64,128,
	0,0,63,224,31,240,79,248,0,0,32,32,16,16,72,8,0,0,
	39,32,23,144,75,200,0,0,33,32,20,16,74,8,0,0,34,32,
	23,144,75,200,0,0,33,32,16,144,74,72,0,0,39,32,23,144,
	75,200,0,0,32,32,16,16,72,8,0,0,63,224,31,240,79,248,
	0,0,2,0,0,8,64,128,0,0,2,0,0,4,127,128,0,0,
	2,0,0,2,0,128,0,0,2,0,0,1,0,128,0,0,2,0,
	0,0,128,128,0,0,2,0,0,0,64,128,0,0,2,0,0,0,
	32,128,0,0,2,0,0,0,16,128,127,192,63,224,0,0,15,248,
	64,64,32,32,0,0,8,8,68,64,39,32,0,0,8,8,68,64,
	41,32,0,0,8,72,68,64,34,32,0,0,9,72,68,64,36,32,
	0,0,9,200,68,64,47,32,0,0,8,72,64,64,32,32,0,0,
	8,8,127,192,63,224,0,0,15,248,4,0,2,0,0,0,0,128,
	4,0,2,0,0,0,0,128,4,0,2,0,0,0,0,128,4,0,
	2,0,0,0,0,128,7,255,255,255,255,255,255,128,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,3,252,0,0,
	0,0,0,0,2,4,0,0,0,0,0,0,63,228,31,240,15,248,
	0,0,32,36,16,16,8,8,0,0,39,36,23,144,11,200,0,0,
	33,36,20,16,10,8,0,0,34,36,23,144,11,200,0,0,33,36,
	16,144,10,72,0,0,39,36,23,144,11,200,0,0,32,36,16,16,
	8,8,0,0,63,228,31,240,15,248,0,0,2,4,0,8,0,128,
	0,0,2,4,0,4,0,128,0,0,3,252,0,2,0,128,0,0,
	2,0,0,1,0,128,0,0,2,0,0,0,128,128,0,0,2,0,
	0,0,64,128,0,0,2,0,0,0,32,128,0,0,2,0,0,0,
	16,128,127,192,63,224,0,0,15,248,64,64,32,32,0,0,8,8,
	68,64,39,32,0,0,8,8,68,64,41,32,0,0,8,72,68,64,
	34,32,0,0,9,72,68,64,36,32,0,0,9,200,68,64,47,32,
	0,0,8,72,64,64,32,32,0,0,8,8,127,192,63,224,0,0,
	15,248,4,0,2,0,0,0,0,128,4,0,2,0,0,0,0,128,
	4,0,2,0,0,0,0,128,4,0,2,0,0,0,0,128,7,255,
	255,255,255,255,255,128,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,255,0,0,0,0,0,0,
	0,0,0,129,0,0,0,0,0,0,0,0,15,249,0,0,0,0,
	0,0,0,0,8,9,0,0,0,0,0,0,0,0,11,201,0,0,
	0,0,0,0,0,0,10,9,0,0,0,0,0,0,0,0,11,201,
	0,0,0,0,0,0,0,0,10,73,0,0,0,0,0,0,0,0,
	11,201,0,0,0,0,0,0,0,0,8,9,0,0,0,0,0,0,
	0,0,15,249,0,0,0,0,0,0,0,0,16,133,0,0,0,0,
	0,0,0,0,32,131,0,0,0,0,0,0,0,0,64,129,0,0,
	0,0,0,0,0,0,128,128,128,0,0,0,0,0,0,1,0,128,
	64,0,0,0,0,0,0,2,0,128,32,0,0,0,0,0,0,4,
	0,128,16,0,0,0,0,0,0,8,0,128,8,0,127,192,63,224,
	31,240,15,248,7,252,64,64,32,32,16,16,8,8,4,4,68,64,
	39,32,19,144,8,8,5,228,68,64,41,32,16,144,8,72,5,4,
	68,64,34,32,17,16,9,72,5,228,68,64,36,32,16,144,9,200,
	4,36,68,64,47,32,19,144,8,72,5,228,64,64,32,32,16,16,
	8,8,4,4,127,192,63,224,31,240,15,248,7,252,4,0,2,0,
	1,0,0,128,0,64,4,0,2,0,1,0,0,128,0,64,4,0,
	2,0,1,0,0,128,0,64,4,0,2,0,1,0,0,128,0,64,
	7,255,255,255,255,255,255,255,255,192,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,255,0,0,0,0,0,0,0,0,0,129,0,0,0,0,0,0,
	0,0,15,249,0,0,0,0,0,0,0,0,8,9,0,0,0,0,
	0,0,0,0,11,201,0,0,0,0,0,0,0,0,10,9,0,0,
	0,0,0,0,0,0,11,201,0,0,0,0,0,0,0,0,10,73,
	0,0,0,0,0,0,0,0,11,201,0,0,0,0,0,0,0,0,
	8,9,0,0,0,0,0,0,0,0,15,249,0,0,0,0,0,0,
	0,0,0,133,0,0,0,0,0,0,0,0,0,131,0,0,0,0,
	0,0,0,0,0,129,0,0,0,0,0,0,0,0,0,128,128,0,
	0,0,0,0,0,0,0,128,64,0,0,0,0,0,0,0,0,128,
	32,0,0,0,0,0,0,0,0,128,16,0,0,0,0,0,0,0,
	0,128,8,0,127,192,63,224,31,240,15,248,7,252,64,64,32,32,
	16,16,8,8,4,4,68,64,39,32,19,144,8,8,5,228,68,64,
	41,32,16,144,8,72,5,4,68,64,34,32,17,16,9,72,5,228,
	68,64,36,32,16,144,9,200,4,36,68,64,47,32,19,144,8,72,
	5,228,64,64,32,32,16,16,8,8,4,4,127,192,63,224,31,240,
	15,248,7,252,4,0,2,0,1,0,0,128,0,64,4,0,2,0,
	1,0,0,128,0,64,4,0,2,0,1,0,0,128,0,64,4,0,
	2,0,1,0,0,128,0,64,7,255,255,255,255,255,255,255,255,192,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,31,192,0,0,0,0,0,0,
	0,0,16,64,0,0,0,0,0,0,0,0,23,252,0,0,0,0,
	0,0,0,0,20,4,0,0,0,0,0,0,0,0,21,228,0,0,
	0,0,0,0,0,0,21,4,0,0,0,0,0,0,0,0,21,228,
	0,0,0,0,0,0,0,0,21,36,0,0,0,0,0,0,0,0,
	21,228,0,0,0,0,0,0,0,0,20,4,0,0,0,0,0,0,
	0,0,23,252,0,0,0,0,0,0,0,0,16,64,0,0,0,0,
	0,0,0,0,16,64,0,0,0,0,0,0,0,0,31,192,0,0,
	0,0,0,0,0,0,0,64,0,0,0,0,0,0,0,0,0,64,
	0,0,0,0,0,0,0,0,0,64,0,0,0,0,0,0,0,0,
	0,64,0,0,0,0,0,0,0,0,0,64,127,192,63,224,31,240,
	15,248,7,252,64,64,32,32,16,16,8,8,4,4,68,64,39,32,
	19,144,8,8,5,228,68,64,41,32,16,144,8,72,5,4,68,64,
	34,32,17,16,9,72,5,228,68,64,36,32,16,144,9,200,4,36,
	68,64,47,32,19,144,8,72,5,228,64,64,32,32,16,16,8,8,
	4,4,127,192,63,224,31,240,15,248,7,252,4,0,2,0,1,0,
	0,128,0,64,4,0,2,0,1,0,0,128,0,64,4,0,2,0,
	1,0,0,128,0,64,4,0,2,0,1,0,0,128,0,64,7,255,
	255,255,255,255,255,255,255,192,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,254,0,0,
	0,0,0,0,1,2,0,0,0,0,63,224,31,242,0,0,0,0,
	32,32,16,18,0,0,0,0,39,32,23,146,0,0,0,0,33,32,
	20,18,0,0,0,0,34,32,23,146,0,0,0,0,33,32,20,146,
	0,0,0,0,39,32,23,146,0,0,0,0,32,32,16,18,0,0,
	0,0,63,224,31,242,0,0,0,0,2,0,1,10,0,0,0,0,
	2,0,1,6,0,0,0,0,2,0,1,2,0,0,0,0,2,0,
	1,1,0,0,0,0,2,0,1,0,128,0,0,0,2,0,1,0,
	64,0,0,0,2,0,1,0,32,0,0,0,2,0,1,0,16,0,
	127,192,63,224,31,240,15,248,64,64,32,32,16,16,8,8,68,64,
	39,32,16,16,11,200,68,64,41,32,16,144,10,8,68,64,34,32,
	18,144,11,200,68,64,36,32,19,144,8,72,68,64,47,32,16,144,
	11,200,64,64,32,32,16,16,8,8,127,192,63,224,31,240,15,248,
	4,0,2,0,1,0,0,128,4,0,2,0,1,0,0,128,4,0,
	2,0,1,0,0,128,4,0,2,0,1,0,0,128,7,255,255,255,
	255,255,255,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,1,254,0,0,0,0,0,0,1,2,0,0,
	127,192,0,0,31,242,0,0,64,64,0,0,16,18,0,0,78,64,
	0,0,23,146,0,0,66,64,0,0,20,18,0,0,68,64,0,0,
	23,146,0,0,66,64,0,0,20,146,0,0,78,64,0,0,23,146,
	0,0,64,64,0,0,16,18,0,0,127,192,0,0,31,242,0,0,
	4,0,0,0,33,10,0,0,4,0,0,0,65,6,0,0,4,0,
	0,0,129,2,0,0,4,0,0,1,1,1,0,0,4,0,0,2,
	1,0,128,0,4,0,0,4,1,0,64,0,4,0,0,8,1,0,
	32,0,4,0,0,16,1,0,16,0,127,192,63,224,31,240,15,248,
	64,64,32,32,16,16,8,8,68,64,39,32,16,16,11,200,68,64,
	41,32,16,144,10,8,68,64,34,32,18,144,11,200,68,64,36,32,
	19,144,8,72,68,64,47,32,16,144,11,200,64,64,32,32,16,16,
	8,8,127,192,63,224,31,240,15,248,4,0,2,0,1,0,0,128,
	4,0,2,0,1,0,0,128,4,0,2,0,1,0,0,128,4,0,
	2,0,1,0,0,128,7,255,255,255,255,255,255,128,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,7,248,0,0,0,0,
	0,0,4,8,0,0,0,0,0,0,127,200,0,0,31,240,0,0,
	64,72,0,0,16,16,0,0,78,72,0,0,23,144,0,0,66,72,
	0,0,20,16,0,0,68,72,0,0,23,144,0,0,66,72,0,0,
	20,144,0,0,78,72,0,0,23,144,0,0,64,72,0,0,16,16,
	0,0,127,200,0,0,31,240,0,0,4,40,0,0,1,8,0,0,
	4,24,0,0,1,4,0,0,4,8,0,0,1,2,0,0,4,4,
	0,0,1,1,0,0,4,2,0,0,1,0,128,0,4,1,0,0,
	1,0,64,0,4,0,128,0,1,0,32,0,4,0,64,0,1,0,
	16,0,127,192,63,224,31,240,15,248,64,64,32,32,16,16,8,8,
	68,64,39,32,16,16,11,200,68,64,41,32,16,144,10,8,68,64,
	34,32,18,144,11,200,68,64,36,32,19,144,8,72,68,64,47,32,
	16,144,11,200,64,64,32,32,16,16,8,8,127,192,63,224,31,240,
	15,248,4,0,2,0,1,0,0,128,4,0,2,0,1,0,0,128,
	4,0,2,0,1,0,0,128,4,0,2,0,1,0,0,128,7,255,
	255,255,255,255,255,128,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,1,254,0,0,0,0,0,0,1,2,
	0,0,127,192,63,224,31,242,15,248,64,64,32,32,16,18,8,8,
	66,64,47,32,23,146,9,200,74,64,40,32,20,18,10,72,78,64,
	47,32,23,146,8,136,66,64,33,32,20,146,9,8,64,64,47,32,
	23,146,11,200,64,64,32,32,16,18,8,8,127,192,63,224,31,242,
	15,248,0,32,2,0,32,2,0,128,0,16,2,0,127,254,0,128,
	0,8,2,0,128,0,0,128,0,4,2,1,0,0,0,128,0,2,
	2,2,0,0,0,128,0,1,2,4,0,0,0,128,0,0,130,8,
	0,0,0,128,0,0,66,16,0,0,0,128,0,0,63,224,0,0,
	15,248,0,0,32,32,0,0,8,8,0,0,39,32,0,0,8,136,
	0,0,33,32,0,0,8,136,0,0,34,32,0,0,8,136,0,0,
	33,32,0,0,8,136,0,0,39,32,0,0,8,136,0,0,32,32,
	0,0,8,8,0,0,63,224,0,0,15,248,0,0,2,0,0,0,
	0,128,0,0,2,0,0,0,0,128,0,0,2,0,0,0,0,128,
	0,0,2,0,0,0,0,128,0,0,3,255,255,255,255,128,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,127,128,0,0,0,0,0,0,64,128,127,192,63,224,31,240,
	79,248,64,64,32,32,16,16,72,8,66,64,47,32,23,144,73,200,
	74,64,40,32,20,16,74,72,78,64,47,32,23,144,72,136,66,64,
	33,32,20,144,73,8,64,64,47,32,23,144,75,200,64,64,32,32,
	16,16,72,8,127,192,63,224,31,240,79,248,0,32,2,0,32,0,
	64,128,0,16,2,0,64,0,64,128,0,8,2,0,128,0,127,128,
	0,4,2,1,0,0,0,128,0,2,2,2,0,0,0,128,0,1,
	2,4,0,0,0,128,0,0,130,8,0,0,0,128,0,0,66,16,
	0,0,0,128,0,0,63,224,0,0,15,248,0,0,32,32,0,0,
	8,8,0,0,39,32,0,0,8,136,0,0,33,32,0,0,8,136,
	0,0,34,32,0,0,8,136,0,0,33,32,0,0,8,136,0,0,
	39,32,0,0,8,136,0,0,32,32,0,0,8,8,0,0,63,224,
	0,0,15,248,0,0,2,0,0,0,0,128,0,0,2,0,0,0,
	0,128,0,0,2,0,0,0,0,128,0,0,2,0,0,0,0,128,
	0,0,3,255,255,255,255,128,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,255,0,0,0,0,0,129,0,
	0,0,0,0,159,240,0,0,0,0,144,16,0,0,0,0,151,144,
	0,0,0,0,148,16,0,0,0,0,151,144,0,0,0,0,148,144,
	0,0,0,0,151,144,0,0,0,0,144,16,0,0,0,0,159,240,
	0,0,0,0,129,0,0,0,0,0,129,0,0,0,0,0,255,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,127,192,63,224,31,240,
	64,64,32,32,16,16,78,64,33,32,23,144,82,64,37,32,20,16,
	68,64,39,32,23,144,72,64,33,32,16,144,94,64,33,32,23,144,
	64,64,32,32,16,16,127,192,63,224,31,240,4,0,2,0,32,0,
	4,0,2,0,64,0,4,0,2,0,128,0,4,0,2,1,0,0,
	4,0,2,2,0,0,4,0,2,4,0,0,4,0,2,8,0,0,
	4,0,2,16,0,0,127,192,63,224,0,0,64,64,32,32,0,0,
	68,64,39,32,0,0,68,64,33,32,0,0,68,64,34,32,0,0,
	68,64,33,32,0,0,68,64,39,32,0,0,64,64,32,32,0,0,
	127,192,63,224,0,0,4,0,2,0,0,0,4,0,2,0,0,0,
	4,0,2,0,0,0,4,0,2,0,0,0,7,255,254,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,31,240,0,0,0,0,16,16,0,0,0,0,23,144,
	0,0,0,0,20,16,0,0,0,0,23,144,0,0,0,0,20,144,
	0,0,0,0,23,144,0,0,0,0,16,16,0,0,0,0,31,240,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,1,254,0,1,0,0,1,2,0,1,0,127,193,63,224,31,240,
	64,65,32,32,16,16,78,65,33,32,23,144,82,65,37,32,20,16,
	68,65,39,32,23,144,72,65,33,32,16,144,94,65,33,32,23,144,
	64,65,32,32,16,16,127,193,63,224,31,240,4,1,2,0,32,0,
	4,1,2,0,64,0,4,1,254,0,128,0,4,0,2,1,0,0,
	4,0,2,2,0,0,4,0,2,4,0,0,4,0,2,8,0,0,
	4,0,2,16,0,0,127,192,63,224,0,0,64,64,32,32,0,0,
	68,64,39,32,0,0,68,64,33,32,0,0,68,64,34,32,0,0,
	68,64,33,32,0,0,68,64,39,32,0,0,64,64,32,32,0,0,
	127,192,63,224,0,0,4,0,2,0,0,0,4,0,2,0,0,0,
	4,0,2,0,0,0,4,0,2,0,0,0,7,255,254,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,31,240,0,0,0,0,16,16,0,0,0,0,23,144,
	0,0,0,0,20,16,0,0,0,0,23,144,0,0,0,0,20,144,
	0,0,0,0,23,144,0,0,0,0,16,16,0,0,0,0,31,240,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	7,248,0,0,1,0,4,8,0,0,1,0,127,200,63,224,31,240,
	64,72,32,32,16,16,78,72,33,32,23,144,82,72,37,32,20,16,
	68,72,39,32,23,144,72,72,33,32,16,144,94,72,33,32,23,144,
	64,72,32,32,16,16,127,200,63,224,31,240,4,8,2,0,32,0,
	4,8,2,0,64,0,7,248,2,0,128,0,4,0,2,1,0,0,
	4,0,2,2,0,0,4,0,2,4,0,0,4,0,2,8,0,0,
	4,0,2,16,0,0,127,192,63,224,0,0,64,64,32,32,0,0,
	68,64,39,32,0,0,68,64,33,32,0,0,68,64,34,32,0,0,
	68,64,33,32,0,0,68,64,39,32,0,0,64,64,32,32,0,0,
	127,192,63,224,0,0,4,0,2,0,0,0,4,0,2,0,0,0,
	4,0,2,0,0,0,4,0,2,0,0,0,7,255,254,0,0,0,
	0,0,0,0,0,0,0,0,0,0,255,0,0,0,0,0,129,0,
	0,0,0,0,159,240,0,0,0,0,144,16,0,0,0,0,147,144,
	0,0,0,0,144,144,0,0,0,0,145,16,0,0,0,0,144,144,
	0,0,0,0,147,144,0,0,0,0,144,16,0,0,0,0,159,240,
	0,0,0,0,129,0,0,0,0,0,129,0,0,0,0,0,255,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,127,192,63,224,31,240,
	64,64,32,32,16,16,94,64,47,32,19,144,80,64,40,32,20,144,
	94,64,47,32,17,16,66,64,41,32,18,16,94,64,47,32,23,144,
	64,64,32,32,16,16,127,192,63,224,31,240,0,32,2,0,1,0,
	0,16,2,0,1,0,0,8,2,0,1,0,0,4,2,0,1,0,
	0,2,2,0,1,0,0,1,2,0,1,0,0,0,130,0,1,0,
	0,0,66,0,1,0,0,0,63,224,31,240,0,0,32,32,16,16,
	0,0,33,32,17,16,0,0,37,32,17,16,0,0,39,32,17,16,
	0,0,33,32,17,16,0,0,33,32,17,16,0,0,32,32,16,16,
	0,0,63,224,31,240,0,0,2,0,1,0,0,0,2,0,1,0,
	0,0,2,0,1,0,0,0,3,255,255,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,31,240,0,0,0,0,16,16,0,0,0,0,19,144,
	0,0,0,0,16,144,0,0,0,0,17,16,0,0,0,0,16,144,
	0,0,0,0,19,144,0,0,0,0,16,16,0,0,0,0,31,240,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,3,252,1,0,
	0,0,2,4,1,0,0,0,2,4,1,0,127,192,63,228,31,240,
	64,64,32,36,16,16,94,64,47,36,19,144,80,64,40,36,20,144,
	94,64,47,36,17,16,66,64,41,36,18,16,94,64,47,36,23,144,
	64,64,32,36,16,16,127,192,63,228,31,240,0,32,2,4,1,0,
	0,16,2,4,1,0,0,8,3,252,1,0,0,4,2,0,1,0,
	0,2,2,0,1,0,0,1,2,0,1,0,0,0,130,0,1,0,
	0,0,66,0,1,0,0,0,63,224,31,240,0,0,32,32,16,16,
	0,0,33,32,17,16,0,0,37,32,17,16,0,0,39,32,17,16,
	0,0,33,32,17,16,0,0,33,32,17,16,0,0,32,32,16,16,
	0,0,63,224,31,240,0,0,2,0,1,0,0,0,2,0,1,0,
	0,0,2,0,1,0,0,0,3,255,255,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,63,224,31,240,0,0,32,32,16,16,0,0,33,32,23,144,
	0,0,37,32,20,16,0,0,39,32,23,144,0,0,33,32,20,144,
	0,0,33,32,23,144,0,0,32,32,16,16,0,0,63,224,31,240,
	0,0,2,0,1,0,0,0,2,0,1,0,0,0,2,0,1,0,
	0,0,2,0,1,0,0,0,2,0,1,0,7,252,2,0,1,0,
	4,4,2,0,1,0,4,4,2,0,1,0,127,196,63,224,31,240,
	64,68,32,32,16,16,78,68,39,32,23,144,82,68,33,32,20,16,
	68,68,34,32,23,144,72,68,33,32,16,144,94,68,39,32,23,144,
	64,68,32,32,16,16,127,196,63,224,31,240,0,36,2,0,32,0,
	0,20,2,0,64,0,0,12,2,0,128,0,0,4,2,1,0,0,
	0,2,2,2,0,0,0,1,2,4,0,0,0,0,130,8,0,0,
	0,0,66,16,0,0,0,0,63,224,0,0,0,0,32,32,0,0,
	0,0,34,32,0,0,0,0,34,32,0,0,0,0,34,32,0,0,
	0,0,34,32,0,0,0,0,34,32,0,0,0,0,32,32,0,0,
	0,0,63,224,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,255,0,0,0,0,0,129,0,
	0,0,63,224,159,240,0,0,32,32,144,16,0,0,33,32,151,144,
	0,0,37,32,148,16,0,0,39,32,151,144,0,0,33,32,148,144,
	0,0,33,32,151,144,0,0,32,32,144,16,0,0,63,224,159,240,
	0,0,2,0,129,0,0,0,2,0,129,0,0,0,2,0,255,0,
	0,0,2,0,1,0,0,0,2,0,1,0,0,0,2,0,1,0,
	0,0,2,0,1,0,0,0,2,0,1,0,127,192,63,224,31,240,
	64,64,32,32,16,16,78,64,39,32,23,144,82,64,33,32,20,16,
	68,64,34,32,23,144,72,64,33,32,16,144,94,64,39,32,23,144,
	64,64,32,32,16,16,127,192,63,224,31,240,0,32,2,0,32,0,
	0,16,2,0,64,0,0,8,2,0,128,0,0,4,2,1,0,0,
	0,2,2,2,0,0,0,1,2,4,0,0,0,0,130,8,0,0,
	0,0,66,16,0,0,0,0,63,224,0,0,0,0,32,32,0,0,
	0,0,34,32,0,0,0,0,34,32,0,0,0,0,34,32,0,0,
	0,0,34,32,0,0,0,0,34,32,0,0,0,0,32,32,0,0,
	0,0,63,224,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,31,240,0,0,0,0,16,16,
	0,0,0,0,23,144,0,0,0,0,20,16,0,0,0,0,23,144,
	0,0,0,0,20,144,0,0,0,0,23,144,0,0,0,0,16,16,
	0,0,0,0,31,240,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,31,240,0,0,0,0,16,16,0,0,0,0,23,144,
	0,0,0,0,20,16,0,0,0,0,23,144,0,0,0,0,16,144,
	0,0,0,0,23,144,0,0,0,0,16,16,0,0,0,0,31,240,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,0,0,0,1,0,0,0,0,0,1,0,0,0,0,0,1,0,
	0,1,254,0,1,0,0,1,2,0,1,0,127,193,63,224,31,240,
	64,65,32,32,16,16,78,65,39,32,16,144,82,65,33,32,18,144,
	68,65,34,32,19,144,72,65,33,32,16,144,94,65,39,32,16,144,
	64,65,32,32,16,16,127,193,63,224,31,240,0,33,2,0,32,0,
	0,17,254,0,64,0,0,8,2,0,128,0,0,4,2,1,0,0,
	0,2,2,2,0,0,0,1,2,4,0,0,0,0,130,8,0,0,
	0,0,66,16,0,0,0,0,63,224,0,0,0,0,32,32,0,0,
	0,0,34,32,0,0,0,0,34,32,0,0,0,0,34,32,0,0,
	0,0,34,32,0,0,0,0,34,32,0,0,0,0,32,32,0,0,
	0,0,63,224,0,0,0,0,0,0,0,0,7,252,0,0,0,0,
	4,4,0,0,0,0,127,196,63,224,31,240,64,68,32,32,16,16,
	78,68,47,32,23,144,66,68,40,32,20,16,68,68,47,32,23,144,
	66,68,33,32,20,144,78,68,47,32,23,144,64,68,32,32,16,16,
	127,196,63,224,31,240,4,36,2,0,1,0,4,20,2,0,1,0,
	4,12,2,0,1,0,4,4,2,0,1,0,4,2,2,0,1,0,
	4,1,2,0,1,0,4,0,130,0,1,0,4,0,66,0,1,0,
	127,192,63,224,31,240,64,64,32,32,16,16,68,64,39,32,16,144,
	68,64,41,32,18,144,68,64,34,32,19,144,68,64,36,32,16,144,
	68,64,47,32,16,16,64,64,32,32,16,16,127,192,63,224,31,240,
	4,0,2,0,1,0,4,0,2,0,1,0,4,0,2,0,1,0,
	4,0,2,0,1,0,7,255,255,255,255,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,1,255,0,0,1,
	1,0,0,1,1,0,127,193,31,240,64,65,16,16,78,65,23,144,
	66,65,20,16,68,65,23,144,66,65,20,144,78,65,23,144,64,65,
	16,16,127,193,31,240,4,1,1,0,4,1,255,0,4,0,1,0,
	127,192,31,240,64,64,16,16,78,64,23,144,82,64,20,16,68,64,
	23,144,72,64,16,144,94,64,23,144,64,64,16,16,127,192,31,240,
	4,0,1,0,4,0,1,0,4,0,1,0,127,192,31,240,64,64,
	16,16,68,64,16,144,68,64,18,144,68,64,19,144,68,64,16,144,
	68,64,16,16,64,64,16,16,127,192,31,240,4,0,1,0,7,255,
	255,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,31,240,0,0,16,16,
	0,0,23,144,0,0,20,16,0,0,23,144,0,0,20,144,0,0,
	23,144,0,0,16,16,0,0,31,240,0,0,1,0,0,0,1,0,
	0,0,1,0,0,0,31,240,0,0,16,16,0,0,23,144,0,0,
	20,16,0,0,23,144,0,0,16,144,0,0,23,144,0,0,16,16,
	0,0,31,240,0,0,1,0,7,240,1,0,4,16,1,0,127,208,
	31,240,64,80,16,16,78,80,16,144,82,80,18,144,68,80,19,144,
	72,80,16,144,94,80,16,144,64,80,16,16,127,208,31,240,4,16,
	1,0,7,240,1,0,4,0,1,0,127,192,31,240,64,64,16,16,
	68,64,19,144,68,64,16,144,68,64,17,16,68,64,16,144,68,64,
	19,144,64,64,16,16,127,192,31,240,4,0,1,0,7,255,255,0,
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,1,255,0,0,1,1,0,
	0,1,1,0,0,1,31,240,0,1,16,16,0,1,23,144,0,1,
	20,16,0,1,23,144,0,1,20,144,0,1,23,144,0,1,16,16,
	0,1,31,240,0,1,1,0,0,1,255,0,0,0,1,0,0,0,
	31,240,0,0,16,16,0,0,23,144,0,0,20,16,0,0,23,144,
	0,0,16,144,0,0,23,144,0,0,16,16,0,0,31,240,0,0,
	1,0,0,0,1,0,0,0,1,0,127,192,31,240,64,64,16,16,
	78,64,16,144,82,64,18,144,68,64,19,144,72,64,16,144,94,64,
	16,144,64,64,16,16,127,192,31,240,4,0,1,0,4,0,1,0,
	4,0,1,0,127,192,31,240,64,64,16,16,68,64,19,144,68,64,
	16,144,68,64,17,16,68,64,16,144,68,64,19,144,64,64,16,16,
	127,192,31,240,4,0,1,0,7,255,255,0,0,0,0,0,0,0,
	0,0,0,0,0,0,0,0,255,0,0,0,0,0,129,0,127,192,
	63,224,159,240,64,64,32,32,144,16,78,64,33,32,151,144,82,64,
	37,32,148,16,68,64,39,32,151,144,72,64,33,32,148,144,94,64,
	32,32,151,144,64,64,32,32,144,16,127,192,63,224,159,240,4,0,
	2,0,129,0,4,0,2,0,129,0,4,0,2,0,129,0,4,0,
	2,0,255,0,4,0,2,0,1,0,4,0,2,0,1,0,4,0,
	2,0,1,0,4,0,2,0,1,0,4,0,2,0,1,0,127,192,
	63,224,31,240,64,64,32,32,16,16,68,64,39,32,23,144,68,64,
	33,32,20,16,68,64,34,32,23,144,68,64,33,32,16,144,68,64,
	39,32,23,144,64,64,32,32,16,16,127,192,63,224,31,240,4,0,
	2,0,1,0,4,0,2,0,1,0,7,255,255,255,255,0,0,0,
	0,0,0,0,0,0,0,0,0,0,0,0,14,138,0,4,0,46,
	0,0,0,0,0,1,0,0,15,66,0,4,0,46,0,0,0,0,
	0,1,0,0,15,250,0,6,0,35,0,0,0,0,0,1,0,0,
	16,204,0,4,0,46,0,0,0,0,0,1,0,0,17,132,0,12,
	0,19,0,0,0,0,0,1,0,0,18,104,0,6,0,51,0,0,
	0,0,0,1,0,0,19,154,0,6,0,51,0,0,0,0,0,1,
	0,0,20,204,0,8,0,49,0,0,0,0,0,1,0,0,22,84,
	0,8,0,35,0,0,0,0,0,1,0,0,23,108,0,8,0,35,
	0,0,0,0,0,1,0,0,24,132,0,8,0,35,0,0,0,0,
	0,1,0,0,25,156,0,10,0,35,0,0,0,0,0,1,0,0,
	26,250,0,10,0,35,0,0,0,0,0,1,0,0,28,88,0,10,
	0,35,0,0,0,0,0,1,0,0,29,182,0,8,0,35,0,0,
	0,0,0,1,0,0,30,206,0,8,0,35,0,0,0,0,0,1,
	0,0,31,230,0,8,0,35,0,0,0,0,0,1,0,0,32,254,
	0,8,0,35,0,0,0,0,0,1,0,0,34,22,0,8,0,35,
	0,0,0,0,0,1,0,0,35,46,0,6,0,51,0,0,0,0,
	0,1,0,0,36,96,0,6,0,51,0,0,0,0,0,1,0,0,
	37,146,0,6,0,51,0,0,0,0,0,1,0,0,38,196,0,6,
	0,51,0,0,0,0,0,1,0,0,39,246,0,6,0,51,0,0,
	0,0,0,1,0,0,41,40,0,6,0,51,0,0,0,0,0,1,
	0,0,42,90,0,6,0,51,0,0,0,0,0,1,0,0,43,140,
	0,6,0,64,0,0,0,0,0,1,0,0,45,12,0,6,0,35,
	0,0,0,0,0,1,0,0,45,222,0,4,0,46,0,0,0,0,
	0,1,0,0,46,150,0,4,0,57,0,0,0,0,0,1,0,0,
	47,122,0,4,0,57,0,0,0,0,0,1,0,0,48,94,0,6,
	0,35,0,0,0,0,0,1,0,0,5,39,0,0,0,0,0,0,
	5,60,0,3,0,6,0,2,17,161,0,0,0,255,0,21,0,1,
	0,0,11,105,0,0,11,116,0,0,11,138,0,3,0,6,0,0,
	17,128,0,0,0,255,0,11,0,22,255,255,0,1,0,44,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,54,0,23,0,2,
	255,255,255,255,0,28,0,0,0,0,0,0,0,36,0,15,0,1,
	0,28,0,1,0,35,0,3,0,34,0,20,0,0,0,0,0,255,
	17,0,0,3,0,3,0,30,0,18,0,4,255,255,255,255,0,28,
	0,64,0,0,0,0,0,65,0,2,0,3,0,10,0,1,0,5,
	255,255,255,255,0,28,0,64,0,0,0,0,0,76,0,2,0,4,
	0,10,0,1,0,6,255,255,255,255,0,28,0,64,0,0,0,0,
	0,87,0,2,0,5,0,10,0,1,0,7,255,255,255,255,0,28,
	0,64,0,0,0,0,0,98,0,2,0,6,0,10,0,1,0,8,
	255,255,255,255,0,28,0,64,0,0,0,0,0,109,0,2,0,7,
	0,10,0,1,0,9,255,255,255,255,0,28,0,64,0,0,0,0,
	0,120,0,2,0,8,0,10,0,1,0,10,255,255,255,255,0,28,
	0,64,0,0,0,0,0,131,0,2,0,9,0,10,0,1,0,11,
	255,255,255,255,0,28,0,64,0,0,0,0,0,142,0,2,0,10,
	0,10,0,1,0,12,255,255,255,255,0,28,0,64,0,0,0,0,
	0,153,0,2,0,11,0,10,0,1,0,13,255,255,255,255,0,28,
	0,64,0,0,0,0,0,164,0,2,0,12,0,10,0,1,0,14,
	255,255,255,255,0,28,0,64,0,0,0,0,0,175,0,2,0,13,
	0,10,0,1,0,15,255,255,255,255,0,28,0,64,0,0,0,0,
	0,186,0,2,0,14,0,10,0,1,0,16,255,255,255,255,0,28,
	0,64,0,0,0,0,0,197,0,2,0,15,0,10,0,1,0,17,
	255,255,255,255,0,28,0,64,0,0,0,0,0,208,0,2,0,16,
	0,10,0,1,0,18,255,255,255,255,0,28,0,64,0,0,0,0,
	0,219,0,16,0,1,0,10,0,1,0,19,255,255,255,255,0,28,
	0,64,0,0,0,0,0,230,0,16,0,2,0,10,0,1,0,20,
	255,255,255,255,0,28,0,64,0,0,0,0,0,241,0,16,0,3,
	0,10,0,1,0,21,255,255,255,255,0,28,0,64,0,0,0,0,
	0,252,0,16,0,4,0,10,0,1,0,22,255,255,255,255,0,28,
	0,64,0,0,0,0,1,7,0,16,0,7,0,10,0,1,0,23,
	255,255,255,255,0,28,0,64,0,0,0,0,1,18,0,16,0,8,
	0,10,0,1,0,24,255,255,255,255,0,28,0,64,0,0,0,0,
	1,29,0,16,0,9,0,10,0,1,0,25,255,255,255,255,0,28,
	0,64,0,0,0,0,1,40,0,16,0,10,0,10,0,1,0,26,
	255,255,255,255,0,28,0,64,0,0,0,0,1,51,0,16,0,11,
	0,10,0,1,0,27,255,255,255,255,0,28,0,64,0,0,0,0,
	1,62,0,16,0,12,0,10,0,1,0,28,255,255,255,255,0,28,
	0,64,0,0,0,0,1,73,0,16,0,13,0,10,0,1,0,29,
	255,255,255,255,0,28,0,64,0,0,0,0,1,84,0,16,0,15,
	0,10,0,1,0,30,255,255,255,255,0,28,0,64,0,0,0,0,
	1,95,0,16,0,16,0,10,0,1,0,31,255,255,255,255,0,28,
	0,64,0,0,0,0,1,106,0,2,0,2,0,10,0,1,0,32,
	255,255,255,255,0,28,0,64,0,0,0,0,1,117,0,16,0,6,
	0,10,0,1,0,33,255,255,255,255,0,28,0,64,0,0,0,0,
	1,128,0,2,0,1,0,10,0,1,0,34,255,255,255,255,0,28,
	0,64,0,0,0,0,1,139,0,16,0,5,0,10,0,1,0,2,
	255,255,255,255,0,28,0,64,0,0,0,0,1,150,0,16,0,14,
	0,10,0,1,0,36,255,255,255,255,0,26,0,65,0,0,0,0,
	1,161,0,39,0,4,0,8,0,1,0,37,255,255,255,255,0,26,
	0,65,0,0,0,0,1,166,0,39,0,8,0,12,0,1,0,38,
	255,255,255,255,0,26,0,65,0,0,0,0,1,176,0,39,0,10,
	0,8,0,1,0,39,255,255,255,255,0,26,0,65,0,0,0,0,
	1,181,0,39,0,6,0,12,0,1,0,40,255,255,255,255,0,28,
	0,0,0,0,0,0,1,192,0,36,0,12,0,17,0,1,0,41,
	255,255,255,255,0,28,0,0,0,0,0,0,1,210,0,36,0,13,
	0,17,0,1,0,42,255,255,255,255,0,28,0,0,0,0,0,0,
	1,228,0,36,0,14,0,17,0,1,0,43,255,255,255,255,0,28,
	0,0,0,0,0,0,1,246,0,36,0,15,0,17,0,1,0,44,
	255,255,255,255,0,28,0,0,0,0,0,0,2,8,0,36,0,16,
	0,13,0,1,0,0,255,255,255,255,0,28,0,32,0,0,0,0,
	2,22,0,36,0,17,0,6,0,1,255,255,0,1,0,30,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,52,0,18,0,2,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,6,0,10,
	0,2,0,1,0,3,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,34,0,10,0,2,0,1,0,4,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,27,0,10,0,2,0,1,0,5,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,20,0,10,
	0,2,0,1,0,6,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,41,0,10,0,2,0,1,0,7,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,13,0,10,0,2,0,1,0,9,
	0,8,0,8,0,20,0,64,0,0,0,255,17,17,0,6,0,5,
	0,2,0,5,0,7,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,11,0,10,0,10,0,20,
	0,64,0,0,0,255,17,17,0,13,0,5,0,2,0,5,0,9,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,13,0,12,0,12,0,20,0,64,0,0,0,255,
	17,17,0,20,0,5,0,2,0,5,0,11,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,15,
	0,14,0,14,0,20,0,64,0,0,0,255,17,17,0,27,0,5,
	0,2,0,5,0,13,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,17,0,16,0,16,0,20,
	0,64,0,0,0,255,17,17,0,34,0,5,0,2,0,5,0,15,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,19,0,18,0,18,0,20,0,64,0,0,0,255,
	17,17,0,41,0,5,0,2,0,5,0,17,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,20,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,6,0,4,
	0,2,0,1,0,21,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,13,0,4,0,2,0,1,0,22,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,20,0,4,0,2,0,1,0,23,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,27,0,4,
	0,2,0,1,0,24,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,34,0,4,0,2,0,1,0,25,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,41,0,4,0,2,0,1,0,26,
	255,255,255,255,0,28,0,0,0,0,0,0,2,29,0,43,0,1,
	0,1,0,1,0,27,255,255,255,255,0,28,0,0,0,0,0,0,
	2,31,0,5,0,1,0,32,0,1,0,28,255,255,255,255,0,28,
	0,0,0,0,0,0,2,64,0,37,0,1,0,4,0,1,0,36,
	0,29,0,29,0,20,0,0,0,0,0,255,17,0,0,41,0,12,
	0,2,0,1,0,28,255,255,255,255,0,28,0,0,0,0,0,0,
	2,69,0,0,0,0,0,2,0,1,0,0,0,31,0,31,0,20,
	0,0,0,0,0,255,17,0,0,33,0,12,0,4,0,1,0,30,
	255,255,255,255,0,28,0,32,0,0,0,0,2,130,0,0,0,0,
	0,4,0,1,0,30,0,33,0,33,0,20,0,0,0,0,0,255,
	17,0,0,26,0,12,0,4,0,1,0,32,255,255,255,255,0,28,
	0,0,0,0,0,0,2,125,0,0,0,0,0,4,0,1,0,32,
	0,35,0,35,0,20,0,0,0,0,0,255,17,0,0,20,0,12,
	0,2,0,1,0,34,255,255,255,255,0,28,0,0,0,0,0,0,
	2,122,0,0,0,0,0,2,0,1,0,40,0,37,0,37,0,20,
	0,0,0,0,0,255,17,0,0,13,0,12,0,2,0,1,0,36,
	255,255,255,255,0,28,0,0,0,0,0,0,2,72,0,0,0,0,
	0,2,0,1,0,34,0,39,0,39,0,20,0,0,0,0,0,255,
	17,0,0,5,0,12,0,4,0,1,0,38,255,255,255,255,0,28,
	0,0,0,0,0,0,2,117,0,0,0,0,0,4,0,1,0,41,
	255,255,255,255,0,28,0,0,0,0,0,0,2,75,0,5,0,14,
	0,4,0,1,0,42,255,255,255,255,0,28,0,0,0,0,0,0,
	2,80,0,12,0,14,0,4,0,1,0,43,255,255,255,255,0,28,
	0,0,0,0,0,0,2,85,0,19,0,14,0,4,0,1,0,44,
	255,255,255,255,0,28,0,0,0,0,0,0,2,90,0,33,0,14,
	0,4,0,1,0,45,255,255,255,255,0,28,0,0,0,0,0,0,
	2,95,0,26,0,14,0,4,0,1,0,46,255,255,255,255,0,28,
	0,0,0,0,0,0,2,100,0,40,0,14,0,4,0,1,0,47,
	255,255,255,255,0,26,0,67,0,0,0,0,2,105,0,13,0,16,
	0,8,0,1,0,38,255,255,255,255,0,26,0,65,0,0,0,0,
	2,110,0,29,0,16,0,8,0,1,255,255,0,1,0,33,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,42,0,19,0,2,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,14,0,11,
	0,2,0,1,0,3,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,22,0,11,0,2,0,1,0,4,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,6,0,11,0,2,0,1,0,6,
	0,5,0,5,0,20,0,64,0,0,0,255,17,17,0,6,0,5,
	0,2,0,6,0,4,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,3,0,2,0,1,0,8,0,7,0,7,0,20,
	0,64,0,0,0,255,17,17,0,14,0,5,0,2,0,6,0,6,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,3,
	0,2,0,1,0,10,0,9,0,9,0,20,0,64,0,0,0,255,
	17,17,0,22,0,5,0,2,0,6,0,8,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,3,0,2,0,1,0,11,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,30,0,11,
	0,2,0,1,0,13,0,12,0,12,0,20,0,64,0,0,0,255,
	17,17,0,30,0,8,0,2,0,3,0,11,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,1,0,2,0,1,0,14,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,22,0,4,
	0,2,0,1,0,15,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,30,0,7,0,2,0,1,0,16,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,14,0,4,0,2,0,1,0,17,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,6,0,4,
	0,2,0,1,0,19,0,18,0,18,0,20,0,0,0,0,0,255,
	17,0,0,30,0,13,0,2,0,1,0,17,255,255,255,255,0,28,
	0,0,0,0,0,0,2,135,0,0,0,0,0,2,0,1,0,21,
	0,20,0,20,0,20,0,0,0,0,0,255,17,0,0,22,0,13,
	0,2,0,1,0,19,255,255,255,255,0,28,0,0,0,0,0,0,
	2,138,0,0,0,0,0,2,0,1,0,23,0,22,0,22,0,20,
	0,0,0,0,0,255,17,0,0,14,0,13,0,2,0,1,0,21,
	255,255,255,255,0,28,0,0,0,0,0,0,2,141,0,0,0,0,
	0,2,0,1,0,25,0,24,0,24,0,20,0,0,0,0,0,255,
	17,0,0,6,0,13,0,2,0,1,0,23,255,255,255,255,0,28,
	0,0,0,0,0,0,2,144,0,0,0,0,0,2,0,1,0,26,
	255,255,255,255,0,28,0,0,0,0,0,0,2,147,0,5,0,1,
	0,32,0,1,0,27,255,255,255,255,0,28,0,0,0,0,0,0,
	2,180,0,19,0,2,0,1,0,1,0,28,255,255,255,255,0,28,
	0,0,0,0,0,0,2,182,0,4,0,15,0,6,0,1,0,29,
	255,255,255,255,0,28,0,0,0,0,0,0,2,189,0,13,0,15,
	0,4,0,1,0,30,255,255,255,255,0,28,0,0,0,0,0,0,
	2,194,0,20,0,15,0,6,0,1,0,31,255,255,255,255,0,28,
	0,0,0,0,0,0,2,201,0,29,0,15,0,4,0,1,0,32,
	255,255,255,255,0,26,0,67,0,0,0,0,2,206,0,6,0,17,
	0,8,0,1,0,33,255,255,255,255,0,26,0,65,0,0,0,0,
	2,211,0,22,0,17,0,8,0,1,0,0,0,34,0,34,0,20,
	0,0,0,0,0,255,17,0,0,28,0,4,0,8,0,1,0,33,
	255,255,255,255,0,28,0,32,0,0,0,0,2,218,0,0,0,0,
	0,8,0,1,255,255,0,1,0,19,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,33,0,20,0,2,255,255,255,255,0,26,
	0,65,0,0,0,0,2,227,0,3,0,4,0,8,0,1,0,3,
	255,255,255,255,0,26,0,65,0,0,0,0,2,232,0,3,0,6,
	0,8,0,1,0,4,255,255,255,255,0,26,0,65,0,0,0,0,
	2,237,0,3,0,8,0,8,0,1,0,5,255,255,255,255,0,26,
	0,65,0,0,0,0,2,242,0,3,0,10,0,8,0,1,0,6,
	255,255,255,255,0,26,0,65,0,0,0,0,2,247,0,3,0,12,
	0,8,0,1,0,7,255,255,255,255,0,26,0,65,0,0,0,0,
	2,252,0,3,0,14,0,8,0,1,0,8,255,255,255,255,0,26,
	0,65,0,0,0,0,3,1,0,18,0,4,0,8,0,1,0,9,
	255,255,255,255,0,26,0,65,0,0,0,0,3,4,0,18,0,6,
	0,8,0,1,0,10,255,255,255,255,0,26,0,65,0,0,0,0,
	3,7,0,18,0,8,0,8,0,1,0,11,255,255,255,255,0,26,
	0,65,0,0,0,0,3,10,0,18,0,10,0,8,0,1,0,12,
	255,255,255,255,0,26,0,65,0,0,0,0,3,13,0,18,0,12,
	0,8,0,1,0,13,255,255,255,255,0,26,0,65,0,0,0,0,
	3,16,0,18,0,14,0,8,0,1,0,14,255,255,255,255,0,26,
	0,67,0,0,0,0,3,19,0,3,0,17,0,8,0,1,0,15,
	255,255,255,255,0,26,0,65,0,0,0,0,3,22,0,18,0,17,
	0,8,0,1,0,16,255,255,255,255,0,28,0,0,0,0,0,0,
	3,29,4,0,1,0,6,2,1,0,0,17,255,255,255,255,0,28,
	0,0,0,0,0,0,3,30,0,4,0,2,0,6,0,1,0,18,
	255,255,255,255,0,28,0,0,0,0,0,0,3,37,0,3,0,1,
	0,8,0,1,0,19,255,255,255,255,0,28,0,0,0,0,0,0,
	3,46,0,19,0,2,0,6,0,1,0,0,255,255,255,255,0,28,
	0,32,0,0,0,0,3,53,0,18,0,1,0,8,0,1,255,255,
	0,1,0,59,0,20,0,0,0,16,0,2,17,0,0,0,0,0,
	0,52,0,17,0,2,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,22,0,11,0,2,0,1,0,3,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,27,0,11,0,2,0,1,0,4,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,17,0,11,
	0,2,0,1,0,5,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,32,0,11,0,2,0,1,0,7,0,6,0,6,0,20,
	0,64,0,0,0,255,17,17,0,17,0,6,0,2,0,5,0,5,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,9,0,8,0,8,0,20,0,64,0,0,0,255,
	17,17,0,22,0,6,0,2,0,5,0,7,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,11,
	0,10,0,10,0,20,0,64,0,0,0,255,17,17,0,27,0,6,
	0,2,0,5,0,9,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,13,0,12,0,12,0,20,
	0,64,0,0,0,255,17,17,0,32,0,6,0,2,0,5,0,11,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,14,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,32,0,5,0,2,0,1,0,15,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,27,0,5,0,2,0,1,0,16,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,22,0,5,
	0,2,0,1,0,17,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,17,0,5,0,2,0,1,0,18,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,37,0,11,0,2,0,1,0,20,
	0,19,0,19,0,20,0,64,0,0,0,255,17,17,0,37,0,6,
	0,2,0,5,0,18,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,21,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,37,0,5,0,2,0,1,0,22,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,42,0,11,
	0,2,0,1,0,23,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,42,0,5,0,2,0,1,0,25,0,24,0,24,0,20,
	0,64,0,0,0,255,17,17,0,42,0,6,0,2,0,5,0,23,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,27,0,26,0,26,0,20,0,64,0,0,0,255,
	17,17,0,12,0,6,0,2,0,5,0,25,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,28,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,12,0,11,
	0,2,0,1,0,29,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,12,0,5,0,2,0,1,0,30,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,7,0,5,0,2,0,1,0,31,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,7,0,11,
	0,2,0,1,0,33,0,32,0,32,0,20,0,64,0,0,0,255,
	17,17,0,7,0,6,0,2,0,5,0,31,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,34,
	255,255,255,255,0,26,0,67,0,0,0,0,3,62,0,12,0,15,
	0,8,0,1,0,51,255,255,255,255,0,26,0,65,0,0,0,0,
	3,65,0,31,0,15,0,8,0,1,0,37,0,36,0,36,0,20,
	0,0,0,0,0,255,17,0,0,17,0,13,0,2,0,1,0,35,
	255,255,255,255,0,28,0,0,0,0,0,0,3,119,0,0,0,0,
	0,2,0,1,0,39,0,38,0,38,0,20,0,0,0,0,0,255,
	17,0,0,22,0,13,0,2,0,1,0,37,255,255,255,255,0,28,
	0,0,0,0,0,0,3,122,0,0,0,0,0,2,0,1,0,41,
	0,40,0,40,0,20,0,0,0,0,0,255,17,0,0,27,0,13,
	0,2,0,1,0,39,255,255,255,255,0,28,0,0,0,0,0,0,
	3,125,0,0,0,0,0,2,0,1,0,43,0,42,0,42,0,20,
	0,0,0,0,0,255,17,0,0,32,0,13,0,2,0,1,0,41,
	255,255,255,255,0,28,0,0,0,0,0,0,3,128,0,0,0,0,
	0,2,0,1,0,45,0,44,0,44,0,20,0,0,0,0,0,255,
	17,0,0,37,0,13,0,2,0,1,0,43,255,255,255,255,0,28,
	0,0,0,0,0,0,3,131,0,0,0,0,0,2,0,1,0,61,
	0,46,0,46,0,20,0,0,0,0,0,255,17,0,0,42,0,13,
	0,2,0,1,0,45,255,255,255,255,0,28,0,0,0,0,0,0,
	3,134,0,0,0,0,0,2,0,1,0,49,0,48,0,48,0,20,
	0,0,0,0,0,255,17,0,0,7,0,13,0,2,0,1,0,47,
	255,255,255,255,0,28,0,0,0,0,0,0,3,113,0,0,0,0,
	0,2,0,1,0,35,0,50,0,50,0,20,0,0,0,0,0,255,
	17,0,0,12,0,13,0,2,0,1,0,49,255,255,255,255,0,28,
	0,0,0,0,0,0,3,116,0,0,0,0,0,2,0,1,0,52,
	255,255,255,255,0,28,0,0,0,0,0,0,3,72,0,6,0,3,
	0,4,0,1,0,53,255,255,255,255,0,28,0,0,0,0,0,0,
	3,77,0,11,0,3,0,4,0,1,0,54,255,255,255,255,0,28,
	0,0,0,0,0,0,3,82,0,16,0,3,0,4,0,1,0,55,
	255,255,255,255,0,28,0,0,0,0,0,0,3,87,0,21,0,3,
	0,4,0,1,0,56,255,255,255,255,0,28,0,0,0,0,0,0,
	3,92,0,41,0,3,0,4,0,1,0,57,255,255,255,255,0,28,
	0,0,0,0,0,0,3,97,0,36,0,3,0,4,0,1,0,58,
	255,255,255,255,0,28,0,0,0,0,0,0,3,102,0,31,0,3,
	0,4,0,1,0,60,255,255,255,255,0,28,0,0,0,0,0,0,
	3,107,0,26,0,3,0,4,0,1,0,0,255,255,255,255,0,28,
	0,32,0,0,0,0,3,159,0,34,0,1,0,1,0,1,0,47,
	255,255,255,255,0,28,0,0,0,0,0,0,3,112,7,0,1,0,
	2,4,1,0,0,59,255,255,255,255,0,28,0,0,0,0,0,0,
	3,137,0,13,0,1,0,21,0,1,255,255,0,1,0,17,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,45,0,12,0,2,
	255,255,255,255,0,26,0,65,0,0,0,0,3,161,0,3,0,3,
	0,8,0,1,0,3,255,255,255,255,0,26,0,65,0,0,0,0,
	3,163,0,3,0,5,0,8,0,1,0,4,255,255,255,255,0,26,
	0,65,0,0,0,0,3,165,0,3,0,7,0,8,0,1,0,5,
	255,255,255,255,0,26,0,65,0,0,0,0,3,167,0,3,0,9,
	0,8,0,1,0,6,255,255,255,255,0,26,0,65,0,0,0,0,
	3,169,0,14,0,9,0,8,0,1,0,7,255,255,255,255,0,26,
	0,65,0,0,0,0,3,171,0,14,0,7,0,8,0,1,0,8,
	255,255,255,255,0,26,0,65,0,0,0,0,3,173,0,14,0,5,
	0,8,0,1,0,9,255,255,255,255,0,26,0,65,0,0,0,0,
	3,175,0,14,0,3,0,8,0,1,0,10,255,255,255,255,0,26,
	0,65,0,0,0,0,3,177,0,24,0,3,0,8,0,1,0,11,
	255,255,255,255,0,26,0,65,0,0,0,0,3,179,0,24,0,5,
	0,8,0,1,0,12,255,255,255,255,0,26,0,65,0,0,0,0,
	3,182,0,24,0,7,0,8,0,1,0,13,255,255,255,255,0,26,
	0,65,0,0,0,0,3,185,0,24,0,9,0,8,0,1,0,14,
	255,255,255,255,0,26,0,65,0,0,0,0,3,188,0,34,0,9,
	0,8,0,1,0,15,255,255,255,255,0,26,0,65,0,0,0,0,
	3,191,0,34,0,7,0,8,0,1,0,16,255,255,255,255,0,26,
	0,65,0,0,0,0,3,194,0,34,0,5,0,8,0,1,0,17,
	255,255,255,255,0,26,0,65,0,0,0,0,3,197,0,34,0,3,
	0,8,0,1,0,0,255,255,255,255,0,28,0,32,0,0,0,0,
	3,200,0,14,0,1,0,16,0,1,255,255,0,1,0,56,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,56,0,17,0,2,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,6,0,11,
	0,2,0,1,0,4,0,3,0,3,0,20,0,64,0,0,0,255,
	17,17,0,6,0,6,0,2,0,5,0,2,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,5,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,6,0,5,
	0,2,0,1,0,7,0,6,0,6,0,20,0,0,0,0,0,255,
	17,0,0,6,0,13,0,2,0,1,0,5,255,255,255,255,0,28,
	0,0,0,0,0,0,3,217,0,0,0,0,0,2,0,1,0,8,
	255,255,255,255,0,28,0,0,0,0,0,0,3,220,0,4,0,3,
	0,5,0,1,0,10,0,9,0,9,0,20,0,0,0,0,0,255,
	17,0,0,13,0,13,0,2,0,1,0,8,255,255,255,255,0,28,
	0,0,0,0,0,0,3,226,0,0,0,0,0,2,0,1,0,12,
	0,11,0,11,0,20,0,0,0,0,0,255,17,0,0,20,0,13,
	0,2,0,1,0,10,255,255,255,255,0,28,0,0,0,0,0,0,
	3,229,0,0,0,0,0,2,0,1,0,14,0,13,0,13,0,20,
	0,0,0,0,0,255,17,0,0,27,0,13,0,2,0,1,0,12,
	255,255,255,255,0,28,0,0,0,0,0,0,3,232,0,0,0,0,
	0,2,0,1,0,16,0,15,0,15,0,20,0,0,0,0,0,255,
	17,0,0,34,0,13,0,2,0,1,0,14,255,255,255,255,0,28,
	0,0,0,0,0,0,3,235,0,0,0,0,0,2,0,1,0,18,
	0,17,0,17,0,20,0,0,0,0,0,255,17,0,0,48,0,13,
	0,2,0,1,0,16,255,255,255,255,0,28,0,0,0,0,0,0,
	3,238,0,0,0,0,0,2,0,1,0,19,255,255,255,255,0,26,
	0,67,0,0,0,0,3,241,0,13,0,15,0,8,0,1,0,20,
	255,255,255,255,0,26,0,65,0,0,0,0,3,244,0,34,0,15,
	0,8,0,1,0,21,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,48,0,11,0,2,0,1,0,22,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,48,0,5,0,2,0,1,0,24,
	0,23,0,23,0,20,0,64,0,0,0,255,17,17,0,48,0,6,
	0,2,0,5,0,22,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,25,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,41,0,11,0,2,0,1,0,26,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,41,0,5,
	0,2,0,1,0,28,0,27,0,27,0,20,0,64,0,0,0,255,
	17,17,0,41,0,6,0,2,0,5,0,26,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,29,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,34,0,5,
	0,2,0,1,0,30,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,34,0,11,0,2,0,1,0,32,0,31,0,31,0,20,
	0,64,0,0,0,255,17,17,0,34,0,6,0,2,0,5,0,30,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,33,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,27,0,5,0,2,0,1,0,34,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,27,0,11,0,2,0,1,0,36,
	0,35,0,35,0,20,0,64,0,0,0,255,17,17,0,27,0,6,
	0,2,0,5,0,34,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,37,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,20,0,5,0,2,0,1,0,38,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,20,0,11,
	0,2,0,1,0,40,0,39,0,39,0,20,0,64,0,0,0,255,
	17,17,0,20,0,6,0,2,0,5,0,38,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,42,
	0,41,0,41,0,20,0,64,0,0,0,255,17,17,0,13,0,6,
	0,2,0,5,0,40,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,43,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,13,0,11,0,2,0,1,0,44,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,13,0,5,
	0,2,0,1,0,45,255,255,255,255,0,28,0,0,0,0,0,0,
	3,251,0,18,0,3,0,5,0,1,0,46,255,255,255,255,0,28,
	0,0,0,0,0,0,4,1,0,12,0,3,0,5,0,1,0,47,
	255,255,255,255,0,28,0,0,0,0,0,0,4,7,0,18,0,2,
	0,5,0,1,0,48,255,255,255,255,0,28,0,0,0,0,0,0,
	4,13,0,25,0,3,0,5,0,1,0,49,255,255,255,255,0,28,
	0,0,0,0,0,0,4,19,0,25,0,2,0,5,0,1,0,50,
	255,255,255,255,0,28,0,0,0,0,0,0,4,25,0,33,0,3,
	0,4,0,1,0,51,255,255,255,255,0,28,0,0,0,0,0,0,
	4,30,0,34,0,2,0,3,0,1,0,53,0,52,0,52,0,20,
	0,0,0,0,0,255,17,0,0,40,0,13,0,4,0,1,0,51,
	255,255,255,255,0,28,0,0,0,0,0,0,4,34,0,0,0,0,
	0,4,0,1,0,54,255,255,255,255,0,28,0,0,0,0,0,0,
	4,39,0,40,0,3,0,4,0,1,0,55,255,255,255,255,0,28,
	0,0,0,0,0,0,4,44,0,47,0,2,0,3,0,1,0,56,
	255,255,255,255,0,28,0,0,0,0,0,0,4,48,0,47,0,3,
	0,3,0,1,0,0,255,255,255,255,0,28,0,32,0,0,0,0,
	4,52,0,21,0,1,0,13,0,1,255,255,0,1,0,23,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,44,0,18,0,3,
	0,2,0,2,0,20,0,64,0,0,0,255,17,17,0,9,0,6,
	0,2,0,6,0,1,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,3,0,2,0,1,0,5,0,4,0,4,0,20,
	0,64,0,0,0,255,17,17,0,19,0,6,0,2,0,6,0,3,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,3,
	0,2,0,1,0,6,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,19,0,12,0,2,0,1,0,7,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,9,0,12,0,2,0,1,0,8,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,19,0,5,
	0,2,0,1,0,9,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,9,0,5,0,2,0,1,0,11,0,10,0,10,0,20,
	0,0,0,0,0,255,17,0,0,19,0,14,0,2,0,1,0,9,
	255,255,255,255,0,28,0,0,0,0,0,0,4,66,0,0,0,0,
	0,2,0,1,0,13,0,12,0,12,0,20,0,0,0,0,0,255,
	17,0,0,9,0,14,0,2,0,1,0,11,255,255,255,255,0,28,
	0,0,0,0,0,0,4,69,0,0,0,0,0,2,0,1,0,17,
	0,14,0,16,0,20,0,0,0,0,0,255,17,0,0,26,0,10,
	0,14,0,3,0,15,255,255,255,255,0,28,0,0,0,0,0,0,
	4,72,0,3,0,0,0,7,0,1,0,16,255,255,255,255,0,28,
	0,0,0,0,0,0,4,80,0,2,0,1,0,9,0,1,0,13,
	255,255,255,255,0,28,0,0,0,0,0,0,4,90,0,4,0,2,
	0,6,0,1,0,18,255,255,255,255,0,28,0,0,0,0,0,0,
	4,96,0,4,0,3,0,11,0,1,0,19,255,255,255,255,0,28,
	0,0,0,0,0,0,4,108,0,17,0,3,0,6,0,1,0,20,
	255,255,255,255,0,28,0,0,0,0,0,0,4,115,0,27,0,8,
	0,11,0,1,0,21,255,255,255,255,0,26,0,67,0,0,0,0,
	4,127,0,6,0,16,0,8,0,1,0,22,255,255,255,255,0,26,
	0,65,0,0,0,0,4,130,0,29,0,16,0,8,0,1,0,23,
	255,255,255,255,0,28,0,0,0,0,0,0,4,137,0,27,0,7,
	0,11,0,1,0,0,255,255,255,255,0,28,0,32,0,0,0,0,
	4,149,0,11,0,1,0,22,0,1,255,255,0,1,0,2,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,41,0,14,0,3,
	255,255,255,255,0,26,0,67,0,0,0,0,4,172,0,29,0,8,
	0,8,0,4,0,0,255,255,255,255,0,26,0,97,0,0,0,0,
	5,61,0,29,0,1,0,8,0,4,0,14,0,4,0,13,0,20,
	0,0,0,0,0,255,17,0,0,3,0,2,0,17,0,10,0,5,
	255,255,255,255,0,28,0,64,0,0,0,0,4,175,0,0,0,0,
	0,17,0,1,0,6,255,255,255,255,0,28,0,64,0,0,0,0,
	4,187,0,0,0,1,0,17,0,1,0,7,255,255,255,255,0,28,
	0,64,0,0,0,0,4,199,0,0,0,2,0,17,0,1,0,8,
	255,255,255,255,0,28,0,64,0,0,0,0,4,211,0,0,0,3,
	0,17,0,1,0,9,255,255,255,255,0,28,0,64,0,0,0,0,
	4,223,0,0,0,4,0,17,0,1,0,10,255,255,255,255,0,28,
	0,64,0,0,0,0,4,235,0,0,0,5,0,17,0,1,0,11,
	255,255,255,255,0,28,0,64,0,0,0,0,4,247,0,0,0,6,
	0,17,0,1,0,12,255,255,255,255,0,28,0,64,0,0,0,0,
	5,3,0,0,0,7,0,17,0,1,0,13,255,255,255,255,0,28,
	0,64,0,0,0,0,5,15,0,0,0,8,0,17,0,1,0,3,
	255,255,255,255,0,28,0,64,0,0,0,0,5,27,0,0,0,9,
	0,17,0,1,0,15,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,20,0,2,0,3,0,1,0,17,0,16,0,16,0,20,
	0,64,0,0,0,255,17,17,0,20,0,3,0,3,0,8,0,15,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,3,
	0,3,0,1,0,18,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,20,0,11,0,3,0,1,0,2,255,255,255,255,0,22,
	0,0,0,0,0,0,50,240,0,3,0,1,0,20,0,1,255,255,
	0,1,0,11,0,25,0,0,0,0,0,0,0,0,0,0,0,0,
	0,80,0,25,0,11,0,2,0,2,0,20,0,0,0,0,0,0,
	17,0,0,0,0,0,0,80,2,1,0,1,0,3,0,10,0,25,
	0,0,0,0,0,0,0,0,0,2,0,0,0,58,3,1,0,4,
	255,255,255,255,0,32,0,0,0,0,0,0,5,68,0,0,0,0,
	0,6,3,1,0,5,255,255,255,255,0,32,0,0,0,0,0,0,
	5,75,0,6,0,0,0,6,3,1,0,6,255,255,255,255,0,32,
	0,0,0,0,0,0,5,82,0,12,0,0,0,7,3,1,0,7,
	255,255,255,255,0,32,0,0,0,0,0,0,5,90,0,19,0,0,
	0,7,3,1,0,8,255,255,255,255,0,32,0,0,0,0,0,0,
	5,99,0,26,0,0,0,8,3,1,0,9,255,255,255,255,0,32,
	0,0,0,0,0,0,5,108,0,34,0,0,0,8,3,1,0,10,
	255,255,255,255,0,32,0,0,0,0,0,0,5,117,0,42,0,0,
	0,8,3,1,0,2,255,255,255,255,0,32,0,0,0,0,0,0,
	5,125,0,50,0,0,0,8,3,1,0,0,0,12,0,58,0,25,
	0,0,0,0,0,0,0,0,0,0,3,1,0,80,0,19,0,21,
	0,13,0,20,0,20,0,0,0,0,0,255,17,0,0,2,0,0,
	0,20,0,8,0,14,255,255,255,255,0,28,0,0,0,0,0,0,
	5,132,0,0,0,0,0,20,0,1,0,15,255,255,255,255,0,28,
	0,0,0,8,0,0,5,153,0,0,0,1,0,20,0,1,0,16,
	255,255,255,255,0,28,0,0,0,0,0,0,5,174,0,0,0,2,
	0,20,0,1,0,17,255,255,255,255,0,28,0,0,0,0,0,0,
	5,195,0,0,0,3,0,20,0,1,0,18,255,255,255,255,0,28,
	0,0,0,0,0,0,5,216,0,0,0,4,0,20,0,1,0,19,
	255,255,255,255,0,28,0,0,0,0,0,0,5,237,0,0,0,5,
	0,20,0,1,0,20,255,255,255,255,0,28,0,0,0,0,0,0,
	6,2,0,0,0,6,0,20,0,1,0,12,255,255,255,255,0,28,
	0,0,0,0,0,0,6,23,0,0,0,7,0,20,0,1,0,32,
	0,22,0,31,0,20,0,0,0,0,0,255,17,0,0,8,0,0,
	0,16,0,10,0,23,255,255,255,255,0,28,0,0,0,0,0,0,
	6,44,0,0,0,0,0,16,0,1,0,24,255,255,255,255,0,28,
	0,0,0,0,0,0,6,52,0,0,0,1,0,16,0,1,0,25,
	255,255,255,255,0,28,0,0,0,8,0,0,6,59,0,0,0,2,
	0,16,0,1,0,26,255,255,255,255,0,28,0,0,0,0,0,0,
	6,76,0,0,0,3,0,16,0,1,0,27,255,255,255,255,0,28,
	0,0,0,0,0,0,6,89,0,0,0,4,0,16,0,1,0,28,
	255,255,255,255,0,28,0,0,0,8,0,0,6,100,0,0,0,5,
	0,16,0,1,0,29,255,255,255,255,0,28,0,0,0,0,0,0,
	6,117,0,0,0,6,0,16,0,1,0,30,255,255,255,255,0,28,
	0,0,0,0,0,0,6,130,0,0,0,7,0,16,0,1,0,31,
	255,255,255,255,0,28,0,0,0,8,0,0,6,147,0,0,0,8,
	0,16,0,1,0,21,255,255,255,255,0,28,0,0,0,0,0,0,
	6,164,0,0,0,9,0,16,0,1,0,36,0,33,0,35,0,20,
	0,0,0,0,0,255,17,0,0,14,0,0,0,16,0,3,0,34,
	255,255,255,255,0,28,0,0,0,0,0,0,6,172,0,0,0,0,
	0,16,0,1,0,35,255,255,255,255,0,28,0,0,0,0,0,0,
	6,189,0,0,0,1,0,16,0,1,0,32,255,255,255,255,0,28,
	0,0,0,0,0,0,6,206,0,0,0,2,0,16,0,1,0,39,
	0,37,0,38,0,20,0,0,0,0,0,255,17,0,0,21,0,0,
	5,13,0,2,0,38,255,255,255,255,0,28,0,0,0,0,0,0,
	6,223,0,0,0,0,5,13,0,1,0,36,255,255,255,255,0,28,
	0,0,0,0,0,0,6,237,0,0,0,1,5,13,0,1,0,45,
	0,40,0,44,0,20,0,0,0,0,0,255,17,0,0,28,0,0,
	0,19,0,5,0,41,255,255,255,255,0,28,0,0,0,0,0,0,
	6,251,0,0,0,0,0,19,0,1,0,42,255,255,255,255,0,28,
	0,0,0,0,0,0,7,9,0,0,0,1,0,19,0,1,0,43,
	255,255,255,255,0,28,0,0,0,0,0,0,7,19,0,0,0,2,
	0,19,0,1,0,44,255,255,255,255,0,28,0,0,0,0,0,0,
	7,32,0,0,0,3,0,19,0,1,0,39,255,255,255,255,0,28,
	0,0,0,0,0,0,7,47,0,0,0,4,0,19,0,1,0,50,
	0,46,0,49,0,20,0,0,0,0,0,255,17,0,0,36,0,0,
	0,17,0,4,0,47,255,255,255,255,0,28,0,0,0,0,0,0,
	7,59,0,0,0,0,0,17,0,1,0,48,255,255,255,255,0,28,
	0,0,0,0,0,0,7,77,0,0,0,1,0,17,0,1,0,49,
	255,255,255,255,0,28,0,0,0,0,0,0,7,84,0,0,0,2,
	0,17,0,1,0,45,255,255,255,255,0,28,0,0,0,0,0,0,
	7,96,0,0,0,3,0,17,0,1,0,58,0,51,0,57,0,20,
	0,0,0,0,0,255,17,0,0,44,0,0,0,21,0,7,0,52,
	255,255,255,255,0,28,0,0,0,0,0,0,7,105,0,0,0,0,
	0,21,0,1,0,53,255,255,255,255,0,28,0,0,0,0,0,0,
	7,119,0,0,0,1,0,21,0,1,0,54,255,255,255,255,0,28,
	0,0,0,0,0,0,7,133,0,0,0,2,0,21,0,1,0,55,
	255,255,255,255,0,28,0,0,0,0,0,0,7,152,0,0,0,3,
	0,21,0,1,0,56,255,255,255,255,0,28,0,0,0,0,0,0,
	7,168,0,0,0,4,0,21,0,1,0,57,255,255,255,255,0,28,
	0,0,0,0,0,0,7,182,0,0,0,5,0,21,0,1,0,50,
	255,255,255,255,0,28,0,0,0,0,0,0,7,199,0,0,0,6,
	0,21,0,1,0,11,0,59,0,63,0,20,0,0,0,0,0,255,
	17,0,0,52,0,0,0,19,0,5,0,60,255,255,255,255,0,28,
	0,0,0,0,0,0,7,208,0,0,0,0,0,19,0,1,0,61,
	255,255,255,255,0,28,0,0,0,0,0,0,7,222,0,0,0,1,
	0,19,0,1,0,62,255,255,255,255,0,28,0,0,0,8,0,0,
	7,242,0,0,0,2,0,19,0,1,0,63,255,255,255,255,0,28,
	0,0,0,0,0,0,8,6,0,0,0,3,0,19,0,1,0,58,
	255,255,255,255,0,28,0,32,0,0,0,0,8,20,0,0,0,4,
	0,19,0,1,255,255,0,1,0,58,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,52,0,17,0,2,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,22,0,11,0,2,0,1,0,3,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,27,0,11,
	0,2,0,1,0,4,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,17,0,11,0,2,0,1,0,5,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,32,0,11,0,2,0,1,0,7,
	0,6,0,6,0,20,0,64,0,0,0,255,17,17,0,17,0,6,
	0,2,0,5,0,5,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,9,0,8,0,8,0,20,
	0,64,0,0,0,255,17,17,0,22,0,6,0,2,0,5,0,7,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,11,0,10,0,10,0,20,0,64,0,0,0,255,
	17,17,0,27,0,6,0,2,0,5,0,9,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,13,
	0,12,0,12,0,20,0,64,0,0,0,255,17,17,0,32,0,6,
	0,2,0,5,0,11,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,14,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,32,0,5,0,2,0,1,0,15,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,27,0,5,
	0,2,0,1,0,16,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,22,0,5,0,2,0,1,0,17,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,17,0,5,0,2,0,1,0,18,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,37,0,11,
	0,2,0,1,0,20,0,19,0,19,0,20,0,64,0,0,0,255,
	17,17,0,37,0,6,0,2,0,5,0,18,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,21,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,37,0,5,
	0,2,0,1,0,22,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,42,0,11,0,2,0,1,0,23,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,42,0,5,0,2,0,1,0,25,
	0,24,0,24,0,20,0,64,0,0,0,255,17,17,0,42,0,6,
	0,2,0,5,0,23,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,27,0,26,0,26,0,20,
	0,64,0,0,0,255,17,17,0,12,0,6,0,2,0,5,0,25,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,28,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,12,0,11,0,2,0,1,0,29,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,12,0,5,0,2,0,1,0,30,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,7,0,5,
	0,2,0,1,0,31,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,7,0,11,0,2,0,1,0,33,0,32,0,32,0,20,
	0,64,0,0,0,255,17,17,0,7,0,6,0,2,0,5,0,31,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,34,255,255,255,255,0,26,0,67,0,0,0,0,
	8,34,0,12,0,15,0,8,0,1,0,35,255,255,255,255,0,26,
	0,65,0,0,0,0,8,37,0,31,0,15,0,8,0,1,0,36,
	255,255,255,255,0,28,0,0,0,0,0,0,8,44,0,6,0,3,
	0,4,0,1,0,37,255,255,255,255,0,28,0,0,0,0,0,0,
	8,49,0,11,0,3,0,4,0,1,0,38,255,255,255,255,0,28,
	0,0,0,0,0,0,8,54,0,16,0,3,0,4,0,1,0,39,
	255,255,255,255,0,28,0,0,0,0,0,0,8,59,0,21,0,3,
	0,4,0,1,0,40,255,255,255,255,0,28,0,0,0,0,0,0,
	8,64,0,41,0,3,0,4,0,1,0,41,255,255,255,255,0,28,
	0,0,0,0,0,0,8,69,0,36,0,3,0,4,0,1,0,42,
	255,255,255,255,0,28,0,0,0,0,0,0,8,74,0,31,0,3,
	0,4,0,1,0,43,255,255,255,255,0,28,0,0,0,0,0,0,
	8,79,0,26,0,3,0,4,0,1,0,44,255,255,255,255,0,28,
	0,0,0,0,0,0,8,84,0,7,0,1,0,35,0,1,0,46,
	0,45,0,45,0,20,0,0,0,0,0,255,17,0,0,7,0,13,
	0,2,0,1,0,44,255,255,255,255,0,28,0,0,0,0,0,0,
	8,120,0,0,0,0,0,2,0,1,0,48,0,47,0,47,0,20,
	0,0,0,0,0,255,17,0,0,12,0,13,0,2,0,1,0,46,
	255,255,255,255,0,28,0,0,0,0,0,0,8,123,0,0,0,0,
	0,2,0,1,0,50,0,49,0,49,0,20,0,0,0,0,0,255,
	17,0,0,17,0,13,0,2,0,1,0,48,255,255,255,255,0,28,
	0,0,0,0,0,0,8,126,0,0,0,0,0,2,0,1,0,52,
	0,51,0,51,0,20,0,0,0,0,0,255,17,0,0,22,0,13,
	0,2,0,1,0,50,255,255,255,255,0,28,0,0,0,0,0,0,
	8,129,0,0,0,0,0,2,0,1,0,54,0,53,0,53,0,20,
	0,0,0,0,0,255,17,0,0,27,0,13,0,2,0,1,0,52,
	255,255,255,255,0,28,0,0,0,0,0,0,8,132,0,0,0,0,
	0,2,0,1,0,56,0,55,0,55,0,20,0,0,0,0,0,255,
	17,0,0,32,0,13,0,2,0,1,0,54,255,255,255,255,0,28,
	0,0,0,0,0,0,8,135,0,0,0,0,0,2,0,1,0,58,
	0,57,0,57,0,20,0,0,0,0,0,255,17,0,0,37,0,13,
	0,2,0,1,0,56,255,255,255,255,0,28,0,0,0,0,0,0,
	8,138,0,0,0,0,0,2,0,1,0,0,0,59,0,59,0,20,
	0,0,0,0,0,255,17,0,0,42,0,13,0,2,0,1,0,58,
	255,255,255,255,0,28,0,32,0,0,0,0,8,141,0,0,0,0,
	0,2,0,1,255,255,0,1,0,23,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,44,0,18,0,3,0,2,0,2,0,20,
	0,64,0,0,0,255,17,17,0,9,0,6,0,2,0,6,0,1,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,3,
	0,2,0,1,0,5,0,4,0,4,0,20,0,64,0,0,0,255,
	17,17,0,19,0,6,0,2,0,6,0,3,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,3,0,2,0,1,0,6,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,19,0,12,
	0,2,0,1,0,7,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,9,0,12,0,2,0,1,0,8,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,19,0,5,0,2,0,1,0,9,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,9,0,5,
	0,2,0,1,0,11,0,10,0,10,0,20,0,0,0,0,0,255,
	17,0,0,19,0,14,0,2,0,1,0,9,255,255,255,255,0,28,
	0,0,0,0,0,0,8,144,0,0,0,0,0,2,0,1,0,13,
	0,12,0,12,0,20,0,0,0,0,0,255,17,0,0,9,0,14,
	0,2,0,1,0,11,255,255,255,255,0,28,0,0,0,0,0,0,
	8,147,0,0,0,0,0,2,0,1,0,17,0,14,0,16,0,20,
	0,0,0,0,0,255,17,0,0,26,0,10,0,14,0,3,0,15,
	255,255,255,255,0,28,0,0,0,0,0,0,8,150,0,3,0,0,
	0,7,0,1,0,16,255,255,255,255,0,28,0,0,0,0,0,0,
	8,158,0,2,0,1,0,9,0,1,0,13,255,255,255,255,0,28,
	0,0,0,0,0,0,8,168,0,4,0,2,0,6,0,1,0,18,
	255,255,255,255,0,28,0,0,0,0,0,0,8,174,0,4,0,3,
	0,11,0,1,0,19,255,255,255,255,0,28,0,0,0,0,0,0,
	8,186,0,17,0,3,0,6,0,1,0,20,255,255,255,255,0,28,
	0,0,0,0,0,0,8,193,0,27,0,8,0,11,0,1,0,21,
	255,255,255,255,0,26,0,67,0,0,0,0,8,205,0,6,0,16,
	0,8,0,1,0,22,255,255,255,255,0,26,0,65,0,0,0,0,
	8,208,0,29,0,16,0,8,0,1,0,23,255,255,255,255,0,28,
	0,0,0,0,0,0,8,215,0,9,0,1,0,25,0,1,0,0,
	255,255,255,255,0,28,0,32,0,0,0,0,8,241,0,26,0,7,
	0,14,0,1,255,255,0,1,0,28,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,33,0,19,0,2,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,6,0,11,0,2,0,1,0,4,
	0,3,0,3,0,20,0,64,0,0,0,255,17,17,0,6,0,5,
	0,2,0,6,0,2,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,6,0,5,0,5,0,20,
	0,64,0,0,0,255,17,17,0,14,0,5,0,2,0,6,0,4,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,7,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,14,0,11,0,2,0,1,0,9,0,8,0,8,0,20,
	0,64,0,0,0,255,17,17,0,22,0,5,0,2,0,6,0,7,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,10,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,22,0,11,0,2,0,1,0,11,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,6,0,4,0,2,0,1,0,12,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,14,0,4,
	0,2,0,1,0,13,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,22,0,4,0,2,0,1,0,15,0,14,0,14,0,20,
	0,0,0,0,0,255,17,0,0,6,0,13,0,2,0,1,0,13,
	255,255,255,255,0,28,0,0,0,0,0,0,9,0,0,0,0,0,
	0,2,0,1,0,17,0,16,0,16,0,20,0,0,0,0,0,255,
	17,0,0,22,0,13,0,2,0,1,0,15,255,255,255,255,0,28,
	0,0,0,0,0,0,9,3,0,0,0,0,0,2,0,1,0,19,
	0,18,0,18,0,20,0,0,0,0,0,255,17,0,0,14,0,13,
	0,2,0,1,0,17,255,255,255,255,0,28,0,0,0,0,0,0,
	9,6,0,0,0,0,0,2,0,1,0,20,255,255,255,255,0,28,
	0,0,0,0,0,0,9,9,0,4,0,1,0,22,0,1,0,21,
	255,255,255,255,0,28,0,0,0,0,0,0,9,32,0,14,0,2,
	0,1,0,1,0,23,0,22,0,22,0,20,0,0,0,0,0,255,
	17,0,0,11,0,15,0,8,0,1,0,21,255,255,255,255,0,28,
	0,0,0,0,0,0,9,34,0,0,0,0,0,8,0,1,0,25,
	0,24,0,24,0,20,0,0,0,0,0,255,17,0,0,3,0,15,
	0,7,0,1,0,23,255,255,255,255,0,28,0,0,0,0,0,0,
	9,43,0,0,0,0,0,7,0,1,0,27,0,26,0,26,0,20,
	0,0,0,0,0,255,17,0,0,20,0,15,0,7,0,1,0,25,
	255,255,255,255,0,28,0,0,0,0,0,0,9,51,0,0,0,0,
	0,7,0,1,0,28,255,255,255,255,0,26,0,67,0,0,0,0,
	9,59,0,3,0,17,0,8,0,1,0,0,255,255,255,255,0,26,
	0,97,0,0,0,0,9,64,0,19,0,17,0,8,0,1,255,255,
	0,1,0,16,0,20,0,0,0,16,0,2,17,0,0,0,0,0,
	0,39,0,22,0,2,255,255,255,255,0,28,0,0,0,0,0,0,
	9,71,0,3,0,4,0,34,0,1,0,3,255,255,255,255,0,28,
	0,0,0,0,0,0,9,106,0,13,0,2,0,15,0,1,0,4,
	255,255,255,255,0,28,0,0,0,0,0,0,9,122,0,3,0,5,
	0,31,0,1,0,5,255,255,255,255,0,28,0,0,0,0,0,0,
	9,154,0,3,0,6,0,34,0,1,0,6,255,255,255,255,0,28,
	0,0,0,0,0,0,9,189,0,3,0,7,0,35,0,1,0,7,
	255,255,255,255,0,28,0,0,0,0,0,0,9,225,0,3,0,8,
	0,34,0,1,0,8,255,255,255,255,0,28,0,0,0,0,0,0,
	10,4,0,3,0,9,0,35,0,1,0,9,255,255,255,255,0,28,
	0,0,0,0,0,0,10,40,0,3,0,10,0,33,0,1,0,14,
	255,255,255,255,0,28,0,0,0,0,0,0,10,74,0,3,0,11,
	0,22,0,1,0,11,255,255,255,255,0,28,0,0,0,0,0,0,
	10,100,0,2,0,18,0,23,0,1,0,12,255,255,255,255,0,28,
	0,0,0,0,0,0,10,124,0,2,0,17,0,15,0,1,0,13,
	255,255,255,255,0,28,0,0,0,0,0,0,10,140,0,2,0,16,
	0,12,0,1,0,15,255,255,255,255,0,28,0,0,0,0,0,0,
	10,153,0,3,0,13,0,27,0,1,0,10,255,255,255,255,0,26,
	0,67,0,0,0,0,10,97,0,14,0,20,0,8,0,1,0,16,
	255,255,255,255,0,28,0,0,0,0,0,0,10,181,0,3,0,14,
	0,26,0,1,0,0,255,255,255,255,0,28,0,32,0,0,0,0,
	10,208,0,13,0,1,0,15,0,1,255,255,0,1,0,17,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,42,0,17,0,2,
	255,255,255,255,0,28,0,0,0,0,0,0,10,224,0,10,0,1,
	0,21,0,1,0,3,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,8,0,12,0,2,0,1,0,4,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,17,0,12,0,2,0,1,0,6,
	0,5,0,5,0,20,0,64,0,0,0,255,17,17,0,17,0,6,
	0,2,0,6,0,4,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,3,0,2,0,1,0,8,0,7,0,7,0,20,
	0,64,0,0,0,255,17,17,0,8,0,6,0,2,0,6,0,6,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,3,
	0,2,0,1,0,9,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,8,0,5,0,2,0,1,0,10,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,17,0,5,0,2,0,1,0,12,
	0,11,0,11,0,20,0,0,0,0,0,255,17,0,0,8,0,14,
	0,2,0,1,0,10,255,255,255,255,0,28,0,0,0,0,0,0,
	10,246,0,0,0,0,0,2,0,1,0,14,0,13,0,13,0,20,
	0,0,0,0,0,255,17,0,0,17,0,14,0,2,0,1,0,12,
	255,255,255,255,0,28,0,0,0,0,0,0,10,249,0,0,0,0,
	0,2,0,1,0,15,255,255,255,255,0,28,0,0,0,0,0,0,
	10,252,0,7,0,3,0,4,0,1,0,16,255,255,255,255,0,28,
	0,0,0,0,0,0,11,1,0,16,0,3,0,5,0,1,0,17,
	255,255,255,255,0,26,0,67,0,0,0,0,11,7,0,27,0,6,
	0,8,0,1,0,0,255,255,255,255,0,26,0,97,0,0,0,0,
	11,10,0,27,0,11,0,8,0,1,255,255,0,1,0,3,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,58,0,19,0,2,
	255,255,255,255,0,23,0,65,0,0,0,0,49,48,0,24,0,1,
	0,4,14,2,0,4,255,255,255,255,0,23,0,65,0,0,0,0,
	49,62,0,29,0,1,0,4,14,2,0,0,255,255,255,255,0,23,
	0,97,0,0,0,0,50,226,0,34,0,1,0,6,3,2,0,9,
	255,255,255,255,0,23,0,65,0,0,0,0,49,76,0,41,0,1,
	0,6,3,2,0,8,255,255,255,255,0,23,0,65,0,0,0,0,
	50,170,0,49,0,2,0,6,3,2,0,7,255,255,255,255,0,23,
	0,65,0,0,0,0,50,198,0,6,0,1,0,4,9,3,0,3,
	255,255,255,255,0,23,0,65,0,0,0,0,50,212,0,1,0,1,
	0,4,9,3,0,6,255,255,255,255,0,23,0,65,0,0,0,0,
	50,184,0,12,0,1,0,4,14,2,0,32,255,255,255,255,0,23,
	0,65,0,0,0,0,49,90,0,18,0,1,0,4,14,2,0,11,
	255,255,255,255,0,23,0,65,0,0,0,0,50,58,0,2,0,5,
	0,6,3,3,0,30,255,255,255,255,0,23,0,65,0,0,0,0,
	50,72,0,9,0,5,0,6,3,3,0,29,255,255,255,255,0,23,
	0,65,0,0,0,0,49,132,0,22,0,15,0,6,3,3,0,14,
	255,255,255,255,0,23,0,65,0,0,0,0,50,100,0,23,0,5,
	0,6,3,3,0,15,255,255,255,255,0,23,0,65,0,0,0,0,
	50,114,0,30,0,5,0,6,3,3,0,16,255,255,255,255,0,23,
	0,65,0,0,0,0,50,128,0,37,0,5,0,6,3,3,0,17,
	255,255,255,255,0,23,0,65,0,0,0,0,50,142,0,44,0,5,
	0,6,3,3,0,5,255,255,255,255,0,23,0,65,0,0,0,0,
	50,156,0,51,0,5,0,6,0,4,0,10,255,255,255,255,0,23,
	0,65,0,0,0,0,50,44,0,2,0,9,0,8,3,2,0,18,
	255,255,255,255,0,23,0,65,0,0,0,0,50,30,0,12,0,9,
	0,8,3,2,0,19,255,255,255,255,0,23,0,65,0,0,0,0,
	50,16,0,21,0,9,0,8,3,2,0,20,255,255,255,255,0,23,
	0,65,0,0,0,0,50,2,0,33,0,9,0,8,3,2,0,21,
	255,255,255,255,0,23,0,65,0,0,0,0,49,244,0,45,0,9,
	0,8,3,2,0,24,255,255,255,255,0,23,0,65,0,0,0,0,
	49,174,0,1,0,12,0,8,3,2,0,25,255,255,255,255,0,23,
	0,65,0,0,0,0,49,188,0,10,0,12,0,8,3,2,0,26,
	255,255,255,255,0,23,0,65,0,0,0,0,49,202,0,20,0,12,
	0,10,3,2,0,27,255,255,255,255,0,23,0,65,0,0,0,0,
	49,216,0,31,0,12,0,10,3,2,0,22,255,255,255,255,0,23,
	0,65,0,0,0,0,49,230,0,42,0,13,0,10,3,2,0,23,
	255,255,255,255,0,23,0,65,0,0,0,0,49,160,0,2,0,16,
	0,8,3,2,0,28,255,255,255,255,0,23,0,65,0,0,0,0,
	49,146,0,11,0,15,0,8,1,3,0,13,255,255,255,255,0,23,
	0,65,0,0,0,0,50,86,0,16,0,5,0,6,3,3,0,12,
	255,255,255,255,0,23,0,65,0,0,0,0,49,118,0,31,0,15,
	0,6,3,3,0,31,255,255,255,255,0,23,0,65,0,0,0,0,
	49,104,0,42,0,17,0,12,3,1,255,255,0,1,0,34,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,52,0,21,0,3,
	0,2,0,2,0,20,0,0,0,0,0,255,17,0,0,3,0,6,
	0,3,0,1,0,1,255,255,255,255,0,28,0,0,0,0,0,0,
	11,17,0,0,0,0,0,3,0,1,0,4,255,255,255,255,0,28,
	0,0,0,0,0,0,11,21,0,3,0,3,0,3,0,1,0,5,
	255,255,255,255,0,28,0,0,0,0,0,0,11,25,0,1,0,4,
	0,7,0,1,0,6,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,16,0,12,0,2,0,1,0,8,0,7,0,7,0,20,
	0,64,0,0,0,255,17,17,0,16,0,6,0,2,0,6,0,6,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,9,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,16,0,5,0,2,0,1,0,10,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,26,0,12,0,2,0,1,0,12,
	0,11,0,11,0,20,0,64,0,0,0,255,17,17,0,26,0,6,
	0,2,0,6,0,10,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,2,0,2,0,1,0,13,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,26,0,5,0,2,0,1,0,14,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,36,0,12,
	0,2,0,1,0,16,0,15,0,15,0,20,0,64,0,0,0,255,
	17,17,0,36,0,6,0,2,0,6,0,14,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,17,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,36,0,5,
	0,2,0,1,0,18,255,255,255,255,0,28,0,0,0,0,0,0,
	11,33,0,14,0,1,0,23,0,1,0,21,0,19,0,19,0,20,
	0,0,0,0,0,255,17,0,0,16,0,14,0,2,0,1,0,18,
	0,20,0,20,0,20,0,0,0,0,0,255,17,0,0,0,0,0,
	0,2,0,1,0,19,255,255,255,255,0,28,0,0,0,0,0,0,
	11,57,0,0,0,0,0,2,0,1,0,23,0,22,0,22,0,20,
	0,0,0,0,0,255,17,0,0,26,0,14,0,2,0,1,0,21,
	255,255,255,255,0,28,0,0,0,0,0,0,11,60,0,0,0,0,
	0,2,0,1,0,25,0,24,0,24,0,20,0,0,0,0,0,255,
	17,0,0,36,0,14,0,2,0,1,0,23,255,255,255,255,0,28,
	0,0,0,0,0,0,11,63,0,0,0,0,0,2,0,1,0,26,
	255,255,255,255,0,28,0,0,0,0,0,0,11,66,0,13,0,3,
	0,8,0,1,0,27,255,255,255,255,0,28,0,0,0,0,0,0,
	11,75,0,23,0,3,0,9,0,1,0,28,255,255,255,255,0,28,
	0,0,0,0,0,0,11,85,0,33,0,3,0,10,0,1,0,29,
	255,255,255,255,0,26,0,67,0,0,0,0,11,95,0,9,0,19,
	0,8,0,1,0,30,255,255,255,255,0,26,0,65,0,0,0,0,
	11,98,0,35,0,19,0,8,0,1,0,31,255,255,255,255,0,29,
	0,8,0,0,0,0,51,12,0,11,0,16,0,21,0,1,0,33,
	0,32,0,32,0,20,0,64,0,0,0,255,17,17,0,4,0,9,
	0,2,0,3,0,31,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,1,0,2,0,1,0,34,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,4,0,12,0,2,0,1,0,0,
	255,255,255,255,0,27,0,96,0,0,1,255,17,0,0,4,0,8,
	0,2,0,1,255,255,0,1,0,4,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,31,0,11,0,2,255,255,255,255,0,26,
	0,65,0,0,0,0,11,149,0,6,0,3,0,19,0,1,0,3,
	255,255,255,255,0,26,0,65,0,0,0,0,11,169,0,6,0,5,
	0,19,0,1,0,4,255,255,255,255,0,26,0,65,0,0,0,0,
	11,184,0,6,0,7,0,19,0,1,0,0,255,255,255,255,0,28,
	0,32,0,0,0,0,11,200,0,6,0,1,0,20,0,1,255,255,
	0,1,0,9,0,20,0,0,0,16,0,2,17,0,0,0,0,0,
	0,28,0,12,0,2,255,255,255,255,0,28,0,0,0,0,0,0,
	11,221,0,5,0,1,0,20,0,1,0,3,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,9,0,3,0,2,0,1,0,5,
	0,4,0,4,0,20,0,64,0,0,0,255,17,17,0,9,0,4,
	0,2,0,4,0,3,255,255,255,255,0,20,0,0,0,0,0,255,
	17,0,0,0,0,1,0,2,0,1,0,6,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,9,0,8,0,2,0,1,0,8,
	0,7,0,7,0,20,0,0,0,0,0,255,17,0,0,9,0,10,
	0,2,0,1,0,6,255,255,255,255,0,28,0,0,0,0,0,0,
	11,242,0,0,0,0,0,2,0,1,0,9,255,255,255,255,0,26,
	0,65,0,0,0,0,11,245,0,16,0,4,0,8,0,1,0,0,
	255,255,255,255,0,26,0,97,0,0,0,0,11,248,0,16,0,7,
	0,8,0,1,255,255,0,1,0,23,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,44,0,18,0,3,0,2,0,2,0,20,
	0,64,0,0,0,255,17,17,0,9,0,6,0,2,0,6,0,1,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,3,
	0,2,0,1,0,5,0,4,0,4,0,20,0,64,0,0,0,255,
	17,17,0,19,0,6,0,2,0,6,0,3,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,3,0,2,0,1,0,6,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,19,0,12,
	0,2,0,1,0,7,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,9,0,12,0,2,0,1,0,8,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,19,0,5,0,2,0,1,0,9,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,9,0,5,
	0,2,0,1,0,11,0,10,0,10,0,20,0,0,0,0,0,255,
	17,0,0,19,0,14,0,2,0,1,0,9,255,255,255,255,0,28,
	0,0,0,0,0,0,11,255,0,0,0,0,0,2,0,1,0,13,
	0,12,0,12,0,20,0,0,0,0,0,255,17,0,0,9,0,14,
	0,2,0,1,0,11,255,255,255,255,0,28,0,0,0,0,0,0,
	12,2,0,0,0,0,0,2,0,1,0,17,0,14,0,16,0,20,
	0,0,0,0,0,255,17,0,0,26,0,10,0,14,0,3,0,15,
	255,255,255,255,0,28,0,0,0,0,0,0,12,5,0,2,0,1,
	0,9,0,1,0,16,255,255,255,255,0,28,0,0,0,0,0,0,
	12,15,0,4,0,2,0,6,0,1,0,13,255,255,255,255,0,28,
	0,0,0,0,0,0,12,21,0,3,0,0,0,7,0,1,0,18,
	255,255,255,255,0,28,0,0,0,0,0,0,12,29,0,4,0,3,
	0,11,0,1,0,19,255,255,255,255,0,28,0,0,0,0,0,0,
	12,41,0,17,0,3,0,6,0,1,0,20,255,255,255,255,0,28,
	0,0,0,0,0,0,12,48,0,27,0,8,0,11,0,1,0,21,
	255,255,255,255,0,26,0,67,0,0,0,0,12,60,0,6,0,16,
	0,8,0,1,0,22,255,255,255,255,0,26,0,65,0,0,0,0,
	12,63,0,29,0,16,0,8,0,1,0,23,255,255,255,255,0,28,
	0,0,0,0,0,0,12,70,0,10,0,1,0,27,0,1,0,0,
	255,255,255,255,0,28,0,32,0,0,0,0,12,98,0,27,0,7,
	0,12,0,1,255,255,0,1,0,4,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,33,0,10,0,2,255,255,255,255,0,28,
	0,0,0,0,0,0,12,111,0,4,0,1,0,26,0,1,0,3,
	255,255,255,255,0,26,0,65,0,0,0,0,12,138,0,5,0,3,
	0,24,0,1,0,4,255,255,255,255,0,26,0,65,0,0,0,0,
	12,153,0,5,0,5,0,24,0,1,0,0,255,255,255,255,0,26,
	0,97,0,0,0,0,12,171,0,13,0,7,0,8,0,1,255,255,
	0,1,0,27,0,20,0,0,0,16,0,2,17,0,0,0,0,0,
	0,33,0,20,0,2,255,255,255,255,0,26,0,65,0,0,0,0,
	12,178,0,19,0,17,0,8,0,1,0,3,255,255,255,255,0,26,
	0,67,0,0,0,0,12,185,0,5,0,17,0,8,0,1,0,5,
	0,4,0,4,0,20,0,64,0,0,0,255,17,17,0,7,0,6,
	0,2,0,6,0,3,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,3,0,2,0,1,0,8,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,7,0,12,0,2,0,1,0,27,
	0,7,0,7,0,20,0,0,0,0,0,255,17,0,0,6,0,14,
	0,3,0,1,0,6,255,255,255,255,0,28,0,0,0,0,0,0,
	12,254,0,0,0,0,0,3,0,1,0,9,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,7,0,5,0,2,0,1,0,10,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,17,0,5,
	0,2,0,1,0,12,0,11,0,11,0,20,0,64,0,0,0,255,
	17,17,0,17,0,6,0,2,0,6,0,10,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,3,0,2,0,1,0,13,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,17,0,12,
	0,2,0,1,0,15,0,14,0,14,0,20,0,0,0,0,0,255,
	17,0,0,17,0,14,0,2,0,1,0,13,255,255,255,255,0,28,
	0,0,0,0,0,0,12,188,0,0,0,0,0,2,0,1,0,16,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,25,0,12,
	0,2,0,1,0,18,0,17,0,17,0,20,0,64,0,0,0,255,
	17,17,0,25,0,10,0,2,0,2,0,16,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,1,0,2,0,1,0,19,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,25,0,9,
	0,2,0,1,0,21,0,20,0,20,0,20,0,0,0,0,0,255,
	17,0,0,24,0,14,0,4,0,1,0,19,255,255,255,255,0,28,
	0,0,0,0,0,0,12,191,0,0,0,0,0,4,0,1,0,22,
	255,255,255,255,0,28,0,0,0,0,0,0,12,196,0,4,0,1,
	0,24,0,1,0,23,255,255,255,255,0,28,0,0,0,0,0,0,
	12,221,0,11,0,2,0,10,0,1,0,24,255,255,255,255,0,28,
	0,0,0,0,0,0,12,232,0,24,0,7,0,6,0,1,0,25,
	255,255,255,255,0,28,0,0,0,0,0,0,12,237,0,23,0,6,
	0,6,0,1,0,26,255,255,255,255,0,28,0,0,0,0,0,0,
	12,244,0,3,0,3,0,8,0,1,0,6,255,255,255,255,0,28,
	0,0,0,0,0,0,12,253,6,1,3,0,2,1,1,0,0,0,
	255,255,255,255,0,28,0,32,0,0,0,0,13,2,0,14,0,3,
	0,9,0,1,255,255,0,2,0,24,0,20,0,0,0,16,0,2,
	17,0,0,0,0,0,0,57,0,20,0,11,255,255,255,255,0,28,
	0,0,0,0,0,0,13,15,0,5,0,3,0,4,0,1,0,3,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,6,0,13,
	0,2,0,1,0,5,0,4,0,4,0,20,0,64,0,0,0,255,
	17,17,0,6,0,6,0,2,0,7,0,3,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,3,0,2,0,1,0,6,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,6,0,5,
	0,2,0,1,0,1,0,7,0,7,0,20,0,0,0,0,0,255,
	17,0,0,6,0,15,0,2,0,1,0,6,255,255,255,255,0,28,
	0,0,0,0,0,0,13,12,0,0,0,0,0,2,0,1,0,15,
	255,255,255,255,0,28,0,0,0,0,0,0,13,31,0,12,0,4,
	0,20,0,1,0,24,255,255,255,255,0,26,0,67,0,0,0,0,
	13,82,0,13,0,18,0,8,0,1,0,9,255,255,255,255,0,26,
	0,65,0,0,0,0,13,75,0,35,0,18,0,8,0,1,0,8,
	0,12,0,12,0,20,0,0,0,0,0,255,17,0,0,17,0,6,
	0,10,0,1,0,11,255,255,255,255,0,28,0,0,0,0,0,0,
	13,20,0,0,0,0,0,10,0,1,0,16,0,14,0,14,0,20,
	0,0,0,0,0,255,17,0,0,40,0,6,0,6,0,1,0,13,
	255,255,255,255,0,28,0,0,0,0,0,0,13,68,0,0,0,0,
	0,6,0,1,0,13,255,255,255,255,0,28,0,0,0,0,0,0,
	13,52,0,37,0,4,0,15,0,1,0,17,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,20,0,9,0,2,0,1,0,19,
	0,18,0,18,0,20,0,64,0,0,0,255,17,17,0,20,0,10,
	0,2,0,3,0,17,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,1,0,2,0,1,0,20,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,20,0,13,0,2,0,1,0,21,
	255,255,255,255,0,27,0,64,0,0,1,255,17,0,0,42,0,9,
	0,2,0,1,0,23,0,22,0,22,0,20,0,64,0,0,0,255,
	17,17,0,42,0,10,0,2,0,3,0,21,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,1,0,2,0,1,0,10,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,42,0,13,
	0,2,0,1,0,0,255,255,255,255,0,28,0,32,0,0,0,0,
	13,85,0,17,0,1,0,21,0,1,255,255,0,1,0,42,0,20,
	0,0,0,16,0,2,17,0,0,0,0,0,0,58,0,19,0,2,
	255,255,255,255,0,28,0,0,0,0,0,0,13,107,0,17,0,1,
	0,21,0,1,0,3,255,255,255,255,0,26,0,65,0,0,0,0,
	13,129,0,5,0,4,0,3,0,1,0,4,255,255,255,255,0,26,
	0,65,0,0,0,0,13,131,0,9,0,4,0,3,0,1,0,5,
	255,255,255,255,0,26,0,65,0,0,0,0,13,134,0,13,0,4,
	0,3,0,1,0,6,255,255,255,255,0,26,0,65,0,0,0,0,
	13,136,0,17,0,4,0,3,0,1,0,7,255,255,255,255,0,26,
	0,65,0,0,0,0,13,139,0,21,0,4,0,3,0,1,0,8,
	255,255,255,255,0,26,0,65,0,0,0,0,13,141,0,25,0,4,
	0,3,0,1,0,9,255,255,255,255,0,26,0,65,0,0,0,0,
	13,143,0,29,0,4,0,3,0,1,0,10,255,255,255,255,0,26,
	0,65,0,0,0,0,13,146,0,33,0,4,0,3,0,1,0,11,
	255,255,255,255,0,26,0,65,0,0,0,0,13,148,0,37,0,4,
	0,3,0,1,0,12,255,255,255,255,0,26,0,65,0,0,0,0,
	13,151,0,41,0,4,0,3,0,1,0,13,255,255,255,255,0,26,
	0,65,0,0,0,0,13,153,0,45,0,4,0,3,0,1,0,14,
	255,255,255,255,0,26,0,65,0,0,0,0,13,156,0,49,0,4,
	0,3,0,1,0,19,255,255,255,255,0,28,0,0,0,0,0,0,
	13,158,0,15,0,3,0,26,0,1,0,16,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,2,0,8,0,4,0,1,0,18,
	0,17,0,17,0,20,0,0,0,0,0,255,17,0,0,6,0,8,
	0,5,0,1,0,16,255,255,255,255,0,28,0,0,0,0,0,0,
	13,241,0,0,0,0,0,5,0,1,0,39,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,11,0,8,0,4,0,1,0,23,
	255,255,255,255,0,28,0,0,0,0,0,0,13,185,0,17,0,7,
	0,11,0,1,0,21,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,17,0,8,0,4,0,1,0,22,0,41,0,41,0,20,
	0,0,0,0,0,255,17,0,0,21,0,8,0,2,0,1,0,15,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,23,0,8,
	0,4,0,1,0,24,255,255,255,255,0,26,0,65,0,0,0,0,
	13,197,0,4,0,17,0,8,0,1,0,25,255,255,255,255,0,26,
	0,65,0,0,0,0,13,202,0,46,0,17,0,8,0,1,0,27,
	255,255,255,255,0,26,0,67,0,0,0,0,13,209,0,25,0,17,
	0,8,0,1,0,31,255,255,255,255,0,28,0,0,0,0,0,0,
	13,212,0,46,0,6,0,6,0,1,0,28,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,48,0,7,0,2,0,1,0,29,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,48,0,13,
	0,2,0,1,0,26,0,30,0,30,0,20,0,64,0,0,0,255,
	17,17,0,48,0,8,0,2,0,5,0,29,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,2,0,2,0,1,0,35,
	255,255,255,255,0,28,0,0,0,0,0,0,13,218,0,37,0,6,
	0,8,0,1,0,42,0,33,0,33,0,20,0,0,0,0,0,255,
	17,0,0,47,0,15,0,3,0,1,0,32,255,255,255,255,0,28,
	0,0,0,0,0,0,13,251,0,0,0,0,0,3,0,1,0,20,
	255,255,255,255,0,28,0,0,0,0,0,0,13,227,0,4,0,7,
	0,10,0,1,0,36,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,40,0,7,0,2,0,1,0,38,0,37,0,37,0,20,
	0,64,0,0,0,255,17,17,0,40,0,8,0,2,0,5,0,36,
	255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,0,2,
	0,2,0,1,0,34,255,255,255,255,0,27,0,64,0,0,2,255,
	17,0,0,40,0,13,0,2,0,1,0,32,0,40,0,40,0,20,
	0,0,0,0,0,255,17,0,0,39,0,15,0,3,0,1,0,39,
	255,255,255,255,0,28,0,0,0,0,0,0,13,247,0,0,0,0,
	0,3,0,1,0,21,255,255,255,255,0,28,0,0,0,0,0,0,
	13,238,0,0,0,0,0,2,0,1,0,0,255,255,255,255,0,28,
	0,32,0,16,0,0,13,255,0,3,0,12,0,30,0,1,255,255,
	0,1,0,23,0,20,0,0,0,16,0,2,17,0,0,0,0,0,
	0,44,0,18,0,3,0,2,0,2,0,20,0,64,0,0,0,255,
	17,17,0,9,0,6,0,2,0,6,0,1,255,255,255,255,0,20,
	0,64,0,0,0,255,17,0,0,0,0,3,0,2,0,1,0,5,
	0,4,0,4,0,20,0,64,0,0,0,255,17,17,0,19,0,6,
	0,2,0,6,0,3,255,255,255,255,0,20,0,64,0,0,0,255,
	17,0,0,0,0,3,0,2,0,1,0,6,255,255,255,255,0,27,
	0,64,0,0,2,255,17,0,0,19,0,12,0,2,0,1,0,7,
	255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,9,0,12,
	0,2,0,1,0,8,255,255,255,255,0,27,0,64,0,0,1,255,
	17,0,0,19,0,5,0,2,0,1,0,9,255,255,255,255,0,27,
	0,64,0,0,1,255,17,0,0,9,0,5,0,2,0,1,0,11,
	0,10,0,10,0,20,0,0,0,0,0,255,17,0,0,19,0,14,
	0,2,0,1,0,9,255,255,255,255,0,28,0,0,0,0,0,0,
	14,30,0,0,0,0,0,2,0,1,0,13,0,12,0,12,0,20,
	0,0,0,0,0,255,17,0,0,9,0,14,0,2,0,1,0,11,
	255,255,255,255,0,28,0,0,0,0,0,0,14,33,0,0,0,0,
	0,2,0,1,0,17,0,14,0,16,0,20,0,0,0,0,0,255,
	17,0,0,26,0,10,0,14,0,3,0,15,255,255,255,255,0,28,
	0,0,0,0,0,0,14,36,0,3,0,0,0,7,0,1,0,16,
	255,255,255,255,0,28,0,0,0,0,0,0,14,44,0,2,0,1,
	0,9,0,1,0,13,255,255,255,255,0,28,0,0,0,0,0,0,
	14,54,0,4,0,2,0,6,0,1,0,18,255,255,255,255,0,28,
	0,0,0,0,0,0,14,60,0,4,0,3,0,11,0,1,0,19,
	255,255,255,255,0,28,0,0,0,0,0,0,14,72,0,17,0,3,
	0,6,0,1,0,20,255,255,255,255,0,28,0,0,0,0,0,0,
	14,79,0,27,0,8,0,11,0,1,0,21,255,255,255,255,0,26,
	0,67,0,0,0,0,14,91,0,6,0,16,0,8,0,1,0,22,
	255,255,255,255,0,28,0,0,0,0,0,0,14,94,0,10,0,1,
	0,24,0,1,0,23,255,255,255,255,0,28,0,0,0,0,0,0,
	14,118,0,27,0,7,0,12,0,1,0,0,255,255,255,255,0,26,
	0,97,0,0,0,0,14,131,0,29,0,16,0,8,0,1,0,0,
	81,232,0,0,65,8,0,0,55,96,0,0,59,224,0,0,95,200,
	0,0,72,136,0,0,87,232,0,0,63,40,0,0,104,224,0,0,
	114,232,0,0,100,24,0,0,109,144,0,0,121,72,0,0,112,72,
	0,0,93,136,0,0,77,224,0,0,98,128,0,0,70,216,0,0,
	108,40,0,0,80,32,0,0,101,200,0,0,51,40,0,0,108,160,
	0,0,111,208,0,0,117,64
};
