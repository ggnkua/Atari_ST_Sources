#define ARRANGE 21
#define PORT_MD 14
#define PORT_B2 13
#define SCL_F 7
#define SCL_E 6
#define SLIDER45 4
#define PO_POLYB 19
#define UP52 18
#define ARR_VBOX 2
#define UP54 16
#define SCL_FS 8
#define DN44 6
#define DN45 5
#define PO_POLY 20
#define AR_VN03 3
#define TRACK54 17
#define SCL_G 9
#define UP45 7
#define AR_VN04 4
#define DN54 19
#define SLIDER54 18
#define SCL_A 11
#define SCL_GS 10
#define UP44 8
#define SCALING 2
#define AR_VN06 6
#define AR_VN05 5
#define UP55 20
#define SCL_AS 12
#define NUMBER45 10
#define BN45 9
#define DN8 1
#define AR_VN07 7
#define TRACK55 21
#define SCL_B 13
#define BN44 11
#define DN12 2
#define AR_VN08 8
#define DN55 23
#define SLIDER55 22
#define NUMBER44 12
#define FREQENCY 3
#define BN50 6
#define OPR_OP1 1
#define OPERATOR 7
#define DN10 4
#define DN11 3
#define AR_VN10 10
#define AR_VN09 9
#define PORT_CAN 10
#define SCLPLAY 23
#define FC_EGB 14
#define FC_BOX 13
#define DN19 1
#define NUMBER50 7
#define OPR_OP2 2
#define DN13 5
#define AR_VN11 11
#define PORT_OK 9
#define SCLCAN 24
#define FC_AMPL 15
#define DN18 3
#define DN20 2
#define OPR_OP3 3
#define DN9 6
#define AR_VN12 12
#define SCL_UP1 27
#define SCLOK 25
#define FC_PITCH 16
#define TRACK18 4
#define OPR_OP5 5
#define OPR_OP4 4
#define SLIDER8 8
#define TRACK8 7
#define AR_VN14 14
#define AR_VN13 13
#define SCL_DN1 28
#define SLIDER18 5
#define OPR_OP6 6
#define TRACK9 9
#define AR_VN15 15
#define SCL_TK1 29
#define SLIDER19 7
#define TRACK19 6
#define OPR_1_ON 7
#define SLIDER9 10
#define AR_VN16 16
#define SCL_SL1 30
#define FC_OK 20
#define TRACK20 8
#define OPR_3_ON 9
#define OPR_2_ON 8
#define SLIDER10 12
#define TRACK10 11
#define AR_VN18 18
#define AR_VN17 17
#define SLIDER20 9
#define OPR_4_ON 10
#define TRACK11 13
#define AR_VN19 19
#define SCL_UP0 35
#define FC_CAN 23
#define TRACK17 11
#define DN17 10
#define OPR_5_ON 11
#define SLIDER11 14
#define AR_VN20 20
#define SCL_SL0 37
#define SCL_TK0 36
#define SLIDER17 12
#define OPR_OK 13
#define OPR_6_ON 12
#define SLIDER12 16
#define TRACK12 15
#define AR_VN24 22
#define AR_VN23 21
#define SCL_DN0 38
#define UP20 13
#define OPR_CAN 14
#define TRACK13 17
#define AR_VN25 23
#define UP19 15
#define UP17 14
#define SLIDER13 18
#define AR_VN26 24
#define SCL_NOBN 21
#define SCL_NOUP 20
#define UP18 16
#define UP9 20
#define UP8 19
#define AR_VN28 26
#define AR_VN27 25
#define SCL_NONM 41
#define BN17 17
#define UP10 21
#define AR_VN29 27
#define SCL_NODN 22
#define BN20 19
#define NUMBER17 18
#define UP11 22
#define AR_VN31 28
#define SCL_SNBN 16
#define SCL_SNUP 15
#define NUMBER20 20
#define UP13 24
#define UP12 23
#define AR_VN02 30
#define AR_VN32 29
#define SCL_SNNM 17
#define BN19 21
#define SCALE_NM 25
#define AR_VN22 31
#define SCL_SNDN 18
#define BN18 23
#define NUMBER19 22
#define AR_VN01 32
#define SCL_NM0 40
#define SCL_BN0 39
#define NUMBER18 24
#define BN13 28
#define AR_VN30 34
#define AR_VN21 33
#define SCL_BN1 32
#define NUMBER13 29
#define AR_SAVE 35
#define SCL_NM1 33
#define FREQ_NUM 26
#define BN9 36
#define AR_LDBNK 36
#define SCLSTPMS 42
#define ENVELOPE 1
#define NUMBER9 37
#define AR_LDVCE 38
#define AR_EXIT 37
#define DN3 1
#define DN2 3
#define DN4 2
#define FREQ_XIT 31
#define DN5 4
#define FREQ_CAN 32
#define TRACK2 5
#define FREQ_BOX 33
#define SET_MIDI 17
#define TRACK3 7
#define SLIDER2 6
#define FREQ_VAL 34
#define CH_1 1
#define SCALEXIT 46
#define SLIDER3 8
#define CH_3 3
#define CH_2 2
#define BN8 38
#define SCALECAN 47
#define TRACK4 9
#define CH_4 4
#define NUMBER8 39
#define LFO 5
#define TRACK5 11
#define SLIDER4 10
#define CH_8 5
#define BN10 34
#define DN29 1
#define SLIDER5 12
#define CH_6 7
#define CH_7 6
#define BN11 32
#define NUMBER10 35
#define TRACK29 2
#define UP5 13
#define CH_5 8
#define NUMBER11 33
#define UP29 4
#define SLIDER29 3
#define UP3 15
#define UP4 14
#define CH_9 9
#define BN12 30
#define BN29 5
#define UP2 16
#define CH_11 11
#define CH_10 10
#define NUMBER12 31
#define NUMBER29 6
#define DN6 17
#define CH_12 12
#define AFTR_TCH 15
#define BN30 8
#define SLIDER6 19
#define TRACK6 18
#define CH_16 13
#define TRACK46 1
#define NUMBER30 9
#define UP6 20
#define CH_14 15
#define CH_15 14
#define SLIDER46 2
#define BN31 10
#define DN7 21
#define CH_13 16
#define SLIDER47 4
#define TRACK47 3
#define BN32 12
#define NUMBER31 11
#define TRACK7 23
#define UP7 22
#define V_SEL 19
#define DN47 5
#define NUMBER32 13
#define SLIDER7 24
#define VSELBOX 3
#define VS_OK 1
#define DN46 6
#define BN33 14
#define TRACK1 25
#define VSELNM1 4
#define UP46 8
#define UP47 7
#define BN35 16
#define NUMBER33 15
#define DN1 27
#define SLIDER1 26
#define VSELNM2 5
#define BN47 9
#define NUMBER35 17
#define UP1 28
#define VSELNM4 7
#define VSELNM3 6
#define NUMBER47 10
#define MOD_OK 18
#define UP0 29
#define VSELNM5 8
#define NUMBER46 12
#define BN46 11
#define DN35 20
#define MOD_CAN 19
#define TRACK0 31
#define DN0 30
#define VSELNM6 9
#define AT_BOX 13
#define UP35 21
#define SLIDER0 32
#define VSELNM8 11
#define VSELNM7 10
#define AT_EGB 14
#define TRACK35 22
#define ENVEL_OK 33
#define VSELNM9 12
#define AT_PITCH 16
#define AT_AMPL 15
#define DN34 24
#define SLIDER35 23
#define ENVELCAN 34
#define VSELNM10 13
#define UP34 25
#define MENU_TRE 0
#define VSELTRK 15
#define VSELUP 14
#define TRACK34 26
#define VSELSLID 16
#define AT_OK 20
#define UP33 28
#define SLIDER34 27
#define M_DESK 3
#define VSELDN 17
#define AT_CAN 21
#define DN33 29
#define M_FILE 4
#define VS_CAN 2
#define VSELNAME 18
#define TRACK33 30
#define M_MIDI 5
#define UP32 32
#define SLIDER33 31
#define M_EDIT 7
#define M_ED 6
#define DN32 33
#define M_MODULA 8
#define BN0 47
#define TRACK32 34
#define M_PERFRM 9
#define NUMBER0 48
#define UP31 36
#define SLIDER32 35
#define M_PLAY 10
#define NUMBER1 50
#define BN1 49
#define DN31 37
#define BN2 35
#define TRACK31 38
#define M_D_INFO 13
#define NUMBER2 36
#define TRACK30 40
#define SLIDER31 39
#define NUMBER3 38
#define BN3 37
#define SLIDER30 41
#define BN4 39
#define DN30 42
#define NUMBER4 40
#define DN24 1
#define P_ENVEL 6
#define UP30 43
#define NUMBER5 42
#define BN5 41
#define DN25 2
#define BN6 43
#define DN23 3
#define NUMBER6 44
#define TRACK23 5
#define DN26 4
#define M_F_NEW 23
#define M_F_OPEN 22
#define NUMBER7 46
#define BN7 45
#define SLIDER23 6
#define BREATH 14
#define TRACK24 7
#define M_F_SBNK 25
#define EN_OPNNM 59
#define TRACK48 1
#define TRACK25 9
#define SLIDER24 8
#define SENSITIV 4
#define NUMBER34 52
#define BN34 51
#define M_F_ARNG 26
#define SLIDER48 2
#define SLIDER25 10
#define DN14 1
#define M_F_DATA 28
#define SLIDER49 4
#define TRACK49 3
#define TRACK26 11
#define ABOUT_DX 16
#define SLIDER14 3
#define TRACK14 2
#define M_F_CAT 29
#define DN49 5
#define UP26 13
#define SLIDER26 12
#define TRACK15 4
#define M_F_QUIT 31
#define DN48 6
#define UP25 14
#define SLIDER15 5
#define UP48 8
#define UP49 7
#define UP24 15
#define TRACK16 7
#define DN15 6
#define M_M_SBNK 33
#define BN49 9
#define DN27 17
#define UP23 16
#define SLIDER16 8
#define M_M_PATC 35
#define M_M_SMCH 34
#define NUMBER49 10
#define TRACK27 18
#define DN16 9
#define NUMBER48 12
#define BN48 11
#define SLIDER27 19
#define UP15 11
#define UP14 10
#define ED_VOICE 37
#define BT_BOX 13
#define DN28 21
#define UP27 20
#define UP16 12
#define ED_SAVE 38
#define BT_EGB 14
#define UP28 22
#define ABOUT_OK 14
#define BN14 13
#define M_O_ENVL 40
#define BT_PITCH 16
#define BT_AMPL 15
#define TRACK28 23
#define BN16 15
#define NUMBER14 14
#define M_O_SCAL 41
#define TRACK22 25
#define SLIDER28 24
#define NUMBER16 16
#define PTCH_BND 10
#define M_O_SENS 43
#define M_O_FREQ 42
#define SLIDER22 26
#define BN15 17
#define M_O_OPR 44
#define BT_OK 20
#define DN22 27
#define VERSION 16
#define NUMBER15 18
#define DN41 3
#define DN40 2
#define ALGORITH 20
#define BT_CAN 21
#define UP21 29
#define UP22 28
#define SENS_NUM 20
#define TRACK41 4
#define AL15 2
#define AL14 1
#define M_MD_LFO 47
#define M_MD_PEV 46
#define DN21 30
#define SLIDER41 5
#define AL06 4
#define M_MD_ALG 48
#define TRACK21 31
#define SLIDER40 7
#define TRACK40 6
#define AL04 9
#define M_MD_OTH 49
#define PEV_OK 33
#define SLIDER21 32
#define UP40 8
#define AL19 31
#define AL32 32
#define M_PR_PRT 51
#define PEV_CAN 34
#define UP41 9
#define AL28 12
#define M_PR_BND 52
#define SEN_XIT 27
#define NUMBER40 11
#define BN40 10
#define AL30 29
#define M_PR_MWH 53
#define O_B_KYSN 1
#define M_OTHER 8
#define SEN_CAN 28
#define BN41 12
#define AL26 23
#define AL29 28
#define M_PR_AFT 55
#define M_PR_FCT 54
#define O_KEYSYN 2
#define SEL_FUNC 18
#define NUMBER41 13
#define AL27 24
#define M_PR_BTH 56
#define E_FBULK 1
#define AL24 25
#define M_PR_OTH 57
#define DN36 5
#define E_DXBULK 2
#define PB_OK 16
#define AL31 27
#define AL25 26
#define PLAYSCAL 59
#define TRACK36 6
#define E_NEWVOI 3
#define PB_CAN 17
#define AL23 22
#define PLAYMS 60
#define SLIDER36 7
#define PATCHSEL 22
#define AL22 21
#define DN37 9
#define UP36 8
#define NUMBER21 45
#define BN21 44
#define PS_UP 2
#define AL13 19
#define AL21 20
#define PLAY_PB 63
#define PLAY_REC 62
#define TRACK37 10
#define BN22 46
#define PS_TRACK 3
#define AL12 18
#define SLIDER37 11
#define NUMBER22 47
#define MOD_WHEL 11
#define PS_SLIDE 4
#define AL07 10
#define DN38 13
#define UP37 12
#define NUMBER23 49
#define BN23 48
#define TRACK42 1
#define PS_BN 6
#define PS_DN 5
#define AL09 30
#define AL08 11
#define TRACK38 14
#define BN24 50
#define SLIDER42 2
#define PS_NUM 7
#define AL10 13
#define SLIDER38 15
#define NUMBER24 51
#define SLIDER43 4
#define TRACK43 3
#define PS_OK 8
#define AL11 14
#define UP38 16
#define NUMBER25 53
#define BN25 52
#define DN43 5
#define PS_CAN 9
#define AL16 16
#define AL17 15
#define SAVE_SEL 23
#define BN26 54
#define DN42 6
#define AL18 17
#define BN36 19
#define NUMBER26 55
#define UP42 8
#define UP43 7
#define AL20 5
#define SS_BUFF 3
#define SS_DX 2
#define BN37 21
#define NUMBER36 20
#define NUMBER27 57
#define BN27 56
#define BN43 9
#define AL02 6
#define AL03 8
#define SS_CAN 4
#define NUMBER37 22
#define BN28 58
#define NUMBER43 10
#define AL01 7
#define BN38 23
#define NUMBER28 59
#define NUMBER42 12
#define BN42 11
#define AL05 3
#define NUMBER38 24
#define MW_BOX 13
#define MW_AMPL 14
#define MW_EGB 16
#define MW_PITCH 15
#define OTH_CAN 29
#define OTH_OK 28
#define O_VNAME 30
#define PO_CAN 1
#define P_OTHER 13
#define TRACK53 31
#define PO_OK 2
#define MW_OK 20
#define DN53 33
#define SLIDER53 32
#define TRACK50 3
#define MW_CAN 21
#define DN39 2
#define PORTAMEN 9
#define UP53 34
#define DN50 5
#define SLIDER50 4
#define TRACK39 3
#define UP50 8
#define SLIDER39 4
#define UP51 9
#define BN39 6
#define UP39 5
#define SLIDER51 11
#define TRACK51 10
#define NUMBER39 7
#define SCALES 24
#define DN51 12
#define BN51 13
#define PORT_GLS 12
#define PORT_B1 11
#define SCL_CS 3
#define SCL_C 2
#define FOOT_CTL 12
#define DN52 15
#define NUMBER51 14
#define SCL_D 4
#define SLIDER44 2
#define TRACK44 1
#define TRACK52 16
#define SCL_DS 5
#define TRACK45 3
#define SLIDER52 17
extern unsigned char DXED1RSC[];
