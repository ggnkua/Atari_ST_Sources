#define UP12 23
#define OPR_OP4 4
#define NUMBER19 22
#define UP13 24
#define OPR_OP6 6
#define OPR_OP5 5
#define BN18 23
#define DN40 2
#define CH_1 1
#define SET_MIDI 17
#define SCALE_NM 25
#define OPR_1_ON 7
#define NUMBER18 24
#define TRACK41 4
#define DN41 3
#define CH_2 2
#define OPR_2_ON 8
#define FREQ_NUM 26
#define SLIDER41 5
#define CH_3 3
#define BN13 28
#define OPR_4_ON 10
#define OPR_3_ON 9
#define TRACK40 6
#define CH_8 5
#define CH_4 4
#define BN9 36
#define NUMBER13 29
#define OPR_5_ON 11
#define TRACK46 1
#define AFTR_TCH 15
#define UP40 8
#define SLIDER40 7
#define SEL_FUNC 18
#define CH_7 6
#define NUMBER9 37
#define OPR_6_ON 12
#define SLIDER46 2
#define UP41 9
#define E_FBULK 1
#define CH_6 7
#define OPR_CAN 14
#define OPR_OK 13
#define TRACK47 3
#define FREQ_XIT 31
#define BN40 10
#define E_DXBULK 2
#define CH_9 9
#define CH_5 8
#define DN47 5
#define SLIDER47 4
#define FREQ_BOX 33
#define FREQ_CAN 32
#define BN41 12
#define NUMBER40 11
#define E_NEWVOI 3
#define CH_10 10
#define DN46 6
#define FREQ_VAL 34
#define NUMBER41 13
#define CH_11 11
#define UP47 7
#define CH_16 13
#define CH_12 12
#define SCALEXIT 46
#define BN47 9
#define UP46 8
#define PB_OK 16
#define ABOUT_DX 16
#define CH_15 14
#define SCALECAN 47
#define NUMBER47 10
#define PB_CAN 17
#define CH_14 15
#define BN8 38
#define BN46 11
#define CH_13 16
#define BN10 34
#define NUMBER8 39
#define AT_BOX 13
#define NUMBER46 12
#define NUMBER10 35
#define AT_EGB 14
#define BN11 32
#define AT_AMPL 15
#define BN12 30
#define NUMBER11 33
#define AT_PITCH 16
#define NUMBER12 31
#define ABOUT_OK 14
#define AT_CAN 21
#define AT_OK 20
#define LFO 5
#define TRACK29 2
#define DN29 1
#define SLIDER29 3
#define VERSION 16
#define UP29 4
#define NUMBER29 6
#define BN29 5
#define BN30 8
#define BN31 10
#define NUMBER30 9
#define NUMBER31 11
#define SAVE_SEL 23
#define BN32 12
#define BN33 14
#define NUMBER32 13
#define SS_DX 2
#define M_OTHER 8
#define NUMBER33 15
#define SS_CAN 4
#define SS_BUFF 3
#define ENVELOPE 1
#define O_B_KYSN 1
#define BN35 16
#define DN4 2
#define DN3 1
#define O_KEYSYN 2
#define MOD_OK 18
#define NUMBER35 17
#define DN2 3
#define MOD_CAN 19
#define DN5 4
#define DN36 5
#define DN35 20
#define SLIDER2 6
#define TRACK2 5
#define TRACK36 6
#define TRACK35 22
#define UP35 21
#define TRACK3 7
#define UP36 8
#define SLIDER36 7
#define SLIDER35 23
#define SLIDER3 8
#define DN37 9
#define DN34 24
#define SLIDER4 10
#define TRACK4 9
#define TRACK37 10
#define TRACK34 26
#define UP34 25
#define TRACK5 11
#define UP37 12
#define SLIDER37 11
#define SLIDER34 27
#define SLIDER5 12
#define DN38 13
#define UP33 28
#define UP4 14
#define UP5 13
#define TRACK38 14
#define TRACK33 30
#define DN33 29
#define UP3 15
#define UP38 16
#define SLIDER38 15
#define SLIDER33 31
#define UP2 16
#define UP32 32
#define TRACK6 18
#define DN6 17
#define TRACK32 34
#define DN32 33
#define SLIDER6 19
#define NUMBER36 20
#define BN36 19
#define SLIDER32 35
#define UP6 20
#define BN37 21
#define UP31 36
#define UP7 22
#define DN7 21
#define NUMBER37 22
#define TRACK31 38
#define DN31 37
#define BREATH 14
#define TRACK7 23
#define NUMBER38 24
#define BN38 23
#define SLIDER31 39
#define TRACK48 1
#define SLIDER7 24
#define TRACK30 40
#define TRACK49 3
#define SLIDER48 2
#define SLIDER1 26
#define TRACK1 25
#define DN30 42
#define SLIDER30 41
#define SLIDER49 4
#define DN1 27
#define OTH_OK 28
#define UP30 43
#define DN49 5
#define UP1 28
#define OTH_CAN 29
#define UP49 7
#define DN48 6
#define DN0 30
#define UP0 29
#define O_VNAME 30
#define UP48 8
#define TRACK0 31
#define SLIDER53 32
#define TRACK53 31
#define BN49 9
#define SLIDER0 32
#define ARRANGE 21
#define DN53 33
#define BN48 11
#define NUMBER49 10
#define ENVELCAN 34
#define ENVEL_OK 33
#define ARR_VBOX 2
#define UP53 34
#define NUMBER48 12
#define AR_VN03 3
#define BN34 51
#define BT_BOX 13
#define AR_VN04 4
#define NUMBER34 52
#define BT_AMPL 15
#define BT_EGB 14
#define AR_VN06 6
#define AR_VN05 5
#define BT_PITCH 16
#define AR_VN07 7
#define AR_VN08 8
#define AR_VN10 10
#define AR_VN09 9
#define BT_OK 20
#define AR_VN11 11
#define BT_CAN 21
#define BN0 47
#define AR_VN12 12
#define BN1 49
#define NUMBER0 48
#define AR_VN14 14
#define AR_VN13 13
#define NUMBER1 50
#define AR_VN15 15
#define BN2 35
#define AR_VN16 16
#define DN39 2
#define PORTAMEN 9
#define BN3 37
#define NUMBER2 36
#define AR_VN18 18
#define AR_VN17 17
#define TRACK39 3
#define NUMBER3 38
#define AR_VN19 19
#define SLIDER39 4
#define BN4 39
#define AR_VN20 20
#define BN39 6
#define UP39 5
#define BN5 41
#define NUMBER4 40
#define AR_VN24 22
#define AR_VN23 21
#define NUMBER39 7
#define NUMBER5 42
#define AR_VN25 23
#define BN6 43
#define AR_VN26 24
#define PORT_GLS 12
#define PORT_B1 11
#define BN7 45
#define NUMBER6 44
#define P_ENVEL 6
#define AR_VN28 26
#define AR_VN27 25
#define MOD_WHEL 11
#define NUMBER7 46
#define DN24 1
#define AR_VN29 27
#define TRACK42 1
#define DN25 2
#define AR_VN31 28
#define PORT_MD 14
#define PORT_B2 13
#define TRACK43 3
#define SLIDER42 2
#define EN_OPNNM 59
#define DN26 4
#define DN23 3
#define AR_VN02 30
#define AR_VN32 29
#define MENU_TRE 0
#define UP54 16
#define SLIDER43 4
#define TRACK23 5
#define AR_VN22 31
#define TRACK54 17
#define DN43 5
#define PO_CAN 1
#define P_OTHER 13
#define SLIDER23 6
#define AR_VN01 32
#define M_DESK 3
#define DN54 19
#define SLIDER54 18
#define UP43 7
#define DN42 6
#define PO_OK 2
#define SLIDER24 8
#define TRACK24 7
#define AR_VN30 34
#define AR_VN21 33
#define M_MIDI 5
#define M_FILE 4
#define UP55 20
#define UP42 8
#define TRACK50 3
#define TRACK25 9
#define AR_SAVE 35
#define M_ED 6
#define V_SEL 19
#define TRACK55 21
#define BN43 9
#define DN50 5
#define SLIDER50 4
#define SLIDER25 10
#define AR_LDBNK 36
#define M_EDIT 7
#define VS_CAN 2
#define DN55 23
#define SLIDER55 22
#define BN42 11
#define NUMBER43 10
#define UP50 8
#define SLIDER26 12
#define TRACK26 11
#define AR_LDVCE 38
#define AR_EXIT 37
#define M_PERFRM 9
#define M_MODULA 8
#define VS_OK 1
#define PORT_CAN 10
#define NUMBER42 12
#define UP51 9
#define UP26 13
#define M_PLAY 10
#define PORT_OK 9
#define MW_BOX 13
#define SLIDER51 11
#define TRACK51 10
#define UP25 14
#define MW_PITCH 15
#define MW_AMPL 14
#define DN51 12
#define UP23 16
#define UP24 15
#define M_D_INFO 13
#define MW_EGB 16
#define BN51 13
#define DN27 17
#define DN52 15
#define NUMBER51 14
#define TRACK27 18
#define TRACK52 16
#define UP27 20
#define SLIDER27 19
#define MW_OK 20
#define SLIDER52 17
#define DN28 21
#define MW_CAN 21
#define PO_POLYB 19
#define UP52 18
#define UP28 22
#define PO_POLY 20
#define SLIDER28 24
#define TRACK28 23
#define TRACK22 25
#define M_F_OPEN 22
#define SLIDER22 26
#define M_F_NEW 23
#define UP22 28
#define DN22 27
#define M_F_SBNK 25
#define UP21 29
#define M_F_ARNG 26
#define BN50 6
#define DN21 30
#define NUMBER50 7
#define SLIDER21 32
#define TRACK21 31
#define M_F_QUIT 28
#define PEV_OK 33
#define M_M_SBNK 30
#define PEV_CAN 34
#define M_M_SMCH 31
#define M_M_PATC 32
#define FOOT_CTL 12
#define PATCHSEL 22
#define ED_VOICE 34
#define TRACK44 1
#define ED_SAVE 35
#define SLIDER44 2
#define SENSITIV 4
#define PS_UP 2
#define M_O_ENVL 37
#define SLIDER45 4
#define TRACK45 3
#define DN14 1
#define PS_SLIDE 4
#define PS_TRACK 3
#define M_O_SCAL 38
#define DN45 5
#define SLIDER14 3
#define TRACK14 2
#define PS_DN 5
#define M_O_FREQ 39
#define DN44 6
#define TRACK15 4
#define PS_BN 6
#define BN21 44
#define M_O_OPR 41
#define M_O_SENS 40
#define UP44 8
#define UP45 7
#define SLIDER15 5
#define PS_OK 8
#define PS_NUM 7
#define NUMBER21 45
#define BN45 9
#define TRACK16 7
#define DN15 6
#define PS_CAN 9
#define BN22 46
#define M_MD_PEV 43
#define NUMBER45 10
#define SLIDER16 8
#define SCALING 2
#define BN23 48
#define NUMBER22 47
#define M_MD_OTH 45
#define M_MD_LFO 44
#define NUMBER44 12
#define BN44 11
#define DN16 9
#define DN12 2
#define DN8 1
#define NUMBER23 49
#define DN19 1
#define FREQENCY 3
#define FC_BOX 13
#define UP15 11
#define UP14 10
#define DN11 3
#define BN24 50
#define DN20 2
#define M_PR_PRT 47
#define FC_EGB 14
#define UP16 12
#define DN10 4
#define BN25 52
#define NUMBER24 51
#define DN18 3
#define M_PR_MWH 49
#define M_PR_BND 48
#define FC_PITCH 16
#define FC_AMPL 15
#define BN14 13
#define DN9 6
#define DN13 5
#define NUMBER25 53
#define SLIDER18 5
#define TRACK18 4
#define M_PR_FCT 50
#define BN16 15
#define NUMBER14 14
#define TRACK8 7
#define BN26 54
#define TRACK19 6
#define M_PR_AFT 51
#define NUMBER16 16
#define SLIDER8 8
#define BN27 56
#define NUMBER26 55
#define SLIDER19 7
#define M_PR_OTH 53
#define M_PR_BTH 52
#define FC_OK 20
#define BN15 17
#define SLIDER9 10
#define TRACK9 9
#define NUMBER27 57
#define SLIDER20 9
#define TRACK20 8
#define NUMBER15 18
#define TRACK10 11
#define BN28 58
#define DN17 10
#define PLAY_REC 55
#define SENS_NUM 20
#define SLIDER10 12
#define NUMBER28 59
#define TRACK17 11
#define PLAY_PB 56
#define FC_CAN 23
#define SLIDER11 14
#define TRACK11 13
#define UP20 13
#define SLIDER17 12
#define TRACK12 15
#define UP17 14
#define SLIDER12 16
#define UP19 15
#define SLIDER13 18
#define TRACK13 17
#define BN17 17
#define UP18 16
#define SEN_XIT 27
#define UP8 19
#define OPERATOR 7
#define NUMBER17 18
#define SEN_CAN 28
#define UP9 20
#define OPR_OP2 2
#define OPR_OP1 1
#define BN20 19
#define UP11 22
#define UP10 21
#define OPR_OP3 3
#define BN19 21
#define NUMBER20 20
#define PTCH_BND 10
