/* Resource Datei Indizes f�r CALLUFSL */

#define SETFLAGS 0   /* Formular/Dialog */
#define U_TITLE  2   /* FTEXT in Baum SETFLAGS */
#define U_INFO   3   /* FTEXT in Baum SETFLAGS */
#define U_BSP    4   /* FTEXT in Baum SETFLAGS */
#define U_WINDOW 6   /* BUTTON in Baum SETFLAGS */
#define U_DIALOG 7   /* BUTTON in Baum SETFLAGS */
#define U_PROP   9   /* BUTTON in Baum SETFLAGS */
#define U_GDOS   10  /* BUTTON in Baum SETFLAGS */
#define U_CSIZE  11  /* BUTTON in Baum SETFLAGS */
#define U_DSIZE  12  /* BUTTON in Baum SETFLAGS */
#define U_CWIDTH 13  /* BUTTON in Baum SETFLAGS */
#define U_CATTR  14  /* BUTTON in Baum SETFLAGS */
#define U_IATTR  15  /* BUTTON in Baum SETFLAGS */
#define U_CCOLOR 16  /* BUTTON in Baum SETFLAGS */
#define U_CSKEW  17  /* BUTTON in Baum SETFLAGS */
#define U_ID10   19  /* FTEXT in Baum SETFLAGS */
#define U_ID8    20  /* FTEXT in Baum SETFLAGS */
#define U_ID     22  /* FTEXT in Baum SETFLAGS */
#define U_SIZE   23  /* FTEXT in Baum SETFLAGS */
#define U_WIDTH  24  /* FTEXT in Baum SETFLAGS */
#define U_ATTR   25  /* FTEXT in Baum SETFLAGS */
#define U_COLOR  26  /* FTEXT in Baum SETFLAGS */
#define U_SKEW   27  /* FTEXT in Baum SETFLAGS */
#define U_NSKEW  28  /* BOXCHAR in Baum SETFLAGS */
#define UFSL_ID  30  /* TEXT in Baum SETFLAGS */
#define UFSL_VER 31  /* TEXT in Baum SETFLAGS */
#define U_CALL   32  /* BUTTON in Baum SETFLAGS */
#define U_STOP   33  /* BUTTON in Baum SETFLAGS */
