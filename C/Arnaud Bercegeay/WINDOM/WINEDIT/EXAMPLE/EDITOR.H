/* Indices du fichier ressource pour EDITOR */

#define MENU1            0   /* Menu */
#define INFOS            3   /* TITLE dans l'arbre MENU1 */
#define APROPOS          11  /* STRING dans l'arbre MENU1 */
#define NOUVEAU          20  /* STRING dans l'arbre MENU1 */
#define CHARGER          21  /* STRING dans l'arbre MENU1 */
#define SAUVER           22  /* STRING dans l'arbre MENU1 */
#define SAUVE_SOUS       23  /* STRING dans l'arbre MENU1 */
#define QUITTER          25  /* STRING dans l'arbre MENU1 */
#define WIN_CYCLE        27  /* STRING dans l'arbre MENU1 */
#define WIN_CLOSE        28  /* STRING dans l'arbre MENU1 */
#define WIN_ICON         29  /* STRING dans l'arbre MENU1 */
#define WIN_FULL         30  /* STRING dans l'arbre MENU1 */
#define COPIER           32  /* STRING dans l'arbre MENU1 */
#define COLLER           33  /* STRING dans l'arbre MENU1 */
#define INSERT_CHAR      36  /* STRING dans l'arbre MENU1 */
#define INSERT_STRING    37  /* STRING dans l'arbre MENU1 */
#define DELETE_EOL       38  /* STRING dans l'arbre MENU1 */
#define DELETE_LINE      39  /* STRING dans l'arbre MENU1 */
#define GOTO             41  /* STRING dans l'arbre MENU1 */
#define CURS_STD         43  /* STRING dans l'arbre MENU1 */
#define CURS_VIDINV      44  /* STRING dans l'arbre MENU1 */
#define CURS_OUTLINE     45  /* STRING dans l'arbre MENU1 */
#define CURS_VBAR        46  /* STRING dans l'arbre MENU1 */
#define CURS_HBAR        47  /* STRING dans l'arbre MENU1 */
#define CURS_FLASH       48  /* STRING dans l'arbre MENU1 */
#define CONFIG           50  /* STRING dans l'arbre MENU1 */
#define TAB_ESP          51  /* STRING dans l'arbre MENU1 */
#define INFO_TXT         52  /* STRING dans l'arbre MENU1 */
#define AVSERVER         53  /* STRING dans l'arbre MENU1 */
#define MAKE             54  /* STRING dans l'arbre MENU1 */

#define INFO_PROGRAMME   0   /* Chaine d'alerte */
