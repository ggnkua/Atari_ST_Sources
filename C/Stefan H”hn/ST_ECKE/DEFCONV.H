/* resource set indicies for DEFCONV */

#define MAIN     0	/* form/dialog */
#define DEF2DFN  3	/* BUTTON in tree MAIN */
#define DFN2DEF  4	/* BUTTON in tree MAIN */
#define ABBRUCH  5	/* BUTTON in tree MAIN */
#define DEF2HRD  6	/* BUTTON in tree MAIN */
#define HRD2DEF  7	/* BUTTON in tree MAIN */
