
macro   clc                             ; clear carry
        and     #$fe,ccr
endm

*-----------------------------------------------------------------------*
*-----------------------------------------------------------------------*
*  Swapword, swap high and low byte in a word
*-----------------------------------------------------------------------*
*-----------------------------------------------------------------------*
        XDEF    swapword
swapword:
		clc        
        ror.w   #8,d0
        rts

