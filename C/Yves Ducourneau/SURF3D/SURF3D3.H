/* Indice du ressource pour SURF3D3 */

#define MENU     0   /* Arbre menu */
#define MINFO    8   /* STRING dans l'arbre MENU */
#define Z1       17  /* STRING dans l'arbre MENU */
#define Z2       18  /* STRING dans l'arbre MENU */
#define Z3       19  /* STRING dans l'arbre MENU */
#define Z4       20  /* STRING dans l'arbre MENU */
#define Z5       21  /* STRING dans l'arbre MENU */
#define Z6       22  /* STRING dans l'arbre MENU */
#define Z7       23  /* STRING dans l'arbre MENU */
#define Z8       24  /* STRING dans l'arbre MENU */
#define Z9       25  /* STRING dans l'arbre MENU */
#define Z10      26  /* STRING dans l'arbre MENU */
#define Z11      27  /* STRING dans l'arbre MENU */
#define MQUIT    29  /* STRING dans l'arbre MENU */
#define PAL1     31  /* STRING dans l'arbre MENU */
#define PAL2     32  /* STRING dans l'arbre MENU */
#define ANG      34  /* STRING dans l'arbre MENU */
#define AXES     36  /* STRING dans l'arbre MENU */

#define BOXINFO  1   /* Formulaire/Dialogue */
#define BOXOK    4   /* BUTTON dans l'arbre BOXINFO */

#define ACQUI    2   /* Formulaire/Dialogue */
#define ACQUIOK  1   /* BUTTON dans l'arbre ACQUI */
#define ACQUIEDI 2   /* FTEXT dans l'arbre ACQUI */
#define ACQUIANU 8   /* BUTTON dans l'arbre ACQUI */
#define ACQUISAV 9   /* BUTTON dans l'arbre ACQUI */
#define ACQUIOUV 10  /* BUTTON dans l'arbre ACQUI */

#define DANGLE   3   /* Formulaire/Dialogue */
#define AROTA    2   /* FTEXT dans l'arbre DANGLE */
#define AHAUT    3   /* FTEXT dans l'arbre DANGLE */
#define DAO      5   /* BUTTON dans l'arbre DANGLE */
#define DAA      6   /* BUTTON dans l'arbre DANGLE */
