/* resource set indices for NEC_RSCM */

#define HAUPT      0 /* free form */
#define MAIN       0 /* Hauptbox */
#define HAUPT2     1 /* BOX in tree HAUPT */
#define ARRUP      2 /* BOXCHAR in tree HAUPT */
#define HAUPTWIN   3 /* BOX in tree HAUPT */
#define ZEILE1     4 /* BOXTEXT in tree HAUPT */
#define BUTTON1    5 /* BOXTEXT in tree HAUPT */
#define ZEILE2     6 /* BOXTEXT in tree HAUPT */
#define BUTTON2    7 /* BOXTEXT in tree HAUPT */
#define ZEILE3     8 /* BOXTEXT in tree HAUPT */
#define BUTTON3    9 /* BOXTEXT in tree HAUPT */
#define ZEILE4    10 /* BOXTEXT in tree HAUPT */
#define BUTTON4   11 /* BOXTEXT in tree HAUPT */
#define SLBACK    12 /* BOX in tree HAUPT */
#define SLIDER    13 /* BOX in tree HAUPT */
#define ARRDOWN   14 /* BOXCHAR in tree HAUPT */
#define OK        16 /* BUTTON in tree HAUPT */
#define ABBRUCH   17 /* BOXTEXT in tree HAUPT */
#define SICHERN   19 /* BOXTEXT in tree HAUPT */

