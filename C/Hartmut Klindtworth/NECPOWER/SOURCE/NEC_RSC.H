/* resource set indices for NEC_RSC */

#define HAUPT      0 /* free form */
#define MAIN       0 /* Hauptbox */
#define DRUCKE     1 /* IMAGE in tree HAUPT */
#define INFORM     2 /* ICON in tree HAUPT */
#define ALLES      5 /* BOXTEXT in tree HAUPT */
#define SELECT     6 /* BOXTEXT in tree HAUPT */
#define CONFIG     7 /* BOXTEXT in tree HAUPT */
#define HAUPT2     8 /* BOX in tree HAUPT */
#define ARRUP      9 /* BOXCHAR in tree HAUPT */
#define HAUPTWIN  10 /* BOX in tree HAUPT */
#define ZEILE1    11 /* BOXTEXT in tree HAUPT */
#define BUTTON1   12 /* BOXTEXT in tree HAUPT */
#define ZEILE2    13 /* BOXTEXT in tree HAUPT */
#define BUTTON2   14 /* BOXTEXT in tree HAUPT */
#define ZEILE3    15 /* BOXTEXT in tree HAUPT */
#define BUTTON3   16 /* BOXTEXT in tree HAUPT */
#define ZEILE4    17 /* BOXTEXT in tree HAUPT */
#define BUTTON4   18 /* BOXTEXT in tree HAUPT */
#define SLBACK    19 /* BOX in tree HAUPT */
#define SLIDER    20 /* BOX in tree HAUPT */
#define ARRDOWN   21 /* BOXCHAR in tree HAUPT */
#define OK        23 /* BUTTON in tree HAUPT */
#define ABBRUCH   24 /* BOXTEXT in tree HAUPT */
#define SICHERN   26 /* BOXTEXT in tree HAUPT */

#define CONFMAIN   1 /* free form */
#define COTPS      4 /* BOXTEXT in tree CONFMAIN */
#define COPSP      5 /* BOXTEXT in tree CONFMAIN */
#define CODSP      6 /* BOXTEXT in tree CONFMAIN */
#define COLCS      7 /* BOXTEXT in tree CONFMAIN */
#define COCSD      8 /* BOXTEXT in tree CONFMAIN */
#define COSOZ      9 /* BOXTEXT in tree CONFMAIN */
#define COGPD     10 /* BOXTEXT in tree CONFMAIN */
#define COQUI     11 /* BOXTEXT in tree CONFMAIN */
#define COFFL     12 /* BOXTEXT in tree CONFMAIN */
#define COSOE     13 /* BOXTEXT in tree CONFMAIN */
#define COLPI     14 /* BOXTEXT in tree CONFMAIN */
#define COMEM     15 /* BOXTEXT in tree CONFMAIN */
#define COATO     16 /* BOXTEXT in tree CONFMAIN */
#define COCUP     17 /* BOXTEXT in tree CONFMAIN */
#define COCRF     19 /* BOXTEXT in tree CONFMAIN */
#define COLFF     20 /* BOXTEXT in tree CONFMAIN */
#define COBLF     21 /* BOXTEXT in tree CONFMAIN */
#define COPUL     22 /* BOXTEXT in tree CONFMAIN */
#define COSFL     23 /* BOXTEXT in tree CONFMAIN */
#define CODCC     24 /* BOXTEXT in tree CONFMAIN */
#define COBAU     25 /* BOXTEXT in tree CONFMAIN */
#define COWOR     26 /* BOXTEXT in tree CONFMAIN */
#define COPAR     27 /* BOXTEXT in tree CONFMAIN */
#define CODCD     28 /* BOXTEXT in tree CONFMAIN */
#define COCOM     29 /* BOXTEXT in tree CONFMAIN */
#define CODHA     30 /* BOXTEXT in tree CONFMAIN */
#define COLQA     31 /* BOXTEXT in tree CONFMAIN */
#define CONFOK    33 /* BUTTON in tree CONFMAIN */
#define CONFABBR  34 /* BOXTEXT in tree CONFMAIN */

#define USERINFO   2 /* free form */

