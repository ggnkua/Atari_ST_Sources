/* Module de dВclarations pour TOTO.C */

#ifdef PRINCIPAL
	#define DEC
#else
	#define DEC extern
#endif

DEC void quitter (void);
