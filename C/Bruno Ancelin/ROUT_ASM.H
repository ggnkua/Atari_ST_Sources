/* DВclaration de la fonction assembleur. */

/* Remarquez que la dВclaration est toujours externe, puisque la routine
se trouve dans un fichier .O */

extern long cdecl MULTIPLY (int v1, int v2);