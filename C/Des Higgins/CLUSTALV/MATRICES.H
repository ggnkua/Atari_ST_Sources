
char pam250mt[]={
12,
 0, 2,
-2, 1, 3,
-3, 1, 0, 6,
-2, 1, 1, 1, 2,
-3, 1, 0,-1, 1, 5,
-4, 1, 0,-1, 0, 0, 2,
-5, 0, 0,-1, 0, 1, 2, 4,
-5, 0, 0,-1, 0, 0, 1, 3, 4,
-5,-1,-1, 0, 0,-1, 1, 2, 2, 4,
-3,-1,-1, 0,-1,-2, 2, 1, 1, 3, 6,
-4, 0,-1, 0,-2,-3, 0,-1,-1, 1, 2, 6,
-5, 0, 0,-1,-1,-2, 1, 0, 0, 1, 0, 3, 5,
-5,-2,-1,-2,-1,-3,-2,-3,-2,-1,-2, 0, 0, 6,
-2,-1, 0,-2,-1,-3,-2,-2,-2,-2,-2,-2,-2, 2, 5,
-6,-3,-2,-3,-2,-4,-3,-4,-3,-2,-2,-3,-3, 4, 2, 6,
-2,-1, 0,-1, 0,-1,-2,-2,-2,-2,-2,-2,-2, 2, 4, 2, 4,
-4,-3,-3,-5,-4,-5,-4,-6,-5,-5,-2,-4,-5, 0, 1, 2,-1, 9,
 0,-3,-3,-5,-3,-5,-2,-4,-4,-4, 0,-4,-4,-2,-1,-1,-2, 7,10,
-8,-2,-5,-6,-6,-7,-4,-7,-7,-5,-3, 2,-3,-4,-5,-2,-6, 0, 0,17 };

char idmat[]={
10,
 0, 10,
 0, 0, 10,
 0, 0, 0, 10,
 0, 0, 0, 0, 10,
 0, 0, 0, 0, 1, 10,
 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,10,
 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,10};


 char pam100mt[]={
 14,
 -1, 6,
 -5, 2,  7,
 -6, 1, -1, 10,
 -5, 2,  2,  1,  6,
 -8, 1, -3, -3,  1,  8,
 -8, 2,  0, -3, -1, -1, 7,
-11,-1, -2, -4, -1, -1, 4,  8,
-11,-2, -3, -3,  0, -2, 1,  5,  8,
-11,-3, -3, -1, -2, -5,-1,  1,  4,  9,
 -6,-4, -5, -2, -5, -7, 2, -1, -2,  4,11,
 -6,-1, -4, -2, -5, -8,-3, -6, -5,  1, 1, 10,
-11,-2, -1, -4, -4, -5, 1, -2, -2, -1,-3,  3,  8,
-11,-4, -2, -6, -3, -8,-5, -8, -6, -2,-7, -2,  1, 13,
 -5,-4, -1, -6, -3, -7,-4, -6, -5, -5,-7, -4, -4,  2,  9,
-12,-7, -5, -5, -5, -8,-6, -9, -7, -3,-5, -7, -6,  4,  2, 9,
 -4,-4, -1, -4,  0, -4,-5, -6, -5, -5,-6, -6, -6,  1,  5, 1,  8,
-10,-5, -6, -9, -7, -8,-6,-11,-11,-10,-4, -7,-11, -2,  0, 0, -5,12,
 -2,-6, -6,-11, -6,-11,-3, -9, -7, -9,-1,-10,-10, -8, -4,-5, -6, 6,13,
-13,-4,-10,-11,-11,-13,-8,-13,-14,-11,-7,  1, -9,-11,-12,-7,-14,-2,-2,19 };
