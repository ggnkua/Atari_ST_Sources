/* Indices du fichier ressource pour AWELERSC */

#define MENU             0   /* Menu */
#define MENU_NIVEAU      7   /* TITLE dans l'arbre MENU */
#define MENU_INFO        10  /* STRING dans l'arbre MENU */
#define MENU_NEW_P1      12  /* STRING dans l'arbre MENU */
#define MENU_NEW_P2      13  /* STRING dans l'arbre MENU */
#define MENU_UNDO        14  /* STRING dans l'arbre MENU */
#define MENU_INVERSE     15  /* STRING dans l'arbre MENU */
#define MENU_BEST        16  /* STRING dans l'arbre MENU */
#define MENU_QUIT        18  /* STRING dans l'arbre MENU */
#define MENU_L1          20  /* STRING dans l'arbre MENU */
#define MENU_L2          21  /* STRING dans l'arbre MENU */
#define MENU_L3          22  /* STRING dans l'arbre MENU */
#define MENU_L4          23  /* STRING dans l'arbre MENU */
#define MENU_L5          24  /* STRING dans l'arbre MENU */
#define MENU_L6          25  /* STRING dans l'arbre MENU */
#define MENU_CONFIG      27  /* STRING dans l'arbre MENU */
#define MENU_HELP        28  /* STRING dans l'arbre MENU */

#define BOARD            1   /* Formulaire/Dialogue */
#define CAPTURE_PLAYER2  25  /* BOXTEXT dans l'arbre BOARD */
#define CAPTURE_PLAYER1  26  /* BOXTEXT dans l'arbre BOARD */

#define ICONES           2   /* Formulaire/Dialogue */
#define CASE0            1   /* USERDEF dans l'arbre ICONES */
#define CASE1            2   /* USERDEF dans l'arbre ICONES */
#define CASE2            3   /* USERDEF dans l'arbre ICONES */
#define CASE3            4   /* USERDEF dans l'arbre ICONES */
#define CASE4            5   /* USERDEF dans l'arbre ICONES */
#define CASE5            6   /* USERDEF dans l'arbre ICONES */
#define CASE6            7   /* USERDEF dans l'arbre ICONES */
#define CASE7            8   /* USERDEF dans l'arbre ICONES */
#define CASEN            9   /* USERDEF dans l'arbre ICONES */

#define INFOS            3   /* Formulaire/Dialogue */

#define CONFIG           4   /* Formulaire/Dialogue */
#define CONFIG_OK        1   /* BUTTON dans l'arbre CONFIG */
#define CONFIG_ANNULER   2   /* BUTTON dans l'arbre CONFIG */
#define CONFIG_TACHE     4   /* BUTTON dans l'arbre CONFIG */
#define CONFIG_NIVEAU    5   /* BUTTON dans l'arbre CONFIG */
#define CONFIG_SAUVER    6   /* BUTTON dans l'arbre CONFIG */
#define CONFIG_MOUSE     7   /* BUTTON dans l'arbre CONFIG */

#define ICON             5   /* Formulaire/Dialogue */

#define ALERT1           0   /* Chaine d'alerte */

#define ALERT2           1   /* Chaine d'alerte */

#define ALERT3           2   /* Chaine d'alerte */

#define APROPOS          3   /* Chaine libre */

#define WINTITLE         4   /* Chaine libre */

#define CALL_ST_GUIDE    5   /* Chaine libre */

#define MSG_WIN          6   /* Chaine libre */

#define MSG_LOSE         7   /* Chaine libre */

#define MSG_END_THINK    8   /* Chaine libre */

#define MSG_BEG_THINK    9   /* Chaine libre */

#define MSG_BAD_MOVE     10  /* Chaine libre */

#define MSG_WELCOME      11  /* Chaine libre */

#define MSG_NEW          12  /* Chaine libre */

#define ICONTITLE        13  /* Chaine libre */

#define MSG_BEST         14  /* Chaine libre */
