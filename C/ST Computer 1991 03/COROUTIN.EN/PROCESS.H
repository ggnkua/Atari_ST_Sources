/*                                                                         *\
                                 process.h
                      (eigentlich v”llig �berfl�ssig)
\*                                                                         */


extern NEWPROCESS();
extern TRANSFER();



