#define ABOUT 7
#define DIALBOX 1
#define MENUBAR 0
