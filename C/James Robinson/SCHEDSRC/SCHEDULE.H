#define TMENU 0  	/* TREE */
#define TABOUT 1  	/* TREE */
#define TSYSDATE 6  	/* TREE */
#define TENTMORE 20  	/* TREE */
#define TPRTREPT 24  	/* TREE */
#define TCALCBD 2  	/* TREE */
#define TBDRESLT 3  	/* TREE */
#define TCALCFD 4  	/* TREE */
#define TFDRESLT 5  	/* TREE */
#define TCUSTOM 14  	/* TREE */
#define TMACROS 16  	/* TREE */
#define ABOUT 13  	/* OBJECT in TREE #0 */
#define FNEW 22  	/* OBJECT in TREE #0 */
#define FOPENF 23  	/* OBJECT in TREE #0 */
#define FMERGE 24  	/* OBJECT in TREE #0 */
#define FSAVE 26  	/* OBJECT in TREE #0 */
#define FABANDON 28  	/* OBJECT in TREE #0 */
#define FQUIT 34  	/* OBJECT in TREE #0 */
#define RECEDIT 53  	/* OBJECT in TREE #0 */
#define OCALCBD 39  	/* OBJECT in TREE #0 */
#define OCALCFD 40  	/* OBJECT in TREE #0 */
#define PAUTTICK 45  	/* OBJECT in TREE #0 */
#define PMACROS 46  	/* OBJECT in TREE #0 */
#define SDDATE 3  	/* OBJECT in TREE #6 */
#define EMOREYES 1  	/* OBJECT in TREE #20 */
#define PRSDATE 2  	/* OBJECT in TREE #24 */
#define PREDATE 6  	/* OBJECT in TREE #24 */
#define BDSDATE 2  	/* OBJECT in TREE #2 */
#define BDEDATE 9  	/* OBJECT in TREE #2 */
#define FDDATE 3  	/* OBJECT in TREE #4 */
#define FDDAYS 10  	/* OBJECT in TREE #4 */
#define FDNODAYS 3  	/* OBJECT in TREE #5 */
#define FDBOTMSG 4  	/* OBJECT in TREE #5 */
#define FDRESULT 6  	/* OBJECT in TREE #5 */
#define CENTYES 3  	/* OBJECT in TREE #14 */
#define CENTNO 4  	/* OBJECT in TREE #14 */
#define STIMEYES 15  	/* OBJECT in TREE #14 */
#define STIMENO 16  	/* OBJECT in TREE #14 */
#define AMAC 3  	/* OBJECT in TREE #16 */
#define MACLOAD 31  	/* OBJECT in TREE #16 */
#define MACSAVE 32  	/* OBJECT in TREE #16 */
#define MCANCEL 30  	/* OBJECT in TREE #16 */
#define TAUTTICK 13  	/* TREE */
#define TCALEND 10  	/* TREE */
#define MDESK 3  	/* OBJECT in TREE #0 */
#define MFILE 4  	/* OBJECT in TREE #0 */
#define MRECORDS 8  	/* OBJECT in TREE #0 */
#define MOPTIONS 6  	/* OBJECT in TREE #0 */
#define MPREFS 7  	/* OBJECT in TREE #0 */
#define MREPORT 9  	/* OBJECT in TREE #0 */
#define RPTEDIT 64  	/* OBJECT in TREE #0 */
#define RPTPRINT 65  	/* OBJECT in TREE #0 */
#define RPTCREAT 63  	/* OBJECT in TREE #0 */
#define TSELRPT 25  	/* TREE */
#define SPNAME1 7  	/* OBJECT in TREE #25 */
#define ATCANCEL 117  	/* OBJECT in TREE #13 */
#define PRCANCEL 55  	/* OBJECT in TREE #24 */
#define ATKEY1 6  	/* OBJECT in TREE #13 */
#define ATFRWD1 9  	/* OBJECT in TREE #13 */
#define ATDAYS1 11  	/* OBJECT in TREE #13 */
#define TPRTCODE 17  	/* TREE */
#define CALFIRST 1  	/* OBJECT in TREE #10 */
#define CALLAST 37  	/* OBJECT in TREE #10 */
#define TTICKRES 21  	/* TREE */
#define  TRINFO 3  	/* OBJECT in TREE #21 */
#define FDELETE 30  	/* OBJECT in TREE #0 */
#define TEDITREC 19  	/* TREE */
#define ERDATE 3  	/* OBJECT in TREE #19 */
#define ERCANCEL 44  	/* OBJECT in TREE #19 */
#define ERETIME 17  	/* OBJECT in TREE #19 */
#define ERETPAR 15  	/* OBJECT in TREE #19 */
#define ERSTIME 14  	/* OBJECT in TREE #19 */
#define ERSTPAR 12  	/* OBJECT in TREE #19 */
#define EROK 45  	/* OBJECT in TREE #19 */
#define CAFCHRS1 49  	/* OBJECT in TREE #14 */
#define CAFLAB1 43  	/* OBJECT in TREE #14 */
#define RECNEW 52  	/* OBJECT in TREE #0 */
#define OSYSDATE 41  	/* OBJECT in TREE #0 */
#define PXF1PAR 20  	/* OBJECT in TREE #24 */
#define PXF2PAR 24  	/* OBJECT in TREE #24 */
#define PXF3PAR 28  	/* OBJECT in TREE #24 */
#define PXF4PAR 32  	/* OBJECT in TREE #24 */
#define PXF5PAR 36  	/* OBJECT in TREE #24 */
#define PXF1LAB 22  	/* OBJECT in TREE #24 */
#define PXF2LAB 26  	/* OBJECT in TREE #24 */
#define PXF3LAB 30  	/* OBJECT in TREE #24 */
#define PXF4LAB 34  	/* OBJECT in TREE #24 */
#define PXF5LAB 38  	/* OBJECT in TREE #24 */
#define PXF1ED 21  	/* OBJECT in TREE #24 */
#define PXF2ED 25  	/* OBJECT in TREE #24 */
#define PXF3ED 29  	/* OBJECT in TREE #24 */
#define PXF4ED 33  	/* OBJECT in TREE #24 */
#define PXF5ED 37  	/* OBJECT in TREE #24 */
#define SUBJYES 23  	/* OBJECT in TREE #14 */
#define PSUBJPAR 16  	/* OBJECT in TREE #24 */
#define PSUBJLAB 17  	/* OBJECT in TREE #24 */
#define TSUBJPAR 18  	/* OBJECT in TREE #19 */
#define TSUBJLAB 19  	/* OBJECT in TREE #19 */
#define TXF1PAR 21  	/* OBJECT in TREE #19 */
#define TXF1LAB 22  	/* OBJECT in TREE #19 */
#define TXF1ED 23  	/* OBJECT in TREE #19 */
#define CCANCEL 55  	/* OBJECT in TREE #14 */
#define SUBJNO 24  	/* OBJECT in TREE #14 */
#define ERDELABL 41  	/* OBJECT in TREE #19 */
#define PRDETREE 40  	/* OBJECT in TREE #24 */
#define PRDESCR 41  	/* OBJECT in TREE #24 */
#define TICKYES 11  	/* OBJECT in TREE #14 */
#define TICKNO 12  	/* OBJECT in TREE #14 */
#define PRINBUT 46  	/* OBJECT in TREE #24 */
#define PREQBUT 47  	/* OBJECT in TREE #24 */
#define PRNEBUT 48  	/* OBJECT in TREE #24 */
#define ERDEPAR 36  	/* OBJECT in TREE #19 */
#define RECTRANS 55  	/* OBJECT in TREE #0 */
#define THELP 7  	/* TREE */
#define BDCANCEL 13  	/* OBJECT in TREE #2 */
#define FDCANCEL 12  	/* OBJECT in TREE #4 */
#define TPRTDEV 26  	/* TREE */
#define PDCANCEL 12  	/* OBJECT in TREE #26 */
#define PDWINDOW 7  	/* OBJECT in TREE #26 */
#define PDPRINT 9  	/* OBJECT in TREE #26 */
#define PDDISK 8  	/* OBJECT in TREE #26 */
#define PPRINTER 47  	/* OBJECT in TREE #0 */
#define PCCANCEL 73  	/* OBJECT in TREE #17 */
#define TGODATE 12  	/* TREE */
#define GDCANCEL 6  	/* OBJECT in TREE #12 */
#define GDDATE 2  	/* OBJECT in TREE #12 */
#define PRSDMSG 4  	/* OBJECT in TREE #24 */
#define PREDMSG 7  	/* OBJECT in TREE #24 */
#define BDSDMSG 3  	/* OBJECT in TREE #2 */
#define BDEDMSG 7  	/* OBJECT in TREE #2 */
#define FDMSG 4  	/* OBJECT in TREE #4 */
#define SDMSG 4  	/* OBJECT in TREE #6 */
#define GDMSG 3  	/* OBJECT in TREE #12 */
#define DELINES1 28  	/* OBJECT in TREE #14 */
#define DELINES2 29  	/* OBJECT in TREE #14 */
#define DELINES3 30  	/* OBJECT in TREE #14 */
#define DELINES4 31  	/* OBJECT in TREE #14 */
#define YEARYES 7  	/* OBJECT in TREE #14 */
#define YEARNO 8  	/* OBJECT in TREE #14 */
#define YEARPAR 6  	/* OBJECT in TREE #14 */
#define PRTITLE2 1  	/* OBJECT in TREE #24 */
#define TPAGERNG 28  	/* TREE */
#define TPAGESET 27  	/* TREE */
#define PSCANCEL 46  	/* OBJECT in TREE #27 */
#define PSLEFTM 6  	/* OBJECT in TREE #27 */
#define PSRIGHTM 7  	/* OBJECT in TREE #27 */
#define PSTOPM 8  	/* OBJECT in TREE #27 */
#define PSSPICA 30  	/* OBJECT in TREE #27 */
#define PSSELITE 29  	/* OBJECT in TREE #27 */
#define PSSCOND 28  	/* OBJECT in TREE #27 */
#define PCNLQON 9  	/* OBJECT in TREE #17 */
#define PSCONTIN 43  	/* OBJECT in TREE #27 */
#define PSSINGLE 44  	/* OBJECT in TREE #27 */
#define TEDITRPT 23  	/* TREE */
#define EPDATE 13  	/* OBJECT in TREE #23 */
#define EPLEN1 25  	/* OBJECT in TREE #23 */
#define EPEMPTY 12  	/* OBJECT in TREE #23 */
#define EPDAYWK 14  	/* OBJECT in TREE #23 */
#define EPTIME 15  	/* OBJECT in TREE #23 */
#define EPDESCR 16  	/* OBJECT in TREE #23 */
#define EPDAYSTO 17  	/* OBJECT in TREE #23 */
#define EPCLMIN1 99  	/* OBJECT in TREE #23 */
#define EPCLMCK1 90  	/* OBJECT in TREE #23 */
#define EPTOTCHR 122  	/* OBJECT in TREE #23 */
#define EPSPACE 114  	/* OBJECT in TREE #23 */
#define EPCOLUMN 110  	/* OBJECT in TREE #23 */
#define EPDAILY 111  	/* OBJECT in TREE #23 */
#define EPNAME 6  	/* OBJECT in TREE #23 */
#define EPSUBJ 18  	/* OBJECT in TREE #23 */
#define TCALINFO 11  	/* TREE */
#define CIDONE 35  	/* OBJECT in TREE #11 */
#define CIDELETE 27  	/* OBJECT in TREE #11 */
#define CICLEAR 29  	/* OBJECT in TREE #11 */
#define EPXF1BUT 19  	/* OBJECT in TREE #23 */
#define EPMINSPA 125  	/* OBJECT in TREE #23 */
#define EPDET1 3  	/* OBJECT in TREE #23 */
#define EPDET2 4  	/* OBJECT in TREE #23 */
#define CIPRINTD 39  	/* OBJECT in TREE #11 */
#define CIEDIT 26  	/* OBJECT in TREE #11 */
#define CIPRINT 28  	/* OBJECT in TREE #11 */
#define EPCANCEL 119  	/* OBJECT in TREE #23 */
#define EPDELETE 117  	/* OBJECT in TREE #23 */
#define EPMIN1 34  	/* OBJECT in TREE #23 */
#define EPPLUS1 43  	/* OBJECT in TREE #23 */
#define EPPLUS10 116  	/* OBJECT in TREE #23 */
#define EPMIN10 115  	/* OBJECT in TREE #23 */
#define CIDELDAY 30  	/* OBJECT in TREE #11 */
#define CIBACKD 36  	/* OBJECT in TREE #11 */
#define CIAHEADD 37  	/* OBJECT in TREE #11 */
#define CIGODATE 38  	/* OBJECT in TREE #11 */
#define CISEEKBK 31  	/* OBJECT in TREE #11 */
#define CISEEKAH 32  	/* OBJECT in TREE #11 */
#define CILFARR 20  	/* OBJECT in TREE #11 */
#define CIDNARR 19  	/* OBJECT in TREE #11 */
#define CIRTARR 24  	/* OBJECT in TREE #11 */
#define CIUPARR 4  	/* OBJECT in TREE #11 */
#define CIHZSCR 22  	/* OBJECT in TREE #11 */
#define CIHZSLID 23  	/* OBJECT in TREE #11 */
#define MCALEND 5  	/* OBJECT in TREE #0 */
#define CALEDIT 36  	/* OBJECT in TREE #0 */
#define CIHEADER 3  	/* OBJECT in TREE #11 */
#define CITITLE 1  	/* OBJECT in TREE #11 */
#define FRENAME 32  	/* OBJECT in TREE #0 */
#define PDWDWICN 3  	/* OBJECT in TREE #26 */
#define PSSBOX 25  	/* OBJECT in TREE #27 */
#define PSSHBOX 40  	/* OBJECT in TREE #27 */
#define SDTIME 5  	/* OBJECT in TREE #6 */
#define PRSTIME 10  	/* OBJECT in TREE #24 */
#define PRETIME 14  	/* OBJECT in TREE #24 */
#define PSTPAR 8  	/* OBJECT in TREE #24 */
#define PSTLAB 9  	/* OBJECT in TREE #24 */
#define PETPAR 12  	/* OBJECT in TREE #24 */
#define PETLAB 13  	/* OBJECT in TREE #24 */
#define PRLEBUT 51  	/* OBJECT in TREE #24 */
#define PRLTBUT 49  	/* OBJECT in TREE #24 */
#define PRGTBUT 50  	/* OBJECT in TREE #24 */
#define PSMBOX 32  	/* OBJECT in TREE #27 */
#define PSMDRAFT 37  	/* OBJECT in TREE #27 */
#define PSMBOLD 36  	/* OBJECT in TREE #27 */
#define PSMDOUBL 35  	/* OBJECT in TREE #27 */
#define PSMEXPAN 38  	/* OBJECT in TREE #27 */
#define PSBUTBOX 45  	/* OBJECT in TREE #27 */
#define PSSNLQ 31  	/* OBJECT in TREE #27 */
#define TSENDCOD 9  	/* TREE */
#define PCNLQOFF 14  	/* OBJECT in TREE #17 */
#define PCELITE 48  	/* OBJECT in TREE #17 */
#define PCBOLDON 61  	/* OBJECT in TREE #17 */
#define PCBOLDOF 66  	/* OBJECT in TREE #17 */
#define PCPICA 33  	/* OBJECT in TREE #17 */
#define PCDOUBON 19  	/* OBJECT in TREE #17 */
#define PCDOUBOF 24  	/* OBJECT in TREE #17 */
#define PCCONDEN 56  	/* OBJECT in TREE #17 */
#define PCEXPAON 38  	/* OBJECT in TREE #17 */
#define PCEXPAOF 43  	/* OBJECT in TREE #17 */
#define PCLOAD 70  	/* OBJECT in TREE #17 */
#define PCSAVE 71  	/* OBJECT in TREE #17 */
#define PSDOUBLD 39  	/* OBJECT in TREE #27 */
#define FSAVEAS 27  	/* OBJECT in TREE #0 */
#define PCOK 72  	/* OBJECT in TREE #17 */
#define PCNOTES 2  	/* OBJECT in TREE #17 */
#define SCCODE1 2  	/* OBJECT in TREE #9 */
#define SCCANCEL 11  	/* OBJECT in TREE #9 */
#define OSENDCOD 42  	/* OBJECT in TREE #0 */
#define ERTICKLE 7  	/* OBJECT in TREE #19 */
#define ERTICKAH 10  	/* OBJECT in TREE #19 */
#define ERTIKPAR 5  	/* OBJECT in TREE #19 */
#define ERMSG 4  	/* OBJECT in TREE #19 */
#define EREXIT 42  	/* OBJECT in TREE #19 */
#define ERDELETE 43  	/* OBJECT in TREE #19 */
#define PSBOTM 9  	/* OBJECT in TREE #27 */
#define PSPGSIZE 13  	/* OBJECT in TREE #27 */
#define PSCOPIES 50  	/* OBJECT in TREE #27 */
#define PSCBOX 48  	/* OBJECT in TREE #27 */
#define CIEDDAY 33  	/* OBJECT in TREE #11 */
#define PGRCNCL 7  	/* OBJECT in TREE #28 */
#define PGRTOTPG 3  	/* OBJECT in TREE #28 */
#define PGRFIRST 4  	/* OBJECT in TREE #28 */
#define PGRLAST 5  	/* OBJECT in TREE #28 */
#define TPRINT 29  	/* TREE */
#define PPRINTED 3  	/* OBJECT in TREE #29 */
#define PREMAIN 5  	/* OBJECT in TREE #29 */
#define ERTITLE1 1  	/* OBJECT in TREE #19 */
#define PSTITLE 2  	/* OBJECT in TREE #27 */
#define EPALGNL1 54  	/* OBJECT in TREE #23 */
#define EPALGNL2 58  	/* OBJECT in TREE #23 */
#define EPALGNL3 62  	/* OBJECT in TREE #23 */
#define EPALGNL4 66  	/* OBJECT in TREE #23 */
#define EPALGNL5 70  	/* OBJECT in TREE #23 */
#define EPALGNL6 74  	/* OBJECT in TREE #23 */
#define EPALGNL7 78  	/* OBJECT in TREE #23 */
#define EPALGNL8 82  	/* OBJECT in TREE #23 */
#define EPALGNL9 86  	/* OBJECT in TREE #23 */
#define EPALGNC1 55  	/* OBJECT in TREE #23 */
#define EPALGNC2 59  	/* OBJECT in TREE #23 */
#define EPALGNC3 63  	/* OBJECT in TREE #23 */
#define EPALGNC4 67  	/* OBJECT in TREE #23 */
#define EPALGNC5 71  	/* OBJECT in TREE #23 */
#define EPALGNC6 75  	/* OBJECT in TREE #23 */
#define EPALGNC7 79  	/* OBJECT in TREE #23 */
#define EPALGNC8 83  	/* OBJECT in TREE #23 */
#define EPALGNC9 87  	/* OBJECT in TREE #23 */
#define EPALGNR1 56  	/* OBJECT in TREE #23 */
#define EPALGNR2 60  	/* OBJECT in TREE #23 */
#define EPALGNR3 64  	/* OBJECT in TREE #23 */
#define EPALGNR4 68  	/* OBJECT in TREE #23 */
#define EPALGNR5 72  	/* OBJECT in TREE #23 */
#define EPALGNR6 76  	/* OBJECT in TREE #23 */
#define EPALGNR8 84  	/* OBJECT in TREE #23 */
#define EPALGNR9 88  	/* OBJECT in TREE #23 */
#define EPALGNR7 80  	/* OBJECT in TREE #23 */
#define RECDELET 54  	/* OBJECT in TREE #0 */
#define TXF2PAR 24  	/* OBJECT in TREE #19 */
#define TXF2LAB 25  	/* OBJECT in TREE #19 */
#define TXF2ED 26  	/* OBJECT in TREE #19 */
#define TXF3PAR 27  	/* OBJECT in TREE #19 */
#define TXF3LAB 28  	/* OBJECT in TREE #19 */
#define TXF3ED 29  	/* OBJECT in TREE #19 */
#define TXF4PAR 30  	/* OBJECT in TREE #19 */
#define TXF5LAB 34  	/* OBJECT in TREE #19 */
#define TXF5ED 35  	/* OBJECT in TREE #19 */
#define ERDESCR1 37  	/* OBJECT in TREE #19 */
#define ERDESCR2 38  	/* OBJECT in TREE #19 */
#define ERDESCR3 39  	/* OBJECT in TREE #19 */
#define ERDESCR4 40  	/* OBJECT in TREE #19 */
#define CSUBJLEN 26  	/* OBJECT in TREE #14 */
#define CDELEN1 34  	/* OBJECT in TREE #14 */
#define CDELEN2 35  	/* OBJECT in TREE #14 */
#define CDELEN3 36  	/* OBJECT in TREE #14 */
#define CDELEN4 37  	/* OBJECT in TREE #14 */
#define TSUBJED 20  	/* OBJECT in TREE #19 */
#define TXF5PAR 33  	/* OBJECT in TREE #19 */
#define TXF4LAB 31  	/* OBJECT in TREE #19 */
#define TXF4ED 32  	/* OBJECT in TREE #19 */
#define EPMIN11 126  	/* OBJECT in TREE #23 */
#define EPPLUS11 127  	/* OBJECT in TREE #23 */
#define RECCLEAR 56  	/* OBJECT in TREE #0 */
#define SPCANCEL 51  	/* OBJECT in TREE #25 */
#define SPNAME2 29  	/* OBJECT in TREE #25 */
#define SPCLM1 18  	/* OBJECT in TREE #25 */
#define SPCLM2 40  	/* OBJECT in TREE #25 */
#define RECSETFL 59  	/* OBJECT in TREE #0 */
#define ATLOAD 115  	/* OBJECT in TREE #13 */
#define ATSAVE 116  	/* OBJECT in TREE #13 */
#define PRSTDEC 11  	/* OBJECT in TREE #24 */
#define PRETDEC 15  	/* OBJECT in TREE #24 */
#define PRSUBDEC 18  	/* OBJECT in TREE #24 */
#define PRXF1DEC 23  	/* OBJECT in TREE #24 */
#define PRXF2DEC 27  	/* OBJECT in TREE #24 */
#define PRXF3DEC 31  	/* OBJECT in TREE #24 */
#define PRXF4DEC 35  	/* OBJECT in TREE #24 */
#define PRXF5DEC 39  	/* OBJECT in TREE #24 */
#define PRDESDEC 43  	/* OBJECT in TREE #24 */
#define PRGEBUT 52  	/* OBJECT in TREE #24 */
#define PRDECBOX 45  	/* OBJECT in TREE #24 */
#define OHELP 43  	/* OBJECT in TREE #0 */
#define EPTITLE1 1  	/* OBJECT in TREE #23 */
#define TINFO 22  	/* TREE */
#define FIUSED 4  	/* OBJECT in TREE #22 */
#define RECINFO 61  	/* OBJECT in TREE #0 */
#define FITITLE 1  	/* OBJECT in TREE #22 */
#define PSUBJED 19  	/* OBJECT in TREE #24 */
#define RPTLOAD 67  	/* OBJECT in TREE #0 */
#define RPTSAVE 68  	/* OBJECT in TREE #0 */
#define WDWCLOSE 70  	/* OBJECT in TREE #0 */
#define WDWEDIT 73  	/* OBJECT in TREE #0 */
#define WDWLOAD 78  	/* OBJECT in TREE #0 */
#define WDWSAVE 79  	/* OBJECT in TREE #0 */
#define MWINDOWS 10  	/* OBJECT in TREE #0 */
#define TCALEDIT 30  	/* TREE */
#define CEYEAR 2  	/* OBJECT in TREE #30 */
#define CEJAN 5  	/* OBJECT in TREE #30 */
#define CECANCEL 18  	/* OBJECT in TREE #30 */
#define BDSTIME 6  	/* OBJECT in TREE #2 */
#define BDETIME 10  	/* OBJECT in TREE #2 */
#define BDRESULT 3  	/* OBJECT in TREE #3 */
#define BDOK 12  	/* OBJECT in TREE #2 */
#define FDOK 11  	/* OBJECT in TREE #4 */
#define SDOK 7  	/* OBJECT in TREE #6 */
#define SCOK 10  	/* OBJECT in TREE #9 */
#define ATOK 118  	/* OBJECT in TREE #13 */
#define COK 54  	/* OBJECT in TREE #14 */
#define MACOK 29  	/* OBJECT in TREE #16 */
#define EPOK 118  	/* OBJECT in TREE #23 */
#define PROK 54  	/* OBJECT in TREE #24 */
#define PSOK 47  	/* OBJECT in TREE #27 */
#define SROK 6  	/* OBJECT in TREE #28 */
#define PSPGNUM 23  	/* OBJECT in TREE #27 */
#define PSPDATE 20  	/* OBJECT in TREE #27 */
#define PSPHEAD 19  	/* OBJECT in TREE #27 */
#define PSSIZBOX 10  	/* OBJECT in TREE #27 */
#define PSMARBOX 3  	/* OBJECT in TREE #27 */
#define PPRTLAB 2  	/* OBJECT in TREE #29 */
#define PREMLAB 4  	/* OBJECT in TREE #29 */
#define CIDEBUGT 25  	/* OBJECT in TREE #11 */
#define ETIMEYES 19  	/* OBJECT in TREE #14 */
#define ETIMENO 20  	/* OBJECT in TREE #14 */
#define TIMEPAR 18  	/* OBJECT in TREE #14 */
#define FIBYTES 6  	/* OBJECT in TREE #22 */
#define POTHER 49  	/* OBJECT in TREE #0 */
#define TOTHERPF 18  	/* TREE */
#define OPCANCEL 17  	/* OBJECT in TREE #18 */
#define OPYESBAK 3  	/* OBJECT in TREE #18 */
#define OPNOBAK 4  	/* OBJECT in TREE #18 */
#define FIMAX 3  	/* OBJECT in TREE #22 */
#define OPYESDAT 7  	/* OBJECT in TREE #18 */
#define OPNODATE 8  	/* OBJECT in TREE #18 */
#define OPYESTIM 11  	/* OBJECT in TREE #18 */
#define OPNOTIME 12  	/* OBJECT in TREE #18 */
#define PSPTIME 21  	/* OBJECT in TREE #27 */
#define WDWMARK 75  	/* OBJECT in TREE #0 */
#define WDWGOTO 76  	/* OBJECT in TREE #0 */
#define PCANCEL 6  	/* OBJECT in TREE #29 */
#define OPEXTENS 15  	/* OBJECT in TREE #18 */
#define RECPRINT 57  	/* OBJECT in TREE #0 */
#define PSPFILE 22  	/* OBJECT in TREE #27 */
#define PSZERO 17  	/* OBJECT in TREE #27 */
#define PSZCBOX 14  	/* OBJECT in TREE #27 */
#define EPMSBORD 123  	/* OBJECT in TREE #23 */
#define PSDLABEL 3  	/* OBJECT in TREE #24 */
#define PEDLABEL 5  	/* OBJECT in TREE #24 */
#define WDWEDALL 72  	/* OBJECT in TREE #0 */
#define TSELXFLD 15  	/* TREE */
#define SXCHGFLD 3  	/* OBJECT in TREE #15 */
#define SXXFLD1 4  	/* OBJECT in TREE #15 */
#define SXXFLD2 5  	/* OBJECT in TREE #15 */
#define SXXFLD3 6  	/* OBJECT in TREE #15 */
#define SXXFLD4 7  	/* OBJECT in TREE #15 */
#define SXXFLD5 8  	/* OBJECT in TREE #15 */
#define CALOPEN 37  	/* OBJECT in TREE #0 */
#define PSAVECFG 50  	/* OBJECT in TREE #0 */
#define CINEWREC 34  	/* OBJECT in TREE #11 */
#define CIEVENTS 2  	/* OBJECT in TREE #11 */
#define PSEJECT 24  	/* OBJECT in TREE #27 */
#define TWDWKEYS 8  	/* TREE */
#define HVWDWKEY 32  	/* OBJECT in TREE #7 */
#define ATKEY2 17  	/* OBJECT in TREE #13 */
#define ATKEY3 28  	/* OBJECT in TREE #13 */
#define ATKEY4 39  	/* OBJECT in TREE #13 */
#define ATKEY5 50  	/* OBJECT in TREE #13 */
#define ATKEY6 61  	/* OBJECT in TREE #13 */
#define ATKEY7 72  	/* OBJECT in TREE #13 */
#define ATKEY8 83  	/* OBJECT in TREE #13 */
#define ATKEY9 94  	/* OBJECT in TREE #13 */
#define ATKEY10 105  	/* OBJECT in TREE #13 */
#define ATFRWD2 20  	/* OBJECT in TREE #13 */
#define ATFRWD3 31  	/* OBJECT in TREE #13 */
#define ATFRWD4 42  	/* OBJECT in TREE #13 */
#define ATFRWD5 53  	/* OBJECT in TREE #13 */
#define ATFRWD6 64  	/* OBJECT in TREE #13 */
#define ATFRWD7 75  	/* OBJECT in TREE #13 */
#define ATFRWD8 86  	/* OBJECT in TREE #13 */
#define ATFRWD9 97  	/* OBJECT in TREE #13 */
#define ATFRWD10 108  	/* OBJECT in TREE #13 */
#define ATDAYS2 22  	/* OBJECT in TREE #13 */
#define ATDAYS3 33  	/* OBJECT in TREE #13 */
#define ATDAYS4 44  	/* OBJECT in TREE #13 */
#define ATDAYS5 55  	/* OBJECT in TREE #13 */
#define ATDAYS6 66  	/* OBJECT in TREE #13 */
#define ATDAYS7 77  	/* OBJECT in TREE #13 */
#define ATDAYS8 88  	/* OBJECT in TREE #13 */
#define ATDAYS9 99  	/* OBJECT in TREE #13 */
#define ATDAYS10 110  	/* OBJECT in TREE #13 */
#define SDCANCEL 8  	/* OBJECT in TREE #6 */
#define FDFRWD 8  	/* OBJECT in TREE #4 */
#define PRBUTPAR 53  	/* OBJECT in TREE #24 */
#define ERTICKBK 11  	/* OBJECT in TREE #19 */
#define EPMIN2 35  	/* OBJECT in TREE #23 */
#define EPPLUS2 44  	/* OBJECT in TREE #23 */
#define EPMIN3 36  	/* OBJECT in TREE #23 */
#define EPPLUS3 45  	/* OBJECT in TREE #23 */
#define EPMIN4 37  	/* OBJECT in TREE #23 */
#define EPPLUS4 46  	/* OBJECT in TREE #23 */
#define EPMIN5 38  	/* OBJECT in TREE #23 */
#define EPPLUS5 47  	/* OBJECT in TREE #23 */
#define EPMIN6 39  	/* OBJECT in TREE #23 */
#define EPPLUS6 48  	/* OBJECT in TREE #23 */
#define EPMIN7 40  	/* OBJECT in TREE #23 */
#define EPPLUS7 49  	/* OBJECT in TREE #23 */
#define EPMIN8 41  	/* OBJECT in TREE #23 */
#define EPPLUS8 50  	/* OBJECT in TREE #23 */
#define EPMIN9 42  	/* OBJECT in TREE #23 */
#define EPPLUS9 51  	/* OBJECT in TREE #23 */
#define EPMSLAB 124  	/* OBJECT in TREE #23 */
#define PRDECLAB 44  	/* OBJECT in TREE #24 */
#define CIVTSCR 17  	/* OBJECT in TREE #11 */
#define CIVTSLID 18  	/* OBJECT in TREE #11 */
#define CIDESCR1 6  	/* OBJECT in TREE #11 */
#define CIWDWBOX 5  	/* OBJECT in TREE #11 */
