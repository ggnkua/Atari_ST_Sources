char *right(),*left(),*mid(),*month_str(),*wday_str(),*fd_forward(),
     *fd_backward(),*replicate(),*rjustify();

long calc_bd();

