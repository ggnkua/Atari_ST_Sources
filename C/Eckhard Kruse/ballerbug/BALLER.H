#define MENUE 0  	/* TREE */
#define INFO 10  	/* OBJECT in TREE #0 */
#define MOD1 25  	/* OBJECT in TREE #0 */
#define MOD2 26  	/* OBJECT in TREE #0 */
#define MOD3 27  	/* OBJECT in TREE #0 */
#define MOD4 28  	/* OBJECT in TREE #0 */
#define INFOTREE 2  	/* TREE */
#define SCHUSS 1  	/* TREE */
#define WL2 9  	/* OBJECT in TREE #1 */
#define WL1 8  	/* OBJECT in TREE #1 */
#define WR1 7  	/* OBJECT in TREE #1 */
#define WR2 10  	/* OBJECT in TREE #1 */
#define PL2 15  	/* OBJECT in TREE #1 */
#define PL1 13  	/* OBJECT in TREE #1 */
#define PR1 14  	/* OBJECT in TREE #1 */
#define PR2 16  	/* OBJECT in TREE #1 */
#define WINK 6  	/* OBJECT in TREE #1 */
#define PULV 12  	/* OBJECT in TREE #1 */
#define SPI3 19  	/* OBJECT in TREE #0 */
#define SOK 1  	/* OBJECT in TREE #1 */
#define SAB 2  	/* OBJECT in TREE #1 */
#define KAST 3  	/* OBJECT in TREE #1 */
#define BURG 3  	/* TREE */
#define BK1 4  	/* OBJECT in TREE #3 */
#define BK2 5  	/* OBJECT in TREE #3 */
#define BL1 3  	/* OBJECT in TREE #3 */
#define BR1 6  	/* OBJECT in TREE #3 */
#define BL2 7  	/* OBJECT in TREE #3 */
#define BR2 8  	/* OBJECT in TREE #3 */
#define BOK 10  	/* OBJECT in TREE #3 */
#define BAB 9  	/* OBJECT in TREE #3 */
#define MOD5 30  	/* OBJECT in TREE #0 */
#define BSP1 1  	/* OBJECT in TREE #3 */
#define BSP2 2  	/* OBJECT in TREE #3 */
#define SPI1 20  	/* OBJECT in TREE #0 */
#define SPI2 22  	/* OBJECT in TREE #0 */
#define NAMEN 5  	/* TREE */
#define NSP1 2  	/* OBJECT in TREE #5 */
#define NSP2 3  	/* OBJECT in TREE #5 */
#define NOK 4  	/* OBJECT in TREE #5 */
#define DRAN 4  	/* TREE */
#define DWIN 4  	/* OBJECT in TREE #4 */
#define DWBX 6  	/* OBJECT in TREE #4 */
#define DNAM 2  	/* OBJECT in TREE #4 */
#define ACC1 12  	/* OBJECT in TREE #0 */
#define STATUS 6  	/* TREE */
#define SH1 3  	/* OBJECT in TREE #6 */
#define SH2 4  	/* OBJECT in TREE #6 */
#define SH3 5  	/* OBJECT in TREE #6 */
#define SH4 6  	/* OBJECT in TREE #6 */
#define SH5 7  	/* OBJECT in TREE #6 */
#define SH6 8  	/* OBJECT in TREE #6 */
#define SM1 16  	/* OBJECT in TREE #6 */
#define SM2 17  	/* OBJECT in TREE #6 */
#define SM3 18  	/* OBJECT in TREE #6 */
#define SM4 19  	/* OBJECT in TREE #6 */
#define SM5 20  	/* OBJECT in TREE #6 */
#define SM6 21  	/* OBJECT in TREE #6 */
#define FERTIG 13  	/* OBJECT in TREE #6 */
#define DOK 7  	/* OBJECT in TREE #4 */
#define SH7 9  	/* OBJECT in TREE #6 */
#define SH8 10  	/* OBJECT in TREE #6 */
#define SHK 11  	/* OBJECT in TREE #6 */
#define SHG 12  	/* OBJECT in TREE #6 */
#define SIEGER 7  	/* TREE */
#define SG1 6  	/* OBJECT in TREE #7 */
#define SG2 8  	/* OBJECT in TREE #7 */
#define SG3 9  	/* OBJECT in TREE #7 */
#define COMPUTER 8  	/* TREE */
#define CTS2 24  	/* OBJECT in TREE #8 */
#define CN1 3  	/* OBJECT in TREE #8 */
#define CN2 11  	/* OBJECT in TREE #8 */
#define CTS1 19  	/* OBJECT in TREE #8 */
#define REG 32  	/* OBJECT in TREE #0 */
#define REGEL1 9  	/* TREE */
#define R1F 30  	/* OBJECT in TREE #9 */
#define R12 32  	/* OBJECT in TREE #9 */
#define R13 31  	/* OBJECT in TREE #9 */
#define REGEL2 10  	/* TREE */
#define R21 30  	/* OBJECT in TREE #10 */
#define R23 29  	/* OBJECT in TREE #10 */
#define R2F 28  	/* OBJECT in TREE #10 */
#define REGEL3 11  	/* TREE */
#define R31 30  	/* OBJECT in TREE #11 */
#define R32 29  	/* OBJECT in TREE #11 */
#define R3F 28  	/* OBJECT in TREE #11 */
#define SPI4 23  	/* OBJECT in TREE #0 */
#define ERG1 34  	/* OBJECT in TREE #0 */
#define ERG2 35  	/* OBJECT in TREE #0 */
#define ERG3 36  	/* OBJECT in TREE #0 */
#define ERG4 38  	/* OBJECT in TREE #0 */
#define EINTRAG 12  	/* TREE */
#define OPTION 13  	/* TREE */
#define EI_N1 5  	/* OBJECT in TREE #12 */
#define EI_N2 6  	/* OBJECT in TREE #12 */
#define EI_N3 7  	/* OBJECT in TREE #12 */
#define EI_N4 8  	/* OBJECT in TREE #12 */
#define EI_N5 9  	/* OBJECT in TREE #12 */
#define EI_N6 10  	/* OBJECT in TREE #12 */
#define ER_LOE 12  	/* OBJECT in TREE #12 */
#define ER_BLE 13  	/* OBJECT in TREE #12 */
#define ER_OK 1  	/* OBJECT in TREE #12 */
#define A_ERL 9  	/* OBJECT in TREE #13 */
#define A_VER 10  	/* OBJECT in TREE #13 */
#define MAX_1 3  	/* OBJECT in TREE #13 */
#define MAX_2 4  	/* OBJECT in TREE #13 */
#define MAX_XX 6  	/* OBJECT in TREE #13 */
#define MAX_NE 5  	/* OBJECT in TREE #13 */
#define OP_OK 11  	/* OBJECT in TREE #13 */
#define A_KAP 15  	/* OBJECT in TREE #13 */
