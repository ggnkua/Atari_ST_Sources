/* header file for Mountain Solitaire
** written by Michael C. Gilbert
** Copyright 1990 by Antic Publishing, Inc.
*/

#define TREE01 1
#define OKC 2
#define CNAME 3
#define TREE00 0
#define DSK 3
#define FLE 4
#define OPTIONS 5
#define MOUNTAIN 8
#define RSET 17
#define QUIT 18
#define NEW 20
#define REPLAY 21
#define DEMO 23
#define SLOW 26
#define TIMER 25
#define MED 27
#define FAST 28
