
#define	MAINMENU	    0

#define T_DESK	    3
#define T_FILE	    4
#define T_TITLE1	    5
#define T_TITLE2	    6
#define D_ABOUT	    9
#define F_BOX	   17
#define F_QUIT	   18
#define T1_PARENT	   19
#define MENU1	   20
#define MENU2	   21
#define MENU3	   22
#define T2_PARENT	   23
#define MENU4	   24
#define MENU5	   25
#define MENU6	   26

#define	PARENT1	    1

#define M2_PARENT	    1
#define SUBMENU4	    2
#define SUBMENU5	    3
#define SUBMENU6	    4
#define M1_PARENT	    5
#define SUBMENU1	    6
#define SUBMENU2	    7
#define SUBMENU3	    8

#define	PARENT2	    2

#define M3_PARENT	    0
#define SUBMENU7	    1
#define SUBMENU8	    2
#define SUBMENU9	    3
