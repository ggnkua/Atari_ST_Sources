/*	$Id: GET_PUT.H,v 1.23 1994/06/12 22:00:00 SCR Exp SCR $ */

int menu_get(int, GRECT *, int);
void menu_put(int);
