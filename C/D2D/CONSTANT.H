#define	LTATTEN		0
#define	RTATTEN 	1
#define	LTGAIN  	2
#define	RTGAIN		3
#define	ADDERIN 	4
#define	ADCINPUT	5
#define SETPRESCALE	6

#define	DMAPLAY		0
#define	DSPXMIT		1
#define	EXTINP		2
#define	ADC			3

#define	DMAREC		1
#define	DSPREC		2
#define	EXTOUT		4
#define	DAC			8

#define SOUND_BUF_LEN	102400
#define HALF_BUFFER		SOUND_BUF_LEN/2

#define GAIN_MAX	15
#define GAIN_MIN	0