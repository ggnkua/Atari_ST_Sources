/* resource file indicies for CDPLAYER */

#define HIGH     0	/* form/dialog */
#define PANELH   0	/* BOX in tree HIGH */
#define EJECTH   2	/* IMAGE in tree HIGH */
#define RPTH     3	/* IMAGE in tree HIGH */
#define RANDH    4	/* IMAGE in tree HIGH */
#define STOPH    5	/* IMAGE in tree HIGH */
#define PLAYH    6	/* IMAGE in tree HIGH */
#define BACKH    7	/* IMAGE in tree HIGH */
#define FWDH     8	/* IMAGE in tree HIGH */
#define EXITH    9	/* BUTTON in tree HIGH */
#define REPTH    10	/* BOXTEXT in tree HIGH */
#define DISPH    11	/* BOXTEXT in tree HIGH */

#define MEDIUM   1	/* form/dialog */
#define PANELM   0	/* BOX in tree MEDIUM */
#define EJECTM   2	/* IMAGE in tree MEDIUM */
#define RPTM     3	/* IMAGE in tree MEDIUM */
#define RANDM    4	/* IMAGE in tree MEDIUM */
#define STOPM    5	/* IMAGE in tree MEDIUM */
#define PLAYM    6	/* IMAGE in tree MEDIUM */
#define BACKM    7	/* IMAGE in tree MEDIUM */
#define FWDM     8	/* IMAGE in tree MEDIUM */
#define EXITM    9	/* BUTTON in tree MEDIUM */
#define REPTM    10	/* BOXTEXT in tree MEDIUM */
#define DISPM    11	/* BOXTEXT in tree MEDIUM */

#define MENUBAR  2	/* menu tree */
#define QUIT     16	/* STRING in tree MENUBAR */

