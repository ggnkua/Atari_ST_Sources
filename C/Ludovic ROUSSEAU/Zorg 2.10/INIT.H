/* init.c */
boolean	init_resources( void );
boolean	init_menu( void );
void	shutdown( int reset );
void	reset( void );
void	cleanup( void );
OBJECT	*make_slide( GRECT *work, long max );
void	init_drive( void );
