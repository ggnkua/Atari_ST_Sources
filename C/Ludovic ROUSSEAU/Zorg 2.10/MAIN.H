/* main.c */
int		InitMsg( XEVENT *evt, int events_available );
int 	Messag( XEVENT *event );
int		main( int argc, char *argv[] );
int		scantoascii( int scancode );
