/* Resource Datei Indizes f�r 1B_PIPE */

#define MAIN     0   /* Formular/Dialog */
#define SELMARKED 5   /* BUTTON in Baum MAIN */
#define SELNMARKED 6   /* BUTTON in Baum MAIN */
#define SELLIST  7   /* BUTTON in Baum MAIN */
#define SELALL   8   /* BUTTON in Baum MAIN */
#define MVERSION 9   /* BUTTON in Baum MAIN */
#define MFIELDS  10  /* BUTTON in Baum MAIN */
#define MSEARCH  11  /* BUTTON in Baum MAIN */
#define MEND     12  /* BUTTON in Baum MAIN */

#define RECORDS  1   /* Formular/Dialog */
#define AFIELD0  8   /* BOXTEXT in Baum RECORDS */
#define AFIELD1  9   /* BOXTEXT in Baum RECORDS */
#define AFIELD2  10  /* BOXTEXT in Baum RECORDS */
#define AFIELD3  11  /* BOXTEXT in Baum RECORDS */
#define AFIELD4  12  /* BOXTEXT in Baum RECORDS */
#define AFIELD5  13  /* BOXTEXT in Baum RECORDS */
#define ACANCEL  14  /* BUTTON in Baum RECORDS */
#define ANEXT    15  /* BUTTON in Baum RECORDS */

#define FIELDS   2   /* Formular/Dialog */
#define FNUM     7   /* BOXTEXT in Baum FIELDS */
#define FFIELD0  8   /* BOXTEXT in Baum FIELDS */
#define FFIELD1  9   /* BOXTEXT in Baum FIELDS */
#define FFIELD2  10  /* BOXTEXT in Baum FIELDS */
#define FFIELD3  11  /* BOXTEXT in Baum FIELDS */
#define FOK      12  /* BUTTON in Baum FIELDS */

#define VERSION  3   /* Formular/Dialog */
#define VVERSION 3   /* TEXT in Baum VERSION */
#define VOK      4   /* BUTTON in Baum VERSION */

#define ERR_NODC 0   /* Alert String */

#define ERR_NOREC 1   /* Alert String */

#define ERR_NOVERSION 2   /* Alert String */
