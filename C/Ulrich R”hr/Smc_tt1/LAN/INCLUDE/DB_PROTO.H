/*--- Prototypen fuer Debugausgaben ---- */

void debug_open(void);
void debug_close(void);
void debug_str(char *str);
void debug_int(char *txt,long wert);

