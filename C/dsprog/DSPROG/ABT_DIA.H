DIALOG about_dia = {ABOUTINF, "Programminfo", 0, 0, NULL, NULL, 1, 0, -1, ""};
