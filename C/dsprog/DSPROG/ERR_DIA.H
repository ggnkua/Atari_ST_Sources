ACTIVATOR error_a[] = {{ERR_OK, okay_but},
											 {ERR_CNC, cancel_but}};

DIALOG err_dia = {ERRDETEC, "Fehler!!!", 0, 2, NULL, error_a, 1, 0, -1, ""};
