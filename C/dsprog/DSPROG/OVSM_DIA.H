INDICATOR ovsmopt_i[] = {{OVSMOF2, &ovsm_typ},
												 {OVSMOF3, &ovsm_typ},
												 {OVSM_SFT,&ovsm_typ}};

DIALOG ovsmopt_dia = {OVSMOPT, "Oversampling-Optionen", 3, 0, ovsmopt_i, NULL, 0, 0, -1, ""};

