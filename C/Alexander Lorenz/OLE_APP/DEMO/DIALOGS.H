/*
*	Funktionsdeklarationen
*/

VOID about(VOID);
WORD change(VOID);
