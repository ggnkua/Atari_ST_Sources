/*
*	Funktionsdeklarationen
*/

WORD rc_intersect(GRECT *r1, GRECT *r2);
