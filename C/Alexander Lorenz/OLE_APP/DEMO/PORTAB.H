#ifndef BYTE
#define BYTE	char
#define WORD	int
#define UWORD	unsigned int
#define LONG	long
#define ULONG	unsigned long
#define VOID	void
#endif

#ifndef TRUE
#define TRUE 1
#endif

#ifndef FALSE
#define FALSE 0
#endif
