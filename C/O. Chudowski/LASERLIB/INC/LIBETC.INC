/**************************************************************************/
/*                                                                        */
/*  NAME:         libetc.inc                                              */
/*                                                                        */
/*  DATUM:        09.06.89                                                */
/*                                                                        */
/*  BESCHREIBUNG: Include-Datei fuer libetc.a.                            */
/*                                                                        */
/**************************************************************************/

#ifndef LIBETCINC
#define LIBETCINC

#include <portab.h>

extern BOOL getarg();
extern WORD system();
extern BYTE *editfld();
#endif LIBETCINC

