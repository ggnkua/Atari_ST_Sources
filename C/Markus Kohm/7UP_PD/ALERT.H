extern char *Agrepfile[];
extern char *Aprinter[];
extern char *Agrep[];
extern char *Adesktop[];
extern char *Atabulat[];
extern char *Afontsel[];
extern char *Afbinfo[];
extern char *A7up[];
extern char *Afkeys[];
extern char *Asort[];
extern char *Aconfig[];
extern char *Aavprot[];
extern char *Ablock[];
extern char *Ashell[];
extern char *Aeditor[];
extern char *Afindrep[];
extern char *Anumerik[];
extern char *Aformat[];
extern char *Afileio[];
extern char *Aundo[];
extern char *Apreview[];
extern char *Adeadkey[];
extern char *Apicklist[];
extern char *Aregcode[];
extern char *Amacrorec[];
extern char *Atoolbar[];

extern char *fselmsg[];
