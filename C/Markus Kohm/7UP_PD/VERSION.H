#define VERSION "  7UP 2.3"
#define VERSIONNAME  "7UP 2.3 ½ 1990-94 bei TheoSoft"
#define VERSIONSTRLEN (strlen(VERSIONNAME)+1)
