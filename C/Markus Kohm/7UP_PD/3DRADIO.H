/* Resource Datei Indizes f�r 3DRADIO */

#define K        0   /* Formular/Dialog */
