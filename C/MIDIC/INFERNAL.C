/*------------------------------------------------------------------*/
/*--------------------- PLAY AN INFERNAL TUNE ----------------------*/
/*------------------------------------------------------------------*/
 
 
#include <stdio.h>
#include <osbind.h>
 
#define BELL printf("\7") 
#define MIDI 3
               
int ftune[97] = {
 
0xFF, 
0x5D, 0x9C, 0xE7, 0x3C, 0x9B, 0x2, 0x73, 0xEB, 0x6B, 0xF2, 
0x80, 0x14, 0xAE, 0x4E, 0xF4, 0x9E, 0x4D, 0x1, 0xB9, 0x75, 
0x35, 0xF9, 0xC0, 0x8A, 0x57, 0x27, 0xFA, 0xCF, 0xA7, 0x81, 
0x5D, 0x36, 0x1B, 0xFC, 0xE0, 0xC5, 0xAC, 0x94, 0x7D, 0x68, 
0x53, 0x40, 0x2E, 0x1D, 0xD, 0xFE, 0xF0, 0xE2, 0xD8, 0xCA, 
0xBE, 0xB4, 0xAA, 0xA0, 0x97, 0x8F, 0x87, 0x7F, 0x78, 0x71, 
0x6B, 0x65, 0x5F, 0x5A, 0x55, 0x50, 0x4C, 0x47, 0x43, 0x40, 
0x3C, 0x39, 0x35, 0x32, 0x30, 0x2D, 0x2A, 0x28, 0x26, 0x24, 
0x22, 0x20, 0x1E, 0x1C, 0x1B, 0x19, 0x18, 0x16, 0x15, 0x14, 
0x13, 0x12, 0x11, 0x10, 0xF, 0xE};
 
int ctune[97] = {
 
0xFF, 
0xD, 0xC, 0xB, 0xB, 0xA, 0xA, 0x9, 0x8, 0x8, 0x7, 
0x7, 0x7, 0x6, 0x6, 0x5, 0x5, 0x5, 0x5, 0x4, 0x4, 
0x4, 0x3, 0x3, 0x3, 0x3, 0x3, 0x2, 0x2, 0x2, 0x2, 
0x2, 0x2, 0x2, 0x1, 0x1, 0x1, 0x1, 0x1, 0x1, 0x1, 
0x1, 0x1, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 0x0, 0x0};
 
 
                    
unsigned char note[26] = {0, 2, 3, 5, 
                          7, 3, 7, 6, 
                          2, 6, 5, 1, 
                          5, 0, 2, 3, 
                          5, 7, 3, 7, 
                          12, 10, 7, 3, 
                          7, 10};             /* Note list */
                             
unsigned char time[26] = {1, 1, 1, 1, 
                          1, 1, 2, 1, 
                          1, 2, 1, 1, 
                          2, 1, 1, 1, 
                          1, 1, 1, 1, 
                          1, 1, 1, 1, 
                          1, 4};             /* Timing list */
                            
int x, 
    z, 
    modulation, 
    speed = 5000;                            /* Tempo factor */
 
main()                                  /* Main control loop */
{
unsigned char m;
modulation = 0; 
BELL; 
while (!Bconstat(2))
{
     for (x = 0; x < 26; x++)       /* Play one cycle of tune */
     {
          m = note[x]+48+modulation;             
          Note_On(m);
          sound(m, 127);
          for (z = 0; z < speed*time[x]; z++);  /* timing loop */
          Note_Off(m);
          sound(m, 0);
     }
     if (modulation < 36)
     {
     modulation = modulation+7;            /* Modulate a fifth */
     }
     else modulation = 0;
}
}
 
Note_On(m)                                 /* Play a midi note */
unsigned char m;
{
     Bconout(3, 144);
     Bconout(3, m);
     Bconout(3, 127);
}
 
 
Note_Off(m)                                 /* Stop a midi note */
unsigned char m;
{
     Bconout(3, 144);
     Bconout(3, m);
     Bconout(3, 0);
}
 
 
 
sound(frq, vme)                      /* play internal soundchip */
unsigned char frq, vme;               /* same arguments as midi */
{
        frq = frq - 25;                    /* conversion factor */
        vme = vme / 9;                     /* compress volume   */
        Giaccess(vme, 0x88);
        Giaccess(ftune[frq], 0x80);
        Giaccess(ctune[frq], 0x81);
}
 
     
