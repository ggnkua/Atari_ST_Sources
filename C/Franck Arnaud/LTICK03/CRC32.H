int crc32file(char *, unsigned long *);