/*
 *	List of Internet Primary Domains
 *		originally for the BloufGate project
 *		public domain - may be copied and sold freely
 */

char *validdom[]={"uucp","bitnet",							/* fake domains */
				  "org","com","net","edu","mil",			/* US P1 domains */
				  "oz","su","yu",					   		/* special coutry codes that are not official
				  												(non iso code or country that disapearred) */
				  "af","al","dz","as","ad","ao","ai",		/* ISO country codes */
				  "aq","ag","ar","am","aw","au","at",
				  "az","bs","bh","bd","bb","be","bz",
				  "bj","bm","bt","bo","bw","bv","br",
				  "bn","bg","bf","bi","by","kh","cm",
				  "ca","cv","ky","cf","td","io","cl",
				  "cn","cx","ci","cc","co","co","cg", 		/* "ci" == "bf" ? */
				  "cg","cr",/* croatia, */"cu","cy","cs",
				  "dk","dj","dm","do","tp","ec","eg",
				  "sv","gq","ee","et","fk","fo","fj",
				  "fi","fr","pf","tf","ga","gm","gg",
				  "de","gh","gi","gr","gl","gd","gp",
				  "gt","gf","gn","gw","gy","ht","hm",
				  "hn","hk","hu","is","in","id","ir",
				  "iq","ie","il","it","jm","jp","jo",
				  "kk","ke","ki","kp","kr","kw","kg",
				  "la","lv","lb","ls","lr","ly","li",
				  "lt","lu","mo","mg","mw","my","mv",
				  "ml","mt","mh","mq","mr","mu","mx",
				  "fm","md","mc","mn","ms","ma","mz",
				  "mm","na","nr","np","nl","an","nt",
				  "nc","nz","ni","ne","ng","nu","nf",
				  "mp","no","om","pk","pw","pa","pg",
				  "py","pe","ph","pn","pl","pt","qa",
				  "re","ro","ru","rw","sh","kn","lc",
				  "pm","vc","sm","st","sa","sn","sc",
				  "sl","sg","si","sb","so","za","es",
				  "lk","sd","sr","sj","sz","se","ch",
				  "sy","tw","tj","tz","th","tg","tk",
				  "to","tt","tn","tr","tm","tc","tv",
				  "ug","ua","ae","uk","us","um","uy",
				  "uz","vu","va","ve","vn","vg","vi",
				  "wf","eh","ws","ye","zr","zm","zw",
				  NULL };


/**/