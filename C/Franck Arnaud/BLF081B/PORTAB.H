/* portab.h, public domain */

typedef int WORD;
typedef unsigned long LONG;
typedef char BYTE;
