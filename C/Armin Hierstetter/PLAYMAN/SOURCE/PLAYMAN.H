/* Resource Datei Indizes f�r PLAYMAN */

#define MAIN     0   /* Formular/Dialog */
#define P1       5   /* BOX in Baum MAIN */
#define B_GAIN   6   /* BOX in Baum MAIN */
#define P2       8   /* BOX in Baum MAIN */
#define B_ATTEN  9   /* BOX in Baum MAIN */
#define B_MUSIK  16  /* BUTTON in Baum MAIN */
#define B_INFO   17  /* BUTTON in Baum MAIN */
#define B_OK     18  /* BUTTON in Baum MAIN */

#define ABOUT    1   /* Formular/Dialog */

#define LOCKED   0   /* Alert String */
