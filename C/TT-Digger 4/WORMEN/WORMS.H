/* Resource file indications for WORMS */

#define DB       0   /* Form / Dialogue */
#define WMOVE    1   /* BOXTEXT in tree DB */
#define WORML    5   /* FTEXT in tree DB */
#define WORMEN   6   /* FTEXT in tree DB */
#define WORMK    7   /* FTEXT in tree DB */
#define WORMR    8   /* FTEXT in tree DB */
#define WORMS    9   /* FTEXT in tree DB */
#define QUIT     10  /* BOXTEXT in tree DB */
#define CONT     12  /* BOXTEXT in tree DB */
#define OK       13  /* BUTTON in tree DB */
