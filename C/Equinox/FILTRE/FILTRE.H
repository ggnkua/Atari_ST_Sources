#define MENU     0
#define INFORM   8
#define LOAD     17
#define SAVE     18
#define PREFS    20
#define BYEBYE   22
#define SETFREQ  24
#define SETAMPLI 25
#define LOWPASS  28
#define HIGHPASS 29
#define BANDPASS 30
#define BANDCUT  31
#define DOFILTER 33
#define ABOUT    1
#define FREEMEM  6
#define INPUT    2
#define VALUE    1
#define TEXTINP  2
#define SETUP    3
#define LSIGN    5
#define L8BITS   8
#define SSIGN    13
#define S8BITS   16
#define STATUS   4
#define STATBOX  3