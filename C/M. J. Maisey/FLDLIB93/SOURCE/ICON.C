#include <aes.h>

static short BBDATA0[] = {
0x0000,0x0000,0x7fff,0xfffe,
0x6aaa,0xaaaa,0x5555,0x5556,
0x7fff,0xfffe,0x4000,0x0002,
0x5ffe,0x0042,0x5dde,0x5142,
0x5ffe,0x7dc2,0x4000,0x0042,
0x5ffe,0x0002,0x5492,0x0002,
0x5ffe,0x3ff2,0x4000,0x2912,
0x5ffe,0x3ff2,0x5422,0x0002,
0x5ffe,0x7ffa,0x4000,0x7ffa,
0x5ffe,0x651a,0x5112,0x7ffa,
0x5ffe,0x7ffa,0x4000,0x0002,
0x7fff,0xfffe,0x0000,0x0000,
};

BITBLK BBOB0 = {BBDATA0,4,24,0,0,1};

OBJECT FLD_ICONFORM[] = {
/*0*/	{-1,1,1,G_BOX,0x0,0x0,(void *)0x11181,1792,1536,10,4},
/*1*/	{0,-1,-1,G_IMAGE,0x20,0x0,&BBOB0,3,1,4,2},
};



static void fix_tree(OBJECT *s,int max)
{
	int i;

	for(i=0; i<=max; i++)
		rsrc_obfix(s,i);
}

void rsrc_init(void)
{
	fix_tree(FLD_ICONFORM,1);
}
