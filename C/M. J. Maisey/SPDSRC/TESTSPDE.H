extern void rsrc_init(void);

extern OBJECT MAINMENU[];
#define ME_ABOUT 8
#define ME_QUIT 17
#define ME_FONT 19
#define ME_SIZE 20
#define ME_WIDTH 21
extern OBJECT SIZEMENU[];
#define SI_10 1
#define SI_12 2
#define SI_18 3
#define SI_24 4
#define SI_OTHER 5
extern OBJECT OTHERSIZE[];
#define OS_OK 1
#define OS_CANCEL 2
#define OS_TEXT 3
extern OBJECT ABOUT[];
#define AB_OK 4
extern OBJECT WIDTHMENU[];
#define WI_50 1
#define WI_75 2
#define WI_100 3
#define WI_150 4
#define WI_200 5
#define WI_OTHER 6
extern OBJECT OTHERWIDTH[];
#define OW_OK 1
#define OW_CANCEL 2
#define OW_TEXT 3
