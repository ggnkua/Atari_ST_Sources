/* Host character set */

const char charset[256] = {
	'\0', '', '', '', '', '', '','\a',
	'\b','\t','\n','\v','\f','\r', '', '',
	 '', '', '', '', '', '', '', '',
	 '', '', '', '', '', '', '', '',
	 ' ', '!', '"', '#', '$', '%', '&','\'',
	 '(', ')', '*', '+', ',', '-', '.', '/',
	 '0', '1', '2', '3', '4', '5', '6', '7',
	 '8', '9', ':', ';', '<', '=', '>', '?',
	 '@', 'A', 'B', 'C', 'D', 'E', 'F', 'G',
	 'H', 'I', 'J', 'K', 'L', 'M', 'N', 'O',
	 'P', 'Q', 'R', 'S', 'T', 'U', 'V', 'W',
	 'X', 'Y', 'Z', '[','\\', ']', '^', '_',
	 '`', 'a', 'b', 'c', 'd', 'e', 'f', 'g',
	 'h', 'i', 'j', 'k', 'l', 'm', 'n', 'o',
	 'p', 'q', 'r', 's', 't', 'u', 'v', 'w',
	 'x', 'y', 'z', '{', '|', '}', '~', '?',
	 'Ç', 'ü', 'é', 'â', 'ä', 'à', 'å', 'ç',
	 'ê', 'ë', 'è', 'ï', 'î', 'ì', 'Ä', 'Å',
	 'É', 'æ', 'Æ', 'ô', 'ö', 'ò', 'û', 'ù',
	 'ÿ', 'ö', 'Ü', '¢', '£', '¥', 'ß', 'ƒ',
	 'á', 'í', 'ó', 'ú', 'ñ', 'Ñ', '?', '?',
	 '¿', '?', '¬', '½', '¼', '¡', '«', '»',
	 'ã', 'õ', 'Ø', 'ø', 'œ', 'Œ', 'À', 'Ã',
	 'Õ', '¨', '´', '†', '¶', '©', '®', '™',
	 '?', '?', '?', '?', '?', '?', '?', '?',
	 '?', '?', '?', '?', '?', '?', '?', '?',
	 '?', '?', '?', '?', '?', '?', '?', '?',
	 '?', '?', '?', '?', '?', '?', '?', '?',
	 '?', '?', '?', '?', '?', '?', '?', '?',
	 '?', '?', '?', '?', '?', '?', '?', '?',
	 '?', '?', '?', '?', '?', '?', '?', '?',
	 '?', '?', '?', '?', '?', '?', '?', '?'
};

