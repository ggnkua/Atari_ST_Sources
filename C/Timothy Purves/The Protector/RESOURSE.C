#define T0OBJ 0
#define T1OBJ 24
#define FREEBB 2
#define FREEIMG 2
#define FREESTR 60

BYTE *rs_strings[] = {
"OK",
"SoftWare Write-Protect V1.0",
"",
"",
"Program by Timothy Purves of MichTron",
"",
"",
"A",
"B",
"C",
"D",
"E",
"F",
"G",
"H",
"I",
"J",
"K",
"L",
"M",
"N",
"O",
"P",
"Selected Drives are write-protected",
"",
"",
"12345678901234567890123456789012345",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"TEXT",
"",
"",
"OK"};

WORD IMAG0[] = {
0x0, 0x80, 0x0, 0x0, 
0xA0, 0x0, 0x78, 0xF0, 
0x0, 0xCC, 0x7E, 0x24, 
0x84, 0xF9, 0xF048, 0x1C6, 
0x7F, 0xF83F, 0x1C2, 0xFF, 
0xF83C, 0x183, 0x7F, 0x107E, 
0x81, 0xFF, 0x8078, 0x1, 
0x7D, 0xE0E0, 0x1, 0x7C, 
0x1C0, 0x3, 0xFE, 0x780, 
0x2, 0x3E, 0x1F00, 0x2, 
0x7F, 0x7E00, 0x6, 0xFF, 
0xE400, 0x4, 0x7F, 0xF800, 
0x4, 0x1FF, 0xFE06, 0x4, 
0xF7, 0xFFCC, 0x6, 0x1FB, 
0xFFFF, 0x2, 0x7FC, 0x7BFE, 
0x3, 0x1FFF, 0xB18A, 0x1, 
0xBFE0, 0x10, 0x0, 0xFFFC, 
0x0, 0x0, 0x1EFF, 0x8000, 
0xF, 0xF7F, 0xC000, 0x1F, 
0xEF3F, 0x0, 0xF, 0xF73F, 
0x8000, 0x1F, 0xFF9F, 0x0, 
0x1E, 0xFF9F, 0x0, 0x1E, 
0x3F8F, 0x0, 0x3C, 0x1F0F, 
0x8000, 0x3F, 0x71F, 0x8200, 
0x1F, 0xC437, 0xCC00, 0x1F, 
0x4007, 0xFF00, 0x35, 0x8001, 
0xF880, 0x24, 0x8000, 0x6C00, 
0x0, 0x0, 0x8400, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0};

WORD IMAG1[] = {
0x0, 0x100, 0x0, 0x0, 
0x500, 0x0, 0x0, 0xF00, 
0x1E00, 0x2400, 0x7E00, 0x3300, 
0x120F, 0x9F00, 0x2100, 0xFC1F, 
0xFE00, 0x6380, 0x3C1F, 0xFF00, 
0x4380, 0x7E08, 0xFE00, 0xC180, 
0x1E01, 0xFF00, 0x8100, 0x707, 
0xBE00, 0x8000, 0x380, 0x3E00, 
0x8000, 0x1E0, 0x7F00, 0xC000, 
0xF8, 0x7C00, 0x4000, 0x7E, 
0xFE00, 0x4000, 0x27, 0xFF00, 
0x6000, 0x1F, 0xFE00, 0x2000, 
0x607F, 0xFF80, 0x2000, 0x33FF, 
0xEF00, 0x2000, 0xFFFF, 0xDF80, 
0x6000, 0x7FDE, 0x3FE0, 0x4000, 
0x518D, 0xFFF8, 0xC000, 0x800, 
0x7FD, 0x8000, 0x0, 0x3FFF, 
0x0, 0x1, 0xFF78, 0x0, 
0x3, 0xFEF0, 0xF000, 0x0, 
0xFCF7, 0xF800, 0x1, 0xFCEF, 
0xF000, 0x0, 0xF9FF, 0xF800, 
0x0, 0xF9FF, 0x7800, 0x0, 
0xF1FC, 0x7800, 0x1, 0xF0F8, 
0x3C00, 0x41, 0xF8E0, 0xFC00, 
0x33, 0xEC23, 0xF800, 0xFF, 
0xE002, 0xF800, 0x11F, 0x8001, 
0xAC00, 0x36, 0x1, 0x2400, 
0x21, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0};

LONG rs_frstr[] = {
0};

BITBLK rs_bitblk[] = {
0L, 6, 40, 0, 0, 1,
1L, 6, 40, 0, 0, 1};

LONG rs_frimg[] = {
0};

ICONBLK rs_iconblk[] = {
0};

TEDINFO rs_tedinfo[] = {
1L, 2L, 3L, 3, 6, 2, 0x1180, 0x0, -1, 28,1,
4L, 5L, 6L, 3, 6, 2, 0x1180, 0x0, -1, 38,1,
23L, 24L, 25L, 3, 6, 0, 0x1180, 0x0, -1, 36,1,
26L, 27L, 28L, 3, 6, 0, 0x1180, 0x0, -1, 36,1,
29L, 30L, 31L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
32L, 33L, 34L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
35L, 36L, 37L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
38L, 39L, 40L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
41L, 42L, 43L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
44L, 45L, 46L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
47L, 48L, 49L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
50L, 51L, 52L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
53L, 54L, 55L, 3, 6, 0, 0x1180, 0x0, -1, 5,1,
56L, 57L, 58L, 3, 6, 0, 0x1180, 0x0, -1, 5,1};

OBJECT rs_object[] = {
-1, 1, 23, G_BOX, NONE, OUTLINED, 0x21120L, 0,0, 39,15,
2, -1, -1, G_IMAGE, NONE, NORMAL, 0x0L, 1,11, 8,3,
3, -1, -1, G_IMAGE, NONE, NORMAL, 0x1L, 32,11, 6,3,
4, -1, -1, G_BUTTON, 0x7, NORMAL, 0x0L, 16,12, 7,1,
5, -1, -1, G_TEXT, NONE, NORMAL, 0x0L, 0,0, 39,2,
6, -1, -1, G_TEXT, NONE, NORMAL, 0x1L, 0,2, 39,1,
23, 7, 22, G_BOX, NONE, NORMAL, 0xFF1123L, 3,4, 33,5,
8, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x7L, 1,1, 3,1,
9, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x8L, 5,1, 3,1,
10, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x9L, 9,1, 3,1,
11, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0xAL, 13,1, 3,1,
12, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0xBL, 17,1, 3,1,
13, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0xCL, 21,1, 3,1,
14, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0xDL, 25,1, 3,1,
15, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0xEL, 29,1, 3,1,
16, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0xFL, 1,3, 3,1,
17, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x10L, 5,3, 3,1,
18, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x11L, 9,3, 3,1,
19, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x12L, 13,3, 3,1,
20, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x13L, 17,3, 3,1,
21, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x14L, 21,3, 3,1,
22, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x15L, 25,3, 3,1,
6, -1, -1, G_BUTTON, SELECTABLE, NORMAL, 0x16L, 29,3, 3,1,
0, -1, -1, G_TEXT, LASTOB, NORMAL, 0x2L, 2,9, 36,2,
-1, 1, 12, G_BOX, NONE, OUTLINED, 0x21120L, 0,0, 39,15,
2, -1, -1, G_TEXT, NONE, NORMAL, 0x3L, 2,1, 35,1,
3, -1, -1, G_TEXT, NONE, NORMAL, 0x4L, 2,2, 35,1,
4, -1, -1, G_TEXT, NONE, NORMAL, 0x5L, 2,3, 35,1,
5, -1, -1, G_TEXT, NONE, NORMAL, 0x6L, 2,4, 35,1,
6, -1, -1, G_TEXT, NONE, NORMAL, 0x7L, 2,5, 35,1,
7, -1, -1, G_TEXT, NONE, NORMAL, 0x8L, 2,6, 35,1,
8, -1, -1, G_TEXT, NONE, NORMAL, 0x9L, 2,7, 35,1,
9, -1, -1, G_TEXT, NONE, NORMAL, 0xAL, 2,8, 35,1,
10, -1, -1, G_TEXT, NONE, NORMAL, 0xBL, 2,9, 35,1,
11, -1, -1, G_TEXT, NONE, NORMAL, 0xCL, 2,10, 35,1,
12, -1, -1, G_TEXT, NONE, NORMAL, 0xDL, 2,11, 35,1,
0, -1, -1, G_BUTTON, 0x27, NORMAL, 0x3BL, 13,13, 14,1};

LONG rs_trindex[] = {
0L,
24L};

struct foobar {
	WORD	dummy;
	WORD	*image;
	} rs_imdope[] = {
0, &IMAG0[0],
0, &IMAG1[0]};

#define NUM_STRINGS 60
#define NUM_FRSTR 0
#define NUM_IMAGES 2
#define NUM_BB 2
#define NUM_FRIMG 0
#define NUM_IB 0
#define NUM_TI 14
#define NUM_OBS 37
#define NUM_TREE 2

BYTE pname[] = "RESOURSE.RSC";