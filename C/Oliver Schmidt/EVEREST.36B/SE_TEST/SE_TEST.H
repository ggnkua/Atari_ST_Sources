/* resource set indices for SE_TEST */

#define MENU       0 /* menu */
#define FILE       4 /* TITLE in tree MENU */
#define OPEN      16 /* STRING in tree MENU */
#define CLOSE     17 /* STRING in tree MENU */
#define EDQUIT    18 /* STRING in tree MENU */
#define ERROR     20 /* STRING in tree MENU */
#define ERRFILE   21 /* STRING in tree MENU */
#define QUIT      23 /* STRING in tree MENU */

