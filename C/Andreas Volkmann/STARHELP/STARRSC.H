#define STARMENU 0  	/* TREE */
#define NLQE 9  	/* OBJECT in TREE #0 */
#define NLQA 10  	/* OBJECT in TREE #0 */
#define KURSE 13  	/* OBJECT in TREE #0 */
#define KURSA 14  	/* OBJECT in TREE #0 */
#define UNTE 17  	/* OBJECT in TREE #0 */
#define UNTA 18  	/* OBJECT in TREE #0 */
#define SUPE 21  	/* OBJECT in TREE #0 */
#define SUPA 22  	/* OBJECT in TREE #0 */
#define SUBE 25  	/* OBJECT in TREE #0 */
#define SUBA 26  	/* OBJECT in TREE #0 */
#define PICAE 29  	/* OBJECT in TREE #0 */
#define ELITEE 32  	/* OBJECT in TREE #0 */
#define SCHME 35  	/* OBJECT in TREE #0 */
#define PROPE 38  	/* OBJECT in TREE #0 */
#define PROPA 39  	/* OBJECT in TREE #0 */
#define BREITE 42  	/* OBJECT in TREE #0 */
#define BREITA 43  	/* OBJECT in TREE #0 */
#define VORSCH 47  	/* OBJECT in TREE #0 */
#define URANDL 53  	/* OBJECT in TREE #0 */
#define URANDR 55  	/* OBJECT in TREE #0 */
#define URAND 54  	/* OBJECT in TREE #0 */
#define LRAND 59  	/* OBJECT in TREE #0 */
#define RRAND 64  	/* OBJECT in TREE #0 */
#define LRANDL 58  	/* OBJECT in TREE #0 */
#define LRANDR 60  	/* OBJECT in TREE #0 */
#define RRANDL 63  	/* OBJECT in TREE #0 */
#define RRANDR 65  	/* OBJECT in TREE #0 */
#define PAPE 76  	/* OBJECT in TREE #0 */
#define PAPA 77  	/* OBJECT in TREE #0 */
#define NULSTR 68  	/* OBJECT in TREE #0 */
#define NULO 69  	/* OBJECT in TREE #0 */
#define RESET 50  	/* OBJECT in TREE #0 */
#define DOPPELE 80  	/* OBJECT in TREE #0 */
#define DOPPELA 81  	/* OBJECT in TREE #0 */
#define FETTE 84  	/* OBJECT in TREE #0 */
#define FETTA 85  	/* OBJECT in TREE #0 */
#define OKAY 87  	/* OBJECT in TREE #0 */
#define URANDGES 52  	/* OBJECT in TREE #0 */
#define LRANDGES 57  	/* OBJECT in TREE #0 */
#define RRANDGES 62  	/* OBJECT in TREE #0 */
#define UNIE 72  	/* OBJECT in TREE #0 */
#define UNIA 73  	/* OBJECT in TREE #0 */
