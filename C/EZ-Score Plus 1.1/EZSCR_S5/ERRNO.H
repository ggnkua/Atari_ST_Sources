extern int errno;   /* defined in exit.c */
