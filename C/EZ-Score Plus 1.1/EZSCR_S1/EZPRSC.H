/* ezp resource definitions - crd 880321 - copyright 1987 hybrid arts inc. */

/* pagedial */
#define LINE1 3
#define LARGE1 5
#define CENTER1 6
#define LINE2 7
#define LARGE2 9
#define CENTER2 10
#define LINE3 11
#define LARGE3 13
#define CENTER3 14
#define LINE4 15
#define LARGE4 17
#define CENTER4 18
#define LINE5 19
#define LARGE5 21
#define CENTER5 22
#define LINE6 24
#define LINE7 25
#define DSYSPG 27
#define DMAXSYS 28
#define DRECSYS 29
#define PNPTOP 33
#define PNPBOT 34
#define PNPALT 36
#define PNPLEFT 37
#define PNPCENT 38
#define PNPRIGT 39
#define MNOFFSET 41
#define PNOFFSET 42
#define PAGEOK 44
#define PAGECAN 45

/* poptdial */
#define ROUGH 4
#define DRAFT 5
#define FINAL 6
#define DSTRKON 9
#define DSTRKOFF 10
#define SINGLE 13
#define FEED 14
#define TIHIDDEN 17
#define TISHOWN 18
#define PNHIDDEN 21
#define PNSHOWN 22
#define MNHIDDEN 25
#define MNSHOWN 26
#define RMHIDDEN 29
#define RMSHOWN 30
#define INDFSNO 33
#define INDFSYES 34
#define OKAY 36
#define CANCEL 37

/* prntdial */
#define PRINTING 24
#define PRNTYPE 4
#define ABORT 5

/* resource stuff of tom's that i need */

/* from formdial */
#define STAFFMT3 4
#define STAFFMT4 5

/* EOF */
