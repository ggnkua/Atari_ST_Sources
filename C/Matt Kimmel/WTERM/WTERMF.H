/* resource set indicies for WTERMF */

#define MENU     0	/* form/dialog */
#define SETRS232 4	/* BUTTON in tree MENU */
#define SETSIZE  5	/* BUTTON in tree MENU */
#define BUFSIZE  6	/* BUTTON in tree MENU */
#define CURSON   7	/* BUTTON in tree MENU */
#define SAVESET  8	/* BUTTON in tree MENU */
#define MCANCEL  9	/* BUTTON in tree MENU */
#define ABOUT    10	/* BUTTON in tree MENU */

#define RS232    1	/* form/dialog */
#define B19200   4	/* BUTTON in tree RS232 */
#define B9600    5	/* BUTTON in tree RS232 */
#define B4800    6	/* BUTTON in tree RS232 */
#define B2400    7	/* BUTTON in tree RS232 */
#define B1200    8	/* BUTTON in tree RS232 */
#define B300     9	/* BUTTON in tree RS232 */
#define EVEN     12	/* BUTTON in tree RS232 */
#define ODD      13	/* BUTTON in tree RS232 */
#define NONE     14	/* BUTTON in tree RS232 */
#define BIT8     17	/* BOXCHAR in tree RS232 */
#define BIT7     18	/* BOXCHAR in tree RS232 */
#define BIT6     19	/* BOXCHAR in tree RS232 */
#define BIT5     20	/* BOXCHAR in tree RS232 */
#define STOP1    23	/* BUTTON in tree RS232 */
#define STOP2    24	/* BUTTON in tree RS232 */
#define FLOWNONE 27	/* BUTTON in tree RS232 */
#define FLOWXON  28	/* BUTTON in tree RS232 */
#define FLOWRTS  29	/* BUTTON in tree RS232 */
#define FLOWBOTH 30	/* BUTTON in tree RS232 */
#define ROK      31	/* BUTTON in tree RS232 */
#define RCANCEL  32	/* BUTTON in tree RS232 */

#define FONT     2	/* form/dialog */
#define MONO     3	/* BUTTON in tree FONT */
#define COLOR    4	/* BUTTON in tree FONT */
#define ICON     5	/* BUTTON in tree FONT */
#define FOK      6	/* BUTTON in tree FONT */
#define FCANCEL  7	/* BUTTON in tree FONT */

#define BUFSET   3	/* form/dialog */
#define BSIZ     2	/* FBOXTEXT in tree BUFSET */
#define BCANCEL  3	/* BUTTON in tree BUFSET */
#define BOK      4	/* BUTTON in tree BUFSET */

