/* bitmaps.c */

unsigned int pal[16]=
{
	0x0000,0x2f00,0x40f0,0x6ff0,
	0x60f0,0x4f80,0x2840,0x8fff,
	0x4ccc,0x2f88,0x68f8,0x2ff8,
	0x688f,0x2f00,0x4f0f,0x8fff
};

char *blocaa[21]=  /* 16 en largeur */
{
	"     0000       ",
	"    055550      ",
	"   05555550  0  ",
	"  0555555550050 ",
	"  05555555505550",
	" 055555555550550",
	" 05555555555050 ",
	" 0555555555500  ",
	" 055555555550   ",
	"  0555555550    ",
	"  0555555550    ",
	"   05555550     ",
	"    055550      ",
	"   0500005000   ",
	"  055550550550  ",
	"  0555505505550 ",
	"   05505555550  ",
	"    000555500   ",
	"       0550     ",
	"        00      ",
	"                "
};

char *blocab[21]=  /* 16 en largeur */
{
	"      0000      ",
	"     055550     ",
	"    05555550    ",
	"   05ff555550   ",
	"   05ff5ff550   ",
	"  0550f5ff5550  ",
	"  0500550f5550  ",
	"  005505555550  ",
	" 0555550555550  ",
	"0500550555550   ",
	"0500505555550   ",
	" 05505555550    ",
	"  00 055550     ",
	"  0005000050    ",
	" 05505550550    ",
	"055555000550    ",
	"0555505505550   ",
	" 055055555550   ",
	"  0005555500    ",
	"     05500      ",
	"      00        "
};

char *blocac[21]=  /* 16 en largeur */
{
	"                ",
	" 0000           ",
	"  04400         ",
	"   044400       ",
	"   0444440      ",
	"   04444440     ",
	"  044444444000  ",
	"  044444444000  ",
	" 0444444400400  ",
	" 044444440440   ",
	" 044444444440   ",
	"  0444444440    ",
	"   04444440     ",
	"   0044440 0    ",
	"  04400004040   ",
	"  044440440440  ",
	"   0440444440   ",
	"    00044440    ",
	"       0440     ",
	"        00      ",
	"                "
};

char *blocad[21]=  /* 16 en largeur */
{
	"                ",
	"          0000  ",
	"        00440   ",
	"      004440    ",
	"     0444440    ",
	"    04444440    ",
	"   0444444440   ",
	" 000444444440   ",
	" 00f0000040040  ",
	" 00f040f004040  ",
	"  00040f004440  ",
	"   0444000440   ",
	"    04444440    ",
	"   00044440     ",
	"  0440000040    ",
	" 04444000440    ",
	"  04400440440   ",
	"   0004444440   ",
	"      044400    ",
	"       000      ",
	"                "
};

char *blocba[24]=  /* 16 en largeur */
{
	"     0000       ",
	"    055550      ",
	"   05555550  0  ",
	"  0555555550050 ",
	"  05555555505550",
	" 055555555550550",
	" 05555555555050 ",
	" 0555555555500  ",
	" 055555555550   ",
	"  0555555550    ",
	"  0555555550    ",
	"   05555550     ",
	"    055550      ",
	"   05000050     ",
	"   05500550     ",
	"  055500550     ",
	"  055050550     ",
	"   05505550     ",
	"   055055050    ",
	"    05505550    ",
	"    055055550   ",
	"     00 05550   ",
	"        0550    ",
	"         00     "
};

char *blocbb[24]=  /* 16 en largeur */
{
	"      0000      ",
	"     055550     ",
	"    05555550    ",
	"   05ff555550   ",
	"   05ff5ff550   ",
	"  0550f5ff5550  ",
	"  0500550f5550  ",
	"  005505555550  ",
	" 0555550555550  ",
	"0500550555550   ",
	"0500505555550   ",
	" 05505555550    ",
	"  00 055550     ",
	"    05000050    ",
	"    05500550    ",
	"    05550550    ",
	"   050550550    ",
	"   0555005550   ",
	"  05555050550   ",
	"  0555005550    ",
	"   055055550    ",
	"    0005550     ",
	"       0550     ",
	"        00      "
};

char *blocbc[24]=  /* 16 en largeur */
{
	"     000000     ",
	"    0eeeeee0    ",
	"   0eeeeeeee0   ",
	"   0eeeeeeee00  ",
	"  0eeeeeeeee0e0 ",
	" 0eeeeeeeeee0e0 ",
	"0eeee0eeeee0 0  ",
	"0eee0 00000000  ",
	"0eee0  0eeeeee0 ",
	"0eeee00000000ee0",
	" 0eeeeeeeeeeeee0",
	"  0eeeeeeeeeeee0",
	" 0e00eeeeeeeee0 ",
	"0eeee000000000  ",
	"0eee0  0eeeeee0 ",
	"0eeee00000000ee0",
	" 0eeeeeeeeeeeee0",
	"  0eeeeeeeeeeee0",
	" 0e00eeeeeeeee0 ",
	" 0eee000000000  ",
	" 0eeeee00000    ",
	"  0eeeeeeeee0   ",
	"   00eeeee00    ",
	"     00000      "
};

char *blocbd[24]=  /* 16 en largeur */
{
	"    000000      ",
	"   0eeeeee0     ",
	"  0effeffee0    ",
	"  0ef0e0fee00   ",
	"  00ee0eeeeee0  ",
	" 0eeeeeeeeeeee0 ",
	" 0e0ee0e00e0eee0",
	"  0eeee000e0eee0",
	" 0e0000eee 0eee0",
	"0ee00000000eeee0",
	"0eeeeeeeeeeeee0 ",
	"0eeeeeeeeeeee0  ",
	" 0eeeeeeeee00e0 ",
	"  000000000eeee0",
	" 0eeeeee0  0eee0",
	"0ee00000000eeee0",
	"0eeeeeeeeeeeee0 ",
	"0eeeeeeeeeeee0  ",
	" 0eeeeeeeee00e0 ",
	"  000000000eee0 ",
	"    00000eeeee0 ",
	"   0eeeeeeeee0  ",
	"    00eeeee00   ",
	"      00000     "
};

char *blocbe[24]=  /* 16 en largeur */
{
	"                ",
	" 0000           ",
	"  04400         ",
	"   044400       ",
	"   0444440      ",
	"   04444440     ",
	"  044444444000  ",
	"  044444444000  ",
	" 0444444400400  ",
	" 044444440440   ",
	" 044444444440   ",
	"  0444444440    ",
	"   04444440     ",
	"    044440      ",
	"   04000040     ",
	"  040400440     ",
	"  044440440     ",
	"   04404040     ",
	"   044044440    ",
	"    00 04440    ",
	"       0440     ",
	"        00      ",
	"                ",
	"                "
};

char *blocbf[24]=  /* 16 en largeur */
{
	"                ",
	"          0000  ",
	"        00440   ",
	"      004440    ",
	"     0444440    ",
	"    04444440    ",
	"   0444444440   ",
	" 000444444440   ",
	" 00f0000040040  ",
	" 00f040f004040  ",
	"  00040f004440  ",
	"   0444000440   ",
	"    04444440    ",
	"     044440     ",
	"    04000040    ",
	"    04040440    ",
	"   044440440    ",
	"   0444004040   ",
	"    044044440   ",
	"     0004440    ",
	"        0440    ",
	"         00     ",
	"                ",
	"                "
};

char *blocca[10]=  /* 16 en largeur */
{
	"      0000      ",
	"     0dddd0     ",
	"    0dffddd0    ",
	"   0dffddddd0   ",
	"   0dffddddd0   ",
	"   0dddddddd0   ",
	"   0dddddddd0   ",
	"    0dddddd0    ",
	"     0dddd0     ",
	"      0000      "
};

char *bloccb[10]=  /* 16 en largeur */
{
	"      0000      ",
	"     0eeee0     ",
	"    0effeee0    ",
	"   0effeeeee0   ",
	"   0effeeeee0   ",
	"   0eeeeeeee0   ",
	"   0eeeeeeee0   ",
	"    0eeeeee0    ",
	"     0eeee0     ",
	"      0000      "
};

char *bloccc[10]=  /* 16 en largeur */
{
	"      0000      ",
	"     044440     ",
	"    04ff4440    ",
	"   04ff444440   ",
	"   04ff444440   ",
	"   0444444440   ",
	"   0444444440   ",
	"    04444440    ",
	"     044440     ",
	"      0000      "
};

char *bloccd[10]=  /* 16 en largeur */
{
	"     000000     ",
	"  000bbbbbb000  ",
	" 0cccccbbbbbba0 ",
	"0cccccccbbbbaaa0",
	"0ccc9999aaaaaaa0",
	"0fc999999aaaaaf0",
	"0ffff999999ffff0",
	" 0ffffffffffff0 ",
	"  000ffffff000  ",
	"     000000     "
};

char *blocda[32]=  /* 32 en largeur */
{
	"              2222              ",
	"            22222222            ",
	"          222222222222          ",
	"        2222222222222222        ",
	"      22222222222222222222      ",
	"    222222222222222222222222    ",
	"  2222222222222222222222222222  ",
	"22222222222222222222222222222222",
	"77222222222222222222222222222288",
	"77772222222222222222222222228888",
	"77777722222222222222222222888888",
	"77777777222222222222222288888888",
	"77777777772222222222228888888888",
	"77777777777722222222888888888888",
	"77777777777777222288888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"  7777777777777788888888888888  ",
	"    777777777777888888888888    ",
	"      77777777778888888888      ",
	"        7777777788888888        ",
	"          777777888888          ",
	"            77778888            ",
	"              7788              ",
	"                                "
};

char *blocdb[32]=  /* 32 en largeur */
{
	"              1111              ",
	"            11111111            ",
	"          111111111111          ",
	"        1111111111111111        ",
	"      11111111111111111111      ",
	"    111111111111111111111111    ",
	"  1111111111111111111111111111  ",
	"11111111111111111111111111111111",
	"77111111111111111111111111111188",
	"77771111111111111111111111118888",
	"77777711111111111111111111888888",
	"77777777111111111111111188888888",
	"77777777771111111111118888888888",
	"77777777777711111111888888888888",
	"77777777777777111188888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"  7777777777777788888888888888  ",
	"    777777777777888888888888    ",
	"      77777777778888888888      ",
	"        7777777788888888        ",
	"          777777888888          ",
	"            77778888            ",
	"              7788              ",
	"                                "
};

char *blocdc[32]=  /* 32 en largeur */
{
	"              3333              ",
	"            33333333            ",
	"          333333333333          ",
	"        3333333333333333        ",
	"      33333333333333333333      ",
	"    333333333333333333333333    ",
	"  3333333333333333333333333333  ",
	"33333333333333333333333333333333",
	"77333333333333333333333333333388",
	"77773333333333333333333333338888",
	"77777733333333333333333333888888",
	"77777777333333333333333388888888",
	"77777777773333333333338888888888",
	"77777777777733333333888888888888",
	"77777777777777333388888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"77777777777777778888888888888888",
	"  7777777777777788888888888888  ",
	"    777777777777888888888888    ",
	"      77777777778888888888      ",
	"        7777777788888888        ",
	"          777777888888          ",
	"            77778888            ",
	"              7788              ",
	"                                "
};

char *blocea[16]=  /* 16 en largeur */
{
	"                ",
	"                ",
	"                ",
	"     00 0000    ",
	"    0ff0ffff0   ",
	"   0ff0ffffff0  ",
	"  0fff0ffffff0  ",
	"  0ffff0ffff0   ",
	"   0ff0f0ff0    ",
	"    00fff00     ",
	"     0fffff0    ",
	"      0fff0     ",
	"       000      ",
	"                ",
	"                ",
	"                "
};

char *bloceb[16]=  /* 16 en largeur */
{
	"                ",
	"   00     000   ",
	"  0ff0   0fff0  ",
	" 0ffff0 0fffff0 ",
	"0ffffff0ffffff0 ",
	"0fffff000fffff0 ",
	"0ffff0fff0fff0  ",
	"0fff0fffff000   ",
	" 0ff0fffff0     ",
	"  00 0fff0f0    ",
	"    0f000fff0   ",
	"    0fffffff0   ",
	"     0ffffff0   ",
	"      0ffff0    ",
	"       0000     ",
	"                "
};

char *blocec[16]=  /* 16 en largeur */
{
	"  0             ",
	" 0f0       00   ",
	"0fff0     0ff0  ",
	"0fff0 0  0ffff0 ",
	" 0f0 0f00fffff0 ",
	"  0 0fff00fff0  ",
	"     0f0  000   ",
	"      0  0      ",
	"        0f0     ",
	"   00  0fff0    ",
	"  0ff0  0f0     ",
	"  0ff0   000    ",
	"   00    0ff0   ",
	"        0ffff0  ",
	"         0ff0   ",
	"          00    "
};

char *bloced[16]=  /* 16 en largeur */
{
	"                ",
	"  0          0  ",
	" 0f0        0f0 ",
	"0fff0      0fff0",
	" 0f0 0      0f0 ",
	"  0 0f0      0  ",
	"     0          ",
	"                ",
	"           0    ",
	"   0      0f0   ",
	"  0f0      0    ",
	"   0        0   ",
	"           0f0  ",
	"          0fff0 ",
	"           0f0  ",
	"            0   "
};

char *blocfa[34]=  /* 16 en largeur */
{
	"     000000     ",
	"    0eeeeee0    ",
	"   0eeeeeeee0   ",
	"   0eeeeeeee00  ",
	"  0eeeeeeeee0e0 ",
	" 0eeeeeeeeee0e0 ",
	" 0eeee0eeee0 0  ",
	"0eeee0 0000     ",
	"0eee0    00000  ",
	"0eeee0 00eeeee0 ",
	" 0eee00eeee0eee0",
	" 0eeee000000eee0",
	"  0eeeeeeeeeeee0",
	"   0eeeeeeeeee0 ",
	"  0e00eeeeeee0  ",
	" 0eeee0000000   ",
	" 0eee0          ",
	"0eeee0          ",
	"0eee0    00000  ",
	"0eeee0 00eeeee0 ",
	" 0eee00eeee0eee0",
	" 0eeee000000eee0",
	"  0eeeeeeeeeeee0",
	"   0eeeeeeeeee0 ",
	"  0e00eeeeeee0  ",
	" 0eeee0000000   ",
	" 0eeee0         ",
	" 0eee0          ",
	" 0eee0          ",
	" 0eeee0         ",
	"  0eeee0000     ",
	"   0eeeeeee0    ",
	"    00eeee0     ",
	"      0000      "
};

char *blocfb[34]=  /* 16 en largeur */
{
	"    000000      ",
	"   0eeeeee0     ",
	"  0effeffee0    ",
	"  0ef0e0fee00   ",
	"  00ee0eeeeee0  ",
	" 0eeeeeeeeeeee0 ",
	" 0e0ee0e00e0ee0 ",
	"  0eeee000e0eee0",
	"  00000eee00eee0",
	" 0eeeee0000eeee0",
	"0eee0eeee00eee0 ",
	"0eee000000eeee0 ",
	"0eeeeeeeeeeee0  ",
	" 0eeeeeeeeee0   ",
	"  0eeeeeee00e0  ",
	"   0000000eeee0 ",
	"          0eee0 ",
	"          0eeee0",
	"  00000    0eee0",
	" 0eeeee00 0eeee0",
	"0eee0eeee00eee0 ",
	"0eee000000eeee0 ",
	"0eeeeeeeeeeee0  ",
	" 0eeeeeeeeee0   ",
	"  0eeeeeee00e0  ",
	"   0000000eeee0 ",
	"         0eeee0 ",
	"          0eee0 ",
	"          0eee0 ",
	"         0eeee0 ",
	"     0000eeee0  ",
	"    0eeeeeee0   ",
	"     0eeee00    ",
	"      0000      "
};

char *blocga[46]=  /* 96 en largeur */
{
	"                                   000000000000000000000000000000                               ",
	"                           000000000ffffffffffffffffffffffffffff00000000000                     ",
	"                      000000ffffffffffffffffffffffffffffffffffffffffffffff0000                  ",
	"                   0000ffffffffffffffffffffffffffffffffffffffffffffffffffffff0000               ",
	"                0000ffffffffffffffffffffffffffffffffffffffffffffffffffffffffffff000             ",
	"              000fffffffffffffffffffffffffffffffffffffffffffffffffffffffffffffffff000           ",
	"            000fffffffffffffffffffffffffffffffffffffffffffffffffffddffffffffffffffff00          ",
	"           00fffffffffffffffffffffffffffffffffffffffffffffffffffdddffffffffffffffffff00         ",
	"         000ffffffffffffffffffffffffffff000000ffffffffffffffffddddffffffffffffffffffff00        ",
	"        00fffffffffffffff66ffffffffffff00000000fffffffffffffdddddffffffffffffffffffffff00       ",
	"       00fffffffffffffff6666fffffffffff00000000fffffffffffddddddffffffffffffffffffffffff00      ",
	"      00ffffffffffffffff66666ffffffffff00000000f000fffffdddddddffffffff444444444fffffffff00     ",
	"     00fffffffffffffffff666666fffffffff00000000f0000ffddddddddffffffff44444444444ffffffff00     ",
	"    00ffffffffeeeeeeefff6666666ffffffff00000000f0000fffddddddddffffff4444444444444ffffffff00    ",
	"    00fffffffeeeeeeeeefff6666666fffffff0000000f00000ffffddddddddffff4444ffffff4444ffffffff00    ",
	"    00fffffffeeeeeeeeeefff6666666fffff0f00000f000000fffffddddddddfff444ffffffff444ffffffff00    ",
	"    00ffffffeeeefffffffffff6666666ffff0fffffff00000fffffffddddddddff444ffffffff444ffffffff00    ",
	"    00ffffffeeefffeeeeeeffff6666666fff000f0000fffffffffffdddddddfffff44fffffff4444ffffffff00    ",
	"    00ffffffeeeffeeeeeeeeffff6666666fff00f00000000fffffdddddddffffffffffff44444444ffffffff00    ",
	"    00ffffffeeeefeeefffeeeffff666666ffffff00000000fffddddddddddddfffffff444444444fffffffff00    ",
	"    00fffffffeeeffeefffeeefffff66666ffffff00000000ffffffddddddddddddfff4444444fffffffffff00     ",
	"     00ffffffeeeeffffffeeeffffff666ffffffff00000fffffffffffdddddddffff44444ffffffffffffff00     ",
	"      00ffffffeeeeeeeeeeeeffffffffffffffffffffffffffffffffdddddfffffff4444ffffffffffffff00      ",
	"       00ffffffeeeeeeeeeefffffffffff6666ffffffffffffffffddddfffffffffff44ffffffffffffff00       ",
	"        00fffffffeeeeeeefffffffffff666666fffffffffffffdddffffffffff444ffffffffffffffff00        ",
	"         000fffffffffffffffffffffff666666fffffffffffffffffffffffff44444ffffffffffffff00         ",
	"           000ffffffffffffffffffffff6666ffffffffffffffffffffffffff44444ffffffffffff000          ",
	"             0000ffffffffffffffffffffffffffffffffffffffffffffffffff444ffffffffff0000            ",
	"                0000fffffffffffffffffffffffffffffffffffffffffffffffffffffffff0000               ",
	"                   000fffffffffffffffffffffffffffffffffffffffffffffffffffff000                  ",
	"                     000000fffffffffffffffffffffffffffffffffffffffff00000000                    ",
	"                          000000ffffffffffffffffffffffffffffffff00000                           ",
	"                               0000000000fffffffffffffffffffff000                               ",
	"                                        000ffffffffffffff000000                                 ",
	"                                          0000fffffffff000                                      ",
	"                                             00ffffffff00                                       ",
	"                                              00fffffff00                                       ",
	"                                              00fffffff00                                       ",
	"                                               00fffff00                                        ",
	"                                               00fffff00                                        ",
	"                                               00fffff00                                        ",
	"                                               00fffff00                                        ",
	"                                               00ffff00                                         ",
	"                                               00fff00                                          ",
	"                                              00ff000                                           ",
	"                                             000000                                             "
};
