/* bitmaps separees en deux pour limiter taille code objet (MAC) */

unsigned int gamepal[16]=
{
	0x0000,0x2f00,0x40f0,0x6ff0,
	0x60f0,0x4f80,0x2840,0x8fff,
	0x4ccc,0x2f88,0x68f8,0x2ff8,
	0x688f,0x2f00,0x4f0f,0x8fff
};

char *blokaa[23]=  /* 32 en largeur */
{
	"            00 0000             ",
	"     00    05506666000          ",
	"    05500 0555506666660         ",
	"   055555005505506066660        ",
	"  0555050660505500 0666600000   ",
	"  0555050666055066066600066660  ",
	"   0500506666006666060666066660 ",
	"    0000 0666066666606666600060 ",
	"    05500 00066666660600f66660  ",
	"   05555500066666666060f6666660 ",
	"  055505066066666666060f6600f60 ",
	"  05550506606066600000000000f60 ",
	"   05005066066660555555550fff60 ",
	"    0  0 0606660500555555506660 ",
	"          0 0660500555555506660 ",
	"            0660500555555000f60 ",
	"             060500555500600f60 ",
	"           005005555500f66fff60 ",
	"          05505505550600f66660  ",
	"          0550050000606666000   ",
	"          0555550666660000      ",
	"           05550666000          ",
	"            000 000             "
};

char *blokab[23]=  /* 32 en largeur */
{
	"           00                   ",
	"         00440                  ",
	"       004440400                ",
	"     004440f0f440               ",
	"    04440f00440040              ",
	"    040f00444000400             ",
	"   04400444040ff0400            ",
	"   0444f40000fddf000       0000 ",
	"   0404440040fdf04000   00044440",
	"   0440044440ff04406600044444440",
	"   04444444440044060044000004440",
	"   0444444404440406044444440000 ",
	"   04444444400040604004444400   ",
	"   044400044444060444000000040  ",
	"   0440444044440604440004444440 ",
	"    044444404440604444000044440 ",
	"    04444444444060044044000440  ",
	"     004444440000604404444000   ",
	"       000000    0404004440     ",
	"                 0440404440     ",
	"                 044440000      ",
	"                 04440          ",
	"                  000           "
};

char *blokba[26]=  /* 32 en largeur */
{
	"                                ",
	"         00             000     ",
	"        0550           05550    ",
	"       055550         0555550   ",
	"   00  0555500        0005550   ",
	"  0550 055505500     05555550   ",
	" 055550 055550660   0005555060  ",
	" 0555500 055066660005550000660  ",
	" 05550550005066660550005006660  ",
	"  0555506600000005000555006660  ",
	"   055066660066605555550066660  ",
	"    0506666066066055555000660   ",
	"     006660666666605555066060   ",
	"      0060666660000555500f60    ",
	"    0050006666006000500666660   ",
	"   050550066606600f006660ff660  ",
	"  055055006606600f6666600ff660  ",
	"  0555550 060666f6660ff6ff6660  ",
	"  05555060 0066666600ff6666660  ",
	"   05550660660066666ff6666660   ",
	"    000666666660066666666600    ",
	"       066666600600666660060    ",
	"        000000  06600000660     ",
	"                 066666660      ",
	"                  0666600       ",
	"                   0000         "
};

char *blokca[22]=  /* 32 en largeur */
{
	"                                ",
	"     00      000000             ",
	"    0550  0006666660            ",
	"   055550055506666660  0000     ",
	"  05555005505066066600066660    ",
	"  055506055050600060666066660   ",
	"   05006055506066606666600060   ",
	"    000660550666660600f66660    ",
	"    05500000666666060f6666660   ",
	"   055550066666666060f6600f60   ",
	"  055550006066600000000000f60   ",
	"  0555066066660555555550fff60   ",
	"   05006606660500555555506660   ",
	"    0 06660060500555555506660   ",
	"       0005500500555555000f60   ",
	"        055500500555500600f60   ",
	"        0550505555500f66fff60   ",
	"        05505005550600f66660    ",
	"         055506000606666000     ",
	"          000666660 0000        ",
	"             00000              ",
	"                                "
};

char *blokcb[22]=  /* 32 en largeur */
{
	"          000                   ",
	"        004440                  ",
	"      00440f0400                ",
	"     0440f000f440               ",
	"    044f0000440040              ",
	"    040000444000400    000      ",
	"   044f0444040ff0400  04440     ",
	"   0444f40000fddf000   04440    ",
	"   0404440040fdf044000004440    ",
	"   0440044440ff0444446604440    ",
	"   044444444400400444044440     ",
	"   04444444044404004400440      ",
	"   0444444440004060000060 000   ",
	"   044400044444060040044404440  ",
	"   044044404444000404044444440  ",
	"    0444444044044400440044440   ",
	"    044444444044440444400000    ",
	"     0044444404400400440        ",
	"       000000000044004440       ",
	"              04444004440       ",
	"              04440  0440       ",
	"               000    00        "
};

char *blokda[24]=  /* 32 en largeur */
{
	"         00                     ",
	"        0550                    ",
	"       055550      000          ",
	"   00  055550 00  05550         ",
	"  0550 055505066005000500       ",
	" 0555500550506666005550060      ",
	" 055550 0050666005500050660     ",
	" 05550506600000050005550660     ",
	" 055050666606660555555006660    ",
	"  05506666066066055555000660    ",
	"   0500660666666605555066060    ",
	"    05500066660000555500f60     ",
	"   0550055066006000500666660    ",
	"   05555550606600f006660ff660   ",
	"   0555550 06600f6666600ff660   ",
	"    05550600666f6660ff6ff6660   ",
	"     000660066666600ff6666660   ",
	"      0666660066666ff6666660    ",
	"       06666660066666666600     ",
	"        0066600600666660060     ",
	"          000  06600000660      ",
	"                066666660       ",
	"                 0666600        ",
	"                  0000          "
};

char *blokea[34]=  /* 16 en largeur */
{
	"        0  00   ",
	"       0  0     ",
	"       0 0   00 ",
	"      0  0 00000",
	"      0 0  00000",
	"      0 0 000   ",
	"      0 0 00    ",
	"      0 0 00    ",
	"      00000     ",
	"     0444440    ",
	"     0044400    ",
	"    044444440   ",
	"   04000044440  ",
	"  040ffff04440  ",
	" 000fddfff04400 ",
	"0 00fdffff0440 0",
	"00040ffff04440 0",
	"0ff0400004440000",
	"0fff044444400ff0",
	"0ff000000000fff0",
	" 000   0  0 0ff0",
	"   0  0    0 00 ",
	"  0   0    00   ",
	" 00   00   00   ",
	" 00   00    000 ",
	"   0   0    0550",
	"   000 0    0550",
	"   0550000 05550",
	"   055005500550 ",
	"  0555005500550 ",
	"  055005550 00  ",
	"  05500550      ",
	"   00 0550      ",
	"       00       "
};

char *blokeb[34]=  /* 16 en largeur */
{
	"   00  0        ",
	"     0  0       ",
	" 00   0 0       ",
	"00000 0  0      ",
	"00000  0 0      ",
	"   000 0 0      ",
	"    00 0 0      ",
	"    00 0 0      ",
	"     00000      ",
	"    0444440     ",
	"    0044400     ",
	"   044444440    ",
	"  04400444440   ",
	"  040044444440  ",
	" 00400444444000 ",
	"0 040044444400 0",
	"00044444444440 0",
	"0ff0444444440000",
	"0fff044444400ff0",
	"0ff000000000fff0",
	" 00  0  0   0ff0",
	"    0    0  000 ",
	"   00    0   0  ",
	"   00    0   00 ",
	" 000    00   00 ",
	"0550    00  0   ",
	"0550    0 000   ",
	"05550 0000550   ",
	" 055005500550   ",
	" 0550055005550  ",
	"  00 055500550  ",
	"      05500550  ",
	"      0550 00   ",
	"       00       "
};

char *blokfa[31]=  /* 16 en largeur */
{
	"        0  00   ",
	"       0  0     ",
	"       0 0   00 ",
	"      0  0 00000",
	"      0 0  00000",
	"      0 0 000   ",
	"      0 0 00    ",
	"      0 0 00    ",
	"      00000     ",
	"     0444440    ",
	"     0044400    ",
	"    044444440   ",
	"   04000044440  ",
	"  040ffff04440  ",
	" 0 0fddfff04000 ",
	"0000fdffff0400 0",
	"0ff00ffff0444000",
	"0ff0400004440ff0",
	"0ff0044444400ff0",
	" 00 0000000 0ff0",
	"   00  0  0  00 ",
	"   0  0   0     ",
	"  00 00  00     ",
	"  00 00  000    ",
	"   000 0   0000 ",
	" 0055500  005550",
	"0555550000555550",
	"055500555055500 ",
	" 000555550000   ",
	"   055500       ",
	"    000         "
};

char *blokfb[31]=  /* 16 en largeur */
{
	"   00  0        ",
	"     0  0       ",
	" 00   0 0       ",
	"00000 0  0      ",
	"00000  0 0      ",
	"   000 0 0      ",
	"    00 0 0      ",
	"    00 0 0      ",
	"     00000      ",
	"    0444440     ",
	"    0044400     ",
	"   044444440    ",
	"  04400444440   ",
	"  04004444440   ",
	" 0040044444000  ",
	"0004004444400 0 ",
	"0f0444444444000 ",
	"0ff0444444440ff0",
	"0ff0044444400ff0",
	" 00 000000000ff0",
	"    0   0   000 ",
	"     00  00 0   ",
	"    000  00  00 ",
	"   0    00   00 ",
	"  0000 000000   ",
	" 005550005500   ",
	"00055505550000  ",
	"055500055005550 ",
	" 000   00005550 ",
	"        055500  ",
	"         000    "
};

char *blokga[20]=  /* 32 en largeur */
{
	"          00000    0000         ",
	"        004444400 044440        ",
	"       044444444400444440       ",
	"      0440444444000004440       ",
	"     04444044440444004440 00    ",
	"     0444440000044440440 0440   ",
	"    0440044444440444400004440   ",
	"   04444404440044004404444440   ",
	"  044f0044444440406040444400    ",
	"  04f00400440040406040400000    ",
	"  0400040040ff044060000444440   ",
	"  04f004040fdf0000040044444440  ",
	"  040004440fdf0444444006044440  ",
	"  04f0040440ff0444440440 00440  ",
	"  04000400440040000064440  00   ",
	"   04f0400444440    00440       ",
	"    04f044000000    04440       ",
	"     00000   00    044440       ",
	"                    0440        ",
	"                     00         "
};

char *blokgb[20]=  /* 32 en largeur */
{
	"          00000                 ",
	"        004444400       00      ",
	"       04444444440     0440     ",
	"      0440444444440    04440    ",
	"     04444044440440   044440    ",
	"     044444000044440004004000   ",
	"    04400444444444006004400440  ",
	"    044440444004400600440444440 ",
	"   044f04444444040600444044440  ",
	"   04f04004400404060444044400   ",
	"   040040040ff0440604400000000  ",
	"   04f04040fdf04406000004444440 ",
	"   04004440fdf044060444400044440",
	"   04f040440ff04406004444440440 ",
	"   040040044004044060000444000  ",
	"   04f0400444440000060440000    ",
	"    04f044000000    000444440   ",
	"     00000   00        0044440  ",
	"                         0440   ",
	"                          00    "
};
