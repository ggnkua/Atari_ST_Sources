/*  bitmaps.c */

#define blob_width 32
#define blob_height 32
#define blob_x_hot -1
#define blob_y_hot -1
 char blob_bits[] = {
   0xd3, 0x24, 0xbe, 0xff, 0x0f, 0x8c, 0xb5, 0xff, 0xef, 0xf3, 0x7d, 0x00,
   0x6e, 0xfe, 0x05, 0xf6, 0x7c, 0x03, 0xe0, 0x05, 0x03, 0x41, 0x3e, 0x02,
   0x0e, 0xfc, 0x01, 0x78, 0x90, 0x07, 0xf0, 0xcb, 0xc1, 0x19, 0xff, 0xff,
   0x86, 0xe0, 0x07, 0x00, 0xff, 0xff, 0x12, 0x00, 0x11, 0xc2, 0xff, 0xd1,
   0x11, 0xd0, 0xe8, 0xef, 0xec, 0x0b, 0x24, 0xec, 0x44, 0xfe, 0x01, 0x01,
   0xd2, 0xca, 0x3e, 0x88, 0x00, 0x00, 0x60, 0x3c, 0xbe, 0x03, 0x4b, 0x89,
   0xff, 0x3b, 0x00, 0x80, 0x00, 0xe4, 0xff, 0xfe, 0xff, 0xfb, 0x7b, 0x77,
   0x83, 0x87, 0xc0, 0x83, 0x00, 0x07, 0x0c, 0xf8, 0xf9, 0xfc, 0x80, 0x37,
   0xcc, 0xf8, 0xf7, 0x2d, 0x4e, 0xf1, 0xb6, 0x2b, 0x7c, 0x86, 0x7f, 0x60,
   0x01, 0x60, 0x00, 0x7d, 0xe4, 0x1e, 0xfc, 0x23, 0xf8, 0xe7, 0xc0, 0x1f,
   0x06, 0xdc, 0x07, 0x80, 0x8f, 0x04, 0x7d, 0xf2};
#define blob2_width 32
#define blob2_height 32
#define blob2_x_hot -1
#define blob2_y_hot -1
 char blob2_bits[] = {
   0xce, 0x03, 0x5f, 0x43, 0xf4, 0xf8, 0xfd, 0x89, 0x1c, 0xae, 0x07, 0x3f,
   0x80, 0x3f, 0x08, 0xbc, 0xb8, 0x40, 0xe2, 0x39, 0x5f, 0xfe, 0x01, 0x70,
   0xb2, 0xff, 0xff, 0xdb, 0xff, 0x47, 0xfe, 0x7b, 0x03, 0x11, 0x00, 0x4f,
   0x00, 0x18, 0x20, 0xf0, 0x58, 0xe1, 0x87, 0x00, 0x7f, 0x3c, 0x1f, 0x3c,
   0x00, 0x8e, 0x35, 0xe0, 0x80, 0xe7, 0xff, 0x03, 0x79, 0x7f, 0x58, 0x0e,
   0xfb, 0x1f, 0xc1, 0xff, 0xaf, 0xc0, 0x11, 0x86, 0xf8, 0x01, 0x00, 0x1e,
   0xbf, 0x0e, 0x5f, 0xee, 0xf0, 0x73, 0x80, 0xfb, 0x04, 0x7e, 0xfe, 0x3a,
   0x00, 0xe0, 0xf7, 0x81, 0xe3, 0x01, 0x00, 0x08, 0x3e, 0x46, 0xfb, 0xe3,
   0x0f, 0x49, 0x40, 0x98, 0x14, 0x3f, 0x31, 0xe7, 0xf4, 0xcf, 0xf5, 0x3c,
   0x7e, 0xb8, 0xfe, 0x03, 0x03, 0xe0, 0x1a, 0xf8, 0x80, 0x83, 0xbb, 0x3e,
   0xf3, 0x8f, 0xfc, 0xc3, 0x71, 0x0e, 0x02, 0x80};
#define boulder_width 32
#define boulder_height 32
#define boulder_x_hot -1
#define boulder_y_hot -1
 char boulder_bits[] = {
   0xff, 0x47, 0x91, 0xff, 0x7f, 0x02, 0xa8, 0xfe, 0x5f, 0x18, 0x00, 0xfc,
   0x2f, 0x18, 0x02, 0xf8, 0x17, 0x00, 0x10, 0xf0, 0x2b, 0x80, 0x00, 0xe2,
   0x57, 0x55, 0x85, 0xc1, 0xab, 0xaa, 0x0a, 0xe1, 0x15, 0x15, 0x15, 0x90,
   0xab, 0x2a, 0xaa, 0x80, 0x55, 0x5d, 0x55, 0xc1, 0xaa, 0xaa, 0xaa, 0x82,
   0xd5, 0x55, 0x55, 0x05, 0xaa, 0xaa, 0x8a, 0x82, 0x55, 0x5d, 0x14, 0x05,
   0xaa, 0xaa, 0x2a, 0x8a, 0x77, 0x55, 0x55, 0x55, 0xea, 0xaa, 0xa2, 0xaa,
   0xdf, 0x55, 0x55, 0x55, 0xae, 0xaa, 0xea, 0xaa, 0xd5, 0x5d, 0xd5, 0x55,
   0xaf, 0xaa, 0xaa, 0xaa, 0x7d, 0xd5, 0x55, 0xd5, 0xeb, 0xab, 0xab, 0xaa,
   0xdf, 0x5f, 0x55, 0xd5, 0xaf, 0xae, 0xba, 0xea, 0xff, 0x75, 0xf5, 0xf5,
   0xbf, 0xef, 0xaa, 0xfa, 0xff, 0xdf, 0x75, 0xfd, 0xff, 0xbf, 0xae, 0xfe,
   0xff, 0x57, 0xd5, 0xff, 0xff, 0xaf, 0xea, 0xff};
#define diamond_width 32
#define diamond_height 32
#define diamond_x_hot -1
#define diamond_y_hot -1
 char diamond_bits[] = {
   0xff, 0x7f, 0xfe, 0xff, 0xff, 0xbf, 0xfd, 0xff, 0xff, 0x1f, 0xf8, 0xff,
   0xff, 0x0f, 0xf0, 0xff, 0xff, 0xf7, 0xef, 0xff, 0xff, 0xfb, 0xdf, 0xff,
   0xff, 0xfd, 0xbf, 0xff, 0xff, 0x00, 0x00, 0xff, 0x7f, 0x00, 0x00, 0xfe,
   0xbf, 0xff, 0xff, 0xfd, 0x1f, 0x00, 0x00, 0xf8, 0xef, 0xff, 0xff, 0xf7,
   0x07, 0x00, 0x00, 0xe0, 0x03, 0x00, 0x00, 0xc0, 0xfd, 0xff, 0xff, 0xbf,
   0xfe, 0xff, 0xff, 0x7f, 0x00, 0x00, 0x00, 0x00, 0xfd, 0xff, 0xff, 0xbf,
   0xfb, 0xff, 0xff, 0xcf, 0x07, 0x00, 0x00, 0xe0, 0x0f, 0x00, 0x00, 0xf0,
   0x1f, 0x00, 0x00, 0xf8, 0xbf, 0xff, 0xff, 0xfd, 0x7f, 0x00, 0x00, 0xfe,
   0xff, 0x00, 0x00, 0xff, 0xff, 0xfd, 0xbf, 0xff, 0xff, 0x03, 0xc0, 0xff,
   0xff, 0xf7, 0xef, 0xff, 0xff, 0xef, 0xf7, 0xff, 0xff, 0x1f, 0xf8, 0xff,
   0xff, 0x3f, 0xfc, 0xff, 0xff, 0x7f, 0xfe, 0xff};
#define diamond2_width 32
#define diamond2_height 32
#define diamond2_x_hot -1
#define diamond2_y_hot -1
 char diamond2_bits[] = {
   0xff, 0x7f, 0xfe, 0xff, 0xff, 0xbf, 0xfd, 0xff, 0xff, 0xdf, 0xfb, 0xff,
   0xff, 0xef, 0xf7, 0xff, 0xff, 0x07, 0xe0, 0xff, 0xff, 0xfb, 0xdf, 0xff,
   0xff, 0x01, 0x80, 0xff, 0xff, 0xfe, 0x7f, 0xff, 0x7f, 0xff, 0xff, 0xfe,
   0x3f, 0x00, 0x00, 0xfc, 0x1f, 0x00, 0x00, 0xf8, 0xef, 0xff, 0xff, 0xf7,
   0xf7, 0xff, 0xff, 0xef, 0x03, 0x00, 0x00, 0xc0, 0x01, 0x00, 0x00, 0x80,
   0xfe, 0xff, 0xff, 0x7f, 0xfe, 0xff, 0xff, 0x7f, 0x01, 0x00, 0x00, 0x80,
   0xfb, 0xff, 0xff, 0xdf, 0x07, 0x00, 0x00, 0xe0, 0x0f, 0x00, 0x00, 0xf0,
   0xdf, 0xff, 0xff, 0xfb, 0x3f, 0x00, 0x00, 0xfc, 0x7f, 0xff, 0xff, 0xfe,
   0xff, 0x00, 0x00, 0xff, 0xff, 0x01, 0x80, 0xff, 0xff, 0xfb, 0xdf, 0xff,
   0xff, 0x07, 0xe0, 0xff, 0xff, 0xef, 0xf7, 0xff, 0xff, 0xdf, 0xfb, 0xff,
   0xff, 0x3f, 0xfc, 0xff, 0xff, 0x7f, 0xfe, 0xff};
#define eater_width 32
#define eater_height 32
#define eater_x_hot -1
#define eater_y_hot -1
 char eater_bits[] = {
   0xff, 0x0f, 0xf0, 0xff, 0xff, 0x61, 0xc1, 0xff, 0x7f, 0x08, 0x02, 0xff,
   0x1f, 0x04, 0x00, 0xfe, 0x1f, 0x52, 0x50, 0xfc, 0x0f, 0x09, 0x00, 0xf9,
   0x8f, 0x1a, 0x10, 0xf0, 0x87, 0x40, 0x4d, 0xe2, 0x63, 0x2c, 0x30, 0xe2,
   0x13, 0x9f, 0x79, 0xc4, 0x51, 0x3f, 0xfc, 0x81, 0xa1, 0x33, 0xfc, 0x82,
   0x21, 0x73, 0xce, 0x80, 0x81, 0x3e, 0xcd, 0xa2, 0x41, 0xb8, 0xfe, 0x84,
   0x11, 0x01, 0x64, 0x81, 0x41, 0xc8, 0x1b, 0x8a, 0x11, 0x52, 0xca, 0x80,
   0x49, 0xc5, 0x6e, 0x8a, 0xf1, 0xff, 0xff, 0x8f, 0x39, 0x1f, 0xf1, 0x8b,
   0x59, 0x4f, 0xc6, 0xa5, 0x51, 0xa6, 0xd1, 0x89, 0xa1, 0x1f, 0xca, 0xa0,
   0x31, 0xac, 0xd0, 0x8a, 0x51, 0xa9, 0x44, 0x94, 0x11, 0x00, 0xb5, 0x88,
   0xc1, 0x40, 0x00, 0x92, 0x05, 0x02, 0xf4, 0x80, 0x39, 0x62, 0xf8, 0xa1,
   0x7d, 0xf7, 0xfc, 0xb9, 0xff, 0xff, 0xff, 0xff};
#define eater2_width 32
#define eater2_height 32
#define eater2_x_hot -1
#define eater2_y_hot -1
 char eater2_bits[] = {
   0xff, 0x0f, 0xf8, 0xff, 0xff, 0x01, 0xc0, 0xff, 0x7f, 0xa8, 0x08, 0xff,
   0x3f, 0x1c, 0x00, 0xfe, 0x9f, 0x52, 0x50, 0xfc, 0x0f, 0x41, 0x00, 0xf8,
   0x8f, 0x1a, 0x12, 0xf0, 0x87, 0x40, 0xc8, 0xe2, 0x63, 0x2e, 0xb2, 0xe2,
   0x13, 0x9f, 0xf9, 0xc4, 0xd9, 0x39, 0x9d, 0xc9, 0xa9, 0xb9, 0x9c, 0x86,
   0x21, 0x7f, 0xfe, 0x98, 0x89, 0x3e, 0xfd, 0xaa, 0x79, 0xb8, 0xfe, 0x94,
   0x51, 0x21, 0x64, 0x81, 0xc5, 0xc8, 0x1b, 0x98, 0x11, 0x52, 0xca, 0x80,
   0x49, 0xc5, 0x6e, 0x8a, 0xf5, 0xff, 0xff, 0x9f, 0xb9, 0x55, 0xd5, 0x9b,
   0xd9, 0x55, 0xd5, 0xb7, 0xdd, 0xa7, 0xea, 0x8b, 0xa5, 0xbf, 0xfa, 0x87,
   0x3d, 0xff, 0xff, 0x8f, 0x7d, 0xef, 0xdf, 0x97, 0x2d, 0xc6, 0xf7, 0x8b,
   0xfd, 0x47, 0xf0, 0x83, 0x29, 0x02, 0x06, 0x81, 0x41, 0x40, 0x01, 0x9d,
   0x75, 0xf3, 0x2c, 0xb8, 0xff, 0xff, 0xff, 0xff};
#define exit2_width 32
#define exit2_height 32
 char exit2_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0xfd, 0xff, 0xff, 0xff, 0xf9, 0xff, 0xff, 0xff,
   0x01, 0x00, 0x00, 0xe0, 0x01, 0x00, 0x00, 0xe0, 0x09, 0x00, 0x00, 0xe0,
   0x19, 0x00, 0x00, 0xe0, 0x99, 0x1f, 0xf8, 0xe1, 0x19, 0x1f, 0xf0, 0xe1,
   0x19, 0x18, 0x80, 0xe1, 0x19, 0x19, 0x90, 0xe1, 0x19, 0x1b, 0xb0, 0xe1,
   0x19, 0x10, 0x00, 0xe1, 0x19, 0x00, 0x00, 0xe0, 0x19, 0x00, 0x00, 0xe0,
   0x19, 0x00, 0x00, 0xe0, 0x19, 0x00, 0x00, 0xe0, 0x19, 0x00, 0x00, 0xe0,
   0x19, 0x00, 0x00, 0xe0, 0x99, 0x1f, 0xf8, 0xe1, 0x19, 0x1f, 0xf0, 0xe1,
   0x19, 0x18, 0x80, 0xe1, 0x19, 0x19, 0x90, 0xe1, 0x19, 0x1b, 0xb0, 0xe1,
   0x19, 0x10, 0x00, 0xe1, 0x19, 0x00, 0x00, 0xe0, 0x19, 0x00, 0x00, 0xe0,
   0xf9, 0xff, 0xff, 0xe7, 0xf9, 0xff, 0xff, 0xcf, 0x01, 0x00, 0x00, 0xc0,
   0x01, 0x00, 0x00, 0x80, 0xff, 0xff, 0xff, 0xff};
#define exit3_width 32
#define exit3_height 32
#define exit3_x_hot -1
#define exit3_y_hot -1
 char exit3_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0x61, 0x18, 0x63, 0x80, 0xef, 0x7b, 0xef, 0xbf,
   0xef, 0x7b, 0xef, 0xbf, 0xfd, 0x7b, 0xff, 0xf7, 0xfd, 0x7b, 0xff, 0xf7,
   0xfd, 0x7b, 0xff, 0xf7, 0xfd, 0x7b, 0xff, 0xf7, 0xfd, 0x7b, 0xe3, 0xf7,
   0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x77, 0xef, 0xf7,
   0xfd, 0x77, 0xef, 0xf7, 0xe1, 0x7f, 0xef, 0xf7, 0xef, 0xbf, 0xef, 0xf7,
   0xef, 0xdf, 0xef, 0xf7, 0xfd, 0xbf, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7,
   0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7,
   0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7,
   0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7, 0xfd, 0x7b, 0xef, 0xf7,
   0xfd, 0x7b, 0xef, 0xf7, 0xe1, 0x7b, 0xef, 0xf7, 0xef, 0x7b, 0xef, 0xf7,
   0xef, 0x7b, 0xef, 0xf7, 0xff, 0xff, 0xff, 0xff};
#define explosion_width 32
#define explosion_height 32
 char explosion_bits[] = {
   0xff, 0xff, 0xb7, 0x7f, 0xee, 0xb9, 0xb7, 0xbc, 0xcd, 0xf3, 0xdf, 0xbe,
   0xdf, 0xb5, 0x7b, 0xff, 0xff, 0xf1, 0xbb, 0xef, 0x9f, 0xe7, 0xdf, 0xf7,
   0x7e, 0xaf, 0x6e, 0x7e, 0xfc, 0xef, 0x66, 0xbf, 0xeb, 0xbb, 0xd2, 0xcf,
   0xdf, 0xdf, 0xfa, 0xef, 0x7f, 0xdf, 0xf7, 0xfd, 0xff, 0xdc, 0x3e, 0xfe,
   0xf9, 0xf3, 0x39, 0xfb, 0xcf, 0x1f, 0xdc, 0xbd, 0x3b, 0x19, 0xf9, 0xd4,
   0x7d, 0x5f, 0xbf, 0xfe, 0xff, 0x53, 0x54, 0xff, 0xbf, 0x39, 0xb7, 0xa9,
   0xfd, 0xbe, 0x7d, 0xbf, 0xde, 0xbe, 0xfb, 0x70, 0x7f, 0xdf, 0xd7, 0xcf,
   0xb7, 0x8f, 0xcf, 0xbf, 0xbf, 0x5d, 0xde, 0x7c, 0xfb, 0xdd, 0x7d, 0xfa,
   0xff, 0xcd, 0xfb, 0xe7, 0xe7, 0xc4, 0xef, 0xfc, 0xfb, 0xf6, 0xee, 0xf7,
   0xfd, 0xf6, 0x1b, 0x8f, 0x7c, 0xdf, 0x77, 0x7e, 0x8e, 0xdb, 0xef, 0xfe,
   0xe7, 0xdb, 0xff, 0xf7, 0xff, 0xfb, 0xcf, 0xef};
#define grass_width 32
#define grass_height 32
#define grass_x_hot -1
#define grass_y_hot -1
 char grass_bits[] = {
   0x5c, 0x55, 0x55, 0x55, 0xda, 0xfa, 0xeb, 0xfe, 0x55, 0x10, 0x00, 0x45,
   0x29, 0xee, 0xea, 0xaa, 0xd5, 0x55, 0x51, 0xdd, 0xfa, 0xaa, 0xe2, 0xac,
   0x77, 0x5d, 0x55, 0x15, 0xaa, 0xe7, 0xa2, 0xaa, 0x57, 0x75, 0x4b, 0xd8,
   0xaa, 0xeb, 0xa2, 0xaa, 0x76, 0x55, 0x5d, 0x4f, 0xca, 0xb8, 0xea, 0xaa,
   0x77, 0x55, 0x47, 0xd0, 0xab, 0xeb, 0xba, 0xea, 0x75, 0x45, 0x5f, 0x55,
   0xab, 0xab, 0xba, 0xea, 0x5f, 0x5d, 0x55, 0x47, 0xaa, 0xeb, 0x3b, 0xab,
   0xd5, 0x1f, 0x75, 0x55, 0xe6, 0xca, 0xab, 0xee, 0x55, 0x55, 0x55, 0x55,
   0xea, 0xab, 0xea, 0xaa, 0x57, 0xf5, 0x55, 0x69, 0xae, 0xab, 0xba, 0x98,
   0x55, 0x7d, 0xdd, 0x5d, 0xee, 0xba, 0xaa, 0xba, 0x5f, 0xd5, 0x75, 0x55,
   0xab, 0xaa, 0xaa, 0xef, 0xd7, 0x57, 0x55, 0x1f, 0xff, 0xbe, 0xab, 0xbf,
   0x5f, 0xf5, 0x5f, 0xd5, 0xfe, 0xab, 0xfe, 0x7f};
#define icon_width 32
#define icon_height 32
 char icon_bits[] = {
   0x7f, 0xf5, 0x57, 0xfd, 0xbf, 0xea, 0xab, 0xfa, 0x5f, 0x55, 0x55, 0xf5,
   0xaf, 0xaa, 0xaa, 0xfa, 0x5f, 0x55, 0x55, 0xf5, 0xab, 0xaf, 0xfa, 0xea,
   0xd5, 0xdf, 0xfd, 0xd5, 0xab, 0xef, 0xfb, 0xaa, 0x55, 0x55, 0x55, 0xd5,
   0xab, 0xaa, 0xaa, 0xea, 0x5f, 0x5d, 0x5d, 0xfd, 0xbf, 0xfa, 0xaf, 0xfe,
   0xff, 0xf5, 0x55, 0xff, 0xff, 0xef, 0xaa, 0xff, 0xff, 0xf7, 0xfd, 0xff,
   0xab, 0xaa, 0xaa, 0xea, 0x41, 0x55, 0x55, 0xc5, 0xa3, 0xff, 0xff, 0x8a,
   0x55, 0x01, 0x40, 0xc5, 0xff, 0x00, 0x80, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0x6d, 0x18, 0xf3, 0xff, 0x6d, 0xdb, 0xe2, 0xff,
   0x73, 0xd8, 0xfe, 0xff, 0x73, 0xdb, 0xea, 0xff, 0x6d, 0xdb, 0xf6, 0xff,
   0x6d, 0x18, 0xeb, 0xff, 0xff, 0xff, 0xf7, 0xff, 0xff, 0xf1, 0xeb, 0xff,
   0x1f, 0xf8, 0x07, 0xfe, 0x1f, 0xf8, 0x07, 0xfe};
#define lmonster_width 32
#define lmonster_height 32
#define lmonster_x_hot -1
#define lmonster_y_hot -1
 char lmonster_bits[] = {
   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
   0xf8, 0xff, 0xff, 0x1f, 0xf8, 0xff, 0xff, 0x1f, 0xf8, 0xff, 0xff, 0x1f,
   0x38, 0x00, 0x00, 0x1c, 0xb8, 0xff, 0xff, 0x1d, 0xb8, 0xff, 0xff, 0x1d,
   0xb8, 0x01, 0x80, 0x1d, 0xb8, 0x01, 0x80, 0x1d, 0xb8, 0xf9, 0x9f, 0x1d,
   0xb8, 0xf9, 0x9f, 0x1d, 0xb8, 0x19, 0x98, 0x1d, 0xb8, 0x19, 0x98, 0x1d,
   0xb8, 0x19, 0x98, 0x1d, 0xb8, 0x19, 0x98, 0x1d, 0xb8, 0x19, 0x98, 0x1d,
   0xb8, 0x19, 0x98, 0x1d, 0xb8, 0xf9, 0x9f, 0x1d, 0xb8, 0xf9, 0x9f, 0x1d,
   0xb8, 0x01, 0x80, 0x1d, 0xb8, 0x01, 0x80, 0x1d, 0xb8, 0xff, 0xff, 0x1d,
   0xb8, 0xff, 0xff, 0x1d, 0x38, 0x00, 0x00, 0x1c, 0xf8, 0xff, 0xff, 0x1f,
   0xf8, 0xff, 0xff, 0x1f, 0xf8, 0xff, 0xff, 0x1f, 0x00, 0x00, 0x00, 0x00,
   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
#define lmonster2_width 32
#define lmonster2_height 32
#define lmonster2_x_hot -1
#define lmonster2_y_hot -1
 char lmonster2_bits[] = {
   0x00, 0x00, 0x00, 0x00, 0xfe, 0xff, 0xff, 0x7f, 0xfe, 0xff, 0xff, 0x7f,
   0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0xe6, 0xff, 0xff, 0x67,
   0xe6, 0xff, 0xff, 0x67, 0x66, 0x00, 0x00, 0x66, 0x66, 0x00, 0x00, 0x66,
   0x66, 0xfe, 0x7f, 0x66, 0x66, 0xfe, 0x7f, 0x66, 0x66, 0xfe, 0x7f, 0x66,
   0x66, 0x0e, 0x70, 0x66, 0x66, 0x0e, 0x70, 0x66, 0x66, 0xce, 0x73, 0x66,
   0x66, 0x4e, 0x72, 0x66, 0x66, 0x4e, 0x72, 0x66, 0x66, 0xce, 0x73, 0x66,
   0x66, 0x0e, 0x70, 0x66, 0x66, 0x0e, 0x70, 0x66, 0x66, 0xfe, 0x7f, 0x66,
   0x66, 0xfe, 0x7f, 0x66, 0x66, 0xfe, 0x7f, 0x66, 0x66, 0x00, 0x00, 0x66,
   0x66, 0x00, 0x00, 0x66, 0xe6, 0xff, 0xff, 0x67, 0xe6, 0xff, 0xff, 0x67,
   0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0xfe, 0xff, 0xff, 0x7f,
   0xfe, 0xff, 0xff, 0x7f, 0x00, 0x00, 0x00, 0x00};
#define nucbal_width 32
#define nucbal_height 32
 char nucbal_bits[] = {
   0xff, 0x1f, 0xf0, 0xff, 0xff, 0x03, 0x80, 0xff, 0xff, 0x00, 0x00, 0xfe,
   0x7f, 0x00, 0xc0, 0xfc, 0x3f, 0x07, 0xc0, 0xf9, 0x9f, 0x0f, 0xe0, 0xf3,
   0xcf, 0x0f, 0xe0, 0xe7, 0xc7, 0x1f, 0xf0, 0xcf, 0xe7, 0x1f, 0xf0, 0xcf,
   0xf3, 0x3f, 0xf8, 0x9f, 0xf3, 0xff, 0xff, 0x9f, 0xf3, 0xff, 0xff, 0xbf,
   0xf9, 0x7f, 0xfc, 0x3f, 0xf9, 0x3f, 0xf8, 0x3f, 0xf9, 0x3f, 0xf8, 0x3f,
   0xf9, 0x3f, 0xf8, 0x3f, 0xf9, 0x73, 0xdc, 0x3f, 0x79, 0xe0, 0x0f, 0x3f,
   0x09, 0xc0, 0x07, 0x3c, 0x03, 0xc0, 0x07, 0x90, 0x03, 0xc0, 0x07, 0x80,
   0x03, 0xe0, 0x0f, 0x80, 0x07, 0xf0, 0x0f, 0xc0, 0x07, 0xf0, 0x1f, 0xc0,
   0x0f, 0xf8, 0x1f, 0xe0, 0x1f, 0xf8, 0x3f, 0xf0, 0x3f, 0xfc, 0x3f, 0xf8,
   0x7f, 0xfc, 0x7f, 0xfc, 0xff, 0xf0, 0x1f, 0xfe, 0xff, 0x03, 0x80, 0xff,
   0xff, 0x1f, 0xf0, 0xff, 0xff, 0xff, 0xff, 0xff};
#define player_width 32
#define player_height 32
#define player_x_hot -1
#define player_y_hot -1
 char player_bits[] = {
   0x7f, 0xf5, 0x57, 0xfd, 0xbf, 0xea, 0xab, 0xfa, 0x5f, 0x55, 0x55, 0xf5,
   0xaf, 0xaa, 0xaa, 0xfa, 0x5f, 0x55, 0x55, 0xf5, 0xab, 0xaf, 0xfa, 0xea,
   0xd5, 0xdf, 0xfd, 0xd5, 0xaf, 0xef, 0xfb, 0xba, 0x55, 0x55, 0x55, 0xd5,
   0xab, 0xaa, 0xaa, 0xea, 0x5f, 0x5d, 0x5d, 0xfd, 0xbf, 0xfa, 0xaf, 0xfe,
   0xff, 0xb5, 0x55, 0xff, 0xff, 0xef, 0xaa, 0xff, 0xff, 0xf7, 0xfd, 0xff,
   0xab, 0xaa, 0xaa, 0xea, 0x41, 0x55, 0x55, 0xc5, 0xa3, 0xff, 0xff, 0x8a,
   0x55, 0x01, 0x40, 0xc5, 0xff, 0x00, 0x80, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0x07, 0xf0, 0xff, 0xff, 0x03, 0xe0, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xab, 0xea, 0xff, 0xff, 0xd7, 0xf5, 0xff,
   0xff, 0xeb, 0xeb, 0xff, 0xff, 0xf5, 0xf7, 0xff, 0xff, 0xf1, 0xeb, 0xff,
   0x1f, 0xf8, 0x07, 0xfe, 0x1f, 0xf8, 0x07, 0xfe};
#define player2_width 32
#define player2_height 32
#define player2_x_hot -1
#define player2_y_hot -1
 char player2_bits[] = {
   0x7f, 0xf5, 0x57, 0xfd, 0xbf, 0xea, 0xab, 0xfa, 0x5f, 0x55, 0x55, 0xf5,
   0xaf, 0xaa, 0xaa, 0xfa, 0x5f, 0x55, 0x55, 0xf5, 0xab, 0xaa, 0xaa, 0xea,
   0xd5, 0xdf, 0xf5, 0xd7, 0xaf, 0xee, 0xeb, 0xba, 0x55, 0x55, 0x55, 0xd5,
   0xab, 0xaa, 0xaa, 0xea, 0x5f, 0x5d, 0x5d, 0xfd, 0xbf, 0xfa, 0xaf, 0xfe,
   0xff, 0xd5, 0x55, 0xff, 0xff, 0xaf, 0xaa, 0xff, 0xff, 0xd7, 0xfd, 0xff,
   0xab, 0xaa, 0xaa, 0xea, 0x41, 0x55, 0x55, 0xc5, 0xa3, 0xff, 0xff, 0x8a,
   0x55, 0x01, 0x40, 0xc5, 0xff, 0x00, 0x80, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0x07, 0xf0, 0xff, 0xff, 0x03, 0xe0, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xab, 0xea, 0xff, 0xff, 0xd7, 0xf5, 0xff,
   0xff, 0xeb, 0xeb, 0xff, 0xff, 0xf5, 0xf7, 0xff, 0x1f, 0xf1, 0xeb, 0xff,
   0x1f, 0xf8, 0x07, 0xfe, 0xff, 0xfb, 0x07, 0xfe};
#define rmonster_width 32
#define rmonster_height 32
#define rmonster_x_hot -1
#define rmonster_y_hot -1
 char rmonster_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0xf9, 0xff, 0xff, 0x9f, 0xf1, 0xff, 0xff, 0x8f,
   0xe1, 0xff, 0xff, 0x87, 0xc1, 0xff, 0xff, 0x83, 0x81, 0xff, 0xff, 0x81,
   0x01, 0xff, 0xff, 0x80, 0x01, 0xfe, 0x7f, 0x80, 0x11, 0xfc, 0x3f, 0x88,
   0x31, 0xf8, 0x1f, 0x8c, 0x71, 0xf0, 0x0f, 0x8e, 0xd1, 0xe0, 0x07, 0x8b,
   0x91, 0xc1, 0x83, 0x89, 0x11, 0x83, 0xc1, 0x88, 0x11, 0x06, 0x60, 0x88,
   0x11, 0x0c, 0x30, 0x88, 0x11, 0x0c, 0x30, 0x88, 0x11, 0x06, 0x60, 0x88,
   0x11, 0x83, 0xc1, 0x88, 0x91, 0xc1, 0x83, 0x89, 0xd1, 0xe0, 0x07, 0x8b,
   0x71, 0xf0, 0x0f, 0x8e, 0x31, 0xf8, 0x1f, 0x8c, 0x11, 0xfc, 0x3f, 0x88,
   0x01, 0xfe, 0x7f, 0x80, 0x01, 0xff, 0xff, 0x80, 0x81, 0xff, 0xff, 0x81,
   0xc1, 0xff, 0xff, 0x83, 0xe1, 0xff, 0xff, 0x87, 0xf1, 0xff, 0xff, 0x8f,
   0xf9, 0xff, 0xff, 0x9f, 0xff, 0xff, 0xff, 0xff};
#define rmonster2_width 32
#define rmonster2_height 32
#define rmonster2_x_hot -1
#define rmonster2_y_hot -1
 char rmonster2_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0xf1, 0xff, 0xff, 0x8f, 0xe1, 0xff, 0xff, 0x87,
   0xc1, 0xff, 0xff, 0x83, 0x81, 0xff, 0xff, 0x81, 0x01, 0xff, 0xff, 0x80,
   0x09, 0xfe, 0x7f, 0x90, 0x19, 0xfc, 0x3f, 0x98, 0x39, 0xf8, 0x1f, 0x9c,
   0x79, 0xf0, 0x0f, 0x9e, 0xf9, 0xe0, 0x07, 0x9f, 0xd9, 0xc1, 0x83, 0x9b,
   0x99, 0x83, 0xc1, 0x99, 0x19, 0x07, 0xe0, 0x98, 0x19, 0x0e, 0x70, 0x98,
   0xd9, 0x1c, 0x38, 0x9b, 0xd9, 0x1c, 0x38, 0x9b, 0x19, 0x1e, 0x70, 0x98,
   0x19, 0x07, 0xe0, 0x98, 0x99, 0x83, 0xc1, 0x99, 0xd9, 0xc1, 0x83, 0x9b,
   0xf9, 0xe0, 0x07, 0x9f, 0x79, 0xf0, 0x0f, 0x9e, 0x39, 0xf8, 0x1f, 0x9c,
   0x19, 0xfc, 0x3f, 0x98, 0x09, 0xfe, 0x7f, 0x90, 0x01, 0xff, 0xff, 0x80,
   0x81, 0xff, 0xff, 0x81, 0xc1, 0xff, 0xff, 0x83, 0xe1, 0xff, 0xff, 0x87,
   0xf1, 0xff, 0xff, 0x8f, 0xff, 0xff, 0xff, 0xff};
#define space_width 32
#define space_height 32
 char space_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
   0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff
   };
#define steel_width 32
#define steel_height 32
#define steel_x_hot -1
#define steel_y_hot -1
 char steel_bits[] = {
   0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
   0xfe, 0xff, 0xff, 0x1f, 0xfe, 0xff, 0xff, 0x1f, 0xf6, 0xff, 0xff, 0x1f,
   0xe6, 0xff, 0xff, 0x1f, 0x66, 0xe0, 0x07, 0x1e, 0xe6, 0xe0, 0x0f, 0x1e,
   0xe6, 0xe7, 0x7f, 0x1e, 0xe6, 0xe6, 0x6f, 0x1e, 0xe6, 0xe4, 0x4f, 0x1e,
   0xe6, 0xef, 0xff, 0x1e, 0xe6, 0xff, 0xff, 0x1f, 0xe6, 0xff, 0xff, 0x1f,
   0xe6, 0xff, 0xff, 0x1f, 0xe6, 0xff, 0xff, 0x1f, 0xe6, 0xff, 0xff, 0x1f,
   0xe6, 0xff, 0xff, 0x1f, 0x66, 0xe0, 0x07, 0x1e, 0xe6, 0xe0, 0x0f, 0x1e,
   0xe6, 0xe7, 0x7f, 0x1e, 0xe6, 0xe6, 0x6f, 0x1e, 0xe6, 0xe4, 0x4f, 0x1e,
   0xe6, 0xef, 0xff, 0x1e, 0xe6, 0xff, 0xff, 0x1f, 0xe6, 0xff, 0xff, 0x1f,
   0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0xfe, 0xff, 0xff, 0x3f,
   0xfe, 0xff, 0xff, 0x7f, 0x00, 0x00, 0x00, 0x00};
#define tinkle1_width 32
#define tinkle1_height 32
 char tinkle1_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0x20, 0x40, 0x20, 0x20, 0x20, 0x40, 0x20, 0x20,
   0x20, 0x40, 0x20, 0x20, 0xff, 0xff, 0xff, 0xff, 0x02, 0x02, 0x04, 0x02,
   0x02, 0x02, 0x04, 0x02, 0x02, 0x02, 0x04, 0x02, 0xff, 0xff, 0xff, 0xff,
   0x20, 0x40, 0x20, 0x20, 0x20, 0x40, 0x20, 0x20, 0x20, 0x40, 0x20, 0x20,
   0xff, 0xff, 0xff, 0xff, 0x02, 0x02, 0x04, 0x04, 0x02, 0x02, 0x04, 0x04,
   0x02, 0x02, 0x04, 0x04, 0xff, 0xff, 0xff, 0xff, 0x10, 0x80, 0x40, 0x40,
   0x10, 0x80, 0x40, 0x40, 0x10, 0x80, 0x40, 0x40, 0xff, 0xff, 0xff, 0xff,
   0x01, 0x04, 0x08, 0x08, 0x01, 0x04, 0x08, 0x08, 0x01, 0x04, 0x08, 0x08,
   0xff, 0xff, 0xff, 0xff, 0x10, 0x10, 0x80, 0x40, 0x10, 0x10, 0x80, 0x40,
   0x10, 0x10, 0x80, 0x40, 0xff, 0xff, 0xff, 0xff, 0x04, 0x02, 0x04, 0x04,
   0x04, 0x02, 0x04, 0x04, 0x04, 0x02, 0x04, 0x04};
#define tinkle2_width 32
#define tinkle2_height 32
 char tinkle2_bits[] = {
   0xff, 0x3f, 0xf3, 0xff, 0x81, 0x80, 0x87, 0x00, 0x81, 0xc0, 0x8f, 0x00,
   0x81, 0xe0, 0x9f, 0x00, 0xff, 0xf3, 0x3f, 0xff, 0x08, 0xf8, 0x7f, 0x08,
   0x08, 0xfc, 0xff, 0x08, 0x08, 0xfe, 0xff, 0x09, 0x7f, 0xff, 0xff, 0xfb,
   0x01, 0xf8, 0x3f, 0x00, 0x81, 0xf8, 0xbf, 0x00, 0x81, 0xf8, 0xbf, 0x00,
   0xff, 0xfb, 0xbf, 0xff, 0x08, 0xf8, 0x3f, 0x10, 0x08, 0xf8, 0x3f, 0x10,
   0x08, 0xf8, 0x3f, 0x10, 0xff, 0xfb, 0xbf, 0xff, 0x41, 0xf8, 0x3f, 0x01,
   0x41, 0xf8, 0x3f, 0x01, 0x41, 0xf8, 0x3f, 0x01, 0xff, 0xfb, 0xbf, 0xff,
   0x04, 0xf8, 0x3f, 0x20, 0x04, 0xf8, 0x3f, 0x20, 0x04, 0xff, 0xff, 0x23,
   0x7f, 0xfe, 0xff, 0xf9, 0x41, 0xfc, 0xff, 0x00, 0x41, 0xf8, 0x7f, 0x02,
   0x41, 0xf0, 0x3f, 0x02, 0xff, 0xe7, 0xbf, 0xff, 0x10, 0xc8, 0x0f, 0x10,
   0x10, 0x88, 0x17, 0x10, 0x10, 0x08, 0x13, 0x10};
#define wall_width 32
#define wall_height 32
 char wall_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00,
   0x81, 0x00, 0x81, 0x00, 0xff, 0xff, 0xff, 0xff, 0x08, 0x08, 0x10, 0x08,
   0x08, 0x08, 0x10, 0x08, 0x08, 0x08, 0x10, 0x08, 0xff, 0xff, 0xff, 0xff,
   0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00,
   0xff, 0xff, 0xff, 0xff, 0x08, 0x08, 0x10, 0x10, 0x08, 0x08, 0x10, 0x10,
   0x08, 0x08, 0x10, 0x10, 0xff, 0xff, 0xff, 0xff, 0x41, 0x00, 0x02, 0x01,
   0x41, 0x00, 0x02, 0x01, 0x41, 0x00, 0x02, 0x01, 0xff, 0xff, 0xff, 0xff,
   0x04, 0x10, 0x20, 0x20, 0x04, 0x10, 0x20, 0x20, 0x04, 0x10, 0x20, 0x20,
   0xff, 0xff, 0xff, 0xff, 0x41, 0x40, 0x00, 0x02, 0x41, 0x40, 0x00, 0x02,
   0x41, 0x40, 0x00, 0x02, 0xff, 0xff, 0xff, 0xff, 0x10, 0x08, 0x10, 0x10,
   0x10, 0x08, 0x10, 0x10, 0x10, 0x08, 0x10, 0x10};
#define wall2_width 32
#define wall2_height 32
 char wall2_bits[] = {
   0xff, 0xff, 0xff, 0xff, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00,
   0x81, 0x00, 0x81, 0x00, 0xff, 0xff, 0xff, 0xff, 0x08, 0x08, 0x10, 0x08,
   0x08, 0x08, 0x10, 0x08, 0x08, 0x08, 0x10, 0x08, 0x9f, 0xfe, 0x7f, 0xf9,
   0xc1, 0x00, 0x01, 0x03, 0xe1, 0x00, 0x00, 0x07, 0xf1, 0xff, 0xff, 0x0f,
   0xf9, 0xff, 0xff, 0x9f, 0xfc, 0xff, 0xff, 0x3f, 0xfe, 0xff, 0xff, 0x7f,
   0xff, 0xff, 0xff, 0xff, 0xfe, 0xff, 0xff, 0x7f, 0xfc, 0xff, 0xff, 0x3f,
   0xf9, 0xff, 0xff, 0x1f, 0xf1, 0xff, 0xff, 0x0f, 0xe7, 0x00, 0x00, 0xe7,
   0xc4, 0x10, 0x20, 0x23, 0x84, 0x10, 0x20, 0x21, 0x04, 0x10, 0x20, 0x20,
   0xff, 0xff, 0xff, 0xff, 0x41, 0x40, 0x00, 0x02, 0x41, 0x40, 0x00, 0x02,
   0x41, 0x40, 0x00, 0x02, 0xff, 0xff, 0xff, 0xff, 0x10, 0x08, 0x10, 0x10,
   0x10, 0x08, 0x10, 0x10, 0x10, 0x08, 0x10, 0x10};
