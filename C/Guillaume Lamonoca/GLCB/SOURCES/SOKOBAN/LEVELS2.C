/* levels2.c */

char *ecrans2[20*50]=
{
/* ecran no: 50 */
"#########",
"#       #",
"#  $   $#",
"####    #",
"   # $  ##",
"####   $ #",
"#.. $ ## ####",
"#..  $##    #",
"#..    $    #",
"#.###$### #@#",
"#.# #     ###",
"### #######",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 51 */
"####        ########",
"#  ##########     @#",
"# $#    #     ######",
"#      ####   #  #",
"#####         #  #",
"#   $         #  ###",
"#  $####  #   #    #",
"# # #  #..#$###  # #",
"# # #$ #..#  $  $$ #",
"#      #..#  #   # #",
"#   #  #..#  #   # #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 52 */
"##################",
"#                ##",
"# $#   $ ##  $    #",
"#    $###    # $$ #",
"#.###     $ $ ##  ##",
"#...#  #  #    #$  #",
"#..##$$#### $  #   #",
"#...#      $ ##  ###",
"#...$  ###  #    # #",
"##..  $#  ##   ##@ #",
" ##.#              #",
"  ##################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 53 */
"####################",
"#   #    #   #   #@#",
"# $      $   $   # #",
"## ###..## ###     #",
"#   #....#$#  $### #",
"# $ #....#  $  $ $ #",
"#   #....# # # $ $ #",
"#   ##..##   #$#   #",
"##$##    ##  #  #$##",
"#   $  $     #  #  #",
"#   #    #   #     #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 54 */
"###################",
"#    @##      #   #",
"#    ##    $    $ #",
"#  ###....# # #  ###",
"#   #....# # # $   #",
"### #...#  #       #",
" #  ##.#     $   $ #",
" #  $ $ ###  # # ###",
" # $       # # $   #",
" ### $  $# # # # $ #",
"   #         # #  ##",
"   ################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 55 */
"##################",
"#  #  ##    #   @###",
"##    $    # $###  #",
"##$# $ ##$# $ $    #",
"#   $#    $      ###",
"# ##   $ ###  #....#",
"# # $# # # # #....##",
"#    $ $ #  #....##",
"##$ ###  $ #....##",
"#  # $        ###",
"#      # #    #",
"###############",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 56 */
"####################",
"#@     ###   #  #  #",
"# # #  #  $  $     #",
"#####     # $ $#$# #",
"#.#..#    ##$ $    #",
"#.....    $   #   ##",
"#.....    ###$##$###",
"#.#..#    $    #   #",
"#####     #  #$  $ #",
"    #  #  $    $ $ #",
"    #  #  #  #  #  #",
"    ################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 57 */
" ###################",
"##...   ## #    #  #",
"#....         $ ## #",
"#....# # #$###$    #",
"#...#    #       # #",
"##.#  #$ #     $## #",
"#  #  # $ $ ###  $ #",
"#     $  $ #  # ## #",
"## # ## #$$# $#  # #",
"#  #   $ $ #      ##",
"#    #     #  #   @#",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 58 */
"################",
"#   #  #@# ##  #",
"# # #  $    $  ###",
"# #    ###### $  ###",
"#   #  #....#  $$  #",
"##$##$##....#      #",
"#      #....##$##$##",
"#  $$  #....#      #",
"# $  $  #  #  ###  #",
"#####  $   $    $  #",
"    # #    #  #   ##",
"    ###############",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 59 */
"####################",
"# #     #          #",
"#       $  ## ### ##",
"#####  ##   $  $   #",
"##..##  # # $ # #  #",
"#....  $     ##$# ##",
"#....  $#####   #$##",
"##..# #  #   #  $  #",
" ##.# #  $   $  # @#",
" #  $  $ #   #  ####",
" #       ########",
" #########",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 60 */
"####### #### #######",
"#     # #..# #     #",
"# $$  ###..###  $@ #",
"#  # ##......#  $  #",
"#     #......#  $  #",
"####  ###..######$ #",
"#   $$$ #..#    #  #",
"# $#   $  $  $$ #$ #",
"#  #  ## $  ##  #  #",
"# $    $ ## $    $ #",
"#  #  ##    ##  #  #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 61 */
"####################",
"#    #  # #  #  #  #",
"# @# # ## $   $   ##",
"#### #    #  # $   #",
"#    # ## #$ ## ## #",
"#      $   $   $   #",
"#..###$$## $##$ ## #",
"#..#.#  # $   $ #  #",
"#....# $$   ##$ ####",
"#....#  #####      #",
"#...###        ##  #",
"##### ##############",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 62 */
"####################",
"#....#       #  #  #",
"#....# # $  $      #",
"#.... ##  $# # $#$ #",
"#...#   $   $#  $  #",
"#..####  # $   $$  #",
"#      #### #### ###",
"#        #   #     #",
"# ##   #   $ # $ $ #",
"# ##    $ ## $  $  #",
"#     @#     #   # #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 63 */
"###### #############",
"#....# #           #",
"#....# ### #  #$# ##",
"#....# #   #$  $   #",
"#....# #    $  #$$##",
"##  ## # $#  #$ $  #",
" #  #  #  $  $  #  #",
" #@ ####$###$## $  #",
" #        #  #  $  #",
" #   ###  #  $  ####",
" ##### #  #  #     #",
"       #############",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 64 */
"##################",
"#     #     @#...##",
"#     #      ##...##",
"# # # ##$## ## ....#",
"#   $ #   $$$  ....#",
"###$### $$  ### ##.#",
"#     $  #    # ####",
"#  $  #  ###  # #  #",
"## #$##    $  $$   #",
"#   $ ##   #  # #  #",
"#     #    #  #    #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 65 */
"####################",
"#     #  #...#@    #",
"# #       ....#    #",
"#  $  #   #....#   #",
"# ##$#### ##....#  #",
"# $   $  #  #...#  #",
"# $$ #   #   # $$  #",
"###  $$$#   $$  $  #",
"# $  #  #    # $#  #",
"#   $#  #       $  #",
"#  #    #    #  #  #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 66 */
"   ################",
"   #@###.##...##  #",
"  ##$  ..#...#    #",
" ##    ......#  $ #",
"##  $ #.....## # ##",
"#  $$# #####  $ $ #",
"# $# $    ##  $$  #",
"#  #  #    # $  $ #",
"#   $$ ### #$##   #",
"# $#      $ $  $ ##",
"##    #    #    ##",
" ################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 67 */
"####################",
"#@     #   #       #",
"## ### ##  #### # ##",
"#    # #  $$       #",
"#  # # # $ # $ ## ##",
"#     $ #  #$$ #   #",
"#  ###  #      ## ##",
"#..#.# $ #  $ #    #",
"#..#.#  $ # ## $$  #",
"#....##   $$  $  # #",
"#.....##        #  #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 68 */
"###################",
"#  #      #   #   ##",
"# $# $ $ ##...$  $ #",
"#  $  # ##....# $  #",
"# ## $ ##....#   $ #",
"# $    #....## $   #",
"# $##  #...#       #",
"#   $$$##$##  ### ##",
"# # #  #   #  #    #",
"# $ #  $  ##       #",
"#    #    #@       #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 69 */
"####################",
"#  #  # #    #  #  #",
"#   $      $ $     #",
"## #  #$###$##  ## #",
"#   $     $  #  $  #",
"# ###$##$#   # $   #",
"# #   $ $  ###### $#",
"# $  $$ $  #@#.#...#",
"# #     #  # #.#...#",
"# ########## #.....#",
"#            #.....#",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 70 */
"###################",
"#  #     #  ##    ##",
"# $#   $ #     ##  #",
"# $  $  #..#     $ #",
"# $ $  #....#   # ##",
"# $#  #......### $ #",
"#   #  #....#  #$  #",
"# $  ####..#   #   #",
"## $   ## # # $  $##",
" ## $    $#@$ $#   #",
"  ##   #       #   #",
"   #################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 71 */
"#################",
"#      ....#    ####",
"#      ....        #",
"# # ##########     #",
"# #$   #      ###..#",
"#  $   #$$###   #..#",
"# $ ### $   $   #..#",
"# $ #   $ $ #  ##..#",
"#  #  $$ # $ ##   ##",
"#@## $#  $  $     #",
"##       ##   #  ##",
" #################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 72 */
"####################",
"#        #   #@ #  #",
"# $$  #$$# # #  ## #",
"#  # $ $ #$$ #     #",
"## #  #  # # #  #  #",
"#   ##       #     #",
"#   # $ #   #   #  #",
"# $ #$ #   #  $ #..#",
"##$ #  ####    #...#",
"#  $          #....#",
"#   #  #     #.....#",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 73 */
"###########   ######",
"#     #   #  ##    #",
"## $  #   ####  $  #",
"#### $$   #..#  #  #",
"#  $  $  ##..#### ##",
"# $   ###....   $$ #",
"#  #$#   ....# # $ #",
"# #  # $ ..###$#   #",
"# #   $ #..#   ##  #",
"#   $#  ####   # $##",
"# #  #    @#      #",
"###################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 74 */
"####################",
"#   #   #    #   #@#",
"#   $  $     # $ # #",
"##$# $### #    $$# #",
"#  #  #.###  #$ $  #",
"#  #$#....#  # ### #",
"# $  #.....##    # #",
"##$  #.#....#$$ $  #",
"#  ######..## #  # #",
"#  $         $ ### #",
"#   #   #        # #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 75 */
"####################",
"# # # #   #@##   # #",
"#             $    #",
"#  ##$# ##### $ # ##",
"##    ##.....#  #  #",
"##$##$#.....###$#$ #",
"#   # ##.....#  # ##",
"#  $    ##..##  #  #",
"# $ #   $   $  $$$ #",
"## $  $# #  #  $   #",
"#   ##   #  #      #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 76 */
"######  #####",
"#    #  #   #",
"# $  #### $ #",
"# $      $  #",
"#  ###@###$ #",
"########## ###",
"#..   ##     #",
"#..   ##$    #",
"#..   ## $   #",
"#..   ## $   #",
"#..     $ $  #",
"###  #########",
"  ####",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 77 */
"       ###########",
"       #         #",
"       #    $ $  #",
"###### # $ ##### #",
"#    ##### $  ##$#",
"#       $ $      #",
"#          ## ## #",
"#    ##@##### ## #",
"#    ####   # ## ##",
"#....#      # $   #",
"#....#      #     #",
"######      #######",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 78 */
"#############",
"#           #",
"# ### $$    #",
"#   # $  $  #",
"#  $####$######",
"# $ ##        #####",
"#  $$ $        ...#",
"### ## $$#     ...#",
"  # ##   #     ...#",
"  #      #     ...#",
"  ###@#############",
"    ###",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 79 */
"  #################",
"###@##         ...#",
"#    #         ...#",
"# $  #         ...#",
"# $$ #         ...#",
"## $ ###$##########",
" # ###  $ #",
"##   $  $ #",
"#  $ #  $ #",
"# $  #    #",
"#  $ #    #",
"#    #    #",
"###########",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 80 */
"              #####",
"     ##########   #",
"     #        #   #",
"     #  $ $    $$ #",
"     # ##### ## $ #",
"     #$$   #$## $ #",
"     # ### # ##$  #",
"###### ### $ $    #",
"#....        ##   #",
"#....        ######",
"#....        #",
"###########@##",
"          ###",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 81 */
"    ######",
" ####    #",
" #    ## #",
" # $     #",
"### #### ########",
"#  $   $ ##  ...#",
"#   $$ $$    ...#",
"#    $  $##  ...#",
"##@## ## ##  ...#",
" ###  $  ########",
" #   $$  #",
" #    #  #",
" #########",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 82 */
"####### #########",
"#     # #   ##  #",
"# ### # #   $   #",
"# # $ ###   $   #",
"#   $$      ##$ #",
"#    ####   ##  #",
"#@############ ##",
"###..    #####$ #",
"  #..    ####   #",
"  #..       $$  #",
"  #..    #### $ #",
"  #..    #  #   #",
"  ########  #####",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 83 */
"#######",
"#     #########",
"#     #    #  ##",
"# $   #   $ $  #",
"#  $  #  $ ##  #",
"# $$  ##$ $    #",
"## #  ## #######",
"## #  ##    ...#",
"#  #$       ...#",
"#   $$      ...#",
"#     ##@#  ...#",
"################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 84 */
"############",
"#      #   ##",
"# $  $   #  ######",
"####  #####      #",
" #..  #     #### #",
" #.####  ####    #",
" #....    #  $ ####",
" # ...#   # $$$#  ##",
"###.#### ##  $@$   #",
"#     ##### $ #    #",
"# #.# $      $###$ #",
"# #.########  #  $ #",
"# #..        ##  $ #",
"# # ####### $ # #  #",
"#   #     #       ##",
"#####     ##########",
"",
"",
"",
"",
/* ecran no: 85 */
"######",
"#. $.#",
"#$ @ #",
"# $$ #",
"#.  .#",
"######",
"",
"",
"",
"",
"",
"",
"",
"",
"",
"               #####",
"               #.  #",
"               # $ #",
"               #.$@#",
"               #####",
/* ecran no: 86 */
"    ################",
"    #............$ #",
"#################  #",
"#        $   $   $ #",
"#  $   $   $   *...#",
"##$#################",
"#     $   $        #",
"#...*   $   $   $  #",
"#################$##",
"#@ $ $   $   $     #",
"#  $   $   $   *...#",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 87 */
"####################",
"#@$ *  *  *  *  * .#",
"#   *  *  *  *  * *#",
"# $ *  *  *  *  * .#",
"#   *  *  *  *  * *#",
"# $ *  *  *  *  * .#",
"#   *  *  *  *  * *#",
"# $ *  *  *  *  * .#",
"#   *  *  *  *  * *#",
"# $ *  *  *  *  * .#",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 88 */
"  ################",
" ##@  #        # ##",
"##  #  #$ # $# $  ##",
"# #      # #   #   #",
"#  #$# #....    $  #",
"##    # .##.# #  # #",
"#       ....      ##",
"# #$#  #  #  # #   #",
"#     $  #  #   $# #",
"## #$#     $   #  ##",
" ##    #  #  #   ##",
"  ################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 89 */
"############",
"#@$.... ...#",
"#  #  # #  #",
"## $$   #  #",
"#  $  # #$ #",
"# # #$$ #  #",
"#.  $ $$   #",
"#.#   $  #$#",
"#.  #    # #",
"## #####$# #",
"#..       .#",
"############",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 90 */
"",
"",
"",
"",
"       #####",
"       #   #",
"       # # #",
"      ##  $##",
"      #     #",
"######### #########",
"#.@$           $..#",
"######### #########",
"      #. $  #",
"      ##$ $##",
"       # # #",
"       #. .#",
"       ##@##",
"        #$#",
"        #.#",
"        ###",
/* ecran no: 91 */
"###################",
"#.               .#",
"# ### ### ### ### #",
"# # # # # # # # # #",
"# ### ###.### ### #",
"#. $ .$  $   *   *#",
"# ### ### ### ### #",
"# # # # # # # # # #",
"# ### ### ### ### #",
"#. $ $ $ @ $ $ $ .#",
"# ### ### ### ### #",
"# # # # # # # # # #",
"# ### ### ### ### #",
"#*   *   $  $. $ .#",
"# ### ###.### ### #",
"# # # # # # # # # #",
"# ### ### ### ### #",
"#.               .#",
"###################",
"",
/* ecran no: 92 */
"       ######",
"     ##      ##",
"    #  $# $#$  #",
"   # $#      #$ #",
"  # #   .##.   # #",
" # $ . #.##.# . $ #",
" # #  . $..$ .  # #",
"# $  #  #  #  #  $ #",
"# # ..$#  $ #$.. # #",
"# $ ##.  #@$ .##   #",
"#   ##. $@#  .## $ #",
"# # ..$# $  #$.. # #",
"# $  #  #  #  #  $ #",
" # #  . $..$ .  # #",
" # $ . #.##.# . $ #",
"  # #   .##.   # #",
"   # $#      #$ #",
"    #  $#$ #$  #",
"     ##      ##",
"       ######",
/* ecran no: 93 */
"####################",
"#            .     #",
"# #######$$####### #",
"# #      ..      # #",
"# # #####$$##### # #",
"# $.$.   ..   .$.$ #",
"# $.$.   .. $ .$.$ #",
"# # #####$$##### # #",
"# #@     ..      # #",
"# #######$$####### #",
"#@                 #",
"####################",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 94 */
"###################",
"#                 #",
"#                 #",
"#                 #",
"#          # # #  #",
"#   #     #   # $ #",
"#    ##  # $ #    #",
"#   #  # #   ##   #",
"#  #  $ ##  #  #  #",
"# $#$    #@# $  $ #",
"#  $     ##       #",
"#        #        #",
"#        #        #",
"#        #        #",
"#        #        #",
"#  ..    #    ..  #",
"# #..#  ###  #..# #",
"#  ##  #  ##  ##  #",
"#                 #",
"###################",
/* ecran no: 95 */
"#########",
"#    #  ## ####",
"#   $ $  # #  #",
"#  $ ##  # #  ###",
"##$ $    ###    #",
" # #######    # #",
" # #@# $  $##$# #",
" # # #     ## # #",
" # # #   $  $ $ #",
" # # #     $  ####",
" # # # $###   #  #",
" # # #  #     #  #",
" # # #  #        #",
"## # ####  ##    #",
"#         $ #....#",
"#        $$ #....#",
"#    $$###  #....#",
"#   $ $     #....#",
"#      ##   #....#",
"##################",
/* ecran no: 96 */
"###### #####",
"#    ###   #",
"#  $    $$ ##",
"# $ $ #$$  @#",
"#     #    #######",
"#####$######.....#",
"#              ..#",
"#      # ##### ..#",
"#   $$$$.#   # ..#",
"#      #.#   # ..#",
"########.#  $#  ####",
"       #.#   $  $  #",
"       #.# $ #  $  #",
"       #.# $$# $   #",
"       #.#   ## ## #",
"       #.# ####$## #",
"       #.# # $ $   #",
"       #.# #  $ ####",
"       #.#      #",
"       ##########",
/* ecran no: 97 */

"   ################",
"   #    #  #......#",
"#####  $$  #......#",
"#   #   $  #    ..#",
"# # ### ## #    ..#",
"# #    $  $#    ..#",
"# #   $$ $$     ..#",
"# #  $   $ #    ..#",
"# ### #### ########",
"#  # $      $ $  #",
"#  #    ## # $   #",
"## #       # $   #",
" #         #$    #",
" # ####    #     #",
" #    ## ##### ###",
" ####  ###@  #$ #",
"    # $      $  #",
"    # $  #### $ #",
"    #    #  #   #",
"    ######  #####",
/* ecran no: 98 */
"#####          #####",
"## ############## ##",
"#   .$@            #",
"##  ############  ##",
"## ## #    #   ##.##",
" # #  # ## #$#  #$#",
" # # $   $   ## #@#",
" # #  # ####  # # #",
" # # ####  #  # # #",
" # # #   ..#$## # #",
" # # ## #..#  # # #",
" # #  # ####  # # #",
" # #  #       # # #",
" #@# ## ####### # #",
" #$#  ###    #  # #",
"##.##          ## ##",
"##  #####  #####  ##",
"#            @$.   #",
"## ############## ##",
"#####          #####",
/* ecran no: 99 */
"####################",
"# @@@@ #. #@ #@@@@.#",
"# @@@$ #@@#$@#@@@@@#",
"###@@###@@#@@#@@####",
"  #@@# #@@@@@#@@@@ #",
"  #@@# #@@@@@#@@@@@#",
"  #@@# #@@#@@#@@####",
"  #@@# #@$#@@#@@@$ #",
"  #@+# #@@#@+#@@@@@#",
"####################",
"#@@@@@#@@@@@#@@@@@#",
"#@$@$@#@@$@@#@$@$@##",
"#@@####@$#$@#@@#@@@#",
"#@@@.+#@@#+@#++##@ #",
"#@@@.+#@$#@+#++##@ #",
"#@@####@@#+@#@@#@@@#",
"#@$@$@#@$#@+#@$@$@##",
"#@@@@@#@ #+@#@@@@@#",
"###################",
""
};

