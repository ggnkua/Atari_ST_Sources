/* levels.c */
/* niveaux separes en 2 fichiers
   pour eviter que les objets
   ne depassent 32ko (sur MAC) */

char *ecrans[20*50]=
{
/* ecran no: 0 */
"    #####",
"    #   #",
"    #$  #",
"  ###  $##",
"  #  $ $ #",
"### # ## #   ######",
"#   # ## #####  ..#",
"# $  $          ..#",
"##### ### #@##  ..#",
"    #     #########",
"    #######",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 1 */
"############",
"#..  #     ###",
"#..  # $  $  #",
"#..  #$####  #",
"#..    @ ##  #",
"#..  # #  $ ##",
"###### ##$ $ #",
"  # $  $ $ $ #",
"  #    #     #",
"  ############",
"",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 2 */
"        ########",
"        #     @#",
"        # $#$ ##",
"        # $  $#",
"        ##$ $ #",
"######### $ # ###",
"#....  ## $  $  #",
"##...    $  $   #",
"#....  ##########",
"########",
"",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 3 */
"           ########",
"           #  ....#",
"############  ....#",
"#    #  $ $   ....#",
"# $$$#$  $ #  ....#",
"#  $     $ #  ....#",
"# $$ #$ $ $########",
"#  $ #     #",
"## #########",
"#    #    ##",
"#     $   ##",
"#  $$#$$  @#",
"#    #    ##",
"###########",
"",
"",
"",
"",
"",
"",
/* ecran no: 4 */
"        #####",
"        #   #####",
"        # #$##  #",
"        #     $ #",
"######### ###   #",
"#....  ## $  $###",
"#....    $ $$ ##",
"#....  ##$  $ @#",
"#########  $  ##",
"        # $ $  #",
"        ### ## #",
"          #    #",
"          ######",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 5 */
"######  ###",
"#..  # ##@##",
"#..  ###   #",
"#..     $$ #",
"#..  # # $ #",
"#..### # $ #",
"#### $ #$  #",
"   #  $# $ #",
"   # $  $  #",
"   #  ##   #",
"   #########",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 6 */
"       #####",
" #######   ##",
"## # @## $$ #",
"#    $      #",
"#  $  ###   #",
"### #####$###",
"# $  ### ..#",
"# $ $ $ ...#",
"#    ###...#",
"# $$ # #...#",
"#  ### #####",
"####",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 7 */
"  ####",
"  #  ###########",
"  #    $   $ $ #",
"  # $# $ #  $  #",
"  #  $ $  #    #",
"### $# #  #### #",
"#@#$ $ $  ##   #",
"#    $ #$#   # #",
"#   $    $ $ $ #",
"#####  #########",
"  #      #",
"  #      #",
"  #......#",
"  #......#",
"  #......#",
"  ########",
"",
"",
"",
"",
/* ecran no: 8 */
"          #######",
"          #  ...#",
"      #####  ...#",
"      #      . .#",
"      #  ##  ...#",
"      ## ##  ...#",
"     ### ########",
"     # $$$ ##",
" #####  $ $ #####",
"##   #$ $   #   #",
"#@ $  $    $  $ #",
"###### $$ $ #####",
"     #      #",
"     ########",
"",
"",
"",
"",
"",
"",
/* ecran no: 9 */
" ###  #############",
"##@####       #   #",
"# $$   $$  $ $ ...#",
"#  $$$#    $  #...#",
"# $   # $$ $$ #...#",
"###   #  $    #...#",
"#     # $ $ $ #...#",
"#    ###### ###...#",
"## #  #  $ $  #...#",
"#  ## # $$ $ $##..#",
"# ..# #  $      #.#",
"# ..# # $$$ $$$ #.#",
"##### #       # #.#",
"    # ######### #.#",
"    #           #.#",
"    ###############",
"",
"",
"",
"",
/* ecran no: 10 */
"          ####",
"     #### #  #",
"   ### @###$ #",
"  ##      $  #",
" ##  $ $$## ##",
" #  #$##     #",
" # # $ $$ # ###",
" #   $ #  # $ #####",
"####    #  $$ #   #",
"#### ## $         #",
"#.    ###  ########",
"#.. ..# ####",
"#...#.#",
"#.....#",
"#######",
"",
"",
"",
"",
"",
/* ecran no: 11 */
"################",
"#              #",
"# # ######     #",
"# #  $ $ $ $#  #",
"# #   $@$   ## ##",
"# #  $ $ $###...#",
"# #   $ $  ##...#",
"# ###$$$ $ ##...#",
"#     # ## ##...#",
"#####   ## ##...#",
"    #####     ###",
"        #     #",
"        #######",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 12 */
"   #########",
"  ##   ##  #####",
"###     #  #    ###",
"#  $ #$ #  #  ... #",
"# # $#@$## # #.#. #",
"#  # #$  #    . . #",
"# $    $ # # #.#. #",
"#   ##  ##$ $ . . #",
"# $ #   #  #$#.#. #",
"## $  $   $  $... #",
" #$ ######    ##  #",
" #  #    ##########",
" ####",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 13 */
"       #######",
" #######     #",
" #     # $@$ #",
" #$$ #   #########",
" # ###......##   #",
" #   $......## # #",
" # ###......     #",
"##   #### ### #$##",
"#  #$   #  $  # #",
"#  $ $$$  # $## #",
"#   $ $ ###$$ # #",
"#####     $   # #",
"    ### ###   # #",
"      #     #   #",
"      ########  #",
"             ####",
"",
"",
"",
"",
/* ecran no: 14 */
"   ########",
"   #   #  #",
"   #  $   #",
" ### #$   ####",
" #  $  ##$   #",
" #  # @ $ # $#",
" #  #      $ ####",
" ## ####$##     #",
" # $#.....# #   #",
" #  $..**. $# ###",
"##  #.....#   #",
"#   ### #######",
"# $$  #  #",
"#  #     #",
"######   #",
"     #####",
"",
"",
"",
"",
/* ecran no: 15 */
"#####",
"#   ##",
"#    #  ####",
"# $  ####  #",
"#  $$ $   $#",
"###@ #$    ##",
" #  ##  $ $ ##",
" # $  ## ## .#",
" #  #$##$  #.#",
" ###   $..##.#",
"  #    #.*...#",
"  # $$ #.....#",
"  #  #########",
"  #  #",
"  ####",
"",
"",
"",
"",
"",
/* ecran no: 16 */
"   ##########",
"   #..  #   #",
"   #..      #",
"   #..  #  ####",
"  #######  #  ##",
"  #            #",
"  #  #  ##  #  #",
"#### ##  #### ##",
"#  $  ##### #  #",
"# # $  $  # $  #",
"# @$  $   #   ##",
"#### ## #######",
"   #    #",
"   ######",
"",
"",
"",
"",
"",
"",
/* ecran no: 17 */
"     ###########",
"     #  .  #   #",
"     # #.    @ #",
" ##### ##..# ####",
"##  # ..###     ###",
"# $ #...   $ #  $ #",
"#    .. ##  ## ## #",
"####$##$# $ #   # #",
"  ## #    #$ $$ # #",
"  #  $ # #  # $## #",
"  #               #",
"  #  ###########  #",
"  ####         ####",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 18 */
"  ######",
"  #   @####",
"##### $   #",
"#   ##    ####",
"# $ #  ##    #",
"# $ #  ##### #",
"## $  $    # #",
"## $ $ ### # #",
"## #  $  # # #",
"## # #$#   # #",
"## ###   # # ######",
"#  $  #### # #....#",
"#    $    $   ..#.#",
"####$  $# $   ....#",
"#       #  ## ....#",
"###################",
"",
"",
"",
"",
/* ecran no: 19 */
"    ##########",
"#####        ####",
"#     #   $  #@ #",
"# #######$####  ###",
"# #    ## #  #$ ..#",
"# # $     #  #  #.#",
"# # $  #     #$ ..#",
"# #  ### ##     #.#",
"# ###  #  #  #$ ..#",
"# #    #  ####  #.#",
"# #$   $  $  #$ ..#",
"#    $ # $ $ #  #.#",
"#### $###    #$ ..#",
"   #    $$ ###....#",
"   #      ## ######",
"   ########",
"",
"",
"",
"",
/* ecran no: 20 */
"#########",
"#       #",
"#       ####",
"## #### #  #",
"## #@##    #",
"# $$$ $  $$#",
"#  # ## $  #",
"#  # ##  $ ####",
"####  $$$ $#  #",
" #   ##   ....#",
" # #   # #.. .#",
" #   # # ##...#",
" ##### $  #...#",
"     ##   #####",
"      #####",
"",
"",
"",
"",
"",
/* ecran no: 21 */
"######     ####",
"#    #######  #####",
"#   $#  #  $  #   #",
"#  $  $  $ # $ $  #",
"##$ $   # @# $    #",
"#  $ ########### ##",
"# #   #.......# $#",
"# ##  # ......#  #",
"# #   $........$ #",
"# # $ #.... ..#  #",
"#  $ $####$#### $#",
"# $   ### $   $  ##",
"# $     $ $  $    #",
"## ###### $ ##### #",
"#         #       #",
"###################",
"",
"",
"",
"",
/* ecran no: 22 */
"    #######",
"    #  #  ####",
"##### $#$ #  ##",
"#.. #  #  #   #",
"#.. # $#$ #  $####",
"#.  #     #$  #  #",
"#..   $#  # $    #",
"#..@#  #$ #$  #  #",
"#.. # $#     $#  #",
"#.. #  #$$#$  #  ##",
"#.. # $#  #  $#$  #",
"#.. #  #  #   #   #",
"##. ####  #####   #",
" ####  ####   #####",
"",
"",
"",
"",
"",
"",
/* ecran no: 23 */
"###############",
"#..........  .####",
"#..........$$.#  #",
"###########$ #   ##",
"#      $  $     $ #",
"## ####   #  $ #  #",
"#      #   ##  # ##",
"#  $#  # ##  ### ##",
"# $ #$###    ### ##",
"###  $ #  #  ### ##",
"###    $ ## #  # ##",
" # $  #  $  $ $   #",
" #  $  $#$$$  #   #",
" #  #  $      #####",
" # @##  #  #  #",
" ##############",
"",
"",
"",
"",
/* ecran no: 24 */
"####",
"#  ##############",
"#  #   ..#......#",
"#  # # ##### ...#",
"##$#    ........#",
"#   ##$######  ####",
"# $ #     ######@ #",
"##$ # $   ######  #",
"#  $ #$$$##       #",
"#      #    #$#$###",
"# #### #$$$$$    #",
"# #    $     #   #",
"# #   ##        ###",
"# ######$###### $ #",
"#        #    #   #",
"##########    #####",
"",
"",
"",
"",
/* ecran no: 25 */
" #######",
" #  #  #####",
"##  #  #...###",
"#  $#  #...  #",
"# $ #$$ ...  #",
"#  $#  #... .#",
"#   # $########",
"##$       $ $ #",
"##  #  $$ #   #",
" ######  ##$$@#",
"      #      ##",
"      ########",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 26 */
" #################",
" #...   #    #   ##",
"##.....  $## # #$ #",
"#......#  $  #    #",
"#......#  #  # #  #",
"######### $  $ $  #",
"  #     #$##$ ##$##",
" ##   $    # $    #",
" #  ## ### #  ##$ #",
" # $ $$     $  $  #",
" # $    $##$ ######",
" #######  @ ##",
"       ######",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 27 */
"         #####",
"     #####   #",
"    ## $  $  ####",
"##### $  $ $ ##.#",
"#       $$  ##..#",
"#  ###### ###.. #",
"## #  #    #... #",
"# $   #    #... #",
"#@ #$ ## ####...#",
"####  $ $$  ##..#",
"   ##  $ $  $...#",
"    # $$  $ #  .#",
"    #   $ $  ####",
"    ######   #",
"         #####",
"",
"",
"",
"",
"",
/* ecran no: 28 */
"#####",
"#   ##",
"# $  #########",
"## # #       ######",
"## #   $#$#@  #   #",
"#  #      $ #   $ #",
"#  ### ######### ##",
"#  ## ..*..... # ##",
"## ## *.*..*.* # ##",
"# $########## ##$ #",
"#  $   $  $    $  #",
"#  #   #   #   #  #",
"###################",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 29 */
"       ###########",
"       #   #     #",
"#####  #     $ $ #",
"#   ##### $## # ##",
"# $ ##   # ## $  #",
"# $  @$$ # ##$$$ #",
"## ###   # ##    #",
"## #   ### #####$#",
"## #     $  #....#",
"#  ### ## $ #....##",
"# $   $ #   #..$. #",
"#  ## $ #  ##.... #",
"#####   ######...##",
"    #####    #####",
"",
"",
"",
"",
"",
"",
/* ecran no: 30 */
"  ####",
"  #  #########",
" ##  ##  #   #",
" #  $# $@$   ####",
" #$  $  # $ $#  ##",
"##  $## #$ $     #",
"#  #  # #   $$$  #",
"# $    $  $## ####",
"# $ $ #$#  #  #",
"##  ###  ###$ #",
" #  #....     #",
" ####......####",
"   #....####",
"   #...##",
"   #...#",
"   #####",
"",
"",
"",
"",
/* ecran no: 31 */
"      ####",
"  #####  #",
" ##     $#",
"## $  ## ###",
"#@$ $ # $  #",
"#### ##   $#",
" #....#$ $ #",
" #....#   $#",
" #....  $$ ##",
" #... # $   #",
" ######$ $  #",
"      #   ###",
"      #$ ###",
"      #  #",
"      ####",
"",
"",
"",
"",
"",
/* ecran no: 32 */
"############",
"##     ##  #",
"##   $   $ #",
"#### ## $$ #",
"#   $ #    #",
"# $$$ # ####",
"#   # # $ ##",
"#  #  #  $ #",
"# $# $#    #",
"#   ..# ####",
"####.. $ #@#",
"#.....# $# #",
"##....#  $ #",
"###..##    #",
"############",
"",
"",
"",
"",
"",
/* ecran no: 33 */
" #########",
" #....   ##",
" #.#.#  $ ##",
"##....# # @##",
"# ....#  #  ##",
"#     #$ ##$ #",
"## ###  $    #",
" #$  $ $ $#  #",
" # #  $ $ ## #",
" #  ###  ##  #",
" #    ## ## ##",
" #  $ #  $  #",
" ###$ $   ###",
"   #  #####",
"   ####",
"",
"",
"",
"",
"",
/* ecran no: 34 */
"############ ######",
"#   #    # ###....#",
"#   $$#   @  .....#",
"#   # ###   # ....#",
"## ## ###  #  ....#",
" # $ $     # # ####",
" #  $ $##  #      #",
"#### #  #### # ## #",
"#  # #$   ## #    #",
"# $  $  # ## #   ##",
"# # $ $    # #   #",
"#  $ ## ## # #####",
"# $$     $$  #",
"## ## ### $  #",
" #    # #    #",
" ###### ######",
"",
"",
"",
"",
/* ecran no: 35 */
"            #####",
"#####  ######   #",
"#   ####  $ $ $ #",
"# $   ## ## ##  ##",
"#   $ $     $  $ #",
"### $  ## ##     ##",
"  # ##### #####$$ #",
" ##$##### @##     #",
" # $  ###$### $  ##",
" # $  #   ###  ###",
" # $$ $ #   $$ #",
" #     #   ##  #",
" #######.. .###",
"    #.........#",
"    #.........#",
"    ###########",
"",
"",
"",
"",
/* ecran no: 36 */
"###########",
"#......   #########",
"#......   #  ##   #",
"#..### $    $     #",
"#... $ $ #   ##   #",
"#...#$#####    #  #",
"###    #   #$  #$ #",
"  #  $$ $ $  $##  #",
"  #  $   #$#$ ##$ #",
"  ### ## #    ##  #",
"   #  $ $ ## ######",
"   #    $  $  #",
"   ##   # #   #",
"    #####@#####",
"        ###",
"",
"",
"",
"",
"",
/* ecran no: 37 */
"      ####",
"####### @#",
"#     $  #",
"#   $## $#",
"##$#...# #",
" # $...  #",
" # #. .# ##",
" #   # #$ #",
" #$  $    #",
" #  #######",
" ####",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 38 */
"             ######",
" #############....#",
"##   ##     ##....#",
"#  $$##  $ @##....#",
"#      $$ $#  ....#",
"#  $ ## $$ # # ...#",
"#  $ ## $  #  ....#",
"## ##### ### ##.###",
"##   $  $ ##   .  #",
"# $###  # ##### ###",
"#   $   #       #",
"#  $ #$ $ $###  #",
"# $$$# $   # ####",
"#    #  $$ #",
"######   ###",
"     #####",
"",
"",
"",
"",
/* ecran no: 39 */
"    ############",
"    #          ##",
"    #  # #$$ $  #",
"    #$ #$#  ## @#",
"   ## ## # $ # ##",
"   #   $ #$  # #",
"   #   # $   # #",
"   ## $ $   ## #",
"   #  #  ##  $ #",
"   #    ## $$# #",
"######$$   #   #",
"#....#  ########",
"#.#... ##",
"#....   #",
"#....   #",
"#########",
"",
"",
"",
"",
/* ecran no: 40 */
"           #####",
"          ##   ##",
"         ##     #",
"        ##  $$  #",
"       ## $$  $ #",
"       # $    $ #",
"####   #   $$ #####",
"#  ######## ##    #",
"#.            $$$@#",
"#.# ####### ##   ##",
"#.# #######. #$ $##",
"#........... #    #",
"##############  $ #",
"             ##  ##",
"              ####",
"",
"",
"",
"",
"",
/* ecran no: 41 */
"     ########",
"  ####      ######",
"  #    ## $ $   @#",
"  # ## ##$#$ $ $##",
"### ......#  $$ ##",
"#   ......#  #   #",
"# # ......#$  $  #",
"# #$...... $$# $ #",
"#   ### ###$  $ ##",
"###  $  $  $  $ #",
"  #  $  $  $  $ #",
"  ######   ######",
"       #####",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 42 */
"        #######",
"    #####  #  ####",
"    #   #   $    #",
" #### #$$ ## ##  #",
"##      # #  ## ###",
"#  ### $#$  $  $  #",
"#...    # ##  #   #",
"#...#    @ # ### ##",
"#...#  ###  $  $  #",
"######## ##   #   #",
"          #########",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 43 */
" #####",
" #   #",
" # # #######",
" #      $@######",
" # $ ##$ ###   #",
" # #### $    $ #",
" # ##### #  #$ ####",
"##  #### ##$      #",
"#  $#  $  # ## ## #",
"#         # #...# #",
"######  ###  ...  #",
"     #### # #...# #",
"          # ### # #",
"          #       #",
"          #########",
"",
"",
"",
"",
"",
/* ecran no: 44 */
"##### ####",
"#...# #  ####",
"#...###  $  #",
"#....## $  $###",
"##....##   $  #",
"###... ## $ $ #",
"# ##    #  $  #",
"#  ## # ### ####",
"# $ # #$  $    #",
"#  $ @ $    $  #",
"#   # $ $$ $ ###",
"#  ######  ###",
"# ##    ####",
"###",
"",
"",
"",
"",
"",
"",
/* ecran no: 45 */
"##########",
"#        ####",
"# ###### #  ##",
"# # $ $ $  $ #",
"#       #$   #",
"###$  $$#  ###",
"  #  ## # $##",
"  ##$#   $ @#",
"   #  $ $ ###",
"   # #   $  #",
"   # ##   # #",
"  ##  ##### #",
"  #         #",
"  #.......###",
"  #.......#",
"  #########",
"",
"",
"",
"",
/* ecran no: 46 */
"         ####",
" #########  ##",
"##  $      $ #####",
"#   ## ##   ##...#",
"# #$$ $ $$#$##...#",
"# #   @   #   ...#",
"#  $# ###$$   ...#",
"# $  $$  $ ##....#",
"###$       #######",
"  #  #######",
"  ####",
"",
"",
"",
"",
"",
"",
"",
"",
"",
/* ecran no: 47 */
"  #########  ",
"  #*.*#*.*#  ",
"  #.*.*.*.#  ",
"  #*.*.*.*#  ",
"  #.*.*.*.#  ",
"  #*.*.*.*#  ",
"  ###   ###  ",
"    #   #    ",
"###### ######",
"#           #",
"# $ $ $ $ $ #",
"## $ $ $ $ ##",
" #$ $ $ $ $# ",
" #   $@$   # ",
" #  #####  # ",
" ####   ####",
"",
"",
"",
"",
/* ecran no: 48 */
"       ####",
"       #  ##",
"       #   ##",
"       # $$ ##",
"     ###$  $ ##",
"  ####    $   #",
"###  # #####  #",
"#    # #....$ #",
"# #   $ ....# #",
"#  $ # #.*..# #",
"###  #### ### #",
"  #### @$  ##$##",
"     ### $     #",
"       #  ##   #",
"       ######### ",
"",
"",
"",
"",
"",
/* ecran no: 49 */
"      ############",
"     ##..    #   #",
"    ##..* $    $ #",
"   ##..*.# # # $##",
"   #..*.# # # $  #",
"####...#  #    # #",
"#  ## #          #",
"# @$ $ ###  #   ##",
"# $   $   # #   #",
"###$$   # # # # #",
"  #   $   # # #####",
"  # $# #####      #",
"  #$   #   #    # #",
"  #  ###   ##     #",
"  #  #      #    ##",
"  ####      ######",
"",
"",
"",
""
};
