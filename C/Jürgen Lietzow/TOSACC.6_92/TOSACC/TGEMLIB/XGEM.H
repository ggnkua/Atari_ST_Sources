/* Resource Datei Indizes f�r XGEM */

#define BUTIMG   0   /* Formular/Dialog */
#define RBUT     1   /* IMAGE in Baum BUTIMG */
#define RSBUT    2   /* IMAGE in Baum BUTIMG */
#define NBUT     3   /* IMAGE in Baum BUTIMG */
#define NSBUT    4   /* IMAGE in Baum BUTIMG */

#define FONTCHAR 1   /* Formular/Dialog */
#define XCHARS   2   /* IBOX in Baum FONTCHAR */

#define ALERT    2   /* Formular/Dialog */
#define ICSTOP   2   /* IMAGE in Baum ALERT */
#define ICEXCLAM 3   /* IMAGE in Baum ALERT */
#define ICQUEST  4   /* IMAGE in Baum ALERT */
#define STRING1  5   /* STRING in Baum ALERT */
#define STRING2  6   /* STRING in Baum ALERT */
#define STRING3  7   /* STRING in Baum ALERT */
#define NXTDFLT  8   /* BOXTEXT in Baum ALERT */
#define STRING4  9   /* STRING in Baum ALERT */
#define NXTAUTO  10  /* BOXTEXT in Baum ALERT */
#define STRING5  11  /* STRING in Baum ALERT */
#define BUTTON1  12  /* BUTTON in Baum ALERT */
#define BUTTON2  13  /* BUTTON in Baum ALERT */
#define BUTTON3  14  /* BUTTON in Baum ALERT */
