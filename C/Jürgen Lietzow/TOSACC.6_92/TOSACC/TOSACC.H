/* Resource Datei Indizes f�r TOSACC */

#define TOSACC   0   /* Formular/Dialog */
#define TOOLS    1   /* IBOX in Baum TOSACC */
#define SAVE     2   /* BUTTON in Baum TOSACC */
#define ICTOS    3   /* IMAGE in Baum TOSACC */
#define ICACC    4   /* IMAGE in Baum TOSACC */

#define XDIAL    1   /* Formular/Dialog */
#define XDON     2   /* BUTTON in Baum XDIAL */
#define XEDON    3   /* BUTTON in Baum XDIAL */
#define XDRAWON  4   /* BUTTON in Baum XDIAL */
#define XSHGRON  5   /* BUTTON in Baum XDIAL */
#define ALDEFPOS 7   /* BUTTON in Baum XDIAL */
#define ALERTDEL 8   /* BUTTON in Baum XDIAL */
#define ALON     9   /* BUTTON in Baum XDIAL */

#define KEYBOARD 2   /* Formular/Dialog */
#define RPSLIDER 2   /* IBOX in Baum KEYBOARD */
#define KBSLIDER 7   /* IBOX in Baum KEYBOARD */
#define DKSLIDER 15  /* IBOX in Baum KEYBOARD */
#define DKTEST   20  /* BUTTON in Baum KEYBOARD */

#define SETMOUSE 3   /* Formular/Dialog */
#define SMON     2   /* BUTTON in Baum SETMOUSE */
#define SMDIREC  3   /* BUTTON in Baum SETMOUSE */
#define SMOFF    5   /* BUTTON in Baum SETMOUSE */
#define SMSLIDER 8   /* IBOX in Baum SETMOUSE */

#define MESSAGE  4   /* Formular/Dialog */

#define SETTIME  5   /* Formular/Dialog */
#define CDATE    2   /* FTEXT in Baum SETTIME */
#define CTIME    3   /* FTEXT in Baum SETTIME */
#define TIMEON   7   /* BUTTON in Baum SETTIME */
#define TDATE    8   /* FTEXT in Baum SETTIME */
#define TTIME    9   /* FTEXT in Baum SETTIME */

#define RS232    6   /* Formular/Dialog */
#define SLBAUD   2   /* IBOX in Baum RS232 */
#define SHAKEXON 8   /* BUTTON in Baum RS232 */
#define SHAKERTS 9   /* BUTTON in Baum RS232 */
#define PARINO   11  /* BUTTON in Baum RS232 */
#define PARIODD  12  /* BUTTON in Baum RS232 */
#define PARIEVEN 13  /* BUTTON in Baum RS232 */
#define SGN8     15  /* BUTTON in Baum RS232 */
#define SGN6     16  /* BUTTON in Baum RS232 */
#define SGN7     17  /* BUTTON in Baum RS232 */
#define SGN5     18  /* BUTTON in Baum RS232 */
#define STOP00   20  /* BUTTON in Baum RS232 */
#define STOP15   21  /* BUTTON in Baum RS232 */
#define STOP10   22  /* BUTTON in Baum RS232 */
#define STOP20   23  /* BUTTON in Baum RS232 */

#define CETRONIC 7   /* Formular/Dialog */
#define PRUNLIM  3   /* BUTTON in Baum CETRONIC */
#define PRSINGL  4   /* BUTTON in Baum CETRONIC */
#define PRATARI  6   /* BUTTON in Baum CETRONIC */
#define PREPSON  7   /* BUTTON in Baum CETRONIC */
#define PRSER    9   /* BUTTON in Baum CETRONIC */
#define PRCETRON 10  /* BUTTON in Baum CETRONIC */
#define PRMONO   12  /* BUTTON in Baum CETRONIC */
#define PRCOLOR  13  /* BUTTON in Baum CETRONIC */
#define PRMATRI  15  /* BUTTON in Baum CETRONIC */
#define PRTYP    16  /* BUTTON in Baum CETRONIC */
#define PRNLQ    18  /* BUTTON in Baum CETRONIC */
#define PRDRAFT  19  /* BUTTON in Baum CETRONIC */

#define RAMDISK  8   /* Formular/Dialog */
#define RDPARAM  3   /* FTEXT in Baum RAMDISK */
#define RDPRG    4   /* STRING in Baum RAMDISK */
#define RDONLY   6   /* BUTTON in Baum RAMDISK */
#define RDRESET  7   /* BUTTON in Baum RAMDISK */
#define RDDRIVE  8   /* IBOX in Baum RAMDISK */
#define RDON     14  /* BUTTON in Baum RAMDISK */
#define RDOFF    15  /* BUTTON in Baum RAMDISK */

#define SPOOLER  9   /* Formular/Dialog */
#define SPON     2   /* BUTTON in Baum SPOOLER */
#define SPOFF    3   /* BUTTON in Baum SPOOLER */
#define SPRESET  4   /* BUTTON in Baum SPOOLER */
#define SPCHARS  5   /* FTEXT in Baum SPOOLER */
#define SPQUICK  6   /* BUTTON in Baum SPOOLER */
#define SPRATE   7   /* IBOX in Baum SPOOLER */

#define SCSAVER  10  /* Formular/Dialog */
#define SCON     2   /* BUTTON in Baum SCSAVER */
#define SCOFF    3   /* BUTTON in Baum SCSAVER */
#define SCSLIDER 5   /* IBOX in Baum SCSAVER */
#define SCINVERT 10  /* BUTTON in Baum SCSAVER */

#define CACHE    11  /* Formular/Dialog */
#define DCON     2   /* BUTTON in Baum CACHE */
#define DCOFF    3   /* BUTTON in Baum CACHE */
#define DCDRIVE  5   /* IBOX in Baum CACHE */
#define DCDREAD  10  /* BUTTON in Baum CACHE */
#define DCDWRITE 11  /* BUTTON in Baum CACHE */
#define DCDLOCK  12  /* BUTTON in Baum CACHE */
#define DCDOFF   13  /* BUTTON in Baum CACHE */
#define DCRESET  15  /* BUTTON in Baum CACHE */
#define DCDELAY  16  /* IBOX in Baum CACHE */

#define STATIST  12  /* Formular/Dialog */
#define CIPHRD   6   /* TEXT in Baum STATIST */
#define CILOGRD  7   /* TEXT in Baum STATIST */
#define CILOGWRT 8   /* TEXT in Baum STATIST */
#define CIPHWRT  9   /* TEXT in Baum STATIST */
#define CIRATRD  10  /* FTEXT in Baum STATIST */
#define CIRATWRT 11  /* FTEXT in Baum STATIST */
#define CICHKERR 14  /* TEXT in Baum STATIST */
#define CIFATERR 15  /* TEXT in Baum STATIST */
#define SPBLK    21  /* TEXT in Baum STATIST */
#define RDBLK    22  /* TEXT in Baum STATIST */
#define CIBLK    23  /* TEXT in Baum STATIST */
#define FREEBLK  24  /* TEXT in Baum STATIST */
#define SENDCHAR 26  /* TEXT in Baum STATIST */

#define MEMORY   13  /* Formular/Dialog */
#define MEMINST  2   /* BUTTON in Baum MEMORY */
#define NXTMEM   3   /* IBOX in Baum MEMORY */
#define CURMEM   13  /* STRING in Baum MEMORY */
#define CURBLK   14  /* STRING in Baum MEMORY */
#define AHDIFLAG 15  /* STRING in Baum MEMORY */
#define NXTBLK   18  /* IBOX in Baum MEMORY */
