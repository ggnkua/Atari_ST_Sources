/* Resource Datei Indizes f�r TOSACC */

#define ALERT    0   /* Formular/Dialog */
#define ICSTOP   2   /* IMAGE in Baum ALERT */
#define ICEXCLAM 3   /* IMAGE in Baum ALERT */
#define ICQUEST  4   /* IMAGE in Baum ALERT */
#define STRING1  5   /* STRING in Baum ALERT */
#define STRING2  6   /* STRING in Baum ALERT */
#define STRING3  7   /* STRING in Baum ALERT */
#define NXTDFLT  8   /* BOXTEXT in Baum ALERT */
#define STRING4  9   /* STRING in Baum ALERT */
#define NXTAUTO  10  /* BOXTEXT in Baum ALERT */
#define STRING5  11  /* STRING in Baum ALERT */
#define BUTTON1  12  /* BUTTON in Baum ALERT */
#define BUTTON2  13  /* BUTTON in Baum ALERT */
#define BUTTON3  14  /* BUTTON in Baum ALERT */

#define TOSACC   1   /* Formular/Dialog */
#define ICTOS    2   /* IMAGE in Baum TOSACC */
#define ICACC    3   /* IMAGE in Baum TOSACC */
#define TOOLS    5   /* IBOX in Baum TOSACC */
#define SAVE     6   /* BUTTON in Baum TOSACC */

#define XDIAL    2   /* Formular/Dialog */
#define ALON     2   /* BOXCHAR in Baum XDIAL */
#define ALOFF    4   /* BOXCHAR in Baum XDIAL */
#define ALERTDEL 6   /* BUTTON in Baum XDIAL */
#define XDON     9   /* BOXCHAR in Baum XDIAL */
#define XDOFF    11  /* BOXCHAR in Baum XDIAL */

#define SCSAVER  3   /* Formular/Dialog */
#define SCTIME   2   /* FTEXT in Baum SCSAVER */
#define SCOFF    3   /* BOXCHAR in Baum SCSAVER */
#define SCON     4   /* BOXCHAR in Baum SCSAVER */
#define SCSLIDER 7   /* IBOX in Baum SCSAVER */
#define SCINVERT 12  /* BOXCHAR in Baum SCSAVER */

#define KEYBOARD 4   /* Formular/Dialog */
#define RPTIME   2   /* FTEXT in Baum KEYBOARD */
#define RPSLIDER 3   /* IBOX in Baum KEYBOARD */
#define KBTIME   10  /* FTEXT in Baum KEYBOARD */
#define KBSLIDER 11  /* IBOX in Baum KEYBOARD */

#define SETMOUSE 5   /* Formular/Dialog */
#define SMON     2   /* BOXCHAR in Baum SETMOUSE */
#define SMOFF    3   /* BOXCHAR in Baum SETMOUSE */
#define SMFIELD  6   /* IBOX in Baum SETMOUSE */
#define SMDIREC  19  /* BOXCHAR in Baum SETMOUSE */
#define SMSLIDER 21  /* IBOX in Baum SETMOUSE */

#define MESSAGE  6   /* Formular/Dialog */

#define SETTIME  7   /* Formular/Dialog */
#define CDATE    2   /* FTEXT in Baum SETTIME */
#define CTIME    3   /* FTEXT in Baum SETTIME */
#define TIMEON   8   /* BUTTON in Baum SETTIME */
#define TDATE    9   /* FTEXT in Baum SETTIME */
#define TTIME    10  /* FTEXT in Baum SETTIME */
