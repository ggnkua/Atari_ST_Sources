/* Resource Datei Indizes f�r TOSACC */

#define TOSACC   0   /* Formular/Dialog */
#define TOOLS    1   /* IBOX in Baum TOSACC */
#define SAVE     2   /* BUTTON in Baum TOSACC */
#define ICTOS    3   /* IMAGE in Baum TOSACC */
#define ICACC    4   /* IMAGE in Baum TOSACC */

#define XDIAL    1   /* Formular/Dialog */
#define XDON     2   /* BUTTON in Baum XDIAL */
#define XEDON    3   /* BUTTON in Baum XDIAL */
#define XDRAWON  4   /* BUTTON in Baum XDIAL */
#define XSHGRON  5   /* BUTTON in Baum XDIAL */
#define MAPPLE   7   /* BUTTON in Baum XDIAL */
#define MATARI   8   /* BUTTON in Baum XDIAL */
#define MWINDOWS 9   /* BUTTON in Baum XDIAL */
#define ALDEFPOS 11  /* BUTTON in Baum XDIAL */
#define ALERTDEL 12  /* BUTTON in Baum XDIAL */
#define ALON     13  /* BUTTON in Baum XDIAL */

#define SCSAVER  2   /* Formular/Dialog */
#define SCON     2   /* BUTTON in Baum SCSAVER */
#define SCOFF    3   /* BUTTON in Baum SCSAVER */
#define SCSLIDER 5   /* IBOX in Baum SCSAVER */
#define SCINVERT 10  /* BUTTON in Baum SCSAVER */

#define KEYBOARD 3   /* Formular/Dialog */
#define RPSLIDER 2   /* IBOX in Baum KEYBOARD */
#define KBSLIDER 7   /* IBOX in Baum KEYBOARD */
#define DKSLIDER 15  /* IBOX in Baum KEYBOARD */
#define DKTEST   20  /* BUTTON in Baum KEYBOARD */

#define SETMOUSE 4   /* Formular/Dialog */
#define SMON     2   /* BUTTON in Baum SETMOUSE */
#define SMDIREC  3   /* BUTTON in Baum SETMOUSE */
#define SMOFF    5   /* BUTTON in Baum SETMOUSE */
#define SMSLIDER 8   /* IBOX in Baum SETMOUSE */

#define MESSAGE  5   /* Formular/Dialog */

#define SETTIME  6   /* Formular/Dialog */
#define CDATE    2   /* FTEXT in Baum SETTIME */
#define CTIME    3   /* FTEXT in Baum SETTIME */
#define TIMEON   7   /* BUTTON in Baum SETTIME */
#define TDATE    8   /* FTEXT in Baum SETTIME */
#define TTIME    9   /* FTEXT in Baum SETTIME */

#define RS232    7   /* Formular/Dialog */
#define SLBAUD   2   /* IBOX in Baum RS232 */
#define SHAKEXON 8   /* BUTTON in Baum RS232 */
#define SHAKERTS 9   /* BUTTON in Baum RS232 */
#define PARINO   11  /* BUTTON in Baum RS232 */
#define PARIODD  12  /* BUTTON in Baum RS232 */
#define PARIEVEN 13  /* BUTTON in Baum RS232 */
#define SGN8     15  /* BUTTON in Baum RS232 */
#define SGN6     16  /* BUTTON in Baum RS232 */
#define SGN7     17  /* BUTTON in Baum RS232 */
#define SGN5     18  /* BUTTON in Baum RS232 */
#define STOP00   20  /* BUTTON in Baum RS232 */
#define STOP15   21  /* BUTTON in Baum RS232 */
#define STOP10   22  /* BUTTON in Baum RS232 */
#define STOP20   23  /* BUTTON in Baum RS232 */

#define CETRONIC 8   /* Formular/Dialog */
#define PRUNLIM  3   /* BUTTON in Baum CETRONIC */
#define PRSINGL  4   /* BUTTON in Baum CETRONIC */
#define PRATARI  6   /* BUTTON in Baum CETRONIC */
#define PREPSON  7   /* BUTTON in Baum CETRONIC */
#define PRSER    9   /* BUTTON in Baum CETRONIC */
#define PRCETRON 10  /* BUTTON in Baum CETRONIC */
#define PRMONO   12  /* BUTTON in Baum CETRONIC */
#define PRCOLOR  13  /* BUTTON in Baum CETRONIC */
#define PRMATRI  15  /* BUTTON in Baum CETRONIC */
#define PRTYP    16  /* BUTTON in Baum CETRONIC */
#define PRNLQ    18  /* BUTTON in Baum CETRONIC */
#define PRDRAFT  19  /* BUTTON in Baum CETRONIC */

#define RAMDISK  9   /* Formular/Dialog */
#define RDON     2   /* BUTTON in Baum RAMDISK */
#define RDOFF    3   /* BUTTON in Baum RAMDISK */
#define RDINSTAL 4   /* BUTTON in Baum RAMDISK */
#define RDPARAM  6   /* FTEXT in Baum RAMDISK */
#define RDPRG    7   /* STRING in Baum RAMDISK */
#define RDONLY   9   /* BUTTON in Baum RAMDISK */
#define RDRESET  10  /* BUTTON in Baum RAMDISK */
#define RDDRIVE  11  /* IBOX in Baum RAMDISK */
#define RDSIZE   16  /* IBOX in Baum RAMDISK */
