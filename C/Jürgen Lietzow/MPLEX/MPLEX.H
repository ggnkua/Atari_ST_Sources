/* Resource Datei Indizes f�r CODEC */

#define DIALOG   0   /* Formular/Dialog */
#define OK       4   /* BUTTON in Baum DIALOG */
#define CANCEL   5   /* BUTTON in Baum DIALOG */
#define IN_L     9   /* TEXT in Baum DIALOG */
#define IN_R     10  /* TEXT in Baum DIALOG */
#define IL_P     11  /* BOXCHAR in Baum DIALOG */
#define IR_M     12  /* BOXCHAR in Baum DIALOG */
#define IL_M     13  /* BOXCHAR in Baum DIALOG */
#define IR_P     14  /* BOXCHAR in Baum DIALOG */
#define OUT_L    20  /* TEXT in Baum DIALOG */
#define OUT_R    21  /* TEXT in Baum DIALOG */
#define OL_P     22  /* BOXCHAR in Baum DIALOG */
#define OR_M     23  /* BOXCHAR in Baum DIALOG */
#define OL_M     24  /* BOXCHAR in Baum DIALOG */
#define OR_P     25  /* BOXCHAR in Baum DIALOG */
#define PATH     39  /* IBOX in Baum DIALOG */
#define OUT_ADC  60  /* BUTTON in Baum DIALOG */
#define OUT_CODEC 61  /* BUTTON in Baum DIALOG */
#define FREQ     64  /* TEXT in Baum DIALOG */
#define FREQ_P   65  /* BOXCHAR in Baum DIALOG */
#define FREQ_M   66  /* BOXCHAR in Baum DIALOG */
#define FORMAT   68  /* TEXT in Baum DIALOG */
#define FMT_P    69  /* BOXCHAR in Baum DIALOG */
#define FMT_M    70  /* BOXCHAR in Baum DIALOG */
#define CHIP     72  /* BUTTON in Baum DIALOG */
#define MICRO    73  /* BUTTON in Baum DIALOG */
#define SHAKE_ON 76  /* BUTTON in Baum DIALOG */
