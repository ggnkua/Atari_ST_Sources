#define ALERT 0  	/* TREE */
#define TOSACC 1  	/* TREE */
#define XDIAL 2  	/* TREE */
#define SCSAVER 3  	/* TREE */
#define KEYBOARD 4  	/* TREE */
#define SETMOUSE 5  	/* TREE */
#define MESSAGE 6  	/* TREE */
#define STRING1 1  	/* OBJECT in TREE #0 */
#define STRING2 2  	/* OBJECT in TREE #0 */
#define STRING3 3  	/* OBJECT in TREE #0 */
#define BUTTON1 4  	/* OBJECT in TREE #0 */
#define BUTTON2 5  	/* OBJECT in TREE #0 */
#define BUTTON3 6  	/* OBJECT in TREE #0 */
#define STRING4 7  	/* OBJECT in TREE #0 */
#define STRING5 8  	/* OBJECT in TREE #0 */
#define ICQUEST 9  	/* OBJECT in TREE #0 */
#define ICSTOP 10  	/* OBJECT in TREE #0 */
#define ICEXCLAM 11  	/* OBJECT in TREE #0 */
#define ICTOS 2  	/* OBJECT in TREE #1 */
#define ICACC 3  	/* OBJECT in TREE #1 */
#define TOOLS 5  	/* OBJECT in TREE #1 */
#define SAVE 6  	/* OBJECT in TREE #1 */
#define ALON 2  	/* OBJECT in TREE #2 */
#define ALOFF 4  	/* OBJECT in TREE #2 */
#define XDON 8  	/* OBJECT in TREE #2 */
#define XDOFF 10  	/* OBJECT in TREE #2 */
#define SCTIME 2  	/* OBJECT in TREE #3 */
#define SCOFF 3  	/* OBJECT in TREE #3 */
#define SCBLACK 4  	/* OBJECT in TREE #3 */
#define SCSLIDER 7  	/* OBJECT in TREE #3 */
#define SCINVERT 12  	/* OBJECT in TREE #3 */
#define RPTIME 2  	/* OBJECT in TREE #4 */
#define RPSLIDER 3  	/* OBJECT in TREE #4 */
#define KBTIME 10  	/* OBJECT in TREE #4 */
#define KBSLIDER 11  	/* OBJECT in TREE #4 */
#define SMON 2  	/* OBJECT in TREE #5 */
#define SMOFF 3  	/* OBJECT in TREE #5 */
#define SMFIELD 6  	/* OBJECT in TREE #5 */
#define SMDIREC 19  	/* OBJECT in TREE #5 */
#define SMSLIDER 21  	/* OBJECT in TREE #5 */
