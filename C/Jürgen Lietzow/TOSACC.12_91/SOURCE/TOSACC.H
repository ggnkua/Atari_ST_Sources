/* Resource Datei Indizes f�r TOSACC */

#define ALERT    0   /* Formular/Dialog */
#define ICSTOP   2   /* IMAGE in Baum ALERT */
#define ICEXCLAM 3   /* IMAGE in Baum ALERT */
#define ICQUEST  4   /* IMAGE in Baum ALERT */
#define STRING1  5   /* STRING in Baum ALERT */
#define STRING2  6   /* STRING in Baum ALERT */
#define STRING3  7   /* STRING in Baum ALERT */
#define NXTDFLT  8   /* BOXTEXT in Baum ALERT */
#define STRING4  9   /* STRING in Baum ALERT */
#define NXTAUTO  10  /* BOXTEXT in Baum ALERT */
#define STRING5  11  /* STRING in Baum ALERT */
#define BUTTON1  12  /* BUTTON in Baum ALERT */
#define BUTTON2  13  /* BUTTON in Baum ALERT */
#define BUTTON3  14  /* BUTTON in Baum ALERT */

#define TOSACC   1   /* Formular/Dialog */
#define ICTOS    2   /* IMAGE in Baum TOSACC */
#define ICACC    3   /* IMAGE in Baum TOSACC */
#define TOOLS    5   /* IBOX in Baum TOSACC */
#define SAVE     6   /* BUTTON in Baum TOSACC */

#define XDIAL    2   /* Formular/Dialog */
#define ALON     2   /* BOXCHAR in Baum XDIAL */
#define ALOFF    4   /* BOXCHAR in Baum XDIAL */
#define ALERTDEL 6   /* BUTTON in Baum XDIAL */
#define ALDEFPOS 8   /* BOXCHAR in Baum XDIAL */
#define XEDOFF   14  /* BOXCHAR in Baum XDIAL */
#define XEDON    16  /* BOXCHAR in Baum XDIAL */
#define XDON     21  /* BOXCHAR in Baum XDIAL */
#define XDOFF    22  /* BOXCHAR in Baum XDIAL */

#define SCSAVER  3   /* Formular/Dialog */
#define SCSLIDER 3   /* IBOX in Baum SCSAVER */
#define SCON     9   /* BOXCHAR in Baum SCSAVER */
#define SCINVERT 11  /* BOXCHAR in Baum SCSAVER */
#define SCOFF    13  /* BOXCHAR in Baum SCSAVER */

#define KEYBOARD 4   /* Formular/Dialog */
#define RPSLIDER 2   /* IBOX in Baum KEYBOARD */
#define KBSLIDER 7   /* IBOX in Baum KEYBOARD */
#define DKSLIDER 16  /* IBOX in Baum KEYBOARD */
#define DKTEST   21  /* BUTTON in Baum KEYBOARD */

#define SETMOUSE 5   /* Formular/Dialog */
#define SMSLIDER 2   /* IBOX in Baum SETMOUSE */
#define SMDIREC  63  /* BOXCHAR in Baum SETMOUSE */
#define SMOFF    65  /* BOXCHAR in Baum SETMOUSE */
#define SMON     67  /* BOXCHAR in Baum SETMOUSE */

#define MESSAGE  6   /* Formular/Dialog */

#define SETTIME  7   /* Formular/Dialog */
#define CDATE    2   /* FTEXT in Baum SETTIME */
#define CTIME    3   /* FTEXT in Baum SETTIME */
#define TIMEON   8   /* BUTTON in Baum SETTIME */
#define TDATE    9   /* FTEXT in Baum SETTIME */
#define TTIME    10  /* FTEXT in Baum SETTIME */

#define RS232    8   /* Formular/Dialog */
#define PARINO   7   /* BUTTON in Baum RS232 */
#define PARIODD  8   /* BUTTON in Baum RS232 */
#define PARIEVEN 9   /* BUTTON in Baum RS232 */
#define SGN8     11  /* BUTTON in Baum RS232 */
#define SGN7     12  /* BUTTON in Baum RS232 */
#define SGN6     13  /* BUTTON in Baum RS232 */
#define SGN5     14  /* BUTTON in Baum RS232 */
#define STOP10   16  /* BUTTON in Baum RS232 */
#define STOP15   17  /* BUTTON in Baum RS232 */
#define STOP20   18  /* BUTTON in Baum RS232 */
#define STOP00   19  /* BUTTON in Baum RS232 */
#define SHAKEOFF 21  /* BUTTON in Baum RS232 */
#define SHAKEXON 22  /* BUTTON in Baum RS232 */
#define SHAKERTS 23  /* BUTTON in Baum RS232 */
#define SLBAUD   24  /* IBOX in Baum RS232 */

#define CETRONIC 9   /* Formular/Dialog */
#define PRMATRI  5   /* BUTTON in Baum CETRONIC */
#define PRTYP    6   /* BUTTON in Baum CETRONIC */
#define PRUNLIM  8   /* BUTTON in Baum CETRONIC */
#define PRSINGL  9   /* BUTTON in Baum CETRONIC */
#define PRCETRON 13  /* BUTTON in Baum CETRONIC */
#define PRSER    14  /* BUTTON in Baum CETRONIC */
#define PRATARI  16  /* BUTTON in Baum CETRONIC */
#define PREPSON  17  /* BUTTON in Baum CETRONIC */
#define PRNLQ    21  /* BUTTON in Baum CETRONIC */
#define PRDRAFT  22  /* BUTTON in Baum CETRONIC */
#define PRMONO   24  /* BUTTON in Baum CETRONIC */
#define PRCOLOR  25  /* BUTTON in Baum CETRONIC */
