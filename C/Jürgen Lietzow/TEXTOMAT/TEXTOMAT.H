/* Resource Datei Indizes f�r TEXTOMAT */

#define TMAT     0   /* Formular/Dialog */
#define QUIT     1   /* BUTTON in Baum TMAT */
#define SAVEWRD  2   /* BUTTON in Baum TMAT */
#define LOADTXT  3   /* BUTTON in Baum TMAT */
#define SWORD    4   /* FTEXT in Baum TMAT */
#define SEARCH   5   /* BUTTON in Baum TMAT */
#define WORDLIST 8   /* IBOX in Baum TMAT */
#define WORDUP   14  /* BOXCHAR in Baum TMAT */
#define WORDDOWN 15  /* BOXCHAR in Baum TMAT */
#define DELETE   22  /* BUTTON in Baum TMAT */
#define NUMWORD  23  /* BOXTEXT in Baum TMAT */

#define BUSY     1   /* Formular/Dialog */
