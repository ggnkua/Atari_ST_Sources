#define DIALOG2 1
#define STRING 2
#define DIALOG1 0
#define NAME 1
#define OK 2
