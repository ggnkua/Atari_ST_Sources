
#define	TOOLFORM	    0

#define TLPLAY	    1
#define TLGOTO	    3
#define TLDELETE	    4
#define TLCLEAR	    5
#define TLADD	    6
#define TLCUT	    8
#define TLPASTE	    9
#define TLSET	   10
#define TLLINE	   11
#define TLCLINE	   12
#define TLBOX	   13
#define TLFBOX	   14
#define TLDRAW	   15
#define TLLOAD	   16
#define TLSAVE	   17
#define TLNEW	   18
#define TLQUIT	   19
#define TLFILL	   20
#define TLCIRCLE	   21
#define TLOVAL	   22
#define TLWHITE	   23
#define TLBLACK	   24
#define TLFORWARD	   25
#define TLBACK	   26

#define	FORM2	    1

