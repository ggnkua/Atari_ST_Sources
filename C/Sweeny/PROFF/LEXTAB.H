#ifndef STRUC_DEFINED

/*	lextab.h	*/

struct _lex_h { 	char 	*__s;
		  	int 	 __v;
		  	int  	 __f;
		struct  _lex_h  *__l;
};

#define STRUC_DEFINED
#endif
struct
_lex_h __ce = {  "ce",
                  21,     0,NULL };
struct
_lex_h __ec = {  "ec",
                  27,     0,&__ce };
struct
_lex_h __de = {  "de",
                  25,     0,NULL };
struct
_lex_h __f = {  "f",
                  33,     1,NULL };
struct
_lex_h __ef = {  "ef",
                  29,     0,NULL };
struct
_lex_h __nojustify = {  "nojustify",
                  57,     0,&__ef };
struct
_lex_h __eh = {  "eh",
                  31,     0,NULL };
struct
_lex_h __he = {  "he",
                  37,     0,&__eh };
struct
_lex_h __j = {  "j",
                  41,     1,NULL };
struct
_lex_h __fi = {  "fi",
                  33,     0,NULL };
struct
_lex_h __na = {  "na",
                  99,     0,&__fi };
struct
_lex_h __cl = {  "cl",
                 103,     0,&__na };
struct
_lex_h __ig = {  "ig",
                  91,     0,NULL };
struct
_lex_h __dbo = {  "dbo",
                   5,     1,NULL };
struct
_lex_h __pa = {  "pa",
                  11,     1,&__dbo };
struct
_lex_h __ap = {  "ap",
                  99,     1,&__pa };
struct
_lex_h __el = {  "el",
                 109,     1,&__ap };
struct
_lex_h __ebo = {  "ebo",
                   7,     1,NULL };
struct
_lex_h __bp = {  "bp",
                   9,     0,&__ebo };
struct
_lex_h __ne = {  "ne",
                  53,     0,NULL };
struct
_lex_h __pc = {  "pc",
                 105,     0,&__ne };
struct
_lex_h __br = {  "br",
                  15,     1,NULL };
struct
_lex_h __need = {  "need",
                  53,     0,&__br };
struct
_lex_h __nf = {  "nf",
                  55,     1,&__need };
struct
_lex_h __oe = {  "oe",
                  63,     0,&__nf };
struct
_lex_h __noautoparagraph = {  "noautoparagraph",
                 101,     1,&__oe };
struct
_lex_h __page = {  "page",
                   9,     1,NULL };
struct
_lex_h __bs = {  "bs",
                  17,     0,&__page };
struct
_lex_h __cchar = {  "cchar",
                  19,     0,&__bs };
struct
_lex_h __fo = {  "fo",
                  35,     0,&__cchar };
struct
_lex_h __of = {  "of",
                  65,     0,&__fo };
struct
_lex_h __pg = {  "pg",
                   9,     1,NULL };
struct
_lex_h __echar = {  "echar",
                  27,     0,&__pg };
struct
_lex_h __in = {  "in",
                  39,     0,&__echar };
struct
_lex_h __oh = {  "oh",
                  67,     0,&__in };
struct
_lex_h __s = {  "s",
                  77,     1,&__oh };
struct
_lex_h __cu = {  "cu",
                  23,     0,NULL };
struct
_lex_h __nj = {  "nj",
                  57,     1,&__cu };
struct
_lex_h __bold = {  "bold",
                   3,     0,NULL };
struct
_lex_h __break = {  "break",
                  15,     1,&__bold };
struct
_lex_h __header = {  "header",
                  37,     0,&__break };
struct
_lex_h __lm = {  "lm",
                  39,     1,&__header };
struct
_lex_h __define = {  "define",
                  25,     0,NULL };
struct
_lex_h __nap = {  "nap",
                 101,     1,&__define };
struct
_lex_h __pl = {  "pl",
                  69,     0,NULL };
struct
_lex_h __get = {  "get",
                  95,     0,&__pl };
struct
_lex_h __ti = {  "ti",
                  81,     0,NULL };
struct
_lex_h __vg = {  "vg",
                  95,     0,&__ti };
struct
_lex_h __np = {  "np",
                  13,     0,NULL };
struct
_lex_h __pn = {  "pn",
                  97,     0,&__np };
struct
_lex_h __fill = {  "fill",
                  33,     1,NULL };
struct
_lex_h __ju = {  "ju",
                  41,     0,&__fill };
struct
_lex_h __ls = {  "ls",
                  43,     0,&__ju };
struct
_lex_h __po = {  "po",
                  71,     0,&__ls };
struct
_lex_h __rm = {  "rm",
                  73,     1,&__po };
struct
_lex_h __nr = {  "nr",
                  59,     0,NULL };
struct
_lex_h __lt = {  "lt",
                 107,     1,&__nr };
struct
_lex_h __ul = {  "ul",
                  83,     0,NULL };
struct
_lex_h __spc = {  "spc",
                  43,     1,NULL };
struct
_lex_h __so = {  "so",
                  75,     0,&__spc };
struct
_lex_h __ps = {  "ps",
                  69,     1,NULL };
struct
_lex_h __sp = {  "sp",
                  77,     0,&__ps };
struct
_lex_h __left = {  "left",
                  81,     1,&__sp };
struct
_lex_h __tp = {  "tp",
                  53,     1,NULL };
struct
_lex_h __ou = {  "ou",
                  61,     0,&__tp };
struct
_lex_h __req = {  "req",
                  75,     1,&__ou };
struct
_lex_h __lx = {  "lx",
                  89,     0,&__req };
struct
_lex_h __rs = {  "rs",
                  87,     0,NULL };
struct
_lex_h __lex = {  "lex",
                  89,     0,&__rs };
struct
_lex_h __paging = {  "paging",
                  11,     1,NULL };
struct
_lex_h __st = {  "st",
                  79,     0,NULL };
struct
_lex_h __save = {  "save",
                  85,     0,&__st };
struct
_lex_h __set = {  "set",
                  93,     0,NULL };
struct
_lex_h __sv = {  "sv",
                  85,     0,NULL };
struct
_lex_h __vs = {  "vs",
                  93,     0,&__sv };
struct
_lex_h __wr = {  "wr",
                 111,     0,&__vs };
struct
_lex_h __skip = {  "skip",
                  77,     1,NULL };
struct
_lex_h __include = {  "include",
                  75,     0,NULL };
struct
_lex_h __center = {  "center",
                  21,     0,NULL };
struct
_lex_h __spacing = {  "spacing",
                  43,     1,&__center };
struct
_lex_h __nofill = {  "nofill",
                  55,     0,NULL };
struct
_lex_h __ignore = {  "ignore",
                  91,     0,&__nofill };
struct
_lex_h __reset = {  "reset",
                   1,     0,NULL };
struct
_lex_h __offset = {  "offset",
                  71,     0,&__reset };
struct
_lex_h __literal = {  "literal",
                 107,     1,NULL };
struct
_lex_h __enablebolding = {  "enablebolding",
                   7,     1,NULL };
struct
_lex_h __nopaging = {  "nopaging",
                  13,     1,NULL };
struct
_lex_h __footer = {  "footer",
                  35,     0,NULL };
struct
_lex_h __outend = {  "outend",
                  63,     0,&__footer };
struct
_lex_h __write = {  "write",
                 111,     0,&__outend };
struct
_lex_h __pagesize = {  "pagesize",
                  69,     1,NULL };
struct
_lex_h __source = {  "source",
                  75,     0,NULL };
struct
_lex_h __m1 = {  "m1",
                  45,     0,NULL };
struct
_lex_h __disablebolding = {  "disablebolding",
                   5,     1,NULL };
struct
_lex_h __m2 = {  "m2",
                  47,     0,&__disablebolding };
struct
_lex_h __m3 = {  "m3",
                  49,     0,NULL };
struct
_lex_h __contline = {  "contline",
                 103,     0,&__m3 };
struct
_lex_h __endliteral = {  "endliteral",
                 109,     1,&__contline };
struct
_lex_h __m4 = {  "m4",
                  51,     0,NULL };
struct
_lex_h __testpage = {  "testpage",
                  53,     1,&__m4 };
struct
_lex_h __pagenumber = {  "pagenumber",
                  97,     0,NULL };
struct
_lex_h __leftmargin = {  "leftmargin",
                  39,     1,NULL };
struct
_lex_h __require = {  "require",
                  75,     1,&__leftmargin };
struct
_lex_h __skipto = {  "skipto",
                  79,     0,NULL };
struct
_lex_h __underline = {  "underline",
                  83,     0,&__skipto };
struct
_lex_h __restore = {  "restore",
                  87,     0,NULL };
struct
_lex_h __rightmargin = {  "rightmargin",
                  73,     1,NULL };
struct
_lex_h __justify = {  "justify",
                  41,     1,NULL };
struct
_lex_h __output = {  "output",
                  61,     0,NULL };
struct
_lex_h __autoparagraph = {  "autoparagraph",
                  99,     1,NULL };
struct
_lex_h __printcont = {  "printcont",
                 105,     0,NULL };
struct
_lex_h __bd = {  "bd",
                   3,     0,NULL };
struct
_lex_h __db = {  "db",
                   5,     0,&__bd };
struct
_lex_h __cc = {  "cc",
                  19,     0,&__db };
struct
_lex_h __eb = {  "eb",
                   7,     0,NULL };


/*  Hash Table */

struct _lex_h *lextab[100] = {
	&__ec,	
	&__de,	&__f,	&__nojustify,	NULL,	
	&__he,	&__j,	&__cl,	&__ig,	
	&__el,	&__bp,	&__pc,	&__noautoparagraph,	
	&__of,	NULL,	&__s,	&__nj,	
	&__lm,	NULL,	&__nap,	&__get,	
	&__vg,	&__pn,	&__rm,	&__lt,	
	&__ul,	&__so,	&__left,	&__lx,	
	&__lex,	&__paging,	&__save,	&__set,	
	&__wr,	NULL,	NULL,	NULL,	
	NULL,	NULL,	&__skip,	&__include,	
	&__spacing,	NULL,	NULL,	&__ignore,	
	NULL,	NULL,	&__offset,	NULL,	
	&__literal,	&__enablebolding,	&__nopaging,	NULL,	
	NULL,	NULL,	&__write,	&__pagesize,	
	&__source,	&__m1,	&__m2,	&__endliteral,	
	&__testpage,	&__pagenumber,	NULL,	NULL,	
	&__require,	&__underline,	NULL,	NULL,	
	NULL,	NULL,	NULL,	&__restore,	
	NULL,	NULL,	NULL,	NULL,	
	NULL,	NULL,	NULL,	&__rightmargin,	
	NULL,	&__justify,	NULL,	NULL,	
	NULL,	NULL,	NULL,	NULL,	
	&__output,	NULL,	&__autoparagraph,	NULL,	
	&__printcont,	NULL,	NULL,	NULL,	
	NULL,	&__cc,	&__eb   };
