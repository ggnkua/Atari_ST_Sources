/* Resource Datei Indizes f�r AHDICONF */

#define DIALOG   0   /* Formular/Dialog */
#define ACSINUM  5   /* FTEXT in Baum DIALOG */
#define SCSI     13  /* BOX in Baum DIALOG */
#define SCSINUM  15  /* FTEXT in Baum DIALOG */
#define CHUNK    23  /* FTEXT in Baum DIALOG */
#define DEFBIGSE 25  /* BUTTON in Baum DIALOG */
#define ABORT    31  /* BUTTON in Baum DIALOG */
