/* Resource Datei Indizes f�r SETFLAGS */

#define DIALOG   0   /* Formular/Dialog */
#define FILENAME 4   /* STRING in Baum DIALOG */
#define FASTLOAD 5   /* BUTTON in Baum DIALOG */
#define TTMEM    6   /* BUTTON in Baum DIALOG */
#define TTRAM    7   /* BUTTON in Baum DIALOG */
#define PRIVATE  8   /* BUTTON in Baum DIALOG */
#define GLOBAL   9   /* BUTTON in Baum DIALOG */
#define SUPER    10  /* BUTTON in Baum DIALOG */
#define READABLE 11  /* BUTTON in Baum DIALOG */
#define OK       12  /* BUTTON in Baum DIALOG */
