/*
 * ARGX.H
 *
 * Header-Datei fuer automatische Argument-Expansion.
 */

#define main main_              /* das wars schon */

