/*************************/
/* Quelldatei: INTERNA.H */
/*************************/

# if !defined( __INTERNA )
# define __INTERNA

int boot_dev(void);

# endif
