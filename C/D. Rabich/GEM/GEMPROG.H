/***************************************************/
/* Resource-Set indicies fuer GEMPROG              */
/* =============================================== */
/* Quelldatei: GEMPROG.H                           */
/***************************************************/

#define MENUE    0      /* Menuebaum */
#define MNINFO   3      /* TITLE in Baum MENUE */
#define MNDATEI  4      /* TITLE in Baum MENUE */
#define ITINFO   7      /* STRING in Baum MENUE */
#define ITNEU    16     /* STRING in Baum MENUE */
#define ITOEFFNE 17     /* STRING in Baum MENUE */
#define ITSICHER 19     /* STRING in Baum MENUE */
#define ITSICALS 20     /* STRING in Baum MENUE */
#define ITAUSGAB 21     /* STRING in Baum MENUE */
#define ITENDE   23     /* STRING in Baum MENUE */

#define DESKTOP  1      /* Formula/Dialog */
#define BSPICON  1      /* ICON in Baum DESKTOP */

#define INFODIAL 2      /* Formula/Dialog */
#define INFOEXIT 4      /* BUTTON in Baum INFODIAL */

#define LADEN    0      /* Alarm-String Index */

#define SPEICHER 1      /* Alarm-String Index */

#define DOPPEL   2      /* Alarm-String Index */

#define AUSGABE  3      /* Alarm-String Index */

