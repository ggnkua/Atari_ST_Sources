/*********************************/
/* Quelldatei: SCANKEY.H         */
/*********************************/

# if !defined( __SCANKEY )
# define __SCANKEY

# define K_Q 16
# define K_O 24
# define K_A 30
# define K_S 31
# define K_N 49
/* Bei Bedarf k”nnen hier die    */
/* weiteren Scancodes deklariert */
/* werden.                       */

# endif
