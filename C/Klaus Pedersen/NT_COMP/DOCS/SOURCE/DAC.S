/* DAC.S distributed, together with "NT_COMP" - the NoiseTracker 
 * Compiler for Atari [MEGA] ST, STe and TT computers.
 */

dc.w $080C, $090B, $0A09, $0000, $080C, $090B, $0A09, $0000
dc.w $080D, $0908, $0A08, $0000, $080B, $090B, $0A0B, $0000
dc.w $080D, $0909, $0A05, $0000, $080C, $090B, $0A08, $0000
dc.w $080D, $0909, $0A02, $0000, $080D, $0908, $0A06, $0000
dc.w $080C, $090B, $0A07, $0000, $080D, $0907, $0A07, $0000
dc.w $080C, $090B, $0A06, $0000, $080C, $090A, $0A09, $0000
dc.w $080B, $090B, $0A0A, $0000, $080C, $090B, $0A02, $0000
dc.w $080C, $090B, $0A00, $0000, $080C, $090A, $0A08, $0000
dc.w $080D, $0906, $0A04, $0000, $080D, $0905, $0A05, $0000
dc.w $080D, $0905, $0A04, $0000, $080C, $0909, $0A09, $0000
dc.w $080D, $0904, $0A03, $0000, $080B, $090B, $0A09, $0000
dc.w $080C, $090A, $0A05, $0000, $080B, $090A, $0A0A, $0000
dc.w $080C, $0909, $0A08, $0000, $080B, $090B, $0A08, $0000
dc.w $080C, $090A, $0A00, $0000, $080C, $090A, $0A00, $0000
dc.w $080C, $0909, $0A07, $0000, $080B, $090B, $0A07, $0000
dc.w $080C, $0909, $0A06, $0000, $080B, $090B, $0A06, $0000
dc.w $080B, $090A, $0A09, $0000, $080B, $090B, $0A05, $0000
dc.w $080A, $090A, $0A0A, $0000, $080B, $090B, $0A02, $0000
dc.w $080B, $090A, $0A08, $0000, $080C, $0907, $0A07, $0000
dc.w $080C, $0908, $0A04, $0000, $080C, $0907, $0A06, $0000
dc.w $080B, $0909, $0A09, $0000, $080C, $0906, $0A06, $0000
dc.w $080A, $090A, $0A09, $0000, $080C, $0907, $0A03, $0000
dc.w $080B, $090A, $0A05, $0000, $080B, $0909, $0A08, $0000
dc.w $080B, $090A, $0A03, $0000, $080A, $090A, $0A08, $0000
dc.w $080B, $090A, $0A00, $0000, $080B, $0909, $0A07, $0000
dc.w $080B, $0908, $0A08, $0000, $080A, $090A, $0A07, $0000
dc.w $080A, $0909, $0A09, $0000, $080C, $0901, $0A01, $0000
dc.w $080A, $090A, $0A06, $0000, $080B, $0908, $0A07, $0000
dc.w $080A, $090A, $0A05, $0000, $080A, $0909, $0A08, $0000
dc.w $080A, $090A, $0A02, $0000, $080A, $090A, $0A01, $0000
dc.w $080A, $090A, $0A00, $0000, $0809, $0909, $0A09, $0000
dc.w $080A, $0908, $0A08, $0000, $080B, $0908, $0A01, $0000
dc.w $080A, $0909, $0A06, $0000, $080B, $0907, $0A04, $0000
dc.w $080A, $0909, $0A05, $0000, $0809, $0909, $0A08, $0000
dc.w $080A, $0909, $0A03, $0000, $080A, $0908, $0A06, $0000
dc.w $080A, $0909, $0A00, $0000, $0809, $0909, $0A07, $0000
dc.w $0809, $0908, $0A08, $0000, $080A, $0908, $0A04, $0000
dc.w $0809, $0909, $0A06, $0000, $080A, $0908, $0A01, $0000
dc.w $0809, $0909, $0A05, $0000, $0809, $0908, $0A07, $0000
dc.w $0808, $0908, $0A08, $0000, $0809, $0909, $0A02, $0000
dc.w $0809, $0908, $0A06, $0000, $0809, $0909, $0A00, $0000
dc.w $0809, $0907, $0A07, $0000, $0808, $0908, $0A07, $0000
dc.w $0809, $0907, $0A06, $0000, $0809, $0908, $0A02, $0000
dc.w $0808, $0908, $0A06, $0000, $0809, $0906, $0A06, $0000
dc.w $0808, $0907, $0A07, $0000, $0808, $0908, $0A04, $0000
dc.w $0808, $0907, $0A06, $0000, $0808, $0908, $0A02, $0000
dc.w $0807, $0907, $0A07, $0000, $0808, $0906, $0A06, $0000
dc.w $0808, $0907, $0A04, $0000, $0807, $0907, $0A06, $0000
dc.w $0808, $0906, $0A05, $0000, $0808, $0906, $0A04, $0000
dc.w $0807, $0906, $0A06, $0000, $0807, $0907, $0A04, $0000
dc.w $0808, $0905, $0A04, $0000, $0806, $0906, $0A06, $0000
dc.w $0807, $0906, $0A04, $0000, $0807, $0905, $0A05, $0000
dc.w $0806, $0906, $0A05, $0000, $0806, $0906, $0A04, $0000
dc.w $0806, $0905, $0A05, $0000, $0806, $0906, $0A02, $0000
dc.w $0806, $0905, $0A04, $0000, $0805, $0905, $0A05, $0000
dc.w $0806, $0905, $0A02, $0000, $0805, $0905, $0A04, $0000
dc.w $0805, $0904, $0A04, $0000, $0805, $0905, $0A02, $0000
dc.w $0804, $0904, $0A04, $0000, $0804, $0904, $0A03, $0000
dc.w $0804, $0904, $0A02, $0000, $0804, $0903, $0A03, $0000
dc.w $0803, $0903, $0A03, $0000, $0803, $0903, $0A02, $0000
dc.w $0803, $0902, $0A02, $0000, $0802, $0902, $0A02, $0000
dc.w $0802, $0902, $0A01, $0000, $0801, $0901, $0A01, $0000
dc.w $0802, $0901, $0A00, $0000, $0801, $0901, $0A00, $0000
dc.w $0801, $0900, $0A00, $0000, $0800, $0900, $0A00, $0000
dc.w $080E, $090D, $0A0C, $0000, $080F, $0903, $0A00, $0000
dc.w $080F, $0903, $0A00, $0000, $080F, $0903, $0A00, $0000
dc.w $080F, $0903, $0A00, $0000, $080F, $0903, $0A00, $0000
dc.w $080F, $0903, $0A00, $0000, $080E, $090D, $0A0B, $0000
dc.w $080E, $090D, $0A0B, $0000, $080E, $090D, $0A0B, $0000
dc.w $080E, $090D, $0A0B, $0000, $080E, $090D, $0A0B, $0000
dc.w $080E, $090D, $0A0B, $0000, $080E, $090D, $0A0B, $0000
dc.w $080E, $090D, $0A0A, $0000, $080E, $090D, $0A0A, $0000
dc.w $080E, $090D, $0A0A, $0000, $080E, $090D, $0A0A, $0000
dc.w $080E, $090C, $0A0C, $0000, $080E, $090D, $0A00, $0000
dc.w $080D, $090D, $0A0D, $0000, $080D, $090D, $0A0D, $0000
dc.w $080D, $090D, $0A0D, $0000, $080D, $090D, $0A0D, $0000
dc.w $080D, $090D, $0A0D, $0000, $080D, $090D, $0A0D, $0000
dc.w $080E, $090C, $0A0B, $0000, $080E, $090C, $0A0B, $0000
dc.w $080E, $090C, $0A0B, $0000, $080E, $090C, $0A0B, $0000
dc.w $080E, $090C, $0A0B, $0000, $080E, $090C, $0A0B, $0000
dc.w $080E, $090C, $0A0B, $0000, $080E, $090C, $0A0B, $0000
dc.w $080E, $090C, $0A0A, $0000, $080E, $090C, $0A0A, $0000
dc.w $080E, $090C, $0A0A, $0000, $080E, $090C, $0A0A, $0000
dc.w $080D, $090D, $0A0C, $0000, $080D, $090D, $0A0C, $0000
dc.w $080E, $090C, $0A09, $0000, $080E, $090C, $0A09, $0000
dc.w $080E, $090C, $0A05, $0000, $080E, $090C, $0A00, $0000
dc.w $080E, $090C, $0A00, $0000, $080E, $090B, $0A0B, $0000
dc.w $080E, $090B, $0A0B, $0000, $080E, $090B, $0A0B, $0000
dc.w $080E, $090B, $0A0B, $0000, $080E, $090B, $0A0A, $0000
dc.w $080E, $090B, $0A0A, $0000, $080E, $090B, $0A0A, $0000
dc.w $080D, $090D, $0A0B, $0000, $080D, $090D, $0A0B, $0000
dc.w $080D, $090D, $0A0B, $0000, $080E, $090B, $0A09, $0000
dc.w $080E, $090B, $0A09, $0000, $080E, $090B, $0A09, $0000
dc.w $080D, $090C, $0A0C, $0000, $080D, $090D, $0A0A, $0000
dc.w $080E, $090B, $0A07, $0000, $080E, $090B, $0A00, $0000
dc.w $080E, $090B, $0A00, $0000, $080D, $090D, $0A09, $0000
dc.w $080D, $090D, $0A09, $0000, $080E, $090A, $0A09, $0000
dc.w $080D, $090D, $0A08, $0000, $080D, $090D, $0A07, $0000
dc.w $080D, $090D, $0A04, $0000, $080D, $090D, $0A00, $0000
dc.w $080E, $090A, $0A04, $0000, $080E, $0909, $0A09, $0000
dc.w $080E, $0909, $0A09, $0000, $080D, $090C, $0A0B, $0000
dc.w $080E, $0909, $0A08, $0000, $080E, $0909, $0A08, $0000
dc.w $080E, $0909, $0A07, $0000, $080E, $0908, $0A08, $0000
dc.w $080E, $0909, $0A01, $0000, $080C, $090C, $0A0C, $0000
dc.w $080D, $090C, $0A0A, $0000, $080E, $0908, $0A06, $0000
dc.w $080E, $0907, $0A07, $0000, $080E, $0908, $0A00, $0000
dc.w $080E, $0907, $0A05, $0000, $080E, $0906, $0A06, $0000
dc.w $080D, $090C, $0A09, $0000, $080E, $0905, $0A05, $0000
dc.w $080E, $0904, $0A04, $0000, $080D, $090C, $0A08, $0000
dc.w $080D, $090B, $0A0B, $0000, $080E, $0900, $0A00, $0000
dc.w $080D, $090C, $0A06, $0000, $080D, $090C, $0A05, $0000
dc.w $080D, $090C, $0A02, $0000, $080C, $090C, $0A0B, $0000
dc.w $080C, $090C, $0A0B, $0000, $080D, $090B, $0A0A, $0000
dc.w $080D, $090B, $0A0A, $0000, $080D, $090B, $0A0A, $0000
dc.w $080D, $090B, $0A0A, $0000, $080C, $090C, $0A0A, $0000
dc.w $080C, $090C, $0A0A, $0000, $080C, $090C, $0A0A, $0000
dc.w $080D, $090B, $0A09, $0000, $080D, $090B, $0A09, $0000
dc.w $080D, $090A, $0A0A, $0000, $080D, $090A, $0A0A, $0000
dc.w $080D, $090A, $0A0A, $0000, $080C, $090C, $0A09, $0000
dc.w $080C, $090C, $0A09, $0000, $080C, $090C, $0A09, $0000
dc.w $080D, $090B, $0A06, $0000, $080C, $090B, $0A0B, $0000
dc.w $080C, $090C, $0A08, $0000, $080D, $090B, $0A00, $0000
dc.w $080D, $090B, $0A00, $0000, $080C, $090C, $0A07, $0000
dc.w $080C, $090C, $0A06, $0000, $080C, $090C, $0A05, $0000
dc.w $080C, $090C, $0A03, $0000, $080C, $090C, $0A01, $0000
dc.w $080C, $090B, $0A0A, $0000, $080D, $090A, $0A05, $0000
dc.w $080D, $090A, $0A04, $0000, $080D, $090A, $0A02, $0000
dc.w $080D, $0909, $0A08, $0000, $080D, $0909, $0A08, $0000

