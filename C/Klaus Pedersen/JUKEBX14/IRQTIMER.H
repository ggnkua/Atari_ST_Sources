#define MENU 0  	/* TREE */
#define QUIT 17  	/* OBJECT in TREE #0 */
#define SYNC 19  	/* OBJECT in TREE #0 */
#define INDEX 20  	/* OBJECT in TREE #0 */
#define ABOUT 8  	/* OBJECT in TREE #0 */
