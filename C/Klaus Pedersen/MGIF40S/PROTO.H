#include <stdio.h>
#include "mgif.h"
#include "file.i"
#include "low.i"
#include "mgif.i"
#include "readgif.i"
#include "readpi.i"
#include "process.i"
#include "flicker.i"