/* Resource Datei Indizes f�r GPRINT */

#define GDOSUTIL         0   /* Formular/Dialog */
#define UMLAUTE          2   /* IBOX in Baum GDOSUTIL */
#define DATEINAME        5   /* IBOX in Baum GDOSUTIL */
#define TAB2SPACE        7   /* IBOX in Baum GDOSUTIL */
#define TABSPACE         9   /* FTEXT in Baum GDOSUTIL */
#define DATUM            11  /* IBOX in Baum GDOSUTIL */
#define PAGENUM          13  /* IBOX in Baum GDOSUTIL */
#define HEFTRAND         15  /* IBOX in Baum GDOSUTIL */
#define LEFTSPACE        18  /* FTEXT in Baum GDOSUTIL */
#define UNTERSTRICH      20  /* IBOX in Baum GDOSUTIL */
#define LOCHERMARKE      22  /* IBOX in Baum GDOSUTIL */
#define SEITENRAHMEN     24  /* IBOX in Baum GDOSUTIL */
#define PAGEBREAK        26  /* IBOX in Baum GDOSUTIL */
#define PAGEQUER         28  /* IBOX in Baum GDOSUTIL */
#define HELP             30  /* BOXTEXT in Baum GDOSUTIL */
#define PROFONT          33  /* STRING in Baum GDOSUTIL */
#define SPDFONT          34  /* STRING in Baum GDOSUTIL */
#define SPECIAL          35  /* FTEXT in Baum GDOSUTIL */
#define FONTSELECT       36  /* FTEXT in Baum GDOSUTIL */
#define POPBTN           37  /* BOXTEXT in Baum GDOSUTIL */
#define DEVINFO          38  /* ICON in Baum GDOSUTIL */
#define NAMEDATEI        40  /* FTEXT in Baum GDOSUTIL */
#define AKTUELLERPFAD    42  /* FTEXT in Baum GDOSUTIL */
#define EINSTELLUNGEN    43  /* BOXTEXT in Baum GDOSUTIL */
#define CATALOG          44  /* BUTTON in Baum GDOSUTIL */
#define GDUOK            45  /* BUTTON in Baum GDOSUTIL */

#define HILFE            1   /* Formular/Dialog */

#define FONTEINST        2   /* Formular/Dialog */
#define FONTSINSGESAMT   2   /* FTEXT in Baum FONTEINST */
#define FONTVORHER       5   /* BOXCHAR in Baum FONTEINST */
#define FONTNAME         6   /* FTEXT in Baum FONTEINST */
#define FONTDANACH       7   /* BOXCHAR in Baum FONTEINST */
#define PROPFONT         8   /* TEXT in Baum FONTEINST */
#define SPEEDFONT        9   /* TEXT in Baum FONTEINST */
#define ZH6              12  /* IBOX in Baum FONTEINST */
#define SZH6             13  /* TEXT in Baum FONTEINST */
#define ZH8              14  /* IBOX in Baum FONTEINST */
#define SZH8             15  /* TEXT in Baum FONTEINST */
#define ZH10             16  /* IBOX in Baum FONTEINST */
#define SZH10            17  /* TEXT in Baum FONTEINST */
#define ZHBEL            18  /* IBOX in Baum FONTEINST */
#define ZHBELIEBIG       19  /* FTEXT in Baum FONTEINST */
#define FONTOK           21  /* BUTTON in Baum FONTEINST */
#define FONTABBR         22  /* BUTTON in Baum FONTEINST */

#define OPTIONENEINST    3   /* Formular/Dialog */
#define SAVEPFAD         3   /* IBOX in Baum OPTIONENEINST */
#define ABSATZMODE       5   /* IBOX in Baum OPTIONENEINST */
#define MEMDYN           7   /* IBOX in Baum OPTIONENEINST */
#define SPARMODE         9   /* IBOX in Baum OPTIONENEINST */
#define PPAGEPOP         13  /* BOXTEXT in Baum OPTIONENEINST */
#define FROMPAGE         14  /* IBOX in Baum OPTIONENEINST */
#define FROMPAGENUM      16  /* FTEXT in Baum OPTIONENEINST */
#define COPYS            17  /* IBOX in Baum OPTIONENEINST */
#define ANZCOPYS         18  /* FTEXT in Baum OPTIONENEINST */
#define OKOPT            20  /* BUTTON in Baum OPTIONENEINST */
#define CANCELOPT        21  /* BUTTON in Baum OPTIONENEINST */
#define SAVEOPT          22  /* BUTTON in Baum OPTIONENEINST */

#define IDPOP            4   /* Formular/Dialog */
#define ID21             1   /* STRING in Baum IDPOP */
#define ID22             2   /* STRING in Baum IDPOP */
#define ID23             3   /* STRING in Baum IDPOP */
#define ID24             4   /* STRING in Baum IDPOP */
#define ID25             5   /* STRING in Baum IDPOP */
#define ID26             6   /* STRING in Baum IDPOP */
#define ID27             7   /* STRING in Baum IDPOP */
#define ID28             8   /* STRING in Baum IDPOP */
#define ID29             9   /* STRING in Baum IDPOP */
#define ID30             10  /* STRING in Baum IDPOP */

#define PAGEPOP          5   /* Formular/Dialog */
#define PPAGEALL         1   /* STRING in Baum PAGEPOP */
#define PPAGEGERADE      2   /* STRING in Baum PAGEPOP */
#define PPAGEUNGERADE    3   /* STRING in Baum PAGEPOP */

#define DEVICEINFO       6   /* Formular/Dialog */
#define DEVID            4   /* FTEXT in Baum DEVICEINFO */
#define DEVNAME          6   /* FTEXT in Baum DEVICEINFO */
#define DEVDPI           8   /* FTEXT in Baum DEVICEINFO */
#define DEVX             11  /* FTEXT in Baum DEVICEINFO */
#define DEVY             14  /* FTEXT in Baum DEVICEINFO */
#define DEVSLICES        17  /* FTEXT in Baum DEVICEINFO */
#define DEVSLICESH       19  /* FTEXT in Baum DEVICEINFO */
#define DEVTEXTZ         21  /* FTEXT in Baum DEVICEINFO */
#define DEVTEXTZH        23  /* FTEXT in Baum DEVICEINFO */
#define DEVINFOOK        24  /* BUTTON in Baum DEVICEINFO */
