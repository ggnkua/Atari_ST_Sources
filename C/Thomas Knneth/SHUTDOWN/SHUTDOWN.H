/* Resource Datei Indizes f�r SHUTDOWN */

#define MAIN_PAGE        0   /* Formular/Dialog */
#define BT_MP_SHUTDOWN   2   /* BUTTON in Baum MAIN_PAGE */
#define PU_MP_SELRES     4   /* BUTTON in Baum MAIN_PAGE */
#define BT_MP_CANCEL     10  /* BUTTON in Baum MAIN_PAGE */

#define SHUT_ERROR       1   /* Formular/Dialog */
#define BT_ED_KILL       9   /* BUTTON in Baum SHUT_ERROR */
#define BT_ED_OK         10  /* BUTTON in Baum SHUT_ERROR */

#define SHUT_DO          2   /* Formular/Dialog */
#define BT_DOSHUT_OK     8   /* BUTTON in Baum SHUT_DO */
#define BT_DOSHUT_CAN    9   /* BUTTON in Baum SHUT_DO */

#define SHUT_DONE        3   /* Formular/Dialog */
