; Startup-Code 
; f�r SHUTDOWN.CPX

; geschrieben 1995 von 
; Thomas K�nneth, R”thenbach
; f�r MAXON Computer

; 17.1.1995

IMPORT	cpx_init

.text

   cpxstart:   jmp cpx_init

.end
