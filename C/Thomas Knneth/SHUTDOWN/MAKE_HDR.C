/*
	dieses Programm erzeugt einen
	512 Byte langen Header, der
	mit SHUTDOWN.CP zu einem
	funktionierenden SHUTDOWN.CPX
	zusammengef�gt werden muž

	geschrieben 1995 Thomas K�nneth

	(c) MAXON
*/

#include <tos.h>
#include <portab.h>

UBYTE data[512] = {
0x00,0x64,0x00,0x00,0x54,0x48,0x4B,0x32,
0x01,0x00,0x28,0x63,0x29,0x20,0x4D,0x41,
0x58,0x4F,0x4E,0x20,0x39,0x35,0x00,0x00,
0x07,0xFF,0xFF,0xE1,0x07,0xFF,0xFF,0xE2,
0x07,0xFF,0xFF,0xEC,0x07,0x00,0x00,0xF4,
0x07,0x68,0x00,0xE4,0x07,0x00,0x00,0xE4,
0x07,0x00,0x01,0x64,0x07,0x6E,0xEA,0xA4,
0x07,0x00,0x0F,0x64,0x07,0x6A,0x92,0xA4,
0x07,0x00,0x25,0x64,0x07,0x6C,0xE6,0xA4,
0x07,0x01,0x65,0x64,0x07,0x66,0xB2,0xA4,
0x07,0x0D,0x53,0x64,0x07,0x73,0xF3,0xE4,
0x07,0x34,0x12,0x14,0x07,0xD8,0x12,0x0C,
0x07,0x9F,0xE7,0xFC,0x07,0x61,0x84,0x00,
0x0C,0x1E,0x08,0x00,0x10,0x40,0x30,0x00,
0x21,0xB0,0xC0,0x00,0xC6,0x0F,0x00,0x00,
0x20,0x00,0x53,0x68,0x75,0x74,0x64,0x6F,
0x77,0x6E,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x12,0x80,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
} ;

void main(void)
{
	long	error;
	int		fd;
	error = Fcreate("shutdown.hdr",0);
	if (error >= 0) {
		fd = (int)error;
		Fwrite(fd,512,data);
		Fclose(fd);
	}
}
