/* Resource file indices for GEM-DEU */

#define EDITMENU 0   /* Menu tree */
#define T_EDESK  3   /* TITLE in Tree EDITMENU */
#define T_EFILE  4   /* TITLE in Tree EDITMENU */
#define T_EEDIT  5   /* TITLE in Tree EDITMENU */
#define T_ESEARCH 6   /* TITLE in Tree EDITMENU */
#define T_EMODES 7   /* TITLE in Tree EDITMENU */
#define T_EMISC  8   /* TITLE in Tree EDITMENU */
#define T_ECHECK 9   /* TITLE in Tree EDITMENU */
#define T_EHELP  10  /* TITLE in Tree EDITMENU */
#define EDITSAVE 22  /* STRING in Tree EDITMENU */
#define EDITSAVEAS 23  /* STRING in Tree EDITMENU */
#define EDITEXIT 26  /* STRING in Tree EDITMENU */
#define EDITADD  28  /* STRING in Tree EDITMENU */
#define EDITDELETE 29  /* STRING in Tree EDITMENU */
#define EDITEDITOBJ 30  /* STRING in Tree EDITMENU */
#define EDITCOPY 31  /* STRING in Tree EDITMENU */
#define MARKUNMARK 32  /* STRING in Tree EDITMENU */
#define CLEARMARKS 33  /* STRING in Tree EDITMENU */
#define EDITPREFS 35  /* STRING in Tree EDITMENU */
#define EDITFIND 37  /* STRING in Tree EDITMENU */
#define EDITREPEATFIND 38  /* STRING in Tree EDITMENU */
#define EDITNEXT 39  /* STRING in Tree EDITMENU */
#define EDITPREV 40  /* STRING in Tree EDITMENU */
#define EDITJUMPTONEXT 41  /* STRING in Tree EDITMENU */
#define EDITMODE_THING 43  /* STRING in Tree EDITMENU */
#define EDITMODE_VERTEX 44  /* STRING in Tree EDITMENU */
#define EDITMODE_LINE 45  /* STRING in Tree EDITMENU */
#define EDITMODE_SECTORS 46  /* STRING in Tree EDITMENU */
#define EDITMODE_NEXT 47  /* STRING in Tree EDITMENU */
#define EDITMODE_PREV 48  /* STRING in Tree EDITMENU */
#define EDITMODE_3D 49  /* STRING in Tree EDITMENU */
#define SHOWRULERS 51  /* STRING in Tree EDITMENU */
#define DISPLAYGRID 53  /* STRING in Tree EDITMENU */
#define INCGRIDSCALE 54  /* STRING in Tree EDITMENU */
#define DECGRIDSCALE 55  /* STRING in Tree EDITMENU */
#define INCSCALE 57  /* STRING in Tree EDITMENU */
#define DECSCALE 58  /* STRING in Tree EDITMENU */
#define SETSCALE 59  /* STRING in Tree EDITMENU */
#define CHECK_STATS 61  /* STRING in Tree EDITMENU */
#define CHECK_SECTORS 62  /* STRING in Tree EDITMENU */
#define CHECK_XREFS 63  /* STRING in Tree EDITMENU */
#define CHECK_TEXTURES 64  /* STRING in Tree EDITMENU */
#define EDITHELP_CONTROL 66  /* STRING in Tree EDITMENU */
#define EDITHELP_INFOBAR 67  /* STRING in Tree EDITMENU */
#define EDIT_ABOUT 68  /* STRING in Tree EDITMENU */

#define MAINMENU 1   /* Menu tree */
#define T_DESK   3   /* TITLE in Tree MAINMENU */
#define T_FILE   4   /* TITLE in Tree MAINMENU */
#define T_WADMANAGE 5   /* TITLE in Tree MAINMENU */
#define OPENPWAD 17  /* STRING in Tree MAINMENU */
#define CREATE   19  /* STRING in Tree MAINMENU */
#define EDIT     20  /* STRING in Tree MAINMENU */
#define VIEWSPRITES 21  /* STRING in Tree MAINMENU */
#define QUIT     23  /* STRING in Tree MAINMENU */
#define OPENWADS 25  /* STRING in Tree MAINMENU */
#define LISTMASTER 26  /* STRING in Tree MAINMENU */
#define LISTWAD  27  /* STRING in Tree MAINMENU */
#define SAVEOBJ  29  /* STRING in Tree MAINMENU */
#define GROUPWADS 30  /* STRING in Tree MAINMENU */
#define BUILD    31  /* STRING in Tree MAINMENU */
#define LOADRAW  33  /* STRING in Tree MAINMENU */
#define SAVERAW  34  /* STRING in Tree MAINMENU */
#define DUMPENTRY 35  /* STRING in Tree MAINMENU */

#define WELCOMEDIAG 2   /* Form/Dialog box */

#define SELECTLEVELDIAG 3   /* Form/Dialog box */
#define LEVELNUM 1   /* FTEXT in Tree SELECTLEVELDIAG */
#define ENDSELLEV 2   /* BUTTON in Tree SELECTLEVELDIAG */

#define ABOUTGEMDEU 4   /* Form/Dialog box */

#define INPUTOBJECTNAME 5   /* Form/Dialog box */
#define OBJECTNAME 2   /* FTEXT in Tree INPUTOBJECTNAME */
#define DONESELOBJ 3   /* BUTTON in Tree INPUTOBJECTNAME */

#define OBJECTINFOBAR 6   /* Form/Dialog box */
#define OBJNUM   1   /* TEXT in Tree OBJECTINFOBAR */
#define OBJCOORDS 2   /* TEXT in Tree OBJECTINFOBAR */
#define OBJTYPE  3   /* TEXT in Tree OBJECTINFOBAR */

#define HELPFORM 7   /* Form/Dialog box */
#define HELPOK   8   /* BUTTON in Tree HELPFORM */

#define JUMPTO   8   /* Form/Dialog box */
#define JUMPTOEND 3   /* TEXT in Tree JUMPTO */
#define JUMPTONUM 4   /* FTEXT in Tree JUMPTO */
#define JUMPTOOK 8   /* BUTTON in Tree JUMPTO */
#define JUMPTOTYPE 9   /* TEXT in Tree JUMPTO */

#define STATISTICS 9   /* Form/Dialog box */
#define NUMTHINGS 7   /* TEXT in Tree STATISTICS */
#define NUMVERTICES 8   /* TEXT in Tree STATISTICS */
#define NUMLINEDEFS 9   /* TEXT in Tree STATISTICS */
#define NUMSIDEDEFS 10  /* TEXT in Tree STATISTICS */
#define NUMSECTORS 11  /* TEXT in Tree STATISTICS */

#define SETSCALEDIAG 10  /* Form/Dialog box */
#define SCALETOP 2   /* FTEXT in Tree SETSCALEDIAG */
#define SCALEBOT 3   /* FTEXT in Tree SETSCALEDIAG */
#define SCALEOK  6   /* BUTTON in Tree SETSCALEDIAG */

#define EDITVERTEX 11  /* Form/Dialog box */
#define VERTEXXCO 1   /* FTEXT in Tree EDITVERTEX */
#define VERTEXYCO 2   /* FTEXT in Tree EDITVERTEX */
#define EDITVERTEXOK 6   /* BUTTON in Tree EDITVERTEX */

#define EDITTHING 12  /* Form/Dialog box */
#define EDITTHINGOK 1   /* BUTTON in Tree EDITTHING */
#define EDITTHINGCANCEL 2   /* BUTTON in Tree EDITTHING */
#define THINGDIF3 18  /* BOX in Tree EDITTHING */
#define THINGDIF2 19  /* BOX in Tree EDITTHING */
#define THINGDIF1 20  /* BOX in Tree EDITTHING */
#define THINGMULTI 21  /* BOX in Tree EDITTHING */
#define THINGDEAF 27  /* BOX in Tree EDITTHING */
#define THINGXCOORD 31  /* FTEXT in Tree EDITTHING */
#define THINGYCOORD 32  /* FTEXT in Tree EDITTHING */

#define EDITLINEDEFS 13  /* Form/Dialog box */
#define LINELOWERUNPEG 3   /* BOX in Tree EDITLINEDEFS */
#define LINEIMPASSABLE 4   /* BOX in Tree EDITLINEDEFS */
#define LINEBLOCKMONST 5   /* BOX in Tree EDITLINEDEFS */
#define LINETWOSIDED 6   /* BOX in Tree EDITLINEDEFS */
#define LINEUPPERUNPEG 7   /* BOX in Tree EDITLINEDEFS */
#define LINEONMAP 8   /* BOX in Tree EDITLINEDEFS */
#define LINESECRET 9   /* BOX in Tree EDITLINEDEFS */
#define LINEBLOCKSSOUND 10  /* BOX in Tree EDITLINEDEFS */
#define LINENOTONMAP 11  /* BOX in Tree EDITLINEDEFS */
#define LINESPECUP 33  /* BOXCHAR in Tree EDITLINEDEFS */
#define LINESPECDOWN 34  /* BOXCHAR in Tree EDITLINEDEFS */
#define LINEMISC 37  /* BOX in Tree EDITLINEDEFS */
#define LINELIFTS 38  /* BOX in Tree EDITLINEDEFS */
#define LINECEILINGS 39  /* BOX in Tree EDITLINEDEFS */
#define LINEFLOORS 40  /* BOX in Tree EDITLINEDEFS */
#define LINESTAIRS 41  /* BOX in Tree EDITLINEDEFS */
#define LINELIGHT 42  /* BOX in Tree EDITLINEDEFS */
#define LINEDOORS 43  /* BOX in Tree EDITLINEDEFS */
#define LINEDIALOK 52  /* BUTTON in Tree EDITLINEDEFS */
#define LINEDIALCANCEL 53  /* BUTTON in Tree EDITLINEDEFS */
#define LINESTART 57  /* FTEXT in Tree EDITLINEDEFS */
#define LINEEND  58  /* FTEXT in Tree EDITLINEDEFS */
#define LINETAG  59  /* FTEXT in Tree EDITLINEDEFS */

#define TEXTURES 14  /* Form/Dialog box */
