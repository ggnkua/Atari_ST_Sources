	"FORMAT",	S_FORMAT,
	"LABEL",	S_LABEL,
	"LEFTSTRING",	S_LEFTSTRING,
	"RIGHTSTRING",	S_RIGHTSTRING,
	"GET",	S_GET,
	"PUT",	S_PUT,
	"MERGE",	S_MERGE,
	"LET",	S_LET,
	"WRITE",	S_WRITE,
	"TBL",	S_TBL,
	"PROGLET",	S_PROGLET,
	"COPY",	S_COPY,
	"SHOW",	S_SHOW,
