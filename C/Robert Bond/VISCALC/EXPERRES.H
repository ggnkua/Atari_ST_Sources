	"FIXED",	K_FIXED,
	"SUM",	K_SUM,
	"PROD",	K_PROD,
	"AVE",	K_AVE,
