/* resource set indicies for FSEARCH */

#define SFORM    0	/* form/dialog */
#define SDRIVEA  3	/* BOXCHAR in tree SFORM */
#define SDRIVEB  4	/* BOXCHAR in tree SFORM */
#define SDRIVEC  5	/* BOXCHAR in tree SFORM */
#define SDRIVED  6	/* BOXCHAR in tree SFORM */
#define SDRIVEE  7	/* BOXCHAR in tree SFORM */
#define SDRIVEF  8	/* BOXCHAR in tree SFORM */
#define SDRIVEG  9	/* BOXCHAR in tree SFORM */
#define SDRIVEH  10	/* BOXCHAR in tree SFORM */
#define SDRIVEJ  11	/* BOXCHAR in tree SFORM */
#define SDRIVEK  12	/* BOXCHAR in tree SFORM */
#define SDRIVEL  13	/* BOXCHAR in tree SFORM */
#define SDRIVEM  14	/* BOXCHAR in tree SFORM */
#define SDRIVEN  15	/* BOXCHAR in tree SFORM */
#define SDRIVEO  16	/* BOXCHAR in tree SFORM */
#define SDRIVEP  17	/* BOXCHAR in tree SFORM */
#define SDRIVEI  18	/* BOXCHAR in tree SFORM */
#define SFILE    19	/* FTEXT in tree SFORM */
#define SOK      23	/* BUTTON in tree SFORM */
#define SCANCEL  24	/* BUTTON in tree SFORM */
#define SALL     26	/* BUTTON in tree SFORM */
#define STOTALS  28	/* BUTTON in tree SFORM */
#define SBROWSE  30	/* BUTTON in tree SFORM */
#define SPRINT   31	/* BUTTON in tree SFORM */

#define FFORM    1	/* form/dialog */
#define FREADONL 3	/* BUTTON in tree FFORM */
#define FHIDDEN  4	/* BUTTON in tree FFORM */
#define FSYSTEM  5	/* BUTTON in tree FFORM */
#define FVOL     6	/* BUTTON in tree FFORM */
#define FDIR     7	/* BUTTON in tree FFORM */
#define FARCHIVE 8	/* BUTTON in tree FFORM */
#define FFILE    9	/* TEXT in tree FFORM */
#define FBYTES   10	/* TEXT in tree FFORM */
#define FDATE    11	/* TEXT in tree FFORM */
#define FTIME    12	/* TEXT in tree FFORM */
#define FMATCHES 17	/* TEXT in tree FFORM */
#define FSPEC    19	/* TEXT in tree FFORM */
#define FNEXT    20	/* BUTTON in tree FFORM */
#define FDONE    21	/* BUTTON in tree FFORM */
#define FANOTHER 22	/* BUTTON in tree FFORM */
#define FBROWSE  27	/* BUTTON in tree FFORM */
#define FRENAME  28	/* BUTTON in tree FFORM */
#define FCOPY    29	/* BUTTON in tree FFORM */
#define FDELETE  30	/* BUTTON in tree FFORM */
#define FMOVE    31	/* BUTTON in tree FFORM */
#define FPRINT   32	/* BUTTON in tree FFORM */

#define WFORM    2	/* form/dialog */

#define CFORM    3	/* form/dialog */
#define CT1      1	/* TEXT in tree CFORM */
#define CT2      2	/* TEXT in tree CFORM */
#define CSOURCE  3	/* FTEXT in tree CFORM */
#define CDEST    4	/* FTEXT in tree CFORM */
#define CTITLE   5	/* BOXTEXT in tree CFORM */
#define COK      6	/* BUTTON in tree CFORM */
#define CCANCEL  7	/* BUTTON in tree CFORM */

#define LFORM    4	/* form/dialog */
#define LBOX     2	/* BOX in tree LFORM */

