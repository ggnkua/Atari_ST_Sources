	.data
	.xref font8x8
font8x8:
; Zeichen -> $00
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $01
	.dc.b %00011000
	.dc.b %00100100
	.dc.b %01000010
	.dc.b %10000001
	.dc.b %11100111
	.dc.b %00100100
	.dc.b %00100100
	.dc.b %00111100
; Zeichen -> $02
	.dc.b %00111100
	.dc.b %00100100
	.dc.b %00100100
	.dc.b %11100111
	.dc.b %10000001
	.dc.b %01000010
	.dc.b %00100100
	.dc.b %00011000
; Zeichen -> $03
	.dc.b %00011000
	.dc.b %00010100
	.dc.b %11110010
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %11110010
	.dc.b %00010100
	.dc.b %00011000
; Zeichen -> $04
	.dc.b %00011000
	.dc.b %00101000
	.dc.b %01001111
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %01001111
	.dc.b %00101000
	.dc.b %00011000
; Zeichen -> $05
	.dc.b %11111111
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %11111111
; Zeichen -> $06
	.dc.b %11111000
	.dc.b %10001000
	.dc.b %10001111
	.dc.b %10001001
	.dc.b %11111001
	.dc.b %01000001
	.dc.b %01000001
	.dc.b %01111111
; Zeichen -> $07
	.dc.b %11111111
	.dc.b %10001001
	.dc.b %10001001
	.dc.b %10001001
	.dc.b %11111001
	.dc.b %10000001
	.dc.b %10000001
	.dc.b %11111111
; Zeichen -> $08
	.dc.b %00000001
	.dc.b %00000011
	.dc.b %00000110
	.dc.b %10001100
	.dc.b %11011000
	.dc.b %01110000
	.dc.b %00100000
	.dc.b %00000000
; Zeichen -> $09
	.dc.b %01111110
	.dc.b %11000011
	.dc.b %11010011
	.dc.b %11010011
	.dc.b %11011011
	.dc.b %11000011
	.dc.b %11000011
	.dc.b %01111110
; Zeichen -> $0A
	.dc.b %00011000
	.dc.b %00111100
	.dc.b %00101100
	.dc.b %00101100
	.dc.b %01111110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $0B
	.dc.b %00010000
	.dc.b %00011100
	.dc.b %00010010
	.dc.b %00010000
	.dc.b %00010000
	.dc.b %01110000
	.dc.b %11110000
	.dc.b %01100000
; Zeichen -> $0C
	.dc.b %11110000
	.dc.b %11000000
	.dc.b %11111110
	.dc.b %11011000
	.dc.b %11011110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $0D
	.dc.b %01110000
	.dc.b %11001000
	.dc.b %11011110
	.dc.b %11011011
	.dc.b %11011011
	.dc.b %01111110
	.dc.b %00011011
	.dc.b %00011011
; Zeichen -> $0E
	.dc.b %00000011
	.dc.b %00000000
	.dc.b %00001111
	.dc.b %00000011
	.dc.b %00000011
	.dc.b %00000011
	.dc.b %00000011
	.dc.b %00001111
; Zeichen -> $0F
	.dc.b %10010000
	.dc.b %00100000
	.dc.b %11010000
	.dc.b %10100000
	.dc.b %11010000
	.dc.b %10101000
	.dc.b %11010000
	.dc.b %11100000
; Zeichen -> $10
	.dc.b %01111100
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %00000000
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $11
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
; Zeichen -> $12
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %01111100
	.dc.b %11000000
	.dc.b %11000000
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $13
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $14
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
; Zeichen -> $15
	.dc.b %01111100
	.dc.b %11000000
	.dc.b %11000000
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $16
	.dc.b %01111100
	.dc.b %11000000
	.dc.b %11000000
	.dc.b %01111100
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $17
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
; Zeichen -> $18
	.dc.b %01111100
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %01111100
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $19
	.dc.b %01111100
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $1A
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01000110
	.dc.b %00000110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $1B
	.dc.b %01111000
	.dc.b %01100110
	.dc.b %01111101
	.dc.b %01100100
	.dc.b %01111110
	.dc.b %00000011
	.dc.b %00001011
	.dc.b %00000110
; Zeichen -> $1C
	.dc.b %00000111
	.dc.b %00001111
	.dc.b %00011111
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00010000
	.dc.b %00011110
	.dc.b %00010111
; Zeichen -> $1D
	.dc.b %11110000
	.dc.b %11111000
	.dc.b %11101100
	.dc.b %00000100
	.dc.b %00000100
	.dc.b %00000100
	.dc.b %00111100
	.dc.b %01010100
; Zeichen -> $1E
	.dc.b %00010001
	.dc.b %00001011
	.dc.b %00001101
	.dc.b %00000110
	.dc.b %00000111
	.dc.b %00101110
	.dc.b %00111001
	.dc.b %00111000
; Zeichen -> $1F
	.dc.b %11111100
	.dc.b %11111100
	.dc.b %11111111
	.dc.b %11100001
	.dc.b %11100001
	.dc.b %00100001
	.dc.b %00111111
	.dc.b %00000000
; Zeichen -> $20
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $21,'!'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $22,'"'
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01000100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $23,'#'
	.dc.b %00000000
	.dc.b %00100100
	.dc.b %01111110
	.dc.b %00100100
	.dc.b %00100100
	.dc.b %01111110
	.dc.b %00100100
	.dc.b %00000000
; Zeichen -> $24,'$'
	.dc.b %00010100
	.dc.b %00111110
	.dc.b %01010101
	.dc.b %00111100
	.dc.b %00011110
	.dc.b %01010101
	.dc.b %00111110
	.dc.b %00010100
; Zeichen -> $25,'%'
	.dc.b %01100010
	.dc.b %01100110
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %01100110
	.dc.b %01000110
	.dc.b %00000000
; Zeichen -> $26,'&'
	.dc.b %01111000
	.dc.b %11001100
	.dc.b %01100001
	.dc.b %11001110
	.dc.b %11001100
	.dc.b %11001100
	.dc.b %01111000
	.dc.b %00000000
; Zeichen -> $27,'''
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00010000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $28,'('
	.dc.b %00000100
	.dc.b %00001000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00001000
	.dc.b %00000100
; Zeichen -> $29,')'
	.dc.b %00100000
	.dc.b %00010000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00010000
	.dc.b %00100000
; Zeichen -> $2A,'*'
	.dc.b %00000000
	.dc.b %01010100
	.dc.b %00111000
	.dc.b %11111110
	.dc.b %00111000
	.dc.b %01010100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $2B,'+'
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %01111110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $2C,','
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00110000
	.dc.b %00110000
	.dc.b %00100000
; Zeichen -> $2D,'-'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $2E,'.'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $2F,'/'
	.dc.b %00000011
	.dc.b %00000110
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %01100000
	.dc.b %11000000
	.dc.b %00000000
; Zeichen -> $30,'0'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01101110
	.dc.b %01110110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $31,'1'
	.dc.b %00011000
	.dc.b %00111000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $32,'2'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %00001110
	.dc.b %00011100
	.dc.b %00111000
	.dc.b %01110000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $33,'3'
	.dc.b %01111110
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00111100
	.dc.b %00000110
	.dc.b %01000110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $34,'4'
	.dc.b %00001100
	.dc.b %00011100
	.dc.b %00101100
	.dc.b %01001100
	.dc.b %01111110
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
; Zeichen -> $35,'5'
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %01000110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $36,'6'
	.dc.b %00011100
	.dc.b %00100000
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $37,'7'
	.dc.b %01111110
	.dc.b %00000110
	.dc.b %00001110
	.dc.b %00011100
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $38,'8'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $39,'9'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000110
	.dc.b %00001100
	.dc.b %00111000
	.dc.b %00000000
; Zeichen -> $3A,':'
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $3B,';'
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00010000
	.dc.b %00000000
; Zeichen -> $3C,'<'
	.dc.b %00000110
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00000110
	.dc.b %00000000
; Zeichen -> $3D,'='
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $3E,'>'
	.dc.b %01100000
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %01100000
	.dc.b %00000000
; Zeichen -> $3F,'?'
	.dc.b %00111100
	.dc.b %01000110
	.dc.b %00000110
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00011000
; Zeichen -> $40,'@'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01101110
	.dc.b %01101010
	.dc.b %01101110
	.dc.b %01100000
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $41,'A'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $42,'B'
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $43,'C'
	.dc.b %00111100
	.dc.b %01100010
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100010
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $44,'D'
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $45,'E'
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $46,'F'
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %00000000
; Zeichen -> $47,'G'
	.dc.b %00111100
	.dc.b %01100010
	.dc.b %01100000
	.dc.b %01101110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $48,'H'
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $49,'I'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $4A,'J'
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %01000110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $4B,'K'
	.dc.b %01100110
	.dc.b %01101100
	.dc.b %01111000
	.dc.b %01110000
	.dc.b %01111000
	.dc.b %01101100
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $4C,'L'
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $4D,'M'
	.dc.b %11111100
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %00000000
; Zeichen -> $4E,'N'
	.dc.b %01100010
	.dc.b %01110010
	.dc.b %01111010
	.dc.b %01011110
	.dc.b %01001110
	.dc.b %01000110
	.dc.b %01000010
	.dc.b %00000000
; Zeichen -> $4F,'O'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $50,'P'
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %00000000
; Zeichen -> $51,'Q'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000110
; Zeichen -> $52,'R'
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $53,'S'
	.dc.b %00111100
	.dc.b %01100010
	.dc.b %01110000
	.dc.b %00111100
	.dc.b %00001110
	.dc.b %01000110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $54,'T'
	.dc.b %01111110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $55,'U'
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $56,'V'
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100100
	.dc.b %01111000
	.dc.b %00000000
; Zeichen -> $57,'W'
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11111100
	.dc.b %00000000
; Zeichen -> $58,'X'
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $59,'Y'
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $5A,'Z'
	.dc.b %01111110
	.dc.b %00001110
	.dc.b %00011100
	.dc.b %00111000
	.dc.b %01110000
	.dc.b %01100000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $5B,'['
	.dc.b %00011110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011110
	.dc.b %00000000
; Zeichen -> $5C,'\'
	.dc.b %01000000
	.dc.b %01100000
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00000110
	.dc.b %00000010
	.dc.b %00000000
; Zeichen -> $5D,']'
	.dc.b %01111000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %01111000
	.dc.b %00000000
; Zeichen -> $5E,'^'
	.dc.b %00010000
	.dc.b %00111000
	.dc.b %01101100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $5F,'_'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $60,'`'
	.dc.b %00000000
	.dc.b %11000000
	.dc.b %11000000
	.dc.b %01100000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $61,'a'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01000110
	.dc.b %00111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $62,'b'
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %00000000
; Zeichen -> $63,'c'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100010
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100010
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $64,'d'
	.dc.b %00000110
	.dc.b %00111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $65,'e'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %01100010
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $66,'f'
	.dc.b %00011110
	.dc.b %00110000
	.dc.b %01111100
	.dc.b %00110000
	.dc.b %00110000
	.dc.b %00110000
	.dc.b %00110000
	.dc.b %00000000
; Zeichen -> $67,'g'
	.dc.b %00000000
	.dc.b %00111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %01000110
	.dc.b %00111100
; Zeichen -> $68,'h'
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $69,'i'
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $6A,'j'
	.dc.b %00000000
	.dc.b %00001000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %01011000
	.dc.b %00110000
; Zeichen -> $6B,'k'
	.dc.b %01100000
	.dc.b %01100100
	.dc.b %01101000
	.dc.b %01110000
	.dc.b %01111000
	.dc.b %01101100
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $6C,'l'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00000000
; Zeichen -> $6D,'m'
	.dc.b %00000000
	.dc.b %11111100
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11000110
	.dc.b %00000000
; Zeichen -> $6E,'n'
	.dc.b %00000000
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $6F,'o'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $70,'p'
	.dc.b %00000000
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %01100000
	.dc.b %01100000
; Zeichen -> $71,'q'
	.dc.b %00000000
	.dc.b %00111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000110
; Zeichen -> $72,'r'
	.dc.b %00000000
	.dc.b %01101100
	.dc.b %01110000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %00000000
; Zeichen -> $73,'s'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01110010
	.dc.b %00111000
	.dc.b %00011100
	.dc.b %01001110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $74,'t'
	.dc.b %00011000
	.dc.b %00111100
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00000000
; Zeichen -> $75,'u'
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $76,'v'
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100100
	.dc.b %01111000
	.dc.b %00000000
; Zeichen -> $77,'w'
	.dc.b %00000000
	.dc.b %11000110
	.dc.b %11000110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11111100
	.dc.b %00000000
; Zeichen -> $78,'x'
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $79,'y'
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00100110
	.dc.b %00011110
	.dc.b %01000110
	.dc.b %00111100
; Zeichen -> $7A,'z'
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00001110
	.dc.b %00011100
	.dc.b %00111000
	.dc.b %01110000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $7B,'{'
	.dc.b %00001110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00001110
	.dc.b %00000000
; Zeichen -> $7C,'|'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
; Zeichen -> $7D,'}'
	.dc.b %01110000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %01110000
	.dc.b %00000000
; Zeichen -> $7E,'~'
	.dc.b %00000000
	.dc.b %01100000
	.dc.b %11110010
	.dc.b %10011110
	.dc.b %00001100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $7F,''
	.dc.b %00010000
	.dc.b %00010000
	.dc.b %00101000
	.dc.b %00101000
	.dc.b %01000100
	.dc.b %01000100
	.dc.b %10000010
	.dc.b %11111110
; Zeichen -> $80,'€'
	.dc.b %00111100
	.dc.b %01100010
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100010
	.dc.b %00011100
	.dc.b %00110000
; Zeichen -> $81,'�'
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $82,'‚'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $83,'ƒ'
	.dc.b %00011000
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000110
	.dc.b %01111110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $84,'„'
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01000110
	.dc.b %00111110
	.dc.b %01000110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $85,'…'
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000110
	.dc.b %01111110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $86,'†'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000110
	.dc.b %01111110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $87,'‡'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100010
	.dc.b %01100000
	.dc.b %01100010
	.dc.b %00111100
	.dc.b %00001000
	.dc.b %00011000
; Zeichen -> $88,'ˆ'
	.dc.b %00011000
	.dc.b %00110100
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $89,'‰'
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $8A,'Š'
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $8B,'‹'
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $8C,'Œ'
	.dc.b %00011000
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $8D,'�'
	.dc.b %00010000
	.dc.b %00001000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $8E,'Ž'
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $8F,'�'
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $90,'�'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %01111100
	.dc.b %01100000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $91,'‘'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00011011
	.dc.b %01111111
	.dc.b %11011000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $92,'’'
	.dc.b %00111111
	.dc.b %01111000
	.dc.b %11011000
	.dc.b %11011110
	.dc.b %11111000
	.dc.b %11011000
	.dc.b %11011111
	.dc.b %00000000
; Zeichen -> $93,'“'
	.dc.b %00011000
	.dc.b %00110100
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $94,'”'
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $95,'•'
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $96,'–'
	.dc.b %00011000
	.dc.b %00100100
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $97,'—'
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $98,'˜'
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %01000110
	.dc.b %00111100
; Zeichen -> $99,'™'
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $9A,'š'
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $9B,'›'
	.dc.b %00011000
	.dc.b %00111100
	.dc.b %01100010
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100010
	.dc.b %00111100
	.dc.b %00011000
; Zeichen -> $9C,'œ'
	.dc.b %00011100
	.dc.b %00111010
	.dc.b %00110000
	.dc.b %01111100
	.dc.b %00110000
	.dc.b %00110000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $9D,'�'
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00011000
	.dc.b %00111100
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $9E,'ž'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01101100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %11101100
	.dc.b %00000000
; Zeichen -> $9F,'Ÿ'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
; Zeichen -> $A0,' '
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000110
	.dc.b %01111110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $A1,'¡'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $A2,'¢'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $A3,'£'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $A4,'¤'
	.dc.b %00110100
	.dc.b %01011000
	.dc.b %00000000
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $A5,'¥'
	.dc.b %00011010
	.dc.b %00101100
	.dc.b %01100010
	.dc.b %01110010
	.dc.b %01011010
	.dc.b %01001110
	.dc.b %01000110
	.dc.b %00000000
; Zeichen -> $A6,'¦'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01000110
	.dc.b %00111110
	.dc.b %01100110
	.dc.b %00111110
	.dc.b %00000000
	.dc.b %01111110
; Zeichen -> $A7,'§'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
	.dc.b %01111110
; Zeichen -> $A8,'¨'
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %01100000
	.dc.b %01100110
	.dc.b %00111100
; Zeichen -> $A9,'©'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00111110
	.dc.b %00110000
	.dc.b %00110000
	.dc.b %00110000
	.dc.b %00000000
; Zeichen -> $AA,'ª'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %01111100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
; Zeichen -> $AB,'«'
	.dc.b %01100010
	.dc.b %11100100
	.dc.b %01101000
	.dc.b %01110110
	.dc.b %00101011
	.dc.b %01000011
	.dc.b %10000110
	.dc.b %00001111
; Zeichen -> $AC,'¬'
	.dc.b %01100010
	.dc.b %11100100
	.dc.b %01101000
	.dc.b %01110110
	.dc.b %00101110
	.dc.b %01010110
	.dc.b %10011111
	.dc.b %00000110
; Zeichen -> $AD,'­'
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
; Zeichen -> $AE,'®'
	.dc.b %00011011
	.dc.b %00110110
	.dc.b %01101100
	.dc.b %11011000
	.dc.b %01101100
	.dc.b %00110110
	.dc.b %00011011
	.dc.b %00000000
; Zeichen -> $AF,'¯'
	.dc.b %11011000
	.dc.b %01101100
	.dc.b %00110110
	.dc.b %00011011
	.dc.b %00110110
	.dc.b %01101100
	.dc.b %11011000
	.dc.b %00000000
; Zeichen -> $B0,'°'
	.dc.b %00110100
	.dc.b %01011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00000110
	.dc.b %01111110
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $B1,'±'
	.dc.b %00110100
	.dc.b %01011000
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $B2,'²'
	.dc.b %00000010
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01101110
	.dc.b %01110110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %01000000
; Zeichen -> $B3,'³'
	.dc.b %00000000
	.dc.b %00000010
	.dc.b %00111100
	.dc.b %01101110
	.dc.b %01110110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %01000000
; Zeichen -> $B4,'´'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %11011011
	.dc.b %11011110
	.dc.b %11011000
	.dc.b %01111111
	.dc.b %00000000
; Zeichen -> $B5,'µ'
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %11011000
	.dc.b %11011000
	.dc.b %11111100
	.dc.b %11011000
	.dc.b %11011000
	.dc.b %11011110
; Zeichen -> $B6,'¶'
	.dc.b %00100000
	.dc.b %00010000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01100110
; Zeichen -> $B7,'·'
	.dc.b %00110100
	.dc.b %01011000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01100110
; Zeichen -> $B8,'¸'
	.dc.b %00110100
	.dc.b %01011000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
; Zeichen -> $B9,'¹'
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $BA,'º'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $BB,'»'
	.dc.b %00000000
	.dc.b %00010000
	.dc.b %00111000
	.dc.b %00010000
	.dc.b %00010000
	.dc.b %00010000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $BC,'¼'
	.dc.b %01111010
	.dc.b %11001010
	.dc.b %11001010
	.dc.b %11001010
	.dc.b %01111010
	.dc.b %00001010
	.dc.b %00001010
	.dc.b %00001010
; Zeichen -> $BD,'½'
	.dc.b %00111100
	.dc.b %01000010
	.dc.b %10011001
	.dc.b %10110101
	.dc.b %10110001
	.dc.b %10011101
	.dc.b %01000010
	.dc.b %00111100
; Zeichen -> $BE,'¾'
	.dc.b %00111100
	.dc.b %01000010
	.dc.b %10111001
	.dc.b %10110101
	.dc.b %10111001
	.dc.b %10110101
	.dc.b %01000010
	.dc.b %00111100
; Zeichen -> $BF,'¿'
	.dc.b %11110001
	.dc.b %01011011
	.dc.b %01010101
	.dc.b %01010001
	.dc.b %01010001
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C0,'À'
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %11100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %11110110
	.dc.b %00000110
	.dc.b %00011100
; Zeichen -> $C1,'Á'
	.dc.b %11110110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %11110110
	.dc.b %00000110
	.dc.b %00011100
; Zeichen -> $C2,'Â'
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01110110
	.dc.b %00111100
	.dc.b %01101110
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C3,'Ã'
	.dc.b %00000000
	.dc.b %01111100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C4,'Ä'
	.dc.b %00000000
	.dc.b %00011110
	.dc.b %00000110
	.dc.b %00001110
	.dc.b %00011110
	.dc.b %00110110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C5,'Å'
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C6,'Æ'
	.dc.b %00000000
	.dc.b %01111100
	.dc.b %00000110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C7,'Ç'
	.dc.b %00000000
	.dc.b %00011100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C8,'È'
	.dc.b %00000000
	.dc.b %00011110
	.dc.b %00001100
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $C9,'É'
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $CA,'Ê'
	.dc.b %01100000
	.dc.b %01101110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $CB,'Ë'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $CC,'Ì'
	.dc.b %00000000
	.dc.b %00111110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $CD,'Í'
	.dc.b %01100000
	.dc.b %01111110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00001110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $CE,'Î'
	.dc.b %00000000
	.dc.b %01101100
	.dc.b %00111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01101110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $CF,'Ï'
	.dc.b %00000000
	.dc.b %00011100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00111100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D0,'Ð'
	.dc.b %00000000
	.dc.b %00111110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00011100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D1,'Ñ'
	.dc.b %00000000
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D2,'Ò'
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01110110
	.dc.b %00000110
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D3,'Ó'
	.dc.b %00000000
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00001110
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D4,'Ô'
	.dc.b %00000000
	.dc.b %00111110
	.dc.b %00000110
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00110100
	.dc.b %00110000
	.dc.b %00000000
; Zeichen -> $D5,'Õ'
	.dc.b %00000000
	.dc.b %01111000
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D6,'Ö'
	.dc.b %00000000
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D7,'×'
	.dc.b %00000000
	.dc.b %01111100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %11101100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $D8,'Ø'
	.dc.b %00000000
	.dc.b %00011100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
; Zeichen -> $D9,'Ù'
	.dc.b %00000000
	.dc.b %00111110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
; Zeichen -> $DA,'Ú'
	.dc.b %00000000
	.dc.b %11111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $DB,'Û'
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01110110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000110
	.dc.b %00000000
; Zeichen -> $DC,'Ü'
	.dc.b %00000000
	.dc.b %00110110
	.dc.b %00110110
	.dc.b %00011100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00001100
	.dc.b %00000000
; Zeichen -> $DD,'Ý'
	.dc.b %00011100
	.dc.b %00110010
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %01001100
	.dc.b %00111000
; Zeichen -> $DE,'Þ'
	.dc.b %00000000
	.dc.b %00010000
	.dc.b %00111000
	.dc.b %01101100
	.dc.b %11000110
	.dc.b %10000010
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $DF,'ß'
	.dc.b %01100110
	.dc.b %11110111
	.dc.b %10011001
	.dc.b %10011001
	.dc.b %11101111
	.dc.b %01100110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $E0,'à'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %01110110
	.dc.b %11011100
	.dc.b %11001000
	.dc.b %11011100
	.dc.b %01110110
	.dc.b %00000000
; Zeichen -> $E1,'á'
	.dc.b %00011100
	.dc.b %00110110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01111100
	.dc.b %01100000
; Zeichen -> $E2,'â'
	.dc.b %00000000
	.dc.b %11111110
	.dc.b %01100110
	.dc.b %01100010
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %01100000
	.dc.b %11111000
; Zeichen -> $E3,'ã'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %11111110
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01001000
; Zeichen -> $E4,'ä'
	.dc.b %11111110
	.dc.b %01100110
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %01100110
	.dc.b %11111110
	.dc.b %00000000
; Zeichen -> $E5,'å'
	.dc.b %00000000
	.dc.b %00011110
	.dc.b %00111000
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %00111000
	.dc.b %00000000
; Zeichen -> $E6,'æ'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01111111
	.dc.b %11000000
; Zeichen -> $E7,'ç'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00010000
; Zeichen -> $E8,'è'
	.dc.b %00111100
	.dc.b %00011000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00011000
	.dc.b %00111100
; Zeichen -> $E9,'é'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01111110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00111100
	.dc.b %00000000
; Zeichen -> $EA,'ê'
	.dc.b %00000000
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00100100
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $EB,'ë'
	.dc.b %00011100
	.dc.b %00110110
	.dc.b %01111000
	.dc.b %11011100
	.dc.b %11001100
	.dc.b %11101100
	.dc.b %01111000
	.dc.b %00000000
; Zeichen -> $EC,'ì'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00111000
	.dc.b %01010100
	.dc.b %01010100
	.dc.b %00111000
	.dc.b %00110000
	.dc.b %01100000
; Zeichen -> $ED,'í'
	.dc.b %00000000
	.dc.b %00010000
	.dc.b %01111100
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %11010110
	.dc.b %01111100
	.dc.b %00010000
; Zeichen -> $EE,'î'
	.dc.b %00111110
	.dc.b %01110000
	.dc.b %01100000
	.dc.b %01111110
	.dc.b %01100000
	.dc.b %01110000
	.dc.b %00111110
	.dc.b %00000000
; Zeichen -> $EF,'ï'
	.dc.b %00111100
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %01100110
	.dc.b %00000000
; Zeichen -> $F0,'ð'
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $F1,'ñ'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %01111110
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $F2,'ò'
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $F3,'ó'
	.dc.b %00001100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %00011000
	.dc.b %00001100
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
; Zeichen -> $F4,'ô'
	.dc.b %00000000
	.dc.b %00001110
	.dc.b %00011011
	.dc.b %00011011
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
; Zeichen -> $F5,'õ'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %11011000
	.dc.b %11011000
	.dc.b %01110000
	.dc.b %00000000
; Zeichen -> $F6,'ö'
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %01111110
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
; Zeichen -> $F7,'÷'
	.dc.b %00000000
	.dc.b %00110010
	.dc.b %01001100
	.dc.b %00000000
	.dc.b %00110010
	.dc.b %01001100
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $F8,'ø'
	.dc.b %00111000
	.dc.b %01101100
	.dc.b %00111000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $F9,'ù'
	.dc.b %00111000
	.dc.b %01111100
	.dc.b %00111000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $FA,'ú'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00011000
	.dc.b %00011000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $FB,'û'
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00001111
	.dc.b %00011000
	.dc.b %11011000
	.dc.b %01110000
	.dc.b %00110000
	.dc.b %00000000
; Zeichen -> $FC,'ü'
	.dc.b %00111000
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %01101100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $FD,'ý'
	.dc.b %00111000
	.dc.b %01101100
	.dc.b %00011000
	.dc.b %00110000
	.dc.b %01111100
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $FE,'þ'
	.dc.b %01111000
	.dc.b %00001100
	.dc.b %00111000
	.dc.b %00001100
	.dc.b %01111000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
; Zeichen -> $FF,'ÿ'
	.dc.b %00000000
	.dc.b %11111110
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
	.dc.b %00000000
