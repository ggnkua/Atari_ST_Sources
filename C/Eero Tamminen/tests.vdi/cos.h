/*
 * header with array or pre-generated fraction values
 * for cos values, indexed by decimal degree.
 * 
 * pre-generation done with 'angles.py' python script.
 */
typedef struct {
	short numerator;
	short denominator;
} fraction_t;

fraction_t cos_lookup[360] = {
	{      1,      1 },
	{  26259,  26263 },
	{  11484,  11491 },
	{  20403,  20431 },
	{  11876,  11905 },
	{  23823,  23914 },
	{  28321,  28477 },
	{  14248,  14355 },
	{  28186,  28463 },
	{  22222,  22499 },
	{  15752,  15995 },
	{  22707,  23132 },
	{  12578,  12859 },
	{   9010,   9247 },
	{  14732,  15183 },
	{  14429,  14938 },
	{  25782,  26821 },
	{   8623,   9017 },
	{  14943,  15712 },
	{  13693,  14482 },
	{  25741,  27393 },
	{  28463,  30488 },
	{  29401,  31710 },
	{  23703,  25750 },
	{  23342,  25551 },
	{   4411,   4867 },
	{  28694,  31925 },
	{  19121,  21460 },
	{   3319,   3759 },
	{  24436,  27939 },
	{  18817,  21728 },
	{  20038,  23377 },
	{  10297,  12142 },
	{  20061,  23920 },
	{  15600,  18817 },
	{  25252,  30827 },
	{  23184,  28657 },
	{  19549,  24478 },
	{  14657,  18600 },
	{  21457,  27610 },
	{   4309,   5625 },
	{   1923,   2548 },
	{  15204,  20459 },
	{  13620,  18623 },
	{  19133,  26598 },
	{  19601,  27720 },
	{  11275,  16231 },
	{   9979,  14632 },
	{  13669,  20428 },
	{  14493,  22091 },
	{  14527,  22600 },
	{   3241,   5150 },
	{  18303,  29729 },
	{  15584,  25895 },
	{   4456,   7581 },
	{  18655,  32524 },
	{  16074,  28745 },
	{  17789,  32662 },
	{   6695,  12634 },
	{  16097,  31254 },
	{      1,      2 },
	{   6048,  12475 },
	{   6059,  12906 },
	{  13089,  28831 },
	{  14027,  31998 },
	{   9604,  22725 },
	{   9455,  23246 },
	{    978,   2503 },
	{   4523,  12074 },
	{   5349,  14926 },
	{   9305,  27206 },
	{   6862,  21077 },
	{   5473,  17711 },
	{   1054,   3605 },
	{   6260,  22711 },
	{   7469,  28858 },
	{   7180,  29679 },
	{   6549,  29113 },
	{    226,   1087 },
	{   4887,  25612 },
	{   2993,  17236 },
	{   4956,  31681 },
	{   3659,  26291 },
	{   3703,  30385 },
	{   2209,  21133 },
	{   1807,  20733 },
	{   1627,  23324 },
	{    792,  15133 },
	{   1106,  31691 },
	{    529,  30311 },
	{      0,      1 },
	{   -529,  30311 },
	{  -1106,  31691 },
	{   -792,  15133 },
	{  -1627,  23324 },
	{  -1807,  20733 },
	{  -2209,  21133 },
	{  -3703,  30385 },
	{  -3659,  26291 },
	{  -4956,  31681 },
	{  -2993,  17236 },
	{  -4887,  25612 },
	{   -226,   1087 },
	{  -6549,  29113 },
	{  -7180,  29679 },
	{  -7469,  28858 },
	{  -6260,  22711 },
	{  -1054,   3605 },
	{  -5473,  17711 },
	{  -6862,  21077 },
	{  -9305,  27206 },
	{  -5349,  14926 },
	{  -4523,  12074 },
	{   -978,   2503 },
	{  -9455,  23246 },
	{  -9604,  22725 },
	{ -14027,  31998 },
	{ -13089,  28831 },
	{  -6059,  12906 },
	{  -6048,  12475 },
	{     -1,      2 },
	{ -16097,  31254 },
	{  -6695,  12634 },
	{ -17789,  32662 },
	{ -16074,  28745 },
	{ -18655,  32524 },
	{  -4456,   7581 },
	{ -15584,  25895 },
	{ -18303,  29729 },
	{  -3241,   5150 },
	{ -14527,  22600 },
	{ -14493,  22091 },
	{ -13669,  20428 },
	{  -9979,  14632 },
	{ -11275,  16231 },
	{ -13860,  19601 },
	{ -19133,  26598 },
	{ -13620,  18623 },
	{ -15204,  20459 },
	{  -1923,   2548 },
	{  -4309,   5625 },
	{ -21457,  27610 },
	{ -14657,  18600 },
	{ -19549,  24478 },
	{ -23184,  28657 },
	{ -25252,  30827 },
	{ -15600,  18817 },
	{ -20061,  23920 },
	{ -10297,  12142 },
	{ -20038,  23377 },
	{ -18817,  21728 },
	{ -24436,  27939 },
	{  -3319,   3759 },
	{ -19121,  21460 },
	{ -28694,  31925 },
	{  -4411,   4867 },
	{ -23342,  25551 },
	{ -23703,  25750 },
	{ -29401,  31710 },
	{ -28463,  30488 },
	{ -25741,  27393 },
	{ -13693,  14482 },
	{ -14943,  15712 },
	{  -8623,   9017 },
	{ -25782,  26821 },
	{ -14429,  14938 },
	{ -14732,  15183 },
	{  -9010,   9247 },
	{ -12578,  12859 },
	{ -22707,  23132 },
	{ -15752,  15995 },
	{ -22222,  22499 },
	{ -28186,  28463 },
	{ -14248,  14355 },
	{ -28321,  28477 },
	{ -23823,  23914 },
	{ -11876,  11905 },
	{ -20403,  20431 },
	{ -11484,  11491 },
	{ -26259,  26263 },
	{     -1,      1 },
	{ -26259,  26263 },
	{ -11484,  11491 },
	{ -20403,  20431 },
	{ -11876,  11905 },
	{ -23823,  23914 },
	{ -28321,  28477 },
	{ -14248,  14355 },
	{ -28186,  28463 },
	{ -22222,  22499 },
	{ -15752,  15995 },
	{ -22707,  23132 },
	{ -12578,  12859 },
	{  -9010,   9247 },
	{ -14732,  15183 },
	{ -14429,  14938 },
	{ -25782,  26821 },
	{  -8623,   9017 },
	{ -14943,  15712 },
	{ -13693,  14482 },
	{ -25741,  27393 },
	{ -28463,  30488 },
	{ -29401,  31710 },
	{ -23703,  25750 },
	{ -23342,  25551 },
	{  -4411,   4867 },
	{ -28694,  31925 },
	{ -19121,  21460 },
	{  -3319,   3759 },
	{ -24436,  27939 },
	{ -16296,  18817 },
	{ -20038,  23377 },
	{ -10297,  12142 },
	{ -20061,  23920 },
	{ -15600,  18817 },
	{ -25252,  30827 },
	{ -23184,  28657 },
	{ -19549,  24478 },
	{ -14657,  18600 },
	{ -21457,  27610 },
	{  -4309,   5625 },
	{  -1923,   2548 },
	{ -15204,  20459 },
	{ -13620,  18623 },
	{ -19133,  26598 },
	{ -19601,  27720 },
	{ -11275,  16231 },
	{  -9979,  14632 },
	{ -13669,  20428 },
	{ -14493,  22091 },
	{ -14527,  22600 },
	{  -3241,   5150 },
	{ -18303,  29729 },
	{ -15584,  25895 },
	{  -4456,   7581 },
	{ -18655,  32524 },
	{ -16074,  28745 },
	{ -17789,  32662 },
	{  -6695,  12634 },
	{ -16097,  31254 },
	{     -1,      2 },
	{  -6048,  12475 },
	{  -6059,  12906 },
	{ -13089,  28831 },
	{ -14027,  31998 },
	{  -9604,  22725 },
	{  -9455,  23246 },
	{   -978,   2503 },
	{  -4523,  12074 },
	{  -5349,  14926 },
	{  -9305,  27206 },
	{  -6862,  21077 },
	{  -5473,  17711 },
	{  -1054,   3605 },
	{  -6260,  22711 },
	{  -7469,  28858 },
	{  -7180,  29679 },
	{  -6549,  29113 },
	{   -226,   1087 },
	{  -4887,  25612 },
	{  -2993,  17236 },
	{  -4956,  31681 },
	{  -3659,  26291 },
	{  -3703,  30385 },
	{  -2209,  21133 },
	{  -1807,  20733 },
	{  -1627,  23324 },
	{   -792,  15133 },
	{  -1106,  31691 },
	{   -529,  30311 },
	{      0,      1 },
	{    529,  30311 },
	{   1106,  31691 },
	{    792,  15133 },
	{   1627,  23324 },
	{   1807,  20733 },
	{   2209,  21133 },
	{   3703,  30385 },
	{   3659,  26291 },
	{   4956,  31681 },
	{   2993,  17236 },
	{   4887,  25612 },
	{    226,   1087 },
	{   6549,  29113 },
	{   7180,  29679 },
	{   7469,  28858 },
	{   6260,  22711 },
	{   1054,   3605 },
	{   5473,  17711 },
	{   6862,  21077 },
	{   9305,  27206 },
	{   5349,  14926 },
	{   4523,  12074 },
	{    978,   2503 },
	{   9455,  23246 },
	{   9604,  22725 },
	{  14027,  31998 },
	{  13089,  28831 },
	{   6059,  12906 },
	{   6048,  12475 },
	{      1,      2 },
	{  16097,  31254 },
	{   6695,  12634 },
	{  17789,  32662 },
	{  16074,  28745 },
	{  18655,  32524 },
	{   4456,   7581 },
	{  15584,  25895 },
	{  18303,  29729 },
	{   3241,   5150 },
	{  14527,  22600 },
	{  14493,  22091 },
	{  13669,  20428 },
	{   9979,  14632 },
	{  11275,  16231 },
	{  13860,  19601 },
	{  19133,  26598 },
	{  13620,  18623 },
	{  15204,  20459 },
	{   1923,   2548 },
	{   4309,   5625 },
	{  21457,  27610 },
	{  14657,  18600 },
	{  19549,  24478 },
	{  23184,  28657 },
	{  25252,  30827 },
	{  15600,  18817 },
	{  20061,  23920 },
	{  10297,  12142 },
	{  20038,  23377 },
	{  16296,  18817 },
	{  24436,  27939 },
	{   3319,   3759 },
	{  19121,  21460 },
	{  28694,  31925 },
	{   4411,   4867 },
	{  23342,  25551 },
	{  23703,  25750 },
	{  29401,  31710 },
	{  28463,  30488 },
	{  25741,  27393 },
	{  13693,  14482 },
	{  14943,  15712 },
	{   8623,   9017 },
	{  25782,  26821 },
	{  14429,  14938 },
	{  14732,  15183 },
	{   9010,   9247 },
	{  12578,  12859 },
	{  22707,  23132 },
	{  15752,  15995 },
	{  22222,  22499 },
	{  28186,  28463 },
	{  14248,  14355 },
	{  28321,  28477 },
	{  23823,  23914 },
	{  11876,  11905 },
	{  20403,  20431 },
	{  11484,  11491 },
	{  26259,  26263 },
};

