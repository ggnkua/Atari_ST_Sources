/* 
 * PUNSSi (C) 1995, 1997 by Eero Tamminen
 */

/* device numbers (array indeces) */
#define DEVICE_0	0
#define DEVICE_1	1

/* Control device (joystick) directions */
#define jUP		1
#define jDOWN		2
#define jLEFT		4
#define jRIGHT		8
#define jBUTTON		128

/* additional flag for exit */
#define jEXIT		16

/* flags 32 and 64 still left... */
