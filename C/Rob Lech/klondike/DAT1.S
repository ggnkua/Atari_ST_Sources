* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *
*									*
*			S O L I T A I R E   D A T A			*
*                                                                       *
*                               by Rob Lech                             *
*	               (C) 1988, Antic Publishing, Inc.                 *
*									*
* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *

GLOBL	_menu_desc,_gem_pix,_sol_pal,_SCREEN,_tmfdb,_bmfdb,_cmfdb
GLOBL	_ltl_usuit,_ltl_dsuit,_big_usuit,_big_dsuit,_uval,_dval,_button
GLOBL	_pattern,_sx,_sy,_c_color
GLOBL	_bx,_by,_backs

_menu_desc:	DC.B	'KLONDIKE '
		DC.B	0

*-------------------- GEM PIXEL TRANSLATION ARRAY -------------------*

_gem_pix:	DC.W	$00,$0F,$01,$02,$04,$06,$03,$05
		DC.W	$07,$08,$09,$0A,$0C,$0E,$0B,$0D

*------------------------- SOLITAIRE PALETTE ------------------------*

_sol_pal:	DC.W	$0131;		/* 0 / 0 = DARK GREEN	*/
		DC.W	$0666;		/* 1 / 2 = WHITE	*/
		DC.W	$0000;		/* 2 / 3 = BLACK	*/
		DC.W	$0400;		/* 3 / 6 = RED		*/
		DC.W	$0003;		/* 4 / 4 = BLUE		*/
		DC.W	$0210;		/* 5 / 7 = DARK BROWN	*/
		DC.W	$0432;		/* 6 / 5 = LIGHT BROWN	*/
		DC.W	$0337;		/* 7 / 8 = LIGHT BLUE	*/
		DC.W	$0444;		/* 8 / 9 = MED GRAY	*/
		DC.W	$0555;		/* 9 / A = LIGHT GRAY	*/
		DC.W	$0754;		/* A / B = FLESH PINK	*/
		DC.W	$0420;		/* B / E = DARK ORANGE	*/
		DC.W	$0640;		/* C / C = LIGHT ORANGE	*/
		DC.W	$0536;		/* D / F = LIGHT PURPLE */
		DC.W	$0425;		/* E / D = MID PURPLE	*/
		DC.W	$0203;		/* F / 1 = DARK PURPLE	*/

*-------------------- SCREEN MEMORY DEFINITION BLOCK --------------------*

_SCREEN:	DC.L	0		; MEMORY POINTER
		DC.W	320		; WIDTH IN PIXELS
		DC.W	200		; HEIGHT IN PIXELS
		DC.W	20		; WIDTH IN WORDS
		DC.W	1		; FOR FORMAT FLAG
		DC.W	4		; NUMBER OF MEMORY PLANES
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE

*-------------------- SCREEN MEMORY DEFINITION BLOCK --------------------*

_tmfdb:		DC.L	0		; MEMORY POINTER
		DC.W	16		; WIDTH IN PIXELS
		DC.W	7		; HEIGHT IN PIXELS
		DC.W	1		; WIDTH IN WORDS
		DC.W	1		; FOR FORMAT FLAG
		DC.W	1		; NUMBER OF MEMORY PLANES
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE

*-------------------- SCREEN MEMORY DEFINITION BLOCK --------------------*

_bmfdb:		DC.L	0		; MEMORY POINTER
		DC.W	33		; WIDTH IN PIXELS
		DC.W	150		; HEIGHT IN PIXELS
		DC.W	3		; WIDTH IN WORDS
		DC.W	1		; FORM FORMAT FLAG
		DC.W	4		; NUMBER OF MEMORY PLANES
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE

*-------------------- SCREEN MEMORY DEFINITION BLOCK --------------------*

_cmfdb:		DC.L	0		; MEMORY POINTER
		DC.W	27		; WIDTH IN PIXELS
		DC.W	31		; HEIGHT IN PIXELS
		DC.W	2		; WIDTH IN WORDS
		DC.W	1		; FORM FORMAT FLAG
		DC.W	4		; NUMBER OF MEMORY PLANES
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE
		DC.W	0		; RESERVED FOR FUTURE USE

*---------------------- BUTTON GRAPHICS ADDRESS ARRAYS ----------------------*

_button:	DC.L	GAME
		DC.L	EXIT

_bx:		DC.W	86
		DC.W	123

_by:		DC.W	161
		DC.W	183

* 3 by 15 words
GAME:
DC.L	$7FFF7FFF,$00007FFF,$FFFFFFFF,$0000FFFF,$00000000,$00000000
DC.L	$3FFF3FFF,$8000BFFF,$FFFEFFFE,$0000FFFE,$80008000,$00008000
DC.L	$00001FFF,$E000E000,$0003FFFF,$00000003,$80008000,$00008000
DC.L	$00003FFF,$C000C000,$0001FFFF,$00000001,$80008000,$00008000
DC.L	$00003C71,$C000C38E,$0001BA0F,$000045F1,$80008000,$00008000
DC.L	$00003BAE,$C000C451,$0001BAFF,$00004501,$80008000,$00008000
DC.L	$00003BEE,$C000C411,$000192FF,$00006D01,$80008000,$00008000
DC.L	$00003B20,$C000C4DF,$0001AA3F,$000055C1,$80008000,$00008000
DC.L	$00003BAE,$C000C451,$0001BAFF,$00004501,$80008000,$00008000
DC.L	$00003BAE,$C000C451,$0001BAFF,$00004501,$80008000,$00008000
DC.L	$00003C2E,$C000C3D1,$0001BA0F,$000045F1,$80008000,$00008000
DC.L	$00003FFF,$C000C000,$0001FFFF,$00000001,$80008000,$00008000
DC.L	$00001FFF,$E000E000,$0003FFFF,$00000003,$80008000,$00008000
DC.L	$00000000,$BFFFBFFF,$00000000,$FFFEFFFE,$80008000,$00008000
DC.L	$00000000,$7FFF7FFF,$00000000,$FFFFFFFF,$00000000,$00000000
* 3 by 15 words
EXIT:
DC.L	$7FFF7FFF,$00007FFF,$FFFFFFFF,$0000FFFF,$00000000,$00000000
DC.L	$3FFF3FFF,$8000BFFF,$FFFEFFFE,$0000FFFE,$80008000,$00008000
DC.L	$00001FFF,$E000E000,$0003FFFF,$00000003,$80008000,$00008000
DC.L	$00003FFF,$C000C000,$0001FFFF,$00000001,$80008000,$00008000
DC.L	$0000382E,$C000C7D1,$0001820F,$00007DF1,$80008000,$00008000
DC.L	$00003BEE,$C000C411,$0001EFBF,$00001041,$80008000,$00008000
DC.L	$00003BF5,$C000C40A,$0001EFBF,$00001041,$80008000,$00008000
DC.L	$000038FB,$C000C704,$0001EFBF,$00001041,$80008000,$00008000
DC.L	$00003BF5,$C000C40A,$0001EFBF,$00001041,$80008000,$00008000
DC.L	$00003BEE,$C000C411,$0001EFBF,$00001041,$80008000,$00008000
DC.L	$0000382E,$C000C7D1,$000183BF,$00007C41,$80008000,$00008000
DC.L	$00003FFF,$C000C000,$0001FFFF,$00000001,$80008000,$00008000
DC.L	$00001FFF,$E000E000,$0003FFFF,$00000003,$80008000,$00008000
DC.L	$00000000,$BFFFBFFF,$00000000,$FFFEFFFE,$80008000,$00008000
DC.L	$00000000,$7FFF7FFF,$00000000,$FFFFFFFF,$00000000,$00000000

* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *
*									*
*		   REQUIRED DATA FOR DRAW_CARD(X,Y,C)			*
*									*
* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *

*---------------------------- SUIT COLORS ----------------------------*

_c_color:	DC.W	6,3,6,3

_backs:		DC.L	JACK
		DC.L	QUEEN
		DC.L	KING
		DC.L	BACK

*------------------------ LITTLE SUIT ADDRESS ARRAYS ------------------------*

_ltl_usuit:	DC.L	H1U		; HEARTS
		DC.L	C1U		; CLUBS
		DC.L	D1U		; DIAMONDS
		DC.L	S1U		; SPADES

_ltl_dsuit:	DC.L	H1D		; HEARTS
		DC.L	C1D		; CLUBS
		DC.L	D1U		; DIAMONDS
		DC.L	S1D		; SPADES

*-------------------------- BIG SUIT ADDRESS ARRAYS -------------------------*

_big_usuit:	DC.L	H2U		; HEARTS
		DC.L	C2U		; CLUBS
		DC.L	D2U		; DIAMONDS
		DC.L	S2U		; SPADES

_big_dsuit:	DC.L	H2D		; HEARTS
		DC.L	C2D		; CLUBS
		DC.L	D2U		; DIAMONDS
		DC.L	S2D		; SPADES

*---------------------- GRAPHIC VALUE ADDRESS ARRAYS ---------------------*

_uval:		DC.L	UP1		; ACE
		DC.L	UP2		; TWO
		DC.L	UP3		; THREE
		DC.L	UP4		; FOUR
		DC.L	UP5		; FIVE
		DC.L	UP6		; SIX
		DC.L	UP7		; SEVEN
		DC.L	UP8		; EIGHT
		DC.L	UP9		; NINE
		DC.L	UP10		; TEN
		DC.L	UPJ		; JACK
		DC.L	UPQ		; QUEEN
		DC.L	UPK		; KING

_dval:		DC.L	DN1		; ACE
		DC.L	DN2		; TWO
		DC.L	DN3		; THREE
		DC.L	DN4		; FOUR
		DC.L	DN5		; FIVE
		DC.L	UP9		; SIX
		DC.L	DN7		; SEVEN
		DC.L	DN8		; EIGHT
		DC.L	UP6		; NINE
		DC.L	DN10		; TEN
		DC.L	DNJ		; JACK
		DC.L	DNQ		; QUEEN
		DC.L	DNK		; KING

*-------------------------- SUIT PATTERN ARRAYS -------------------------*

_pattern:	DC.W	0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,0	; ACE
		DC.W	0,1,0,0,0,0,0,0,0,0,0,0,0,2,0,0,0	; TWO
		DC.W	0,1,0,0,0,0,0,1,0,0,0,0,0,2,0,0,0	; THREE
		DC.W	1,0,1,0,0,0,0,0,0,0,0,0,2,0,2,0,0	; FOUR
		DC.W	1,0,1,0,0,0,0,1,0,0,0,0,2,0,2,0,0	; FIVE
		DC.W	1,0,1,0,0,0,1,0,1,0,0,0,2,0,2,0,0	; SIX
		DC.W	1,0,1,0,1,0,1,0,1,0,0,0,2,0,2,0,0	; SEVEN
		DC.W	1,0,1,0,1,0,1,0,1,0,2,0,2,0,2,0,0	; EIGHT
		DC.W	1,0,1,1,0,1,0,1,0,2,0,2,2,0,2,0,0	; NINE
		DC.W	1,0,1,1,0,1,0,0,0,2,0,2,2,0,2,1,2	; TEN

*----------------------- SUIT LOCATION COORDINATES -----------------------*

_sx:		DC.W	08,14,20,08,14,20,08,14,20,08,14,20
		DC.W	08,14,20,14,14

_sy:		DC.W	04,04,04,12,10,12,16,16,16,20,22,20
		DC.W	28,28,28,08,24

*------------------------- SMALL SUIT GRAPHICS -------------------------*

* 1 by 05 words
H1U:
DC.W	$5000
DC.W	$F800
DC.W	$F800
DC.W	$7000
DC.W	$2000
DC.W	$0000,$0000
* 1 by 05 words
H1D:
DC.W	$2000
DC.W	$7000
DC.W	$F800
DC.W	$F800
DC.W	$5000
DC.W	$0000,$0000
* 1 by 05 words
C1U:
DC.W	$2000
DC.W	$7000
DC.W	$2000
DC.W	$F800
DC.W	$2000
DC.W	$0000,$0000
* 1 by 05 words
C1D:
DC.W	$2000
DC.W	$F800
DC.W	$2000
DC.W	$7000
DC.W	$2000
DC.W	$0000,$0000
* 1 by 05 words
D1U:
DC.W	$2000
DC.W	$7000
DC.W	$F800
DC.W	$7000
DC.W	$2000
DC.W	$0000,$0000
* 1 by 05 words
S1U:
DC.W	$2000
DC.W	$7000
DC.W	$F800
DC.W	$2000
DC.W	$7000
DC.W	$0000,$0000
* 1 by 05 words
S1D:
DC.W	$7000
DC.W	$2000
DC.W	$F800
DC.W	$7000
DC.W	$2000
DC.W	$0000,$0000

*------------------------- LARGE SUIT GRAPHICS -------------------------*

* 1 by 07 words
H2U:
DC.W	$6C00
DC.W	$FE00
DC.W	$FE00
DC.W	$FE00
DC.W	$7C00
DC.W	$3800
DC.W	$1000
* 1 by 07 words
H2D:
DC.W	$1000
DC.W	$3800
DC.W	$7C00
DC.W	$FE00
DC.W	$FE00
DC.W	$FE00
DC.W	$6C00
* 1 by 07 words
C2U:
DC.W	$3800
DC.W	$7C00
DC.W	$3800
DC.W	$5400
DC.W	$FE00
DC.W	$FE00
DC.W	$5400
* 1 by 07 words
C2D:
DC.W	$5400
DC.W	$FE00
DC.W	$FE00
DC.W	$5400
DC.W	$3800
DC.W	$7C00
DC.W	$3800
* 1 by 07 words
D2U:
DC.W	$1000
DC.W	$3800
DC.W	$7C00
DC.W	$FE00
DC.W	$7C00
DC.W	$3800
DC.W	$1000
* 1 by 07 words
S2U:
DC.W	$1000
DC.W	$3800
DC.W	$7C00
DC.W	$FE00
DC.W	$FE00
DC.W	$1000
DC.W	$3800
* 1 by 07 words
S2D:
DC.W	$3800
DC.W	$1000
DC.W	$FE00
DC.W	$FE00
DC.W	$7C00
DC.W	$3800
DC.W	$1000

*-------------------- GRAPHIC VALUE REPRESENTATIONS --------------------*

* 1 by 07 words
UP1:
DC.W	$2000
DC.W	$2000
DC.W	$7000
DC.W	$5000
DC.W	$F800
DC.W	$8800
DC.W	$8800
* 1 by 07 words
UP2:
DC.W	$7000
DC.W	$8800
DC.W	$0800
DC.W	$3000
DC.W	$4000
DC.W	$8000
DC.W	$F800
* 1 by 07 words
UP3:
DC.W	$7000
DC.W	$8800
DC.W	$0800
DC.W	$3000
DC.W	$0800
DC.W	$8800
DC.W	$7000
* 1 by 07 words
UP4:
DC.W	$1000
DC.W	$3000
DC.W	$5000
DC.W	$9000
DC.W	$F800
DC.W	$1000
DC.W	$1000
* 1 by 07 words
UP5:
DC.W	$F800
DC.W	$8000
DC.W	$F000
DC.W	$0800
DC.W	$0800
DC.W	$8800
DC.W	$7000
* 1 by 07 words
UP6:
DC.W	$7000
DC.W	$8800
DC.W	$8000
DC.W	$F000
DC.W	$8800
DC.W	$8800
DC.W	$7000
* 1 by 07 words
UP7:
DC.W	$F800
DC.W	$0800
DC.W	$0800
DC.W	$1000
DC.W	$2000
DC.W	$2000
DC.W	$2000
* 1 by 07 words
UP8:
DC.W	$7000
DC.W	$8800
DC.W	$8800
DC.W	$7000
DC.W	$8800
DC.W	$8800
DC.W	$7000
* 1 by 07 words
UP9:
DC.W	$7000
DC.W	$8800
DC.W	$8800
DC.W	$7800
DC.W	$0800
DC.W	$8800
DC.W	$7000
* 1 by 07 words
UP10:
DC.W	$B800
DC.W	$A800
DC.W	$A800
DC.W	$A800
DC.W	$A800
DC.W	$A800
DC.W	$B800
* 1 by 07 words
UPJ:
DC.W	$3800
DC.W	$1000
DC.W	$1000
DC.W	$1000
DC.W	$9000
DC.W	$9000
DC.W	$6000
* 1 by 07 words
UPQ:
DC.W	$7000
DC.W	$8800
DC.W	$8800
DC.W	$8800
DC.W	$A800
DC.W	$9800
DC.W	$7800
* 1 by 07 words
UPK:
DC.W	$8800
DC.W	$8800
DC.W	$9000
DC.W	$E000
DC.W	$9000
DC.W	$8800
DC.W	$8800
* 1 by 07 words
DN1:
DC.W	$8800
DC.W	$8800
DC.W	$F800
DC.W	$5000
DC.W	$7000
DC.W	$2000
DC.W	$2000
* 1 by 07 words
DN2:
DC.W	$F800
DC.W	$0800
DC.W	$1000
DC.W	$6000
DC.W	$8000
DC.W	$8800
DC.W	$7000
* 1 by 07 words
DN3:
DC.W	$7000
DC.W	$8800
DC.W	$8000
DC.W	$6000
DC.W	$8000
DC.W	$8800
DC.W	$7000
* 1 by 07 words
DN4:
DC.W	$4000
DC.W	$4000
DC.W	$F800
DC.W	$4800
DC.W	$5000
DC.W	$6000
DC.W	$4000
* 1 by 07 words
DN5:
DC.W	$7000
DC.W	$8800
DC.W	$8000
DC.W	$8000
DC.W	$7800
DC.W	$0800
DC.W	$F800
* 1 by 07 words
DN7:
DC.W	$2000
DC.W	$2000
DC.W	$2000
DC.W	$4000
DC.W	$8000
DC.W	$8000
DC.W	$F800
* 1 by 07 words
DN8:
DC.W	$7000
DC.W	$8800
DC.W	$8800
DC.W	$7000
DC.W	$8800
DC.W	$8800
DC.W	$7000
* 1 by 07 words
DN10:
DC.W	$E800
DC.W	$A800
DC.W	$A800
DC.W	$A800
DC.W	$A800
DC.W	$A800
DC.W	$E800
* 1 by 07 words
DNJ:
DC.W	$3000
DC.W	$4800
DC.W	$4800
DC.W	$4000
DC.W	$4000
DC.W	$4000
DC.W	$E000
* 1 by 07 words
DNQ:
DC.W	$F000
DC.W	$C800
DC.W	$A800
DC.W	$8800
DC.W	$8800
DC.W	$8800
DC.W	$7000
* 1 by 07 words
DNK:
DC.W	$8800
DC.W	$8800
DC.W	$4800
DC.W	$3800
DC.W	$4800
DC.W	$8800
DC.W	$8800

* 2 by 31 words
BACK:
DC.L	$0000FFFF,$00000000,$0000FFE0,$00000000
DC.L	$5D75E38E,$77DF77DF,$D74038E0,$7DC07DC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$6BAE9C71,$3EFB3EFB,$BAC0C720,$EF80EF80
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5D75E38E,$77DF77DF,$D74038E0,$7DC07DC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$6BAE9C71,$3EFB3EFB,$BAC0C720,$EF80EF80
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5D75E38E,$77DF77DF,$D74038E0,$7DC07DC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$6BAE9C71,$3EFB3EFB,$BAC0C720,$EF80EF80
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5D75E38E,$77DF77DF,$D74038E0,$7DC07DC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$6BAE9C71,$3EFB3EFB,$BAC0C720,$EF80EF80
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5D75E38E,$77DF77DF,$D74038E0,$7DC07DC0
DC.L	$2AAAF7DF,$7FFF7FFF,$AA807DE0,$FFC0FFC0
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$6BAE9C71,$3EFB3EFB,$BAC0C720,$EF80EF80
DC.L	$5555BEFB,$7FFF7FFF,$5540EFA0,$FFC0FFC0
DC.L	$0000FFFF,$00000000,$0000FFE0,$00000000
* 2 by 31 words
JACK:
DC.L	$FFFF0000,$0FFF0000,$FFE00000,$FE000000
DC.L	$FFFF0000,$180007FF,$FFE00000,$0300FC00
DC.L	$FFFF0000,$10000FFF,$FFE00000,$0100FE00
DC.L	$F80007FF,$10000800,$03E0FC00,$01000200
DC.L	$FCDB03FF,$10000C00,$67E0F800,$01000600
DC.L	$FEDB01FF,$10000E00,$6FE0F000,$01000E00
DC.L	$FE0001FF,$10000E00,$0FE0F000,$01000E00
DC.L	$FF60009F,$10600F1F,$DFE02000,$C1001E00
DC.L	$FFC0003F,$10DB0F24,$7FE08000,$61009E00
DC.L	$FF80006E,$10B10F4E,$3FE0C000,$A1005E00
DC.L	$FF80007F,$10800F7F,$3FE0C000,$2100DE00
DC.L	$FF2400DB,$10A40F5B,$9FE06000,$A1005E00
DC.L	$FF9B0064,$105B0FA4,$3FE0C000,$4100BE00
DC.L	$FFC4003F,$10200FDB,$7FE08000,$81007E00
DC.L	$FFE0001F,$101F0FE0,$FFE00000,$0100FE00
DC.L	$FFFF0000,$10000FFF,$FFE00000,$0100FE00
DC.L	$FFE0001F,$101F0FE0,$FFE00000,$0100FE00
DC.L	$FFC4003F,$10200FDB,$7FE08000,$81007E00
DC.L	$FF9B0064,$105B0FA4,$3FE0C000,$4100BE00
DC.L	$FF2400DB,$10A40F5B,$9FE06000,$A1005E00
DC.L	$FF80007F,$10800F7F,$3FE0C000,$2100DE00
DC.L	$FF80006E,$10B10F4E,$3FE0C000,$A1005E00
DC.L	$FFC0003F,$10DB0F24,$7FE08000,$61009E00
DC.L	$FF60009F,$10600F1F,$DFE02000,$C1001E00
DC.L	$FE0001FF,$10000E00,$0FE0F000,$01000E00
DC.L	$FEDB01FF,$10000E00,$6FE0F000,$01000E00
DC.L	$FCDB03FF,$10000C00,$67E0F800,$01000600
DC.L	$F80007FF,$10000800,$03E0FC00,$01000200
DC.L	$FFFF0000,$10000FFF,$FFE00000,$0100FE00
DC.L	$FFFF0000,$180007FF,$FFE00000,$0300FC00
DC.L	$FFFF0000,$0FFF0000,$FFE00000,$FE000000
* 2 by 31 words
QUEEN:
DC.L	$FFFF0000,$0FFF0000,$FFE00000,$FE000000
DC.L	$FFFF0000,$180007FF,$FFE00000,$0300FC00
DC.L	$FBFB0000,$14040FFF,$FBE00000,$0500FE00
DC.L	$FCF10000,$130E0FFF,$E7E00000,$1900FE00
DC.L	$FE200000,$11DF0F7B,$8FE00000,$7100DE00
DC.L	$FF000000,$10FF0FEE,$1FE00000,$E100FE00
DC.L	$FF000000,$10FF0FFF,$1FE00000,$E100FE00
DC.L	$FF7B0004,$10FB0F84,$DFE00000,$E1003E00
DC.L	$FFA0005F,$10F10F0E,$BFE04000,$E1001E00
DC.L	$FFC0002E,$10D10F2E,$7FE08000,$61009E00
DC.L	$FF84007B,$11C40E3B,$3FE0C000,$71008E00
DC.L	$FF80007F,$13C00C3F,$3FE0C000,$79008600
DC.L	$FD0E02FF,$17C00831,$17E0E800,$7D008200
DC.L	$FF60009F,$17E0081F,$DFE02000,$FD000200
DC.L	$FEB1014E,$13F10C0E,$AFE05000,$F9000600
DC.L	$FFFF0000,$10000FFF,$FFE00000,$0100FE00
DC.L	$FEB1014E,$13F10C0E,$AFE05000,$F9000600
DC.L	$FF60009F,$17E0081F,$DFE02000,$FD000200
DC.L	$FD0E02FF,$17C00831,$17E0E800,$7D008200
DC.L	$FF80007F,$13C00C3F,$3FE0C000,$79008600
DC.L	$FF84007B,$11C40E3B,$3FE0C000,$71008E00
DC.L	$FFC0002E,$10D10F2E,$7FE08000,$61009E00
DC.L	$FFA0005F,$10F10F0E,$BFE04000,$E1001E00
DC.L	$FF7B0004,$10FB0F84,$DFE00000,$E1003E00
DC.L	$FF000000,$10FF0FFF,$1FE00000,$E100FE00
DC.L	$FF000000,$10FF0FEE,$1FE00000,$E100FE00
DC.L	$FE200000,$11DF0F7B,$8FE00000,$7100DE00
DC.L	$FCF10000,$130E0FFF,$E7E00000,$1900FE00
DC.L	$FBFB0000,$14040FFF,$FBE00000,$0500FE00
DC.L	$FFFF0000,$180007FF,$FFE00000,$0300FC00
DC.L	$FFFF0000,$0FFF0000,$FFE00000,$FE000000
* 2 by 31 words
KING:
DC.L	$FFFF0000,$0FFF0000,$FFE00000,$FE000000
DC.L	$FFFF0000,$180007FF,$FFE00000,$0300FC00
DC.L	$FBFB0000,$14040FFF,$FBE00000,$0500FE00
DC.L	$FCF10000,$130E0FFF,$E7E00000,$1900FE00
DC.L	$FE200000,$11DF0F7B,$8FE00000,$7100DE00
DC.L	$FF000000,$10FF0FEE,$1FE00000,$E100FE00
DC.L	$FF000000,$10FF0FFF,$1FE00000,$E100FE00
DC.L	$FF40003F,$10E00F9F,$5FE08000,$E1003E00
DC.L	$FFBB0044,$10FB0F04,$BFE04000,$E1001E00
DC.L	$FF80006E,$10910F6E,$3FE0C000,$2100DE00
DC.L	$FF84007B,$10840F7B,$3FE0C000,$2100DE00
DC.L	$FFDF0020,$10FF0F00,$7FE08000,$E1001E00
DC.L	$FFE0001F,$10710F8E,$FFE00000,$C1003E00
DC.L	$FFF5000A,$103F0FC0,$FFE00000,$81007E00
DC.L	$FFFF0000,$101F0FE0,$FFE00000,$0100FE00
DC.L	$FFFF0000,$10000FFF,$FFE00000,$0100FE00
DC.L	$FFFF0000,$101F0FE0,$FFE00000,$0100FE00
DC.L	$FFF5000A,$103F0FC0,$FFE00000,$81007E00
DC.L	$FFE0001F,$10710F8E,$FFE00000,$C1003E00
DC.L	$FFDF0020,$10FF0F00,$7FE08000,$E1001E00
DC.L	$FF84007B,$10840F7B,$3FE0C000,$2100DE00
DC.L	$FF80006E,$10910F6E,$3FE0C000,$2100DE00
DC.L	$FFBB0044,$10FB0F04,$BFE04000,$E1001E00
DC.L	$FF40003F,$10E00F9F,$5FE08000,$E1003E00
DC.L	$FF000000,$10FF0FFF,$1FE00000,$E100FE00
DC.L	$FF000000,$10FF0FEE,$1FE00000,$E100FE00
DC.L	$FE200000,$11DF0F7B,$8FE00000,$7100DE00
DC.L	$FCF10000,$130E0FFF,$E7E00000,$1900FE00
DC.L	$FBFB0000,$14040FFF,$FBE00000,$0500FE00
DC.L	$FFFF0000,$180007FF,$FFE00000,$0300FC00
DC.L	$FFFF0000,$0FFF0000,$FFE00000,$FE000000
