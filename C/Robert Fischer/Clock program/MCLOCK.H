/* C header file for resource file mclock.rsc */
/* Created by rdlcomp on Sat Nov 26 15:03:42 1988 from RDL source file mclock.rdl */

#define	THETREE 	0		/* form tree */
#define	BOX_0000	0		/* Box in form THETREE */
#define	STRN_001	1		/* String in form THETREE */
#define	STRN_002	2		/* String in form THETREE */
#define	STRN_003	3		/* String in form THETREE */
#define	STRN_004	4		/* String in form THETREE */
#define	STRN_005	5		/* String in form THETREE */
#define	BOX_0006	6		/* Box in form THETREE */
#define	MTIMEON 	7		/* Button in form THETREE */
#define	MTIMEOFF	8		/* Button in form THETREE */
#define	BOX_0009	9		/* Box in form THETREE */
#define	OTIMEON 	10		/* Button in form THETREE */
#define	OTIMEOFF	11		/* Button in form THETREE */
#define	BOX_000C	12		/* Box in form THETREE */
#define	H24ON   	13		/* Button in form THETREE */
#define	H24OFF  	14		/* Button in form THETREE */
#define	BUTN_00F	15		/* Button in form THETREE */
