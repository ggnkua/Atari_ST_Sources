/*
 * DFREE.H
 *
 * Objektindizes, wie vom RCS geliefert
 *
 * von Oliver Scholz, Januar 1992
 * (c) 1992 MAXON Computer
 */

#define DFREE 0     /* TREE */
#define CLOSE 1     /* OBJECT in TREE #0 */
#define OFFSET 3    /* OBJECT in TREE #0 */
#define CNAME 4     /* OBJECT in TREE #0 */
#define DNAME 5     /* OBJECT in TREE #0 */
#define ENAME 6     /* OBJECT in TREE #0 */
#define GNAME 7     /* OBJECT in TREE #0 */
#define FNAME 8     /* OBJECT in TREE #0 */
#define CGREY 9     /* OBJECT in TREE #0 */
#define CBAR 10     /* OBJECT in TREE #0 */
#define DGREY 11    /* OBJECT in TREE #0 */
#define DBAR 12     /* OBJECT in TREE #0 */
#define EGREY 13    /* OBJECT in TREE #0 */
#define EBAR 14     /* OBJECT in TREE #0 */
#define FGREY 15    /* OBJECT in TREE #0 */
#define FBAR 16     /* OBJECT in TREE #0 */
#define GGREY 17    /* OBJECT in TREE #0 */
#define GBAR 18     /* OBJECT in TREE #0 */
#define HGREY 19    /* OBJECT in TREE #0 */
#define HBAR 20     /* OBJECT in TREE #0 */
#define HNAME 21    /* OBJECT in TREE #0 */
#define IGREY 22    /* OBJECT in TREE #0 */
#define IBAR 23     /* OBJECT in TREE #0 */
#define JGREY 24    /* OBJECT in TREE #0 */
#define JBAR 25     /* OBJECT in TREE #0 */
#define INAME 26    /* OBJECT in TREE #0 */
#define JNAME 27    /* OBJECT in TREE #0 */
#define FREEC 28    /* OBJECT in TREE #0 */
#define FREED 29    /* OBJECT in TREE #0 */
#define FREEE 30    /* OBJECT in TREE #0 */
#define FREEF 31    /* OBJECT in TREE #0 */
#define FREEG 32    /* OBJECT in TREE #0 */
#define FREEH 33    /* OBJECT in TREE #0 */
#define FREEI 34    /* OBJECT in TREE #0 */
#define FREEJ 35    /* OBJECT in TREE #0 */
#define TOTALC 36   /* OBJECT in TREE #0 */
#define TOTALD 37   /* OBJECT in TREE #0 */
#define TOTALE 38   /* OBJECT in TREE #0 */
#define TOTALF 39   /* OBJECT in TREE #0 */
#define TOTALG 40   /* OBJECT in TREE #0 */
#define TOTALH 41   /* OBJECT in TREE #0 */
#define TOTALI 42   /* OBJECT in TREE #0 */
#define TOTALJ 43   /* OBJECT in TREE #0 */
#define TITLE 44    /* OBJECT in TREE #0 */
#define DRIVE 45    /* OBJECT in TREE #0 */
#define USAGE 46    /* OBJECT in TREE #0 */
#define FREE 47     /* OBJECT in TREE #0 */
