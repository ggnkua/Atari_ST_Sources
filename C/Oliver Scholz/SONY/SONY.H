#define DIALOG 0    /* TREE */
#define POWER 1     /* OBJECT in TREE #0 */
#define PAUSE 3     /* OBJECT in TREE #0 */
#define PLAY 4      /* OBJECT in TREE #0 */
#define REC 5       /* OBJECT in TREE #0 */
#define REW 6       /* OBJECT in TREE #0 */
#define STOP 7      /* OBJECT in TREE #0 */
#define FF 8        /* OBJECT in TREE #0 */
#define EJECT 9     /* OBJECT in TREE #0 */
#define FERTIG 10   /* OBJECT in TREE #0 */
#define PRGUP 11    /* OBJECT in TREE #0 */
#define PRGDOWN 12  /* OBJECT in TREE #0 */
