/***********************************************/
/* Datei: DIPS.H          Version 1.00         */
/* ------------------------------------------- */
/* (C) 1991 by MAXON Computer                  */
/* Autoren: Oliver Scholz & Uwe Hax            */
/***********************************************/

#define SWITCHES 0      /* TREE */
#define DIP1 4      /* OBJECT in TREE #0 */
#define OK 28       /* OBJECT in TREE #0 */
#define CANCEL 29   /* OBJECT in TREE #0 */
#define SAVE 31     /* OBJECT in TREE #0 */
#define DIP2 7      /* OBJECT in TREE #0 */
#define DIP3 10     /* OBJECT in TREE #0 */
#define DIP4 13     /* OBJECT in TREE #0 */
#define DIP5 16     /* OBJECT in TREE #0 */
#define DIP6 19     /* OBJECT in TREE #0 */
#define DIP7 22     /* OBJECT in TREE #0 */
#define DIP8 25     /* OBJECT in TREE #0 */
#define READ 26     /* OBJECT in TREE #0 */
#define ERROR 1     /* TREE */
#define ERROK 1     /* OBJECT in TREE #1 */

