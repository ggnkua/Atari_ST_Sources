/*
 * GLOBALS.H
 * globale Variablen f�r PINDIALS
 * by Oliver Scholz
 * (c) 1991 MAXON Computer
 */

GLOBAL STATUS status;
GLOBAL WINDOW window;
GLOBAL OBJECT *menu, *newdesk;
GLOBAL OBJECT *fontbox, *textbox;
GLOBAL WORD gl_apid;
GLOBAL WORD vdi_handle;
GLOBAL WORD xres, yres, hchar;
GLOBAL WORD dummy;
GLOBAL BITBLK *pin_pinned, *pin_unpinned;
GLOBAL WORD font_pinned, text_pinned;
