/*
 * PINDIALS.H
 */
#define MENU 0          /* TREE */
#define NEWDESK 1       /* TREE */
#define ABOUT 8         /* OBJECT in TREE #0 */
#define QUIT 17         /* OBJECT in TREE #0 */
#define DIAL1 19        /* OBJECT in TREE #0 */
#define DIAL2 20        /* OBJECT in TREE #0 */
#define FONTIBOX 1      /* OBJECT in TREE #1 */
#define FONTBOX 2       /* OBJECT in TREE #1 */
#define FONTOK 3        /* OBJECT in TREE #1 */
#define FPICA 4         /* OBJECT in TREE #1 */
#define FELITE 5        /* OBJECT in TREE #1 */
#define FTIMES 6        /* OBJECT in TREE #1 */
#define FONTPIN 7       /* OBJECT in TREE #1 */
#define TEXTIBOX 9      /* OBJECT in TREE #1 */
#define TEXTBOX 10      /* OBJECT in TREE #1 */
#define TEXTPIN 11      /* OBJECT in TREE #1 */
#define TKURSIV 12      /* OBJECT in TREE #1 */
#define TUNTER 13       /* OBJECT in TREE #1 */
#define TLEICHT 14      /* OBJECT in TREE #1 */
#define TFETT 15        /* OBJECT in TREE #1 */
#define TEXTOK 16       /* OBJECT in TREE #1 */


