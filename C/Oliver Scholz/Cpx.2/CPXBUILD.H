/***********************************************/
/* Datei: CPXBUILD.H                           */
/* ------------------------------------------- */
/* Programm: CPXBUILD.PRG         Version 1.00 */
/* (C) 1991 by MAXON Computer                  */
/* Autoren: Uwe Hax & Oliver Scholz            */
/* vom RCS erstellte Include-Datei             */
/***********************************************/


#define BUILD 0         /* TREE */
#define CPXNAME 3       /* OBJECT in TREE #0 */
#define COLLEFT 5       /* OBJECT in TREE #0 */
#define COLRIGHT 7      /* OBJECT in TREE #0 */
#define TEXTCOL 6       /* OBJECT in TREE #0 */
#define CPXID 8         /* OBJECT in TREE #0 */
#define ICONDATA 10     /* OBJECT in TREE #0 */
#define ICONSMAL 12     /* OBJECT in TREE #0 */
#define ICONBOX 11      /* OBJECT in TREE #0 */
#define ICLEFT 14       /* OBJECT in TREE #0 */
#define ICRIGHT 16      /* OBJECT in TREE #0 */
#define ICCOL 15        /* OBJECT in TREE #0 */
#define ICNNAME 17      /* OBJECT in TREE #0 */
#define INVERT 18       /* OBJECT in TREE #0 */
#define VERSION 9       /* OBJECT in TREE #0 */
#define ICONWORK 19     /* OBJECT in TREE #0 */
#define SETONLY 21      /* OBJECT in TREE #0 */
#define RESFLAG 23      /* OBJECT in TREE #0 */
#define BOOTFLAG 22     /* OBJECT in TREE #0 */
#define LOAD 24         /* OBJECT in TREE #0 */
#define OK 25           /* OBJECT in TREE #0 */
#define ABBRUCH 26      /* OBJECT in TREE #0 */

