/***********************************************/
/* Datei: BOOT.H                               */
/* ------------------------------------------- */
/* Modul: BOOT.CPX                Version 1.00 */
/* (C) 1990 by MAXON Computer                  */
/* Autoren: Uwe Hax & Oliver Scholz            */
/* Vom RCS aus Resource-Datei erstellte        */
/* Include-Datei                               */
/***********************************************/


#define BOOT 0          /* TREE */
#define TYP 2           /* OBJECT in TREE #0 */
#define ACTWIND 5       /* OBJECT in TREE #0 */
#define ACTIVE1 6       /* OBJECT in TREE #0 */
#define ACTIVE3 7       /* OBJECT in TREE #0 */
#define ACTIVE2 9       /* OBJECT in TREE #0 */
#define ACTIVE4 8       /* OBJECT in TREE #0 */
#define ACTIVE5 10      /* OBJECT in TREE #0 */
#define ACT_UP 11       /* OBJECT in TREE #0 */
#define INACTIV1 13     /* OBJECT in TREE #0 */
#define INACWIND 12     /* OBJECT in TREE #0 */
#define INACTIV2 14     /* OBJECT in TREE #0 */
#define INACTIV3 15     /* OBJECT in TREE #0 */
#define INACTIV5 17     /* OBJECT in TREE #0 */
#define INACTIV4 16     /* OBJECT in TREE #0 */
#define INACT_UP 18     /* OBJECT in TREE #0 */
#define PARENT1 19      /* OBJECT in TREE #0 */
#define PARENT2 21      /* OBJECT in TREE #0 */
#define SLIDER1 20      /* OBJECT in TREE #0 */
#define SLIDER2 22      /* OBJECT in TREE #0 */
#define ACT_DOWN 23     /* OBJECT in TREE #0 */
#define ACTION 25       /* OBJECT in TREE #0 */
#define INACT_DO 24     /* OBJECT in TREE #0 */
#define QUIT 26         /* OBJECT in TREE #0 */
#define ERROR 1         /* TREE */
#define MIST 6          /* OBJECT in TREE #1 */

