#define MENU 0  	/* TREE */
#define INFORM 10  	/* OBJECT in TREE #0 */
#define INFIELD 1  	/* TREE */
#define INPUT 1  	/* OBJECT in TREE #1 */
#define LOAD 19  	/* OBJECT in TREE #0 */
#define SAVE 20  	/* OBJECT in TREE #0 */
#define END 21  	/* OBJECT in TREE #0 */
#define EADD 25  	/* OBJECT in TREE #0 */
#define EDEL 26  	/* OBJECT in TREE #0 */
#define KADD 28  	/* OBJECT in TREE #0 */
#define KDEL 29  	/* OBJECT in TREE #0 */
#define VALUE 30  	/* OBJECT in TREE #0 */
#define ERASE 31  	/* OBJECT in TREE #0 */
#define WARSHALL 37  	/* OBJECT in TREE #0 */
#define DIJKSTRA 38  	/* OBJECT in TREE #0 */
#define FLOYD 39  	/* OBJECT in TREE #0 */
#define PRIM 40  	/* OBJECT in TREE #0 */
#define TSUCH 41  	/* OBJECT in TREE #0 */
#define BSUCH 42  	/* OBJECT in TREE #0 */
#define DIGRAPH 44  	/* OBJECT in TREE #0 */
#define BEWERTET 45  	/* OBJECT in TREE #0 */
#define EMOVE 34  	/* OBJECT in TREE #0 */
#define EINFO 35  	/* OBJECT in TREE #0 */
#define OKKNOPF 2  	/* OBJECT in TREE #1 */
#define DRUCK 23  	/* OBJECT in TREE #0 */
