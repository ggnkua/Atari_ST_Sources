/* resource set indicies for DELTA */

#define MENU     0	/* menu tree */
#define MNINFO   8	/* STRING in tree MENU */
#define MNGEN    17	/* STRING in tree MENU */
#define MNPLAY   18	/* STRING in tree MENU */
#define MNPUFF   20	/* STRING in tree MENU */
#define MNSAVE   21	/* STRING in tree MENU */
#define MNEND    23	/* STRING in tree MENU */
#define MNMAX    25	/* STRING in tree MENU */
#define MN350    26	/* STRING in tree MENU */
#define MN710    27	/* STRING in tree MENU */

#define GENFORM  1	/* form/dialog */
#define BILDZ    3	/* FBOXTEXT in tree GENFORM */
#define SDISK    5	/* BUTTON in tree GENFORM */
#define MDISK    6	/* BUTTON in tree GENFORM */
#define PNAME    7	/* FBOXTEXT in tree GENFORM */
#define ANAME    8	/* FBOXTEXT in tree GENFORM */
#define ERSTELL  9	/* BUTTON in tree GENFORM */
#define GENAB    10	/* BUTTON in tree GENFORM */

#define PLAYFORM 2	/* form/dialog */
#define SCR1     4	/* BOXCHAR in tree PLAYFORM */
#define SCR2     5	/* BOXCHAR in tree PLAYFORM */
#define PLAY     6	/* BUTTON in tree PLAYFORM */
#define PAB      7	/* BUTTON in tree PLAYFORM */
#define PAUSEUP  9	/* BOXCHAR in tree PLAYFORM */
#define PAUSEDN  10	/* BOXCHAR in tree PLAYFORM */
#define PAUSEVAL 11	/* BOXTEXT in tree PLAYFORM */

