/* Resource Datei Indizes f�r TESTS */

#define TMENU            0   /* Menuebaum */
#define DESK             3   /* TITLE in Baum TMENU */
#define MDIAL            4   /* TITLE in Baum TMENU */
#define QUIT             16  /* STRING in Baum TMENU */

#define T                1   /* Formular/Dialog */
#define FT1              4   /* FTEXT in Baum T */
#define FT2              5   /* FTEXT in Baum T */
#define FT3              6   /* FTEXT in Baum T */
#define FT4              7   /* FTEXT in Baum T */
#define RB1              9   /* BUTTON in Baum T */
#define RB2              10  /* BUTTON in Baum T */
#define RB3              11  /* BUTTON in Baum T */
#define TEX1             12  /* BUTTON in Baum T */
#define FORM_DO          14  /* BUTTON in Baum T */
#define MYFORM_DO        15  /* BUTTON in Baum T */
#define FORM_MODE        16  /* BUTTON in Baum T */
#define TEX2             17  /* STRING in Baum T */
#define DTX              19  /* FTEXT in Baum T */
#define DTY              20  /* FTEXT in Baum T */
#define DTW              21  /* FTEXT in Baum T */
#define DTH              22  /* FTEXT in Baum T */
#define OBX              25  /* FTEXT in Baum T */
#define OBY              26  /* FTEXT in Baum T */
#define OBW              27  /* FTEXT in Baum T */
#define OBH              28  /* FTEXT in Baum T */
#define TXT16            39  /* BOXTEXT in Baum T */
#define TXT14            40  /* BOXTEXT in Baum T */
#define TXT12            41  /* BOXTEXT in Baum T */
#define ICON             42  /* ICON in Baum T */
#define TXT10            44  /* BOXTEXT in Baum T */
#define TXT8             45  /* BOXTEXT in Baum T */
#define TXT6             46  /* BOXTEXT in Baum T */
#define XA_VERSION       48  /* FTEXT in Baum T */
#define DO               51  /* BUTTON in Baum T */
#define CANCEL           52  /* BUTTON in Baum T */
#define OK               53  /* BUTTON in Baum T */
#define LARGE_POP        54  /* BOX in Baum T */

#define POP              2   /* Formular/Dialog */
#define FORM_POP         0   /* BOX in Baum POP */

#define POPS             3   /* Formular/Dialog */
#define FORM_POPS        1   /* BOX in Baum POPS */
