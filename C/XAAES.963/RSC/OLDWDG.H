/* Resource Datei Indizes f�r OLDWDG */

#define WIDGETS          0   /* Formular/Dialog */
#define WIDG_CLOSER      1   /* USERDEF in Baum WIDGETS */
#define WIDG_LOGO        2   /* USERDEF in Baum WIDGETS */
#define WIDG_HIDE        3   /* USERDEF in Baum WIDGETS */
#define WIDG_ICONIFY     4   /* USERDEF in Baum WIDGETS */
#define WIDG_FULL        5   /* USERDEF in Baum WIDGETS */
#define WIDG_UP          6   /* USERDEF in Baum WIDGETS */
#define WIDG_DOWN        7   /* USERDEF in Baum WIDGETS */
#define WIDG_LEFT        8   /* USERDEF in Baum WIDGETS */
#define WIDG_RIGHT       9   /* USERDEF in Baum WIDGETS */
#define WIDG_SIZE        10  /* USERDEF in Baum WIDGETS */
#define WIDG_CFG         11  /* STRING in Baum WIDGETS */
