/* Mouse Form Block :NESCROLL  */


int NESCROLL[37]={12074,8269,1,0,1


,0x0000,0x01FE,0x01FE,0x01FE


,0x007E,0x00FE,0x01FE,0x73EE


,0x77CE,0x7F80,0x7F00,0x7E00


,0x7F80,0x7F80,0x7F80,0x0000


,0x0000,0x0000,0x00FC,0x003C


,0x003C,0x007C,0x00E4,0x01C4


,0x2380,0x2700,0x3E00,0x3C00


,0x3C00,0x3F00,0x0000,0x0000


};


