/* Mouse Form Block :HSCROLL  */


int HSCROLL[37]={12074,8269,1,0,1


,0x0000,0x0000,0x0000,0x0C30


,0x1C38,0x3C3C,0x7FFE,0xFFFF


,0xFFFF,0x7FFE,0x3C3C,0x1C38


,0x0C30,0x0000,0x0000,0x0000


,0x0000,0x0000,0x0000,0x0000


,0x0810,0x1818,0x381C,0x7FFE


,0x7FFE,0x381C,0x1818,0x0810


,0x0000,0x0000,0x0000,0x0000


};


