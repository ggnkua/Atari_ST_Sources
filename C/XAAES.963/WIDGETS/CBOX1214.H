/* Resource Datei Indizes f�r CBOX1214 */

#define WIDGETS          0   /* Formular/Dialog */
#define RADIO_DESLCT     11  /* USERDEF in Baum WIDGETS */
#define RADIO_SLCT       12  /* USERDEF in Baum WIDGETS */
#define BUT_DESLCT       13  /* USERDEF in Baum WIDGETS */
#define BUT_SLCT         14  /* USERDEF in Baum WIDGETS */
#define WIDG_CFG         15  /* STRING in Baum WIDGETS */
