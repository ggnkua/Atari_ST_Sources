/* Resource Datei Indizes f�r MBOXWDG */

#define WIDGETS          0   /* Formular/Dialog */
#define RADIO_DESLCT     11  /* ICON in Baum WIDGETS */
#define RADIO_SLCT       12  /* ICON in Baum WIDGETS */
#define BUT_DESLCT       13  /* ICON in Baum WIDGETS */
#define WIDG_CFG         15  /* STRING in Baum WIDGETS */
