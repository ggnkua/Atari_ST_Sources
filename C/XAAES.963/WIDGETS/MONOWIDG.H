/* Resource Datei Indizes f�r MONOWIDG */

#define WIDGETS          0   /* Formular/Dialog */
#define WIDG_CLOSER      1   /* ICON in Baum WIDGETS */
#define WIDG_LOGO        2   /* ICON in Baum WIDGETS */
#define WIDG_HIDE        3   /* ICON in Baum WIDGETS */
#define WIDG_ICONIFY     4   /* ICON in Baum WIDGETS */
#define WIDG_FULL        5   /* ICON in Baum WIDGETS */
#define WIDG_UP          6   /* ICON in Baum WIDGETS */
#define WIDG_DOWN        7   /* ICON in Baum WIDGETS */
#define WIDG_LEFT        8   /* ICON in Baum WIDGETS */
#define WIDG_RIGHT       9   /* ICON in Baum WIDGETS */
#define WIDG_SIZE        10  /* ICON in Baum WIDGETS */
#define RADIO_DESLCT     11  /* ICON in Baum WIDGETS */
#define RADIO_SLCT       12  /* ICON in Baum WIDGETS */
#define BUT_DESLCT       13  /* ICON in Baum WIDGETS */
#define WIDG_CFG         15  /* STRING in Baum WIDGETS */
