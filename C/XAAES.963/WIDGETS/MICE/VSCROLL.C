/* Mouse Form Block :VSCROLL  */


int VSCROLL[37]={12074,8269,1,0,1


,0x0180,0x03C0,0x07E0,0x0FF0


,0x1FF8,0x1FF8,0x03C0,0x03C0


,0x03C0,0x03C0,0x1FF8,0x1FF8


,0x0FF0,0x07E0,0x03C0,0x0180


,0x0000,0x0180,0x03C0,0x07E0


,0x0FF0,0x0180,0x0180,0x0180


,0x0180,0x0180,0x0180,0x0FF0


,0x07E0,0x03C0,0x0180,0x0000


};


