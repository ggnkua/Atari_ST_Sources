struct {int n; char *name;} tok_tab[] = {
    {258, "CHEX"},
    {259, "CDEC"},
    {260, "FRAC"},
    {261, "AREG"},
    {262, "BREG"},
    {263, "MREG"},
    {264, "NREG"},
    {265, "RREG"},
    {266, "XREG"},
    {267, "YREG"},
    {268, "OP"},
    {269, "OPA"},
    {270, "OPP"},
    {271, "OP_JCC"},
    {272, "OP_JSCC"},
    {273, "OP_TCC"},
    {274, "SYM"},
    {275, "STRING"},
    {276, "CHAR"},
    {277, "XMEM"},
    {278, "YMEM"},
    {279, "LMEM"},
    {280, "PMEM"},
    {281, "AAAA"},
    {282, "A10"},
    {283, "BBBB"},
    {284, "B10"},
    {285, "AABB"},
    {286, "BBAA"},
    {287, "XXXX"},
    {288, "YYYY"},
    {289, "SR"},
    {290, "MR"},
    {291, "CCR"},
    {292, "OMR"},
    {293, "SP"},
    {294, "SSH"},
    {295, "SSL"},
    {296, "LA"},
    {297, "LC"},
    {298, "EOL"},
    {299, "EOS"},
    {300, "LEXBAD"},
    {301, "OP_ABS"},
    {302, "OP_ADC"},
    {303, "OP_ADD"},
    {304, "OP_ADDL"},
    {305, "OP_ADDR"},
    {306, "OP_ASL"},
    {307, "OP_ASR"},
    {308, "OP_CLR"},
    {309, "OP_CMP"},
    {310, "OP_CMPM"},
    {311, "OP_DIV"},
    {312, "OP_MAC"},
    {313, "OP_MACR"},
    {314, "OP_MPY"},
    {315, "OP_MPYR"},
    {316, "OP_NEG"},
    {317, "OP_NORM"},
    {318, "OP_RND"},
    {319, "OP_SBC"},
    {320, "OP_SUB"},
    {321, "OP_SUBL"},
    {322, "OP_SUBR"},
    {323, "OP_TFR"},
    {324, "OP_TST"},
    {325, "OP_AND"},
    {326, "OP_ANDI"},
    {327, "OP_EOR"},
    {328, "OP_LSL"},
    {329, "OP_LSR"},
    {330, "OP_NOT"},
    {331, "OP_OR"},
    {332, "OP_ORI"},
    {333, "OP_ROL"},
    {334, "OP_ROR"},
    {335, "OP_BCLR"},
    {336, "OP_BSET"},
    {337, "OP_BCHG"},
    {338, "OP_BTST"},
    {339, "OP_DO"},
    {340, "OP_ENDDO"},
    {341, "OP_LUA"},
    {342, "OP_MOVE"},
    {343, "OP_MOVEC"},
    {344, "OP_MOVEM"},
    {345, "OP_MOVEP"},
    {346, "OP_ILLEGAL"},
    {347, "OP_INCLUDE"},
    {348, "OP_JMP"},
    {349, "OP_JCLR"},
    {350, "OP_JSET"},
    {351, "OP_JSR"},
    {352, "OP_JSCLR"},
    {353, "OP_JSSET"},
    {354, "OP_NOP"},
    {355, "OP_REP"},
    {356, "OP_RESET"},
    {357, "OP_RTI"},
    {358, "OP_RTS"},
    {359, "OP_STOP"},
    {360, "OP_SWI"},
    {361, "OP_WAIT"},
    {362, "OP_EQU"},
    {363, "OP_ORG"},
    {364, "OP_DC"},
    {365, "OP_DS"},
    {366, "OP_DSM"},
    {367, "OP_END"},
    {368, "OP_PAGE"},
    {369, "OP_PSECT"},
    {370, "OP_ALIGN"},
    {371, "OP_INT"},
    {372, "SHL"},
    {373, "SHR"},
};
#define N_TOK (sizeof tok_tab / sizeof tok_tab[0])
int n_tok = N_TOK;
