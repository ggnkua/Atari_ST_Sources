/*
 *	CHNGERES.H
 * 	Prototypen
 *	Copyright 1991: Oliver Spornitz und Detlev Nolte
 */


#if !defined( CHNGERES )
#define CHNGERES

_pexec_setres();
_pterm_setres();
int program_in_list(void);
	
#endif

