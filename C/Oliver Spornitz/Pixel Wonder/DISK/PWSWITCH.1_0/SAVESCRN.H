/*
 *	SAVESCRN.H
 * 	Prototypen
 *	Copyright 1991: Oliver Spornitz und Detlev Nolte
 */


#if !defined( __SAVESCRN__ )
#define __SAVESCRN__

void save_screen(void);
void restore_screen(void);
void copy_screen(void);
	
#endif

