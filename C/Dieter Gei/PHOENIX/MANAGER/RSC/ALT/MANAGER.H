/* Resource Datei Indizes f�r MANAGER */

#define MENUE            0   /* Menuebaum */
#define MDESK            3   /* TITLE in Baum MENUE */
#define MFILE            4   /* TITLE in Baum MENUE */
#define MEDIT            5   /* TITLE in Baum MENUE */
#define MPROCESS         6   /* TITLE in Baum MENUE */
#define MACCOUNT         7   /* TITLE in Baum MENUE */
#define MPARAMS          8   /* TITLE in Baum MENUE */
#define MOPTIONS         9   /* TITLE in Baum MENUE */
#define MHELP            10  /* TITLE in Baum MENUE */
#define MABOUT           13  /* STRING in Baum MENUE */
#define MOPEN            22  /* STRING in Baum MENUE */
#define MCLOSE           23  /* STRING in Baum MENUE */
#define MCLOSEDB         24  /* STRING in Baum MENUE */
#define MSAVE            26  /* STRING in Baum MENUE */
#define MSAVEAS          27  /* STRING in Baum MENUE */
#define MEXPORT          29  /* STRING in Baum MENUE */
#define MIMPORT          30  /* STRING in Baum MENUE */
#define MDISK            31  /* STRING in Baum MENUE */
#define MPRINT           33  /* STRING in Baum MENUE */
#define MQUIT            35  /* STRING in Baum MENUE */
#define MUNDO            37  /* STRING in Baum MENUE */
#define MCUT             39  /* STRING in Baum MENUE */
#define MCOPY            40  /* STRING in Baum MENUE */
#define MPASTE           41  /* STRING in Baum MENUE */
#define MCLEAR           42  /* STRING in Baum MENUE */
#define MSELALL          43  /* STRING in Baum MENUE */
#define MSEARCH          45  /* STRING in Baum MENUE */
#define MCONT            46  /* STRING in Baum MENUE */
#define MICONIFY         48  /* STRING in Baum MENUE */
#define MCYCLEWI         49  /* STRING in Baum MENUE */
#define MOPENTBL         51  /* STRING in Baum MENUE */
#define MEDITDAT         52  /* STRING in Baum MENUE */
#define MREMOVE          53  /* STRING in Baum MENUE */
#define MREMSEL          54  /* STRING in Baum MENUE */
#define MEMPTYTR         55  /* STRING in Baum MENUE */
#define MTOCLIP          57  /* STRING in Baum MENUE */
#define MPNEW            59  /* STRING in Baum MENUE */
#define MPLIST           60  /* STRING in Baum MENUE */
#define MPEXEC           61  /* STRING in Baum MENUE */
#define MPASSIGN         63  /* STRING in Baum MENUE */
#define MPREMOVE         64  /* STRING in Baum MENUE */
#define MPAGEHDR         66  /* STRING in Baum MENUE */
#define MACCHDR          67  /* STRING in Baum MENUE */
#define MSHOWRST         69  /* STRING in Baum MENUE */
#define MRASTER          70  /* STRING in Baum MENUE */
#define MFOREGND         72  /* STRING in Baum MENUE */
#define MBACKGND         73  /* STRING in Baum MENUE */
#define MGROUP           75  /* STRING in Baum MENUE */
#define MCONFIG          77  /* STRING in Baum MENUE */
#define MLOADCNF         78  /* STRING in Baum MENUE */
#define MSAVECNF         79  /* STRING in Baum MENUE */
#define MMCONFIG         81  /* STRING in Baum MENUE */
#define MIMPEXP          82  /* STRING in Baum MENUE */
#define MSETPRN          83  /* STRING in Baum MENUE */
#define MQUEUE           84  /* STRING in Baum MENUE */
#define MPAGEFOR         85  /* STRING in Baum MENUE */
#define MFONT            86  /* STRING in Baum MENUE */
#define MUSERINT         88  /* STRING in Baum MENUE */
#define MDESIGNE         90  /* STRING in Baum MENUE */
#define MREORG           91  /* STRING in Baum MENUE */
#define MPROGRAM         92  /* STRING in Baum MENUE */
#define MFLUSH           94  /* STRING in Baum MENUE */
#define MLOCKSCR         95  /* STRING in Baum MENUE */
#define MCHNGPSS         96  /* STRING in Baum MENUE */
#define MREVERSE         98  /* STRING in Baum MENUE */
#define MORDERDE         99  /* STRING in Baum MENUE */
#define MHELPCXT         101 /* STRING in Baum MENUE */
#define MHELPINX         102 /* STRING in Baum MENUE */
#define MHELPCON         103 /* STRING in Baum MENUE */
#define MHELPOBJ         104 /* STRING in Baum MENUE */
#define MINFO            106 /* STRING in Baum MENUE */
#define MDBINFO          108 /* STRING in Baum MENUE */
#define MTBLINFO         109 /* STRING in Baum MENUE */
#define MINXINFO         110 /* STRING in Baum MENUE */

#define ABOUT            1   /* Formular/Dialog */
#define ALOGO            1   /* BOX in Baum ABOUT */
#define AVERSION         2   /* TEXT in Baum ABOUT */
#define ASERIAL          4   /* TEXT in Baum ABOUT */
#define ACOMPANY         7   /* TEXT in Baum ABOUT */
#define ANAME            9   /* TEXT in Baum ABOUT */
#define AOK              10  /* BUTTON in Baum ABOUT */
#define AINFO            11  /* BUTTON in Baum ABOUT */

#define DESKTOP          2   /* Formular/Dialog */
#define DTABLES          1   /* BOX in Baum DESKTOP */
#define DTBLBOX          2   /* IBOX in Baum DESKTOP */
#define DBASE            3   /* BUTTON in Baum DESKTOP */
#define DTBLLIST         4   /* BOX in Baum DESKTOP */
#define DINXLIST         5   /* BOX in Baum DESKTOP */
#define DASCEND          6   /* BUTTON in Baum DESKTOP */
#define DDESCEND         7   /* BUTTON in Baum DESKTOP */
#define ICONBAR          8   /* BOX in Baum DESKTOP */
#define ICNEW            10  /* BUTTON in Baum DESKTOP */
#define ICOPEN           11  /* BUTTON in Baum DESKTOP */
#define ICSAVE           12  /* BUTTON in Baum DESKTOP */
#define ICPRINT          13  /* BUTTON in Baum DESKTOP */
#define ICEXEC           14  /* BUTTON in Baum DESKTOP */
#define ICQBE            15  /* BUTTON in Baum DESKTOP */
#define ICREPDEF         16  /* BUTTON in Baum DESKTOP */
#define ICCALDEF         17  /* BUTTON in Baum DESKTOP */
#define ICBATDEF         18  /* BUTTON in Baum DESKTOP */
#define ICTABLE          19  /* BUTTON in Baum DESKTOP */
#define ICMASK           20  /* BUTTON in Baum DESKTOP */
#define ITABLE           21  /* ICON in Baum DESKTOP */
#define IPROCESS         39  /* ICON in Baum DESKTOP */
#define ITRASH           45  /* USERDEF in Baum DESKTOP */
#define IPRINTER         46  /* USERDEF in Baum DESKTOP */
#define IDISK            47  /* USERDEF in Baum DESKTOP */
#define ICLIPBRD         48  /* USERDEF in Baum DESKTOP */
#define FKEYS            49  /* IBOX in Baum DESKTOP */
#define INFOBOX          60  /* BUTTON in Baum DESKTOP */

#define USERIMG          3   /* Formular/Dialog */
#define RBHNORM          1   /* IMAGE in Baum USERIMG */
#define RBHSEL           2   /* IMAGE in Baum USERIMG */
#define CBHNORM          3   /* IMAGE in Baum USERIMG */
#define CBHSEL           4   /* IMAGE in Baum USERIMG */
#define RBLNORM          5   /* IMAGE in Baum USERIMG */
#define RBLSEL           6   /* IMAGE in Baum USERIMG */
#define CBLNORM          7   /* IMAGE in Baum USERIMG */
#define CBLSEL           8   /* IMAGE in Baum USERIMG */
#define RB7NORM          9   /* IMAGE in Baum USERIMG */
#define RB7SEL           10  /* IMAGE in Baum USERIMG */
#define CB7NORM          11  /* IMAGE in Baum USERIMG */
#define CB7SEL           12  /* IMAGE in Baum USERIMG */
#define RB5NORM          13  /* IMAGE in Baum USERIMG */
#define RB5SEL           14  /* IMAGE in Baum USERIMG */
#define CB5NORM          15  /* IMAGE in Baum USERIMG */
#define CB5SEL           16  /* IMAGE in Baum USERIMG */
#define ARROW6           17  /* IMAGE in Baum USERIMG */
#define ARROW8           18  /* IMAGE in Baum USERIMG */
#define ARROW10          19  /* IMAGE in Baum USERIMG */
#define ARROW12          20  /* IMAGE in Baum USERIMG */
#define ARROW14          21  /* IMAGE in Baum USERIMG */
#define ARROW16          22  /* IMAGE in Baum USERIMG */
#define ARROW32          23  /* IMAGE in Baum USERIMG */

#define ALERT            4   /* Formular/Dialog */

#define SELFILE          5   /* Formular/Dialog */
#define FLNAME           2   /* FBOXTEXT in Baum SELFILE */
#define FLDIR            4   /* STRING in Baum SELFILE */
#define FLNAMES          5   /* BOX in Baum SELFILE */
#define FLDIRS           6   /* BOX in Baum SELFILE */
#define FLTYPES          8   /* BUTTON in Baum SELFILE */
#define FLDRIVES         10  /* BUTTON in Baum SELFILE */
#define FLORDER          12  /* BUTTON in Baum SELFILE */
#define FLOK             13  /* BUTTON in Baum SELFILE */
#define FLCANCEL         14  /* BUTTON in Baum SELFILE */
#define FLHELP           15  /* BUTTON in Baum SELFILE */

#define SELPATH          6   /* Formular/Dialog */
#define PTDIR            2   /* STRING in Baum SELPATH */
#define PTDIRS           3   /* BOX in Baum SELPATH */
#define PTDRIVES         5   /* BUTTON in Baum SELPATH */
#define PTORDER          7   /* BUTTON in Baum SELPATH */
#define PTOK             8   /* BUTTON in Baum SELPATH */
#define PTCANCEL         9   /* BUTTON in Baum SELPATH */
#define PTHELP           10  /* BUTTON in Baum SELPATH */

#define SELFONT          7   /* Formular/Dialog */
#define FNNAME           2   /* FBOXTEXT in Baum SELFONT */
#define FNPOINT          4   /* FBOXTEXT in Baum SELFONT */
#define FNNAMES          5   /* BOX in Baum SELFONT */
#define FNPOINTS         6   /* BOX in Baum SELFONT */
#define FNEFFECT         7   /* BUTTON in Baum SELFONT */
#define FNTHICK          8   /* BUTTON in Baum SELFONT */
#define FNLIGHT          9   /* BUTTON in Baum SELFONT */
#define FNSKEWED         10  /* BUTTON in Baum SELFONT */
#define FNUNDER          11  /* BUTTON in Baum SELFONT */
#define FNOUTLN          12  /* BUTTON in Baum SELFONT */
#define FNCLABEL         13  /* STRING in Baum SELFONT */
#define FNCOLOR          14  /* BUTTON in Baum SELFONT */
#define FNORDER          16  /* BUTTON in Baum SELFONT */
#define FNSAMPLE         18  /* IBOX in Baum SELFONT */
#define FNOK             19  /* BUTTON in Baum SELFONT */
#define FNCANCEL         20  /* BUTTON in Baum SELFONT */
#define FNHELP           21  /* BUTTON in Baum SELFONT */

#define USERINTR         8   /* Formular/Dialog */
#define UISYSINX         3   /* BUTTON in Baum USERINTR */
#define UISYSCOL         5   /* BUTTON in Baum USERINTR */
#define UIUSE3D          7   /* BUTTON in Baum USERINTR */
#define UIROUND          8   /* BUTTON in Baum USERINTR */
#define UISTDFS          9   /* BUTTON in Baum USERINTR */
#define UICOLOR          12  /* BUTTON in Baum USERINTR */
#define UIPAT            14  /* BUTTON in Baum USERINTR */
#define UIUSEWND         15  /* BUTTON in Baum USERINTR */
#define UITOP            16  /* BUTTON in Baum USERINTR */
#define UISB             17  /* BUTTON in Baum USERINTR */
#define UICHECK          20  /* BUTTON in Baum USERINTR */
#define UIRADIO          22  /* BUTTON in Baum USERINTR */
#define UIARROW          24  /* BUTTON in Baum USERINTR */
#define UIROUNDB         26  /* BUTTON in Baum USERINTR */
#define UISHADOW         28  /* FBOXTEXT in Baum USERINTR */
#define UIOK             29  /* BUTTON in Baum USERINTR */
#define UICANCEL         30  /* BUTTON in Baum USERINTR */
#define UIRESET          31  /* BUTTON in Baum USERINTR */
#define UIHELP           32  /* BUTTON in Baum USERINTR */

#define HELPINX          9   /* Formular/Dialog */
#define HINDEX           1   /* STRING in Baum HELPINX */
#define HCONTENT         2   /* STRING in Baum HELPINX */
#define HHELP            3   /* STRING in Baum HELPINX */
#define HDESKTOP         4   /* STRING in Baum HELPINX */
#define HEDIT            5   /* STRING in Baum HELPINX */
#define HIMAGE           6   /* STRING in Baum HELPINX */
#define HMETA            7   /* STRING in Baum HELPINX */
#define HTRASH           8   /* STRING in Baum HELPINX */
#define HCLIPBRD         9   /* STRING in Baum HELPINX */
#define HLIST            10  /* STRING in Baum HELPINX */
#define HMASK            11  /* STRING in Baum HELPINX */
#define HQLIST           12  /* STRING in Baum HELPINX */
#define HQBE             13  /* STRING in Baum HELPINX */
#define HRLIST           14  /* STRING in Baum HELPINX */
#define HREPORT          15  /* STRING in Baum HELPINX */
#define HCLIST           16  /* STRING in Baum HELPINX */
#define HCALC            17  /* STRING in Baum HELPINX */
#define HBLIST           18  /* STRING in Baum HELPINX */
#define HBATCH           19  /* STRING in Baum HELPINX */
#define HPROCESS         20  /* STRING in Baum HELPINX */
#define HITRASH          21  /* STRING in Baum HELPINX */
#define HIPRINTE         22  /* STRING in Baum HELPINX */
#define HIDISK           23  /* STRING in Baum HELPINX */
#define HICLIP           24  /* STRING in Baum HELPINX */
#define HIPROCES         25  /* STRING in Baum HELPINX */
#define HITABLE          26  /* STRING in Baum HELPINX */
#define HITBLCLP         27  /* STRING in Baum HELPINX */
#define HALIST           28  /* STRING in Baum HELPINX */
#define HACCOUNT         29  /* STRING in Baum HELPINX */
#define HPROPERT         30  /* STRING in Baum HELPINX */
#define HPREVIEW         31  /* STRING in Baum HELPINX */
#define HOPENDB          32  /* STRING in Baum HELPINX */
#define HCONFIG          33  /* STRING in Baum HELPINX */
#define HIMEXPAR         34  /* STRING in Baum HELPINX */
#define HPRINTER         35  /* STRING in Baum HELPINX */
#define HPAGEFOR         36  /* STRING in Baum HELPINX */
#define HFONT            37  /* STRING in Baum HELPINX */
#define HCHNGPSS         38  /* STRING in Baum HELPINX */
#define HLOCKSCR         39  /* STRING in Baum HELPINX */
#define HDBINFO          40  /* STRING in Baum HELPINX */
#define HTBLINFO         41  /* STRING in Baum HELPINX */
#define HINXINFO         42  /* STRING in Baum HELPINX */
#define HQUEUE           43  /* STRING in Baum HELPINX */
#define HPROGPAR         44  /* STRING in Baum HELPINX */
#define HDELRECS         45  /* STRING in Baum HELPINX */
#define HCSAVEAS         46  /* STRING in Baum HELPINX */
#define HQSAVEAS         47  /* STRING in Baum HELPINX */
#define HRSAVEAS         48  /* STRING in Baum HELPINX */
#define HBSAVEAS         49  /* STRING in Baum HELPINX */
#define HASAVEAS         50  /* STRING in Baum HELPINX */
#define HORDER           51  /* STRING in Baum HELPINX */
#define HNEWWIDT         52  /* STRING in Baum HELPINX */
#define HCLIPNAM         53  /* STRING in Baum HELPINX */
#define HLSTSRCH         54  /* STRING in Baum HELPINX */
#define HMCHANGE         55  /* STRING in Baum HELPINX */
#define HJOIN            56  /* STRING in Baum HELPINX */
#define HMCONFIG         57  /* STRING in Baum HELPINX */
#define HREORGDB         58  /* STRING in Baum HELPINX */
#define HREORGPA         59  /* STRING in Baum HELPINX */
#define HREMSEL          60  /* STRING in Baum HELPINX */
#define HNEWPROC         61  /* STRING in Baum HELPINX */
#define HLSTPROC         62  /* STRING in Baum HELPINX */
#define HUSERINT         63  /* STRING in Baum HELPINX */
#define HSELFILE         64  /* STRING in Baum HELPINX */
#define HSELPATH         65  /* STRING in Baum HELPINX */
#define HCOPIES          66  /* STRING in Baum HELPINX */
#define HGETPARM         67  /* STRING in Baum HELPINX */

#define POPUP            10  /* Formular/Dialog */

#define POPUPS           11  /* Formular/Dialog */
#define METAINFO         1   /* BOX in Baum POPUPS */
#define MINF             2   /* STRING in Baum POPUPS */
#define MFULL            4   /* STRING in Baum POPUPS */
#define MBESTFIT         5   /* STRING in Baum POPUPS */
#define MICON            6   /* BOX in Baum POPUPS */
#define MINFOICO         7   /* STRING in Baum POPUPS */
#define MOPENICO         8   /* STRING in Baum POPUPS */
#define MDELICON         10  /* STRING in Baum POPUPS */
#define MSORTBAS         11  /* BOX in Baum POPUPS */
#define MSORTNAM         13  /* STRING in Baum POPUPS */
#define MSORTNUM         14  /* STRING in Baum POPUPS */

#define ICONS            12  /* Formular/Dialog */
#define ITBL             1   /* ICON in Baum ICONS */
#define ICLIP            2   /* ICON in Baum ICONS */
#define ISCRATCH         3   /* ICON in Baum ICONS */

#define LISTWIDT         13  /* Formular/Dialog */
#define LIWIDTH          3   /* STRING in Baum LISTWIDT */
#define LIRESULT         5   /* STRING in Baum LISTWIDT */

#define MONTHS           14  /* Formular/Dialog */
#define MOLONG           1   /* BOX in Baum MONTHS */
#define MOSHORT          14  /* BOX in Baum MONTHS */

#define LOADDB           15  /* Formular/Dialog */
#define LOADNAME         3   /* STRING in Baum LOADDB */

#define FLUSHKEY         16  /* Formular/Dialog */
#define FLUSHNAM         3   /* STRING in Baum FLUSHKEY */

#define INFMETA          17  /* Formular/Dialog */
#define MPAGEW           3   /* STRING in Baum INFMETA */
#define MPAGEH           6   /* STRING in Baum INFMETA */
#define MPICW            9   /* STRING in Baum INFMETA */
#define MPICH            12  /* STRING in Baum INFMETA */
#define MPIXW            16  /* STRING in Baum INFMETA */
#define MPIXH            19  /* STRING in Baum INFMETA */
#define MORIGOY          24  /* STRING in Baum INFMETA */
#define MFACTORX         26  /* STRING in Baum INFMETA */
#define MFACTORY         28  /* STRING in Baum INFMETA */
#define MORIGOX          29  /* STRING in Baum INFMETA */
#define MVDICALL         31  /* STRING in Baum INFMETA */

#define MOREINFO         18  /* Formular/Dialog */

#define SELBOX           19  /* Formular/Dialog */
#define SELSTR           2   /* FBOXTEXT in Baum SELBOX */
#define SELTITLE         3   /* STRING in Baum SELBOX */
#define SELLIST          4   /* BOX in Baum SELBOX */
#define SELOK            5   /* BUTTON in Baum SELBOX */
#define SELCANCE         6   /* BUTTON in Baum SELBOX */
#define SELHELP          7   /* BUTTON in Baum SELBOX */

#define CONFIG           20  /* Formular/Dialog */
#define CTMPLABE         1   /* STRING in Baum CONFIG */
#define CTMPDIR          2   /* FBOXTEXT in Baum CONFIG */
#define CBLINK           4   /* FBOXTEXT in Baum CONFIG */
#define CBEEP            6   /* BUTTON in Baum CONFIG */
#define CPRBEEP          7   /* BUTTON in Baum CONFIG */
#define CGROW            8   /* BUTTON in Baum CONFIG */
#define CAUTO            9   /* BUTTON in Baum CONFIG */
#define CUSEFONT         10  /* BUTTON in Baum CONFIG */
#define CHIDEFNC         11  /* BUTTON in Baum CONFIG */
#define CHIDEICO         12  /* BUTTON in Baum CONFIG */
#define CQUERY           13  /* BUTTON in Baum CONFIG */
#define CUSECALC         14  /* BUTTON in Baum CONFIG */
#define CMINIMIZ         15  /* BUTTON in Baum CONFIG */
#define CWARNTAB         16  /* BUTTON in Baum CONFIG */
#define CGRID            18  /* BUTTON in Baum CONFIG */
#define CINFO            19  /* BUTTON in Baum CONFIG */
#define CTOP             20  /* BUTTON in Baum CONFIG */
#define CLEFT            21  /* BUTTON in Baum CONFIG */
#define CPATTERN         22  /* BUTTON in Baum CONFIG */
#define CMAXIND          25  /* FBOXTEXT in Baum CONFIG */
#define CMAXDAT          27  /* FBOXTEXT in Baum CONFIG */
#define COK              28  /* BUTTON in Baum CONFIG */
#define CCANCEL          29  /* BUTTON in Baum CONFIG */
#define CHELP            30  /* BUTTON in Baum CONFIG */

#define IMEXPARM         21  /* Formular/Dialog */
#define EXRECSEP         3   /* FBOXTEXT in Baum IMEXPARM */
#define EXCOLSEP         5   /* FBOXTEXT in Baum IMEXPARM */
#define EXTXTSEP         7   /* FBOXTEXT in Baum IMEXPARM */
#define EXBINARY         9   /* BUTTON in Baum IMEXPARM */
#define EXASCII          10  /* BUTTON in Baum IMEXPARM */
#define EXCOLNAM         11  /* BUTTON in Baum IMEXPARM */
#define EXDECIMA         13  /* FBOXTEXT in Baum IMEXPARM */
#define EXDDMMYY         15  /* BUTTON in Baum IMEXPARM */
#define EXMMDDYY         16  /* BUTTON in Baum IMEXPARM */
#define EXYYMMDD         17  /* BUTTON in Baum IMEXPARM */
#define EXNUMBER         18  /* BUTTON in Baum IMEXPARM */
#define EXINSERT         20  /* BUTTON in Baum IMEXPARM */
#define EXUPDATE         21  /* BUTTON in Baum IMEXPARM */
#define EXOK             22  /* BUTTON in Baum IMEXPARM */
#define EXCANCEL         23  /* BUTTON in Baum IMEXPARM */
#define EXHELP           24  /* BUTTON in Baum IMEXPARM */
#define EXLOAD           25  /* BUTTON in Baum IMEXPARM */
#define EXSAVE           26  /* BUTTON in Baum IMEXPARM */

#define CFGPRN           22  /* Formular/Dialog */
#define PPRINTER         1   /* USERDEF in Baum CFGPRN */
#define PCONTROL         3   /* FBOXTEXT in Baum CFGPRN */
#define PFILELAB         4   /* STRING in Baum CFGPRN */
#define PFILENAM         5   /* FBOXTEXT in Baum CFGPRN */
#define PPICA            7   /* BUTTON in Baum CFGPRN */
#define PELITE           8   /* BUTTON in Baum CFGPRN */
#define PCONDENS         9   /* BUTTON in Baum CFGPRN */
#define PMICRO           10  /* BUTTON in Baum CFGPRN */
#define PEXPANDE         11  /* BUTTON in Baum CFGPRN */
#define PITALIC          12  /* BUTTON in Baum CFGPRN */
#define PEMPHASI         13  /* BUTTON in Baum CFGPRN */
#define PNLQ             14  /* BUTTON in Baum CFGPRN */
#define PPORTS           15  /* BUTTON in Baum CFGPRN */
#define PSPOOL           16  /* BUTTON in Baum CFGPRN */
#define PFILE            17  /* BUTTON in Baum CFGPRN */
#define PPORT1           18  /* BUTTON in Baum CFGPRN */
#define PPORT2           19  /* BUTTON in Baum CFGPRN */
#define PPORT3           20  /* BUTTON in Baum CFGPRN */
#define PPORT4           21  /* BUTTON in Baum CFGPRN */
#define PPORT5           22  /* BUTTON in Baum CFGPRN */
#define PEVENTS          25  /* FBOXTEXT in Baum CFGPRN */
#define PBYTES           27  /* FBOXTEXT in Baum CFGPRN */
#define PLSPACE6         29  /* BUTTON in Baum CFGPRN */
#define PLSPACE8         30  /* BUTTON in Baum CFGPRN */
#define PDRIVER          31  /* BUTTON in Baum CFGPRN */
#define POK              32  /* BUTTON in Baum CFGPRN */
#define PCANCEL          33  /* BUTTON in Baum CFGPRN */
#define PHELP            34  /* BUTTON in Baum CFGPRN */
#define PLOAD            35  /* BUTTON in Baum CFGPRN */
#define PSAVE            36  /* BUTTON in Baum CFGPRN */

#define QUEUE            23  /* Formular/Dialog */
#define QLIST            5   /* BOX in Baum QUEUE */
#define QOK              6   /* BUTTON in Baum QUEUE */
#define QHELP            7   /* BUTTON in Baum QUEUE */

#define PAGEFORM         24  /* Formular/Dialog */
#define PGHEADL          3   /* FBOXTEXT in Baum PAGEFORM */
#define PGHEADC          4   /* FBOXTEXT in Baum PAGEFORM */
#define PGHEADR          5   /* FBOXTEXT in Baum PAGEFORM */
#define PGFOOTL          7   /* FBOXTEXT in Baum PAGEFORM */
#define PGFOOTC          8   /* FBOXTEXT in Baum PAGEFORM */
#define PGFOOTR          9   /* FBOXTEXT in Baum PAGEFORM */
#define PGBASE           10  /* BUTTON in Baum PAGEFORM */
#define PGSORT           11  /* BUTTON in Baum PAGEFORM */
#define PGPAGE           12  /* BUTTON in Baum PAGEFORM */
#define PGDATE           13  /* BUTTON in Baum PAGEFORM */
#define PGTIME           14  /* BUTTON in Baum PAGEFORM */
#define PGWIDTH          17  /* FBOXTEXT in Baum PAGEFORM */
#define PGLENGTH         19  /* FBOXTEXT in Baum PAGEFORM */
#define PGMARTOP         21  /* FBOXTEXT in Baum PAGEFORM */
#define PGMARBOT         23  /* FBOXTEXT in Baum PAGEFORM */
#define PGMARHEA         25  /* FBOXTEXT in Baum PAGEFORM */
#define PGMARFOO         27  /* FBOXTEXT in Baum PAGEFORM */
#define PGMARLEF         29  /* FBOXTEXT in Baum PAGEFORM */
#define PGLINES          31  /* STRING in Baum PAGEFORM */
#define PGFORMAD         33  /* BUTTON in Baum PAGEFORM */
#define PGCOLHEA         34  /* BUTTON in Baum PAGEFORM */
#define PGSUM            35  /* BUTTON in Baum PAGEFORM */
#define PGGROUP          37  /* FBOXTEXT in Baum PAGEFORM */
#define PGOK             38  /* BUTTON in Baum PAGEFORM */
#define PGCANCEL         39  /* BUTTON in Baum PAGEFORM */
#define PGHELP           40  /* BUTTON in Baum PAGEFORM */
#define PGLOAD           41  /* BUTTON in Baum PAGEFORM */
#define PGSAVE           42  /* BUTTON in Baum PAGEFORM */

#define PROCBOX          25  /* Formular/Dialog */
#define PRFILE           1   /* STRING in Baum PROCBOX */
#define PRDBNAME         2   /* STRING in Baum PROCBOX */
#define PRINDEX          3   /* STRING in Baum PROCBOX */
#define PRRUNNIN         6   /* TEXT in Baum PROCBOX */
#define PRREMAIN         8   /* TEXT in Baum PROCBOX */
#define PRPAUSE          9   /* BUTTON in Baum PROCBOX */
#define PREXCLUS         10  /* BUTTON in Baum PROCBOX */
#define PRRECLBL         11  /* STRING in Baum PROCBOX */
#define PRRECORD         12  /* TEXT in Baum PROCBOX */
#define PRUPPER          14  /* STRING in Baum PROCBOX */
#define PRSLIDER         15  /* BOX in Baum PROCBOX */
#define PRICON           16  /* BUTTON in Baum PROCBOX */
#define PRHELP           17  /* BUTTON in Baum PROCBOX */

#define OPENDB           26  /* Formular/Dialog */
#define BBASE            2   /* STRING in Baum OPENDB */
#define BUSER            4   /* FBOXTEXT in Baum OPENDB */
#define BPASS            6   /* FBOXTEXT in Baum OPENDB */
#define BINDCACH         9   /* FBOXTEXT in Baum OPENDB */
#define BDATCACH         12  /* FBOXTEXT in Baum OPENDB */
#define BINDFLSH         14  /* BUTTON in Baum OPENDB */
#define BDATFLSH         15  /* BUTTON in Baum OPENDB */
#define BSINGLE          17  /* BUTTON in Baum OPENDB */
#define BMULTASK         18  /* BUTTON in Baum OPENDB */
#define BMULUSER         19  /* BUTTON in Baum OPENDB */
#define BRDONLY          20  /* BUTTON in Baum OPENDB */
#define BOK              21  /* BUTTON in Baum OPENDB */
#define BCANCEL          22  /* BUTTON in Baum OPENDB */
#define BHELP            23  /* BUTTON in Baum OPENDB */

#define DBINFO           27  /* Formular/Dialog */
#define DIDBNAME         2   /* STRING in Baum DBINFO */
#define DIUSER           4   /* STRING in Baum DBINFO */
#define DICREAT          6   /* STRING in Baum DBINFO */
#define DILASTUS         8   /* STRING in Baum DBINFO */
#define DIDATSIZ         11  /* STRING in Baum DBINFO */
#define DIDATUSE         13  /* STRING in Baum DBINFO */
#define DIDATUSP         14  /* STRING in Baum DBINFO */
#define DIDATFRE         16  /* STRING in Baum DBINFO */
#define DIDATFRP         17  /* STRING in Baum DBINFO */
#define DIDATCAC         19  /* STRING in Baum DBINFO */
#define DIDATHIT         21  /* STRING in Baum DBINFO */
#define DIDATFLU         23  /* STRING in Baum DBINFO */
#define DIHOLES          25  /* STRING in Baum DBINFO */
#define DIHOLESP         26  /* STRING in Baum DBINFO */
#define DIDATMOD         28  /* STRING in Baum DBINFO */
#define DIRDWR           30  /* STRING in Baum DBINFO */
#define DIINDSIZ         33  /* STRING in Baum DBINFO */
#define DIINDUSE         35  /* STRING in Baum DBINFO */
#define DIINDUSP         36  /* STRING in Baum DBINFO */
#define DIINDFRE         38  /* STRING in Baum DBINFO */
#define DIINDFRP         39  /* STRING in Baum DBINFO */
#define DIINDCAC         41  /* STRING in Baum DBINFO */
#define DIINDHIT         43  /* STRING in Baum DBINFO */
#define DIINDFLU         45  /* STRING in Baum DBINFO */
#define DIOK             46  /* BUTTON in Baum DBINFO */
#define DIHELP           47  /* BUTTON in Baum DBINFO */

#define TBLINFO          28  /* Formular/Dialog */
#define TIDBNAME         2   /* STRING in Baum TBLINFO */
#define TITABLE          4   /* STRING in Baum TBLINFO */
#define TIRECS           6   /* STRING in Baum TBLINFO */
#define TICOLS           8   /* STRING in Baum TBLINFO */
#define TIINXS           10  /* STRING in Baum TBLINFO */
#define TISIZE           12  /* STRING in Baum TBLINFO */
#define TICALC           14  /* STRING in Baum TBLINFO */
#define TILIST           19  /* BOX in Baum TBLINFO */
#define TIOK             20  /* BUTTON in Baum TBLINFO */
#define TIHELP           21  /* BUTTON in Baum TBLINFO */

#define INXINFO          29  /* Formular/Dialog */
#define IIDBNAME         2   /* STRING in Baum INXINFO */
#define IITABLE          4   /* STRING in Baum INXINFO */
#define IINAME           6   /* STRING in Baum INXINFO */
#define IIINDEX          8   /* STRING in Baum INXINFO */
#define IITYPE           10  /* STRING in Baum INXINFO */
#define IIPRIMAR         13  /* STRING in Baum INXINFO */
#define IIUNIQUE         15  /* STRING in Baum INXINFO */
#define IIFOREIG         17  /* STRING in Baum INXINFO */
#define IIROOT           19  /* STRING in Baum INXINFO */
#define IINUMKEY         21  /* STRING in Baum INXINFO */
#define IIOK             22  /* BUTTON in Baum INXINFO */
#define IIHELP           23  /* BUTTON in Baum INXINFO */

#define PARAMS           30  /* Formular/Dialog */
#define PARPROG          2   /* STRING in Baum PARAMS */
#define PARPARAM         4   /* FBOXTEXT in Baum PARAMS */
#define PAROK            5   /* BUTTON in Baum PARAMS */
#define PARCANCE         6   /* BUTTON in Baum PARAMS */
#define PARHELP          7   /* BUTTON in Baum PARAMS */

#define GETPARM          31  /* Formular/Dialog */
#define GPPARM           2   /* STRING in Baum GETPARM */
#define GPVALUE          4   /* FBOXTEXT in Baum GETPARM */
#define GPOK             5   /* BUTTON in Baum GETPARM */
#define GPCANCEL         6   /* BUTTON in Baum GETPARM */
#define GPHELP           7   /* BUTTON in Baum GETPARM */

#define LOCKSCRN         32  /* Formular/Dialog */
#define LOCKBOX          1   /* BOX in Baum LOCKSCRN */
#define LOCKNAME         3   /* STRING in Baum LOCKSCRN */
#define LOCKPASS         5   /* FBOXTEXT in Baum LOCKSCRN */
#define LOCKOK           6   /* BUTTON in Baum LOCKSCRN */
#define LOCKHELP         7   /* BUTTON in Baum LOCKSCRN */

#define CHNGPASS         33  /* Formular/Dialog */
#define CHNAME           2   /* STRING in Baum CHNGPASS */
#define CHUSER           4   /* STRING in Baum CHNGPASS */
#define CHOLDPSS         6   /* FBOXTEXT in Baum CHNGPASS */
#define CHNEWPSS         8   /* FBOXTEXT in Baum CHNGPASS */
#define CHVERIFY         10  /* FBOXTEXT in Baum CHNGPASS */
#define CHOK             11  /* BUTTON in Baum CHNGPASS */
#define CHCANCEL         12  /* BUTTON in Baum CHNGPASS */
#define CHHELP           13  /* BUTTON in Baum CHNGPASS */

#define DELRECS          34  /* Formular/Dialog */
#define DELDBNAM         2   /* STRING in Baum DELRECS */
#define DELTABLE         4   /* STRING in Baum DELRECS */
#define DELNUMRE         6   /* STRING in Baum DELRECS */
#define DELOK            7   /* BUTTON in Baum DELRECS */
#define DELHELP          8   /* BUTTON in Baum DELRECS */
#define DELCANCE         9   /* BUTTON in Baum DELRECS */

#define REMSEL           35  /* Formular/Dialog */
#define RMDBNAME         2   /* STRING in Baum REMSEL */
#define RMTABLE          4   /* STRING in Baum REMSEL */
#define RMFROM           6   /* FBOXTEXT in Baum REMSEL */
#define RMTO             8   /* FBOXTEXT in Baum REMSEL */
#define RMOK             9   /* BUTTON in Baum REMSEL */
#define RMCANCEL         10  /* BUTTON in Baum REMSEL */
#define RMHELP           11  /* BUTTON in Baum REMSEL */

#define COPIES           36  /* Formular/Dialog */
#define CPNUM            4   /* FBOXTEXT in Baum COPIES */
#define CPSCREEN         5   /* BUTTON in Baum COPIES */
#define CPDISK           6   /* BUTTON in Baum COPIES */
#define CPPRINT          7   /* BUTTON in Baum COPIES */
#define CPCANCEL         8   /* BUTTON in Baum COPIES */
#define CPHELP           9   /* BUTTON in Baum COPIES */

#define CLIPNAME         37  /* Formular/Dialog */
#define CLNAME           2   /* FBOXTEXT in Baum CLIPNAME */
#define CLOK             3   /* BUTTON in Baum CLIPNAME */
#define CLCANCEL         4   /* BUTTON in Baum CLIPNAME */
#define CLHELP           5   /* BUTTON in Baum CLIPNAME */

#define LISTSRCH         38  /* Formular/Dialog */
#define LIDBNAME         2   /* STRING in Baum LISTSRCH */
#define LITABLE          4   /* STRING in Baum LISTSRCH */
#define LIINDEXL         5   /* STRING in Baum LISTSRCH */
#define LIINDEX          6   /* STRING in Baum LISTSRCH */
#define LISEARCH         8   /* FBOXTEXT in Baum LISTSRCH */
#define LIOK             9   /* BUTTON in Baum LISTSRCH */
#define LICANCEL         10  /* BUTTON in Baum LISTSRCH */
#define LIHELP           11  /* BUTTON in Baum LISTSRCH */
#define LIDIR            13  /* BUTTON in Baum LISTSRCH */
#define LIASC            14  /* BUTTON in Baum LISTSRCH */
#define LIDESC           15  /* BUTTON in Baum LISTSRCH */
#define LITEXT           16  /* BUTTON in Baum LISTSRCH */
#define LICASE           17  /* BUTTON in Baum LISTSRCH */

#define NEWWIDTH         39  /* Formular/Dialog */
#define NWCOLUMN         2   /* STRING in Baum NEWWIDTH */
#define NWWIDTH          4   /* FBOXTEXT in Baum NEWWIDTH */
#define NWMIN            6   /* STRING in Baum NEWWIDTH */
#define NWMAX            8   /* STRING in Baum NEWWIDTH */
#define NWRESULT         10  /* STRING in Baum NEWWIDTH */
#define NWOK             11  /* BUTTON in Baum NEWWIDTH */
#define NWCANCEL         12  /* BUTTON in Baum NEWWIDTH */
#define NWHELP           13  /* BUTTON in Baum NEWWIDTH */

#define ORDER            40  /* Formular/Dialog */
#define ORDBNAME         2   /* STRING in Baum ORDER */
#define ORTABLE          4   /* STRING in Baum ORDER */
#define ORCOLS           8   /* BOX in Baum ORDER */
#define ORINXS           9   /* BOX in Baum ORDER */
#define ORCOPY           10  /* BUTTON in Baum ORDER */
#define ORDELETE         11  /* BUTTON in Baum ORDER */
#define ORASC            13  /* BUTTON in Baum ORDER */
#define ORDESC           14  /* BUTTON in Baum ORDER */
#define OROK             15  /* BUTTON in Baum ORDER */
#define ORCANCEL         16  /* BUTTON in Baum ORDER */
#define ORNEW            17  /* BUTTON in Baum ORDER */
#define ORHELP           18  /* BUTTON in Baum ORDER */

#define REORGPAR         41  /* Formular/Dialog */
#define REORGDB          2   /* STRING in Baum REORGPAR */
#define REORGFLG         4   /* BUTTON in Baum REORGPAR */
#define REORGIND         5   /* BUTTON in Baum REORGPAR */
#define REORGDAT         6   /* BUTTON in Baum REORGPAR */
#define REORGCRY         7   /* BUTTON in Baum REORGPAR */
#define REORGOK          8   /* BUTTON in Baum REORGPAR */
#define REORGCAN         9   /* BUTTON in Baum REORGPAR */
#define REORGHLP         10  /* BUTTON in Baum REORGPAR */

#define SORTING          42  /* Formular/Dialog */
#define REORGNAM         2   /* STRING in Baum SORTING */
#define SORTNAME         3   /* STRING in Baum SORTING */
#define SORTPASS         5   /* STRING in Baum SORTING */
#define SORTDB           7   /* STRING in Baum SORTING */
#define SORTTBL          9   /* STRING in Baum SORTING */
#define SORTREC          11  /* STRING in Baum SORTING */
#define SORTRECS         13  /* STRING in Baum SORTING */

#define STATIST          43  /* Formular/Dialog */
#define STATNAME         2   /* STRING in Baum STATIST */
#define STATALL          5   /* STRING in Baum STATIST */
#define STATLOST         7   /* STRING in Baum STATIST */
#define STATDEL          9   /* STRING in Baum STATIST */
#define STATBEFO         12  /* STRING in Baum STATIST */
#define STATAFTE         14  /* STRING in Baum STATIST */
#define STATGAIN         16  /* STRING in Baum STATIST */
#define STATPERC         17  /* STRING in Baum STATIST */
#define STATOK           18  /* BUTTON in Baum STATIST */

#define NEWPROC          44  /* Formular/Dialog */
#define NPQUERY          2   /* BUTTON in Baum NEWPROC */
#define NPACC            3   /* BUTTON in Baum NEWPROC */
#define NPCALC           4   /* BUTTON in Baum NEWPROC */
#define NPBATCH          5   /* BUTTON in Baum NEWPROC */
#define NPREPORT         6   /* BUTTON in Baum NEWPROC */
#define NPOK             7   /* BUTTON in Baum NEWPROC */
#define NPCANCEL         8   /* BUTTON in Baum NEWPROC */
#define NPHELP           9   /* BUTTON in Baum NEWPROC */

#define NEWPROCMENU      45  /* Formular/Dialog */
#define NPMENUQBE        1   /* STRING in Baum NEWPROCMENU */
#define NPMENUACC        2   /* STRING in Baum NEWPROCMENU */
#define NPMENUCALC       3   /* STRING in Baum NEWPROCMENU */
#define NPMWENUBATCH     4   /* STRING in Baum NEWPROCMENU */
#define NPMENUREPORT     5   /* STRING in Baum NEWPROCMENU */

#define LISTICON         46  /* Formular/Dialog */
#define LCINFO           1   /* IBOX in Baum LISTICON */
#define LCORDER          2   /* STRING in Baum LISTICON */
#define LCBOX            3   /* IBOX in Baum LISTICON */
#define LCINDEX          4   /* BUTTON in Baum LISTICON */
#define LCASC            5   /* BUTTON in Baum LISTICON */
#define LCDESC           6   /* BUTTON in Baum LISTICON */
#define LCSEARCH         7   /* BUTTON in Baum LISTICON */
#define LCMASK           8   /* BUTTON in Baum LISTICON */

#define QBEICON          47  /* Formular/Dialog */
#define QISORT           2   /* BUTTON in Baum QBEICON */
#define QICOMP           3   /* BUTTON in Baum QBEICON */

#define RPRTICON         48  /* Formular/Dialog */
#define REPTBL           3   /* BUTTON in Baum RPRTICON */
#define REPCOL           5   /* BUTTON in Baum RPRTICON */
#define REPINX           7   /* BUTTON in Baum RPRTICON */
#define RIDATE           8   /* BUTTON in Baum RPRTICON */
#define RITIME           9   /* BUTTON in Baum RPRTICON */
#define RITSTAMP         10  /* BUTTON in Baum RPRTICON */
#define RICOUNT          11  /* BUTTON in Baum RPRTICON */
#define RIBRANCH         12  /* BUTTON in Baum RPRTICON */
#define RIRETURN         13  /* BUTTON in Baum RPRTICON */
#define RIADD            14  /* BUTTON in Baum RPRTICON */

#define CALCICON         49  /* Formular/Dialog */
#define CALTBL           3   /* BUTTON in Baum CALCICON */
#define CALCOL           5   /* BUTTON in Baum CALCICON */
#define CALINX           7   /* BUTTON in Baum CALCICON */
#define CALOP            9   /* BUTTON in Baum CALCICON */

#define BATICON          50  /* Formular/Dialog */
#define BATCMD           3   /* BUTTON in Baum BATICON */
#define BATPARM          5   /* BUTTON in Baum BATICON */

#define ACCICON          51  /* Formular/Dialog */
#define ACCINFBX         1   /* IBOX in Baum ACCICON */
#define ACCINFO          2   /* STRING in Baum ACCICON */
#define ACCTOOLS         3   /* IBOX in Baum ACCICON */
#define ACCARROW         4   /* BUTTON in Baum ACCICON */
#define ACCTEXT          5   /* BUTTON in Baum ACCICON */
#define ACCCOL           6   /* BUTTON in Baum ACCICON */
#define ACCGROUP         7   /* BUTTON in Baum ACCICON */
#define ACCRBUTT         8   /* BUTTON in Baum ACCICON */
#define ACCCHECK         9   /* BUTTON in Baum ACCICON */
#define ACCLINE          10  /* BUTTON in Baum ACCICON */
#define ACCBOX           11  /* BUTTON in Baum ACCICON */
#define ACCGRAF          12  /* BUTTON in Baum ACCICON */
#define ACCSUB           13  /* BUTTON in Baum ACCICON */
#define ACCLOCK          14  /* BUTTON in Baum ACCICON */
#define ACCCOLUM         16  /* BUTTON in Baum ACCICON */
#define ACCZOOM          17  /* BUTTON in Baum ACCICON */

#define PREVICON         52  /* Formular/Dialog */
#define PIBOX            1   /* IBOX in Baum PREVICON */
#define PIFIRST          2   /* BUTTON in Baum PREVICON */
#define PIPREV           3   /* BUTTON in Baum PREVICON */
#define PINEXT           4   /* BUTTON in Baum PREVICON */
#define PILAST           5   /* BUTTON in Baum PREVICON */
#define PIBW             6   /* BUTTON in Baum PREVICON */
#define PIZOOM           7   /* BUTTON in Baum PREVICON */
#define PIPAGENR         8   /* STRING in Baum PREVICON */

#define MASKMENU         53  /* Menuebaum */
#define MMINFO           3   /* TITLE in Baum MASKMENU */
#define MMRECORD         4   /* TITLE in Baum MASKMENU */
#define MMACTION         5   /* TITLE in Baum MASKMENU */
#define MMOPTION         6   /* TITLE in Baum MASKMENU */
#define MMASKINF         9   /* STRING in Baum MASKMENU */
#define MMSAVE           11  /* STRING in Baum MASKMENU */
#define MMINSERT         12  /* STRING in Baum MASKMENU */
#define MMUPDATE         13  /* STRING in Baum MASKMENU */
#define MMSEARCH         14  /* STRING in Baum MASKMENU */
#define MMMULTI          15  /* STRING in Baum MASKMENU */
#define MMDELETE         17  /* STRING in Baum MASKMENU */
#define MMCALC           19  /* STRING in Baum MASKMENU */
#define MMCLEAR          21  /* STRING in Baum MASKMENU */
#define MMPREV           23  /* STRING in Baum MASKMENU */
#define MMNEXT           24  /* STRING in Baum MASKMENU */
#define MMFIRST          25  /* STRING in Baum MASKMENU */
#define MMLAST           26  /* STRING in Baum MASKMENU */
#define MMIMPORT         28  /* STRING in Baum MASKMENU */
#define MMEXPORT         29  /* STRING in Baum MASKMENU */
#define MMOPEN           30  /* STRING in Baum MASKMENU */
#define MMFILENA         32  /* STRING in Baum MASKMENU */
#define MMCHANGE         34  /* STRING in Baum MASKMENU */
#define MMJOIN           35  /* STRING in Baum MASKMENU */
#define MMPOPUP          36  /* STRING in Baum MASKMENU */

#define MASKICON         54  /* Formular/Dialog */
#define MIINFO           1   /* IBOX in Baum MASKICON */
#define MIORDER          2   /* STRING in Baum MASKICON */
#define MIBOX            3   /* IBOX in Baum MASKICON */
#define MIINDEX          4   /* BUTTON in Baum MASKICON */
#define MIASC            5   /* BUTTON in Baum MASKICON */
#define MIDESC           6   /* BUTTON in Baum MASKICON */
#define MIFIRST          7   /* BUTTON in Baum MASKICON */
#define MIPREV           8   /* BUTTON in Baum MASKICON */
#define MINEXT           9   /* BUTTON in Baum MASKICON */
#define MILAST           10  /* BUTTON in Baum MASKICON */
#define MISAVE           11  /* BUTTON in Baum MASKICON */
#define MISEARCH         12  /* BUTTON in Baum MASKICON */
#define MICLEAR          13  /* BUTTON in Baum MASKICON */
#define MICALC           14  /* BUTTON in Baum MASKICON */
#define MIDELETE         15  /* BUTTON in Baum MASKICON */

#define MASKCONF         55  /* Formular/Dialog */
#define MCCLEAR          2   /* BUTTON in Baum MASKCONF */
#define MCFSEL           3   /* BUTTON in Baum MASKCONF */
#define MCPOSPOP         4   /* BUTTON in Baum MASKCONF */
#define MCDELETE         5   /* BUTTON in Baum MASKCONF */
#define MCPLAY           7   /* BUTTON in Baum MASKCONF */
#define MCVOLUME         9   /* FBOXTEXT in Baum MASKCONF */
#define MCOK             10  /* BUTTON in Baum MASKCONF */
#define MCCANCEL         11  /* BUTTON in Baum MASKCONF */
#define MCHELP           12  /* BUTTON in Baum MASKCONF */

#define JOIN             56  /* Formular/Dialog */
#define JSTABLE          2   /* STRING in Baum JOIN */
#define JSI              6   /* BOX in Baum JOIN */
#define JDT              7   /* BOX in Baum JOIN */
#define JDI              8   /* BOX in Baum JOIN */
#define JOK              9   /* BUTTON in Baum JOIN */
#define JCANCEL          10  /* BUTTON in Baum JOIN */
#define JHELP            11  /* BUTTON in Baum JOIN */
#define JASCEND          12  /* BUTTON in Baum JOIN */
#define JDESCEND         13  /* BUTTON in Baum JOIN */

#define HELPMENU         57  /* Menuebaum */
#define MHINFO           3   /* TITLE in Baum HELPMENU */
#define MHFILE           4   /* TITLE in Baum HELPMENU */
#define MHEDIT           5   /* TITLE in Baum HELPMENU */
#define MHHELP           6   /* TITLE in Baum HELPMENU */
#define MHELPINF         9   /* STRING in Baum HELPMENU */
#define MHOPENDB         11  /* STRING in Baum HELPMENU */
#define MHCLOSED         12  /* STRING in Baum HELPMENU */
#define MHUNDO           14  /* STRING in Baum HELPMENU */
#define MHNEXT           16  /* STRING in Baum HELPMENU */
#define MHPREV           17  /* STRING in Baum HELPMENU */
#define MHUSEHLP         19  /* STRING in Baum HELPMENU */
#define MHCONTEN         20  /* STRING in Baum HELPMENU */

#define HABOUT           58  /* Formular/Dialog */

#define NOWINDOW         0   /* Alert String */

#define NOMEMORY         1   /* Alert String */

#define NOHLPINX         2   /* Alert String */
