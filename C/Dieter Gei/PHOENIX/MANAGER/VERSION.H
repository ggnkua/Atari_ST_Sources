/*****************************************************************************
 *
 * Module : VERSION.H
 * Author : Gerhard Stoll
 *
 * Creation date    : 15.06.02
 * Last modification:
 *
 *
 * Description: Verwaltung der Versionsnummer des Managers
 *
 * History:
 * 22.12.07: Version 5.1f
 * 05.08.05: Version 5.1f
 * 15.02.04: Version 5.1e
 * 28.12.02: Version 5.1c
 * 15.06.02: Define erstellt
 *****************************************************************************/

#ifndef __VERSION__
#define __VERSION__

/****** DEFINES **************************************************************/

#define MANAGER_VERSION "Version 5.2"

#endif /* __VERSION__ */
