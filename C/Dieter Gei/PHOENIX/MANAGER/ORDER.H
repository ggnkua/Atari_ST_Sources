/*****************************************************************************/
/*                                                                           */
/* Modul: ORDER.H                                                            */
/* Datum: 08/08/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __ORDER__
#define __ORDER__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN init_order _((VOID));
GLOBAL BOOLEAN term_order _((VOID));

GLOBAL BOOLEAN hndl_order _((DB *db, WORD table, WORD *numsort, WORD *colsort));

#endif /* __ORDER__ */

