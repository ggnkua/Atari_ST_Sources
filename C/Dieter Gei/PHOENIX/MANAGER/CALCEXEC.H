/*****************************************************************************/
/*                                                                           */
/* Modul: CALCEXEC.H                                                         */
/* Datum: 11/08/91                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __CALCEXEC__
#define __CALCEXEC__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN calc_list _((DB *db, WORD table, WORD inx, WORD dir, CALCCODE *calccode, BOOLEAN minimize));

#endif /* __CALCEXEC__ */

