/*****************************************************************************/
/*                                                                           */
/* Modul: MINXINFO.H                                                         */
/* Datum: 05/05/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MINXINFO__
#define __MINXINFO__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID set_inxinfo   _((VOID));
GLOBAL VOID check_inxinfo _((VOID));
GLOBAL VOID minxinfo      _((VOID));

#endif /* __MINXINFO__ */

