/*****************************************************************************/
/*                                                                           */
/* Modul: MDBINFO.H                                                         */
/* Datum: 05/05/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MDBINFO__
#define __MDBINFO__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID set_dbinfo   _((VOID));
GLOBAL VOID check_dbinfo _((VOID));
GLOBAL VOID mdbinfo      _((VOID));

#endif /* __MDBINFO__ */

