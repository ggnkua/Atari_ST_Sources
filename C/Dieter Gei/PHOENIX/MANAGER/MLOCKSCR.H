/*****************************************************************************/
/*                                                                           */
/* Modul: MLOCKSCR.H                                                         */
/* Datum: 13/08/91                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MLOCKSCR__
#define __MLOCKSCR__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mlockscreen _((DB *db));

#endif /* __MLOCKSCR__ */

