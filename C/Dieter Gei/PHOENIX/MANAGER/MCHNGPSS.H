/*****************************************************************************/
/*                                                                           */
/* Modul: MCHNGPSS.H                                                         */
/* Datum: 05/05/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MCHNGPSS__
#define __MCHNGPSS__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mchangepass _((VOID));

#endif /* __MCHNGPSS__ */

