/*****************************************************************************/
/*                                                                           */
/* Modul: SHELL.H                                                            */
/* Datum: 08/02/91                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __SHELL__
#define __SHELL__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN init_shell _((VOID));
GLOBAL BOOLEAN term_shell _((VOID));

GLOBAL VOID call_designer _((VOID));
GLOBAL VOID call_program  _((VOID));

#endif /* __SHELL__ */

