/*****************************************************************************/
/*                                                                           */
/* Modul: MCONFIG.H                                                          */
/* Datum: 05/05/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MCONFIG__
#define __MCONFIG__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN init_mconfig _((VOID));
GLOBAL BOOLEAN term_mconfig _((VOID));

GLOBAL VOID    get_config   _((VOID));
GLOBAL VOID    set_config   _((VOID));

GLOBAL VOID    mconfig      _((VOID));

#endif /* __MCONFIG__ */

