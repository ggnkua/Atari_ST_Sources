/*****************************************************************************/
/*                                                                           */
/* Modul: MTBLINFO.H                                                         */
/* Datum: 05/05/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MTBLINFO__
#define __MTBLINFO__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID set_tblinfo   _((VOID));
GLOBAL VOID check_tblinfo _((VOID));
GLOBAL VOID mtblinfo      _((VOID));

#endif /* __MTBLINFO__ */

