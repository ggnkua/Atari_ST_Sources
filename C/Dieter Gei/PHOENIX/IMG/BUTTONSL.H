LOCAL UBYTE buttonsl [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x20, 
  0x80, 0x04, 0x3F, 0xFC, 0x3F, 0xFC, 0x80, 0x04, 0x20, 0x04, 0x38, 0x1C, 0x80, 0x04, 0x20, 0x04, 
  0x26, 0x64, 0x80, 0x04, 0x20, 0x04, 0x21, 0x84, 0x80, 0x04, 0x20, 0x04, 0x26, 0x64, 0x80, 0x04, 
  0x20, 0x04, 0x38, 0x1C, 0x80, 0x04, 0x3F, 0xFC, 0x3F, 0xFC, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 
  0x80, 0x04, 0x0F, 0xF0, 0x0F, 0xF0, 0x80, 0x04, 0x78, 0x1E, 0x78, 0x1E, 0x80, 0x04, 0xE0, 0x07, 
  0xE3, 0xC7, 0x80, 0x04, 0xC0, 0x03, 0xCF, 0xF3, 0x80, 0x04, 0xC0, 0x03, 0xCF, 0xF3, 0x80, 0x04, 
  0xE0, 0x07, 0xE3, 0xC7, 0x80, 0x04, 0x78, 0x1E, 0x78, 0x1E, 0x80, 0x04, 0x0F, 0xF0, 0x0F, 0xF0, 
  0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 
  0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 
  0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 
  0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 
  0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 
  0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 
}; /* buttonsl */

