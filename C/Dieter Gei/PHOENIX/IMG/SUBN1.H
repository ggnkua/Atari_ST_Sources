LOCAL UBYTE subn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x83, 0xFF, 0xFF, 0x81, 0x80, 0x04, 0x82, 0x00, 0x00, 0x81, 
  0x80, 0x04, 0x82, 0x00, 0x00, 0x81, 0x80, 0x04, 0x82, 0x7E, 0x7C, 0x81, 0x80, 0x04, 0x82, 0x00, 
  0x44, 0x81, 0x80, 0x04, 0x82, 0x00, 0x44, 0x81, 0x80, 0x04, 0x82, 0x7E, 0x7C, 0x81, 0x80, 0x04, 
  0x82, 0x00, 0x00, 0x81, 0x80, 0x04, 0x82, 0x00, 0x00, 0x81, 0x80, 0x04, 0x82, 0x7E, 0x7C, 0x81, 
  0x80, 0x04, 0x82, 0x00, 0x44, 0x81, 0x80, 0x04, 0x82, 0x00, 0x44, 0x81, 0x80, 0x04, 0x82, 0x7E, 
  0x7C, 0x81, 0x80, 0x04, 0x82, 0x00, 0x00, 0x81, 0x80, 0x04, 0x82, 0x00, 0x00, 0x81, 0x80, 0x04, 
  0x83, 0xFF, 0xFF, 0x81, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* subn1 */

