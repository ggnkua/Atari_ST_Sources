LOCAL UBYTE prt1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x55, 0x00, 0x55, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x70, 0x80, 0x02, 0x00, 0x8C, 0x80, 0x02, 0x01, 0x03, 0x80, 0x02, 0x06, 0x04, 
  0x80, 0x02, 0x1A, 0x08, 0x80, 0x02, 0x61, 0x96, 0x80, 0x02, 0xCC, 0x75, 0x80, 0x02, 0xB3, 0x19, 
  0x80, 0x02, 0x8C, 0x61, 0x80, 0x02, 0x83, 0x81, 0x80, 0x02, 0xC1, 0x06, 0x80, 0x02, 0x71, 0x1A, 
  0x80, 0x02, 0x4D, 0x66, 0x80, 0x02, 0x33, 0x98, 0x80, 0x02, 0x0D, 0x60, 0x80, 0x02, 0x03, 0x80, 
}; /* prt1 */

