LOCAL UBYTE lastn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x10, 0x38, 0x01, 0x80, 0x04, 0x80, 0x18, 0x38, 0x01, 0x80, 0x04, 0x80, 0x1C, 
  0x38, 0x01, 0x80, 0x04, 0x80, 0x1E, 0x38, 0x01, 0x80, 0x04, 0x80, 0x1F, 0x38, 0x01, 0x80, 0x04, 
  0x80, 0x1F, 0xB8, 0x01, 0x80, 0x04, 0x80, 0x1F, 0x38, 0x01, 0x80, 0x04, 0x80, 0x1E, 0x38, 0x01, 
  0x80, 0x04, 0x80, 0x1C, 0x38, 0x01, 0x80, 0x04, 0x80, 0x18, 0x38, 0x01, 0x80, 0x04, 0x80, 0x10, 
  0x38, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* lastn1 */

