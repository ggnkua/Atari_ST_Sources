LOCAL UBYTE firstn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x1C, 0x08, 0x01, 0x80, 0x04, 0x80, 0x1C, 0x18, 0x01, 0x80, 0x04, 0x80, 0x1C, 
  0x38, 0x01, 0x80, 0x04, 0x80, 0x1C, 0x78, 0x01, 0x80, 0x04, 0x80, 0x1C, 0xF8, 0x01, 0x80, 0x04, 
  0x80, 0x1D, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x1C, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x1C, 0x78, 0x01, 
  0x80, 0x04, 0x80, 0x1C, 0x38, 0x01, 0x80, 0x04, 0x80, 0x1C, 0x18, 0x01, 0x80, 0x04, 0x80, 0x1C, 
  0x08, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* firstn1 */

