LOCAL UBYTE arrowc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBA, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x10, 
  0x00, 0x80, 0x01, 0x01, 0x80, 0x02, 0xD5, 0x5D, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 
  0xD5, 0x45, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x45, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x18, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBE, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x80, 0x01, 0x01, 0x80, 0x02, 0xD5, 0x5F, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x41, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 
  0xD5, 0x41, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x80, 0x01, 0x01, 
  0x80, 0x03, 0xAA, 0xBF, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA0, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xAA, 0xA0, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x1F, 0x00, 0x80, 0x01, 0x01, 
  0x80, 0x03, 0xD5, 0x5F, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x40, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x02, 0xD5, 0x40, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x1F, 
  0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBF, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA0, 
  0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA0, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x1F, 
  0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x5F, 0xF5, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x40, 
  0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x40, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x1F, 
  0xE0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBF, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA0, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA0, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x1F, 
  0x00, 0x80, 0x01, 0x01, 0x80, 0x02, 0xD5, 0x5F, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 
  0xD5, 0x44, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x44, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x1B, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBB, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x02, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x11, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xD5, 0x55, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x54, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x02, 0xD5, 0x54, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x02, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0x80, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x55, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0xD5, 0x55, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x15, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0x80, 0x00, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 
  0x82, 0x80, 0x01, 0xFE, 
}; /* arrowc4 */

