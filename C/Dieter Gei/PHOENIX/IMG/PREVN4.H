LOCAL UBYTE prevn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x02, 0x04, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x06, 0x0C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFB, 0xF7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xFB, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFB, 0xF7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x0E, 0x1C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF3, 0xE7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xF3, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF3, 0xE7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x1E, 0x3C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x3E, 0x7C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xC3, 0x87, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xC3, 0x87, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC3, 0x87, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x7E, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x3E, 0x7C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF3, 0xE7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xF3, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF3, 0xE7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x1E, 0x3C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFB, 0xF7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xFB, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFB, 0xF7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x0E, 0x1C, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 
  0x06, 0x0C, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x02, 0x04, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 
  0x80, 0x01, 0xFE, 0x00
}; /* prevn4 */

