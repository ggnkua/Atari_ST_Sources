LOCAL UBYTE deleted4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0x3F, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x3F, 0xE7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0x3F, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0xC0, 0x18, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0x0F, 0xC3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x0F, 0xC3, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0x0F, 0xC3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0xF0, 0x30, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x80, 0x01, 0x87, 0x80, 0x01, 0x87, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x80, 0x01, 0x87, 0x80, 0x01, 0x87, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x80, 0x01, 0x87, 
  0x80, 0x01, 0x87, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x78, 0x60, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xC3, 0x4F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC3, 0x4F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xC3, 0x4F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x80, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xF0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xF0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xF8, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xF8, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x07, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xF0, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xF0, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xE0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xE0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0xC0, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xC1, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC1, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xC1, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x38, 0x60, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0x83, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x83, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0x83, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x70, 0x20, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0x87, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x87, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0x87, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x70, 0x10, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xC7, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC7, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xC7, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xEF, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEF, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xEF, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x08, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xFF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xFF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 
  0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* deleted4 */

