LOCAL UBYTE caldefn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x8F, 0x82, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xB0, 0x02, 0x80, 0x01, 0x19, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x90, 0x02, 0x80, 
  0x01, 0x17, 0x80, 0x03, 0xB1, 0xFF, 0xC0, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x97, 0x82, 0x80, 0x01, 0xF7, 0x80, 
  0x01, 0xB1, 0x02, 0x80, 0x01, 0x19, 0x80, 0x03, 0xBF, 0x00, 0x7F, 0x80, 0x01, 0xD9, 0x80, 0x03, 
  0xBF, 0x00, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x97, 0x00, 0x3F, 0x80, 0x01, 0xD7, 0x80, 0x01, 
  0xB1, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x97, 0x00, 0x3F, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xB0, 0x02, 0x80, 
  0x01, 0x19, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0x97, 0x82, 0x80, 0x01, 0xD7, 0x80, 0x03, 0xB0, 0x92, 0x49, 0x80, 0x01, 0x39, 0x80, 
  0x03, 0xBE, 0xDB, 0x6D, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xBE, 0xDB, 0x6D, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x96, 0xDB, 0x6D, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xB1, 0xB6, 0xDB, 0x80, 0x01, 0x19, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x97, 
  0x82, 0x80, 0x01, 0xD7, 0x80, 0x01, 0xB0, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x97, 0x82, 0x80, 0x01, 0xF7, 
  0x80, 0x03, 0xB0, 0x92, 0x49, 0x80, 0x01, 0x19, 0x80, 0x03, 0xBE, 0xDB, 0x6D, 0x80, 0x01, 0xD9, 
  0x80, 0x03, 0xBE, 0xDB, 0x6D, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x96, 0xDB, 0x6D, 0x80, 0x01, 0xD7, 
  0x80, 0x03, 0xB1, 0xB6, 0xDB, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x97, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xB0, 
  0x02, 0x80, 0x01, 0x19, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0x97, 0x82, 0x80, 0x01, 0xD7, 0x80, 0x03, 0xB0, 0x92, 0x43, 0x80, 0x01, 
  0x39, 0x80, 0x03, 0xBE, 0xDB, 0x63, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xBE, 0xDB, 0x63, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0x96, 0xDB, 0x61, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xB1, 0xB6, 0xDF, 0x80, 0x01, 
  0x19, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x97, 0x82, 0x80, 0x01, 0xD7, 0x80, 0x01, 0xB0, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x97, 0x82, 0x80, 
  0x01, 0xF7, 0x80, 0x01, 0xB5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x59, 0x80, 0x01, 
  0xB0, 0x02, 0x80, 0x01, 0x19, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x95, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x57, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 
  0x82, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 
  0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 
  0xFE, 0x00
}; /* caldefn4 */

