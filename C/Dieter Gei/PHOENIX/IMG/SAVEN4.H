LOCAL UBYTE saven4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x83, 0x82, 0x80, 0x01, 0xC7, 0x80, 0x03, 
  0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x02, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0x7F, 
  0xFE, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x02, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 
  0x01, 0x39, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0x39, 
  0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x80, 0x00, 0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0x80, 0x01, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x80, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x80, 0x01, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0x84, 0x02, 0x80, 0x01, 0x27, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x84, 0x02, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x01, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x1F, 0xFE, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0xC0, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x0E, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x3F, 0xF0, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x30, 0xF0, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x30, 0xF0, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x30, 0xF0, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCE, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x30, 0xF0, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBD, 0xC0, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xC0, 0x0E, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xC0, 0x0E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x86, 0x30, 0xF0, 
  0x80, 0x01, 0x27, 0x80, 0x03, 0xBE, 0xC0, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0xC0, 0x00, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0xC0, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x83, 0x3F, 0xFF, 
  0x80, 0x01, 0x27, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0xDF, 0xFE, 0x80, 0x01, 0xC7, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 
  0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* saven4 */

