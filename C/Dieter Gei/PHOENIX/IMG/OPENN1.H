LOCAL UBYTE openn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0xF0, 0x01, 0x80, 0x04, 
  0x80, 0x03, 0x0C, 0x41, 0x80, 0x04, 0x80, 0x04, 0x02, 0xC1, 0x80, 0x04, 0x80, 0x00, 0x01, 0xC1, 
  0x80, 0x04, 0x83, 0xE0, 0x03, 0xC1, 0x80, 0x04, 0x84, 0x10, 0x07, 0xC1, 0x80, 0x04, 0x98, 0x0F, 
  0xF0, 0x01, 0x80, 0x04, 0x90, 0x00, 0x10, 0x01, 0x80, 0x04, 0x90, 0x00, 0x10, 0x01, 0x80, 0x04, 
  0x90, 0x00, 0x10, 0x01, 0x80, 0x04, 0x90, 0x1F, 0xFF, 0xF1, 0x80, 0x04, 0x90, 0x20, 0x00, 0x21, 
  0x80, 0x04, 0x90, 0x40, 0x00, 0x41, 0x80, 0x04, 0x90, 0x80, 0x00, 0x81, 0x80, 0x04, 0x91, 0x00, 
  0x01, 0x01, 0x80, 0x04, 0x92, 0x00, 0x02, 0x01, 0x80, 0x04, 0x94, 0x00, 0x04, 0x01, 0x80, 0x04, 
  0x98, 0x00, 0x08, 0x01, 0x80, 0x04, 0x9F, 0xFF, 0xF0, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* openn1 */

