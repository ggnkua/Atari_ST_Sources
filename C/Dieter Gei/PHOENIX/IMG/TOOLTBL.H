LOCAL UBYTE tooltbl [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x49, 0x80, 0x01, 0x12, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 
  0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x48, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x78, 0x80, 0x01, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 
  0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x48, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x78, 0x80, 0x01, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 
  0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x48, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x78, 0x80, 0x01, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 
  0x80, 0x01, 0x79, 0x80, 0x01, 0x12, 0x80, 0x01, 0x48, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x7F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x02, 
}; /* tooltbl */

