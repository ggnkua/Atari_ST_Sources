LOCAL UBYTE sortn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 
  0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 
  0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0x9F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 
  0x9F, 0xFC, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xFC, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0x9F, 0xFC, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x01, 0x80, 0x01, 0x07, 0x80, 0x02, 0xB8, 
  0x01, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xF9, 0x80, 0x02, 0xB8, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xF9, 0x80, 0x02, 0xB8, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x03, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xB8, 0x01, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x01, 0xF3, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x01, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x83, 0xFF, 0x06, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x9F, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xE7, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x83, 0xFF, 0x0C, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x9F, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xCF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x18, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x80, 0x01, 0x9F, 0x80, 0x01, 0x9F, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x80, 0x01, 0x9F, 0x80, 0x01, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x80, 0x01, 
  0x9F, 0x80, 0x01, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x80, 0x01, 0x30, 0x80, 0x01, 0x30, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x9F, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0x3F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x60, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFE, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x7F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0xC0, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFC, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFC, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFC, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x01, 0x80, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF9, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF9, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF9, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x03, 0x00, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF3, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x06, 0x00, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE7, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0C, 0x00, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xCF, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0xCF, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0xCF, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0x80, 0x18, 0x00, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x9F, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x9F, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x9F, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0x80, 0x30, 0x7F, 
  0x80, 0x01, 0xE7, 0x80, 0x03, 0xBF, 0x3F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x3F, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x3F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x60, 0x7F, 
  0x80, 0x01, 0xE7, 0x80, 0x03, 0xBF, 0x7F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0xC0, 0x00, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 
  0x82, 0x80, 0x01, 0xFE, 
}; /* sortn4 */

