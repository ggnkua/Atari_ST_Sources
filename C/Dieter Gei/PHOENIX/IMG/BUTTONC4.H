LOCAL UBYTE buttonc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD7, 0x82, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0xD6, 0x02, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD6, 0x02, 0x80, 0x01, 0x55, 0x80, 0x01, 0x81, 0x82, 
  0x80, 0x01, 0x81, 0x80, 0x01, 0xAA, 0x02, 0x80, 0x01, 0x6B, 0x80, 0x01, 0xA8, 0x02, 0x80, 0x01, 
  0x2B, 0x80, 0x01, 0xA8, 0x02, 0x80, 0x01, 0x2B, 0x80, 0x01, 0x82, 0x02, 0x80, 0x01, 0xC1, 0x80, 
  0x03, 0xD6, 0xFF, 0xFE, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 
  0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x80, 
  0x03, 0xAA, 0xFF, 0xFE, 0x80, 0x01, 0x6B, 0x80, 0x03, 0xA8, 0xFF, 0xFE, 0x80, 0x01, 0x2B, 0x80, 
  0x03, 0xA8, 0xFF, 0xFE, 0x80, 0x01, 0x2B, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x80, 
  0x03, 0xD6, 0xFF, 0xFE, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 
  0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x80, 
  0x03, 0xAA, 0xFF, 0xFE, 0x80, 0x01, 0x6B, 0x80, 0x03, 0xA8, 0xFF, 0xFE, 0x80, 0x01, 0x2B, 0x80, 
  0x03, 0xA8, 0xFF, 0xFE, 0x80, 0x01, 0x2B, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x80, 
  0x03, 0xD6, 0xFF, 0xFE, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 
  0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x80, 
  0x03, 0xAA, 0xFF, 0xFE, 0x80, 0x01, 0x6B, 0x80, 0x03, 0xA8, 0xFF, 0xFE, 0x80, 0x01, 0x2B, 0x80, 
  0x03, 0xA8, 0xFF, 0xFE, 0x80, 0x01, 0x2B, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x80, 
  0x03, 0xD6, 0xFF, 0xFE, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 
  0x03, 0xD4, 0xFF, 0xFE, 0x80, 0x01, 0x15, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0xC1, 0x80, 
  0x01, 0xAA, 0x02, 0x80, 0x01, 0x6B, 0x80, 0x01, 0xA8, 0x02, 0x80, 0x01, 0x2B, 0x80, 0x01, 0xA8, 
  0x02, 0x80, 0x01, 0x2B, 0x80, 0x01, 0x82, 0x82, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xD6, 0x02, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD4, 0x02, 0x80, 0x01, 0x15, 0x80, 0x01, 0xD4, 0x02, 0x80, 0x01, 0x15, 
  0x80, 0x01, 0x83, 0x82, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xAB, 0x82, 0x80, 0x01, 0xEB, 0x80, 0x01, 
  0xAA, 0x02, 0x80, 0x01, 0x6B, 0x80, 0x01, 0xAA, 0x02, 0x80, 0x01, 0x6B, 0x80, 0x01, 0x81, 0x82, 
  0x80, 0x01, 0x81, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* buttonc4 */

