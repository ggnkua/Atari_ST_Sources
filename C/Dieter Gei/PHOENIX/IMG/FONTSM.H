LOCAL UBYTE fontsm [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01, 0x01, 0x74, 0x01, 0x74, 0x00, 0x40, 0x00, 0x10, 
  0x08, 0x81, 0x80, 0x07, 0xF8, 0xFF, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8, 0x81, 0x80, 0x07, 0xFC, 0xFF, 
  0xFE, 0x7F, 0xFC, 0xFF, 0xFC, 0x81, 0x80, 0x07, 0xFE, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 
  0x00, 0xFF, 0x0B, 0x88, 0x08, 0x00
}; /* fontsm */

