LOCAL UBYTE repdefn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0F, 0xF8, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBF, 0xF8, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x0F, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xF8, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x70, 0x06, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBF, 0xBC, 0x0B, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xBC, 0x0B, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xBC, 0x0B, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x9C, 0x0D, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBE, 0x73, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x73, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBE, 0x73, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x86, 0x32, 0x1E, 0x80, 0x01, 0x87, 0x80, 
  0x03, 0xB8, 0xE1, 0xFD, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0xE1, 0xFD, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB8, 0xE1, 0xFD, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 0x61, 0xE1, 0x80, 0x01, 0xC7, 0x80, 
  0x03, 0xB9, 0xE0, 0xF0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xB9, 0xE0, 0xF0, 0x80, 0x01, 0x79, 0x80, 
  0x03, 0xB9, 0xE0, 0xF0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x88, 0xA0, 0x00, 0x80, 0x01, 0x67, 0x80, 
  0x03, 0xBF, 0xC4, 0xC0, 0x80, 0x01, 0x19, 0x80, 0x03, 0xBF, 0xC0, 0x00, 0x80, 0x01, 0x19, 0x80, 
  0x03, 0xBF, 0xC4, 0xC0, 0x80, 0x01, 0x19, 0x80, 0x03, 0x85, 0x44, 0xC0, 0x80, 0x01, 0x37, 0x80, 
  0x03, 0xBE, 0xC3, 0x40, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBE, 0xC0, 0x00, 0x80, 0x01, 0x39, 0x80, 
  0x03, 0xBE, 0xC3, 0x40, 0x80, 0x01, 0x39, 0x80, 0x03, 0x86, 0x43, 0x40, 0x80, 0x01, 0x27, 0x80, 
  0x03, 0xBD, 0x8E, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBD, 0x80, 0x00, 0x80, 0x01, 0x39, 0x80, 
  0x03, 0xBD, 0x8E, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0x84, 0x8E, 0x80, 0x80, 0x01, 0x27, 0x80, 
  0x03, 0xB9, 0x81, 0x80, 0x80, 0x01, 0x79, 0x80, 0x03, 0xB9, 0x80, 0x00, 0x80, 0x01, 0x79, 0x80, 
  0x03, 0xB9, 0x81, 0x98, 0x80, 0x01, 0x79, 0x80, 0x03, 0x88, 0x81, 0x80, 0x80, 0x01, 0x47, 0x80, 
  0x03, 0xBB, 0x01, 0x00, 0x80, 0x01, 0x79, 0x80, 0x01, 0xBB, 0x02, 0x80, 0x01, 0x79, 0x80, 0x03, 
  0xBB, 0x19, 0x06, 0x80, 0x01, 0x79, 0x80, 0x03, 0x89, 0x01, 0x00, 0x80, 0x01, 0x47, 0x80, 0x01, 
  0xBF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x06, 
  0x30, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x85, 0x02, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBE, 0x02, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBE, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x31, 0x8C, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0x82, 0x02, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBC, 0x00, 0x01, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBC, 0x00, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBC, 0x0C, 0x61, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x00, 0x01, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBC, 0x00, 0x01, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBC, 0x00, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBC, 0x03, 0x19, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x84, 0x00, 0x01, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x00, 0x03, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x00, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x00, 0xC3, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x83, 0x00, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x33, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0xC0, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF0, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xF0, 0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x30, 0x04, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFC, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xFC, 0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFC, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x0C, 0x04, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0x0F, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xFF, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x0F, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x03, 0x08, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xCF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xFF, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xCF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x00, 0xC8, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 
  0x00, 0x30, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* repdefn4 */

