LOCAL UBYTE prevn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x02, 0x04, 0x01, 0x80, 0x04, 0x80, 0x06, 0x0C, 0x01, 0x80, 0x04, 0x80, 0x0E, 
  0x1C, 0x01, 0x80, 0x04, 0x80, 0x1E, 0x3C, 0x01, 0x80, 0x04, 0x80, 0x3E, 0x7C, 0x01, 0x80, 0x04, 
  0x80, 0x7E, 0xFC, 0x01, 0x80, 0x04, 0x80, 0x3E, 0x7C, 0x01, 0x80, 0x04, 0x80, 0x1E, 0x3C, 0x01, 
  0x80, 0x04, 0x80, 0x0E, 0x1C, 0x01, 0x80, 0x04, 0x80, 0x06, 0x0C, 0x01, 0x80, 0x04, 0x80, 0x02, 
  0x04, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* prevn1 */

