LOCAL UBYTE mltkeyn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x83, 0xF0, 0x00, 0x01, 0x80, 0x04, 
  0x84, 0x08, 0x00, 0x01, 0x80, 0x04, 0x84, 0x0F, 0xFF, 0xC1, 0x80, 0x04, 0x84, 0x00, 0x00, 0x21, 
  0x80, 0x04, 0x85, 0x81, 0xFF, 0xE1, 0x80, 0x04, 0x85, 0x80, 0x00, 0x21, 0x80, 0x04, 0x84, 0x01, 
  0xCE, 0x61, 0x80, 0x04, 0x84, 0x01, 0x7B, 0xC1, 0x80, 0x04, 0x84, 0x07, 0x00, 0x01, 0x80, 0x04, 
  0x84, 0x0F, 0xFF, 0xC1, 0x80, 0x04, 0x84, 0x08, 0x00, 0x21, 0x80, 0x04, 0x83, 0xF1, 0xFF, 0xE1, 
  0x80, 0x04, 0x85, 0x80, 0x00, 0x21, 0x80, 0x04, 0x84, 0x01, 0xCE, 0x61, 0x80, 0x04, 0x84, 0x01, 
  0x7B, 0xC1, 0x80, 0x04, 0x84, 0x07, 0x00, 0x01, 0x80, 0x04, 0x84, 0x0C, 0x00, 0x01, 0x80, 0x04, 
  0x84, 0x08, 0x00, 0x01, 0x80, 0x04, 0x83, 0xF0, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* mltkeyn1 */

