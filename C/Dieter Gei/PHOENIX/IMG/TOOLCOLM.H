LOCAL UBYTE toolcolm [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 
  0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x7F, 0xFE, 
  0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x00, 0x00, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 
}; /* toolcolm */

