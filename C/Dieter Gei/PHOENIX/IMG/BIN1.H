LOCAL UBYTE bin1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x3F, 0xE0, 0x80, 0x02, 0x20, 0x30, 0x80, 0x02, 0x24, 0xA8, 
  0x80, 0x02, 0x2A, 0xBC, 0x80, 0x02, 0x2A, 0x86, 0x80, 0x02, 0x24, 0x86, 0x80, 0x02, 0x20, 0x06, 
  0x80, 0x02, 0x29, 0x26, 0x80, 0x02, 0x2A, 0xA6, 0x80, 0x02, 0x2A, 0xA6, 0x80, 0x02, 0x29, 0x26, 
  0x80, 0x02, 0x20, 0x06, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x1F, 0xFE, 0x80, 0x02, 0x00, 0x00, 
}; /* bin1 */

