LOCAL UBYTE arrown1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x10, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x18, 0x00, 0x01, 0x80, 0x04, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x04, 0x80, 0x1E, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x1F, 0x00, 0x01, 0x80, 0x04, 0x80, 0x1F, 0x80, 0x01, 0x80, 0x04, 
  0x80, 0x1F, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x1F, 0xE0, 0x01, 0x80, 0x04, 0x80, 0x1F, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x1B, 0x00, 0x01, 0x80, 0x04, 0x80, 0x11, 0x80, 0x01, 0x80, 0x04, 0x80, 0x01, 
  0x80, 0x01, 0x80, 0x04, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x00, 0xC0, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* arrown1 */

