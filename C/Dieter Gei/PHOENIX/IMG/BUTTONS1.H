LOCAL UBYTE buttons1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x34, 0x00, 0x34, 
  0x80, 0x07, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x80, 0x07, 0x80, 0x16, 0x01, 0xA0, 0x05, 
  0x80, 0x6F, 0x80, 0x07, 0x80, 0x15, 0x02, 0xA0, 0x05, 0x40, 0xAF, 0x80, 0x07, 0x80, 0x14, 0x84, 
  0xA0, 0x05, 0x21, 0x2F, 0x80, 0x07, 0x80, 0x14, 0x48, 0xA0, 0x05, 0x12, 0x2F, 0x80, 0x07, 0x80, 
  0x14, 0x30, 0xA0, 0x05, 0x0C, 0x2F, 0x80, 0x07, 0x80, 0x14, 0x30, 0xA0, 0x05, 0x0C, 0x2F, 0x80, 
  0x07, 0x80, 0x14, 0x48, 0xA0, 0x05, 0x12, 0x2F, 0x80, 0x07, 0x80, 0x14, 0x84, 0xA0, 0x05, 0x21, 
  0x2F, 0x80, 0x07, 0x80, 0x15, 0x02, 0xA0, 0x05, 0x40, 0xAF, 0x80, 0x07, 0x80, 0x16, 0x01, 0xA0, 
  0x05, 0x80, 0x6F, 0x80, 0x07, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x80, 0x07, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x07, 
  0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x8F, 0x80, 0x07, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x4F, 
  0x80, 0x07, 0x40, 0x22, 0x79, 0x10, 0x08, 0x9E, 0x4F, 0x80, 0x07, 0x80, 0x14, 0xFC, 0xA0, 0x05, 
  0x3F, 0x2F, 0x80, 0x07, 0x80, 0x14, 0xFC, 0xA0, 0x05, 0x3F, 0x2F, 0x80, 0x07, 0x80, 0x14, 0xFC, 
  0xA0, 0x05, 0x3F, 0x2F, 0x80, 0x07, 0x80, 0x14, 0xFC, 0xA0, 0x05, 0x3F, 0x2F, 0x80, 0x07, 0x40, 
  0x22, 0x79, 0x10, 0x08, 0x9E, 0x4F, 0x80, 0x07, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x4F, 0x80, 
  0x07, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x8F, 0x80, 0x07, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 
  0x0F, 0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x0C, 
  0x00, 0x60, 0x03, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x0C, 0x02, 0x60, 0x03, 0x00, 0x9F, 0x80, 0x07, 
  0x80, 0x0C, 0x06, 0x60, 0x03, 0x01, 0x9F, 0x80, 0x07, 0x80, 0x0C, 0x8E, 0x60, 0x03, 0x23, 0x9F, 
  0x80, 0x07, 0x80, 0x0C, 0xDC, 0x60, 0x03, 0x37, 0x1F, 0x80, 0x07, 0x80, 0x0C, 0xF8, 0x60, 0x03, 
  0x3E, 0x1F, 0x80, 0x07, 0x80, 0x0C, 0x70, 0x60, 0x03, 0x1C, 0x1F, 0x80, 0x07, 0x80, 0x0C, 0x20, 
  0x60, 0x03, 0x08, 0x1F, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x80, 0x07, 0x80, 
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 
  0x07, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0F, 0x80, 0x07, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 
  0x0F, 0x80, 0x07, 0x08, 0x80, 0x44, 0x02, 0x20, 0x11, 0x0F, 0x80, 0x07, 0x10, 0x40, 0x82, 0x04, 
  0x10, 0x20, 0x8F, 0x80, 0x07, 0x20, 0x21, 0x11, 0x08, 0x08, 0x44, 0x4F, 0x80, 0x07, 0x40, 0x12, 
  0x38, 0x90, 0x04, 0x8E, 0x2F, 0x80, 0x07, 0x80, 0x0C, 0x7C, 0x60, 0x03, 0x1F, 0x1F, 0x80, 0x07, 
  0x40, 0x12, 0x38, 0x90, 0x04, 0x8E, 0x2F, 0x80, 0x07, 0x20, 0x21, 0x11, 0x08, 0x08, 0x44, 0x4F, 
  0x80, 0x07, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x8F, 0x80, 0x07, 0x08, 0x80, 0x44, 0x02, 0x20, 
  0x11, 0x0F, 0x80, 0x07, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x0F, 0x80, 0x07, 0x02, 0x00, 0x10, 
  0x00, 0x80, 0x04, 0x0F, 
}; /* buttons1 */

