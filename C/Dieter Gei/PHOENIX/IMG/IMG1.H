LOCAL UBYTE img1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x3F, 0xE0, 0x80, 0x02, 0x20, 0x30, 0x80, 0x02, 0x21, 0xA8, 
  0x80, 0x02, 0x21, 0xBC, 0x80, 0x02, 0x2C, 0x06, 0x80, 0x02, 0x28, 0x06, 0x80, 0x02, 0x2E, 0x06, 
  0x80, 0x02, 0x2E, 0x06, 0x80, 0x02, 0x20, 0x16, 0x80, 0x02, 0x29, 0xF6, 0x80, 0x02, 0x2F, 0x06, 
  0x80, 0x02, 0x20, 0x06, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x1F, 0xFE, 0x80, 0x02, 0x00, 0x00, 
}; /* img1 */

