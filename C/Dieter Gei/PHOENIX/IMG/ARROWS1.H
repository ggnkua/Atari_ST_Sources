LOCAL UBYTE arrows1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x1B, 0x00, 0x24, 
  0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x08, 0x00, 
  0x1F, 0xC0, 0x80, 0x04, 0x1C, 0x3F, 0x8F, 0x80, 0x80, 0x04, 0x3E, 0x1F, 0x07, 0x00, 0x80, 0x04, 
  0x7F, 0x0E, 0x02, 0x00, 0x80, 0x04, 0x00, 0x04, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x1F, 0xC0, 
  0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x04, 0x08, 
  0x00, 0x00, 0x80, 0x04, 0x0C, 0x0C, 0x00, 0x00, 0x80, 0x04, 0x1C, 0x0E, 0x00, 0x00, 0x80, 0x04, 
  0x3C, 0x0F, 0x00, 0x00, 0x80, 0x04, 0x1C, 0x0E, 0x00, 0x00, 0x80, 0x04, 0x0C, 0x0C, 0x00, 0x00, 
  0x80, 0x04, 0x04, 0x08, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 
  0x00, 0x00, 0x80, 0x04, 0x08, 0x0E, 0x07, 0x00, 0x80, 0x04, 0x1C, 0x0E, 0x07, 0x00, 0x80, 0x04, 
  0x3E, 0x0E, 0x1F, 0xC0, 0x80, 0x04, 0x7F, 0x3F, 0x8F, 0x80, 0x80, 0x04, 0x1C, 0x1F, 0x07, 0x00, 
  0x80, 0x04, 0x1C, 0x0E, 0x02, 0x00, 0x80, 0x04, 0x1C, 0x04, 0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 
  0x1F, 0xC0, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x08, 0x04, 0x00, 0x00, 0x80, 0x04, 
  0x18, 0x06, 0x00, 0x00, 0x80, 0x04, 0x3F, 0x3F, 0x00, 0x00, 0x80, 0x04, 0x7F, 0x3F, 0x80, 0x00, 
  0x80, 0x04, 0x3F, 0x3F, 0x00, 0x00, 0x80, 0x04, 0x18, 0x06, 0x00, 0x00, 0x80, 0x04, 0x08, 0x04, 
  0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 
}; /* arrows1 */

