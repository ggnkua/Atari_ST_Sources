LOCAL UBYTE rbuttn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x18, 0x30, 0x01, 
  0x80, 0x04, 0x80, 0x20, 0x08, 0x01, 0x80, 0x04, 0x80, 0x40, 0x04, 0x01, 0x80, 0x04, 0x80, 0x43, 
  0x84, 0x01, 0x80, 0x04, 0x80, 0x87, 0xC2, 0x01, 0x80, 0x04, 0x80, 0x8F, 0xE2, 0x01, 0x80, 0x04, 
  0x80, 0x8F, 0xE2, 0x01, 0x80, 0x04, 0x80, 0x8F, 0xE2, 0x01, 0x80, 0x04, 0x80, 0x87, 0xC2, 0x01, 
  0x80, 0x04, 0x80, 0x43, 0x84, 0x01, 0x80, 0x04, 0x80, 0x40, 0x04, 0x01, 0x80, 0x04, 0x80, 0x20, 
  0x08, 0x01, 0x80, 0x04, 0x80, 0x18, 0x30, 0x01, 0x80, 0x04, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* rbuttn1 */

