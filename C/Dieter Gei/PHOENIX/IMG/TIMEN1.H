LOCAL UBYTE timen1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x80, 0x01, 0x80, 0x04, 
  0x80, 0x11, 0x84, 0x01, 0x80, 0x04, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x80, 0x80, 0x81, 0x80, 0x04, 0x81, 0x80, 0x81, 0x81, 0x80, 0x04, 0x80, 0x00, 
  0x80, 0x01, 0x80, 0x04, 0x80, 0x00, 0x80, 0x01, 0x80, 0x04, 0x80, 0x00, 0xA0, 0x01, 0x80, 0x04, 
  0x81, 0x00, 0xC0, 0x41, 0x80, 0x04, 0x83, 0x03, 0xFC, 0xC1, 0x80, 0x04, 0x80, 0x01, 0x80, 0x01, 
  0x80, 0x04, 0x80, 0x02, 0x80, 0x01, 0x80, 0x04, 0x80, 0x04, 0x80, 0x01, 0x80, 0x04, 0x80, 0x80, 
  0x00, 0x81, 0x80, 0x04, 0x81, 0x80, 0x01, 0x81, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x10, 0x04, 0x01, 0x80, 0x04, 0x80, 0x30, 0x8C, 0x01, 0x80, 0x04, 0x80, 0x01, 0x80, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* timen1 */

