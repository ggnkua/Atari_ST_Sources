LOCAL UBYTE addn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x3F, 0xF8, 0x01, 
  0x80, 0x04, 0x80, 0x1C, 0x18, 0x01, 0x80, 0x04, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x04, 0x80, 0x07, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x03, 0x80, 0x01, 0x80, 0x04, 0x80, 0x01, 0xC0, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x01, 0x80, 0x01, 0x80, 0x04, 0x80, 0x03, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x06, 0x00, 0x01, 0x80, 0x04, 0x80, 0x0C, 0x18, 0x01, 0x80, 0x04, 0x80, 0x1F, 
  0xF8, 0x01, 0x80, 0x04, 0x80, 0x3F, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* addn1 */

