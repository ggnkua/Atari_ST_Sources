LOCAL UBYTE pagen1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x81, 0xFF, 0xF0, 0x01, 0x80, 0x04, 
  0x81, 0x00, 0x18, 0x01, 0x80, 0x04, 0x81, 0x00, 0x14, 0x01, 0x80, 0x04, 0x81, 0x00, 0x12, 0x01, 
  0x80, 0x04, 0x81, 0x00, 0x11, 0x01, 0x80, 0x04, 0x81, 0x00, 0x1F, 0x81, 0x80, 0x04, 0x81, 0x06, 
  0xC0, 0x81, 0x80, 0x04, 0x81, 0x06, 0xC0, 0x81, 0x80, 0x04, 0x81, 0x0F, 0xE0, 0x81, 0x80, 0x04, 
  0x81, 0x06, 0xC0, 0x81, 0x80, 0x04, 0x81, 0x06, 0xC0, 0x81, 0x80, 0x04, 0x81, 0x06, 0xC0, 0x81, 
  0x80, 0x04, 0x81, 0x0F, 0xE0, 0x81, 0x80, 0x04, 0x81, 0x06, 0xC0, 0x81, 0x80, 0x04, 0x81, 0x06, 
  0xC0, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 
  0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0xFF, 0xFF, 0x81, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* pagen1 */

