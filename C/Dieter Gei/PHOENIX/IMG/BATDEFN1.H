LOCAL UBYTE batdefn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x0F, 0xFF, 0xC1, 0x80, 0x04, 0x80, 0x10, 0x00, 0x41, 
  0x80, 0x04, 0x80, 0x3F, 0xFF, 0x41, 0x80, 0x04, 0x80, 0x40, 0x01, 0x41, 0x80, 0x04, 0x80, 0xFF, 
  0xFD, 0x41, 0x80, 0x04, 0x81, 0x00, 0x05, 0x41, 0x80, 0x04, 0x82, 0x7E, 0x75, 0x41, 0x80, 0x04, 
  0x84, 0x5A, 0x55, 0x41, 0x80, 0x04, 0x88, 0x7E, 0x75, 0x41, 0x80, 0x04, 0x88, 0x00, 0x05, 0x41, 
  0x80, 0x04, 0x8B, 0xFE, 0xE5, 0x41, 0x80, 0x04, 0x8A, 0xDA, 0xA5, 0x81, 0x80, 0x04, 0x8B, 0xFE, 
  0xE5, 0x01, 0x80, 0x04, 0x88, 0x00, 0x06, 0x01, 0x80, 0x04, 0x8F, 0xFF, 0xFC, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* batdefn1 */

