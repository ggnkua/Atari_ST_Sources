LOCAL UBYTE firstd4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xE3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xE3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x18, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xEB, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xEB, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x80, 0x01, 0x10, 0x80, 0x01, 0x10, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEB, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xD7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x20, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEB, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xB7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEB, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0x77, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x80, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEA, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEA, 0xF7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEA, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x11, 0x00, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEB, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0x77, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x80, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEB, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xB7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEB, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xD7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x20, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xEB, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xE7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEB, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x80, 0x01, 0x10, 
  0x80, 0x01, 0x10, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xE3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE3, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0x80, 0x18, 0x00, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 
  0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* firstd4 */

