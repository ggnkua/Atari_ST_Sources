LOCAL UBYTE img4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 
  0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x30, 0x80, 0x01, 0x20, 0x80, 0x01, 0x30, 0x80, 0x01, 0x20, 0x80, 0x01, 0x30, 0x80, 0x01, 
  0x20, 0x80, 0x01, 0x30, 0x80, 0x01, 0x2E, 0x80, 0x01, 0x28, 0x80, 0x01, 0x2F, 0x80, 0x01, 0xE8, 
  0x80, 0x01, 0x21, 0x80, 0x01, 0xE8, 0x80, 0x01, 0x20, 0x80, 0x01, 0x28, 0x80, 0x01, 0x2F, 0x80, 
  0x01, 0x3C, 0x80, 0x01, 0x2F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x20, 0x80, 0x01, 0xFC, 0x80, 0x01, 
  0x20, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x2F, 0x80, 0x01, 0x04, 0x80, 0x01, 0x23, 0x80, 0x01, 0xF4, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x64, 0x80, 0x01, 0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x2E, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x26, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x20, 0x80, 0x01, 0x24, 0x80, 0x01, 
  0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x2E, 0x80, 0x01, 0x04, 0x80, 0x01, 0x21, 0x80, 0x01, 0xF4, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0xC4, 0x80, 0x01, 0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x2E, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x21, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x20, 0x80, 0x01, 0xC4, 0x80, 0x01, 
  0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x2F, 0x80, 0x01, 0xE4, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x16, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x26, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 
  0x29, 0x80, 0x01, 0xF6, 0x80, 0x01, 0x20, 0x80, 0x01, 0x74, 0x80, 0x01, 0x20, 0x80, 0x01, 0x74, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x74, 0x80, 0x01, 0x2F, 0x80, 0x01, 0x06, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 
  0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x80, 
  0x01, 0x1F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x02, 0x00
}; /* img4 */

