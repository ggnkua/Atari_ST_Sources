LOCAL UBYTE subn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 
  0x79, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x79, 0x80, 
  0x01, 0x87, 0x82, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 
  0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0x87, 0x82, 0x80, 
  0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 
  0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0x86, 0x02, 0x80, 0x01, 0x87, 0x80, 0x01, 
  0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 
  0x80, 0x01, 0xB9, 0x80, 0x01, 0x86, 0x02, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 
  0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 
  0x03, 0x86, 0x7E, 0x7C, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 
  0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0x86, 0x00, 
  0x44, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 
  0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0x86, 0x00, 0x44, 0x80, 0x01, 
  0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 
  0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0x86, 0x7E, 0x7C, 0x80, 0x01, 0x87, 0x80, 0x01, 
  0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 
  0x80, 0x01, 0xB9, 0x80, 0x01, 0x86, 0x02, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 
  0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 
  0x01, 0x86, 0x02, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 
  0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0x86, 0x7E, 0x7C, 
  0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 
  0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0x86, 0x00, 0x44, 0x80, 0x01, 0x87, 
  0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 
  0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0x86, 0x00, 0x44, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 
  0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0x86, 0x7E, 0x7C, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 
  0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 
  0x01, 0x86, 0x02, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 
  0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0x86, 0x02, 0x80, 
  0x01, 0x87, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 
  0x80, 0x01, 0xBB, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0x87, 0x82, 0x80, 0x01, 0x87, 0x80, 0x01, 
  0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 0x02, 
  0x80, 0x01, 0x39, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* subn4 */

