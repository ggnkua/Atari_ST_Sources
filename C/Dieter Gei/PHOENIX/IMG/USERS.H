LOCAL UBYTE users [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x20, 
  0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04, 0x80, 0x02, 0x03, 0xFF, 0x02, 0x80, 0x02, 0x03, 
  0xFF, 0x02, 0x80, 0x02, 0x03, 0xFF, 0x02, 0x80, 0x02, 0x03, 0xFF, 0x02, 0x80, 0x03, 0x0F, 0xFF, 
  0x80, 0x80, 0x01, 0x00, 0x80, 0x03, 0x0F, 0xFF, 0x80, 0x80, 0x01, 0x00, 0x80, 0x03, 0x0F, 0xFF, 
  0x80, 0x80, 0x01, 0x00, 0x80, 0x03, 0x0F, 0xFF, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x1F, 0x82, 
  0x80, 0x01, 0xC0, 0x80, 0x01, 0x1F, 0x82, 0x80, 0x01, 0xC0, 0x80, 0x01, 0x1F, 0x82, 0x80, 0x01, 
  0xC0, 0x80, 0x01, 0x1F, 0x82, 0x80, 0x01, 0xC0, 0x80, 0x01, 0x3F, 0x82, 0x80, 0x01, 0xF0, 0x80, 
  0x01, 0x3F, 0x82, 0x80, 0x01, 0xF0, 0x80, 0x03, 0x3F, 0xFF, 0xE8, 0x80, 0x01, 0x30, 0x80, 0x03, 
  0x3F, 0xFF, 0xE0, 0x80, 0x01, 0x30, 0x80, 0x03, 0x3F, 0xFF, 0xDF, 0x80, 0x01, 0xF8, 0x80, 0x03, 
  0x3F, 0xFF, 0xDF, 0x80, 0x01, 0xF8, 0x80, 0x03, 0x3F, 0xFF, 0xD4, 0x80, 0x01, 0x08, 0x80, 0x03, 
  0x3F, 0xFF, 0xE0, 0x80, 0x01, 0x08, 0x80, 0x03, 0x7F, 0xFF, 0xDF, 0x80, 0x01, 0xFC, 0x80, 0x03, 
  0x7F, 0xFF, 0xDF, 0x80, 0x01, 0xFC, 0x80, 0x03, 0x7F, 0xFF, 0xC8, 0x80, 0x01, 0x04, 0x80, 0x03, 
  0x7F, 0xFF, 0xE0, 0x80, 0x01, 0x04, 0x80, 0x03, 0x7F, 0xE0, 0xDF, 0x80, 0x01, 0xFE, 0x80, 0x03, 
  0x7F, 0xE0, 0xDF, 0x80, 0x01, 0xFE, 0x80, 0x03, 0x7F, 0xE0, 0xD4, 0x80, 0x01, 0x02, 0x80, 0x03, 
  0x7F, 0xFF, 0xE0, 0x80, 0x01, 0x22, 0x80, 0x03, 0xFF, 0xE0, 0x5F, 0x80, 0x01, 0xFE, 0x80, 0x03, 
  0xFF, 0xE0, 0x5F, 0x80, 0x01, 0xFE, 0x80, 0x03, 0xFF, 0xE0, 0x48, 0x80, 0x01, 0x0A, 0x82, 0x80, 
  0x01, 0xEB, 0x80, 0x01, 0x52, 0x80, 0x03, 0xFF, 0xE0, 0xDE, 0x80, 0x01, 0xAA, 0x80, 0x03, 0xFF, 
  0xE0, 0xDE, 0x80, 0x01, 0xAA, 0x80, 0x03, 0xFF, 0xE0, 0xD6, 0x80, 0x01, 0xA2, 0x82, 0x80, 0x01, 
  0xEC, 0x80, 0x01, 0xAE, 0x80, 0x03, 0xFF, 0xE1, 0xDC, 0x80, 0x01, 0x04, 0x80, 0x03, 0xFF, 0xE1, 
  0xDC, 0x80, 0x01, 0x04, 0x80, 0x03, 0xFF, 0xE1, 0xC4, 0x80, 0x01, 0x04, 0x82, 0x80, 0x01, 0xE8, 
  0x80, 0x01, 0x0C, 0x80, 0x03, 0xFF, 0x83, 0x28, 0x80, 0x01, 0x78, 0x80, 0x03, 0xFF, 0x83, 0x28, 
  0x80, 0x01, 0x78, 0x80, 0x03, 0xFF, 0x83, 0x28, 0x80, 0x01, 0x78, 0x82, 0x80, 0x01, 0xF0, 0x80, 
  0x01, 0x08, 0x80, 0x03, 0xFF, 0x81, 0x10, 0x80, 0x01, 0x68, 0x80, 0x03, 0xFF, 0x81, 0x10, 0x80, 
  0x01, 0x68, 0x80, 0x03, 0xFF, 0x81, 0x10, 0x80, 0x01, 0x68, 0x82, 0x80, 0x01, 0xF8, 0x80, 0x01, 
  0xF8, 0x80, 0x02, 0xFE, 0x00, 0x80, 0x01, 0x08, 0x80, 0x01, 0x08, 0x80, 0x02, 0xFE, 0x00, 0x80, 
  0x01, 0x08, 0x80, 0x01, 0x08, 0x80, 0x03, 0xFE, 0x00, 0x08, 0x80, 0x01, 0xC8, 0x82, 0x80, 0x01, 
  0xF8, 0x80, 0x01, 0x08, 0x80, 0x03, 0xFE, 0x00, 0x3C, 0x80, 0x01, 0x04, 0x80, 0x03, 0xFE, 0x00, 
  0x3C, 0x80, 0x01, 0x04, 0x80, 0x03, 0xFE, 0x00, 0x3C, 0x80, 0x01, 0x04, 0x82, 0x80, 0x01, 0xF8, 
  0x80, 0x01, 0x04, 0x80, 0x03, 0x7F, 0x00, 0x1C, 0x80, 0x01, 0x02, 0x80, 0x03, 0x7F, 0x00, 0x1C, 
  0x80, 0x01, 0x02, 0x80, 0x03, 0x7F, 0x00, 0x1C, 0x80, 0x01, 0x02, 0x80, 0x03, 0x7F, 0xFF, 0xF0, 
  0x80, 0x01, 0x02, 0x80, 0x03, 0x3F, 0x80, 0x18, 0x80, 0x01, 0x1E, 0x80, 0x03, 0x3F, 0x80, 0x18, 
  0x80, 0x01, 0x1E, 0x80, 0x03, 0x3F, 0x80, 0x18, 0x80, 0x01, 0x1E, 0x80, 0x03, 0x3F, 0xFF, 0xF0, 
  0x80, 0x01, 0x1E, 0x80, 0x03, 0x3F, 0x80, 0x68, 0x80, 0x01, 0x0C, 0x80, 0x03, 0x3F, 0x80, 0x68, 
  0x80, 0x01, 0x0C, 0x80, 0x03, 0x3F, 0x80, 0x68, 0x80, 0x01, 0x0C, 0x80, 0x03, 0x3F, 0xFF, 0xF0, 
  0x80, 0x01, 0x04, 0x80, 0x03, 0x1F, 0x80, 0x18, 0x80, 0x01, 0x1C, 0x80, 0x03, 0x1F, 0x80, 0x18, 
  0x80, 0x01, 0x1C, 0x80, 0x03, 0x1F, 0x80, 0x18, 0x80, 0x01, 0x1C, 0x80, 0x03, 0x1F, 0xFF, 0xF0, 
  0x80, 0x01, 0x3C, 0x80, 0x03, 0x1F, 0x80, 0x18, 0x80, 0x01, 0x0C, 0x80, 0x03, 0x1F, 0x80, 0x18, 
  0x80, 0x01, 0x0C, 0x80, 0x03, 0x1F, 0x80, 0x18, 0x80, 0x01, 0x0C, 0x80, 0x03, 0x1F, 0xFF, 0xF0, 
  0x80, 0x01, 0x04, 0x80, 0x03, 0x06, 0x00, 0x28, 0x80, 0x01, 0x04, 0x80, 0x03, 0x06, 0x00, 0x28, 
  0x80, 0x01, 0x04, 0x80, 0x03, 0x06, 0x00, 0x28, 0x80, 0x01, 0x04, 0x80, 0x03, 0x07, 0xFF, 0xF0, 
  0x80, 0x01, 0x04, 0x80, 0x03, 0x0E, 0x1F, 0xD0, 0x80, 0x01, 0x04, 0x80, 0x03, 0x0E, 0x1F, 0xD0, 
  0x80, 0x01, 0x04, 0x80, 0x03, 0x0E, 0x1F, 0xC0, 0x80, 0x01, 0x04, 0x80, 0x03, 0x0F, 0xFF, 0xF0, 
  0x80, 0x01, 0x0C, 0x80, 0x03, 0x0B, 0x03, 0xF1, 0x80, 0x01, 0xF8, 0x80, 0x03, 0x0F, 0x03, 0xF1, 
  0x80, 0x01, 0xF8, 0x80, 0x03, 0x0F, 0x03, 0xC1, 0x80, 0x01, 0xF8, 0x80, 0x03, 0x0F, 0xFF, 0xB7, 
  0x80, 0x01, 0xF8, 0x80, 0x03, 0x08, 0x81, 0xF9, 0x80, 0x01, 0x40, 0x80, 0x03, 0x0F, 0x81, 0xF9, 
  0x80, 0x01, 0x40, 0x80, 0x03, 0x0F, 0x81, 0xC9, 0x80, 0x01, 0x40, 0x80, 0x03, 0x0A, 0xFF, 0x90, 
  0x80, 0x01, 0xC0, 0x80, 0x03, 0x38, 0x41, 0xBC, 0x80, 0x01, 0x40, 0x80, 0x03, 0x3F, 0xC1, 0xBC, 
  0x80, 0x01, 0x40, 0x80, 0x03, 0x3F, 0xC1, 0x84, 0x80, 0x01, 0x40, 0x80, 0x03, 0x3C, 0x7F, 0xE8, 
  0x80, 0x01, 0xC0, 0x80, 0x03, 0xC4, 0x23, 0x7E, 0x80, 0x01, 0x40, 0x80, 0x03, 0xFF, 0xE3, 0xFE, 
  0x80, 0x01, 0x40, 0x80, 0x03, 0xFF, 0xE3, 0xE2, 0x80, 0x01, 0x40, 0x80, 0x03, 0xEE, 0x3F, 0x54, 
  0x80, 0x01, 0xC0, 0x80, 0x03, 0x02, 0x1E, 0x7E, 0x80, 0x01, 0x70, 0x82, 0x80, 0x01, 0xFE, 0x80, 
  0x01, 0x70, 0x82, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x70, 0x80, 0x03, 0x56, 0x1E, 0x67, 0x80, 0x01, 
  0xF0, 0x80, 0x03, 0x01, 0x12, 0x7E, 0x80, 0x01, 0x7C, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x5C, 
  0x82, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x7C, 0x80, 0x03, 0xA3, 0x1A, 0x6B, 0x80, 0x01, 0xFC, 0x80, 
  0x03, 0x00, 0x91, 0x7F, 0x80, 0x01, 0xFF, 0x82, 0x80, 0x01, 0xEF, 0x80, 0x01, 0x13, 0x82, 0x80, 
  0x01, 0xD9, 0x80, 0x01, 0xFF, 0x80, 0x03, 0x41, 0x95, 0x5F, 0x80, 0x01, 0x9F, 0x80, 0x02, 0x00, 
  0x70, 0x82, 0x80, 0x03, 0x3F, 0xFF, 0xE7, 0x80, 0x01, 0x33, 0x80, 0x03, 0x3F, 0xFF, 0xDF, 0x80, 
  0x01, 0xFF, 0x80, 0x03, 0x00, 0x78, 0xE7, 0x80, 0x01, 0x33, 0x04, 0x04, 0x04, 0x04, 
}; /* users */

