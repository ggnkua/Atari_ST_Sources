LOCAL UBYTE repdefn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x0F, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x70, 0x06, 0x01, 0x80, 0x04, 
  0x81, 0x9C, 0x0D, 0x01, 0x80, 0x04, 0x86, 0x32, 0x1E, 0x81, 0x80, 0x04, 0x88, 0x61, 0xE1, 0xC1, 
  0x80, 0x04, 0x88, 0xA0, 0x00, 0x61, 0x80, 0x04, 0x85, 0x44, 0xC0, 0x31, 0x80, 0x04, 0x86, 0x43, 
  0x40, 0x21, 0x80, 0x04, 0x84, 0x8E, 0x80, 0x21, 0x80, 0x04, 0x88, 0x81, 0x98, 0x41, 0x80, 0x04, 
  0x89, 0x19, 0x06, 0x41, 0x80, 0x04, 0x85, 0x06, 0x30, 0x81, 0x80, 0x04, 0x82, 0x31, 0x8C, 0x81, 
  0x80, 0x04, 0x84, 0x0C, 0x61, 0x01, 0x80, 0x04, 0x84, 0x03, 0x19, 0x01, 0x80, 0x04, 0x83, 0x00, 
  0xC2, 0x01, 0x80, 0x04, 0x80, 0xC0, 0x32, 0x01, 0x80, 0x04, 0x80, 0x30, 0x04, 0x01, 0x80, 0x04, 
  0x80, 0x0C, 0x04, 0x01, 0x80, 0x04, 0x80, 0x03, 0x08, 0x01, 0x80, 0x04, 0x80, 0x00, 0xC8, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x30, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* repdefn1 */

