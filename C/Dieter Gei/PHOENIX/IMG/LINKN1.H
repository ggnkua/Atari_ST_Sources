LOCAL UBYTE linkn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x08, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x18, 0x00, 0x01, 0x80, 0x04, 0x80, 0x38, 0x00, 0x01, 0x80, 0x04, 0x80, 0x7F, 
  0x80, 0x01, 0x80, 0x04, 0x80, 0xFF, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x7F, 0xC0, 0x01, 0x80, 0x04, 
  0x80, 0x39, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x19, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x09, 0xC0, 0x01, 
  0x80, 0x04, 0x80, 0x01, 0xFE, 0x01, 0x80, 0x04, 0x80, 0x01, 0xFE, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0xFE, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* linkn1 */

