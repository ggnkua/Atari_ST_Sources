LOCAL UBYTE qben1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xE1, 0x80, 0x04, 
  0x8F, 0xFF, 0xFF, 0xF1, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 
  0x80, 0x04, 0x89, 0x20, 0x42, 0x31, 0x80, 0x04, 0x89, 0x20, 0x42, 0x31, 0x80, 0x04, 0x8F, 0xFF, 
  0xFF, 0xF1, 0x80, 0x04, 0x89, 0x00, 0x00, 0x31, 0x80, 0x04, 0x89, 0x03, 0xE0, 0x31, 0x80, 0x04, 
  0x8F, 0x07, 0x70, 0x31, 0x80, 0x04, 0x89, 0x00, 0x70, 0x31, 0x80, 0x04, 0x89, 0x00, 0xE0, 0x31, 
  0x80, 0x04, 0x8F, 0x01, 0xC0, 0x31, 0x80, 0x04, 0x89, 0x01, 0xC0, 0x31, 0x80, 0x04, 0x89, 0x00, 
  0x00, 0x31, 0x80, 0x04, 0x8F, 0x01, 0xC0, 0x31, 0x80, 0x04, 0x89, 0x01, 0xC0, 0x31, 0x80, 0x04, 
  0x89, 0x00, 0x00, 0x31, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 0x80, 0x04, 0x87, 0xFF, 0xFF, 0xF1, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* qben1 */

