LOCAL UBYTE group [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x18, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x3E, 0x80, 0x01, 0x00, 0x80, 0x02, 0x00, 0x3E, 0x80, 0x01, 0x00, 0x80, 0x02, 
  0x00, 0x3E, 0x80, 0x01, 0x00, 0x80, 0x02, 0x00, 0x3E, 0x80, 0x01, 0x00, 0x80, 0x02, 0x00, 0x7F, 
  0x80, 0x01, 0xE0, 0x80, 0x02, 0x00, 0x7F, 0x80, 0x01, 0xE0, 0x80, 0x02, 0x00, 0x41, 0x80, 0x01, 
  0xE0, 0x80, 0x02, 0x00, 0x41, 0x80, 0x01, 0xE0, 0x80, 0x02, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x80, 
  0x02, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x80, 0x02, 0x00, 0x8F, 0x80, 0x01, 0xF0, 0x80, 0x02, 0x00, 
  0x8F, 0x80, 0x01, 0xF0, 0x80, 0x02, 0x01, 0xF1, 0x80, 0x01, 0xB0, 0x80, 0x02, 0x01, 0xF1, 0x80, 
  0x01, 0xB0, 0x80, 0x02, 0x01, 0x11, 0x80, 0x01, 0xB0, 0x80, 0x02, 0x01, 0x11, 0x80, 0x01, 0xF0, 
  0x80, 0x02, 0x01, 0xF3, 0x80, 0x01, 0x10, 0x80, 0x02, 0x01, 0xF3, 0x80, 0x01, 0x10, 0x80, 0x02, 
  0x01, 0x13, 0x80, 0x01, 0x10, 0x80, 0x02, 0x01, 0x17, 0x80, 0x01, 0xF0, 0x80, 0x02, 0x0F, 0xE0, 
  0x80, 0x01, 0xB0, 0x80, 0x02, 0x0F, 0xE0, 0x80, 0x01, 0xB0, 0x80, 0x02, 0x0F, 0x20, 0x80, 0x01, 
  0xB0, 0x80, 0x02, 0x0F, 0x20, 0x80, 0x01, 0xF0, 0x80, 0x02, 0x1F, 0xE3, 0x80, 0x01, 0x08, 0x80, 
  0x02, 0x1F, 0xE3, 0x80, 0x01, 0x08, 0x80, 0x02, 0x1F, 0x23, 0x80, 0x01, 0x08, 0x80, 0x02, 0x10, 
  0x21, 0x80, 0x01, 0xF8, 0x80, 0x02, 0x18, 0xE1, 0x80, 0x01, 0x10, 0x80, 0x02, 0x18, 0xE1, 0x80, 
  0x01, 0x10, 0x80, 0x02, 0x1F, 0x21, 0x80, 0x01, 0x10, 0x80, 0x02, 0x17, 0x21, 0x80, 0x01, 0xF0, 
  0x80, 0x02, 0x18, 0xE6, 0x80, 0x01, 0x10, 0x80, 0x02, 0x1A, 0xE6, 0x80, 0x01, 0x10, 0x80, 0x02, 
  0x1F, 0x26, 0x80, 0x01, 0x10, 0x80, 0x02, 0x14, 0x2F, 0x80, 0x01, 0xF0, 0x80, 0x02, 0x18, 0x77, 
  0x80, 0x01, 0x60, 0x80, 0x02, 0x1A, 0x77, 0x80, 0x01, 0x60, 0x80, 0x02, 0x1F, 0x97, 0x80, 0x01, 
  0x60, 0x80, 0x02, 0x14, 0x57, 0x80, 0x01, 0xE0, 0x80, 0x02, 0x18, 0x3B, 0x80, 0x01, 0x40, 0x80, 
  0x02, 0x18, 0x3B, 0x80, 0x01, 0x40, 0x80, 0x02, 0x1F, 0xCB, 0x80, 0x01, 0x40, 0x80, 0x02, 0x10, 
  0x0B, 0x80, 0x01, 0xC0, 0x80, 0x02, 0x1F, 0xFD, 0x80, 0x01, 0x20, 0x80, 0x02, 0x1F, 0xF1, 0x80, 
  0x01, 0xA0, 0x80, 0x02, 0x1F, 0xFD, 0x80, 0x01, 0xA0, 0x80, 0x02, 0x10, 0x01, 0x80, 0x01, 0x60, 
  0x80, 0x02, 0x1F, 0xFF, 0x80, 0x01, 0x90, 0x80, 0x02, 0x1F, 0xF8, 0x80, 0x01, 0x90, 0x80, 0x02, 
  0x1F, 0xFF, 0x80, 0x01, 0x90, 0x80, 0x02, 0x1F, 0xF8, 0x80, 0x01, 0x90, 0x80, 0x02, 0x20, 0x04, 
  0x80, 0x01, 0x00, 0x80, 0x02, 0x20, 0x04, 0x80, 0x01, 0x00, 0x80, 0x02, 0x20, 0x04, 0x80, 0x01, 
  0x00, 0x80, 0x02, 0x20, 0x04, 0x80, 0x01, 0x00, 0x80, 0x02, 0x3F, 0xFC, 0x80, 0x01, 0x00, 0x80, 
  0x02, 0x3F, 0xFC, 0x80, 0x01, 0x00, 0x80, 0x02, 0x3F, 0xFC, 0x80, 0x01, 0x00, 0x80, 0x02, 0x20, 
  0x04, 0x80, 0x01, 0x00, 0x80, 0x02, 0x3F, 0xFC, 0x80, 0x01, 0x00, 0x80, 0x02, 0x3F, 0xFC, 0x80, 
  0x01, 0x00, 0x80, 0x02, 0x3F, 0xFC, 0x80, 0x01, 0x00, 0x80, 0x02, 0x3F, 0xFC, 0x80, 0x01, 0x00, 
}; /* group */

