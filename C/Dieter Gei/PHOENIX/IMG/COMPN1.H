LOCAL UBYTE compn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x87, 0xFC, 0x00, 0x01, 0x80, 0x04, 0x86, 0x0C, 0x00, 0x01, 0x80, 0x04, 
  0x85, 0x14, 0x00, 0x01, 0x80, 0x04, 0x84, 0xA4, 0x00, 0x01, 0x80, 0x04, 0x84, 0x45, 0xE0, 0x01, 
  0x80, 0x04, 0x84, 0xA5, 0xC0, 0x01, 0x80, 0x04, 0x85, 0x15, 0xC0, 0x01, 0x80, 0x04, 0x86, 0x0D, 
  0x20, 0x01, 0x80, 0x04, 0x87, 0xFC, 0x10, 0x01, 0x80, 0x04, 0x80, 0x00, 0x08, 0x01, 0x80, 0x04, 
  0x80, 0x40, 0x04, 0x01, 0x80, 0x04, 0x80, 0x20, 0x00, 0x01, 0x80, 0x04, 0x80, 0x10, 0x7F, 0xC1, 
  0x80, 0x04, 0x80, 0x09, 0x40, 0x41, 0x80, 0x04, 0x80, 0x07, 0x40, 0x41, 0x80, 0x04, 0x80, 0x07, 
  0x40, 0x41, 0x80, 0x04, 0x80, 0x0F, 0x40, 0x41, 0x80, 0x04, 0x80, 0x00, 0x40, 0x41, 0x80, 0x04, 
  0x80, 0x00, 0x40, 0x41, 0x80, 0x04, 0x80, 0x00, 0x40, 0x41, 0x80, 0x04, 0x80, 0x00, 0x7F, 0xC1, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* compn1 */

