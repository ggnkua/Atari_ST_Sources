LOCAL UBYTE grafc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAF, 0x82, 0x80, 0x01, 0xFB, 0x80, 0x01, 0xA0, 0x02, 0x80, 0x01, 0x0B, 0x80, 0x01, 
  0xA0, 0x02, 0x80, 0x01, 0x0B, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF1, 0x80, 0x01, 0xDD, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x45, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x45, 
  0x80, 0x01, 0x88, 0x02, 0x80, 0x01, 0x11, 0x80, 0x03, 0xAA, 0xAE, 0xAA, 0x80, 0x01, 0xBB, 0x80, 
  0x01, 0xA2, 0x80, 0x02, 0xA2, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xA2, 0x80, 0x02, 0xA2, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x88, 0x0C, 0x00, 0x80, 0x01, 0x11, 0x80, 0x03, 0xDD, 0x5F, 0x57, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x4D, 0x50, 0x80, 0x01, 0x45, 0x80, 0x03, 0xD5, 0x4D, 0x50, 
  0x80, 0x01, 0x45, 0x80, 0x03, 0x88, 0x12, 0x07, 0x80, 0x01, 0x11, 0x80, 0x03, 0xAA, 0xBE, 0xAA, 
  0x80, 0x01, 0xBB, 0x80, 0x03, 0xA2, 0xAC, 0xA2, 0x80, 0x01, 0x2B, 0x80, 0x03, 0xA2, 0xAC, 0xA2, 
  0x80, 0x01, 0x2B, 0x80, 0x03, 0x88, 0x12, 0x08, 0x80, 0x01, 0x91, 0x80, 0x03, 0xDD, 0x7F, 0x5D, 
  0x80, 0x01, 0xD5, 0x80, 0x03, 0xD5, 0x0D, 0x55, 0x80, 0x01, 0x45, 0x80, 0x03, 0xD5, 0x0D, 0x55, 
  0x80, 0x01, 0x45, 0x80, 0x03, 0x88, 0x72, 0x08, 0x80, 0x01, 0x91, 0x80, 0x03, 0xAA, 0xFE, 0xAA, 
  0x80, 0x01, 0xBB, 0x80, 0x03, 0xA2, 0x6C, 0xA2, 0x80, 0x01, 0x2B, 0x80, 0x03, 0xA2, 0x6C, 0xA2, 
  0x80, 0x01, 0x2B, 0x80, 0x03, 0x88, 0x92, 0x08, 0x80, 0x01, 0x91, 0x80, 0x03, 0xDD, 0xFF, 0xD7, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x6C, 0x50, 0x80, 0x01, 0x45, 0x80, 0x03, 0xD5, 0x6C, 0x50, 
  0x80, 0x01, 0x45, 0x80, 0x03, 0x88, 0x93, 0x87, 0x80, 0x01, 0x11, 0x80, 0x03, 0xAA, 0xFF, 0xEA, 
  0x80, 0x01, 0xBB, 0x80, 0x03, 0xA2, 0x6D, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA2, 0x6D, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x88, 0x92, 0x40, 0x80, 0x01, 0x11, 0x80, 0x03, 0xDD, 0xFF, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x6D, 0x95, 0x80, 0x01, 0x45, 0x80, 0x03, 0xD5, 0x6D, 0x95, 
  0x80, 0x01, 0x45, 0x80, 0x03, 0x88, 0x92, 0x40, 0x80, 0x01, 0x11, 0x80, 0x03, 0xAA, 0xFF, 0xEA, 
  0x80, 0x01, 0xBB, 0x80, 0x03, 0xA2, 0xBD, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA2, 0xBD, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x88, 0x42, 0x40, 0x80, 0x01, 0x11, 0x80, 0x01, 0xDF, 0x82, 0x80, 
  0x01, 0xF5, 0x80, 0x03, 0xD0, 0x1F, 0x00, 0x80, 0x01, 0x05, 0x80, 0x03, 0xD0, 0x1F, 0x00, 0x80, 
  0x01, 0x05, 0x80, 0x03, 0x8F, 0xE0, 0xFF, 0x80, 0x01, 0xF1, 0x80, 0x03, 0xAA, 0xBF, 0xAA, 0x80, 
  0x01, 0xBB, 0x80, 0x03, 0xA2, 0xAE, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA2, 0xAE, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x88, 0x11, 0x00, 0x80, 0x01, 0x11, 0x80, 0x02, 0xDD, 0x5F, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x4D, 0x55, 0x80, 0x01, 0x45, 0x80, 0x03, 0xD5, 0x4D, 
  0x55, 0x80, 0x01, 0x45, 0x80, 0x03, 0x88, 0x12, 0x00, 0x80, 0x01, 0x11, 0x80, 0x03, 0xAA, 0xBE, 
  0xEB, 0x80, 0x01, 0xBB, 0x80, 0x03, 0xA2, 0xAC, 0x88, 0x80, 0x01, 0x2B, 0x80, 0x03, 0xA2, 0xAC, 
  0x88, 0x80, 0x01, 0x2B, 0x80, 0x03, 0x88, 0x12, 0x63, 0x80, 0x01, 0x91, 0x80, 0x03, 0xDD, 0x5F, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x4D, 0x80, 0x01, 0x45, 0x80, 0x01, 0x45, 0x80, 0x02, 
  0xD5, 0x4D, 0x80, 0x01, 0x45, 0x80, 0x01, 0x45, 0x80, 0x03, 0x88, 0x12, 0x90, 0x80, 0x01, 0x11, 
  0x80, 0x03, 0xAA, 0xBE, 0xFA, 0x80, 0x01, 0xBB, 0x80, 0x03, 0xA2, 0xAC, 0x72, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xA2, 0xAC, 0x72, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x88, 0x12, 0x88, 0x80, 0x01, 0x11, 
  0x80, 0x03, 0xDD, 0x5F, 0xFD, 0x80, 0x01, 0xD5, 0x80, 0x03, 0xD5, 0x41, 0x01, 0x80, 0x01, 0x45, 
  0x80, 0x03, 0xD5, 0x41, 0x01, 0x80, 0x01, 0x45, 0x80, 0x03, 0x88, 0x1E, 0xFC, 0x80, 0x01, 0x91, 
  0x80, 0x03, 0xAA, 0xFE, 0xAA, 0x80, 0x01, 0xBB, 0x80, 0x03, 0xA2, 0x02, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xA2, 0x02, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x88, 0xFC, 0x00, 0x80, 0x01, 0x11, 
  0x80, 0x02, 0xDF, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD0, 0x05, 0x55, 0x80, 
  0x01, 0x45, 0x80, 0x03, 0xD0, 0x05, 0x55, 0x80, 0x01, 0x45, 0x80, 0x03, 0x8F, 0xF8, 0x00, 0x80, 
  0x01, 0x11, 0x80, 0x01, 0xAF, 0x82, 0x80, 0x01, 0xFB, 0x80, 0x01, 0xA0, 0x02, 0x80, 0x01, 0x0B, 
  0x80, 0x01, 0xA0, 0x02, 0x80, 0x01, 0x0B, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF1, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 
  0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* grafc4 */

