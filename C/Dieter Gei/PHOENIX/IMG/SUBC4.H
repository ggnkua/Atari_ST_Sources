LOCAL UBYTE subc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD7, 0x82, 0x80, 0x01, 0xD5, 0x80, 0x01, 0xD0, 
  0x02, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD0, 0x02, 0x80, 0x01, 0x55, 0x80, 0x01, 0x85, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAF, 0x82, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xA8, 0x02, 0x80, 0x01, 0x2B, 0x80, 0x01, 0xA8, 0x02, 0x80, 0x01, 0x2B, 0x80, 0x01, 0x83, 0x82, 
  0x80, 0x01, 0x81, 0x80, 0x01, 0xD7, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0xD1, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD1, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x86, 0x02, 0x80, 0x01, 0x81, 0x80, 0x01, 
  0xAE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0x2B, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0x2B, 0x80, 0x01, 0x82, 0x02, 0x80, 0x01, 0x81, 0x80, 0x03, 0xD7, 0x7F, 0x7D, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0xD1, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD1, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0x86, 0x7E, 0x7C, 0x80, 0x01, 
  0x81, 0x80, 0x03, 0xAE, 0xAA, 0xEE, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0x2B, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0x2B, 0x80, 0x03, 0x82, 0x00, 0x44, 0x80, 0x01, 0x81, 0x80, 0x01, 0xD7, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x03, 0xD1, 0x55, 0x11, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD1, 
  0x55, 0x11, 0x80, 0x01, 0x55, 0x80, 0x03, 0x86, 0x00, 0x44, 0x80, 0x01, 0x81, 0x80, 0x01, 0xAE, 
  0x80, 0x01, 0xFE, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA8, 0x80, 0x82, 0x80, 0x01, 
  0x2B, 0x80, 0x03, 0xA8, 0x80, 0x82, 0x80, 0x01, 0x2B, 0x80, 0x03, 0x82, 0x7E, 0x7C, 0x80, 0x01, 
  0x81, 0x80, 0x01, 0xD7, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0xD1, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD1, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x86, 0x02, 0x80, 0x01, 0x81, 0x80, 0x01, 0xAE, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0x2B, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0x2B, 
  0x80, 0x01, 0x82, 0x02, 0x80, 0x01, 0x81, 0x80, 0x03, 0xD7, 0x7F, 0x7D, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0xD1, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD1, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0x86, 0x7E, 0x7C, 0x80, 0x01, 0x81, 0x80, 
  0x03, 0xAE, 0xAA, 0xEE, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0x2B, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0x2B, 0x80, 
  0x03, 0x82, 0x00, 0x44, 0x80, 0x01, 0x81, 0x80, 0x01, 0xD7, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0xD5, 0x80, 0x03, 0xD1, 0x55, 0x11, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD1, 0x55, 0x11, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0x86, 0x00, 0x44, 0x80, 0x01, 0x81, 0x80, 0x01, 0xAE, 0x80, 0x01, 
  0xFE, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA8, 0x80, 0x82, 0x80, 0x01, 0x2B, 0x80, 
  0x03, 0xA8, 0x80, 0x82, 0x80, 0x01, 0x2B, 0x80, 0x03, 0x82, 0x7E, 0x7C, 0x80, 0x01, 0x81, 0x80, 
  0x01, 0xD7, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0xD1, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD1, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x86, 0x02, 0x80, 0x01, 0x81, 0x80, 0x01, 0xAE, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0x2B, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0x2B, 0x80, 0x01, 
  0x82, 0x02, 0x80, 0x01, 0x81, 0x80, 0x01, 0xD7, 0x82, 0x80, 0x01, 0xD5, 0x80, 0x01, 0xD0, 0x02, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD0, 0x02, 0x80, 0x01, 0x55, 0x80, 0x01, 0x87, 0x82, 0x80, 0x01, 
  0x81, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 
  0x01, 0xFE, 
}; /* subc4 */

