LOCAL UBYTE lockn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x08, 0x20, 0x01, 
  0x80, 0x04, 0x80, 0x08, 0x20, 0x01, 0x80, 0x04, 0x80, 0x08, 0x20, 0x01, 0x80, 0x04, 0x80, 0x08, 
  0x20, 0x01, 0x80, 0x04, 0x80, 0x08, 0x20, 0x01, 0x80, 0x04, 0x80, 0x3F, 0xF8, 0x01, 0x80, 0x04, 
  0x80, 0x3F, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x3E, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x3E, 0xF8, 0x01, 
  0x80, 0x04, 0x80, 0x3E, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x3F, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x3F, 
  0xF8, 0x01, 0x80, 0x04, 0x80, 0x3F, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x3F, 0xF8, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* lockn1 */

