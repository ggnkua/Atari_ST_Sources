LOCAL UBYTE calcd4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x00, 0x02, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x02, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8F, 0xFF, 0xF9, 0x80, 0x01, 0x87, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 0x01, 0x39, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x90, 0x00, 0x05, 0x80, 0x01, 0x87, 0x80, 0x03, 0xA6, 0x00, 0x38, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xA6, 0x00, 0x38, 0x80, 0x01, 0x39, 0x80, 0x03, 0xA6, 0x00, 0x38, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x91, 0xFF, 0xC5, 0x80, 0x01, 0x87, 0x80, 0x03, 0xA6, 0x00, 0x78, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xA6, 0x00, 0x78, 0x80, 0x01, 0x39, 0x80, 0x03, 0xA6, 0x00, 0x78, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x91, 0x00, 0x05, 0x80, 0x01, 0x87, 0x80, 0x03, 0xA6, 0xFF, 0xF8, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xA6, 0xFF, 0xF8, 0x80, 0x01, 0x09, 0x80, 0x03, 0xA6, 0xFF, 0xF8, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0x91, 0x00, 0x05, 0x80, 0x01, 0xA7, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 0x01, 0x09, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0x90, 0x00, 0x05, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 0x01, 0x09, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0x90, 0x92, 0x45, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 0x01, 0x09, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0x91, 0xB6, 0xC5, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 0x01, 0x09, 0x80, 0x03, 0xA7, 0xFF, 0xF8, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0x90, 0x00, 0x05, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 0x01, 0x09, 0x80, 0x03, 0xA6, 0x49, 0x38, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0x90, 0x92, 0x45, 0x80, 0x01, 0x67, 0x80, 0x03, 0xA6, 0x49, 0x39, 0x80, 
  0x01, 0x89, 0x80, 0x03, 0xA6, 0x49, 0x39, 0x80, 0x01, 0x89, 0x80, 0x03, 0xA6, 0x49, 0x39, 0x80, 
  0x01, 0x89, 0x80, 0x03, 0x91, 0xB6, 0xC4, 0x80, 0x01, 0x67, 0x80, 0x03, 0xA7, 0xFF, 0xF9, 0x80, 
  0x01, 0x89, 0x80, 0x03, 0xA7, 0xFF, 0xF9, 0x80, 0x01, 0x89, 0x80, 0x03, 0xA7, 0xFF, 0xF9, 0x80, 
  0x01, 0x89, 0x80, 0x03, 0x90, 0x00, 0x04, 0x80, 0x01, 0x67, 0x80, 0x03, 0xA6, 0x48, 0xB9, 0x80, 
  0x01, 0x89, 0x80, 0x03, 0xA6, 0x48, 0xB9, 0x80, 0x01, 0x89, 0x80, 0x03, 0xA6, 0x48, 0xB9, 0x80, 
  0x01, 0x89, 0x80, 0x01, 0x90, 0x80, 0x02, 0x90, 0x44, 0x80, 0x01, 0x67, 0x80, 0x03, 0xA6, 0x48, 
  0x38, 0x80, 0x01, 0x01, 0x80, 0x03, 0xA6, 0x48, 0x38, 0x80, 0x01, 0x01, 0x80, 0x03, 0xA6, 0x48, 
  0x38, 0x80, 0x01, 0x01, 0x80, 0x03, 0x91, 0xB7, 0xC5, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xA7, 0xFF, 
  0xF9, 0x80, 0x01, 0x01, 0x80, 0x03, 0xA7, 0xFF, 0xF9, 0x80, 0x01, 0x01, 0x80, 0x03, 0xA7, 0xFF, 
  0xF9, 0x80, 0x01, 0x01, 0x80, 0x03, 0x90, 0x00, 0x04, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xA7, 0xFF, 
  0xF9, 0x80, 0x01, 0x89, 0x80, 0x03, 0xA7, 0xFF, 0xF9, 0x80, 0x01, 0x89, 0x80, 0x03, 0xA7, 0xFF, 
  0xF9, 0x80, 0x01, 0x89, 0x80, 0x03, 0x90, 0x00, 0x04, 0x80, 0x01, 0x67, 0x80, 0x03, 0xB0, 0x00, 
  0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB0, 0x00, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB0, 0x00, 
  0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8F, 0xFF, 0xF8, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 
  0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* calcd4 */

