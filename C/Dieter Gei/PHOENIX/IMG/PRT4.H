LOCAL UBYTE prt4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x80, 0x01, 0x00, 0x80, 0x01, 0x70, 0x02, 0x02, 0x02, 0x80, 0x01, 0x00, 0x80, 
  0x01, 0x8C, 0x80, 0x01, 0x00, 0x80, 0x01, 0x03, 0x80, 0x01, 0x00, 0x80, 0x01, 0x03, 0x80, 0x01, 
  0x00, 0x80, 0x01, 0x03, 0x80, 0x01, 0x01, 0x80, 0x01, 0x03, 0x80, 0x01, 0x00, 0x80, 0x01, 0x04, 
  0x80, 0x01, 0x00, 0x80, 0x01, 0x04, 0x80, 0x01, 0x00, 0x80, 0x01, 0x04, 0x80, 0x01, 0x06, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x01, 0x80, 0x01, 0x08, 0x80, 0x01, 0x01, 0x80, 0x01, 0x08, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x08, 0x80, 0x01, 0x1A, 0x80, 0x01, 0x08, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x58, 
  0x80, 0x01, 0x0E, 0x80, 0x01, 0x58, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x58, 0x80, 0x01, 0x61, 0x80, 
  0x01, 0x96, 0x80, 0x01, 0x33, 0x80, 0x01, 0x99, 0x80, 0x01, 0x3F, 0x80, 0x01, 0x99, 0x80, 0x01, 
  0x33, 0x80, 0x01, 0x99, 0x80, 0x01, 0x80, 0x80, 0x01, 0x77, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xE1, 
  0x80, 0x01, 0x0C, 0x80, 0x01, 0xE1, 0x80, 0x01, 0x0C, 0x80, 0x01, 0xE1, 0x80, 0x01, 0x80, 0x80, 
  0x01, 0x1F, 0x80, 0x01, 0x33, 0x80, 0x01, 0x81, 0x80, 0x01, 0x33, 0x80, 0x01, 0x81, 0x80, 0x01, 
  0x33, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0x80, 0x01, 0x7F, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x3C, 0x80, 0x01, 0x01, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 
  0x01, 0xFF, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x06, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x06, 0x80, 0x01, 
  0x3E, 0x80, 0x01, 0x06, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x1A, 
  0x80, 0x01, 0x0E, 0x80, 0x01, 0x1A, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x1A, 0x80, 0x01, 0x71, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x72, 0x80, 0x01, 0x66, 0x80, 0x01, 0x72, 0x80, 0x01, 0x66, 0x80, 0x01, 
  0x72, 0x80, 0x01, 0x66, 0x80, 0x01, 0x4D, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x3D, 0x80, 0x01, 0x98, 
  0x80, 0x01, 0x3D, 0x80, 0x01, 0x98, 0x80, 0x01, 0x3D, 0x80, 0x01, 0x98, 0x80, 0x01, 0x33, 0x80, 
  0x01, 0xF8, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x60, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x60, 0x80, 0x01, 
  0x0E, 0x80, 0x01, 0x60, 0x80, 0x01, 0x0D, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 
  0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x03, 0x80, 
  0x01, 0x80, 
}; /* prt4 */

