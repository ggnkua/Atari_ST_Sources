LOCAL UBYTE searchn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x3E, 0x00, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x41, 0x80, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 
  0xF8, 0x40, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x87, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x86, 0x20, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0x81, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x81, 0x80, 0x02, 0x81, 0x20, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBE, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBE, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBE, 0x84, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x84, 0x90, 0x80, 0x01, 
  0x07, 0x80, 0x01, 0xBE, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBE, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBE, 0x82, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x82, 0x80, 0x02, 0x82, 0x90, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xFF, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBE, 0x42, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x42, 0x50, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xFF, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBE, 0x41, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x41, 0x50, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0x3F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x3F, 0xFF, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0x21, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x21, 0x50, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0x1F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x1F, 0xFF, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0x18, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x18, 0x60, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0x87, 0xDF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x87, 0xDF, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0x87, 0xDF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x87, 0xD0, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xE0, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x8F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x60, 0x88, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xFF, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xD7, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1F, 0x5C, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xFF, 0xE3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xE3, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xE3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x3E, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xFF, 0xF1, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF1, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF1, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xFF, 0xF8, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF8, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF8, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x01, 
  0x87, 0x80, 0x03, 0xBF, 0xFF, 0xFC, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFC, 0x80, 0x01, 
  0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFC, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x00, 0x07, 0x80, 0x01, 
  0xC7, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x00, 0x03, 0x80, 0x01, 
  0xC7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x01, 0x80, 0x01, 0x87, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 
  0x80, 0x01, 0xFE, 0x00
}; /* searchn4 */

