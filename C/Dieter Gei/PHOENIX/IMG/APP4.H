LOCAL UBYTE app4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x56, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x0C, 0x80, 0x01, 0x40, 0x80, 0x01, 0x0C, 0x80, 0x01, 0x40, 0x80, 0x01, 0x0C, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x06, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 
  0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x40, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x5F, 0x80, 
  0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 
  0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x40, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x5F, 0x80, 
  0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 
  0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x40, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x5F, 0x80, 
  0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 
  0x80, 0x01, 0x5F, 0x80, 0x01, 0xF4, 0x80, 0x01, 0x40, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x60, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x60, 0x80, 0x01, 0x04, 0x80, 0x01, 0x60, 0x80, 0x01, 0x04, 0x80, 0x01, 
  0x5F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x80, 
  0x01, 0x3F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x02, 0x00
}; /* app4 */

