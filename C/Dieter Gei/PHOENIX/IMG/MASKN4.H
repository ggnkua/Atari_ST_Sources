LOCAL UBYTE maskn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 
  0x39, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x88, 0x02, 0x80, 0x01, 0x37, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 
  0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x88, 0x02, 0x80, 
  0x01, 0x37, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 
  0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 0x02, 
  0x80, 0x01, 0x39, 0x80, 0x01, 0x88, 0x02, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBB, 0xAA, 0x7A, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0xBB, 0xAA, 0x7A, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBB, 0xAA, 0x7A, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0x8B, 0xAA, 0x7A, 0x80, 0x01, 0xB7, 0x80, 0x03, 0xBA, 0x80, 0x00, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBA, 0x80, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBA, 0x80, 0x00, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8A, 0x80, 0x00, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBB, 0xAA, 0x7A, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0xBB, 0xAA, 0x7A, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBB, 0xAA, 0x7A, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0x8B, 0xAA, 0x7A, 0x80, 0x01, 0xB7, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 
  0x39, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 
  0x01, 0x88, 0x02, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBB, 0xA8, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 
  0xBB, 0xA8, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBB, 0xA8, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 
  0x8B, 0xA8, 0x00, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBA, 0x83, 0xFF, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0xBA, 0x83, 0xFF, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBA, 0x83, 0xFF, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0x8A, 0x83, 0xFF, 0x80, 0x01, 0xB7, 0x80, 0x03, 0xBB, 0xAA, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0xBB, 0xAA, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBB, 0xAA, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0x8B, 0xAA, 0x00, 0x80, 0x01, 0xB7, 0x80, 0x03, 0xB8, 0x02, 0xAE, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0xB8, 0x02, 0xAE, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xB8, 0x02, 0xAE, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0x88, 0x02, 0xAE, 0x80, 0x01, 0xB7, 0x80, 0x03, 0xB8, 0x02, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0xB8, 0x02, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xB8, 0x02, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0x88, 0x02, 0x00, 0x80, 0x01, 0xB7, 0x80, 0x03, 0xBB, 0xFA, 0xAE, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0xBB, 0xFA, 0xAE, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBB, 0xFA, 0xAE, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0x8B, 0xFA, 0xAE, 0x80, 0x01, 0xB7, 0x80, 0x03, 0xB8, 0x02, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0xB8, 0x02, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xB8, 0x02, 0x00, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0x88, 0x02, 0x00, 0x80, 0x01, 0xB7, 0x80, 0x03, 0xBA, 0xAB, 0xFF, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0xBA, 0xAB, 0xFF, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBA, 0xAB, 0xFF, 0x80, 0x01, 0xB9, 0x80, 0x03, 
  0x8A, 0xAB, 0xFF, 0x80, 0x01, 0xB7, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 
  0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0x88, 0x02, 0x80, 
  0x01, 0x37, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x87, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* maskn4 */

