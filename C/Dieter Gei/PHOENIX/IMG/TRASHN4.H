LOCAL UBYTE trashn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xC1, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xFF, 0xC1, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xC1, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0x81, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0xFF, 0x81, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x81, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 
  0x02, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 
  0x01, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFC, 0x04, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFC, 
  0x04, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xFC, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x03, 
  0xFB, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF8, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF8, 
  0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF8, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x04, 
  0x0F, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF0, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 
  0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF8, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x08, 
  0x0F, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF0, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 
  0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF8, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0F, 
  0xDF, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 
  0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x79, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 
  0x7E, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xC0, 0x83, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 
  0x83, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 
  0x7C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x81, 0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x81, 
  0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x81, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 
  0xF8, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFE, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 
  0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x01, 
  0xF0, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x02, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 
  0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x01, 
  0xE0, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x02, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 
  0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x01, 
  0xC0, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x02, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 
  0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x01, 
  0x80, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x02, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 
  0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x02, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x01, 
  0x00, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* trashn4 */

