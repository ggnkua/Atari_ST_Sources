LOCAL UBYTE gemm [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x3F, 0xE0, 0x80, 0x02, 0x3F, 0xF0, 0x80, 0x02, 0x3F, 0xF8, 
  0x80, 0x02, 0x3F, 0xFC, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x3F, 0xFE, 
  0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x3F, 0xFE, 
  0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x1F, 0xFE, 0x80, 0x02, 0x00, 0x00, 
}; /* gemm */

