LOCAL UBYTE firstn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x08, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x18, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0xEF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xEF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x38, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0xCF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xCF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x78, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0x8F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0x8F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0xF8, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0x0F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0x0F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1D, 0xF8, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0x8F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0x8F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0xF8, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0xCF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xCF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x78, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0xEF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xEF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x38, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF7, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF7, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1C, 0x18, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x1C, 0x08, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 
  0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* firstn4 */

