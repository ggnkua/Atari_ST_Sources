LOCAL UBYTE textc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xAB, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x02, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0x2A, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x55, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x02, 0xD5, 0x54, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x54, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xAA, 0xAB, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xD5, 0x57, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x54, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xAA, 0xAF, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x0A, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0xA8, 0x0A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xD5, 0x57, 0xF5, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x51, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x51, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x06, 0xE0, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xAA, 0xAE, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA0, 0x0A, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0xA0, 0x0A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x0E, 0xF0, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xD5, 0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x51, 0x05, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x51, 0x05, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x0C, 0x70, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xAA, 0xBE, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0x82, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0xA2, 0x82, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x1C, 0x78, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xD5, 0x5D, 0x7D, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x45, 0x80, 0x01, 0x45, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x45, 0x80, 0x01, 0x45, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0x80, 0x18, 0x38, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBF, 0xFE, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0x80, 0x02, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x02, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x80, 0x3F, 0xFC, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x75, 0x5D, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x45, 0x41, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x45, 0x41, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0x80, 0x30, 0x1C, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xFA, 0xBE, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0x8A, 0xA0, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x8A, 0xA0, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x80, 0x70, 0x1E, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x75, 0x5F, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x15, 0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x15, 0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0x80, 0x60, 0x0E, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xEA, 0xAF, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0x0A, 0xA0, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x0A, 0xA0, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x80, 0xE0, 0x0F, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0xFD, 0x7F, 0x80, 0x01, 0xD5, 0x80, 0x03, 
  0xD4, 0x05, 0x40, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD4, 0x05, 0x40, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0x81, 0xF8, 0x3F, 0x80, 0x01, 0x81, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 
  0x01, 0xFE, 
}; /* textc4 */

