LOCAL UBYTE basen4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0xFF, 0xF0, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x00, 0x1F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x00, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x00, 0x1F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x18, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x00, 0x17, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x00, 0x17, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x00, 0x17, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x14, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFE, 0x13, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x13, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x13, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0xFE, 0x12, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0x91, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x91, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x01, 0x91, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x87, 0xFF, 0x91, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xDF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xDF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x5F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x8E, 0x01, 0xDF, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x01, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x8F, 0xFF, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB9, 0xFE, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x89, 0xFF, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 0x07, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBC, 0x63, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x8B, 0x9F, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xAD, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x8A, 0x57, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xA3, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x8A, 0x5F, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xAD, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x8A, 0x57, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBC, 0x63, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x8B, 0x9F, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x40, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 0x07, 0xC0, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFF, 0x80, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x80, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x01, 0x80, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x86, 0x0F, 0x80, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xFE, 0x00, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x00, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0xFE, 0x00, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBF, 0x02, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0x81, 0x02, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x81, 0x02, 
  0x80, 0x01, 0x87, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x81, 0x82, 0x80, 0x01, 0x87, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 
  0x82, 0x80, 0x01, 0xFE, 
}; /* basen4 */

