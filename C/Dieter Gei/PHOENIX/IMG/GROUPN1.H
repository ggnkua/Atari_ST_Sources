LOCAL UBYTE groupn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x2A, 0xB8, 0x01, 0x80, 0x04, 0x80, 0x12, 0x90, 0x01, 0x80, 0x04, 0x81, 0x91, 0x23, 0x81, 
  0x80, 0x04, 0x81, 0x29, 0x38, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 
  0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 
  0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 
  0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 
  0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 
  0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0xFF, 0xFF, 0x81, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* groupn1 */

