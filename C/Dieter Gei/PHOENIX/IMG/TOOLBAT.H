LOCAL UBYTE toolbat [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xFC, 0x80, 0x01, 
  0x07, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x0F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x08, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x08, 0x80, 0x01, 0x02, 0x80, 0x01, 0x1F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x1F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x13, 0x80, 0x01, 0xBA, 0x80, 0x01, 0x13, 0x80, 0x01, 0xBA, 
  0x80, 0x01, 0x3E, 0x80, 0x01, 0x66, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x66, 0x80, 0x01, 0x22, 0x80, 
  0x01, 0x22, 0x80, 0x01, 0x22, 0x80, 0x01, 0xAA, 0x80, 0x01, 0x7E, 0x80, 0x01, 0x66, 0x80, 0x01, 
  0x7E, 0x80, 0x01, 0x66, 0x80, 0x01, 0x42, 0x80, 0x01, 0x22, 0x80, 0x01, 0x43, 0x80, 0x01, 0xBA, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xBA, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xBA, 
  0x80, 0x01, 0x72, 0x80, 0x01, 0x66, 0x80, 0x01, 0x72, 0x80, 0x01, 0x66, 0x80, 0x01, 0x52, 0x80, 
  0x01, 0x22, 0x80, 0x01, 0x56, 0x80, 0x01, 0xAA, 0x80, 0x01, 0x72, 0x80, 0x01, 0x66, 0x80, 0x01, 
  0x72, 0x80, 0x01, 0x66, 0x80, 0x01, 0x52, 0x80, 0x01, 0x22, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xBA, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 
  0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 
}; /* toolbat */

