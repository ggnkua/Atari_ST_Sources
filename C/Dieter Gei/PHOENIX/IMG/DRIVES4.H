LOCAL UBYTE drives4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x80, 0x00, 0x10, 
  0x10, 0x10, 0x10, 0x10, 0x0F, 0x80, 0x01, 0x10, 0x0F, 0x80, 0x01, 0x10, 0x0F, 0x80, 0x01, 0x10, 
  0x80, 0x05, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x0A, 0x80, 0x01, 0x30, 0x02, 0x80, 0x03, 0x1F, 0x00, 
  0x3E, 0x0A, 0x80, 0x01, 0x38, 0x02, 0x80, 0x03, 0x1F, 0x00, 0x3E, 0x0A, 0x80, 0x01, 0x38, 0x02, 
  0x80, 0x03, 0x1F, 0x00, 0x14, 0x0A, 0x80, 0x01, 0x38, 0x80, 0x05, 0x20, 0x80, 0x20, 0x80, 0x41, 
  0x0A, 0x80, 0x01, 0x88, 0x80, 0x05, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x07, 0x80, 0x03, 0xF8, 0xFF, 
  0x00, 0x80, 0x01, 0xFC, 0x80, 0x05, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0x07, 0x80, 0x03, 0xF8, 0xFF, 
  0x00, 0x80, 0x01, 0xFC, 0x80, 0x05, 0x15, 0x00, 0x35, 0x80, 0x2A, 0x07, 0x80, 0x03, 0xF8, 0xFF, 
  0x00, 0x80, 0x01, 0xFC, 0x80, 0x0F, 0x40, 0x7E, 0x4A, 0x7E, 0x80, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 
  0x3F, 0xFE, 0xF8, 0xFF, 0x02, 0x80, 0x01, 0x04, 0x80, 0x0B, 0x1F, 0x81, 0x3F, 0xFD, 0x00, 0x02, 
  0x3F, 0xFD, 0x3F, 0xFD, 0x3F, 0x80, 0x01, 0xFD, 0x80, 0x03, 0xFD, 0xFF, 0x03, 0x80, 0x01, 0xFE, 
  0x80, 0x0B, 0x1F, 0x81, 0x3F, 0xFD, 0x00, 0x02, 0x3F, 0xFD, 0x3F, 0xFD, 0x3F, 0x80, 0x01, 0xFD, 
  0x80, 0x03, 0xFD, 0xFF, 0x03, 0x80, 0x01, 0xFE, 0x80, 0x0B, 0x0A, 0x81, 0x2A, 0xFD, 0x00, 0x02, 
  0x3F, 0xFD, 0x3F, 0xFD, 0x3F, 0x80, 0x01, 0xFD, 0x80, 0x03, 0xFD, 0xFF, 0x03, 0x80, 0x01, 0xFE, 
  0x80, 0x0F, 0x40, 0x03, 0x55, 0x03, 0x80, 0x06, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x05, 0x00, 
  0x08, 0x80, 0x01, 0x02, 0x80, 0x0C, 0x1F, 0xFD, 0x3F, 0xFD, 0x3F, 0xFA, 0x00, 0x01, 0x00, 0x01, 
  0x00, 0x01, 0x82, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xFD, 0x80, 0x0C, 0x1F, 0xFD, 0x3F, 0xFD, 0x3F, 
  0xFA, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x82, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xFD, 0x80, 0x0C, 
  0x15, 0x55, 0x35, 0x55, 0x15, 0x52, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x82, 0x80, 0x01, 0x0F, 
  0x80, 0x01, 0xFD, 0x80, 0x0F, 0x40, 0x03, 0x4A, 0xAB, 0x80, 0x06, 0x80, 0x07, 0x80, 0x07, 0x80, 
  0x07, 0xF2, 0x7F, 0x20, 0x80, 0x01, 0x03, 0x80, 0x0F, 0x00, 0x05, 0x00, 0x05, 0x3F, 0xFA, 0x78, 
  0x79, 0x7F, 0xE9, 0x7F, 0xF9, 0x0F, 0x80, 0x7F, 0x80, 0x01, 0xF1, 0x80, 0x0F, 0x00, 0x05, 0x00, 
  0x05, 0x3F, 0xFA, 0x78, 0x69, 0x7F, 0xF9, 0x7F, 0xF9, 0x0F, 0x80, 0x7F, 0x80, 0x01, 0xF1, 0x80, 
  0x0F, 0x00, 0x01, 0x00, 0x01, 0x2A, 0xAA, 0x78, 0x69, 0x7F, 0xE9, 0x7F, 0xF9, 0x0F, 0x80, 0x7F, 
  0x80, 0x01, 0xF1, 0x80, 0x02, 0xFF, 0xFB, 0x82, 0x80, 0x02, 0x80, 0x06, 0x80, 0x01, 0x87, 0x80, 
  0x06, 0x87, 0x80, 0x17, 0xBF, 0xF7, 0x08, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x0F, 
  0x80, 0x0F, 0x00, 0x0D, 0x00, 0x0D, 0x3F, 0xFA, 0x47, 0x89, 0x7F, 0xF9, 0x74, 0xB9, 0x07, 0x00, 
  0x3F, 0x80, 0x01, 0xC7, 0x80, 0x0F, 0x00, 0x0D, 0x00, 0x0D, 0x3F, 0xFA, 0x47, 0x89, 0x7F, 0xF9, 
  0x74, 0xB9, 0x07, 0x00, 0x3F, 0x80, 0x01, 0xC7, 0x80, 0x0F, 0x00, 0x0D, 0x00, 0x0D, 0x15, 0x52, 
  0x47, 0x89, 0x7F, 0xF9, 0x74, 0xB9, 0x07, 0x00, 0x3F, 0x80, 0x01, 0xC7, 0x80, 0x0F, 0x80, 0x1B, 
  0x80, 0x1B, 0x80, 0x06, 0xBF, 0xF7, 0x80, 0x07, 0xB9, 0x77, 0x05, 0x00, 0x80, 0x80, 0x01, 0x3F, 
  0x80, 0x0F, 0x3F, 0xF9, 0x3F, 0xF9, 0x3F, 0xFA, 0x78, 0x79, 0x40, 0x09, 0x7E, 0xF9, 0x1F, 0xC0, 
  0x5F, 0x80, 0x01, 0x1A, 0x80, 0x0F, 0x3F, 0xF9, 0x3F, 0xF9, 0x3F, 0xFA, 0x78, 0x79, 0x40, 0x09, 
  0x7E, 0xF9, 0x1F, 0xC0, 0x5F, 0x80, 0x01, 0x1A, 0x80, 0x0F, 0x2A, 0xA9, 0x2A, 0xA9, 0x2A, 0xAA, 
  0x78, 0x79, 0x40, 0x09, 0x7E, 0xF9, 0x1F, 0xC0, 0x5F, 0x80, 0x01, 0x1A, 0x80, 0x0F, 0x80, 0x0F, 
  0x80, 0x0F, 0x80, 0x06, 0x80, 0x07, 0xBF, 0xF7, 0x88, 0x47, 0x1F, 0xC0, 0x80, 0x80, 0x01, 0xFE, 
  0x80, 0x0F, 0x1F, 0xF5, 0x1F, 0xF5, 0x3F, 0xFA, 0x7F, 0xF9, 0x40, 0x09, 0x7F, 0xF9, 0x1F, 0xC0, 
  0x4C, 0x80, 0x01, 0x6A, 0x80, 0x0F, 0x1F, 0xF5, 0x1F, 0xF5, 0x3F, 0xFA, 0x7F, 0xF9, 0x40, 0x09, 
  0x7F, 0xE9, 0x1F, 0xC0, 0x4C, 0x80, 0x01, 0x6A, 0x80, 0x0F, 0x15, 0x55, 0x15, 0x55, 0x15, 0x52, 
  0x7F, 0xF9, 0x40, 0x09, 0x7F, 0xE9, 0x1F, 0xC0, 0x4C, 0x80, 0x01, 0x6A, 0x80, 0x0A, 0x40, 0x0F, 
  0x40, 0x0F, 0x80, 0x06, 0x80, 0x07, 0x80, 0x07, 0x80, 0x01, 0x87, 0x80, 0x04, 0x87, 0x10, 0x40, 
  0x63, 0x80, 0x01, 0xFA, 0x80, 0x0F, 0x1F, 0xFD, 0x1F, 0xFD, 0x3F, 0xFA, 0x00, 0x02, 0x00, 0x02, 
  0x00, 0x02, 0x1F, 0xC0, 0x21, 0x80, 0x01, 0xAA, 0x80, 0x0F, 0x1F, 0xFD, 0x1F, 0xFD, 0x3F, 0xFA, 
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x1F, 0xC0, 0x21, 0x80, 0x01, 0xAA, 0x80, 0x0F, 0x0A, 0xAD, 
  0x0A, 0xAD, 0x2A, 0xAA, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x1F, 0xC0, 0x21, 0x80, 0x01, 0xAA, 
  0x80, 0x0F, 0x40, 0x07, 0x40, 0x07, 0x80, 0x06, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 
  0x37, 0x80, 0x01, 0xEA, 0x80, 0x0F, 0x0F, 0xFB, 0x0F, 0xFB, 0x3F, 0xFA, 0x7F, 0xFC, 0x7F, 0xFC, 
  0x7F, 0xFC, 0x05, 0x00, 0x1E, 0x80, 0x01, 0xA8, 0x80, 0x0F, 0x0F, 0xFB, 0x0F, 0xFB, 0x3F, 0xFA, 
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x05, 0x00, 0x1E, 0x80, 0x01, 0xA8, 0x80, 0x0F, 0x05, 0x53, 
  0x05, 0x53, 0x15, 0x52, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x05, 0x00, 0x1E, 0x80, 0x01, 0xA8, 
  0x80, 0x0F, 0x20, 0x07, 0x20, 0x07, 0x80, 0x06, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x05, 0x00, 
  0x17, 0x80, 0x01, 0xA8, 0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x08, 0x80, 0x01, 0x0A, 
  0x80, 0x01, 0xA0, 0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x08, 0x80, 0x01, 0x0A, 0x80, 
  0x01, 0xA0, 0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x08, 0x80, 0x01, 0x0A, 0x80, 0x01, 
  0xA0, 0x80, 0x03, 0x3F, 0xFF, 0x3F, 0x82, 0x80, 0x01, 0xFE, 0x08, 0x80, 0x01, 0x0E, 0x80, 0x01, 
  0xA0, 0x80, 0x06, 0x1F, 0xFF, 0x1F, 0xFF, 0x7F, 0xFE, 0x08, 0x80, 0x01, 0x02, 0x80, 0x01, 0x80, 
  0x80, 0x06, 0x1F, 0xFF, 0x1F, 0xFF, 0x7F, 0xFE, 0x08, 0x80, 0x01, 0x02, 0x80, 0x01, 0x80, 0x80, 
  0x06, 0x1F, 0xFF, 0x1F, 0xFF, 0x7F, 0xFE, 0x08, 0x80, 0x01, 0x02, 0x80, 0x01, 0x80, 0x80, 0x06, 
  0x1F, 0xFF, 0x1F, 0xFF, 0x7F, 0xFE, 0x08, 0x80, 0x01, 0x02, 0x80, 0x01, 0x80, 0x0E, 0x80, 0x01, 
  0x02, 0x80, 0x01, 0x00, 0x0E, 0x80, 0x01, 0x02, 0x80, 0x01, 0x00, 0x0E, 0x80, 0x01, 0x02, 0x80, 
  0x01, 0x00, 0x0E, 0x80, 0x01, 0x02, 0x80, 0x01, 0x00, 0x10, 0x10, 0x10, 0x10, 0x00
}; /* drives4 */

