LOCAL UBYTE daten4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x87, 0xFD, 0xFF, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBC, 0x03, 0x00, 
  0x80, 0x01, 0x79, 0x80, 0x03, 0xBC, 0x03, 0x00, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBC, 0x03, 0x00, 
  0x80, 0x01, 0x79, 0x80, 0x03, 0x84, 0x03, 0x00, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x61, 0x1C, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xE5, 0xBE, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x05, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x05, 0x80, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x04, 0x80, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xE7, 0xB6, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x07, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x07, 0x80, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x07, 0x80, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x61, 0x06, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x61, 0x1C, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x61, 0x38, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xF1, 0x3E, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xF1, 0x3E, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBD, 0xF5, 0xBE, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBD, 0xF5, 0xBE, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBD, 0xF5, 0xBE, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8D, 0xF4, 0xBE, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x07, 0x80, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x07, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x07, 0x80, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x07, 0x80, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBD, 0xF1, 0x3E, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBD, 0xF1, 0x3E, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBD, 0xF1, 0x3E, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8D, 0xF3, 0x3E, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBE, 0x00, 0x80, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBE, 0x00, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBE, 0x00, 0x80, 0x80, 
  0x01, 0x39, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0x8F, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 
  0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 
  0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* daten4 */

