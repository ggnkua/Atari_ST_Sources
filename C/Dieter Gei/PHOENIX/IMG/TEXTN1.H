LOCAL UBYTE textn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x01, 0x80, 0x01, 0x80, 0x04, 0x80, 0x01, 0x80, 0x01, 0x80, 0x04, 0x80, 0x03, 0xC0, 0x01, 
  0x80, 0x04, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x07, 0xE0, 0x01, 0x80, 0x04, 0x80, 0x06, 
  0xE0, 0x01, 0x80, 0x04, 0x80, 0x0E, 0xF0, 0x01, 0x80, 0x04, 0x80, 0x0C, 0x70, 0x01, 0x80, 0x04, 
  0x80, 0x1C, 0x78, 0x01, 0x80, 0x04, 0x80, 0x18, 0x38, 0x01, 0x80, 0x04, 0x80, 0x3F, 0xFC, 0x01, 
  0x80, 0x04, 0x80, 0x30, 0x1C, 0x01, 0x80, 0x04, 0x80, 0x70, 0x1E, 0x01, 0x80, 0x04, 0x80, 0x60, 
  0x0E, 0x01, 0x80, 0x04, 0x80, 0xE0, 0x0F, 0x01, 0x80, 0x04, 0x81, 0xF8, 0x3F, 0x81, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* textn1 */

