LOCAL UBYTE gem1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x3F, 0xE0, 0x80, 0x02, 0x20, 0x30, 0x80, 0x02, 0x20, 0x28, 
  0x80, 0x02, 0x22, 0x3C, 0x80, 0x02, 0x27, 0x06, 0x80, 0x02, 0x2F, 0x86, 0x80, 0x02, 0x20, 0x26, 
  0x80, 0x02, 0x20, 0x76, 0x80, 0x02, 0x2E, 0xFE, 0x80, 0x02, 0x2E, 0x76, 0x80, 0x02, 0x2E, 0x26, 
  0x80, 0x02, 0x20, 0x06, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x1F, 0xFE, 0x80, 0x02, 0x00, 0x00, 
}; /* gem1 */

