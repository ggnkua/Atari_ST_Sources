LOCAL UBYTE ffn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x03, 
  0xFC, 0x01, 0x80, 0x04, 0x80, 0x02, 0x06, 0x01, 0x80, 0x04, 0x80, 0x02, 0x05, 0x01, 0x80, 0x04, 
  0x80, 0x02, 0x04, 0x81, 0x80, 0x04, 0x80, 0x02, 0x04, 0x41, 0x80, 0x04, 0x80, 0x02, 0x07, 0xC1, 
  0x80, 0x04, 0x80, 0x02, 0x00, 0x41, 0x80, 0x04, 0x80, 0x02, 0x00, 0x41, 0x80, 0x04, 0x80, 0x02, 
  0x00, 0x41, 0x80, 0x04, 0x80, 0x02, 0x00, 0x41, 0x80, 0x04, 0x80, 0x02, 0x00, 0x41, 0x80, 0x04, 
  0x80, 0x02, 0x00, 0x41, 0x80, 0x04, 0x80, 0x82, 0x00, 0x41, 0x80, 0x04, 0x80, 0xC2, 0x00, 0x41, 
  0x80, 0x04, 0x80, 0xE3, 0xFF, 0xC1, 0x80, 0x04, 0x87, 0xF0, 0x00, 0x01, 0x80, 0x04, 0x87, 0xF8, 
  0x00, 0x01, 0x80, 0x04, 0x87, 0xF0, 0x00, 0x01, 0x80, 0x04, 0x80, 0xE3, 0xFF, 0xC1, 0x80, 0x04, 
  0x80, 0xC2, 0x00, 0x41, 0x80, 0x04, 0x80, 0x82, 0x00, 0x41, 0x80, 0x04, 0x80, 0x02, 0x00, 0x41, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* ffn1 */

