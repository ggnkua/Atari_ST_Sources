LOCAL UBYTE boxn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x04, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x81, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0xFF, 0x10, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 
  0x80, 0x04, 0x81, 0xFF, 0xFF, 0x81, 0x00, 0x00, 0xFF, 0x04, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* boxn1 */

