LOCAL UBYTE daten1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x87, 0xFC, 0xFF, 0x81, 0x80, 0x04, 
  0x84, 0x03, 0x00, 0xC1, 0x80, 0x04, 0x84, 0x03, 0x00, 0xE1, 0x80, 0x04, 0x84, 0x63, 0x1C, 0xE1, 
  0x80, 0x04, 0x84, 0xE4, 0xBE, 0xE1, 0x80, 0x04, 0x84, 0xE7, 0xB6, 0xE1, 0x80, 0x04, 0x84, 0x63, 
  0x06, 0xE1, 0x80, 0x04, 0x84, 0x63, 0x1C, 0xE1, 0x80, 0x04, 0x84, 0x63, 0x38, 0xE1, 0x80, 0x04, 
  0x84, 0xF3, 0x3E, 0xE1, 0x80, 0x04, 0x84, 0xF3, 0x3E, 0xE1, 0x80, 0x04, 0x84, 0x03, 0x00, 0xE1, 
  0x80, 0x04, 0x85, 0xF4, 0xBE, 0xE1, 0x80, 0x04, 0x84, 0x07, 0x80, 0xE1, 0x80, 0x04, 0x85, 0xF3, 
  0x3E, 0xE1, 0x80, 0x04, 0x84, 0x03, 0x00, 0xE1, 0x80, 0x04, 0x87, 0xFF, 0xFF, 0xE1, 0x80, 0x04, 
  0x83, 0xFF, 0xFF, 0xE1, 0x80, 0x04, 0x81, 0xFF, 0xFF, 0xE1, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* daten1 */

