LOCAL UBYTE compn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x87, 0xFC, 0x00, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBE, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBE, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x86, 0x0C, 0x00, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBD, 0x17, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0x17, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBD, 0x17, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x85, 0x14, 0x00, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBC, 0xA7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBC, 0xA7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBC, 0xA7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0xA4, 0x00, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBC, 0x47, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBC, 0x47, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBC, 0x47, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x45, 0xE0, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBC, 0xA7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBC, 0xA7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBC, 0xA7, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0xA5, 0xC0, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBD, 0x17, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0x17, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBD, 0x17, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x85, 0x15, 0xC0, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBE, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBE, 0x0F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x86, 0x0D, 0x20, 0x80, 0x01, 0x07, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x87, 0xFC, 0x10, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0x80, 0x00, 0x08, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0x80, 0x40, 0x04, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x00, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x7F, 0x80, 0x01, 0xC7, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x09, 0x40, 0x80, 0x01, 0x47, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x07, 0x40, 0x80, 0x01, 0x47, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x07, 0x40, 0x80, 0x01, 0x47, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x0F, 0x40, 0x80, 0x01, 0x47, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x00, 0x40, 0x80, 0x01, 0x47, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x00, 0x40, 0x80, 0x01, 0x47, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 
  0x80, 0x03, 0xBF, 0xFF, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x80, 0x00, 0x40, 0x80, 0x01, 0x47, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 
  0x01, 0xFE, 
}; /* compn4 */

