LOCAL UBYTE caldefn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x8F, 0xFF, 0xFF, 0xE1, 0x80, 0x04, 0x90, 0x00, 0x00, 0x11, 0x80, 0x04, 0x91, 0xFF, 0xC0, 0x11, 
  0x80, 0x04, 0x91, 0x00, 0x40, 0x11, 0x80, 0x04, 0x91, 0xFF, 0xC0, 0x11, 0x80, 0x04, 0x90, 0x00, 
  0x00, 0x11, 0x80, 0x04, 0x90, 0x92, 0x49, 0x11, 0x80, 0x04, 0x91, 0xB6, 0xDB, 0x11, 0x80, 0x04, 
  0x90, 0x00, 0x00, 0x11, 0x80, 0x04, 0x90, 0x92, 0x49, 0x11, 0x80, 0x04, 0x91, 0xB6, 0xDB, 0x11, 
  0x80, 0x04, 0x90, 0x00, 0x00, 0x11, 0x80, 0x04, 0x90, 0x92, 0x41, 0x11, 0x80, 0x04, 0x91, 0xB6, 
  0xDF, 0x11, 0x80, 0x04, 0x90, 0x00, 0x00, 0x11, 0x80, 0x04, 0x90, 0x00, 0x00, 0x11, 0x80, 0x04, 
  0x8F, 0xFF, 0xFF, 0xE1, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* caldefn1 */

