LOCAL UBYTE checkc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x7F, 
  0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x00, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x00, 
  0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x7F, 0xFC, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xEA, 
  0xAE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x8A, 0xA2, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x8A, 
  0xA2, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x60, 0x0C, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x05, 0x41, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0xD5, 0x05, 0x41, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x50, 0x14, 0x80, 0x01, 0x01, 
  0x80, 0x03, 0xAA, 0xEA, 0xAE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0x8A, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xAA, 0xA2, 0x8A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x48, 0x24, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x11, 0x80, 0x01, 0x11, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x11, 0x80, 0x01, 
  0x11, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x80, 0x01, 0x44, 0x80, 0x01, 0x44, 0x80, 0x01, 0x01, 
  0x80, 0x03, 0xAA, 0xEA, 0xAE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x42, 0x84, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x14, 
  0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x14, 0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x41, 
  0x04, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xEA, 0xAE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 
  0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x42, 
  0x84, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x11, 0x80, 0x01, 0x11, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x11, 0x80, 0x01, 0x11, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x80, 0x01, 0x44, 0x80, 0x01, 
  0x44, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xEA, 0xAE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 
  0x8A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0x8A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x48, 
  0x24, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0xD5, 0x05, 0x41, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x05, 0x41, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0x80, 0x50, 0x14, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xEA, 0xAE, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xAA, 0x8A, 0xA2, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x8A, 0xA2, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0x80, 0x60, 0x0C, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x7F, 0xFD, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0xD5, 0x00, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x00, 0x01, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0x80, 0x7F, 0xFC, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* checkc4 */

