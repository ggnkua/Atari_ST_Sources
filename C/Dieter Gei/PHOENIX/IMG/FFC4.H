LOCAL UBYTE ffc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x03, 0xD5, 0x57, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0x01, 0x80, 0x01, 0x55, 
  0x80, 0x03, 0xD5, 0x54, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x03, 0xFC, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0xAE, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xA8, 
  0x80, 0x01, 0xA8, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xA8, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0x02, 0x06, 0x80, 0x01, 0x01, 0x80, 0x02, 0xD5, 0x57, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x50, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 
  0x50, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x02, 0x05, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 
  0x02, 0xAA, 0xAE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0x2B, 0x80, 0x03, 
  0xAA, 0xA8, 0xAA, 0x80, 0x01, 0x2B, 0x80, 0x03, 0x80, 0x02, 0x04, 0x80, 0x01, 0x81, 0x80, 0x02, 
  0xD5, 0x57, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x51, 0x80, 0x01, 0x15, 
  0x80, 0x03, 0xD5, 0x55, 0x51, 0x80, 0x01, 0x15, 0x80, 0x03, 0x80, 0x02, 0x04, 0x80, 0x01, 0x41, 
  0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0xAF, 0x80, 0x01, 0xEB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xA8, 
  0x80, 0x01, 0xA8, 0x80, 0x01, 0x2B, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xA8, 0x80, 
  0x01, 0x2B, 0x80, 0x03, 0x80, 0x02, 0x07, 0x80, 0x01, 0xC1, 0x80, 0x02, 0xD5, 0x57, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x03, 0x80, 0x02, 
  0x00, 0x80, 0x01, 0x41, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xEB, 
  0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0x80, 0x02, 0x00, 0x80, 0x01, 0x41, 0x80, 0x02, 0xD5, 0x57, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x03, 0x80, 0x02, 0x00, 0x80, 
  0x01, 0x41, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xEB, 0x80, 0x03, 
  0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x80, 0x02, 0x00, 0x80, 0x01, 0x41, 0x80, 0x02, 0xD5, 0x57, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x03, 0x80, 0x02, 0x00, 0x80, 0x01, 0x41, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xEB, 0x80, 0x03, 0xAA, 0xA8, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x02, 
  0x00, 0x80, 0x01, 0x41, 0x80, 0x02, 0xD5, 0xD7, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x01, 0xD5, 0x80, 0x02, 0xD5, 
  0x55, 0x80, 0x01, 0x15, 0x80, 0x03, 0x80, 0x82, 0x00, 0x80, 0x01, 0x41, 0x80, 0x03, 0xAA, 0xEA, 
  0xAA, 0x80, 0x01, 0xEB, 0x80, 0x03, 0xAA, 0x28, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xE8, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0xC2, 0x00, 0x80, 0x01, 0x41, 0x80, 0x03, 0xD5, 0xF7, 
  0xFF, 0x80, 0x01, 0xD5, 0x80, 0x03, 0xD5, 0x14, 0x00, 0x80, 0x01, 0x15, 0x80, 0x03, 0xD5, 0xF4, 
  0x00, 0x80, 0x01, 0x15, 0x80, 0x03, 0x80, 0xE3, 0xFF, 0x80, 0x01, 0xC1, 0x80, 0x03, 0xAF, 0xFA, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA8, 0x0A, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAF, 0xFA, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x87, 0xF0, 0x00, 0x80, 0x01, 0x01, 0x80, 0x02, 0xD7, 0xFD, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD0, 0x05, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x02, 0xD7, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0x87, 0xF8, 0x00, 0x80, 
  0x01, 0x01, 0x80, 0x03, 0xAF, 0xFA, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA8, 0x0A, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0xAF, 0xFA, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x87, 0xF0, 0x00, 0x80, 
  0x01, 0x01, 0x80, 0x03, 0xD5, 0xF7, 0xFF, 0x80, 0x01, 0xD5, 0x80, 0x03, 0xD5, 0x14, 0x00, 0x80, 
  0x01, 0x15, 0x80, 0x03, 0xD5, 0xF4, 0x00, 0x80, 0x01, 0x15, 0x80, 0x03, 0x80, 0xE3, 0xFF, 0x80, 
  0x01, 0xC1, 0x80, 0x03, 0xAA, 0xEA, 0xAA, 0x80, 0x01, 0xEB, 0x80, 0x03, 0xAA, 0x28, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0xAA, 0xE8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0xC2, 0x00, 0x80, 
  0x01, 0x41, 0x80, 0x02, 0xD5, 0xD7, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x01, 0xD5, 0x80, 0x02, 0xD5, 0x55, 0x80, 
  0x01, 0x15, 0x80, 0x03, 0x80, 0x82, 0x00, 0x80, 0x01, 0x41, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xEB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x02, 0x00, 0x80, 0x01, 0x41, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* ffc4 */

