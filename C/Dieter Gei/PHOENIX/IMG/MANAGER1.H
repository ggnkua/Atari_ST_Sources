LOCAL UBYTE manager1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01, 0x01, 0x74, 0x01, 0x74, 0x01, 0x32, 0x00, 0xCE, 
  0x00, 0x00, 0xFF, 0x03, 0x27, 0x80, 0x01, 0x0F, 0xA5, 0x01, 0x00, 0x00, 0xFF, 0x08, 0x80, 0x01, 
  0x08, 0x24, 0x80, 0x02, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x04, 0x80, 0x02, 0x08, 0x01, 0x87, 0x80, 
  0x01, 0xF8, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x03, 0x80, 0x02, 0x08, 0x01, 0x87, 
  0x80, 0x01, 0xF8, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 
  0x01, 0xE0, 0xF9, 0x9F, 0x9F, 0x9E, 0x66, 0x7E, 0x78, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE0, 0x79, 0x9F, 0x0F, 0x9E, 0x66, 0x7E, 0x78, 0x08, 
  0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE6, 0x39, 0x9E, 
  0x67, 0x9E, 0x66, 0x7E, 0x78, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0xE7, 0x19, 0x9E, 0x67, 0x9E, 0x66, 0x7E, 0x78, 0x08, 0x80, 0x01, 0x7F, 0x91, 
  0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 0x99, 0x9C, 0xF3, 0x8E, 0x67, 0x3C, 
  0xF8, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 
  0x99, 0x9C, 0xF3, 0x8E, 0x67, 0x99, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC0, 0xFF, 0xFF, 0x0F, 0x87, 
  0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFC, 0x1F, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0xE7, 0x99, 0x99, 0xE1, 0x86, 0x67, 0x99, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC0, 
  0x3F, 0xFF, 0x0F, 0x87, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFC, 0x1F, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 0x99, 0x99, 0xC1, 0x86, 0x67, 0xC3, 0xF8, 0x08, 
  0x80, 0x15, 0x7F, 0xC0, 0x1F, 0xFF, 0x0F, 0x87, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xF0, 0xFF, 0xE1, 
  0xFF, 0xE0, 0xFC, 0x1F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 0x18, 0x19, 0x89, 0x92, 
  0x67, 0xE7, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC0, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x00, 0x0F, 0xFF, 
  0x07, 0xF0, 0xFF, 0xE1, 0xFF, 0xF0, 0x78, 0x3F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE6, 
  0x38, 0x19, 0x19, 0x92, 0x67, 0xE7, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC0, 0x07, 0xFF, 0x0F, 0x87, 
  0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xF0, 0xFF, 0xE1, 0xFF, 0xF0, 0x78, 0x3F, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0xE0, 0x79, 0x98, 0x39, 0x98, 0x67, 0xC3, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC2, 
  0x03, 0xFF, 0x0F, 0x87, 0xFE, 0x06, 0x07, 0xFF, 0x03, 0xF0, 0xFF, 0xE1, 0xFF, 0xF0, 0x30, 0x7F, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE0, 0xF9, 0x98, 0x79, 0x98, 0x67, 0x99, 0xF8, 0x08, 
  0x80, 0x15, 0x7F, 0xC3, 0x03, 0xFF, 0x0F, 0x87, 0xFE, 0x0F, 0x07, 0xFF, 0x03, 0xF0, 0xFF, 0xE1, 
  0xFF, 0xF8, 0x30, 0x7F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 0xF9, 0x9C, 0xF3, 0x9C, 
  0x67, 0x99, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0x83, 0xFF, 0x0F, 0x87, 0xFE, 0x0F, 0x07, 0xFF, 
  0x01, 0xF0, 0xFF, 0xE1, 0xFF, 0xF8, 0x20, 0x7F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 
  0xF9, 0x9C, 0xF3, 0x9C, 0x67, 0x3C, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xC1, 0xFF, 0x0F, 0x87, 
  0xFE, 0x1F, 0x87, 0xFF, 0x01, 0xF0, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0xE7, 0xF9, 0x9E, 0x67, 0x9E, 0x66, 0x7C, 0x78, 0x08, 0x80, 0x15, 0x7F, 0xC3, 
  0xC1, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x87, 0xFF, 0x00, 0xF0, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 0xF9, 0x9E, 0x67, 0x9E, 0x66, 0x7E, 0x78, 0x08, 
  0x80, 0x15, 0x7F, 0xC3, 0xC1, 0xFF, 0x0F, 0x87, 0xFC, 0x1F, 0x83, 0xFF, 0x00, 0xF0, 0xFF, 0xE1, 
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 0xF9, 0x9F, 0x0F, 0x9E, 
  0x66, 0x7E, 0x78, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x1F, 0x83, 0xFF, 
  0x00, 0x70, 0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 
  0xF9, 0x9F, 0x9F, 0x9E, 0x66, 0x7E, 0x78, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 
  0xFC, 0x10, 0x83, 0xFF, 0x00, 0x70, 0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x02, 0x08, 0x01, 0x87, 0x80, 0x01, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xC1, 0xFF, 0x0F, 0x87, 
  0xFC, 0x20, 0x03, 0xFF, 0x00, 0x70, 0xFF, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x02, 0x08, 0x01, 0x87, 0x80, 0x01, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xC1, 0xFF, 0x0F, 0x87, 
  0xFC, 0x27, 0x03, 0xFF, 0x08, 0x30, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x02, 0x08, 0x01, 0x87, 0x80, 0x01, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xC1, 0xFF, 0x00, 0x07, 
  0xFC, 0x03, 0x03, 0xFF, 0x08, 0x30, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x02, 0x08, 0x01, 0x87, 0x80, 0x01, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0x83, 0xFF, 0x00, 0x07, 
  0xFC, 0x08, 0x03, 0xFF, 0x08, 0x10, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0x99, 0x9E, 0x19, 0x98, 0x78, 0x66, 0x61, 0x98, 0x08, 0x80, 0x15, 0x7F, 0xC3, 
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0C, 0x43, 0xFF, 0x0C, 0x10, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x99, 0x9E, 0x19, 0x98, 0x78, 0x66, 0x61, 0x98, 0x08, 
  0x80, 0x15, 0x7F, 0xC2, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xC3, 0xFF, 0x0C, 0x10, 0xFF, 0xE1, 
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE0, 0x60, 0x66, 0x61, 0x81, 
  0x81, 0x99, 0x98, 0x08, 0x80, 0x15, 0x7F, 0xC0, 0x07, 0xFF, 0x0F, 0x87, 0xFC, 0x21, 0xC3, 0xFF, 
  0x0E, 0x00, 0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE0, 
  0x60, 0x66, 0x61, 0x81, 0x81, 0x99, 0x98, 0x08, 0x80, 0x15, 0x7F, 0xC0, 0x0F, 0xFF, 0x0F, 0x87, 
  0xFC, 0x31, 0xC3, 0xFF, 0x0E, 0x00, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0x86, 0x06, 0x06, 0x1E, 0x66, 0x78, 0x06, 0x78, 0x08, 0x80, 0x15, 0x7F, 0xC0, 
  0x1F, 0xFF, 0x0F, 0x87, 0xFC, 0x1F, 0x83, 0xFF, 0x0E, 0x00, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x86, 0x06, 0x06, 0x1E, 0x66, 0x78, 0x06, 0x78, 0x08, 
  0x80, 0x15, 0x7F, 0xC0, 0x3F, 0xFF, 0x0F, 0x87, 0xFC, 0x1F, 0x83, 0xFF, 0x0F, 0x00, 0xFF, 0xE1, 
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE6, 0x61, 0xE0, 0x61, 0x81, 
  0x81, 0x80, 0x18, 0x08, 0x80, 0x15, 0x7F, 0xC0, 0xFF, 0xFF, 0x0F, 0x87, 0xFC, 0x1F, 0x83, 0xFF, 
  0x0F, 0x00, 0xFF, 0xE1, 0xFF, 0xF8, 0x20, 0xFF, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE6, 
  0x61, 0xE0, 0x61, 0x81, 0x81, 0x80, 0x18, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0x87, 
  0xFE, 0x1F, 0x87, 0xFF, 0x0F, 0x80, 0xFF, 0xE1, 0xFF, 0xF8, 0x20, 0xFF, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0x99, 0xFE, 0x07, 0x9E, 0x18, 0x66, 0x19, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 
  0xFF, 0xFF, 0x0F, 0x87, 0xFE, 0x1F, 0x87, 0xFF, 0x0F, 0x80, 0xFF, 0xE1, 0xFF, 0xF0, 0x30, 0x7F, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x99, 0xFF, 0x07, 0x9E, 0x18, 0x66, 0x19, 0xF8, 0x08, 
  0x80, 0x15, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0x87, 0xFE, 0x0F, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xE1, 
  0xFF, 0xF0, 0x70, 0x7F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 0xFF, 0xC0, 0x61, 0x99, 
  0x9F, 0x9F, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0x87, 0xFE, 0x0F, 0x07, 0xFF, 
  0x0F, 0xC0, 0xFF, 0xE1, 0xFF, 0xF0, 0x70, 0x3F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xE7, 
  0xFF, 0xE0, 0x61, 0x99, 0x9F, 0x9F, 0xF8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0x87, 
  0xFE, 0x06, 0x07, 0xFF, 0x0F, 0xC0, 0xFF, 0xE1, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0xFF, 0xCF, 0xF9, 0xF8, 0x66, 0x7F, 0xFF, 0xD8, 0x08, 0x80, 0x15, 0x7F, 0xC3, 
  0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0x00, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0xF8, 0x3F, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xFF, 0x87, 0xF9, 0xF8, 0x66, 0x7F, 0xFF, 0x98, 0x08, 
  0x80, 0x15, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0x00, 0x0F, 0xFF, 0x0F, 0xE0, 0xFF, 0xE1, 
  0xFF, 0xC0, 0xFC, 0x1F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE7, 
  0xFC, 0xFC, 0x18, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0x80, 0x1F, 0xFF, 
  0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0xF8, 
  0x00, 0x7F, 0xFF, 0xE7, 0xF8, 0x78, 0x18, 0x08, 0x80, 0x15, 0x7F, 0xC3, 0xFF, 0xFF, 0x0F, 0x87, 
  0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFC, 0x1F, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0x80, 0x00, 0x1F, 0xCF, 0xFF, 0xC0, 0x00, 0x18, 0x08, 0x80, 0x15, 0x7F, 0xC3, 
  0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFE, 0x1F, 
  0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x80, 0x00, 0x07, 0x87, 0xFF, 0x80, 0x00, 0x18, 0x08, 
  0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x03, 0x08, 0x01, 0x80, 0x03, 0x80, 
  0x04, 0xFC, 0x00, 0x00, 0x18, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 
  0x03, 0x08, 0x01, 0x80, 0x03, 0x80, 0x04, 0x78, 0x00, 0x00, 0x18, 0x08, 0x80, 0x01, 0x7F, 0x91, 
  0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x05, 0x08, 0x01, 0x80, 0x20, 0x80, 0x04, 0x80, 0x01, 0x18, 
  0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x05, 0x08, 0x01, 0x80, 0x31, 
  0x80, 0x04, 0x80, 0x01, 0x18, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 
  0x0A, 0x08, 0x01, 0x80, 0x31, 0x94, 0xB1, 0x46, 0x9C, 0xE0, 0x18, 0x08, 0x80, 0x01, 0x7F, 0x91, 
  0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x80, 0x2A, 0xAC, 0xCA, 0xC9, 0xA2, 0xA0, 
  0x18, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x80, 
  0x2A, 0xA4, 0x8A, 0x48, 0xA2, 0x80, 0x18, 0x08, 0x80, 0x01, 0x7F, 0x91, 0x80, 0x03, 0xF8, 0x01, 
  0x00, 0x80, 0x0A, 0x08, 0x01, 0x80, 0x2A, 0xA4, 0x8A, 0x48, 0xBE, 0x80, 0x18, 0x1B, 0x80, 0x02, 
  0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x80, 0x24, 0xA4, 0x8A, 0x48, 0xA0, 0x80, 0x18, 0x1B, 0x80, 
  0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x80, 0x24, 0xA4, 0x8A, 0x49, 0xA2, 0x80, 0x18, 0x1B, 
  0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x01, 0x80, 0x24, 0x9A, 0x89, 0xA6, 0x9C, 0x80, 0x18, 
  0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x03, 0x08, 0x01, 0x80, 0x04, 0x80, 0x03, 0x80, 0x00, 0x18, 
  0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x03, 0x08, 0x01, 0x80, 0x03, 0x80, 0x04, 0x08, 0x80, 0x00, 
  0x18, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x03, 0x08, 0x01, 0x80, 0x03, 0x80, 0x04, 0x07, 0x00, 
  0x00, 0x18, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x02, 0x80, 0x02, 0x08, 0x01, 0x87, 
  0x80, 0x01, 0xF8, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x01, 0x08, 0x24, 
  0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 0x08, 0x80, 0x00, 0x20, 0x00, 0x01, 0xE0, 0xE0, 
  0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x04, 0x08, 0x00, 0x08, 0x80, 0x03, 0x80, 0x03, 0x01, 0x01, 
  0x10, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 0x05, 0x1C, 0xE7, 0x23, 0x96, 0x02, 
  0x01, 0x10, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 0x05, 0x22, 0xA8, 0xA4, 0x59, 
  0x03, 0xC1, 0x10, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 0x05, 0x22, 0x88, 0x24, 
  0x51, 0x02, 0x21, 0x10, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 0x05, 0x3E, 0x87, 
  0x24, 0x51, 0x00, 0x21, 0x10, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 0x02, 0x20, 
  0x80, 0xA4, 0x51, 0x00, 0x21, 0x10, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 0x02, 
  0x22, 0x88, 0xA4, 0x51, 0x02, 0x29, 0x10, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x80, 0x0A, 0x08, 0x00, 
  0x02, 0x1C, 0x87, 0x23, 0x91, 0x01, 0xC8, 0xE0, 0x1B, 0x80, 0x02, 0x01, 0x00, 0x00, 0x00, 0xFF, 
  0x11, 0x80, 0x01, 0x08, 0x24, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x02, 0x01, 
  0xF0, 0x0A, 0x80, 0x0F, 0x7C, 0x00, 0x0F, 0x00, 0x23, 0x80, 0x00, 0x00, 0x04, 0x00, 0x40, 0x03, 
  0xC0, 0x08, 0xE0, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x02, 0x01, 0x08, 
  0x0A, 0x80, 0x0F, 0x42, 0x00, 0x10, 0x80, 0x04, 0x40, 0x00, 0x00, 0x04, 0x00, 0x40, 0x04, 0x20, 
  0x01, 0x10, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x02, 0x01, 0x08, 0x0A, 
  0x80, 0x0F, 0x42, 0x00, 0x10, 0x00, 0x04, 0x40, 0x00, 0x00, 0x04, 0x00, 0x40, 0x04, 0x00, 0x01, 
  0x10, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x1B, 0x01, 0x0A, 0xC6, 0x1D, 
  0x59, 0xA5, 0x99, 0x66, 0x01, 0x11, 0x8B, 0x80, 0x41, 0x00, 0x20, 0x0F, 0x24, 0x40, 0x21, 0x5C, 
  0x74, 0x00, 0x40, 0x08, 0x03, 0xC9, 0x10, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 
  0x80, 0x1B, 0x01, 0x0B, 0x49, 0x23, 0x6A, 0x66, 0x65, 0x99, 0x01, 0x12, 0x4C, 0x40, 0x41, 0x00, 
  0x20, 0x10, 0xA4, 0x80, 0x21, 0x62, 0x8C, 0x00, 0x40, 0x08, 0x04, 0x29, 0x20, 0x05, 0x80, 0x02, 
  0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x1B, 0x01, 0xF2, 0x10, 0xA1, 0x42, 0x24, 0x45, 0x11, 
  0x01, 0x14, 0x28, 0x40, 0x41, 0x00, 0x23, 0xD0, 0xA4, 0x40, 0x21, 0x42, 0x84, 0x00, 0x40, 0x08, 
  0xF4, 0x29, 0x10, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x1B, 0x01, 0x02, 
  0x10, 0xA1, 0x42, 0x24, 0x45, 0x11, 0x00, 0xA4, 0x28, 0x40, 0x41, 0x00, 0x20, 0x50, 0xA4, 0x20, 
  0x21, 0x42, 0x84, 0x00, 0x40, 0x08, 0x14, 0x29, 0x08, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 
  0x08, 0x04, 0x80, 0x1B, 0x01, 0x02, 0x10, 0xA1, 0x42, 0x24, 0x45, 0x11, 0x00, 0xA4, 0x28, 0x40, 
  0x41, 0x00, 0x20, 0x5F, 0xA4, 0x20, 0x21, 0x42, 0x84, 0x00, 0x40, 0x08, 0x17, 0xE9, 0x08, 0x05, 
  0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x1B, 0x01, 0x02, 0x10, 0xA1, 0x42, 0x24, 
  0x45, 0x11, 0x00, 0xA4, 0x28, 0x40, 0x42, 0x00, 0x10, 0x50, 0x24, 0x20, 0x21, 0x42, 0x84, 0x04, 
  0x40, 0x04, 0x14, 0x09, 0x08, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x04, 0x80, 0x1B, 
  0x01, 0x02, 0x09, 0x23, 0x42, 0x64, 0x45, 0x11, 0x00, 0x42, 0x48, 0x40, 0x42, 0x40, 0x10, 0xD0, 
  0xA4, 0x20, 0x23, 0x42, 0x8C, 0x04, 0x50, 0x04, 0x34, 0x29, 0x08, 0x05, 0x80, 0x02, 0x01, 0x00, 
  0x80, 0x01, 0x08, 0x04, 0x80, 0x1B, 0x01, 0x02, 0x06, 0x1D, 0x41, 0xB4, 0x45, 0x11, 0x00, 0x41, 
  0x88, 0x40, 0x7C, 0x40, 0x0F, 0x4F, 0x24, 0xC0, 0x1D, 0x42, 0x74, 0x03, 0x90, 0x03, 0xD3, 0xC9, 
  0x30, 0x05, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x07, 0x80, 0x01, 0x01, 0x1C, 0x80, 0x02, 
  0x01, 0x00, 0x80, 0x01, 0x08, 0x07, 0x80, 0x01, 0x21, 0x1C, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 
  0x08, 0x07, 0x80, 0x01, 0x1E, 0x1C, 0x80, 0x02, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x1C, 0x80, 0x01, 
  0x08, 0x24, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x1C, 0x80, 0x01, 0x3F, 0x86, 0x80, 0x03, 
  0xFE, 0x01, 0x00, 0x80, 0x01, 0x08, 0x1C, 0x80, 0x01, 0x20, 0x06, 0x80, 0x03, 0x02, 0x01, 0x00, 
  0x80, 0x03, 0x08, 0x00, 0x81, 0x1A, 0x80, 0x01, 0x20, 0x06, 0x80, 0x03, 0x02, 0x01, 0x00, 0x80, 
  0x0B, 0x08, 0x00, 0x81, 0x00, 0x8E, 0x38, 0x80, 0x00, 0x08, 0xE3, 0x9F, 0x12, 0x80, 0x01, 0x27, 
  0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x0B, 0x08, 0x01, 0x00, 0x81, 0x91, 0x45, 0x80, 0x00, 
  0x19, 0x14, 0x41, 0x12, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x0B, 0x08, 
  0x01, 0x18, 0x81, 0x91, 0x45, 0x80, 0x00, 0x19, 0x14, 0x41, 0x12, 0x80, 0x01, 0x27, 0x86, 0x80, 
  0x03, 0xF2, 0x01, 0x00, 0x80, 0x0B, 0x08, 0x01, 0x24, 0x80, 0x91, 0x44, 0x80, 0x00, 0x09, 0x14, 
  0x42, 0x12, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x0B, 0x08, 0x01, 0x20, 
  0x80, 0x8F, 0x3C, 0x80, 0x00, 0x08, 0xF3, 0xC2, 0x12, 0x80, 0x0A, 0x27, 0xFF, 0xFF, 0xF7, 0xBD, 
  0xFF, 0xFF, 0xF2, 0x01, 0x00, 0x80, 0x0B, 0x08, 0x01, 0x20, 0x80, 0x81, 0x04, 0x80, 0xF8, 0x08, 
  0x10, 0x42, 0x12, 0x80, 0x0A, 0x27, 0xFF, 0xFF, 0xE7, 0x39, 0xFF, 0xFF, 0xF2, 0x01, 0x00, 0x80, 
  0x0B, 0x08, 0x01, 0x20, 0x80, 0x81, 0x04, 0x80, 0x00, 0x08, 0x10, 0x44, 0x12, 0x80, 0x0A, 0x27, 
  0xFF, 0xFF, 0xC6, 0x31, 0xFF, 0xFF, 0xF2, 0x01, 0x00, 0x80, 0x0B, 0x08, 0x01, 0x24, 0x80, 0x91, 
  0x44, 0x80, 0x00, 0x09, 0x14, 0x44, 0x12, 0x80, 0x0A, 0x27, 0xFF, 0xFF, 0xCE, 0x73, 0xFF, 0xFF, 
  0xF2, 0x01, 0x00, 0x80, 0x0B, 0x08, 0x00, 0x99, 0x00, 0x8E, 0x38, 0x80, 0x00, 0x08, 0xE3, 0x84, 
  0x12, 0x80, 0x0A, 0x27, 0xFF, 0xFF, 0x8C, 0x63, 0xFF, 0xFF, 0xF2, 0x01, 0x00, 0x80, 0x03, 0x08, 
  0x00, 0x81, 0x1A, 0x80, 0x0A, 0x27, 0xFF, 0xFF, 0x9C, 0xE7, 0xFF, 0xFF, 0xF2, 0x01, 0x00, 0x00, 
  0x00, 0xFF, 0x05, 0x80, 0x01, 0x08, 0x1C, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 
  0x80, 0x01, 0x08, 0x1C, 0x80, 0x0A, 0x27, 0xB8, 0xC6, 0xEC, 0x7B, 0x8B, 0x1B, 0xB2, 0x01, 0x00, 
  0x80, 0x0C, 0x08, 0x00, 0x60, 0x00, 0x24, 0x00, 0x09, 0x00, 0x00, 0x07, 0x80, 0x01, 0x03, 0x80, 
  0x05, 0x08, 0x80, 0x81, 0x01, 0x20, 0x09, 0x80, 0x0A, 0x27, 0x5B, 0x5A, 0xEB, 0xB5, 0xDA, 0xE9, 
  0xB2, 0x01, 0x00, 0x80, 0x0C, 0x08, 0x00, 0x60, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0x08, 0x40, 
  0x01, 0x03, 0x80, 0x05, 0x08, 0x80, 0x01, 0x01, 0x20, 0x09, 0x80, 0x0A, 0x27, 0x18, 0xC6, 0xEB, 
  0xF1, 0xDA, 0xEA, 0xB2, 0x01, 0x00, 0x80, 0x16, 0x08, 0x00, 0x92, 0xCB, 0x24, 0x62, 0x9D, 0x1C, 
  0xB0, 0x08, 0x12, 0x73, 0x9C, 0xEC, 0x70, 0x08, 0x9C, 0x8D, 0x39, 0x2C, 0x73, 0x9A, 0x07, 0x80, 
  0x0A, 0x26, 0xEB, 0xDE, 0xEB, 0xAE, 0xDA, 0xEB, 0x32, 0x01, 0x00, 0x80, 0x16, 0x08, 0x00, 0x93, 
  0x2C, 0xA4, 0x95, 0x89, 0x22, 0xC8, 0x06, 0x12, 0x89, 0x22, 0x92, 0x88, 0x08, 0xA2, 0x93, 0x45, 
  0x32, 0x8A, 0xA6, 0x07, 0x80, 0x0A, 0x26, 0xEB, 0xDE, 0x2C, 0x6E, 0xDB, 0x1B, 0xB2, 0x01, 0x00, 
  0x80, 0x16, 0x08, 0x00, 0x92, 0x28, 0xA4, 0x84, 0x89, 0x22, 0x88, 0x01, 0x92, 0x81, 0x22, 0x92, 
  0x80, 0x0F, 0xA2, 0x91, 0x45, 0x22, 0x8A, 0x22, 0x07, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 
  0x01, 0x00, 0x80, 0x16, 0x08, 0x01, 0xFA, 0x28, 0xA4, 0x84, 0x89, 0x22, 0x88, 0x00, 0x4C, 0x71, 
  0x3E, 0x92, 0x70, 0x08, 0xBE, 0x91, 0x7D, 0x22, 0xFA, 0x22, 0x07, 0x80, 0x01, 0x27, 0x86, 0x80, 
  0x03, 0xF2, 0x01, 0x00, 0x80, 0x16, 0x08, 0x01, 0x0A, 0x28, 0xA4, 0x84, 0x89, 0x22, 0x88, 0x08, 
  0x4C, 0x09, 0x20, 0x92, 0x08, 0x08, 0xA0, 0x91, 0x41, 0x22, 0x82, 0x22, 0x07, 0x80, 0x01, 0x27, 
  0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x16, 0x08, 0x01, 0x0B, 0x2C, 0xA4, 0x94, 0x89, 0x22, 
  0x88, 0x08, 0x44, 0x89, 0x22, 0x92, 0x88, 0x08, 0xA2, 0x93, 0x45, 0x32, 0x8A, 0x26, 0x07, 0x80, 
  0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x16, 0x08, 0x01, 0x0A, 0xCB, 0x14, 0x63, 
  0x45, 0x1C, 0x88, 0x07, 0x88, 0x70, 0x9C, 0x92, 0x70, 0x08, 0x9C, 0x8D, 0x38, 0xAC, 0x72, 0x1A, 
  0x07, 0x80, 0x0A, 0x27, 0x1D, 0xDE, 0x38, 0x38, 0x77, 0xDE, 0x32, 0x01, 0x00, 0x80, 0x04, 0x08, 
  0x00, 0x02, 0x08, 0x06, 0x80, 0x01, 0x08, 0x0A, 0x80, 0x01, 0x02, 0x07, 0x80, 0x0A, 0x26, 0xFE, 
  0xBD, 0xFE, 0xFB, 0xF3, 0x9D, 0xF2, 0x01, 0x00, 0x80, 0x04, 0x08, 0x00, 0x02, 0x08, 0x06, 0x80, 
  0x01, 0x08, 0x0A, 0x80, 0x01, 0x22, 0x07, 0x80, 0x0A, 0x27, 0x3F, 0x7E, 0x7E, 0xF8, 0x75, 0x5E, 
  0x72, 0x01, 0x00, 0x80, 0x04, 0x08, 0x00, 0x02, 0x08, 0x06, 0x80, 0x01, 0x30, 0x0A, 0x80, 0x01, 
  0x1C, 0x07, 0x80, 0x0A, 0x27, 0xDF, 0x7F, 0xBE, 0xFB, 0xF6, 0xDF, 0xB2, 0x01, 0x00, 0x80, 0x01, 
  0x08, 0x1C, 0x80, 0x0A, 0x26, 0x3F, 0x7C, 0x7E, 0xF8, 0x77, 0xDC, 0x72, 0x01, 0x00, 0x00, 0x00, 
  0xFF, 0x04, 0x80, 0x01, 0x08, 0x1C, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 
  0x17, 0x08, 0x01, 0xC0, 0x00, 0x46, 0x00, 0x10, 0x00, 0x8E, 0x38, 0xE1, 0x8E, 0x00, 0x38, 0x01, 
  0xC7, 0x1C, 0x47, 0x00, 0x88, 0x08, 0x10, 0x12, 0x06, 0x80, 0x0A, 0x26, 0xD8, 0x6C, 0x70, 0xDC, 
  0x61, 0x8E, 0x32, 0x01, 0x00, 0x80, 0x17, 0x08, 0x01, 0x20, 0x00, 0x44, 0x00, 0x10, 0x01, 0x91, 
  0x45, 0x01, 0x90, 0x00, 0x24, 0x02, 0x08, 0xA2, 0xC8, 0x00, 0x88, 0x00, 0x10, 0x12, 0x06, 0x80, 
  0x0A, 0x26, 0xDB, 0xED, 0xB7, 0xDD, 0xAF, 0xB5, 0xF2, 0x01, 0x00, 0x80, 0x1A, 0x08, 0x01, 0x27, 
  0x1C, 0xEE, 0x51, 0x96, 0x01, 0x91, 0x05, 0x02, 0x90, 0x00, 0x22, 0x02, 0x08, 0xA2, 0xC8, 0x00, 
  0x89, 0xC8, 0xD3, 0x92, 0xC7, 0x39, 0xA0, 0x03, 0x80, 0x0A, 0x26, 0x18, 0x6D, 0xB0, 0xDC, 0x61, 
  0x8D, 0x32, 0x01, 0x00, 0x80, 0x1A, 0x08, 0x01, 0x28, 0xA2, 0x44, 0xB2, 0x59, 0x00, 0x91, 0x05, 
  0x02, 0x90, 0x00, 0x22, 0x02, 0x08, 0xA2, 0x48, 0x00, 0x8A, 0x29, 0x34, 0x53, 0x28, 0xAA, 0x60, 
  0x03, 0x80, 0x0A, 0x26, 0xDB, 0xED, 0xB7, 0xDD, 0xAF, 0xAD, 0xB2, 0x01, 0x00, 0x80, 0x1A, 0x08, 
  0x01, 0xC8, 0xA0, 0x44, 0x92, 0x11, 0x00, 0x91, 0x09, 0xE4, 0x9E, 0x00, 0x22, 0x03, 0xC7, 0xA2, 
  0x4F, 0x00, 0xFA, 0x29, 0x14, 0x52, 0x28, 0xA2, 0x20, 0x03, 0x80, 0x0A, 0x26, 0xD8, 0x6C, 0x70, 
  0xC4, 0x61, 0xB6, 0x32, 0x01, 0x00, 0x80, 0x1A, 0x08, 0x01, 0x08, 0x9C, 0x44, 0x92, 0x11, 0x00, 
  0x91, 0x11, 0x14, 0x91, 0x00, 0x22, 0xFA, 0x20, 0xA2, 0x48, 0x80, 0x8B, 0xE9, 0x17, 0xD2, 0x2F, 
  0xA2, 0x20, 0x03, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x1A, 0x08, 0x01, 
  0x08, 0x82, 0x44, 0x92, 0x11, 0x00, 0x91, 0x21, 0x17, 0xD1, 0x00, 0x22, 0x02, 0x20, 0xA2, 0x48, 
  0x80, 0x8A, 0x09, 0x14, 0x12, 0x28, 0x22, 0x20, 0x03, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 
  0x01, 0x00, 0x80, 0x1A, 0x08, 0x01, 0x08, 0xA2, 0x44, 0x92, 0x51, 0x00, 0x91, 0x41, 0x10, 0x91, 
  0x40, 0x24, 0x02, 0x28, 0xA2, 0x48, 0x80, 0x8A, 0x29, 0x34, 0x53, 0x28, 0xA2, 0x60, 0x03, 0x80, 
  0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x1A, 0x08, 0x01, 0x07, 0x1C, 0x24, 0x69, 
  0x91, 0x00, 0x8E, 0x7C, 0xE0, 0x8E, 0x40, 0x38, 0x01, 0xC7, 0x1C, 0x47, 0x00, 0x89, 0xC8, 0xD3, 
  0x8A, 0xC7, 0x21, 0xA0, 0x03, 0x80, 0x01, 0x27, 0x86, 0x80, 0x03, 0xF2, 0x01, 0x00, 0x80, 0x01, 
  0x08, 0x0B, 0x80, 0x01, 0x40, 0x0C, 0x80, 0x01, 0x20, 0x03, 0x80, 0x01, 0x20, 0x06, 0x80, 0x03, 
  0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x0B, 0x80, 0x01, 0x80, 0x0B, 0x80, 0x02, 0x02, 0x20, 0x03, 
  0x80, 0x01, 0x20, 0x06, 0x80, 0x03, 0x02, 0x01, 0x00, 0x80, 0x01, 0x08, 0x17, 0x80, 0x02, 0x01, 
  0xC0, 0x03, 0x80, 0x01, 0x3F, 0x86, 0x80, 0x03, 0xFE, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x04, 0x80, 
  0x01, 0x08, 0x24, 0x80, 0x02, 0x01, 0x00, 0x80, 0x01, 0x0F, 0xA5, 0x01, 0x00, 0x00, 0xFF, 0x03, 
  0x27, 0x00
}; /* manager1 */

