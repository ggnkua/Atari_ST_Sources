LOCAL UBYTE inf4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 0x02, 0x02, 0x80, 
  0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 0x02, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 0x02, 
  0x02, 0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x0F, 0x80, 0x01, 0x80, 0x02, 0x02, 0x02, 0x80, 0x01, 
  0x0F, 0x80, 0x01, 0x80, 0x02, 0x02, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 0x02, 0x02, 
  0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 0x02, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 
  0x02, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 0x02, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 
  0x80, 0x02, 0x02, 0x02, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xE0, 0x02, 0x02, 0x02, 0x80, 0x01, 0x0F, 
  0x80, 0x01, 0xE0, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 
}; /* inf4 */

