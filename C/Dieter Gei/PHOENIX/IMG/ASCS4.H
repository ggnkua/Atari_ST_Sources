LOCAL UBYTE ascs4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xA8, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x00, 0x85, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x00, 0x85, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x00, 0x85, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0x80, 0x06, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x06, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x06, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x3F, 0xFC, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x7E, 0xFD, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x7E, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x7E, 0xFD, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x3D, 0xFC, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xAB, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xAB, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xAB, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 
  0x01, 0xFE, 
}; /* ascs4 */

