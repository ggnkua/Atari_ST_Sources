LOCAL UBYTE nextn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x40, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x30, 0x60, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xEF, 0xDF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xEF, 0xDF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEF, 0xDF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x38, 0x70, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE7, 0xCF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xE7, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE7, 0xCF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x3C, 0x78, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x3E, 0x7C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE1, 0xC3, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xE1, 0xC3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE1, 0xC3, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x3F, 0x7E, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE3, 0xC7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x3E, 0x7C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xE7, 0xCF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xE7, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE7, 0xCF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x3C, 0x78, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xEF, 0xDF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xEF, 0xDF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEF, 0xDF, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x38, 0x70, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 
  0x30, 0x60, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 
  0x80, 0x01, 0xFE, 0x00
}; /* nextn4 */

