LOCAL UBYTE lockc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x03, 0xAA, 0xAF, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0xAA, 0xAF, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x80, 0x01, 
  0x01, 0x80, 0x03, 0xD5, 0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 
  0x08, 0x20, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0xAA, 0xA2, 0x8A, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x08, 0x20, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 
  0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x03, 0xD5, 0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x08, 0x20, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0xA2, 0x8A, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0x80, 0x08, 0x20, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x5D, 0x75, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x08, 0x20, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 
  0xBF, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x02, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0xBF, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x40, 0x05, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 
  0xBE, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x02, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0xBE, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x3E, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x41, 0x05, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x3E, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 
  0xBE, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x02, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0xBE, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x3E, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x40, 0x05, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 
  0xBF, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x02, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0xBF, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x40, 0x05, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x7F, 0xFD, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 
  0xBF, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x80, 0x02, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0xBF, 0xFA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 
  0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* lockc4 */

