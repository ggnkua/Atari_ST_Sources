LOCAL UBYTE printn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBF, 0xF0, 0x00, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x00, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x00, 0x80, 0x01, 0x87, 0x80, 0x02, 0xBF, 0xE7, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xF9, 0x80, 0x02, 0xBF, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xF9, 0x80, 
  0x02, 0xBF, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x27, 0xF9, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x01, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xE0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x01, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xCF, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCF, 0xF3, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xCF, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x4F, 0xF2, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x40, 0x03, 0x80, 0x01, 
  0xE7, 0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x40, 0x02, 0x80, 0x01, 
  0x57, 0x80, 0x03, 0xBF, 0x9F, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xE7, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0x9F, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x9F, 0xE4, 0x80, 0x01, 
  0xB7, 0x80, 0x03, 0xBF, 0x80, 0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x80, 0x07, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0x80, 0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x80, 0x05, 0x80, 0x01, 
  0x57, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0xFF, 0xFA, 0x80, 0x01, 0x97, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 0x00, 0x05, 0x80, 0x01, 0x17, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x8F, 0xFF, 0xFE, 0x80, 0x01, 0x27, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 
  0x00, 0x02, 0x80, 0x01, 0x67, 0x80, 0x03, 0xBF, 0xFE, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0xFE, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 
  0x01, 0xF2, 0x80, 0x01, 0xA7, 0x80, 0x03, 0xBF, 0xFE, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0xFE, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 
  0x00, 0x03, 0x80, 0x01, 0x47, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8F, 0xFF, 0xFC, 0x80, 
  0x01, 0x87, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x00, 0x05, 0x80, 0x01, 0x07, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x84, 0x00, 0x06, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0x83, 0xFF, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* printn4 */

