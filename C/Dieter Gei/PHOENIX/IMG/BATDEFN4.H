LOCAL UBYTE batdefn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xB9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0x80, 0x0F, 0xFF, 
  0x80, 0x01, 0xC7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xD9, 0x80, 0x03, 0xBF, 0xF0, 0x00, 0x80, 0x01, 0x59, 0x80, 0x03, 0x80, 0x10, 0x00, 0x80, 0x01, 
  0x67, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0xD9, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 0x59, 0x80, 0x03, 0x80, 0x3F, 0xFF, 0x80, 0x01, 
  0x67, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 
  0x03, 0xBF, 0xC0, 0x01, 0x80, 0x01, 0x59, 0x80, 0x03, 0x80, 0x40, 0x01, 0x80, 0x01, 0xE7, 0x80, 
  0x03, 0xBF, 0xFF, 0xFB, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xBF, 0xFF, 0xFB, 0x80, 0x01, 0xD9, 0x80, 
  0x03, 0xBF, 0xFF, 0xF9, 0x80, 0x01, 0x59, 0x80, 0x03, 0x80, 0xFF, 0xFD, 0x80, 0x01, 0xE7, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xBF, 
  0x00, 0x05, 0x80, 0x01, 0x59, 0x80, 0x03, 0x81, 0x00, 0x07, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xBE, 0x7E, 0x75, 
  0x80, 0x01, 0x59, 0x80, 0x03, 0x82, 0x7E, 0x77, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xBF, 0xC9, 0xCF, 
  0x80, 0x01, 0xD9, 0x80, 0x03, 0xBF, 0xC9, 0xCF, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xBC, 0x48, 0x45, 
  0x80, 0x01, 0x59, 0x80, 0x03, 0x84, 0x5A, 0x57, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xBF, 0xC9, 0xCF, 
  0x80, 0x01, 0xD9, 0x80, 0x03, 0xBF, 0xC9, 0xCF, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xB8, 0x48, 0x45, 
  0x80, 0x01, 0x59, 0x80, 0x03, 0x88, 0x7E, 0x77, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xD9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xD9, 0x80, 0x03, 0xB8, 0x00, 0x05, 0x80, 0x01, 
  0x59, 0x80, 0x03, 0x88, 0x00, 0x07, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xB9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBB, 0xFE, 0xE5, 0x80, 0x01, 0xB9, 0x80, 
  0x03, 0x8B, 0xFE, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xBE, 0x49, 0x9F, 0x80, 0x01, 0x79, 0x80, 
  0x03, 0xBE, 0x49, 0x9F, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBA, 0x48, 0x85, 0x80, 0x01, 0x79, 0x80, 
  0x03, 0x8A, 0xDA, 0xA7, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBE, 0x49, 0x9E, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBE, 0x49, 0x9E, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBA, 0x48, 0x86, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x8B, 0xFE, 0xE7, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xFD, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xFF, 0xFD, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x05, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x88, 0x00, 0x06, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB7, 0xFF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB7, 0xFF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB7, 0xFF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x8F, 0xFF, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB8, 0x00, 0x07, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB8, 0x00, 0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0x00, 0x07, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x87, 0xFF, 0xF8, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 
  0x82, 0x80, 0x01, 0xFE, 
}; /* batdefn4 */

