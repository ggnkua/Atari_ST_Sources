LOCAL UBYTE execn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x0F, 0x80, 0x01, 0x80, 0x04, 0x80, 0x10, 0x40, 0x01, 0x80, 0x04, 
  0x80, 0x17, 0x40, 0x01, 0x80, 0x04, 0x80, 0x2E, 0x80, 0x01, 0x80, 0x04, 0x80, 0x2E, 0x80, 0x01, 
  0x80, 0x04, 0x80, 0x4E, 0x78, 0x01, 0x80, 0x04, 0x80, 0x5F, 0x04, 0x01, 0x80, 0x04, 0x80, 0x9F, 
  0xE4, 0x01, 0x80, 0x04, 0x80, 0x83, 0xE8, 0x01, 0x80, 0x04, 0x80, 0x79, 0xC8, 0x01, 0x80, 0x04, 
  0x80, 0x05, 0xD0, 0x01, 0x80, 0x04, 0x80, 0x05, 0xD0, 0x01, 0x80, 0x04, 0x80, 0x09, 0xCF, 0x01, 
  0x80, 0x04, 0x80, 0x0B, 0xE0, 0x81, 0x80, 0x04, 0x80, 0x13, 0xF9, 0x01, 0x80, 0x04, 0x80, 0x10, 
  0x72, 0x01, 0x80, 0x04, 0x80, 0x0F, 0x24, 0x01, 0x80, 0x04, 0x80, 0x00, 0xA8, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x90, 0x01, 0x80, 0x04, 0x80, 0x00, 0xA0, 0x01, 0x80, 0x04, 0x80, 0x00, 0x40, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* execn1 */

