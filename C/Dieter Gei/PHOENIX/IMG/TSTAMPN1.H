LOCAL UBYTE tstampn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x03, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x07, 0x80, 0x04, 0x80, 0x00, 0x00, 0x07, 0x80, 0x04, 0x87, 0xFC, 0xFF, 0x87, 0x80, 0x04, 
  0x84, 0x03, 0x00, 0xC7, 0x80, 0x04, 0x84, 0x03, 0x00, 0xE7, 0x80, 0x04, 0x84, 0x63, 0x1C, 0xE7, 
  0x80, 0x04, 0x84, 0xE4, 0xBE, 0xE7, 0x80, 0x04, 0x84, 0xE7, 0xB6, 0xE7, 0x80, 0x04, 0x84, 0x63, 
  0x06, 0xE7, 0x80, 0x04, 0x84, 0x63, 0x1C, 0xE7, 0x80, 0x04, 0x84, 0x3F, 0xF8, 0xE7, 0x80, 0x04, 
  0x84, 0xC0, 0x06, 0xE7, 0x80, 0x04, 0x84, 0xDF, 0xF6, 0xE7, 0x80, 0x04, 0x84, 0x50, 0x14, 0xE7, 
  0x80, 0x04, 0x85, 0xD1, 0x16, 0xE7, 0x80, 0x04, 0x84, 0x51, 0x14, 0xE7, 0x80, 0x04, 0x85, 0xD1, 
  0x96, 0xE7, 0x80, 0x04, 0x84, 0x52, 0x14, 0xE7, 0x80, 0x04, 0x87, 0xD4, 0x17, 0xE7, 0x80, 0x04, 
  0x83, 0xD0, 0x17, 0xE7, 0x80, 0x04, 0x81, 0xDF, 0xF7, 0xE7, 0x80, 0x04, 0x80, 0x40, 0x04, 0x07, 
  0x80, 0x04, 0x80, 0x3F, 0xF8, 0x07, 0x80, 0x04, 0xBF, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0xFF, 0xFF, 
  0xFF, 0xFF, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* tstampn1 */

