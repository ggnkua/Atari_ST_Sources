LOCAL UBYTE calcn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x8F, 0xFF, 0xF9, 0x81, 0x80, 0x04, 0x90, 0x00, 0x05, 0x81, 0x80, 0x04, 0x91, 0xFF, 0xC5, 0x81, 
  0x80, 0x04, 0x91, 0x00, 0x45, 0x81, 0x80, 0x04, 0x91, 0xFF, 0xC5, 0xA1, 0x80, 0x04, 0x90, 0x00, 
  0x05, 0xE1, 0x80, 0x04, 0x90, 0x92, 0x45, 0xE1, 0x80, 0x04, 0x91, 0xB6, 0xC5, 0xE1, 0x80, 0x04, 
  0x90, 0x00, 0x05, 0xE1, 0x80, 0x04, 0x90, 0x92, 0x45, 0x61, 0x80, 0x04, 0x91, 0xB6, 0xC4, 0x61, 
  0x80, 0x04, 0x90, 0x00, 0x04, 0x61, 0x80, 0x04, 0x90, 0x90, 0x44, 0x61, 0x80, 0x04, 0x91, 0xB7, 
  0xC5, 0xF9, 0x80, 0x04, 0x90, 0x00, 0x04, 0xF1, 0x80, 0x04, 0x90, 0x00, 0x04, 0x61, 0x80, 0x04, 
  0x8F, 0xFF, 0xF8, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* calcn1 */

