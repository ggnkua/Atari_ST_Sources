LOCAL UBYTE execn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x80, 0x01, 0x07, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0xF0, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x40, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFD, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 
  0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x15, 0x40, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFB, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x2A, 0x80, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFB, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE0, 0xFF, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x2A, 0x80, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFB, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x7F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0x80, 0x4A, 0x78, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xF1, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC0, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x51, 0x04, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xFE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x80, 0x07, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x80, 0x9E, 0xE4, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xFF, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x80, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0x80, 0x83, 0x68, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0xFF, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 
  0x79, 0x48, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 
  0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFC, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x05, 
  0x50, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x7F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFC, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x05, 0x50, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x7F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x09, 0x4F, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x7F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x00, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0B, 0x60, 0x80, 0x01, 
  0x87, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x9F, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xF0, 0x01, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x13, 0x99, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xDF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xF0, 0x03, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x52, 0x80, 0x01, 0x07, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0xFF, 0x07, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x0F, 0x24, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x8F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0xA8, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0x9F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0x80, 0x00, 0x90, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xBF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x80, 0x00, 0xA0, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 
  0x40, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 
  0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* execn4 */

