LOCAL UBYTE returnn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x9F, 0xE0, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x94, 0x30, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xEF, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xEF, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEF, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x9F, 0xF4, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x94, 0x3C, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB4, 0x3F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB4, 0x3F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB4, 0x3F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x94, 0x3F, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x94, 0x3D, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0x94, 0x35, 0x1F, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xB4, 0x2F, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xB4, 0x2F, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xB4, 0x2F, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x94, 0x31, 0x14, 0x80, 0x01, 0x37, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xE9, 0x80, 
  0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xE9, 0x80, 0x03, 0xB4, 0x2F, 0xFF, 0x80, 0x01, 0xE9, 0x80, 
  0x03, 0x94, 0x31, 0x1F, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xB4, 0x2F, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xB4, 0x2F, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xB4, 0x2F, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x94, 0x31, 0x14, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBF, 0xEF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xBF, 0xEF, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xBF, 0xEF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x9F, 0xF1, 0x14, 0x80, 0x01, 0x37, 0x80, 0x03, 0xB0, 0x0F, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xB0, 0x0F, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xB0, 0x0F, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x8F, 0xF1, 0xF4, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x80, 0x00, 0x14, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x80, 0x00, 0x14, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x80, 0x00, 0x14, 0x80, 0x01, 0x37, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 0x03, 0xBF, 0xFF, 0xF4, 0x80, 0x01, 0x29, 0x80, 
  0x03, 0x80, 0x00, 0x14, 0x80, 0x01, 0x37, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xE9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xE9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xE9, 0x80, 0x03, 0x80, 0x00, 
  0x1F, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBF, 0xFF, 0xF0, 0x80, 0x01, 0x09, 0x80, 0x03, 0xBF, 0xFF, 
  0xF0, 0x80, 0x01, 0x09, 0x80, 0x03, 0xBF, 0xFF, 0xF0, 0x80, 0x01, 0x09, 0x80, 0x03, 0x80, 0x00, 
  0x0F, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 
  0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* returnn4 */

