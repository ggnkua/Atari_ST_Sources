LOCAL UBYTE app1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x7F, 0xFC, 0x80, 0x02, 0x55, 0x56, 0x80, 0x02, 0x7F, 0xFE, 
  0x80, 0x02, 0x40, 0x06, 0x80, 0x02, 0x40, 0x06, 0x80, 0x02, 0x40, 0x06, 0x80, 0x02, 0x40, 0x06, 
  0x80, 0x02, 0x40, 0x06, 0x80, 0x02, 0x40, 0x06, 0x80, 0x02, 0x40, 0x06, 0x80, 0x02, 0x40, 0x06, 
  0x80, 0x02, 0x40, 0x06, 0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x3F, 0xFE, 0x80, 0x02, 0x00, 0x00, 
}; /* app1 */

