LOCAL UBYTE toolcal [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x4F, 0x80, 0x01, 0xF6, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x48, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x78, 0x80, 0x01, 0x1A, 0x80, 0x01, 0x78, 0x80, 0x01, 0x1E, 0x80, 0x01, 
  0x58, 0x80, 0x01, 0x0A, 0x80, 0x01, 0x48, 0x80, 0x01, 0x06, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x58, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x5F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x44, 0x80, 0x01, 0x96, 0x80, 0x01, 0x76, 0x80, 0x01, 0xDA, 
  0x80, 0x01, 0x76, 0x80, 0x01, 0xDE, 0x80, 0x01, 0x56, 0x80, 0x01, 0xDE, 0x80, 0x01, 0x4D, 0x80, 
  0x01, 0xB2, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x5F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x44, 0x80, 
  0x01, 0x36, 0x80, 0x01, 0x76, 0x80, 0x01, 0x3A, 0x80, 0x01, 0x76, 0x80, 0x01, 0x3E, 0x80, 0x01, 
  0x56, 0x80, 0x01, 0x1E, 0x80, 0x01, 0x4D, 0x80, 0x01, 0xF2, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x5F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x06, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x5F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x59, 0x80, 0x01, 0x5A, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x59, 0x80, 0x01, 0x5A, 0x80, 0x01, 0x3F, 0x80, 
  0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 
  0x3F, 0x80, 0x01, 0xFC, 0x02, 0x02, 0x02, 0x02, 
}; /* toolcal */

