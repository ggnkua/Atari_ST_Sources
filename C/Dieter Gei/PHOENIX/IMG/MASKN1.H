LOCAL UBYTE maskn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xE1, 0x80, 0x04, 
  0x8F, 0xFF, 0xFF, 0xF1, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 
  0x80, 0x04, 0x88, 0x00, 0x00, 0x31, 0x80, 0x04, 0x8B, 0xAA, 0x7A, 0xB1, 0x80, 0x04, 0x8A, 0x80, 
  0x00, 0x31, 0x80, 0x04, 0x8B, 0xAA, 0x7A, 0xB1, 0x80, 0x04, 0x88, 0x00, 0x00, 0x31, 0x80, 0x04, 
  0x8B, 0xA8, 0x00, 0x31, 0x80, 0x04, 0x8A, 0x83, 0xFF, 0xB1, 0x80, 0x04, 0x8B, 0xAA, 0x00, 0xB1, 
  0x80, 0x04, 0x88, 0x02, 0xAE, 0xB1, 0x80, 0x04, 0x88, 0x02, 0x00, 0xB1, 0x80, 0x04, 0x8B, 0xFA, 
  0xAE, 0xB1, 0x80, 0x04, 0x88, 0x02, 0x00, 0xB1, 0x80, 0x04, 0x8A, 0xAB, 0xFF, 0xB1, 0x80, 0x04, 
  0x88, 0x00, 0x00, 0x31, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 0x80, 0x04, 0x87, 0xFF, 0xFF, 0xF1, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* maskn1 */

