LOCAL UBYTE ind1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x0F, 0xF0, 0x80, 0x02, 0x30, 0x0C, 0x80, 0x02, 0x40, 0x02, 
  0x80, 0x02, 0x70, 0x0E, 0x80, 0x02, 0x4F, 0xF2, 0x80, 0x02, 0x40, 0x02, 0x80, 0x02, 0x5C, 0xE2, 
  0x80, 0x02, 0x52, 0x92, 0x80, 0x02, 0x52, 0xE2, 0x80, 0x02, 0x52, 0x92, 0x80, 0x02, 0x5C, 0xE2, 
  0x80, 0x02, 0x40, 0x02, 0x80, 0x02, 0x30, 0x0C, 0x80, 0x02, 0x0F, 0xF0, 0x80, 0x02, 0x00, 0x00, 
}; /* ind1 */

