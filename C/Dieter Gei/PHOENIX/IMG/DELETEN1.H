LOCAL UBYTE deleten1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0xC0, 0x18, 0x01, 
  0x80, 0x04, 0x80, 0xF0, 0x30, 0x01, 0x80, 0x04, 0x80, 0x78, 0x60, 0x01, 0x80, 0x04, 0x80, 0x1C, 
  0x80, 0x01, 0x80, 0x04, 0x80, 0x0F, 0x80, 0x01, 0x80, 0x04, 0x80, 0x07, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x0F, 0x80, 0x01, 0x80, 0x04, 0x80, 0x1C, 0xC0, 0x01, 0x80, 0x04, 0x80, 0x38, 0x60, 0x01, 
  0x80, 0x04, 0x80, 0x70, 0x20, 0x01, 0x80, 0x04, 0x80, 0x70, 0x10, 0x01, 0x80, 0x04, 0x80, 0x20, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x08, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* deleten1 */

