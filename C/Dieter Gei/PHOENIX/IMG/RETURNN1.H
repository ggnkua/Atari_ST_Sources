LOCAL UBYTE returnn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x9F, 0xE0, 0x00, 0x01, 0x80, 0x04, 0x94, 0x30, 0x00, 0x01, 0x80, 0x04, 0x9F, 0xF4, 0x00, 0x01, 
  0x80, 0x04, 0x94, 0x3C, 0x00, 0x01, 0x80, 0x04, 0x94, 0x3F, 0x00, 0x01, 0x80, 0x04, 0x94, 0x2D, 
  0x00, 0x01, 0x80, 0x04, 0x94, 0x25, 0x1F, 0xE1, 0x80, 0x04, 0x94, 0x21, 0x14, 0x21, 0x80, 0x04, 
  0x94, 0x21, 0x1F, 0xE1, 0x80, 0x04, 0x94, 0x21, 0x14, 0x21, 0x80, 0x04, 0x9F, 0xE1, 0x14, 0x21, 
  0x80, 0x04, 0x80, 0x01, 0xF4, 0x21, 0x80, 0x04, 0x80, 0x00, 0x14, 0x21, 0x80, 0x04, 0x80, 0x00, 
  0x14, 0x21, 0x80, 0x04, 0x80, 0x00, 0x14, 0x21, 0x80, 0x04, 0x80, 0x00, 0x14, 0x21, 0x80, 0x04, 
  0x80, 0x00, 0x1F, 0xE1, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* returnn1 */

