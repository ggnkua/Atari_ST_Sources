LOCAL UBYTE checkn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x7F, 0xFC, 0x01, 
  0x80, 0x04, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x04, 0x80, 0x50, 0x14, 0x01, 0x80, 0x04, 0x80, 0x48, 
  0x24, 0x01, 0x80, 0x04, 0x80, 0x44, 0x44, 0x01, 0x80, 0x04, 0x80, 0x42, 0x84, 0x01, 0x80, 0x04, 
  0x80, 0x41, 0x04, 0x01, 0x80, 0x04, 0x80, 0x42, 0x84, 0x01, 0x80, 0x04, 0x80, 0x44, 0x44, 0x01, 
  0x80, 0x04, 0x80, 0x48, 0x24, 0x01, 0x80, 0x04, 0x80, 0x50, 0x14, 0x01, 0x80, 0x04, 0x80, 0x60, 
  0x0C, 0x01, 0x80, 0x04, 0x80, 0x7F, 0xFC, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* checkn1 */

