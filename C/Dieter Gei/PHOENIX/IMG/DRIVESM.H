LOCAL UBYTE drivesm [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x80, 0x00, 0x10, 
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x80, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x30, 0x80, 0x10, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x80, 0x10, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0xFE, 
  0x3F, 0xFE, 0x3F, 0xFE, 0xF8, 0xFF, 0x03, 0xFC, 0x80, 0x10, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0x0F, 0xFE, 0x80, 0x10, 0x7F, 0xFF, 0x7F, 0xFF, 
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0xFF, 0xFF, 
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x10, 
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0xFF, 0xFF, 
  0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 
  0xFF, 0xFE, 0x80, 0x10, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 
  0x1F, 0xC0, 0x7F, 0xFA, 0x80, 0x10, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 
  0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0xEA, 0x80, 0x10, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 
  0x7F, 0xFC, 0x7F, 0xFC, 0x05, 0x00, 0x1F, 0xA8, 0x80, 0x10, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xA0, 0x80, 0x10, 0x1F, 0xFF, 0x1F, 0xFF, 
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x80, 0x80, 0x10, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x10, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
}; /* drivesm */

