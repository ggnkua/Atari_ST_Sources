LOCAL UBYTE fonts1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x40, 0x00, 0x10, 
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x08, 0xFF, 0xF8, 0xFF, 0xF8, 
  0xFF, 0xF8, 0xFF, 0xF8, 0x80, 0x08, 0x80, 0x14, 0x81, 0x14, 0x80, 0x14, 0x80, 0x14, 0x80, 0x08, 
  0x81, 0x92, 0x81, 0x92, 0x80, 0x12, 0x80, 0x12, 0x80, 0x08, 0x83, 0xD1, 0x83, 0x91, 0x83, 0xD1, 
  0x9F, 0xF1, 0x80, 0x08, 0x87, 0xFF, 0x82, 0xDF, 0x86, 0x7F, 0x9B, 0x7F, 0x80, 0x08, 0x86, 0x61, 
  0x84, 0x61, 0x8E, 0x61, 0x93, 0x21, 0x80, 0x08, 0x86, 0x61, 0x84, 0x61, 0x8F, 0x81, 0x83, 0x01, 
  0x80, 0x08, 0x87, 0xE1, 0x8F, 0xF1, 0x87, 0xC1, 0x83, 0x01, 0x80, 0x08, 0x87, 0xE1, 0x88, 0x31, 
  0x83, 0xE1, 0x83, 0x01, 0x80, 0x08, 0x86, 0x61, 0x90, 0x19, 0x9C, 0xE1, 0x83, 0x01, 0x80, 0x08, 
  0x86, 0x61, 0x90, 0x19, 0x9C, 0xC1, 0x83, 0x01, 0x80, 0x08, 0x86, 0x61, 0xB8, 0x3D, 0x8F, 0x81, 
  0x87, 0x81, 0x80, 0x08, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x08, 0xFF, 0xFF, 
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
}; /* fonts1 */

