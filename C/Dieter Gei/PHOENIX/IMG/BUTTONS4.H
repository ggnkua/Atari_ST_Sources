LOCAL UBYTE buttons4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x34, 0x00, 0x34, 
  0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x80, 0x01, 0x10, 0x80, 0x06, 0x00, 0x08, 0x00, 
  0x40, 0x02, 0x00, 0x80, 0x01, 0x10, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x80, 0x01, 
  0x10, 0x80, 0x06, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 
  0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 
  0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xFF, 
  0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0x80, 0x01, 0xC0, 0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 0xFF, 
  0x80, 0x01, 0xE0, 0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 
  0x40, 0x12, 0x00, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x00, 0x30, 0x01, 
  0x80, 0x80, 0x01, 0x00, 0x80, 0x06, 0x40, 0x12, 0xC6, 0x9F, 0xFC, 0xCE, 0x80, 0x01, 0x60, 0x80, 
  0x06, 0x40, 0x12, 0xC6, 0x9F, 0xFC, 0xCE, 0x80, 0x01, 0x60, 0x80, 0x06, 0x40, 0x12, 0xC6, 0x9F, 
  0xFC, 0xCE, 0x80, 0x01, 0x60, 0x80, 0x06, 0xC0, 0x06, 0xC6, 0x30, 0x01, 0xB1, 0x80, 0x01, 0x80, 
  0x80, 0x06, 0x40, 0x12, 0xEE, 0x9F, 0xFC, 0xC4, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0xEE, 
  0x9F, 0xFC, 0xC4, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0xEE, 0x9F, 0xFC, 0xC4, 0x80, 0x01, 
  0x20, 0x80, 0x06, 0xC0, 0x06, 0xEE, 0x30, 0x01, 0xBB, 0x80, 0x01, 0x80, 0x80, 0x06, 0x40, 0x12, 
  0x7C, 0x9F, 0xFC, 0xE0, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x7C, 0x9F, 0xFC, 0xE0, 0x80, 
  0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x7C, 0x9F, 0xFC, 0xE0, 0x80, 0x01, 0x20, 0x80, 0x06, 0xC0, 
  0x06, 0x7C, 0x30, 0x01, 0x9F, 0x80, 0x01, 0x00, 0x80, 0x06, 0x40, 0x12, 0x38, 0x9F, 0xFC, 0xF0, 
  0x80, 0x01, 0x60, 0x80, 0x06, 0x40, 0x12, 0x38, 0x9F, 0xFC, 0xF0, 0x80, 0x01, 0x60, 0x80, 0x06, 
  0x40, 0x12, 0x38, 0x9F, 0xFC, 0xF0, 0x80, 0x01, 0x60, 0x80, 0x06, 0xC0, 0x06, 0x38, 0x30, 0x01, 
  0x8E, 0x80, 0x01, 0x00, 0x80, 0x05, 0x40, 0x12, 0x7C, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 0x80, 0x01, 
  0xE0, 0x80, 0x05, 0x40, 0x12, 0x7C, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 0x80, 0x01, 0xE0, 0x80, 0x05, 
  0x40, 0x12, 0x7C, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x7C, 
  0x30, 0x01, 0x9F, 0x80, 0x01, 0x00, 0x80, 0x06, 0x40, 0x12, 0xEE, 0x9F, 0xFC, 0xC0, 0x80, 0x01, 
  0x60, 0x80, 0x06, 0x40, 0x12, 0xEE, 0x9F, 0xFC, 0xC0, 0x80, 0x01, 0x60, 0x80, 0x06, 0x40, 0x12, 
  0xEE, 0x9F, 0xFC, 0xC0, 0x80, 0x01, 0x60, 0x80, 0x06, 0xC0, 0x06, 0xEE, 0x30, 0x01, 0xBB, 0x80, 
  0x01, 0x80, 0x80, 0x06, 0x40, 0x12, 0xC6, 0x9F, 0xFC, 0xC2, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 
  0x12, 0xC6, 0x9F, 0xFC, 0xC2, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0xC6, 0x9F, 0xFC, 0xC2, 
  0x80, 0x01, 0x20, 0x80, 0x06, 0xC0, 0x06, 0xC6, 0x30, 0x01, 0xB1, 0x80, 0x01, 0x80, 0x80, 0x06, 
  0x40, 0x12, 0x00, 0x9F, 0xFC, 0xE7, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 
  0xE7, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 0xE7, 0x80, 0x01, 0x20, 0x80, 
  0x06, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 
  0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 
  0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x00, 
  0x30, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x05, 0x80, 0x04, 0x00, 0x20, 0x01, 0x02, 0x80, 0x05, 
  0x80, 0x04, 0x00, 0x20, 0x01, 0x02, 0x80, 0x05, 0x80, 0x04, 0x00, 0x20, 0x01, 0x02, 0x07, 0x80, 
  0x06, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xF0, 0xFF, 0x87, 0xFC, 
  0x3F, 0xE1, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0x80, 0x01, 0xF0, 
  0x80, 0x06, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x80, 0x01, 0x00, 0x80, 0x06, 0xDF, 0xBE, 0xFD, 
  0xF7, 0xEF, 0xBF, 0x80, 0x01, 0x70, 0x80, 0x06, 0xDF, 0xBE, 0xFD, 0xF7, 0xEF, 0xBF, 0x80, 0x01, 
  0x70, 0x80, 0x06, 0xDF, 0xBE, 0xFD, 0xF7, 0xEF, 0xBF, 0x80, 0x01, 0x70, 0x80, 0x06, 0x3F, 0xC1, 
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0x80, 0x80, 0x06, 0xA0, 0x0D, 0x00, 0x6B, 0xE3, 0x5F, 0x80, 
  0x01, 0x30, 0x80, 0x06, 0xA0, 0x0D, 0x00, 0x6B, 0xE3, 0x5F, 0x80, 0x01, 0x30, 0x80, 0x06, 0xA0, 
  0x0D, 0x00, 0x6B, 0xE3, 0x5F, 0x80, 0x01, 0x30, 0x80, 0x06, 0x70, 0x63, 0x83, 0x1C, 0x18, 0xE0, 
  0x80, 0x01, 0xC0, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x02, 0xF7, 0xBF, 0x80, 
  0x01, 0xB0, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x02, 0xF7, 0xBF, 0x80, 0x01, 
  0xB0, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x02, 0xF7, 0xBF, 0x80, 0x01, 0xB0, 
  0x80, 0x06, 0x60, 0x23, 0x01, 0x18, 0x08, 0xC0, 0x80, 0x01, 0x40, 0x80, 0x06, 0x40, 0x02, 0x38, 
  0x1F, 0xF8, 0xF1, 0x80, 0x01, 0xC0, 0x80, 0x06, 0x40, 0x02, 0x38, 0x1F, 0xF8, 0xF1, 0x80, 0x01, 
  0xC0, 0x80, 0x06, 0x40, 0x02, 0x38, 0x1F, 0xF8, 0xF1, 0x80, 0x01, 0xC0, 0x80, 0x06, 0xC0, 0x16, 
  0x38, 0xB0, 0x05, 0x8E, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x02, 0x7C, 0x1F, 0xF8, 0xE0, 0x80, 
  0x01, 0xC0, 0x80, 0x06, 0x40, 0x02, 0x7C, 0x1F, 0xF8, 0xE0, 0x80, 0x01, 0xC0, 0x80, 0x06, 0x40, 
  0x02, 0x7C, 0x1F, 0xF8, 0xE0, 0x80, 0x01, 0xC0, 0x80, 0x06, 0xC0, 0x16, 0x7C, 0xB0, 0x05, 0x9F, 
  0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x02, 0x7C, 0x1F, 0xF8, 0xE0, 0x80, 0x01, 0x40, 0x80, 0x06, 
  0x40, 0x02, 0x7C, 0x1F, 0xF8, 0xE0, 0x80, 0x01, 0x40, 0x80, 0x06, 0x40, 0x02, 0x7C, 0x1F, 0xF8, 
  0xE0, 0x80, 0x01, 0x40, 0x80, 0x06, 0xC0, 0x16, 0x7C, 0xB0, 0x05, 0x9F, 0x80, 0x01, 0x20, 0x80, 
  0x06, 0x40, 0x02, 0x7C, 0x1F, 0xF8, 0xE0, 0x80, 0x01, 0x40, 0x80, 0x06, 0x40, 0x02, 0x7C, 0x1F, 
  0xF8, 0xE0, 0x80, 0x01, 0x40, 0x80, 0x06, 0x40, 0x02, 0x7C, 0x1F, 0xF8, 0xE0, 0x80, 0x01, 0x40, 
  0x80, 0x06, 0xC0, 0x16, 0x7C, 0xB0, 0x05, 0x9F, 0x80, 0x01, 0x20, 0x80, 0x06, 0xC0, 0x06, 0x38, 
  0x3F, 0xF9, 0xF0, 0x80, 0x01, 0x40, 0x80, 0x06, 0xC0, 0x06, 0x38, 0x3F, 0xF9, 0xF0, 0x80, 0x01, 
  0x40, 0x80, 0x06, 0xC0, 0x06, 0x38, 0x3F, 0xF9, 0xF0, 0x80, 0x01, 0x40, 0x80, 0x06, 0x40, 0x12, 
  0x38, 0x90, 0x04, 0x8E, 0x80, 0x01, 0x20, 0x80, 0x06, 0x80, 0x0C, 0x00, 0x67, 0xF3, 0x30, 0x80, 
  0x01, 0x90, 0x80, 0x06, 0x80, 0x0C, 0x00, 0x67, 0xF3, 0x30, 0x80, 0x01, 0x90, 0x80, 0x06, 0x80, 
  0x0C, 0x00, 0x67, 0xF3, 0x30, 0x80, 0x01, 0x90, 0x80, 0x06, 0x60, 0x23, 0x01, 0x18, 0x08, 0xC0, 
  0x80, 0x01, 0x40, 0x80, 0x06, 0xC0, 0x2E, 0x01, 0x73, 0xEB, 0x9F, 0x80, 0x01, 0x50, 0x80, 0x06, 
  0xC0, 0x2E, 0x01, 0x73, 0xEB, 0x9F, 0x80, 0x01, 0x50, 0x80, 0x06, 0xC0, 0x2E, 0x01, 0x73, 0xEB, 
  0x9F, 0x80, 0x01, 0x50, 0x80, 0x06, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x80, 0x01, 0x80, 0x80, 
  0x06, 0xD0, 0x1E, 0x80, 0xF4, 0x07, 0xE0, 0x80, 0x01, 0x30, 0x80, 0x06, 0xD0, 0x1E, 0x80, 0xF4, 
  0x07, 0xE0, 0x80, 0x01, 0x30, 0x80, 0x06, 0xD0, 0x1E, 0x80, 0xF4, 0x07, 0xE0, 0x80, 0x01, 0x30, 
  0x80, 0x06, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0x00, 0x80, 0x06, 0xF0, 0x7F, 0x83, 
  0xFC, 0x1F, 0xE0, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x80, 0x01, 
  0xF0, 0x80, 0x06, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x06, 0x00, 
  0x08, 0x00, 0x40, 0x02, 0x00, 0x80, 0x01, 0x10, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 
  0x80, 0x01, 0x10, 0x80, 0x06, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x80, 0x01, 0x10, 0x80, 0x06, 
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 
  0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 
  0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xFF, 0xE7, 0xFF, 0x3F, 
  0xF9, 0xFF, 0x80, 0x01, 0xC0, 0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 
  0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x40, 0x12, 0x00, 
  0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x80, 0x01, 
  0x00, 0x80, 0x06, 0x40, 0x12, 0x02, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0x60, 0x80, 0x06, 0x40, 0x12, 
  0x02, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0x60, 0x80, 0x06, 0x40, 0x12, 0x02, 0x9F, 0xFC, 0xFF, 0x80, 
  0x01, 0x60, 0x80, 0x05, 0xC0, 0x06, 0x02, 0x30, 0x01, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 
  0x06, 0x40, 0x12, 0x06, 0x9F, 0xFC, 0xFE, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x06, 0x9F, 
  0xFC, 0xFE, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x06, 0x9F, 0xFC, 0xFE, 0x80, 0x01, 0x20, 
  0x80, 0x01, 0xC0, 0x80, 0x01, 0x06, 0x80, 0x04, 0x06, 0x30, 0x01, 0x81, 0x80, 0x01, 0x80, 0x80, 
  0x06, 0x40, 0x12, 0x8E, 0x9F, 0xFC, 0xDC, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x8E, 0x9F, 
  0xFC, 0xDC, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0x8E, 0x9F, 0xFC, 0xDC, 0x80, 0x01, 0x20, 
  0x80, 0x06, 0xC0, 0x06, 0x8E, 0x30, 0x01, 0xA3, 0x80, 0x01, 0x80, 0x80, 0x06, 0x40, 0x12, 0xDC, 
  0x9F, 0xFC, 0xC8, 0x80, 0x01, 0x20, 0x80, 0x06, 0x40, 0x12, 0xDC, 0x9F, 0xFC, 0xC8, 0x80, 0x01, 
  0x20, 0x80, 0x06, 0x40, 0x12, 0xDC, 0x9F, 0xFC, 0xC8, 0x80, 0x01, 0x20, 0x80, 0x06, 0xC0, 0x06, 
  0xDC, 0x30, 0x01, 0xB7, 0x80, 0x01, 0x00, 0x80, 0x06, 0x40, 0x12, 0xF8, 0x9F, 0xFC, 0xC0, 0x80, 
  0x01, 0x60, 0x80, 0x06, 0x40, 0x12, 0xF8, 0x9F, 0xFC, 0xC0, 0x80, 0x01, 0x60, 0x80, 0x06, 0x40, 
  0x12, 0xF8, 0x9F, 0xFC, 0xC0, 0x80, 0x01, 0x60, 0x80, 0x06, 0xC0, 0x06, 0xF8, 0x30, 0x01, 0xBE, 
  0x80, 0x01, 0x00, 0x80, 0x05, 0x40, 0x12, 0x70, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 0x80, 0x01, 0xE0, 
  0x80, 0x05, 0x40, 0x12, 0x70, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 0x80, 0x01, 0xE0, 0x80, 0x05, 0x40, 
  0x12, 0x70, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x70, 0x30, 
  0x01, 0x9C, 0x80, 0x01, 0x00, 0x80, 0x06, 0x40, 0x12, 0x20, 0x9F, 0xFC, 0xF1, 0x80, 0x01, 0xE0, 
  0x80, 0x06, 0x40, 0x12, 0x20, 0x9F, 0xFC, 0xF1, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x40, 0x12, 0x20, 
  0x9F, 0xFC, 0xF1, 0x80, 0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x20, 0x30, 0x01, 0x88, 0x80, 0x01, 
  0x00, 0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 0xFB, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x40, 0x12, 
  0x00, 0x9F, 0xFC, 0xFB, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x40, 0x12, 0x00, 0x9F, 0xFC, 0xFB, 0x80, 
  0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x06, 0x7F, 
  0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 
  0x80, 0x01, 0xE0, 0x80, 0x06, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0x01, 0xE0, 0x80, 0x06, 
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x05, 0x80, 0x04, 0x00, 0x20, 0x01, 
  0x02, 0x80, 0x05, 0x80, 0x04, 0x00, 0x20, 0x01, 0x02, 0x80, 0x05, 0x80, 0x04, 0x00, 0x20, 0x01, 
  0x02, 0x07, 0x80, 0x06, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xFD, 
  0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 
  0x80, 0x01, 0xF0, 0x07, 0x80, 0x06, 0xFA, 0xFF, 0xD7, 0xFE, 0xBF, 0xF5, 0x80, 0x01, 0xF0, 0x80, 
  0x06, 0xFA, 0xFF, 0xD7, 0xFE, 0xBF, 0xF5, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xFA, 0xFF, 0xD7, 0xFE, 
  0xBF, 0xF5, 0x80, 0x01, 0xF0, 0x80, 0x06, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x80, 0x01, 0x00, 
  0x80, 0x06, 0xF5, 0x7F, 0xAB, 0xFD, 0xDF, 0xEE, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xF5, 0x7F, 0xAB, 
  0xFD, 0xDF, 0xEE, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xF5, 0x7F, 0xAB, 0xFD, 0xDF, 0xEE, 0x80, 0x01, 
  0xF0, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x80, 0x01, 0x00, 0x80, 0x06, 0xE8, 0xBF, 
  0x45, 0xFB, 0xEF, 0xDF, 0x80, 0x01, 0x70, 0x80, 0x06, 0xE8, 0xBF, 0x45, 0xFB, 0xEF, 0xDF, 0x80, 
  0x01, 0x70, 0x80, 0x06, 0xE8, 0xBF, 0x45, 0xFB, 0xEF, 0xDF, 0x80, 0x01, 0x70, 0x80, 0x06, 0x18, 
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x80, 0x01, 0x00, 0x80, 0x03, 0xD0, 0x5E, 0x92, 0x80, 0x01, 0xF7, 
  0x80, 0x02, 0xF7, 0xBB, 0x80, 0x01, 0xB0, 0x80, 0x03, 0xD0, 0x5E, 0x92, 0x80, 0x01, 0xF7, 0x80, 
  0x02, 0xF7, 0xBB, 0x80, 0x01, 0xB0, 0x80, 0x03, 0xD0, 0x5E, 0x92, 0x80, 0x01, 0xF7, 0x80, 0x02, 
  0xF7, 0xBB, 0x80, 0x01, 0xB0, 0x80, 0x06, 0x30, 0x01, 0x90, 0x0C, 0x00, 0x64, 0x80, 0x01, 0x00, 
  0x80, 0x06, 0xA0, 0x2D, 0x39, 0x6F, 0xFB, 0x71, 0x80, 0x01, 0xD0, 0x80, 0x06, 0xA0, 0x2D, 0x39, 
  0x6F, 0xFB, 0x71, 0x80, 0x01, 0xD0, 0x80, 0x06, 0xA0, 0x2D, 0x39, 0x6F, 0xFB, 0x71, 0x80, 0x01, 
  0xD0, 0x80, 0x06, 0x60, 0x03, 0x38, 0x18, 0x00, 0xCE, 0x80, 0x01, 0x00, 0x80, 0x05, 0x40, 0x12, 
  0x7C, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 0x80, 0x01, 0xE0, 0x80, 0x05, 0x40, 0x12, 0x7C, 0x9F, 0xFC, 
  0x80, 0x01, 0xE0, 0x80, 0x01, 0xE0, 0x80, 0x05, 0x40, 0x12, 0x7C, 0x9F, 0xFC, 0x80, 0x01, 0xE0, 
  0x80, 0x01, 0xE0, 0x80, 0x06, 0xC0, 0x06, 0x7C, 0x30, 0x01, 0x9F, 0x80, 0x01, 0x00, 0x80, 0x06, 
  0xA0, 0x2D, 0x39, 0x6F, 0xFB, 0x70, 0x80, 0x01, 0x50, 0x80, 0x06, 0xA0, 0x2D, 0x39, 0x6F, 0xFB, 
  0x70, 0x80, 0x01, 0x50, 0x80, 0x06, 0xA0, 0x2D, 0x39, 0x6F, 0xFB, 0x70, 0x80, 0x01, 0x50, 0x80, 
  0x06, 0x60, 0x03, 0x38, 0x18, 0x00, 0xCE, 0x80, 0x01, 0x00, 0x80, 0x03, 0xD0, 0x5E, 0x92, 0x80, 
  0x01, 0xF7, 0x80, 0x02, 0xF7, 0xB8, 0x80, 0x01, 0xB0, 0x80, 0x03, 0xD0, 0x5E, 0x92, 0x80, 0x01, 
  0xF7, 0x80, 0x02, 0xF7, 0xB8, 0x80, 0x01, 0xB0, 0x80, 0x03, 0xD0, 0x5E, 0x92, 0x80, 0x01, 0xF7, 
  0x80, 0x02, 0xF7, 0xB8, 0x80, 0x01, 0xB0, 0x80, 0x06, 0x30, 0x01, 0x90, 0x0C, 0x00, 0x64, 0x80, 
  0x01, 0x00, 0x80, 0x06, 0xE8, 0xBF, 0x45, 0xFB, 0xEF, 0xDD, 0x80, 0x01, 0x70, 0x80, 0x06, 0xE8, 
  0xBF, 0x45, 0xFB, 0xEF, 0xDD, 0x80, 0x01, 0x70, 0x80, 0x06, 0xE8, 0xBF, 0x45, 0xFB, 0xEF, 0xDD, 
  0x80, 0x01, 0x70, 0x80, 0x06, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x80, 0x01, 0x00, 0x80, 0x06, 
  0xF5, 0x7F, 0xAB, 0xFD, 0xDF, 0xEE, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xF5, 0x7F, 0xAB, 0xFD, 0xDF, 
  0xEE, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xF5, 0x7F, 0xAB, 0xFD, 0xDF, 0xEE, 0x80, 0x01, 0xF0, 0x80, 
  0x06, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x80, 0x01, 0x00, 0x80, 0x06, 0xFA, 0xFF, 0xD7, 0xFE, 
  0xBF, 0xF5, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xFA, 0xFF, 0xD7, 0xFE, 0xBF, 0xF5, 0x80, 0x01, 0xF0, 
  0x80, 0x06, 0xFA, 0xFF, 0xD7, 0xFE, 0xBF, 0xF5, 0x80, 0x01, 0xF0, 0x80, 0x06, 0x04, 0x00, 0x20, 
  0x01, 0x00, 0x08, 0x80, 0x01, 0x00, 0x80, 0x06, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0x80, 0x01, 
  0xF0, 0x80, 0x06, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0x80, 0x01, 0xF0, 0x80, 0x06, 0xFD, 0xFF, 
  0xEF, 0xFF, 0x7F, 0xFB, 0x80, 0x01, 0xF0, 0x07, 
}; /* buttons4 */

