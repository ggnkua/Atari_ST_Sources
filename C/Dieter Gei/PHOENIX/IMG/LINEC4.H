LOCAL UBYTE linec4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x82, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD4, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD4, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x81, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x2A, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xAA, 0x2A, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x80, 0x02, 0x80, 0x00, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 
  0xD5, 0x15, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x15, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x40, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x8A, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0x8A, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x20, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x45, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x45, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0x80, 0x10, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0x08, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x51, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x02, 0xD5, 0x51, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x04, 0x00, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x80, 0x02, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x02, 0xD5, 0x54, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x54, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 
  0x2A, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x80, 0x00, 0x80, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x15, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x00, 0x40, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0x8A, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0x8A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x00, 0x20, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x55, 0x45, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x45, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0x80, 0x00, 0x10, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0xA2, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x02, 0xAA, 0xA2, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x00, 0x08, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x51, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x00, 0x04, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x02, 0xAA, 0xA8, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0xA8, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0x00, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x54, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x55, 0x54, 0x80, 0x01, 0x55, 0x80, 0x02, 0x80, 0x00, 0x80, 0x01, 0x01, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 
  0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* linec4 */

