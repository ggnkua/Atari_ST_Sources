LOCAL UBYTE updd4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x00, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0xFF, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0xFE, 0x00, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xB8, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0xFE, 0x3F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xB8, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x86, 0x01, 0x80, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xB3, 0xFF, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB3, 0xFF, 0x9F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xB3, 0xFF, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 0x00, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xB0, 0xFE, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB0, 0xFE, 0x1F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xB0, 0xFE, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8E, 0x01, 0xC0, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xB2, 0x00, 0x99, 0x80, 0x01, 0x39, 0x80, 0x03, 0xB2, 0x00, 0x99, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xB2, 0x00, 0x99, 0x80, 0x01, 0x39, 0x80, 0x03, 0x89, 0xFE, 0x44, 0x80, 
  0x01, 0x87, 0x80, 0x03, 0xB3, 0xFF, 0x91, 0x80, 0x01, 0x19, 0x80, 0x03, 0xB3, 0xFF, 0x91, 0x80, 
  0x01, 0x19, 0x80, 0x03, 0xB3, 0xFF, 0x91, 0x80, 0x01, 0x19, 0x80, 0x03, 0x88, 0x00, 0x4C, 0x80, 
  0x01, 0xC7, 0x80, 0x03, 0xB3, 0xBD, 0x80, 0x80, 0x01, 0x09, 0x80, 0x03, 0xB0, 0x21, 0x80, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xB0, 0x21, 0x80, 0x80, 0x01, 0x09, 0x80, 0x03, 0x8B, 0x9C, 0x5F, 0x80, 
  0x01, 0xE7, 0x80, 0x03, 0xB2, 0xD6, 0x80, 0x80, 0x01, 0x09, 0x80, 0x03, 0xB0, 0x84, 0x80, 0x80, 
  0x01, 0x09, 0x80, 0x03, 0xB0, 0x84, 0x80, 0x80, 0x01, 0x09, 0x80, 0x03, 0x8A, 0x52, 0x5F, 0x80, 
  0x01, 0xE7, 0x80, 0x03, 0xB2, 0xDD, 0x91, 0x80, 0x01, 0x19, 0x80, 0x03, 0xB0, 0x81, 0x91, 0x80, 
  0x01, 0x19, 0x80, 0x03, 0xB0, 0x81, 0x91, 0x80, 0x01, 0x19, 0x80, 0x03, 0x8A, 0x5C, 0x4C, 0x80, 
  0x01, 0xC7, 0x80, 0x03, 0xB2, 0xD6, 0x99, 0x80, 0x01, 0x39, 0x80, 0x03, 0xB0, 0x84, 0x99, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xB0, 0x84, 0x99, 0x80, 0x01, 0x39, 0x80, 0x03, 0x8A, 0x52, 0x44, 0x80, 
  0x01, 0x87, 0x80, 0x03, 0xB3, 0xBD, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB0, 0x21, 0x9F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xB0, 0x21, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8B, 0x9C, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xB3, 0xFF, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB3, 0xFF, 0x9F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xB3, 0xFF, 0x9F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x88, 0x00, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xB8, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xB8, 0xFE, 0x3F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xB8, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x86, 0x01, 0x80, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x00, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0xFF, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0xFE, 0x00, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* updd4 */

