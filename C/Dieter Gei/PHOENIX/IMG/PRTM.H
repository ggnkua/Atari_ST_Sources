LOCAL UBYTE prtm [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x55, 0x00, 0x55, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x70, 0x80, 0x02, 0x00, 0xFC, 0x80, 0x02, 0x01, 0xFF, 0x80, 0x02, 0x07, 0xFC, 
  0x80, 0x02, 0x1F, 0xF8, 0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0xFF, 0xFF, 0x80, 0x02, 0xFF, 0xFF, 
  0x80, 0x02, 0xFF, 0xFF, 0x80, 0x02, 0xFF, 0xFF, 0x80, 0x02, 0xFF, 0xFE, 0x80, 0x02, 0x7F, 0xFE, 
  0x80, 0x02, 0x7F, 0xFE, 0x80, 0x02, 0x3F, 0xF8, 0x80, 0x02, 0x0F, 0xE0, 0x80, 0x02, 0x03, 0x80, 
}; /* prtm */

