LOCAL UBYTE fieldn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x83, 0xFF, 0xFF, 0xC1, 0x80, 0x04, 0x82, 0x00, 0x00, 0x41, 
  0x80, 0x04, 0x82, 0x00, 0x01, 0x41, 0x80, 0x04, 0x82, 0x01, 0x81, 0x41, 0x80, 0x04, 0x82, 0x01, 
  0x81, 0x41, 0x80, 0x04, 0x82, 0x01, 0x81, 0x41, 0x80, 0x04, 0x82, 0x79, 0xF1, 0x41, 0x80, 0x04, 
  0x82, 0xCD, 0x99, 0x41, 0x80, 0x04, 0x82, 0x3D, 0x99, 0x41, 0x80, 0x04, 0x82, 0x6D, 0x99, 0x41, 
  0x80, 0x04, 0x82, 0xCD, 0x99, 0x41, 0x80, 0x04, 0x82, 0xCD, 0x99, 0x41, 0x80, 0x04, 0x82, 0x7D, 
  0xF1, 0x41, 0x80, 0x04, 0x82, 0x00, 0x01, 0x41, 0x80, 0x04, 0x82, 0x00, 0x00, 0x41, 0x80, 0x04, 
  0x83, 0xFF, 0xFF, 0xC1, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* fieldn1 */

