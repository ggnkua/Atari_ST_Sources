LOCAL UBYTE tstampn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x87, 0xFD, 0xFF, 0x80, 0x01, 0x87, 0x80, 0x03, 0xBC, 0x03, 0x00, 
  0x80, 0x01, 0x79, 0x80, 0x03, 0xBC, 0x03, 0x00, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBC, 0x03, 0x00, 
  0x80, 0x01, 0x79, 0x80, 0x03, 0x84, 0x03, 0x00, 0x80, 0x01, 0xC7, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x61, 0x1C, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xE5, 0xBE, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x05, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x05, 0x80, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x04, 0x80, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xE7, 0xB6, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x07, 0x80, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x07, 0x80, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x07, 0x80, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x61, 0x06, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x61, 0x1C, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x01, 0x00, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0x8C, 0x03, 0x00, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x3F, 0xF8, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x3F, 0xF8, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBC, 0x02, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8C, 0x3F, 0xF8, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xFF, 0xFE, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBC, 0x7F, 0xFC, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x00, 0x04, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8C, 0x40, 0x04, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0xFF, 0xFE, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBC, 0x7F, 0xFC, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x1F, 0xF4, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8C, 0x5F, 0xF4, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x70, 0x1C, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBC, 0x70, 0x1C, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x10, 0x04, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8C, 0x50, 0x14, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBD, 0xF1, 0x1E, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBD, 0xF1, 0x1E, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBD, 0x91, 0x06, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8D, 0xD1, 0x16, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x71, 0x1C, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBC, 0x71, 0x1C, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x11, 0x04, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8C, 0x51, 0x14, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBD, 0xF1, 0x9E, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBD, 0xF1, 0x9E, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBD, 0x91, 0x86, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8D, 0xD1, 0x96, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x72, 0x1C, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBC, 0x70, 0x1C, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x10, 0x04, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8C, 0x50, 0x14, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBC, 0x74, 0x1C, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBC, 0x70, 0x1C, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBC, 0x10, 0x04, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8F, 0xD0, 0x17, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBE, 0x70, 0x1C, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBE, 0x70, 0x1C, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBE, 0x10, 0x04, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0x8F, 0xD0, 0x17, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x90, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x02, 0x8F, 0xDF, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x80, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x8F, 0xC0, 0x07, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x80, 0x02, 0xBF, 0xFB, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x80, 0x02, 0xBF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x80, 
  0x02, 0xBF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x3F, 0xF8, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 
  0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* tstampn4 */

