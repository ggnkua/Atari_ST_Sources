LOCAL UBYTE countn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x81, 0x00, 0x00, 0x01, 0x80, 0x04, 0x83, 0x00, 0x00, 0x01, 0x80, 0x04, 0x81, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x81, 0x00, 0x00, 0x01, 0x80, 0x04, 0x81, 0x00, 0x00, 0x01, 0x80, 0x04, 0x81, 0x22, 
  0xA0, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x83, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x84, 0x80, 0x00, 0x01, 0x80, 0x04, 0x80, 0x80, 0x00, 0x01, 0x80, 0x04, 0x83, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x84, 0x00, 0x00, 0x01, 0x80, 0x04, 0x87, 0xA2, 0xA0, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* countn1 */

