LOCAL UBYTE printn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x1F, 0xFF, 0x81, 0x80, 0x04, 
  0x80, 0x10, 0x00, 0x81, 0x80, 0x04, 0x80, 0x27, 0xF9, 0x01, 0x80, 0x04, 0x80, 0x20, 0x01, 0x01, 
  0x80, 0x04, 0x80, 0x20, 0x01, 0x01, 0x80, 0x04, 0x80, 0x4F, 0xF2, 0x01, 0x80, 0x04, 0x80, 0x40, 
  0x03, 0xE1, 0x80, 0x04, 0x80, 0x40, 0x02, 0x51, 0x80, 0x04, 0x81, 0x9F, 0xE4, 0xB1, 0x80, 0x04, 
  0x82, 0x80, 0x05, 0x51, 0x80, 0x04, 0x84, 0xFF, 0xFA, 0x91, 0x80, 0x04, 0x88, 0x00, 0x05, 0x11, 
  0x80, 0x04, 0x8F, 0xFF, 0xFE, 0x21, 0x80, 0x04, 0x88, 0x00, 0x02, 0x61, 0x80, 0x04, 0x88, 0x01, 
  0xF2, 0xA1, 0x80, 0x04, 0x88, 0x00, 0x03, 0x41, 0x80, 0x04, 0x8F, 0xFF, 0xFC, 0x81, 0x80, 0x04, 
  0x84, 0x00, 0x05, 0x01, 0x80, 0x04, 0x84, 0x00, 0x06, 0x01, 0x80, 0x04, 0x83, 0xFF, 0xFC, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* printn1 */

