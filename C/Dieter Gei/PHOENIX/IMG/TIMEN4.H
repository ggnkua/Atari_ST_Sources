LOCAL UBYTE timen4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xFE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xFE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x80, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xDF, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDF, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xDF, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x11, 0x84, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x0C, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBE, 0xFF, 0xFE, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBE, 0xFF, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0xFF, 0xFE, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x81, 0x80, 0x81, 0x80, 0x01, 0x87, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 
  0x00, 0x80, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x80, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0xA0, 0x80, 0x01, 0x07, 0x80, 
  0x01, 0xBD, 0x82, 0x80, 0x01, 0x79, 0x80, 0x01, 0xBD, 0x82, 0x80, 0x01, 0x79, 0x80, 0x01, 0xBD, 
  0x82, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0xC0, 0x80, 0x01, 0x47, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0x83, 0x03, 0xFC, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0x80, 0x01, 0x80, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x02, 0x80, 
  0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x04, 0x80, 0x80, 0x01, 0x07, 
  0x80, 0x03, 0xBE, 0xFF, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0xFF, 0xFE, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBE, 0xFF, 0xFE, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x80, 0x02, 0x80, 0x00, 0x80, 
  0x01, 0x87, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x80, 0x01, 0x80, 0x01, 0x87, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xDF, 0xF7, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDF, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDF, 0xF7, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x04, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFE, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFE, 0xFF, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x30, 0x8C, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x80, 0x01, 0x80, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* timen4 */

