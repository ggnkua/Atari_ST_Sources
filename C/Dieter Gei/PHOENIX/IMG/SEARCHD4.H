LOCAL UBYTE searchd4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xDE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xDE, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x00, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x80, 0x01, 0xBF, 0x80, 0x01, 0xBF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x80, 0x01, 0xBF, 
  0x80, 0x01, 0xBF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x80, 0x01, 0xBF, 0x80, 0x01, 0xBF, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x40, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x7F, 0xDF, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xDF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xDF, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0x80, 0x80, 0x02, 0x80, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0x3B, 
  0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x3B, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x3B, 
  0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x80, 0x84, 0x00, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBE, 0x80, 
  0x02, 0xBE, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBE, 0x80, 0x02, 0xBE, 0xEF, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBE, 0x80, 0x02, 0xBE, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x01, 0x00, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBD, 0xBF, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xBF, 0x77, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBD, 0xBF, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x00, 0x80, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBD, 0xBF, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xBF, 0x77, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBD, 0xBF, 0x77, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x00, 0x80, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBD, 0xDF, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xDF, 0xB7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBD, 0xDF, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x00, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBD, 0xDF, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBD, 0xDF, 0xB7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBD, 0xDF, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x82, 0x00, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0xEF, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0xEF, 0xB7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0xEF, 0xB7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0xFB, 0xAF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0xFB, 0xAF, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0xFB, 0xAF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x40, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0x7F, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xD7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0x7F, 0xD7, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x80, 0x02, 0x80, 
  0x00, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x80, 0x02, 0xBF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0xBF, 0x80, 0x02, 0xBF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x80, 0x02, 0xBF, 0xFB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x40, 0x00, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xEF, 0x7D, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEF, 0x7D, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xEF, 0x7D, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x80, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xBE, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xBE, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xBE, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x00, 0x40, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xDF, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xDF, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xDF, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0x80, 0x00, 0x20, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xEF, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0xBF, 0xFF, 0xEF, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBF, 0xFF, 0xEF, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0x80, 0x00, 0x10, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xF7, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0xBF, 0xFF, 0xF7, 0x80, 0x01, 0xB9, 0x80, 0x03, 0xBF, 0xFF, 0xF7, 0x80, 
  0x01, 0xB9, 0x80, 0x03, 0x80, 0x00, 0x08, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xFB, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFB, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFB, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0x80, 0x00, 0x04, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* searchd4 */

