LOCAL UBYTE searchn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x3E, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x41, 0x80, 0x01, 0x80, 0x04, 0x80, 0xF8, 0x40, 0x01, 0x80, 0x04, 0x80, 0x86, 0x20, 0x01, 
  0x80, 0x04, 0x81, 0x81, 0x20, 0x01, 0x80, 0x04, 0x82, 0x84, 0x90, 0x01, 0x80, 0x04, 0x82, 0x82, 
  0x90, 0x01, 0x80, 0x04, 0x82, 0x42, 0x50, 0x01, 0x80, 0x04, 0x82, 0x41, 0x50, 0x01, 0x80, 0x04, 
  0x81, 0x21, 0x50, 0x01, 0x80, 0x04, 0x81, 0x18, 0x60, 0x01, 0x80, 0x04, 0x80, 0x87, 0xD0, 0x01, 
  0x80, 0x04, 0x80, 0x60, 0x88, 0x01, 0x80, 0x04, 0x80, 0x1F, 0x5C, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x3E, 0x01, 0x80, 0x04, 0x80, 0x00, 0x1F, 0x01, 0x80, 0x04, 0x80, 0x00, 0x0F, 0x81, 0x80, 0x04, 
  0x80, 0x00, 0x07, 0xC1, 0x80, 0x04, 0x80, 0x00, 0x03, 0xC1, 0x80, 0x04, 0x80, 0x00, 0x01, 0x81, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* searchn1 */

