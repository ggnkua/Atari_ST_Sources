LOCAL UBYTE maskicn [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 
  0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 
  0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x5D, 0x80, 
  0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 
  0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x54, 0x80, 0x01, 0x02, 0x80, 0x01, 0x54, 0x80, 0x01, 0x02, 
  0x80, 0x01, 0x54, 0x80, 0x01, 0x02, 0x80, 0x01, 0x54, 0x80, 0x01, 0x02, 0x80, 0x01, 0x5D, 0x80, 
  0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 
  0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 
  0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x5D, 0x80, 
  0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 
  0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x55, 0x80, 0x01, 0x0A, 0x80, 0x01, 0x55, 0x80, 0x01, 0x0A, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x0A, 0x80, 0x01, 0x55, 0x80, 0x01, 0x0A, 0x80, 0x01, 0x5D, 0x80, 
  0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 
  0x5D, 0x80, 0x01, 0xFA, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 
  0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 
  0x7F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x02, 
}; /* maskicn */

