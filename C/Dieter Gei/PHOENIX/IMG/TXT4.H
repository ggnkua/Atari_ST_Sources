LOCAL UBYTE txt4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 
  0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x30, 0x80, 0x01, 0x20, 0x80, 0x01, 0x30, 0x80, 0x01, 0x20, 0x80, 0x01, 0x30, 0x80, 0x01, 
  0x20, 0x80, 0x01, 0x30, 0x80, 0x01, 0x20, 0x80, 0x01, 0x28, 0x80, 0x01, 0x20, 0x80, 0x01, 0x28, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x28, 0x80, 0x01, 0x20, 0x80, 0x01, 0x28, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x3C, 0x80, 0x01, 0x20, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x27, 0x80, 0x01, 0xBC, 0x80, 0x01, 
  0x27, 0x80, 0x01, 0xBC, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x27, 0x80, 0x01, 0xE4, 0x80, 0x01, 
  0x27, 0x80, 0x01, 0xE6, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x27, 0x80, 0x01, 0xE4, 0x80, 0x01, 
  0x27, 0x80, 0x01, 0xE6, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x27, 0x80, 0x01, 0xE4, 0x80, 0x01, 
  0x27, 0x80, 0x01, 0xE6, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 
  0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x20, 0x80, 
  0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 0x20, 0x80, 0x01, 0x04, 0x80, 0x01, 
  0x20, 0x80, 0x01, 0x06, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x80, 
  0x01, 0x1F, 0x80, 0x01, 0xFE, 0x02, 0x02, 0x02, 0x02, 0x00
}; /* txt4 */

