LOCAL UBYTE qben4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 
  0x39, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x88, 0x02, 0x80, 0x01, 0x37, 0x80, 0x01, 0xB8, 0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xB8, 
  0x02, 0x80, 0x01, 0x39, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x88, 0x02, 0x80, 
  0x01, 0x37, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0x89, 0x20, 0x42, 0x80, 0x01, 0x37, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0x89, 0x20, 0x42, 0x80, 0x01, 0x37, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 
  0x82, 0x80, 0x01, 0xF7, 0x80, 0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 
  0x42, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 0x39, 0x80, 0x01, 0x89, 0x02, 
  0x80, 0x01, 0x37, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x23, 0xE2, 
  0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0x89, 0x03, 0xE0, 
  0x80, 0x01, 0x37, 0x80, 0x03, 0xBF, 0xF8, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8F, 0x07, 0x70, 0x80, 
  0x01, 0x37, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0x72, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0x89, 0x00, 0x70, 0x80, 
  0x01, 0x37, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0xE2, 0x80, 
  0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0x89, 0x00, 0xE0, 0x80, 
  0x01, 0x37, 0x80, 0x03, 0xBF, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8F, 0x01, 0xC0, 0x80, 0x01, 
  0x37, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x21, 0xC2, 0x80, 0x01, 
  0x39, 0x80, 0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0x89, 0x01, 0xC0, 0x80, 0x01, 
  0x37, 0x80, 0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 
  0x39, 0x80, 0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 0x39, 0x80, 0x01, 0x89, 0x02, 0x80, 0x01, 0x37, 
  0x80, 0x03, 0xBF, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xFE, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8F, 0x01, 0xC0, 0x80, 0x01, 0x37, 0x80, 
  0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x21, 0xC2, 0x80, 0x01, 0x39, 0x80, 
  0x03, 0xBF, 0x20, 0x02, 0x80, 0x01, 0x39, 0x80, 0x03, 0x89, 0x01, 0xC0, 0x80, 0x01, 0x37, 0x80, 
  0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 0x39, 0x80, 0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 0x39, 0x80, 
  0x03, 0xBF, 0x20, 0x42, 0x80, 0x01, 0x39, 0x80, 0x01, 0x89, 0x02, 0x80, 0x01, 0x37, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x8F, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x87, 0x82, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* qben4 */

