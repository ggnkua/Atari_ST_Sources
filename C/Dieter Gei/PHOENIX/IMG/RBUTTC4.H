LOCAL UBYTE rbuttc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x03, 0xAA, 0xAF, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x80, 0x01, 
  0x01, 0x80, 0x03, 0xD5, 0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x45, 0x80, 
  0x01, 0x45, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x45, 0x80, 0x01, 0x45, 0x80, 0x01, 
  0x55, 0x80, 0x03, 0x80, 0x18, 0x30, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x8A, 0xA2, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0x8A, 0xA2, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x20, 0x08, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x15, 0x51, 0x80, 0x01, 
  0x55, 0x80, 0x03, 0xD5, 0x15, 0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x40, 0x04, 0x80, 0x01, 
  0x01, 0x80, 0x03, 0xAA, 0xEB, 0xAE, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x43, 0x84, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0xD7, 0x80, 0x01, 0xD7, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x50, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x50, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 
  0x87, 0xC2, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xAF, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0x20, 0x08, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x20, 0x08, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 
  0x8F, 0xE2, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0xDF, 0xF7, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x50, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x50, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 
  0x8F, 0xE2, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xAF, 0xEA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 
  0x20, 0x08, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x20, 0x08, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 
  0x8F, 0xE2, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0xD7, 0x80, 0x01, 0xD7, 0x80, 0x01, 
  0x55, 0x80, 0x03, 0xD5, 0x50, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x50, 0x15, 0x80, 0x01, 
  0x55, 0x80, 0x03, 0x80, 0x87, 0xC2, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xEB, 0xAE, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0x80, 0x43, 0x84, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x15, 0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 
  0x15, 0x51, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x40, 0x04, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x8A, 0xA2, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0xAA, 0x8A, 0xA2, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x20, 0x08, 0x80, 0x01, 
  0x01, 0x80, 0x03, 0xD5, 0x5D, 0x75, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x45, 0x80, 
  0x01, 0x45, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x45, 0x80, 0x01, 0x45, 0x80, 0x01, 
  0x55, 0x80, 0x03, 0x80, 0x18, 0x30, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xAF, 0xEA, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA8, 0x2A, 0x80, 0x01, 
  0xAB, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 
  0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* rbuttc4 */

