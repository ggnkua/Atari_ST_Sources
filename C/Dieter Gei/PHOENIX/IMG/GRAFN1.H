LOCAL UBYTE grafn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0x2A, 0x00, 0x2A, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 0x80, 0x04, 0x88, 0x00, 0x00, 0x11, 0x80, 0x04, 
  0x88, 0x0C, 0x00, 0x11, 0x80, 0x04, 0x88, 0x12, 0x07, 0x11, 0x80, 0x04, 0x88, 0x12, 0x08, 0x91, 
  0x80, 0x04, 0x88, 0x72, 0x08, 0x91, 0x80, 0x04, 0x88, 0x92, 0x08, 0x91, 0x80, 0x04, 0x88, 0x93, 
  0x87, 0x11, 0x80, 0x04, 0x88, 0x92, 0x40, 0x11, 0x80, 0x04, 0x88, 0x92, 0x40, 0x11, 0x80, 0x04, 
  0x88, 0x42, 0x40, 0x11, 0x80, 0x04, 0x8F, 0xE0, 0xFF, 0xF1, 0x80, 0x04, 0x88, 0x11, 0x00, 0x11, 
  0x80, 0x04, 0x88, 0x12, 0x00, 0x11, 0x80, 0x04, 0x88, 0x12, 0x63, 0x91, 0x80, 0x04, 0x88, 0x12, 
  0x90, 0x11, 0x80, 0x04, 0x88, 0x12, 0x88, 0x11, 0x80, 0x04, 0x88, 0x1E, 0xFC, 0x91, 0x80, 0x04, 
  0x88, 0xFC, 0x00, 0x11, 0x80, 0x04, 0x8F, 0xF8, 0x00, 0x11, 0x80, 0x04, 0x8F, 0xFF, 0xFF, 0xF1, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* grafn1 */

