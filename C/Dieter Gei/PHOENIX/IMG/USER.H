LOCAL UBYTE user [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xE0, 
  0x80, 0x01, 0x0F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xE0, 0x80, 0x01, 0x1F, 0x80, 
  0x01, 0xF0, 0x80, 0x01, 0x1F, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x1F, 0x80, 0x01, 0xF0, 0x80, 0x01, 
  0x1F, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x3F, 0x80, 0x01, 0x20, 0x80, 0x01, 0x3F, 0x80, 0x01, 0x20, 
  0x80, 0x01, 0x3F, 0x80, 0x01, 0x20, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xA0, 0x80, 0x01, 0x3D, 0x80, 
  0x01, 0x50, 0x80, 0x01, 0x3D, 0x80, 0x01, 0x50, 0x80, 0x01, 0x3D, 0x80, 0x01, 0x50, 0x80, 0x01, 
  0x3E, 0x80, 0x01, 0x10, 0x80, 0x01, 0x3E, 0x80, 0x01, 0xB0, 0x80, 0x01, 0x3E, 0x80, 0x01, 0xB0, 
  0x80, 0x01, 0x3E, 0x80, 0x01, 0xB0, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x30, 0x80, 0x01, 0x3F, 0x80, 
  0x01, 0x58, 0x80, 0x01, 0x3F, 0x80, 0x01, 0x58, 0x80, 0x01, 0x3F, 0x80, 0x01, 0x78, 0x80, 0x01, 
  0x3F, 0x80, 0x01, 0x08, 0x80, 0x01, 0x3E, 0x80, 0x01, 0xAC, 0x80, 0x01, 0x3E, 0x80, 0x01, 0xAC, 
  0x80, 0x01, 0x3E, 0x80, 0x01, 0xAC, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x04, 0x80, 0x01, 0x1F, 0x80, 
  0x01, 0x58, 0x80, 0x01, 0x1F, 0x80, 0x01, 0x58, 0x80, 0x01, 0x1F, 0x80, 0x01, 0x58, 0x80, 0x01, 
  0x1E, 0x80, 0x01, 0x08, 0x80, 0x01, 0x0E, 0x80, 0x01, 0xB8, 0x80, 0x01, 0x0E, 0x80, 0x01, 0xB8, 
  0x80, 0x01, 0x0E, 0x80, 0x01, 0xB8, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x18, 0x80, 0x01, 0x0F, 0x80, 
  0x01, 0x58, 0x80, 0x01, 0x0F, 0x80, 0x01, 0x58, 0x80, 0x01, 0x0F, 0x80, 0x01, 0x58, 0x80, 0x01, 
  0x0E, 0x80, 0x01, 0x08, 0x80, 0x01, 0x06, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x06, 0x80, 0x01, 0xF0, 
  0x80, 0x01, 0x06, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x04, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x0F, 0x80, 
  0x01, 0x60, 0x80, 0x01, 0x0F, 0x80, 0x01, 0x60, 0x80, 0x01, 0x0F, 0x80, 0x01, 0x60, 0x80, 0x01, 
  0x0E, 0x80, 0x01, 0x20, 0x80, 0x01, 0x1F, 0x80, 0x01, 0xB8, 0x80, 0x01, 0x19, 0x80, 0x01, 0xB8, 
  0x80, 0x01, 0x19, 0x80, 0x01, 0xB8, 0x80, 0x01, 0x19, 0x80, 0x01, 0x38, 0x80, 0x01, 0x3F, 0x80, 
  0x01, 0xFC, 0x80, 0x01, 0x24, 0x80, 0x01, 0xD4, 0x80, 0x01, 0x24, 0x80, 0x01, 0xD4, 0x80, 0x01, 
  0x24, 0x80, 0x01, 0xD4, 0x80, 0x01, 0x1F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x03, 0x80, 0x01, 0x30, 
  0x80, 0x01, 0x03, 0x80, 0x01, 0x30, 0x80, 0x01, 0x03, 0x80, 0x01, 0x30, 
}; /* user */

