LOCAL UBYTE calcn4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x79, 0x80, 0x03, 0x8F, 0xFF, 0xF8, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x00, 0x07, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF6, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x79, 0x80, 0x03, 0x90, 0x00, 0x04, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB1, 0xFF, 0xCF, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF6, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x79, 0x80, 0x03, 0x97, 0xFF, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB1, 0x00, 0x07, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0x00, 0x76, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBF, 0x00, 0x7E, 0x80, 0x01, 
  0x79, 0x80, 0x03, 0x97, 0x00, 0x34, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB1, 0x00, 0x0F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF6, 0x80, 0x01, 0x59, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x59, 0x80, 0x03, 0x97, 0x00, 0x3C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x00, 0x07, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF6, 0x80, 0x01, 0x19, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x19, 0x80, 0x03, 0x97, 0xFF, 0xF4, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x92, 0x4F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBE, 0xDB, 0x76, 0x80, 0x01, 0x19, 0x80, 0x03, 0xBE, 0xDB, 0x7E, 0x80, 0x01, 
  0x19, 0x80, 0x03, 0x96, 0xDB, 0x7C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB1, 0xB6, 0xC7, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF6, 0x80, 0x01, 0x19, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x19, 0x80, 0x03, 0x97, 0xFF, 0xF4, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x00, 0x0F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF6, 0x80, 0x01, 0x19, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 
  0x19, 0x80, 0x03, 0x97, 0xFF, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x92, 0x47, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBE, 0xDB, 0x76, 0x80, 0x01, 0x99, 0x80, 0x03, 0xBE, 0xDB, 0x7E, 0x80, 0x01, 
  0x99, 0x80, 0x03, 0x96, 0xDB, 0x74, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB1, 0xB6, 0xCF, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF7, 0x80, 0x01, 0x99, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0x99, 
  0x80, 0x03, 0x97, 0xFF, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x00, 0x07, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xFF, 0xF7, 0x80, 0x01, 0x99, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0x99, 0x80, 
  0x03, 0x97, 0xFF, 0xF4, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x90, 0xCF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBE, 0xD8, 0xF7, 0x80, 0x01, 0x99, 0x80, 0x03, 0xBE, 0xD8, 0xFF, 0x80, 0x01, 0x99, 0x80, 
  0x03, 0x96, 0xD8, 0x7C, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB1, 0xB7, 0xC7, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xFF, 0xF6, 0x80, 0x01, 0x01, 0x80, 0x03, 0xBF, 0xFF, 0xFE, 0x80, 0x01, 0x01, 0x80, 
  0x03, 0x97, 0xFF, 0xF4, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB0, 0x00, 0x0F, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xFF, 0xF7, 0x80, 0x01, 0x09, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0x09, 0x80, 0x03, 
  0x97, 0xFF, 0xFC, 0x80, 0x01, 0x07, 0x80, 0x03, 0xB5, 0x55, 0x57, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xB0, 0x00, 0x07, 0x80, 0x01, 0x99, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0x99, 0x80, 0x03, 0x95, 
  0x55, 0x54, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x8F, 0xFF, 0xF8, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* calcn4 */

