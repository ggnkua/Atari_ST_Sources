LOCAL UBYTE basen1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x81, 0xFF, 0xF0, 0x01, 0x80, 0x04, 
  0x81, 0x00, 0x18, 0x01, 0x80, 0x04, 0x81, 0x00, 0x14, 0x01, 0x80, 0x04, 0x81, 0xFE, 0x12, 0x01, 
  0x80, 0x04, 0x86, 0x01, 0x91, 0x01, 0x80, 0x04, 0x88, 0x00, 0x5F, 0x81, 0x80, 0x04, 0x8E, 0x01, 
  0xC0, 0x81, 0x80, 0x04, 0x89, 0xFE, 0x40, 0x81, 0x80, 0x04, 0x88, 0x00, 0x40, 0x81, 0x80, 0x04, 
  0x8B, 0x9C, 0x40, 0x81, 0x80, 0x04, 0x8A, 0x52, 0x40, 0x81, 0x80, 0x04, 0x8A, 0x5C, 0x40, 0x81, 
  0x80, 0x04, 0x8A, 0x52, 0x40, 0x81, 0x80, 0x04, 0x8B, 0x9C, 0x40, 0x81, 0x80, 0x04, 0x88, 0x00, 
  0x40, 0x81, 0x80, 0x04, 0x86, 0x01, 0x80, 0x81, 0x80, 0x04, 0x81, 0xFE, 0x00, 0x81, 0x80, 0x04, 
  0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0x00, 0x00, 0x81, 0x80, 0x04, 0x81, 0xFF, 0xFF, 0x81, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* basen1 */

