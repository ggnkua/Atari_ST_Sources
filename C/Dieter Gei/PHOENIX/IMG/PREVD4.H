LOCAL UBYTE prevd4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF9, 0xF3, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF9, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF9, 0xF3, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x04, 0x08, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF5, 0xEB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF5, 0xEB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF5, 0xEB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x08, 0x10, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xED, 0xDB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xED, 0xDB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xED, 0xDB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x20, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xDD, 0xBB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDD, 0xBB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDD, 0xBB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x40, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xBD, 0x7B, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xBD, 0x7B, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xBD, 0x7B, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x40, 0x80, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xDD, 0xBB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDD, 0xBB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xDD, 0xBB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x20, 0x40, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xED, 0xDB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xED, 0xDB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xED, 0xDB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x10, 0x20, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF5, 0xEB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF5, 0xEB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF5, 0xEB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x08, 0x10, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xF9, 0xF3, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF9, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF9, 0xF3, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0x80, 0x04, 0x08, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 
  0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x00
}; /* prevd4 */

