LOCAL UBYTE fieldc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xAB, 0x82, 0x80, 0x01, 0xEB, 0x80, 0x01, 0xA8, 0x02, 0x80, 0x01, 0x2B, 0x80, 
  0x01, 0xA8, 0x02, 0x80, 0x01, 0x2B, 0x80, 0x01, 0x83, 0x82, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xD7, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x15, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x15, 0x80, 0x01, 0x82, 0x02, 0x80, 0x01, 0x41, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0xAB, 0x80, 
  0x01, 0xEB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 
  0x01, 0x41, 0x80, 0x03, 0xD7, 0x55, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x54, 
  0x80, 0x01, 0x54, 0x80, 0x01, 0x15, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x54, 0x80, 0x01, 0x54, 0x80, 
  0x01, 0x15, 0x80, 0x03, 0x82, 0x01, 0x81, 0x80, 0x01, 0x41, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xEB, 0x80, 0x03, 0xA8, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xA8, 0xAA, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x82, 0x01, 0x81, 0x80, 0x01, 0x41, 0x80, 0x03, 
  0xD7, 0x55, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x54, 0x80, 0x01, 0x54, 0x80, 
  0x01, 0x15, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x54, 0x80, 0x01, 0x54, 0x80, 0x01, 0x15, 0x80, 0x03, 
  0x82, 0x01, 0x81, 0x80, 0x01, 0x41, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xFB, 0x80, 0x01, 0xFB, 0x80, 
  0x01, 0xEB, 0x80, 0x03, 0xA8, 0x82, 0x0A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA8, 0x82, 0x0A, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x82, 0x79, 0xF1, 0x80, 0x01, 0x41, 0x80, 0x01, 0xD7, 0x80, 0x01, 0xDD, 
  0x80, 0x01, 0xDD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x10, 0x44, 0x80, 0x01, 0x15, 0x80, 0x03, 
  0xD5, 0x10, 0x44, 0x80, 0x01, 0x15, 0x80, 0x03, 0x82, 0xCD, 0x99, 0x80, 0x01, 0x41, 0x80, 0x03, 
  0xAA, 0xBF, 0xBB, 0x80, 0x01, 0xEB, 0x80, 0x03, 0xA8, 0x82, 0x22, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xA8, 0x82, 0x22, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x82, 0x3D, 0x99, 0x80, 0x01, 0x41, 0x80, 0x03, 
  0xD7, 0x7D, 0xDD, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x10, 0x44, 0x80, 0x01, 0x15, 0x80, 0x03, 
  0xD5, 0x10, 0x44, 0x80, 0x01, 0x15, 0x80, 0x03, 0x82, 0x6D, 0x99, 0x80, 0x01, 0x41, 0x80, 0x03, 
  0xAA, 0xEF, 0xBB, 0x80, 0x01, 0xEB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0x22, 0x80, 0x01, 0x22, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0x22, 0x80, 0x01, 0x22, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x82, 0xCD, 0x99, 0x80, 0x01, 0x41, 0x80, 0x01, 0xD7, 0x80, 0x01, 0xDD, 0x80, 0x01, 0xDD, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0xD5, 0x10, 0x44, 0x80, 0x01, 0x15, 0x80, 0x03, 0xD5, 0x10, 0x44, 0x80, 
  0x01, 0x15, 0x80, 0x03, 0x82, 0xCD, 0x99, 0x80, 0x01, 0x41, 0x80, 0x03, 0xAA, 0xFF, 0xFB, 0x80, 
  0x01, 0xEB, 0x80, 0x03, 0xA8, 0x82, 0x0A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xA8, 0x82, 0x0A, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x82, 0x7D, 0xF1, 0x80, 0x01, 0x41, 0x80, 0x01, 0xD7, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x54, 0x80, 0x01, 0x15, 0x80, 0x03, 
  0xD5, 0x55, 0x54, 0x80, 0x01, 0x15, 0x80, 0x03, 0x82, 0x00, 0x01, 0x80, 0x01, 0x41, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xEB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xA8, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0x82, 0x02, 0x80, 0x01, 0x41, 0x80, 0x01, 0xD7, 0x82, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0xD4, 0x02, 0x80, 0x01, 0x15, 0x80, 0x01, 0xD4, 0x02, 0x80, 0x01, 0x15, 0x80, 0x01, 
  0x83, 0x82, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 
  0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* fieldc4 */

