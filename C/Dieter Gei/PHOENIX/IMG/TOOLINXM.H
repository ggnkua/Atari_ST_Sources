LOCAL UBYTE toolinxm [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x10, 0x00, 0x10, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 
  0x80, 0x02, 0x00, 0x1C, 0x80, 0x02, 0x00, 0x3E, 0x80, 0x02, 0x3F, 0xFF, 0x80, 0x02, 0x7F, 0xF7, 
  0x80, 0x02, 0x3F, 0xFF, 0x80, 0x02, 0x15, 0x3E, 0x80, 0x02, 0x00, 0x1C, 0x80, 0x02, 0x00, 0x00, 
  0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 0x80, 0x02, 0x00, 0x00, 
}; /* toolinxm */

