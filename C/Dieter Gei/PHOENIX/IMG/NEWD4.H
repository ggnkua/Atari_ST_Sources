LOCAL UBYTE newd4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x03, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xFD, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xFD, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xFD, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x03, 0x80, 0x03, 0xBE, 0x00, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0x1F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0xFF, 0xE0, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x00, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0x0F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0x00, 0x0F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x30, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xC7, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x28, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xCB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xCB, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xCB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x24, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xCD, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xCD, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBE, 0x7F, 0xCD, 0x80, 0x01, 0xF9, 0x80, 0x03, 0x81, 0x00, 0x22, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xC0, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xC0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x3F, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xE0, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xE0, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xE0, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 
  0x01, 0x79, 0x80, 0x03, 0xBE, 0x7F, 0xFE, 0x80, 0x01, 0x79, 0x80, 0x03, 0x81, 0x00, 0x01, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBE, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0xBE, 0x02, 0x80, 0x01, 0x79, 
  0x80, 0x01, 0xBE, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0x81, 0x82, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0xBF, 0x02, 0x80, 0x01, 0x79, 0x80, 0x01, 0xBF, 0x02, 
  0x80, 0x01, 0x79, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xA0, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xA0, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xA0, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x9F, 0x83, 0x80, 
  0x01, 0xC0, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xC0, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xC0, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xBF, 0x83, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 
  0x01, 0xFE, 
}; /* newd4 */

