LOCAL UBYTE nextn1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x20, 0x00, 0x1C, 
  0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x20, 0x40, 0x01, 0x80, 0x04, 0x80, 0x30, 0x60, 0x01, 0x80, 0x04, 0x80, 0x38, 
  0x70, 0x01, 0x80, 0x04, 0x80, 0x3C, 0x78, 0x01, 0x80, 0x04, 0x80, 0x3E, 0x7C, 0x01, 0x80, 0x04, 
  0x80, 0x3F, 0x7E, 0x01, 0x80, 0x04, 0x80, 0x3E, 0x7C, 0x01, 0x80, 0x04, 0x80, 0x3C, 0x78, 0x01, 
  0x80, 0x04, 0x80, 0x38, 0x70, 0x01, 0x80, 0x04, 0x80, 0x30, 0x60, 0x01, 0x80, 0x04, 0x80, 0x20, 
  0x40, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 
  0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 
  0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 0x00, 0x01, 0x80, 0x04, 0x80, 0x00, 
  0x00, 0x01, 0x80, 0x04, 0x7F, 0xFF, 0xFF, 0xFE, 
}; /* nextn1 */

