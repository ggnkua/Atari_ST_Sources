LOCAL UBYTE toolmul [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x00, 0x80, 0x01, 0x1C, 0x80, 0x01, 0x00, 0x80, 0x01, 0x1C, 
  0x80, 0x01, 0x00, 0x80, 0x01, 0x1C, 0x80, 0x01, 0x00, 0x80, 0x01, 0x1C, 0x80, 0x01, 0x00, 0x80, 
  0x01, 0x3E, 0x80, 0x01, 0x00, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x00, 0x80, 0x01, 0x22, 0x80, 0x01, 
  0x00, 0x80, 0x01, 0x22, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFF, 
  0x80, 0x01, 0x3F, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFF, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0x40, 0x80, 0x01, 0x09, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x09, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFF, 
  0x80, 0x01, 0x2A, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x2A, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x15, 0x80, 
  0x01, 0x3E, 0x80, 0x01, 0x15, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x15, 0x80, 0x01, 0x22, 0x80, 0x01, 
  0x15, 0x80, 0x01, 0x22, 0x80, 0x01, 0x00, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x00, 0x80, 0x01, 0x3C, 
  0x80, 0x01, 0x00, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x00, 0x80, 0x01, 0x3C, 0x80, 0x01, 0x00, 0x80, 
  0x01, 0x7C, 0x80, 0x01, 0x00, 0x80, 0x01, 0x7C, 0x80, 0x01, 0x00, 0x80, 0x01, 0x44, 0x80, 0x01, 
  0x00, 0x80, 0x01, 0x44, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 
  0x80, 0x01, 0x7F, 0x80, 0x01, 0x82, 0x80, 0x01, 0x7F, 0x80, 0x01, 0x82, 0x80, 0x01, 0xFF, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x80, 0x01, 0x12, 0x80, 0x01, 
  0x80, 0x80, 0x01, 0x12, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x82, 0x80, 0x01, 0x55, 0x80, 0x01, 0x82, 0x80, 0x01, 0x2A, 0x80, 
  0x01, 0x7C, 0x80, 0x01, 0x2A, 0x80, 0x01, 0x7C, 0x80, 0x01, 0x2A, 0x80, 0x01, 0x44, 0x80, 0x01, 
  0x2A, 0x80, 0x01, 0x44, 0x80, 0x01, 0x00, 0x80, 0x01, 0x38, 0x80, 0x01, 0x00, 0x80, 0x01, 0x38, 
  0x80, 0x01, 0x00, 0x80, 0x01, 0x38, 0x80, 0x01, 0x00, 0x80, 0x01, 0x38, 0x02, 0x02, 0x02, 0x02, 
  0x02, 0x02, 0x02, 0x02, 
}; /* toolmul */

