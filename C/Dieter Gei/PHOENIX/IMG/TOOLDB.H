LOCAL UBYTE tooldb [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x10, 0x00, 0x10, 
  0x02, 0x02, 0x02, 0x02, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xF0, 
  0x80, 0x01, 0x0F, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x3F, 0x80, 
  0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x30, 0x80, 0x01, 0x0C, 0x80, 0x01, 
  0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 
  0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x70, 0x80, 0x01, 0x0E, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x70, 0x80, 0x01, 0x0E, 0x80, 0x01, 
  0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 
  0x80, 0x01, 0x4F, 0x80, 0x01, 0xF2, 0x80, 0x01, 0x4F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x63, 0x80, 0x01, 0x1E, 
  0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x5C, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x6D, 0x80, 0x01, 0x6E, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 
  0x52, 0x80, 0x01, 0xBE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x6D, 0x80, 0x01, 0x1E, 
  0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x52, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x6D, 0x80, 0x01, 0x6E, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 
  0x52, 0x80, 0x01, 0xBE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x63, 0x80, 0x01, 0x1E, 
  0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 0x5C, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 
  0x01, 0xFE, 0x80, 0x01, 0x7F, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x40, 0x80, 0x01, 0x02, 0x80, 0x01, 
  0x40, 0x80, 0x01, 0x3E, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 0x80, 0x01, 0x3F, 0x80, 0x01, 0xFC, 
  0x80, 0x01, 0x30, 0x80, 0x01, 0x0C, 0x80, 0x01, 0x30, 0x80, 0x01, 0x7C, 0x80, 0x01, 0x0F, 0x80, 
  0x01, 0xF0, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xF0, 0x80, 0x01, 0x0F, 0x80, 0x01, 0xF0, 0x80, 0x01, 
  0x0F, 0x80, 0x01, 0xF0, 0x02, 0x02, 0x02, 0x02, 
}; /* tooldb */

