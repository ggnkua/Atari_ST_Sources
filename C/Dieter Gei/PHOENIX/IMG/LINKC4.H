LOCAL UBYTE linkc4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x03, 0xAA, 0xA2, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x08, 0x00, 0x80, 0x01, 0x01, 
  0x80, 0x02, 0xD5, 0x5D, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x45, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x45, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0x80, 0x18, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBA, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0xAA, 0x82, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x82, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x03, 
  0x80, 0x38, 0x00, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x7F, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x02, 
  0xD5, 0x00, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x02, 0xD5, 0x00, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x7F, 0x80, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xFF, 0xEA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0xAA, 0x00, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x00, 0x2A, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0xFF, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x7F, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0xD5, 0x00, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x00, 0x15, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x7F, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xBB, 0xEA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0xAA, 0x82, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0x82, 0x2A, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0x39, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x5D, 0xD5, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0xD5, 0x44, 0x15, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x44, 0x15, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x19, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xAB, 0xEA, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0x2A, 0x80, 0x01, 0xAB, 0x80, 0x03, 0xAA, 0xA2, 0x2A, 0x80, 
  0x01, 0xAB, 0x80, 0x03, 0x80, 0x09, 0xC0, 0x80, 0x01, 0x01, 0x80, 0x03, 0xD5, 0x55, 0xFF, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x54, 0x01, 0x80, 
  0x01, 0x55, 0x80, 0x03, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x01, 0x80, 0x03, 0xAA, 0xAB, 0xFE, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x02, 0xAA, 0x00, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x02, 0xAA, 0x00, 0x80, 0x01, 0xAB, 0x80, 0x03, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x01, 0x80, 0x03, 
  0xD5, 0x55, 0xFF, 0x80, 0x01, 0x55, 0x80, 0x03, 0xD5, 0x55, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 
  0xD5, 0x55, 0x01, 0x80, 0x01, 0x55, 0x80, 0x03, 0x80, 0x00, 0xFE, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 
  0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0xAA, 0x80, 0x01, 0xAA, 0x80, 0x01, 
  0xAA, 0x80, 0x01, 0xAB, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0xD5, 0x80, 0x01, 
  0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 
  0x80, 0x01, 0x55, 0x80, 0x01, 0xD5, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 0x01, 0x55, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 
}; /* linkc4 */

