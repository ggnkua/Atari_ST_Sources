LOCAL UBYTE drives1 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x00, 0xD4, 0x00, 0xB0, 0x00, 0x80, 0x00, 0x10, 
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x80, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x30, 0x80, 0x10, 0x20, 0x80, 0x20, 0x80, 0x41, 0x00, 0x00, 0x00, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x88, 0x80, 0x10, 0x40, 0x7E, 0x4A, 0x7E, 0x80, 0xFC, 0x3F, 0xFE, 
  0x3F, 0xFE, 0x3F, 0xFE, 0xF8, 0xFF, 0x02, 0x04, 0x80, 0x10, 0x40, 0x03, 0x55, 0x03, 0x80, 0x06, 
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x05, 0x00, 0x08, 0x02, 0x80, 0x10, 0x40, 0x03, 0x4A, 0xAB, 
  0x80, 0x06, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xF2, 0x7F, 0x20, 0x03, 0x80, 0x10, 0xFF, 0xFB, 
  0xFF, 0xFF, 0x80, 0x06, 0x87, 0x97, 0x80, 0x17, 0xBF, 0xF7, 0x08, 0x80, 0x80, 0x0F, 0x80, 0x10, 
  0x80, 0x1B, 0x80, 0x1B, 0x80, 0x06, 0xBF, 0xF7, 0x80, 0x07, 0xB9, 0x77, 0x05, 0x00, 0x80, 0x3F, 
  0x80, 0x10, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x06, 0x87, 0x87, 0xBF, 0xF7, 0x88, 0x47, 0x1F, 0xC0, 
  0x80, 0xFE, 0x80, 0x10, 0x40, 0x0F, 0x40, 0x0F, 0x80, 0x06, 0x80, 0x07, 0x80, 0x07, 0x87, 0x97, 
  0x10, 0x40, 0x63, 0xFA, 0x80, 0x10, 0x40, 0x07, 0x40, 0x07, 0x80, 0x06, 0xFF, 0xFE, 0xFF, 0xFE, 
  0xFF, 0xFE, 0x1F, 0xC0, 0x37, 0xEA, 0x80, 0x10, 0x20, 0x07, 0x20, 0x07, 0x80, 0x06, 0x7F, 0xFC, 
  0x7F, 0xFC, 0x7F, 0xFC, 0x05, 0x00, 0x17, 0xA8, 0x80, 0x10, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xA0, 0x80, 0x10, 0x1F, 0xFF, 0x1F, 0xFF, 
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x80, 0x80, 0x10, 0x00, 0x00, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x80, 0x10, 
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
}; /* drives1 */

