LOCAL UBYTE deleten4 [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x01, 0x74, 0x01, 0x74, 0x00, 0x20, 0x00, 0x1C, 
  0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 0x01, 0xFE, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x03, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 
  0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 
  0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xDF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x1F, 0xE3, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0x1F, 0xE3, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x07, 0x80, 0x01, 0xBF, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0x07, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x07, 0xC7, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 
  0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFB, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x83, 
  0x8F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x83, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 
  0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 0xFD, 0xBF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE1, 0x3F, 
  0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE1, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 
  0x01, 0x07, 0x80, 0x03, 0xBF, 0xFF, 0xBF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x3F, 0x80, 
  0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x07, 0x80, 0x03, 0xBF, 0xFF, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x7F, 0x80, 0x01, 
  0xF9, 0x80, 0x03, 0xBF, 0xF8, 0x7F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 
  0x80, 0x03, 0xBF, 0xFF, 0xBF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xF0, 0x3F, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0xF0, 0x3F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBF, 0xFD, 0xDF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xE1, 0x1F, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xE1, 0x1F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xFB, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xC3, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xC3, 0x8F, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 0xBF, 
  0xF7, 0xEF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x87, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 
  0x87, 0xCF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x80, 
  0x01, 0xF7, 0x80, 0x01, 0xF7, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0x87, 0xE7, 0x80, 0x01, 0xF9, 
  0x80, 0x03, 0xBF, 0x87, 0xE7, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 
  0x03, 0xBF, 0xEF, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xCF, 0xFF, 0x80, 0x01, 0xF9, 0x80, 
  0x03, 0xBF, 0xCF, 0xFF, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x03, 
  0xBF, 0xFF, 0xFB, 0x80, 0x01, 0xF9, 0x80, 0x03, 0xBF, 0xFF, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x03, 
  0xBF, 0xFF, 0xF3, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 
  0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 
  0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 
  0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 
  0x07, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 
  0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0xBF, 
  0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 0x01, 0xF9, 0x80, 0x01, 0xBF, 0x82, 0x80, 
  0x01, 0xF9, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x07, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 
  0xBF, 0x83, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 
  0x80, 0x01, 0x80, 0x02, 0x80, 0x01, 0x01, 0x84, 0x84, 0x84, 0x84, 0x80, 0x01, 0x7F, 0x82, 0x80, 
  0x01, 0xFE, 
}; /* deleten4 */

