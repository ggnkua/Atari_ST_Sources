/*****************************************************************************/
/*                                                                           */
/* Modul: MSELSIZE.H                                                         */
/* Datum: 03/08/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MSELSIZE__
#define __MSELSIZE__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mselsize _((LONG *size_x, LONG *size_y));

#endif /* __MSELSIZE__ */

