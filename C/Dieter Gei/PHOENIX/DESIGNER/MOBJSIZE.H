/*****************************************************************************/
/*                                                                           */
/* Modul: MOBJSIZE.H                                                         */
/* Datum: 15/10/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MOBJSIZE__
#define __MOBJSIZE__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mobjsize  _((WINDOWP mask_window, WORD obj));
GLOBAL VOID mpicsize  _((WINDOWP mask_window, WORD obj));
GLOBAL VOID mlinesize _((WINDOWP mask_window, WORD obj));

#endif /* __MOBJSIZE__ */

