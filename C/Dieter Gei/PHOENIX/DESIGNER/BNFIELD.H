/*****************************************************************************/
/*                                                                           */
/* Modul: BNFIELD.H                                                          */
/* Datum: 10/04/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BNFIELD__
#define __BNFIELD__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL WORD mnewfield _((WINDOWP base_window, WORD table, SYSCOLUMN *colp, SYSINDEX *inxp, WORD *ret_field));

#endif /* __BNFIELD__ */

