/*****************************************************************************/
/*                                                                           */
/* Modul: BTXT.H                                                             */
/* Datum: 14/08/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BTXT__
#define __BTXT__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mdescription _((BASE_SPEC *base_spec));

#endif /* __BTXT__ */

