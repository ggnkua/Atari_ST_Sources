/*****************************************************************************
 *
 * Module : BTBLINFO.H
 * Author : J�rgen Geiž
 *
 * Creation date    : 01.07.89
 * Last modification: 13.10.93
 *
 *
 * Description: This module implements the table info dialog box.
 *
 * History:
 * 13.10.93: set_tblinfo moved to BTBLINFO.C
 * 01.07.89: Creation of body
 *****************************************************************************/

#ifndef __BTBLINFO__
#define __BTBLINFO__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID btblinfo _((BASE_SPEC *base_spec, WORD table));

#endif /* __BTBLINFO__ */

