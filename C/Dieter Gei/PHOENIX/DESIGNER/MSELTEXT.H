/*****************************************************************************/
/*                                                                           */
/* Modul: MSELTEXT.H                                                         */
/* Datum: 07/08/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MSELTEXT__
#define __MSELTEXT__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL WORD mseltext _((WINDOWP mask_window, WORD obj));

#endif /* __MSELTEXT__ */

