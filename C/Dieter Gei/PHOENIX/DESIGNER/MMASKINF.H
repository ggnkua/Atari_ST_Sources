/*****************************************************************************/
/*                                                                           */
/* Modul: MMASKINF.H                                                         */
/* Datum: 13/11/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MMASKINF__
#define __MMASKINF__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN mmaskinfo _((MASK_SPEC *mask_spec));

#endif /* __MMASKINF__ */

