/* Resource Datei Indizes f�r DESIGNER */

#define MENU     0   /* Menuebaum */
#define MDESK    3   /* TITLE in Baum MENU */
#define MFILE    4   /* TITLE in Baum MENU */
#define MEDIT    5   /* TITLE in Baum MENU */
#define MOPTIONS 6   /* TITLE in Baum MENU */
#define MHELP    7   /* TITLE in Baum MENU */
#define MABOUT   10  /* STRING in Baum MENU */
#define MNEW     19  /* STRING in Baum MENU */
#define MOPEN    20  /* STRING in Baum MENU */
#define MCLOSE   22  /* STRING in Baum MENU */
#define MSAVE    23  /* STRING in Baum MENU */
#define MSAVEAS  24  /* STRING in Baum MENU */
#define MABORT   25  /* STRING in Baum MENU */
#define MEXPORT  27  /* STRING in Baum MENU */
#define MIMPORT  28  /* STRING in Baum MENU */
#define MASCEXP  29  /* STRING in Baum MENU */
#define MPRINT   31  /* STRING in Baum MENU */
#define MQUIT    33  /* STRING in Baum MENU */
#define MUNDO    35  /* STRING in Baum MENU */
#define MCUT     37  /* STRING in Baum MENU */
#define MCOPY    38  /* STRING in Baum MENU */
#define MPASTE   39  /* STRING in Baum MENU */
#define MCLEAR   40  /* STRING in Baum MENU */
#define MSELALL  41  /* STRING in Baum MENU */
#define MCYCLEWI 43  /* STRING in Baum MENU */
#define MTOCLIP  45  /* STRING in Baum MENU */
#define MCONFIG  47  /* STRING in Baum MENU */
#define MPARAMS  48  /* STRING in Baum MENU */
#define MLOADCFG 49  /* STRING in Baum MENU */
#define MSAVECFG 50  /* STRING in Baum MENU */
#define MUSERINT 52  /* STRING in Baum MENU */
#define MHELPCXT 54  /* STRING in Baum MENU */
#define MHELPINX 55  /* STRING in Baum MENU */
#define MHELPCON 56  /* STRING in Baum MENU */
#define MHELPOBJ 57  /* STRING in Baum MENU */
#define MINFO    59  /* STRING in Baum MENU */

#define ABOUT    1   /* Formular/Dialog */
#define ALOGO    1   /* BOX in Baum ABOUT */
#define ASERIAL  4   /* TEXT in Baum ABOUT */
#define ACOMPANY 7   /* TEXT in Baum ABOUT */
#define ANAME    9   /* TEXT in Baum ABOUT */
#define AOK      10  /* BUTTON in Baum ABOUT */
#define AINFO    11  /* BUTTON in Baum ABOUT */

#define MOREINFO 2   /* Formular/Dialog */

#define DESKTOP  3   /* Formular/Dialog */
#define ITRASH   1   /* USERDEF in Baum DESKTOP */
#define ICLIPBRD 2   /* USERDEF in Baum DESKTOP */
#define FKEYS    3   /* IBOX in Baum DESKTOP */
#define INFOBOX  14  /* BUTTON in Baum DESKTOP */

#define USERIMG  4   /* Formular/Dialog */
#define RBHNORM  1   /* IMAGE in Baum USERIMG */
#define RBHSEL   2   /* IMAGE in Baum USERIMG */
#define CBHNORM  3   /* IMAGE in Baum USERIMG */
#define CBHSEL   4   /* IMAGE in Baum USERIMG */
#define RBLNORM  5   /* IMAGE in Baum USERIMG */
#define RBLSEL   6   /* IMAGE in Baum USERIMG */
#define CBLNORM  7   /* IMAGE in Baum USERIMG */
#define CBLSEL   8   /* IMAGE in Baum USERIMG */
#define RB7NORM  9   /* IMAGE in Baum USERIMG */
#define RB7SEL   10  /* IMAGE in Baum USERIMG */
#define CB7NORM  11  /* IMAGE in Baum USERIMG */
#define CB7SEL   12  /* IMAGE in Baum USERIMG */
#define RB5NORM  13  /* IMAGE in Baum USERIMG */
#define RB5SEL   14  /* IMAGE in Baum USERIMG */
#define CB5NORM  15  /* IMAGE in Baum USERIMG */
#define CB5SEL   16  /* IMAGE in Baum USERIMG */
#define ARROW6   17  /* IMAGE in Baum USERIMG */
#define ARROW8   18  /* IMAGE in Baum USERIMG */
#define ARROW10  19  /* IMAGE in Baum USERIMG */
#define ARROW12  20  /* IMAGE in Baum USERIMG */
#define ARROW14  21  /* IMAGE in Baum USERIMG */
#define ARROW16  22  /* IMAGE in Baum USERIMG */
#define ARROW32  23  /* IMAGE in Baum USERIMG */

#define ALERT    5   /* Formular/Dialog */

#define SELFILE  6   /* Formular/Dialog */
#define FLNAME   2   /* FBOXTEXT in Baum SELFILE */
#define FLDIR    4   /* STRING in Baum SELFILE */
#define FLNAMES  5   /* BOX in Baum SELFILE */
#define FLDIRS   6   /* BOX in Baum SELFILE */
#define FLTYPES  8   /* BUTTON in Baum SELFILE */
#define FLDRIVES 10  /* BUTTON in Baum SELFILE */
#define FLORDER  12  /* BUTTON in Baum SELFILE */
#define FLOK     13  /* BUTTON in Baum SELFILE */
#define FLCANCEL 14  /* BUTTON in Baum SELFILE */
#define FLHELP   15  /* BUTTON in Baum SELFILE */

#define SELPATH  7   /* Formular/Dialog */
#define PTDIR    2   /* STRING in Baum SELPATH */
#define PTDIRS   3   /* BOX in Baum SELPATH */
#define PTDRIVES 5   /* BUTTON in Baum SELPATH */
#define PTORDER  7   /* BUTTON in Baum SELPATH */
#define PTOK     8   /* BUTTON in Baum SELPATH */
#define PTCANCEL 9   /* BUTTON in Baum SELPATH */
#define PTHELP   10  /* BUTTON in Baum SELPATH */

#define SELFONT  8   /* Formular/Dialog */
#define FNNAME   2   /* FBOXTEXT in Baum SELFONT */
#define FNPOINT  4   /* FBOXTEXT in Baum SELFONT */
#define FNNAMES  5   /* BOX in Baum SELFONT */
#define FNPOINTS 6   /* BOX in Baum SELFONT */
#define FNEFFECT 7   /* BUTTON in Baum SELFONT */
#define FNTHICK  8   /* BUTTON in Baum SELFONT */
#define FNLIGHT  9   /* BUTTON in Baum SELFONT */
#define FNSKEWED 10  /* BUTTON in Baum SELFONT */
#define FNUNDER  11  /* BUTTON in Baum SELFONT */
#define FNOUTLN  12  /* BUTTON in Baum SELFONT */
#define FNCLABEL 13  /* STRING in Baum SELFONT */
#define FNCOLOR  14  /* BUTTON in Baum SELFONT */
#define FNORDER  16  /* BUTTON in Baum SELFONT */
#define FNSAMPLE 18  /* IBOX in Baum SELFONT */
#define FNOK     19  /* BUTTON in Baum SELFONT */
#define FNCANCEL 20  /* BUTTON in Baum SELFONT */
#define FNHELP   21  /* BUTTON in Baum SELFONT */

#define HELPINX  9   /* Formular/Dialog */
#define HINDEX   1   /* STRING in Baum HELPINX */
#define HCONTENT 2   /* STRING in Baum HELPINX */
#define HHELP    3   /* STRING in Baum HELPINX */
#define HDESKTOP 4   /* STRING in Baum HELPINX */
#define HTRASH   5   /* STRING in Baum HELPINX */
#define HCLIPBRD 6   /* STRING in Baum HELPINX */
#define HBASE    7   /* STRING in Baum HELPINX */
#define HMASK    8   /* STRING in Baum HELPINX */
#define HCONFIG  9   /* STRING in Baum HELPINX */
#define HPARAMS  10  /* STRING in Baum HELPINX */
#define HUSERINT 11  /* STRING in Baum HELPINX */
#define HOPENDB  12  /* STRING in Baum HELPINX */
#define HDBPARAM 13  /* STRING in Baum HELPINX */
#define HDBINFO  14  /* STRING in Baum HELPINX */
#define HTBLINFO 15  /* STRING in Baum HELPINX */
#define HNEWTBL  16  /* STRING in Baum HELPINX */
#define HNEWFIEL 17  /* STRING in Baum HELPINX */
#define HNEWKEY  18  /* STRING in Baum HELPINX */
#define HDOICONS 19  /* STRING in Baum HELPINX */
#define HFORMAT  20  /* STRING in Baum HELPINX */
#define HRELRULE 21  /* STRING in Baum HELPINX */
#define HSELFONT 22  /* STRING in Baum HELPINX */
#define HSELMASK 23  /* STRING in Baum HELPINX */
#define HMASKINF 24  /* STRING in Baum HELPINX */
#define HFIELDAT 25  /* STRING in Baum HELPINX */
#define HSELFILL 26  /* STRING in Baum HELPINX */
#define HSELLINE 27  /* STRING in Baum HELPINX */
#define HSELGRID 28  /* STRING in Baum HELPINX */
#define HSELSIZE 29  /* STRING in Baum HELPINX */
#define HTEXT    30  /* STRING in Baum HELPINX */
#define HOBJSIZE 31  /* STRING in Baum HELPINX */
#define HPICSIZE 32  /* STRING in Baum HELPINX */
#define HLINESIZ 33  /* STRING in Baum HELPINX */
#define HRVALUES 34  /* STRING in Baum HELPINX */
#define HCVALUES 35  /* STRING in Baum HELPINX */
#define HSUBMASK 36  /* STRING in Baum HELPINX */
#define HBUTTON  37  /* STRING in Baum HELPINX */
#define HACCESS  38  /* STRING in Baum HELPINX */
#define HUSERINF 39  /* STRING in Baum HELPINX */
#define HSELFILE 40  /* STRING in Baum HELPINX */

#define POPUPS   10  /* Formular/Dialog */
#define COLPOPUP 1   /* BOX in Baum POPUPS */
#define COWHITE  18  /* STRING in Baum POPUPS */
#define COBLACK  19  /* STRING in Baum POPUPS */
#define CORED    20  /* STRING in Baum POPUPS */
#define COGREEN  21  /* STRING in Baum POPUPS */
#define COBLUE   22  /* STRING in Baum POPUPS */
#define COCYAN   23  /* STRING in Baum POPUPS */
#define COYELLOW 24  /* STRING in Baum POPUPS */
#define COMAGENT 25  /* STRING in Baum POPUPS */
#define COGRAY   26  /* STRING in Baum POPUPS */
#define CODGRAY  27  /* STRING in Baum POPUPS */
#define CODRED   28  /* STRING in Baum POPUPS */
#define CODGREEN 29  /* STRING in Baum POPUPS */
#define CODBLUE  30  /* STRING in Baum POPUPS */
#define CODCYAN  31  /* STRING in Baum POPUPS */
#define CODYELLO 32  /* STRING in Baum POPUPS */
#define CODMAGEN 33  /* STRING in Baum POPUPS */
#define PWIDTH   35  /* TEXT in Baum POPUPS */
#define PHEIGHT  38  /* TEXT in Baum POPUPS */

#define CONFIG   11  /* Formular/Dialog */
#define CTMPDIR  3   /* STRING in Baum CONFIG */
#define CICNDIR  5   /* STRING in Baum CONFIG */
#define CPICDIR  7   /* STRING in Baum CONFIG */
#define CEXPDIR  9   /* STRING in Baum CONFIG */
#define CDBDIR   11  /* STRING in Baum CONFIG */
#define CBLINK   14  /* FBOXTEXT in Baum CONFIG */
#define CBEEP    15  /* BUTTON in Baum CONFIG */
#define CUSEFONT 16  /* BUTTON in Baum CONFIG */
#define CGROW    17  /* BUTTON in Baum CONFIG */
#define CEXPORT  18  /* BUTTON in Baum CONFIG */
#define CAUTO    19  /* BUTTON in Baum CONFIG */
#define CFUNCS   20  /* BUTTON in Baum CONFIG */
#define CMETA    21  /* BUTTON in Baum CONFIG */
#define CUNIX    22  /* BUTTON in Baum CONFIG */
#define COK      23  /* BUTTON in Baum CONFIG */
#define CCANCEL  24  /* BUTTON in Baum CONFIG */
#define CHELP    25  /* BUTTON in Baum CONFIG */

#define PARAMS   12  /* Formular/Dialog */
#define PTABLES  3   /* FBOXTEXT in Baum PARAMS */
#define PFIELDS  5   /* FBOXTEXT in Baum PARAMS */
#define PKEYS    7   /* FBOXTEXT in Baum PARAMS */
#define PRELS    9   /* FBOXTEXT in Baum PARAMS */
#define PUSERS   11  /* FBOXTEXT in Baum PARAMS */
#define PICONS   13  /* FBOXTEXT in Baum PARAMS */
#define PFORMATS 15  /* FBOXTEXT in Baum PARAMS */
#define PLOOKUPS 17  /* FBOXTEXT in Baum PARAMS */
#define PMASKS   19  /* FBOXTEXT in Baum PARAMS */
#define PDTXT    20  /* STRING in Baum PARAMS */
#define PDUSAGE  21  /* STRING in Baum PARAMS */
#define PDOCW    24  /* FBOXTEXT in Baum PARAMS */
#define PDOCH    27  /* FBOXTEXT in Baum PARAMS */
#define PPICS    31  /* FBOXTEXT in Baum PARAMS */
#define PMTXT    32  /* STRING in Baum PARAMS */
#define PMUSAGE  33  /* STRING in Baum PARAMS */
#define PDOCFONT 36  /* STRING in Baum PARAMS */
#define PWINW    38  /* FBOXTEXT in Baum PARAMS */
#define PDOCPOIN 40  /* STRING in Baum PARAMS */
#define PWINH    42  /* FBOXTEXT in Baum PARAMS */
#define POK      43  /* BUTTON in Baum PARAMS */
#define PCANCEL  44  /* BUTTON in Baum PARAMS */
#define PHELP    45  /* BUTTON in Baum PARAMS */
#define PFONT    46  /* BUTTON in Baum PARAMS */

#define USERINTR 13  /* Formular/Dialog */
#define UISYSINX 3   /* BUTTON in Baum USERINTR */
#define UISYSCOL 5   /* BUTTON in Baum USERINTR */
#define UIUSE3D  7   /* BUTTON in Baum USERINTR */
#define UIROUND  8   /* BUTTON in Baum USERINTR */
#define UISTDFS  9   /* BUTTON in Baum USERINTR */
#define UICOLOR  12  /* BUTTON in Baum USERINTR */
#define UIPAT    14  /* BUTTON in Baum USERINTR */
#define UIUSEWND 15  /* BUTTON in Baum USERINTR */
#define UITOP    16  /* BUTTON in Baum USERINTR */
#define UISB     17  /* BUTTON in Baum USERINTR */
#define UICHECK  20  /* BUTTON in Baum USERINTR */
#define UIRADIO  22  /* BUTTON in Baum USERINTR */
#define UIARROW  24  /* BUTTON in Baum USERINTR */
#define UIROUNDB 26  /* BUTTON in Baum USERINTR */
#define UISHADOW 28  /* FBOXTEXT in Baum USERINTR */
#define UIOK     29  /* BUTTON in Baum USERINTR */
#define UICANCEL 30  /* BUTTON in Baum USERINTR */
#define UIRESET  31  /* BUTTON in Baum USERINTR */
#define UIHELP   32  /* BUTTON in Baum USERINTR */

#define OPENDB   14  /* Formular/Dialog */
#define BBASE    2   /* STRING in Baum OPENDB */
#define BUSER    4   /* FBOXTEXT in Baum OPENDB */
#define BPASS    6   /* FBOXTEXT in Baum OPENDB */
#define BINDCACH 9   /* FBOXTEXT in Baum OPENDB */
#define BDATCACH 12  /* FBOXTEXT in Baum OPENDB */
#define BINDFLSH 14  /* BUTTON in Baum OPENDB */
#define BDATFLSH 15  /* BUTTON in Baum OPENDB */
#define BSINGLE  17  /* BUTTON in Baum OPENDB */
#define BMULTI   18  /* BUTTON in Baum OPENDB */
#define BRDONLY  19  /* BUTTON in Baum OPENDB */
#define BOK      20  /* BUTTON in Baum OPENDB */
#define BCANCEL  21  /* BUTTON in Baum OPENDB */
#define BHELP    22  /* BUTTON in Baum OPENDB */

#define BASEMENU 15  /* Menuebaum */
#define MBINFO   3   /* TITLE in Baum BASEMENU */
#define MBVIEW   4   /* TITLE in Baum BASEMENU */
#define MBOPTION 5   /* TITLE in Baum BASEMENU */
#define MBPARAM  6   /* TITLE in Baum BASEMENU */
#define MBBASEIN 9   /* STRING in Baum BASEMENU */
#define MBFULL   11  /* STRING in Baum BASEMENU */
#define MBBESTFI 12  /* STRING in Baum BASEMENU */
#define MBRELS   14  /* STRING in Baum BASEMENU */
#define MBLOOKUP 15  /* STRING in Baum BASEMENU */
#define MBSHORT  17  /* STRING in Baum BASEMENU */
#define MBLONG   18  /* STRING in Baum BASEMENU */
#define MBTOOLS  20  /* STRING in Baum BASEMENU */
#define MBTABLE  22  /* STRING in Baum BASEMENU */
#define MBFIELD  23  /* STRING in Baum BASEMENU */
#define MBKEY    24  /* STRING in Baum BASEMENU */
#define MBMASK   26  /* STRING in Baum BASEMENU */
#define MBFORMAT 27  /* STRING in Baum BASEMENU */
#define MBICONS  28  /* STRING in Baum BASEMENU */
#define MBDELRUL 30  /* STRING in Baum BASEMENU */
#define MBFONT   32  /* STRING in Baum BASEMENU */
#define MBSIZE   33  /* STRING in Baum BASEMENU */
#define MBACCESS 35  /* STRING in Baum BASEMENU */
#define MBPARAMS 36  /* STRING in Baum BASEMENU */
#define MBTXT    38  /* STRING in Baum BASEMENU */
#define MBCIFACE 39  /* STRING in Baum BASEMENU */

#define MASKMENU 16  /* Menuebaum */
#define MMINFO   3   /* TITLE in Baum MASKMENU */
#define MMOPTION 4   /* TITLE in Baum MASKMENU */
#define MMASKINF 7   /* STRING in Baum MASKMENU */
#define MMTOOLS  9   /* STRING in Baum MASKMENU */
#define MMCHECK  11  /* STRING in Baum MASKMENU */
#define MMSORT   12  /* STRING in Baum MASKMENU */
#define MMFONT   14  /* STRING in Baum MASKMENU */
#define MMFILL   15  /* STRING in Baum MASKMENU */
#define MMCOLOR  16  /* STRING in Baum MASKMENU */
#define MMLINES  17  /* STRING in Baum MASKMENU */
#define MMGRID   19  /* STRING in Baum MASKMENU */
#define MMSIZE   20  /* STRING in Baum MASKMENU */

#define DBICONS  17  /* Formular/Dialog */
#define DBARROW  2   /* BUTTON in Baum DBICONS */
#define DBLINK   3   /* BUTTON in Baum DBICONS */
#define ITABLE   4   /* BUTTON in Baum DBICONS */
#define IFIELD   5   /* BUTTON in Baum DBICONS */
#define IKEY     6   /* BUTTON in Baum DBICONS */
#define IMASK    7   /* BUTTON in Baum DBICONS */

#define DBINFO   18  /* Formular/Dialog */
#define DIDBNAME 2   /* STRING in Baum DBINFO */
#define DIUSER   4   /* STRING in Baum DBINFO */
#define DICREAT  6   /* STRING in Baum DBINFO */
#define DILASTUS 8   /* STRING in Baum DBINFO */
#define DIDATSIZ 11  /* STRING in Baum DBINFO */
#define DIDATUSE 13  /* STRING in Baum DBINFO */
#define DIDATUSP 14  /* STRING in Baum DBINFO */
#define DIDATFRE 16  /* STRING in Baum DBINFO */
#define DIDATFRP 17  /* STRING in Baum DBINFO */
#define DIDATCAC 19  /* STRING in Baum DBINFO */
#define DIDATHIT 21  /* STRING in Baum DBINFO */
#define DIDATFLU 23  /* STRING in Baum DBINFO */
#define DIHOLES  25  /* STRING in Baum DBINFO */
#define DIHOLESP 26  /* STRING in Baum DBINFO */
#define DIDATMOD 28  /* STRING in Baum DBINFO */
#define DIRDWR   30  /* STRING in Baum DBINFO */
#define DIINDSIZ 33  /* STRING in Baum DBINFO */
#define DIINDUSE 35  /* STRING in Baum DBINFO */
#define DIINDUSP 36  /* STRING in Baum DBINFO */
#define DIINDFRE 38  /* STRING in Baum DBINFO */
#define DIINDFRP 39  /* STRING in Baum DBINFO */
#define DIINDCAC 41  /* STRING in Baum DBINFO */
#define DIINDHIT 43  /* STRING in Baum DBINFO */
#define DIINDFLU 45  /* STRING in Baum DBINFO */
#define DIOK     46  /* BUTTON in Baum DBINFO */
#define DIHELP   47  /* BUTTON in Baum DBINFO */

#define NEWTABLE 19  /* Formular/Dialog */
#define NTDBNAME 2   /* STRING in Baum NEWTABLE */
#define NTNAME   3   /* STRING in Baum NEWTABLE */
#define NTTABLE  4   /* FBOXTEXT in Baum NEWTABLE */
#define NTCOLOR  6   /* BUTTON in Baum NEWTABLE */
#define NTINUM   9   /* STRING in Baum NEWTABLE */
#define NTICNBOX 10  /* IBOX in Baum NEWTABLE */
#define NTICON   12  /* ICON in Baum NEWTABLE */
#define NTSB     13  /* BOX in Baum NEWTABLE */
#define NTILOAD  14  /* BUTTON in Baum NEWTABLE */
#define NTMTON   15  /* BUTTON in Baum NEWTABLE */
#define NTHIDE   16  /* BUTTON in Baum NEWTABLE */
#define NTOK     17  /* BUTTON in Baum NEWTABLE */
#define NTCANCEL 18  /* BUTTON in Baum NEWTABLE */
#define NTHELP   19  /* BUTTON in Baum NEWTABLE */

#define NEWFIELD 20  /* Formular/Dialog */
#define NFTABLE  2   /* STRING in Baum NEWFIELD */
#define NFNAME   3   /* STRING in Baum NEWFIELD */
#define NFFIELD  4   /* FBOXTEXT in Baum NEWFIELD */
#define NFDTEXT  6   /* BUTTON in Baum NEWFIELD */
#define NFDTLEN  7   /* FBOXTEXT in Baum NEWFIELD */
#define NFDWORD  8   /* BUTTON in Baum NEWFIELD */
#define NFDLONG  9   /* BUTTON in Baum NEWFIELD */
#define NFDFLOAT 10  /* BUTTON in Baum NEWFIELD */
#define NFDDATE  11  /* BUTTON in Baum NEWFIELD */
#define NFDTIME  12  /* BUTTON in Baum NEWFIELD */
#define NFDTSTAM 13  /* BUTTON in Baum NEWFIELD */
#define NFDEXTRN 14  /* BUTTON in Baum NEWFIELD */
#define NFDPIC   15  /* BUTTON in Baum NEWFIELD */
#define NFDPLEN  16  /* FBOXTEXT in Baum NEWFIELD */
#define NFDDBADR 17  /* BUTTON in Baum NEWFIELD */
#define NFDBLOB  18  /* BUTTON in Baum NEWFIELD */
#define NFBTYPE  19  /* BUTTON in Baum NEWFIELD */
#define NFDBLEN  20  /* FBOXTEXT in Baum NEWFIELD */
#define NFANONE  23  /* BUTTON in Baum NEWFIELD */
#define NFAPRIMA 24  /* BUTTON in Baum NEWFIELD */
#define NFAUNIQU 25  /* BUTTON in Baum NEWFIELD */
#define NFAINDLT 26  /* STRING in Baum NEWFIELD */
#define NFAINDLE 27  /* FBOXTEXT in Baum NEWFIELD */
#define NFAMANDA 28  /* BUTTON in Baum NEWFIELD */
#define NFADEFAU 29  /* BUTTON in Baum NEWFIELD */
#define NFAOUT   30  /* BUTTON in Baum NEWFIELD */
#define NFALOOKU 31  /* BUTTON in Baum NEWFIELD */
#define NFAINDEX 32  /* BUTTON in Baum NEWFIELD */
#define NFOK     33  /* BUTTON in Baum NEWFIELD */
#define NFCANCEL 34  /* BUTTON in Baum NEWFIELD */
#define NFHELP   35  /* BUTTON in Baum NEWFIELD */
#define NFNEXT   36  /* BUTTON in Baum NEWFIELD */
#define NFFORMAT 37  /* BUTTON in Baum NEWFIELD */

#define NEWKEY   21  /* Formular/Dialog */
#define NKTABLE  2   /* STRING in Baum NEWKEY */
#define NKINDEX  4   /* FBOXTEXT in Baum NEWKEY */
#define NKFHEAD  5   /* STRING in Baum NEWKEY */
#define NKMHEAD  6   /* STRING in Baum NEWKEY */
#define NKFIELDS 7   /* BOX in Baum NEWKEY */
#define NKCOPY   8   /* BUTTON in Baum NEWKEY */
#define NKKEYS   9   /* BOX in Baum NEWKEY */
#define NKUPDATE 10  /* BUTTON in Baum NEWKEY */
#define NKDELETE 11  /* BUTTON in Baum NEWKEY */
#define NKINDLEN 13  /* FBOXTEXT in Baum NEWKEY */
#define NKSIZE   15  /* STRING in Baum NEWKEY */
#define NKNONE   17  /* BUTTON in Baum NEWKEY */
#define NKPRIMAR 18  /* BUTTON in Baum NEWKEY */
#define NKUNIQUE 19  /* BUTTON in Baum NEWKEY */
#define NKOK     20  /* BUTTON in Baum NEWKEY */
#define NKCANCEL 21  /* BUTTON in Baum NEWKEY */
#define NKHELP   22  /* BUTTON in Baum NEWKEY */

#define DOICONS  22  /* Formular/Dialog */
#define DDBNAME  2   /* STRING in Baum DOICONS */
#define DLOAD    3   /* BUTTON in Baum DOICONS */
#define DICNBOX  4   /* BOX in Baum DOICONS */
#define DINUMBOX 5   /* BOX in Baum DOICONS */
#define DDOWN    6   /* BOXCHAR in Baum DOICONS */
#define DINUM    7   /* BOXTEXT in Baum DOICONS */
#define DUP      8   /* BOXCHAR in Baum DOICONS */
#define DICON    9   /* ICON in Baum DOICONS */
#define DUPDATE  10  /* BUTTON in Baum DOICONS */
#define DEXPORT  11  /* BUTTON in Baum DOICONS */
#define DDELETE  12  /* BUTTON in Baum DOICONS */
#define DOK      13  /* BUTTON in Baum DOICONS */
#define DHELP    14  /* BUTTON in Baum DOICONS */

#define FORMATS  23  /* Formular/Dialog */
#define FNAME    2   /* STRING in Baum FORMATS */
#define FTYPE    4   /* STRING in Baum FORMATS */
#define FNEW     6   /* FBOXTEXT in Baum FORMATS */
#define FLISTBOX 8   /* BOX in Baum FORMATS */
#define FUPDATE  9   /* BUTTON in Baum FORMATS */
#define FDELETE  10  /* BUTTON in Baum FORMATS */
#define FOK      11  /* BUTTON in Baum FORMATS */
#define FCANCEL  12  /* BUTTON in Baum FORMATS */
#define FHELP    13  /* BUTTON in Baum FORMATS */

#define SELMASK  24  /* Formular/Dialog */
#define SMDBNAME 2   /* STRING in Baum SELMASK */
#define SMNAME   4   /* FBOXTEXT in Baum SELMASK */
#define SMSCREEN 8   /* BOX in Baum SELMASK */
#define SMPRINTR 10  /* BOX in Baum SELMASK */
#define SMLIST   12  /* BOX in Baum SELMASK */
#define SMOPEN   13  /* BUTTON in Baum SELMASK */
#define SMDELETE 14  /* BUTTON in Baum SELMASK */
#define SMCANCEL 15  /* BUTTON in Baum SELMASK */
#define SMHELP   16  /* BUTTON in Baum SELMASK */

#define MASKICON 25  /* Formular/Dialog */
#define MIARROW  2   /* BUTTON in Baum MASKICON */
#define MILINE   3   /* BUTTON in Baum MASKICON */
#define MIBOX    4   /* BUTTON in Baum MASKICON */
#define MIRBOX   5   /* BUTTON in Baum MASKICON */
#define MITEXT   6   /* BUTTON in Baum MASKICON */
#define MIGRAF   7   /* BUTTON in Baum MASKICON */
#define MIBUTTON 8   /* BUTTON in Baum MASKICON */
#define MIMASK   9   /* BUTTON in Baum MASKICON */
#define MIFONT   10  /* BOXTEXT in Baum MASKICON */
#define MIFILL   11  /* IBOX in Baum MASKICON */
#define MILINES  12  /* BOX in Baum MASKICON */
#define MIPOINT  13  /* BOXTEXT in Baum MASKICON */

#define DBPARAMS 26  /* Formular/Dialog */
#define BPBASE   2   /* STRING in Baum DBPARAMS */
#define BPDSIZE  5   /* FBOXTEXT in Baum DBPARAMS */
#define BPDENCOD 7   /* BUTTON in Baum DBPARAMS */
#define BPTSIZE  10  /* FBOXTEXT in Baum DBPARAMS */
#define BPTENCOD 12  /* BUTTON in Baum DBPARAMS */
#define BPOK     13  /* BUTTON in Baum DBPARAMS */
#define BPCANCEL 14  /* BUTTON in Baum DBPARAMS */
#define BPHELP   15  /* BUTTON in Baum DBPARAMS */

#define RELRULES 27  /* Formular/Dialog */
#define RREF     1   /* STRING in Baum RELRULES */
#define RDNONE   3   /* BUTTON in Baum RELRULES */
#define RDRESTRI 4   /* BUTTON in Baum RELRULES */
#define RDCASCAD 5   /* BUTTON in Baum RELRULES */
#define RDSETNUL 6   /* BUTTON in Baum RELRULES */
#define RUNONE   8   /* BUTTON in Baum RELRULES */
#define RURESTRI 9   /* BUTTON in Baum RELRULES */
#define RUCASCAD 10  /* BUTTON in Baum RELRULES */
#define RUSETNUL 11  /* BUTTON in Baum RELRULES */
#define RINONE   13  /* BUTTON in Baum RELRULES */
#define RIRESTRI 14  /* BUTTON in Baum RELRULES */
#define R11      16  /* BUTTON in Baum RELRULES */
#define R1N      17  /* BUTTON in Baum RELRULES */
#define ROK      18  /* BUTTON in Baum RELRULES */
#define RCANCEL  19  /* BUTTON in Baum RELRULES */
#define RHELP    20  /* BUTTON in Baum RELRULES */
#define RDELETE  21  /* BUTTON in Baum RELRULES */

#define SELFIELD 28  /* Formular/Dialog */
#define SDTABLE  2   /* FBOXTEXT in Baum SELFIELD */
#define SDFONTN  4   /* STRING in Baum SELFIELD */
#define SDFIELD  6   /* FBOXTEXT in Baum SELFIELD */
#define SDPOINT  8   /* STRING in Baum SELFIELD */
#define SDLABEL  10  /* FBOXTEXT in Baum SELFIELD */
#define SDREPLAC 11  /* BUTTON in Baum SELFIELD */
#define SDTRANS  12  /* BUTTON in Baum SELFIELD */
#define SDSTDLBL 14  /* BUTTON in Baum SELFIELD */
#define SDHSLIDR 15  /* BUTTON in Baum SELFIELD */
#define SDVSLIDR 16  /* BUTTON in Baum SELFIELD */
#define SDWORDWR 17  /* BUTTON in Baum SELFIELD */
#define SDBOUNDS 18  /* BUTTON in Baum SELFIELD */
#define SDNOCLEA 19  /* BUTTON in Baum SELFIELD */
#define SDWHUNIT 20  /* BUTTON in Baum SELFIELD */
#define SDX      22  /* FBOXTEXT in Baum SELFIELD */
#define SDW      25  /* FBOXTEXT in Baum SELFIELD */
#define SDY      27  /* FBOXTEXT in Baum SELFIELD */
#define SDH      30  /* FBOXTEXT in Baum SELFIELD */
#define SDTYPE   32  /* BUTTON in Baum SELFIELD */
#define SDLOWER  34  /* FBOXTEXT in Baum SELFIELD */
#define SDUPPER  36  /* FBOXTEXT in Baum SELFIELD */
#define SDOK     37  /* BUTTON in Baum SELFIELD */
#define SDCANCEL 38  /* BUTTON in Baum SELFIELD */
#define SDHELP   39  /* BUTTON in Baum SELFIELD */
#define SDFONT   40  /* BUTTON in Baum SELFIELD */
#define SDVALUES 41  /* BUTTON in Baum SELFIELD */

#define SELFILL  29  /* Formular/Dialog */
#define SITNAME  1   /* STRING in Baum SELFILL */
#define SICOLOR  3   /* BUTTON in Baum SELFILL */
#define SIPATTER 4   /* BOX in Baum SELFILL */
#define SISELECT 5   /* BOX in Baum SELFILL */
#define SIHOLLOW 8   /* BUTTON in Baum SELFILL */
#define SIWHITE  9   /* BUTTON in Baum SELFILL */
#define SITABLE  10  /* BUTTON in Baum SELFILL */
#define SIOK     11  /* BUTTON in Baum SELFILL */
#define SICANCEL 12  /* BUTTON in Baum SELFILL */
#define SIHELP   13  /* BUTTON in Baum SELFILL */

#define SELLINE  30  /* Formular/Dialog */
#define SLBS1    2   /* BUTTON in Baum SELLINE */
#define SLBS2    4   /* BUTTON in Baum SELLINE */
#define SLBS3    6   /* BUTTON in Baum SELLINE */
#define SLES1    9   /* BUTTON in Baum SELLINE */
#define SLES2    11  /* BUTTON in Baum SELLINE */
#define SLES3    13  /* BUTTON in Baum SELLINE */
#define SLT1     16  /* BUTTON in Baum SELLINE */
#define SLT2     18  /* BUTTON in Baum SELLINE */
#define SLT3     20  /* BUTTON in Baum SELLINE */
#define SLT4     22  /* BUTTON in Baum SELLINE */
#define SLT5     24  /* BUTTON in Baum SELLINE */
#define SLT6     26  /* BUTTON in Baum SELLINE */
#define SLWIDTH  29  /* FBOXTEXT in Baum SELLINE */
#define SLSELECT 30  /* BOX in Baum SELLINE */
#define SLOK     32  /* BUTTON in Baum SELLINE */
#define SLCANCEL 33  /* BUTTON in Baum SELLINE */
#define SLHELP   34  /* BUTTON in Baum SELLINE */

#define SELGRID  31  /* Formular/Dialog */
#define MGRIDX   2   /* FBOXTEXT in Baum SELGRID */
#define MGRIDY   5   /* FBOXTEXT in Baum SELGRID */
#define MGOK     7   /* BUTTON in Baum SELGRID */
#define MGCANCEL 8   /* BUTTON in Baum SELGRID */
#define MGHELP   9   /* BUTTON in Baum SELGRID */

#define SELSIZE  32  /* Formular/Dialog */
#define MSIZEX   2   /* FBOXTEXT in Baum SELSIZE */
#define MSIZEY   5   /* FBOXTEXT in Baum SELSIZE */
#define MSOK     7   /* BUTTON in Baum SELSIZE */
#define MSCANCEL 8   /* BUTTON in Baum SELSIZE */
#define MSHELP   9   /* BUTTON in Baum SELSIZE */

#define SELTEXT  33  /* Formular/Dialog */
#define STTEXT   2   /* FBOXTEXT in Baum SELTEXT */
#define STFONTN  4   /* STRING in Baum SELTEXT */
#define STTHICK  6   /* BUTTON in Baum SELTEXT */
#define STLIGHT  7   /* BUTTON in Baum SELTEXT */
#define STSKEWED 8   /* BUTTON in Baum SELTEXT */
#define STUNDERL 9   /* BUTTON in Baum SELTEXT */
#define STOUTLIN 10  /* BUTTON in Baum SELTEXT */
#define STREPLAC 12  /* BUTTON in Baum SELTEXT */
#define STTRANS  13  /* BUTTON in Baum SELTEXT */
#define STPOINT  15  /* STRING in Baum SELTEXT */
#define STXPOS   17  /* FBOXTEXT in Baum SELTEXT */
#define STYPOS   20  /* FBOXTEXT in Baum SELTEXT */
#define STOK     22  /* BUTTON in Baum SELTEXT */
#define STCANCEL 23  /* BUTTON in Baum SELTEXT */
#define STHELP   24  /* BUTTON in Baum SELTEXT */
#define STFONT   25  /* BUTTON in Baum SELTEXT */

#define OBJSIZE  34  /* Formular/Dialog */
#define OSX      2   /* FBOXTEXT in Baum OBJSIZE */
#define OSY      4   /* FBOXTEXT in Baum OBJSIZE */
#define OSW      7   /* FBOXTEXT in Baum OBJSIZE */
#define OSH      9   /* FBOXTEXT in Baum OBJSIZE */
#define OSOK     11  /* BUTTON in Baum OBJSIZE */
#define OSCANCEL 12  /* BUTTON in Baum OBJSIZE */
#define OSHELP   13  /* BUTTON in Baum OBJSIZE */

#define PICSIZE  35  /* Formular/Dialog */
#define PSFNAME  2   /* STRING in Baum PICSIZE */
#define PSX      4   /* FBOXTEXT in Baum PICSIZE */
#define PSY      6   /* FBOXTEXT in Baum PICSIZE */
#define PSW      9   /* FBOXTEXT in Baum PICSIZE */
#define PSH      11  /* FBOXTEXT in Baum PICSIZE */
#define PSFRAME  13  /* BUTTON in Baum PICSIZE */
#define PSOK     14  /* BUTTON in Baum PICSIZE */
#define PSCANCEL 15  /* BUTTON in Baum PICSIZE */
#define PSEDIT   16  /* BUTTON in Baum PICSIZE */
#define PSHELP   17  /* BUTTON in Baum PICSIZE */

#define LINESIZE 36  /* Formular/Dialog */
#define LSX1     2   /* FBOXTEXT in Baum LINESIZE */
#define LSY1     4   /* FBOXTEXT in Baum LINESIZE */
#define LSX2     7   /* FBOXTEXT in Baum LINESIZE */
#define LSY2     9   /* FBOXTEXT in Baum LINESIZE */
#define LSOK     11  /* BUTTON in Baum LINESIZE */
#define LSCANCEL 12  /* BUTTON in Baum LINESIZE */
#define LSHELP   13  /* BUTTON in Baum LINESIZE */

#define RBVALUES 37  /* Formular/Dialog */
#define RVTEXT1  3   /* FTEXT in Baum RBVALUES */
#define RVOK     7   /* BUTTON in Baum RBVALUES */
#define RVCANCEL 8   /* BUTTON in Baum RBVALUES */
#define RVHELP   9   /* BUTTON in Baum RBVALUES */

#define CBVALUES 38  /* Formular/Dialog */
#define CVSEL    2   /* FBOXTEXT in Baum CBVALUES */
#define CVUNSEL  4   /* FBOXTEXT in Baum CBVALUES */
#define CVOK     5   /* BUTTON in Baum CBVALUES */
#define CVCANCEL 6   /* BUTTON in Baum CBVALUES */
#define CVHELP   7   /* BUTTON in Baum CBVALUES */

#define SELSUBM  39  /* Formular/Dialog */
#define SSSOURCE 2   /* BUTTON in Baum SELSUBM */
#define SSMASTER 4   /* FBOXTEXT in Baum SELSUBM */
#define SSCHILD  6   /* FBOXTEXT in Baum SELSUBM */
#define SSFONTN  8   /* STRING in Baum SELSUBM */
#define SSPOINT  10  /* STRING in Baum SELSUBM */
#define SSX      12  /* FBOXTEXT in Baum SELSUBM */
#define SSY      14  /* FBOXTEXT in Baum SELSUBM */
#define SSW      17  /* FBOXTEXT in Baum SELSUBM */
#define SSH      19  /* FBOXTEXT in Baum SELSUBM */
#define SSTABLE  22  /* BUTTON in Baum SELSUBM */
#define SSMASK   23  /* BUTTON in Baum SELSUBM */
#define SSOK     24  /* BUTTON in Baum SELSUBM */
#define SSCANCEL 25  /* BUTTON in Baum SELSUBM */
#define SSHELP   26  /* BUTTON in Baum SELSUBM */
#define SSFONT   27  /* BUTTON in Baum SELSUBM */

#define SELBUTTO 40  /* Formular/Dialog */
#define SBTEXT   2   /* FBOXTEXT in Baum SELBUTTO */
#define SBPARAM1 5   /* FTEXT in Baum SELBUTTO */
#define SBFUNC   10  /* BUTTON in Baum SELBUTTO */
#define SBX      12  /* FBOXTEXT in Baum SELBUTTO */
#define SBY      14  /* FBOXTEXT in Baum SELBUTTO */
#define SBW      17  /* FBOXTEXT in Baum SELBUTTO */
#define SBH      19  /* FBOXTEXT in Baum SELBUTTO */
#define SBROUND  22  /* BUTTON in Baum SELBUTTO */
#define SBRECT   23  /* BUTTON in Baum SELBUTTO */
#define SBFONTN  25  /* STRING in Baum SELBUTTO */
#define SBHIDDEN 26  /* BUTTON in Baum SELBUTTO */
#define SBPOINT  28  /* STRING in Baum SELBUTTO */
#define SBOK     29  /* BUTTON in Baum SELBUTTO */
#define SBCANCEL 30  /* BUTTON in Baum SELBUTTO */
#define SBHELP   31  /* BUTTON in Baum SELBUTTO */
#define SBFONT   32  /* BUTTON in Baum SELBUTTO */

#define BACCESS  41  /* Formular/Dialog */
#define ADBNAME  2   /* STRING in Baum BACCESS */
#define AUSER    4   /* FBOXTEXT in Baum BACCESS */
#define BAUSERS  6   /* BOX in Baum BACCESS */
#define AUREADON 7   /* BUTTON in Baum BACCESS */
#define AUINSERT 8   /* BUTTON in Baum BACCESS */
#define AUDELETE 9   /* BUTTON in Baum BACCESS */
#define AUUPDATE 10  /* BUTTON in Baum BACCESS */
#define AUINFO   11  /* BUTTON in Baum BACCESS */
#define BATABLES 13  /* BOX in Baum BACCESS */
#define ATSELECT 14  /* BUTTON in Baum BACCESS */
#define ATINSERT 15  /* BUTTON in Baum BACCESS */
#define ATUPDATE 16  /* BUTTON in Baum BACCESS */
#define ATDELETE 17  /* BUTTON in Baum BACCESS */
#define ATSYSTAB 18  /* BUTTON in Baum BACCESS */
#define BAFIELDS 20  /* BOX in Baum BACCESS */
#define AFNONE   21  /* BUTTON in Baum BACCESS */
#define AFSELECT 22  /* BUTTON in Baum BACCESS */
#define AFINSERT 23  /* BUTTON in Baum BACCESS */
#define AFUPDATE 24  /* BUTTON in Baum BACCESS */
#define ACOK     25  /* BUTTON in Baum BACCESS */
#define ACCANCEL 26  /* BUTTON in Baum BACCESS */
#define ACHELP   27  /* BUTTON in Baum BACCESS */

#define STDFORMA 42  /* Formular/Dialog */
#define STDSTRIN 23  /* BOX in Baum STDFORMA */

#define MASKINFO 43  /* Formular/Dialog */
#define MIDBNAME 2   /* STRING in Baum MASKINFO */
#define MIDEVICE 5   /* STRING in Baum MASKINFO */
#define MICOLOR  6   /* BUTTON in Baum MASKINFO */
#define MINAME   8   /* FBOXTEXT in Baum MASKINFO */
#define MITABLE  10  /* FBOXTEXT in Baum MASKINFO */
#define MIUSER   12  /* FBOXTEXT in Baum MASKINFO */
#define MICENTRY 14  /* FBOXTEXT in Baum MASKINFO */
#define MICEXIT  16  /* FBOXTEXT in Baum MASKINFO */
#define MIX      19  /* FBOXTEXT in Baum MASKINFO */
#define MIY      21  /* FBOXTEXT in Baum MASKINFO */
#define MIW      23  /* FBOXTEXT in Baum MASKINFO */
#define MIH      25  /* FBOXTEXT in Baum MASKINFO */
#define MIICONS  26  /* BUTTON in Baum MASKINFO */
#define MIINFO   27  /* BUTTON in Baum MASKINFO */
#define MIOBJS   29  /* STRING in Baum MASKINFO */
#define MI3D     30  /* BUTTON in Baum MASKINFO */
#define MIMENU   31  /* BUTTON in Baum MASKINFO */
#define MIMAXOBJ 33  /* STRING in Baum MASKINFO */
#define MIOK     34  /* BUTTON in Baum MASKINFO */
#define MICANCEL 35  /* BUTTON in Baum MASKINFO */
#define MIHELP   36  /* BUTTON in Baum MASKINFO */
#define MIGETSIZ 37  /* BUTTON in Baum MASKINFO */

#define TBLINFO  44  /* Formular/Dialog */
#define TIDBNAME 2   /* STRING in Baum TBLINFO */
#define TITABLE  4   /* STRING in Baum TBLINFO */
#define TIRECS   6   /* STRING in Baum TBLINFO */
#define TICOLS   8   /* STRING in Baum TBLINFO */
#define TIINXS   10  /* STRING in Baum TBLINFO */
#define TISIZE   12  /* STRING in Baum TBLINFO */
#define TILIST   17  /* BOX in Baum TBLINFO */
#define TIOK     18  /* BUTTON in Baum TBLINFO */
#define TIHELP   19  /* BUTTON in Baum TBLINFO */

#define EMPTY    45  /* Formular/Dialog */
#define EACTION  2   /* STRING in Baum EMPTY */
#define ENAME    3   /* STRING in Baum EMPTY */

#define HELPMENU 46  /* Menuebaum */
#define MHINFO   3   /* TITLE in Baum HELPMENU */
#define MHFILE   4   /* TITLE in Baum HELPMENU */
#define MHEDIT   5   /* TITLE in Baum HELPMENU */
#define MHHELP   6   /* TITLE in Baum HELPMENU */
#define MHELPINF 9   /* STRING in Baum HELPMENU */
#define MHOPENDB 11  /* STRING in Baum HELPMENU */
#define MHCLOSED 12  /* STRING in Baum HELPMENU */
#define MHUNDO   14  /* STRING in Baum HELPMENU */
#define MHNEXT   16  /* STRING in Baum HELPMENU */
#define MHPREV   17  /* STRING in Baum HELPMENU */
#define MHUSEHLP 19  /* STRING in Baum HELPMENU */
#define MHCONTEN 20  /* STRING in Baum HELPMENU */

#define HABOUT   47  /* Formular/Dialog */

#define NOWINDOW 0   /* Alert String */

#define NOMEMORY 1   /* Alert String */

#define NOHLPINX 2   /* Alert String */
