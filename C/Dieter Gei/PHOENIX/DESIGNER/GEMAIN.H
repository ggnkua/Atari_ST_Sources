/*****************************************************************************/
/*                                                                           */
/* Modul: GEMAIN.H                                                           */
/* Datum: 23/05/89                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MAIN__
#define __MAIN__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

#if GEM & XGEM

GLOBAL WORD GEMAIN _((VOID));

#else

GLOBAL WORD main _((INT argc, BYTE *argv []));

#endif

#endif /* __MAIN__ */

