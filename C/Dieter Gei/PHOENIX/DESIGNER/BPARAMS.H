/*****************************************************************************/
/*                                                                           */
/* Modul: BPARAMS.H                                                          */
/* Datum: 10/04/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BPARAMS__
#define __BPARAMS__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mdbparams _((BASE_SPEC *base_spec));

#endif /* __BPARAMS__ */

