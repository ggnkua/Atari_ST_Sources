/*****************************************************************************/
/*                                                                           */
/* Modul: BNTABLE.H                                                          */
/* Datum: 10/04/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BNTABLE__
#define __BNTABLE__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL WORD mnewtable _((WINDOWP base_window, SYSTABLE *tablep, WORD x, WORD y, WORD *ret_table));

#endif /* __BNTABLE__ */

