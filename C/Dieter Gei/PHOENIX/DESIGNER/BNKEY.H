/*****************************************************************************/
/*                                                                           */
/* Modul: BNKEY.H                                                            */
/* Datum: 14/06/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BNKEY__
#define __BNKEY__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID init_newkey _((VOID));
GLOBAL WORD mnewkey     _((WINDOWP base_window, WORD table, SYSINDEX *inxp, WORD *ret_key));

#endif /* __BMENU__ */

