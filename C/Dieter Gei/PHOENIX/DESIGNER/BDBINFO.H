/*****************************************************************************/
/*                                                                           */
/* Modul: BDBINFO.H                                                          */
/* Datum: 10/04/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BDBINFO__
#define __BDBINFO__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mdbinfo _((BASE_SPEC *base_spec));

#endif /* __BDBINFO__ */

