/*****************************************************************************/
/*                                                                           */
/* Modul: MSELFIEL.H                                                         */
/* Datum: 25/01/91                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MSELFIELD__
#define __MSELFIELD__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mselfield _((WINDOWP mask_window, WORD obj, BOOLEAN show_error));

#endif /* __MSELFIELD__ */

