/*****************************************************************************/
/*                                                                           */
/* Modul: BCIF.H                                                             */
/* Datum: 10/04/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BCIF__
#define __BCIF__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mcinterface _((BASE_SPEC *base_spec));

#endif /* __BCIF__ */

