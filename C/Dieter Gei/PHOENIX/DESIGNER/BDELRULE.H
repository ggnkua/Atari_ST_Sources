/*****************************************************************************/
/*                                                                           */
/* Modul: BDELRULE.H                                                         */
/* Datum: 27/09/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BDELRULE__
#define __BDELRULE__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID    mdelrules  _((BASE_SPEC *base_spec, WORD class, SET objs));
GLOBAL BOOLEAN mtestrules _((BASE_SPEC *base_spec, WORD class, SET objs));

#endif /* __BDELRULE__ */

