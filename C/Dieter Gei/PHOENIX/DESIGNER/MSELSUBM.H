/*****************************************************************************
 *
 * Module : MSELSUBM.H
 * Author : J�rgen Geiž
 *
 * Creation date    : 20.09.94
 * Last modification: 10.10.94
 *
 *
 * Description: This module defines the mask select submask dialog box.
 *
 * History:
 * 20.09.94: Creation of body
 *****************************************************************************/

#ifndef __MSELSUBMASK__
#define __MSELSUBMASK__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL WORD mselsubmask _((WINDOWP mask_window, WORD obj));

#endif /* __MSELSUBMASK__ */

