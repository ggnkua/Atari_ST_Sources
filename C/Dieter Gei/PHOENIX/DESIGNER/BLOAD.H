/*****************************************************************************/
/*                                                                           */
/* Modul: BLOAD.H                                                            */
/* Datum: 31/12/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BLOAD__
#define __BLOAD__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN b_new_base  _((BASE_SPEC *base_spec));
GLOBAL BOOLEAN b_load_base _((BASE_SPEC *base_spec));
GLOBAL BOOLEAN b_save_base _((WINDOWP window));
GLOBAL VOID    b_wi_title  _((WINDOWP window));

#endif /* __BLOAD__ */

