/*****************************************************************************/
/*                                                                           */
/* Modul: MSELGRID.H                                                         */
/* Datum: 21/07/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MSELGRID__
#define __MSELGRID__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mselgrid _((WORD *grid_x, WORD *grid_y));

#endif /* __MSELGRID__ */

