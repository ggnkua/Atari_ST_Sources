/*****************************************************************************/
/*                                                                           */
/* Modul: MSELECT.H                                                          */
/* Datum: 28/10/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MSELECT__
#define __MSELECT__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID mselect _((BASE_SPEC *base_spec, WORD table));

#endif /* __MSELECT__ */

