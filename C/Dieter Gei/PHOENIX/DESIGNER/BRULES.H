/*****************************************************************************/
/*                                                                           */
/* Modul: BRULES.H                                                           */
/* Datum: 27/09/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BRULES__
#define __BRULES__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID b_rules _((WINDOWP base_window, WORD ref_table, WORD ref_index, WORD rel_table, WORD rel_index));

#endif /* __BRULES__ */

