/*****************************************************************************/
/*                                                                           */
/* Modul: BACCESS.H                                                          */
/* Datum: 01/12/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BACCESS__
#define __BACCESS__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID maccess _((BASE_SPEC *base_spec));

#endif /* __BACCESS__ */

