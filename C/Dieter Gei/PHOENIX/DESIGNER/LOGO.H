LOCAL UBYTE logo [] =
{
  0x00, 0x01, 0x00, 0x08, 0x00, 0x01, 0x00, 0x02, 0x01, 0x74, 
  0x01, 0x74, 0x01, 0x30, 0x00, 0xB3, 0x00, 0x00, 0xFF, 0x02, 
  0xA4, 0x80, 0x02, 0xE0, 0x00, 0x9E, 0x80, 0x08, 0xFD, 0x44, 
  0x92, 0x7F, 0x0C, 0x22, 0x60, 0x00, 0x9E, 0x80, 0x08, 0xFC, 
  0x52, 0x08, 0x8F, 0x9E, 0x82, 0x60, 0x00, 0x9E, 0x80, 0x08, 
  0xFC, 0x19, 0x54, 0x07, 0xE9, 0x00, 0x60, 0x00, 0x9E, 0x80, 
  0x08, 0xFC, 0x00, 0x03, 0x47, 0x86, 0xB8, 0x60, 0x00, 0x9E, 
  0x80, 0x08, 0xFC, 0x26, 0x20, 0xAF, 0xD0, 0x00, 0x60, 0x00, 
  0x9E, 0x80, 0x08, 0xFC, 0x92, 0x0C, 0x0F, 0xBE, 0x10, 0x60, 
  0x00, 0x80, 0x12, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0x0F, 0xFF, 
  0xC0, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFF, 0xC1, 0xF8, 
  0x3F, 0x8C, 0x80, 0x08, 0xFC, 0x16, 0x40, 0x4F, 0xC7, 0x04, 
  0x60, 0x00, 0x80, 0x12, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0x0F, 
  0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFF, 0xC1, 
  0xF8, 0x3F, 0x8C, 0x80, 0x08, 0xFD, 0x00, 0x40, 0x0F, 0x02, 
  0x90, 0x60, 0x00, 0x80, 0x12, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 
  0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xE1, 0xFF, 0xC3, 0xFF, 
  0xC1, 0xF8, 0x3F, 0x8C, 0x80, 0x08, 0xFC, 0x40, 0x26, 0x1F, 
  0x09, 0x8A, 0xE0, 0x00, 0x80, 0x12, 0xFF, 0x80, 0x1F, 0xFE, 
  0x1F, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xE1, 0xFF, 0xC3, 
  0xFF, 0xE0, 0xF0, 0x7F, 0x8C, 0x80, 0x08, 0xFC, 0x08, 0x05, 
  0x1F, 0x0D, 0x43, 0x60, 0x00, 0x80, 0x12, 0xFF, 0x80, 0x0F, 
  0xFE, 0x1F, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x07, 0xE1, 0xFF, 
  0xC3, 0xFF, 0xE0, 0xF0, 0x7F, 0x8C, 0x80, 0x08, 0xFC, 0x89, 
  0x40, 0x1F, 0x04, 0x01, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x84, 
  0x07, 0xFE, 0x1F, 0x0F, 0xFC, 0x0C, 0x0F, 0xFE, 0x07, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xE0, 0x60, 0x8D, 0x80, 0x08, 0xFC, 0x9C, 
  0x60, 0x5E, 0x05, 0x04, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x86, 
  0x07, 0xFE, 0x1F, 0x0F, 0xFC, 0x1E, 0x0F, 0xFE, 0x07, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xF0, 0x60, 0x8D, 0x80, 0x08, 0xFC, 0x92, 
  0x24, 0x3E, 0x18, 0x08, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x07, 0xFE, 0x1F, 0x0F, 0xFC, 0x1E, 0x0F, 0xFE, 0x03, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xF0, 0x40, 0x8D, 0x80, 0x08, 0xFC, 0x00, 
  0x20, 0x3F, 0x80, 0x24, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x83, 0xFE, 0x1F, 0x0F, 0xFC, 0x3F, 0x0F, 0xFE, 0x03, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0x8D, 0x80, 0x08, 0xFC, 0x01, 
  0x00, 0x7E, 0x00, 0xA1, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x83, 0xFE, 0x1F, 0x0F, 0xFC, 0x3F, 0x0F, 0xFE, 0x01, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0x8D, 0x80, 0x08, 0xFC, 0x70, 
  0x00, 0xBE, 0x20, 0x45, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x83, 0xFE, 0x1F, 0x0F, 0xF8, 0x3F, 0x07, 0xFE, 0x01, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0x8D, 0x80, 0x08, 0xFC, 0x80, 
  0x00, 0x7C, 0x60, 0x84, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0xC3, 0xFE, 0x1F, 0x0F, 0xF8, 0x3F, 0x07, 0xFE, 0x00, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0x8D, 0x80, 0x08, 0xFC, 0x00, 
  0x85, 0x7C, 0x44, 0x81, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0xC3, 0xFE, 0x1F, 0x0F, 0xF8, 0x21, 0x07, 0xFE, 0x00, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0x8D, 0x80, 0x08, 0xFC, 0xB4, 
  0x80, 0x7E, 0x21, 0x38, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x83, 0xFE, 0x1F, 0x0F, 0xF8, 0x40, 0x07, 0xFE, 0x00, 0xE1, 
  0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0x8D, 0x80, 0x08, 0xFC, 0x01, 
  0x22, 0x78, 0x95, 0x0A, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x83, 0xFE, 0x1F, 0x0F, 0xF8, 0x4E, 0x07, 0xFE, 0x10, 0x61, 
  0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0x8D, 0x80, 0x08, 0xFC, 0x85, 
  0x38, 0xF9, 0x80, 0x60, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x06, 0x07, 0xFE, 0x10, 0x61, 
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0x8D, 0x80, 0x08, 0xFD, 0xA6, 
  0x10, 0xF8, 0x83, 0x80, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x10, 0x07, 0xFE, 0x10, 0x21, 
  0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0x8D, 0x80, 0x08, 0xFC, 0x28, 
  0x08, 0xF8, 0x24, 0x68, 0xE0, 0x00, 0x80, 0x11, 0xFF, 0x86, 
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x18, 0x87, 0xFE, 0x18, 0x21, 
  0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0x8D, 0x80, 0x08, 0xFC, 0x80, 
  0x10, 0xF4, 0x00, 0x4C, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x84, 
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0x87, 0xFE, 0x18, 0x21, 
  0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0x8D, 0x80, 0x08, 0xFC, 0x40, 
  0x02, 0xF8, 0x80, 0x03, 0xE0, 0x00, 0x80, 0x11, 0xFF, 0x80, 
  0x0F, 0xFE, 0x1F, 0x0F, 0xF8, 0x43, 0x87, 0xFE, 0x1C, 0x01, 
  0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0x8D, 0x80, 0x08, 0xFC, 0x04, 
  0x80, 0xF8, 0x8C, 0x03, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x80, 
  0x1F, 0xFE, 0x1F, 0x0F, 0xF8, 0x63, 0x87, 0xFE, 0x1C, 0x01, 
  0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0x8D, 0x80, 0x08, 0xFC, 0x10, 
  0xD4, 0xFC, 0x07, 0x08, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x80, 
  0x3F, 0xFE, 0x1F, 0x0F, 0xF8, 0x3F, 0x07, 0xFE, 0x1C, 0x01, 
  0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0x8D, 0x80, 0x08, 0xFC, 0x03, 
  0x80, 0xFC, 0x00, 0x04, 0xE0, 0x00, 0x80, 0x11, 0xFF, 0x80, 
  0x7F, 0xFE, 0x1F, 0x0F, 0xF8, 0x3F, 0x07, 0xFE, 0x1E, 0x01, 
  0xFF, 0xC3, 0xFF, 0xF8, 0x01, 0x8D, 0x80, 0x08, 0xFC, 0x10, 
  0x41, 0x7F, 0x80, 0x00, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x81, 
  0xFF, 0xFE, 0x1F, 0x0F, 0xF8, 0x3F, 0x07, 0xFE, 0x1E, 0x01, 
  0xFF, 0xC3, 0xFF, 0xF0, 0x41, 0x8D, 0x80, 0x08, 0xFC, 0xD0, 
  0x00, 0x3E, 0x12, 0x00, 0xE0, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0xFF, 0xFE, 0x1F, 0x0F, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F, 0x01, 
  0xFF, 0xC3, 0xFF, 0xF0, 0x41, 0x8D, 0x80, 0x08, 0xFC, 0x10, 
  0x10, 0x7F, 0x94, 0x04, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0xFF, 0xFE, 0x1F, 0x0F, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F, 0x01, 
  0xFF, 0xC3, 0xFF, 0xE0, 0x60, 0x8D, 0x80, 0x08, 0xFC, 0x08, 
  0x04, 0x3F, 0x0B, 0x31, 0x60, 0x00, 0x80, 0x11, 0xFF, 0x87, 
  0xFF, 0xFE, 0x1F, 0x0F, 0xFC, 0x1E, 0x0F, 0xFE, 0x1F, 0x81, 
  0xFF, 0xC3, 0xFF, 0xE0, 0xE0, 0x8D, 0x80, 0x08, 0xFD, 0x22, 
  0x00, 0x1F, 0xA6, 0x83, 0x60, 0x00, 0x80, 0x12, 0xFF, 0x87, 
  0xFF, 0xFE, 0x1F, 0x0F, 0xFC, 0x1E, 0x0F, 0xFE, 0x1F, 0x81, 
  0xFF, 0xC3, 0xFF, 0xE0, 0xE0, 0x7F, 0x8C, 0x80, 0x08, 0xFC, 
  0x00, 0x44, 0x0F, 0x90, 0x22, 0xE0, 0x00, 0x80, 0x12, 0xFF, 
  0x87, 0xFF, 0xFE, 0x1F, 0x0F, 0xFC, 0x0C, 0x0F, 0xFE, 0x1F, 
  0x81, 0xFF, 0xC3, 0xFF, 0xC1, 0xF0, 0x7F, 0x8C, 0x80, 0x08, 
  0xFC, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x80, 0x12, 
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 
  0x1F, 0xC1, 0xFF, 0xC3, 0xFF, 0xC1, 0xF0, 0x7F, 0x8C, 0x80, 
  0x08, 0xFC, 0x08, 0x13, 0x67, 0xE0, 0x2C, 0x60, 0x00, 0x80, 
  0x12, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x0F, 0xFE, 0x00, 0x1F, 
  0xFE, 0x1F, 0xC1, 0xFF, 0xC3, 0xFF, 0x81, 0xF8, 0x3F, 0x8C, 
  0x80, 0x08, 0xFC, 0x51, 0x0C, 0x67, 0xE0, 0x01, 0x60, 0x00, 
  0x80, 0x12, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x0F, 0xFF, 0x00, 
  0x3F, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xF8, 0x3F, 
  0x8C, 0x80, 0x08, 0xFC, 0x08, 0x20, 0xA7, 0xFB, 0x01, 0x60, 
  0x00, 0x80, 0x12, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x0F, 0xFF, 
  0x80, 0x7F, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xF8, 
  0x3F, 0x8C, 0x80, 0x08, 0xFC, 0x08, 0x87, 0x03, 0xF1, 0x41, 
  0x60, 0x00, 0x80, 0x12, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x0F, 
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 
  0xFC, 0x3F, 0x8C, 0x80, 0x08, 0xFD, 0x24, 0x04, 0x01, 0xF0, 
  0x00, 0x60, 0x00, 0x9E, 0x80, 0x08, 0xFC, 0x48, 0x50, 0x01, 
  0xF9, 0x00, 0x60, 0x00, 0x9E, 0x80, 0x08, 0xFC, 0x58, 0x20, 
  0x0E, 0xFA, 0x00, 0x60, 0x00, 0x9E, 0x80, 0x08, 0xFD, 0x84, 
  0x10, 0x21, 0xFC, 0x15, 0xE0, 0x00, 0x9E, 0x80, 0x08, 0xFC, 
  0x26, 0x40, 0x00, 0x7C, 0x0A, 0x60, 0x00, 0x9E, 0x80, 0x08, 
  0xFC, 0x48, 0x08, 0x82, 0x7D, 0x66, 0x60, 0x00, 0x9E, 0x80, 
  0x08, 0xFC, 0x30, 0x84, 0xC0, 0x7C, 0x00, 0x60, 0x00, 0x80, 
  0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x22, 0x0C, 0x88, 0x7E, 
  0xD0, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 
  0x01, 0x10, 0x02, 0xFD, 0x20, 0xE0, 0x00, 0x80, 0x01, 0x80, 
  0x1D, 0x80, 0x08, 0x1C, 0x02, 0x40, 0x02, 0xF8, 0x02, 0xE0, 
  0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0xC0, 0x02, 
  0xA1, 0xFC, 0x01, 0x60, 0x00, 0x80, 0x06, 0x80, 0x78, 0x40, 
  0x20, 0x08, 0x04, 0x18, 0x80, 0x08, 0x1D, 0x10, 0x02, 0x21, 
  0xF0, 0x94, 0x60, 0x00, 0x80, 0x06, 0x80, 0x44, 0x40, 0x20, 
  0x08, 0x08, 0x18, 0x80, 0x08, 0x1C, 0x48, 0x12, 0xA3, 0xF1, 
  0x88, 0x60, 0x00, 0x80, 0x06, 0x80, 0x42, 0x00, 0x20, 0x08, 
  0x08, 0x18, 0x80, 0x08, 0x1C, 0x00, 0x58, 0x83, 0xF8, 0x20, 
  0xE0, 0x00, 0x80, 0x08, 0x80, 0x42, 0x56, 0x20, 0x0B, 0x9C, 
  0xE5, 0x76, 0x16, 0x80, 0x08, 0x1C, 0x40, 0x05, 0x1F, 0xE0, 
  0x00, 0x60, 0x00, 0x80, 0x08, 0x80, 0x42, 0x59, 0x20, 0x0A, 
  0x49, 0x16, 0x49, 0x16, 0x80, 0x08, 0x1C, 0x02, 0x50, 0x0F, 
  0xC0, 0x21, 0x60, 0x00, 0x80, 0x08, 0x80, 0x42, 0x51, 0x21, 
  0xCA, 0x49, 0x14, 0x49, 0x16, 0x80, 0x08, 0x1C, 0x40, 0x00, 
  0x0F, 0xC0, 0x55, 0x60, 0x00, 0x80, 0x08, 0x80, 0x42, 0x51, 
  0x20, 0x0A, 0x49, 0x14, 0x49, 0x16, 0x80, 0x08, 0x1C, 0x28, 
  0x10, 0x8F, 0xCB, 0x0A, 0x60, 0x00, 0x80, 0x09, 0x80, 0x44, 
  0x59, 0x2C, 0x0A, 0x49, 0x14, 0x49, 0x60, 0x15, 0x80, 0x08, 
  0x1D, 0x0A, 0x08, 0x0F, 0xA4, 0x04, 0x60, 0x00, 0x80, 0x09, 
  0x80, 0x78, 0x56, 0x2C, 0x0A, 0x48, 0xE4, 0x49, 0x60, 0x15, 
  0x80, 0x08, 0x1C, 0xC2, 0x03, 0x1F, 0x90, 0xB0, 0x60, 0x00, 
  0x80, 0x03, 0x80, 0x00, 0x10, 0x1B, 0x80, 0x08, 0x1D, 0x58, 
  0xC4, 0x3F, 0x41, 0x13, 0x60, 0x00, 0x80, 0x03, 0x80, 0x00, 
  0x10, 0x1B, 0x80, 0x08, 0x1D, 0x00, 0x4A, 0xBF, 0x62, 0x43, 
  0xE0, 0x00, 0x80, 0x03, 0x80, 0x00, 0x10, 0x1B, 0x80, 0x08, 
  0x1D, 0x08, 0x52, 0x7E, 0x4C, 0x0C, 0x60, 0x00, 0x80, 0x02, 
  0x80, 0x7E, 0x06, 0x80, 0x01, 0xFE, 0x02, 0x80, 0x01, 0x0F, 
  0x06, 0x80, 0x01, 0x30, 0x0B, 0x80, 0x08, 0x1D, 0x00, 0x10, 
  0xFF, 0x80, 0x71, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x7F, 0x86, 
  0x04, 0x80, 0x06, 0x01, 0xFF, 0x00, 0x03, 0x1F, 0x80, 0x05, 
  0x80, 0x01, 0x30, 0x0B, 0x80, 0x08, 0x1C, 0xD0, 0x22, 0xFD, 
  0x30, 0x1A, 0x60, 0x00, 0x80, 0x05, 0x80, 0x61, 0xC6, 0x00, 
  0x18, 0x02, 0x80, 0x06, 0x03, 0x83, 0x80, 0x03, 0x39, 0xC0, 
  0x05, 0x80, 0x01, 0x30, 0x0B, 0x80, 0x08, 0x1C, 0x48, 0x81, 
  0xFE, 0x99, 0x84, 0x60, 0x00, 0x80, 0x05, 0x80, 0x60, 0xC0, 
  0x00, 0x18, 0x02, 0x80, 0x02, 0x07, 0x01, 0x02, 0x80, 0x02, 
  0x30, 0xC0, 0x05, 0x80, 0x01, 0x30, 0x0B, 0x80, 0x08, 0x1D, 
  0x40, 0x00, 0x7E, 0x32, 0xC5, 0x60, 0x00, 0x80, 0x05, 0x80, 
  0x60, 0x60, 0x00, 0x18, 0x02, 0x80, 0x01, 0x06, 0x03, 0x80, 
  0x02, 0x30, 0xC0, 0x05, 0x80, 0x01, 0x30, 0x0B, 0x80, 0x08, 
  0x1C, 0x28, 0x00, 0x7C, 0x0A, 0x33, 0x60, 0x00, 0x80, 0x0D, 
  0x80, 0x60, 0x66, 0x3E, 0x3E, 0x3E, 0x36, 0x06, 0x00, 0x07, 
  0xC3, 0x30, 0xC0, 0x02, 0x80, 0x04, 0x61, 0xB7, 0x07, 0xB0, 
  0x0B, 0x80, 0x08, 0x1D, 0x42, 0x48, 0xFC, 0x54, 0xC2, 0xE0, 
  0x00, 0x80, 0x0D, 0x80, 0x60, 0x66, 0x7F, 0x3E, 0x7F, 0x3E, 
  0x06, 0x00, 0x0F, 0xE3, 0x33, 0x80, 0x02, 0x80, 0x04, 0x61, 
  0xBF, 0x8F, 0xF0, 0x0B, 0x80, 0x08, 0x1C, 0x02, 0x92, 0x3E, 
  0x34, 0x05, 0xE0, 0x00, 0x80, 0x0D, 0x80, 0x60, 0x66, 0xE3, 
  0x98, 0xE3, 0xB8, 0x06, 0x1F, 0xDC, 0x73, 0x33, 0xC0, 0x02, 
  0x80, 0x04, 0x61, 0xB9, 0xDC, 0x70, 0x0B, 0x80, 0x08, 0x1D, 
  0x0A, 0xE0, 0x3E, 0x04, 0x4D, 0xE0, 0x00, 0x80, 0x0D, 0x80, 
  0x60, 0x66, 0xC1, 0x98, 0xC1, 0xB0, 0x06, 0x1F, 0xD8, 0x33, 
  0x30, 0xE0, 0x02, 0x80, 0x04, 0x61, 0xB0, 0xD8, 0x30, 0x0B, 
  0x80, 0x08, 0x1D, 0x61, 0x53, 0xBE, 0x20, 0xC4, 0x60, 0x00, 
  0x80, 0x0D, 0x80, 0x60, 0x66, 0xFF, 0x98, 0xFF, 0xB0, 0x06, 
  0x00, 0xDF, 0xF3, 0x30, 0x60, 0x02, 0x80, 0x04, 0x61, 0xB0, 
  0xD8, 0x30, 0x0B, 0x80, 0x08, 0x1C, 0x12, 0x1E, 0x1F, 0xC8, 
  0x5B, 0x60, 0x00, 0x80, 0x0D, 0x80, 0x60, 0x66, 0xFF, 0x98, 
  0xFF, 0xB0, 0x06, 0x00, 0xDF, 0xF3, 0x30, 0x60, 0x02, 0x80, 
  0x04, 0x61, 0xB0, 0xD8, 0x30, 0x0B, 0x80, 0x08, 0x1C, 0x11, 
  0xD1, 0x9F, 0x4C, 0xA0, 0x60, 0x00, 0x80, 0x0D, 0x80, 0x60, 
  0xC6, 0xC0, 0x18, 0xC0, 0x30, 0x07, 0x01, 0xD8, 0x03, 0x30, 
  0x60, 0x02, 0x80, 0x04, 0x61, 0xB0, 0xD8, 0x30, 0x0B, 0x80, 
  0x08, 0x1C, 0x01, 0x80, 0x1F, 0x51, 0x02, 0x60, 0x00, 0x80, 
  0x0D, 0x80, 0x61, 0xC6, 0xE3, 0x18, 0xE3, 0x30, 0x03, 0x83, 
  0x9C, 0x63, 0x30, 0xC0, 0x02, 0x80, 0x04, 0x73, 0xB0, 0xDC, 
  0x70, 0x0B, 0x80, 0x08, 0x1C, 0x73, 0x10, 0xBF, 0xD5, 0x0C, 
  0xE0, 0x00, 0x80, 0x0D, 0x80, 0x7F, 0x86, 0x7F, 0x18, 0x7F, 
  0x30, 0x01, 0xFF, 0x0F, 0xE3, 0x37, 0xC0, 0x02, 0x80, 0x04, 
  0x3F, 0x30, 0xCF, 0xF0, 0x0B, 0x80, 0x08, 0x1C, 0x21, 0x8A, 
  0x2F, 0x80, 0x45, 0x60, 0x00, 0x80, 0x0D, 0x80, 0x7E, 0x06, 
  0x3E, 0x18, 0x3E, 0x30, 0x00, 0xFE, 0x07, 0xC3, 0x37, 0x80, 
  0x02, 0x80, 0x04, 0x1E, 0x30, 0xC7, 0xB0, 0x0B, 0x80, 0x08, 
  0x1D, 0x98, 0x43, 0x0F, 0xD8, 0x10, 0x60, 0x00, 0x80, 0x01, 
  0x80, 0x1D, 0x80, 0x08, 0x1C, 0x08, 0xA0, 0x0F, 0xC0, 0xB9, 
  0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x52, 
  0x02, 0x07, 0xC1, 0xB8, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x1D, 
  0x80, 0x08, 0x1D, 0xB0, 0x44, 0x03, 0xE1, 0x5B, 0x60, 0x00, 
  0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1D, 0x40, 0xA0, 0x83, 
  0xF5, 0x40, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 
  0x1D, 0x2F, 0x84, 0x87, 0xE2, 0x04, 0xE0, 0x00, 0x80, 0x01, 
  0x80, 0x1D, 0x80, 0x08, 0x1C, 0xAB, 0x39, 0xC5, 0xF0, 0x07, 
  0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x4C, 
  0xA2, 0xD3, 0xF2, 0x9C, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 
  0x80, 0x08, 0x1C, 0x70, 0x09, 0x21, 0xFB, 0x40, 0x60, 0x00, 
  0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1D, 0x88, 0xC0, 0xF0, 
  0xF8, 0x2B, 0xE0, 0x00, 0x80, 0x06, 0x80, 0x78, 0x40, 0x20, 
  0x08, 0x04, 0x18, 0x80, 0x08, 0x1C, 0x50, 0x88, 0x03, 0xF9, 
  0x02, 0x60, 0x00, 0x80, 0x06, 0x80, 0x44, 0x40, 0x20, 0x08, 
  0x08, 0x18, 0x80, 0x08, 0x1C, 0x27, 0x3C, 0x07, 0xFA, 0x52, 
  0x60, 0x00, 0x80, 0x06, 0x80, 0x42, 0x00, 0x20, 0x08, 0x08, 
  0x18, 0x80, 0x08, 0x1C, 0x10, 0x99, 0x61, 0xFA, 0x52, 0x60, 
  0x00, 0x80, 0x08, 0x80, 0x42, 0x56, 0x20, 0x0B, 0x9C, 0xE5, 
  0x76, 0x16, 0x80, 0x08, 0x1C, 0xA4, 0xD7, 0x0F, 0xE3, 0x00, 
  0x60, 0x00, 0x80, 0x08, 0x80, 0x42, 0x59, 0x20, 0x0A, 0x49, 
  0x16, 0x49, 0x16, 0x80, 0x08, 0x1D, 0x56, 0x08, 0x0F, 0xE9, 
  0x80, 0x60, 0x00, 0x80, 0x08, 0x80, 0x42, 0x51, 0x21, 0xCA, 
  0x49, 0x14, 0x49, 0x16, 0x80, 0x08, 0x1D, 0x45, 0xCD, 0x8F, 
  0xE0, 0x91, 0x60, 0x00, 0x80, 0x08, 0x80, 0x42, 0x51, 0x20, 
  0x0A, 0x49, 0x14, 0x49, 0x16, 0x80, 0x08, 0x1C, 0x04, 0x78, 
  0x5B, 0xF1, 0x00, 0xE0, 0x00, 0x80, 0x09, 0x80, 0x44, 0x59, 
  0x2C, 0x0A, 0x49, 0x14, 0x49, 0x60, 0x15, 0x80, 0x08, 0x1D, 
  0x82, 0x30, 0x6F, 0xE8, 0x14, 0xE0, 0x00, 0x80, 0x09, 0x80, 
  0x78, 0x56, 0x2C, 0x0A, 0x48, 0xE4, 0x49, 0x60, 0x15, 0x80, 
  0x08, 0x1D, 0xA5, 0xA4, 0x83, 0xE3, 0x43, 0x60, 0x00, 0x80, 
  0x03, 0x80, 0x00, 0x10, 0x1B, 0x80, 0x08, 0x1C, 0x33, 0x83, 
  0x47, 0xD0, 0x14, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x00, 0x10, 
  0x1B, 0x80, 0x08, 0x1C, 0xC0, 0x04, 0x2F, 0xF2, 0x02, 0xE0, 
  0x00, 0x80, 0x03, 0x80, 0x00, 0x10, 0x1B, 0x80, 0x08, 0x1C, 
  0x5A, 0x00, 0xA7, 0xC0, 0x8C, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x1D, 0x80, 0x08, 0x1C, 0x30, 0x21, 0x2F, 0xB5, 0xAC, 0xE0, 
  0x00, 0x80, 0x02, 0x80, 0x03, 0x06, 0x80, 0x02, 0x07, 0xF0, 
  0x02, 0x80, 0x01, 0x78, 0x11, 0x80, 0x08, 0x1C, 0xC8, 0x21, 
  0x2F, 0x85, 0x24, 0x60, 0x00, 0x80, 0x03, 0x80, 0x03, 0x33, 
  0x05, 0x80, 0x05, 0x0F, 0xF8, 0x00, 0x18, 0xFC, 0x11, 0x80, 
  0x08, 0x1C, 0x19, 0x25, 0x2F, 0x94, 0xA3, 0x60, 0x00, 0x80, 
  0x03, 0x80, 0x03, 0x33, 0x05, 0x80, 0x05, 0x1C, 0x1C, 0x00, 
  0x19, 0xCE, 0x11, 0x80, 0x08, 0x1C, 0x05, 0x07, 0x3F, 0xD0, 
  0x4A, 0x60, 0x00, 0x80, 0x02, 0x80, 0x03, 0x06, 0x80, 0x05, 
  0x38, 0x08, 0x00, 0x01, 0x86, 0x11, 0x80, 0x08, 0x1D, 0x0E, 
  0x29, 0x6F, 0x8E, 0x86, 0xE0, 0x00, 0x80, 0x02, 0x80, 0x03, 
  0x06, 0x80, 0x01, 0x30, 0x02, 0x80, 0x02, 0x01, 0x86, 0x11, 
  0x80, 0x08, 0x1D, 0x02, 0x21, 0x1F, 0x44, 0x80, 0x60, 0x00, 
  0x80, 0x0D, 0x80, 0x03, 0x61, 0xB6, 0x3D, 0x8F, 0x8D, 0xC0, 
  0x30, 0x00, 0x3E, 0x19, 0x86, 0x11, 0x80, 0x08, 0x1C, 0x00, 
  0x6C, 0x0F, 0x79, 0xC5, 0xE0, 0x00, 0x80, 0x0D, 0x80, 0x03, 
  0x61, 0xBE, 0x7F, 0x9F, 0xCF, 0xE0, 0x30, 0x00, 0x7F, 0x19, 
  0x9C, 0x11, 0x80, 0x08, 0x1C, 0x09, 0x40, 0x9F, 0x84, 0x00, 
  0x60, 0x00, 0x80, 0x0D, 0x80, 0x03, 0x61, 0xB8, 0xE3, 0xB8, 
  0xEE, 0x70, 0x30, 0xFE, 0xE3, 0x99, 0x9E, 0x11, 0x80, 0x08, 
  0x1C, 0x08, 0x00, 0x1F, 0x40, 0x04, 0x60, 0x00, 0x80, 0x0D, 
  0x80, 0x03, 0x61, 0xB0, 0xC1, 0xB0, 0x6C, 0x30, 0x30, 0xFE, 
  0xC1, 0x99, 0x87, 0x11, 0x80, 0x08, 0x1C, 0x9A, 0x2C, 0x1F, 
  0x04, 0x18, 0xE0, 0x00, 0x80, 0x0D, 0x80, 0x03, 0x61, 0xB0, 
  0xC1, 0xBF, 0xEC, 0x30, 0x30, 0x06, 0xFF, 0x99, 0x83, 0x11, 
  0x80, 0x08, 0x1C, 0x84, 0x05, 0x9E, 0xE2, 0x08, 0xE0, 0x00, 
  0x80, 0x0D, 0x80, 0x03, 0x61, 0xB0, 0xC1, 0xBF, 0xEC, 0x30, 
  0x30, 0x06, 0xFF, 0x99, 0x83, 0x11, 0x80, 0x08, 0x1C, 0x40, 
  0x63, 0xBF, 0x14, 0x58, 0x60, 0x00, 0x80, 0x0D, 0x80, 0x03, 
  0x61, 0xB0, 0xC1, 0xB0, 0x0C, 0x30, 0x38, 0x0E, 0xC0, 0x19, 
  0x83, 0x11, 0x80, 0x08, 0x1D, 0x20, 0x08, 0x3F, 0x51, 0x00, 
  0x60, 0x00, 0x80, 0x0D, 0x80, 0x66, 0x73, 0xB0, 0xE3, 0xB8, 
  0xCC, 0x30, 0x1C, 0x1C, 0xE3, 0x19, 0x86, 0x11, 0x80, 0x08, 
  0x1C, 0xA4, 0x21, 0x3E, 0x40, 0x00, 0x60, 0x00, 0x80, 0x0D, 
  0x80, 0x7E, 0x3F, 0x30, 0x7F, 0x9F, 0xCC, 0x30, 0x0F, 0xF8, 
  0x7F, 0x19, 0xBE, 0x11, 0x80, 0x08, 0x1C, 0x85, 0x00, 0x3E, 
  0xAD, 0x02, 0x60, 0x00, 0x80, 0x0D, 0x80, 0x3C, 0x1E, 0x30, 
  0x3D, 0x8F, 0x8C, 0x30, 0x07, 0xF0, 0x3E, 0x19, 0xBC, 0x11, 
  0x80, 0x08, 0x1C, 0x82, 0x40, 0x3E, 0x09, 0x08, 0x60, 0x00, 
  0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x01, 0x80, 0x18, 0x80, 
  0x08, 0x1C, 0x13, 0x20, 0x3E, 0x3A, 0x8C, 0x60, 0x00, 0x80, 
  0x01, 0x80, 0x03, 0x80, 0x02, 0x01, 0x80, 0x18, 0x80, 0x08, 
  0x1C, 0x40, 0x00, 0xBE, 0x93, 0x0C, 0x60, 0x00, 0x80, 0x01, 
  0x80, 0x03, 0x80, 0x02, 0x63, 0x80, 0x18, 0x80, 0x08, 0x1C, 
  0x42, 0x88, 0xBF, 0x02, 0x52, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x03, 0x80, 0x01, 0x7F, 0x19, 0x80, 0x08, 0x1C, 0x19, 0x00, 
  0x1F, 0x21, 0x02, 0x60, 0x00, 0x80, 0x01, 0x80, 0x03, 0x80, 
  0x01, 0x3E, 0x19, 0x80, 0x08, 0x1C, 0x10, 0xC1, 0x1F, 0x20, 
  0x91, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 
  0x82, 0x68, 0x1F, 0x84, 0x42, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x1D, 0x80, 0x08, 0x1D, 0x18, 0x40, 0x2F, 0x80, 0x02, 0xE0, 
  0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x21, 0x82, 
  0x0F, 0x84, 0xE0, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 
  0x08, 0x1C, 0x3F, 0x11, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x80, 
  0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x31, 0x0C, 0xCF, 0xE0, 
  0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 
  0x4C, 0x85, 0xB7, 0xE0, 0x8A, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x1D, 0x80, 0x08, 0x1C, 0xD0, 0x14, 0x67, 0xE2, 0x20, 0x60, 
  0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x02, 0x15, 
  0xF3, 0xF4, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 
  0x08, 0x1D, 0xA0, 0x20, 0x91, 0xF0, 0x00, 0x60, 0x00, 0x80, 
  0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x62, 0x16, 0x0B, 0xFA, 
  0x02, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 
  0x25, 0x9F, 0x11, 0xFE, 0x43, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x1D, 0x80, 0x08, 0x1D, 0x22, 0x22, 0x6A, 0xF8, 0x40, 0x60, 
  0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0xB0, 0xB4, 
  0x94, 0xFA, 0x0E, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 
  0x08, 0x1C, 0x02, 0x10, 0x29, 0xFA, 0x24, 0xE0, 0x00, 0x80, 
  0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0xA5, 0x0D, 0x06, 0x78, 
  0x81, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 
  0x04, 0x08, 0x30, 0x7C, 0x64, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x1D, 0x80, 0x08, 0x1C, 0x40, 0x80, 0x86, 0xFD, 0x51, 0x60, 
  0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x02, 0x97, 
  0x21, 0xFA, 0x94, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 
  0x08, 0x1C, 0x88, 0x10, 0x14, 0xFA, 0xD4, 0x60, 0x00, 0x80, 
  0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x50, 0x81, 0x00, 0xF4, 
  0x0E, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1D, 
  0xD7, 0x20, 0x30, 0xF7, 0x58, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x1D, 0x80, 0x08, 0x1C, 0x83, 0x90, 0xC0, 0xF8, 0xD0, 0x60, 
  0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x84, 0x18, 
  0xAB, 0xF8, 0x83, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 
  0x08, 0x1D, 0xC1, 0x61, 0x13, 0xF0, 0xB0, 0x60, 0x00, 0x80, 
  0x0A, 0x80, 0x7C, 0x01, 0x8E, 0x0E, 0x18, 0x00, 0x80, 0x00, 
  0x0C, 0x05, 0x80, 0x01, 0x38, 0x05, 0x80, 0x05, 0xC6, 0x00, 
  0x03, 0x00, 0xD8, 0x04, 0x80, 0x08, 0x1C, 0xE0, 0x10, 0x31, 
  0xF2, 0x87, 0xE0, 0x00, 0x80, 0x0A, 0x81, 0x83, 0x03, 0x9F, 
  0x1F, 0x38, 0x00, 0x80, 0x00, 0x0C, 0x05, 0x80, 0x01, 0x7C, 
  0x05, 0x80, 0x05, 0xC6, 0x00, 0x03, 0x00, 0xD8, 0x04, 0x80, 
  0x08, 0x1C, 0x52, 0x83, 0x43, 0xE1, 0x4C, 0xE0, 0x00, 0x80, 
  0x0D, 0x82, 0x00, 0x81, 0xBB, 0xBB, 0x98, 0x01, 0xC0, 0x00, 
  0x0D, 0x80, 0x00, 0xCC, 0x02, 0x80, 0x03, 0xCC, 0x00, 0x18, 
  0x03, 0x80, 0x05, 0xC6, 0x01, 0x83, 0x00, 0xD8, 0x04, 0x80, 
  0x08, 0x1C, 0x0C, 0xA0, 0xF5, 0xE8, 0x14, 0xE0, 0x00, 0x80, 
  0x0D, 0x84, 0x78, 0x41, 0xB1, 0xB1, 0x98, 0x01, 0xC0, 0x00, 
  0x0D, 0x80, 0x00, 0xCC, 0x02, 0x80, 0x03, 0xC0, 0x00, 0x18, 
  0x03, 0x80, 0x05, 0xC6, 0x01, 0x83, 0x00, 0xD8, 0x04, 0x80, 
  0x08, 0x1C, 0x40, 0x2C, 0x01, 0xE1, 0x00, 0x60, 0x00, 0x80, 
  0x0A, 0x84, 0xE4, 0x41, 0xB1, 0xB1, 0x98, 0x01, 0xC0, 0x00, 
  0x0C, 0x02, 0x80, 0x01, 0xC0, 0x02, 0x80, 0x03, 0xC0, 0x00, 
  0x18, 0x03, 0x80, 0x05, 0xC6, 0x00, 0x03, 0x00, 0xD8, 0x04, 
  0x80, 0x08, 0x1C, 0x29, 0x00, 0x43, 0xE0, 0x45, 0xE0, 0x00, 
  0x80, 0x26, 0x84, 0xC0, 0x41, 0xBB, 0xBB, 0x98, 0x03, 0x63, 
  0x66, 0xCD, 0x9C, 0x6D, 0xEC, 0xF3, 0x40, 0x71, 0xB3, 0x3C, 
  0xF3, 0x68, 0xC0, 0xFE, 0x79, 0x9B, 0x3C, 0xDB, 0x1E, 0x53, 
  0x60, 0x00, 0x1D, 0x30, 0x09, 0x93, 0xFA, 0x92, 0x60, 0x00, 
  0x80, 0x26, 0x84, 0xC0, 0x41, 0x9F, 0x1F, 0x18, 0x03, 0x63, 
  0xB7, 0x6D, 0xBE, 0xFD, 0xED, 0xFB, 0xE0, 0x39, 0xB7, 0xBD, 
  0xFB, 0xFD, 0xE0, 0xFE, 0xFD, 0xBF, 0x7E, 0xDD, 0xBF, 0x77, 
  0xE0, 0x00, 0x1D, 0x09, 0xF3, 0x97, 0xE5, 0x42, 0x60, 0x00, 
  0x80, 0x26, 0x84, 0xC0, 0x41, 0x8F, 0x0F, 0x18, 0x06, 0x33, 
  0x36, 0x6D, 0xB0, 0xCC, 0xCD, 0x9B, 0x60, 0x1D, 0xB6, 0x19, 
  0x9B, 0x6D, 0x80, 0xC6, 0xCD, 0xB3, 0x66, 0xD9, 0xB3, 0x66, 
  0x60, 0x00, 0x1C, 0x03, 0x10, 0xD7, 0xE2, 0x11, 0x60, 0x00, 
  0x80, 0x26, 0x84, 0xE4, 0x41, 0x83, 0x03, 0x18, 0x07, 0xF3, 
  0x36, 0x6D, 0xB0, 0xCC, 0xCD, 0x9B, 0x60, 0x0C, 0xE3, 0x19, 
  0xFB, 0x6C, 0xC0, 0xC6, 0xFD, 0xB3, 0x7E, 0xD9, 0xBF, 0x66, 
  0x60, 0x00, 0x1C, 0xC0, 0x02, 0xA3, 0xF9, 0x8D, 0x60, 0x00, 
  0x80, 0x26, 0x84, 0x78, 0x41, 0x86, 0x06, 0x18, 0x07, 0xF3, 
  0x36, 0x6D, 0xB0, 0xCC, 0xCD, 0x9B, 0x60, 0xCC, 0xE1, 0x99, 
  0x83, 0x6C, 0x60, 0xC6, 0xC1, 0xB3, 0x60, 0xD9, 0xB0, 0x66, 
  0x60, 0x00, 0x1C, 0x6C, 0x21, 0xE3, 0xF8, 0x00, 0x60, 0x00, 
  0x80, 0x26, 0x82, 0x00, 0x81, 0x8C, 0x0C, 0x18, 0x0C, 0x1B, 
  0xB7, 0x6D, 0xBE, 0xFC, 0xCD, 0xFB, 0x60, 0xF8, 0xC7, 0x99, 
  0xFB, 0x6D, 0xE0, 0xC6, 0xFD, 0xBF, 0x7E, 0xDD, 0xBF, 0x67, 
  0xE0, 0x00, 0x1C, 0x01, 0x41, 0x59, 0xF4, 0x06, 0x60, 0x00, 
  0x80, 0x26, 0x81, 0x83, 0x01, 0x8C, 0x0C, 0x18, 0x0C, 0x1B, 
  0x66, 0xCD, 0x9C, 0x6C, 0xCC, 0xF3, 0x60, 0x70, 0xC3, 0x18, 
  0xF3, 0x6C, 0xC0, 0xC6, 0x79, 0x9B, 0x3C, 0xDB, 0x1E, 0x63, 
  0x60, 0x00, 0x1C, 0x05, 0x24, 0x07, 0xFB, 0x04, 0xE0, 0x00, 
  0x80, 0x02, 0x80, 0x7C, 0x05, 0x80, 0x02, 0x03, 0x06, 0x06, 
  0x80, 0x02, 0x01, 0x80, 0x0B, 0x80, 0x0A, 0x60, 0x00, 0x1D, 
  0x00, 0x02, 0x81, 0xFC, 0x29, 0x60, 0x00, 0x80, 0x01, 0x80, 
  0x06, 0x80, 0x02, 0x03, 0x06, 0x06, 0x80, 0x02, 0x01, 0x80, 
  0x0A, 0x80, 0x0B, 0x06, 0x60, 0x00, 0x1C, 0x73, 0x40, 0x62, 
  0xFA, 0xD3, 0x60, 0x00, 0x80, 0x01, 0x80, 0x06, 0x80, 0x02, 
  0x03, 0x06, 0x06, 0x80, 0x02, 0x01, 0x80, 0x0A, 0x80, 0x0B, 
  0x03, 0xC0, 0x00, 0x1C, 0x10, 0x24, 0x65, 0xF8, 0x5E, 0xE0, 
  0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0x01, 0x10, 
  0x02, 0xFD, 0x20, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 
  0x08, 0x1C, 0x02, 0x40, 0x02, 0xF8, 0x02, 0xE0, 0x00, 0x80, 
  0x01, 0x80, 0x1D, 0x80, 0x08, 0x1C, 0xC0, 0x02, 0xA1, 0xFC, 
  0x01, 0x60, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 0x08, 0x1D, 
  0x10, 0x02, 0x21, 0xF0, 0x94, 0x60, 0x00, 0x80, 0x03, 0x80, 
  0x00, 0x07, 0x02, 0x80, 0x13, 0x20, 0x01, 0x00, 0x39, 0xC0, 
  0xE0, 0x80, 0x20, 0x80, 0x11, 0x10, 0x04, 0x71, 0xC7, 0x00, 
  0x88, 0x04, 0x10, 0x0A, 0x06, 0x80, 0x08, 0x1C, 0x48, 0x12, 
  0xA3, 0xF1, 0x88, 0x60, 0x00, 0x80, 0x18, 0x80, 0x00, 0x04, 
  0x80, 0x04, 0x40, 0x01, 0x00, 0x0A, 0x21, 0x11, 0x00, 0x61, 
  0x00, 0x11, 0x10, 0x08, 0x8A, 0x28, 0x80, 0x88, 0x04, 0x10, 
  0x0A, 0x06, 0x80, 0x08, 0x1C, 0x00, 0x58, 0x83, 0xF8, 0x20, 
  0xE0, 0x00, 0x80, 0x18, 0x80, 0x00, 0x04, 0x80, 0x04, 0x40, 
  0x01, 0x00, 0x0A, 0x21, 0x12, 0x00, 0xA2, 0x00, 0x11, 0x10, 
  0x10, 0x8A, 0x28, 0x80, 0x88, 0x00, 0x10, 0x0A, 0x06, 0x80, 
  0x08, 0x1C, 0x40, 0x05, 0x1F, 0xE0, 0x00, 0x60, 0x00, 0x80, 
  0x1B, 0x80, 0x00, 0x04, 0x9C, 0x6E, 0xE6, 0x99, 0xC0, 0x0A, 
  0x20, 0x13, 0x80, 0xA3, 0x80, 0x0A, 0xA0, 0x1C, 0x8A, 0x28, 
  0x80, 0x89, 0xC4, 0xD3, 0x8A, 0xC7, 0x29, 0xA0, 0x03, 0x80, 
  0x08, 0x1C, 0x02, 0x50, 0x0F, 0xC0, 0x21, 0x60, 0x00, 0x80, 
  0x1B, 0x80, 0x00, 0x07, 0x22, 0x84, 0x49, 0xA5, 0x20, 0x0A, 
  0x20, 0x24, 0x41, 0x24, 0x40, 0x0A, 0xA0, 0x22, 0x8A, 0x28, 
  0x80, 0xFA, 0x25, 0x34, 0x4B, 0x28, 0xB2, 0x60, 0x03, 0x80, 
  0x08, 0x1C, 0x40, 0x00, 0x0F, 0xC0, 0x55, 0x60, 0x00, 0x80, 
  0x1B, 0x80, 0x00, 0x04, 0x22, 0x44, 0x48, 0xA1, 0x20, 0x0A, 
  0x20, 0x44, 0x41, 0x24, 0x40, 0x0A, 0xA7, 0x22, 0x72, 0x28, 
  0x80, 0x8B, 0xE5, 0x17, 0xCA, 0x2F, 0xA2, 0x20, 0x03, 0x80, 
  0x08, 0x1C, 0x28, 0x10, 0x8F, 0xCB, 0x0A, 0x60, 0x00, 0x80, 
  0x1B, 0x80, 0x00, 0x04, 0x22, 0x24, 0x48, 0xA1, 0x20, 0x0A, 
  0x20, 0x84, 0x43, 0xF4, 0x40, 0x04, 0x40, 0x22, 0x12, 0x28, 
  0x80, 0x8A, 0x05, 0x14, 0x0A, 0x28, 0x22, 0x20, 0x03, 0x80, 
  0x08, 0x1D, 0x0A, 0x08, 0x0F, 0xA4, 0x04, 0x60, 0x00, 0x80, 
  0x1B, 0x80, 0x00, 0x04, 0x22, 0xA4, 0x49, 0xA5, 0x20, 0x0A, 
  0x21, 0x04, 0x40, 0x24, 0x40, 0x04, 0x40, 0x22, 0x22, 0x28, 
  0x80, 0x8A, 0x25, 0x34, 0x4B, 0x28, 0xA2, 0x60, 0x03, 0x80, 
  0x08, 0x1C, 0xC2, 0x03, 0x1F, 0x90, 0xB0, 0x60, 0x00, 0x80, 
  0x1B, 0x80, 0x00, 0x04, 0x1C, 0x44, 0x46, 0x99, 0x20, 0x09, 
  0xC1, 0xF3, 0x80, 0x23, 0x80, 0x04, 0x40, 0x1C, 0x41, 0xC7, 
  0x00, 0x89, 0xC4, 0xD3, 0x8A, 0xC7, 0x21, 0xA0, 0x03, 0x80, 
  0x08, 0x1D, 0x58, 0xC4, 0x3F, 0x41, 0x13, 0x60, 0x00, 0x80, 
  0x01, 0x80, 0x19, 0x80, 0x01, 0x20, 0x03, 0x80, 0x08, 0x1D, 
  0x00, 0x4A, 0xBF, 0x62, 0x43, 0xE0, 0x00, 0x80, 0x01, 0x80, 
  0x18, 0x80, 0x02, 0x02, 0x20, 0x03, 0x80, 0x08, 0x1D, 0x08, 
  0x52, 0x7E, 0x4C, 0x0C, 0x60, 0x00, 0x80, 0x01, 0x80, 0x18, 
  0x80, 0x02, 0x01, 0xC0, 0x03, 0x80, 0x08, 0x1D, 0x00, 0x10, 
  0xFF, 0x80, 0x71, 0xE0, 0x00, 0x80, 0x01, 0x80, 0x1D, 0x80, 
  0x08, 0x1C, 0xD0, 0x22, 0xFD, 0x30, 0x1A, 0x60, 0x00, 0x00, 
  0x00, 0xFF, 0x02, 0xA4, 0x80, 0x02, 0xE0, 0x00
}; /* logo */

