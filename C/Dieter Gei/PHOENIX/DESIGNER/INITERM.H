/*****************************************************************************/
/*                                                                           */
/* Modul: INITERM.H                                                          */
/* Datum: 23/05/89                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __INITERM__
#define __INITERM__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN init_initerm _((INT argc, BYTE *argv []));
GLOBAL BOOLEAN term_initerm _((VOID));

#endif /* __INITERM__ */

