/*****************************************************************************/
/*                                                                           */
/* Modul: MSELFILL.H                                                         */
/* Datum: 25/01/91                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MSELFILL__
#define __MSELFILL__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL BOOLEAN mselfill _((WORD *color, WORD *style, WORD *index));
GLOBAL BOOLEAN mselline _((WORD *type, WORD *width, WORD *bstyle, WORD *estyle));

#endif /* __MSELFILL__ */

