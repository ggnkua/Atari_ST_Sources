/*****************************************************************************/
/*                                                                           */
/* Modul: MSELBUTT.H                                                         */
/* Datum: 17/07/91                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __MSELBUTTON__
#define __MSELBUTTON__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL WORD mselbutton _((WINDOWP mask_window, WORD obj));

#endif /* __MSELBUTTON__ */

