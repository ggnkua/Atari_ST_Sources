/*****************************************************************************/
/*                                                                           */
/* Modul: BFORMAT.H                                                          */
/* Datum: 20/12/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BFORMAT__
#define __BFORMAT__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL WORD mformat _((WINDOWP base_window, WORD table, WORD field, WORD number, BYTE *name));

#endif /* __BFORMAT__ */

