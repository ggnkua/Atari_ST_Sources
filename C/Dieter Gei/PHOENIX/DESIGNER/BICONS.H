/*****************************************************************************/
/*                                                                           */
/* Modul: BICONS.H                                                           */
/* Datum: 28/10/90                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __BICONS__
#define __BICONS__

/****** DEFINES **************************************************************/

/****** TYPES ****************************************************************/

/****** VARIABLES ************************************************************/

/****** FUNCTIONS ************************************************************/

GLOBAL VOID    micons    _((BASE_SPEC *base_spec));
GLOBAL BOOLEAN load_icon _((WORD *mask, WORD *data, WORD *width, WORD *height, WORD title));

#endif /* __BICONS__ */

