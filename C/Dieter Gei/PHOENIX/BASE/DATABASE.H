/*****************************************************************************
 *
 * Module : DATABASE.H
 * Author : Dieter Geiß
 *
 * Creation date    : 01.07.89
 * Last modification: 26.10.92
 *
 *
 * Description: This module includes all other base modules.
 *
 * History:
 * 26.10.92: Module header added
 * 01.07.89: Creation of body
 *****************************************************************************/

#include "conv.h"
#include "files.h"
#include "utility.h"

#include "dbdata.h"
#include "dbtree.h"
#include "dbcall.h"
#include "dbcalc.h"

