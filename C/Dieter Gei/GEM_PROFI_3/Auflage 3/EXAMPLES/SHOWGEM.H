/* resource file indicies for SHOWGEM */

#define DIALOGH  0	/* form/dialog */
#define FILENAME 3	/* STRING in tree DIALOGH */
#define DSCREEN  6	/* ICON in tree DIALOGH */
#define DPLOTTER 7	/* ICON in tree DIALOGH */
#define DPRINTER 8	/* ICON in tree DIALOGH */
#define DCAMERA  9	/* ICON in tree DIALOGH */
#define SFULL    12	/* BOX in tree DIALOGH */
#define SBESTFIT 14	/* BOXCHAR in tree DIALOGH */
#define DSTOP    16	/* BOX in tree DIALOGH */
#define DSTART   21	/* BUTTON in tree DIALOGH */
#define DCANCEL  22	/* BUTTON in tree DIALOGH */

#define DIALOGL  1	/* form/dialog */

#define USERIMG  2	/* form/dialog */
#define RBHNORM  1	/* IMAGE in tree USERIMG */
#define RBHSEL   2	/* IMAGE in tree USERIMG */
#define RBLNORM  3	/* IMAGE in tree USERIMG */
#define RBLSEL   4	/* IMAGE in tree USERIMG */
#define CBHNORM  5	/* IMAGE in tree USERIMG */
#define CBHSEL   6	/* IMAGE in tree USERIMG */
#define CBLNORM  7	/* IMAGE in tree USERIMG */
#define CBLSEL   8	/* IMAGE in tree USERIMG */

#define WORKING  3	/* form/dialog */

#define FSTRINGS 4	/* form/dialog */
#define NSCREEN  1	/* STRING in tree FSTRINGS */
#define NPLOTTER 2	/* STRING in tree FSTRINGS */
#define NPRINTER 3	/* STRING in tree FSTRINGS */
#define NCAMERA  4	/* STRING in tree FSTRINGS */

#define NODEVICE 0	/* Alert string index */

#define NOMEMORY 1	/* Alert string index */

#define NOFILE   2	/* Alert string index */

