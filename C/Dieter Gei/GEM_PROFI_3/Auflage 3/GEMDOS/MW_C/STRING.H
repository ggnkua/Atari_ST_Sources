/*
   string.h
   --------

   by Dieter Geiss

   (not included in the official MWC development system)
*/


char *strcat   ();
char *strchr   ();
char *strcpy   ();
char *strerror ();
char *strncat  ();
char *strncpy  ();
char *strpbrk  ();
char *strrchr  ();
char *strstr   ();
char *strtok   ();

int  strcmp    ();
int  strcspn   ();
int  streq     ();
int  strlen    ();
int  strncmp   ();
int  strspn    ();


char *memchr   ();
char *memcpy   ();
char *memmove  ();
char *memset   ();

int  memcmp    ();

