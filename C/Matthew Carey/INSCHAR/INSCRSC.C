#include <aes.h>

static TEDINFO rs_tedinfo[] = {
/*0*/	{"123", "___", "999", IBM,0,TE_CNTR,0x1181,0,1,4,4},
};

OBJECT CH_TABLE[] = {
/*0*/	{-1,1,241,G_BOX,0x40,0x0,(void *)0x211a1,1794,1024,18,2320},
/*1*/	{240,2,223,G_BOX,0x0,0x0,(void *)0xff0181,1,2048,16,14},
/*2*/	{19,3,18,G_IBOX,0x0,0x0,(void *)0x1101,0,0,16,1},
/*3*/	{4,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x20001100,0,0,1,1},
/*4*/	{5,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x21001100,1,0,1,1},
/*5*/	{6,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x22001100,2,0,1,1},
/*6*/	{7,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x23001100,3,0,1,1},
/*7*/	{8,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x24001100,4,0,1,1},
/*8*/	{9,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x25001100,5,0,1,1},
/*9*/	{10,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x26001100,6,0,1,1},
/*10*/	{11,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x27001100,7,0,1,1},
/*11*/	{12,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x28001100,8,0,1,1},
/*12*/	{13,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x29001100,9,0,1,1},
/*13*/	{14,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x2a001100,10,0,1,1},
/*14*/	{15,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x2b001100,11,0,1,1},
/*15*/	{16,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x2c001100,12,0,1,1},
/*16*/	{17,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x2d001100,13,0,1,1},
/*17*/	{18,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x2e001100,14,0,1,1},
/*18*/	{2,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x2f001100,15,0,1,1},
/*19*/	{36,20,35,G_IBOX,0x0,0x0,(void *)0x1101,0,1,16,1},
/*20*/	{21,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x30001100,0,0,1,1},
/*21*/	{22,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x31001100,1,0,1,1},
/*22*/	{23,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x32001100,2,0,1,1},
/*23*/	{24,-1,-1,G_BOXCHAR,0x0,0x0,(void *)0x33001100,3,0,1,1},
/*24*/	{25,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x34001100,4,0,1,1},
/*25*/	{26,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x35001100,5,0,1,1},
/*26*/	{27,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x36001100,6,0,1,1},
/*27*/	{28,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x37001100,7,0,1,1},
/*28*/	{29,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x38001100,8,0,1,1},
/*29*/	{30,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x39001100,9,0,1,1},
/*30*/	{31,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x3a001100,10,0,1,1},
/*31*/	{32,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x3b001100,11,0,1,1},
/*32*/	{33,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x3c001100,12,0,1,1},
/*33*/	{34,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x3d001100,13,0,1,1},
/*34*/	{35,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x3e001100,14,0,1,1},
/*35*/	{19,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x3f001100,15,0,1,1},
/*36*/	{53,37,52,G_IBOX,0x0,0x0,(void *)0x1101,0,2,16,1},
/*37*/	{38,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x40001100,0,0,1,1},
/*38*/	{39,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x41001100,1,0,1,1},
/*39*/	{40,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x42001100,2,0,1,1},
/*40*/	{41,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x43001100,3,0,1,1},
/*41*/	{42,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x44001100,4,0,1,1},
/*42*/	{43,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x45001100,5,0,1,1},
/*43*/	{44,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x46001100,6,0,1,1},
/*44*/	{45,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x47001100,7,0,1,1},
/*45*/	{46,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x48001100,8,0,1,1},
/*46*/	{47,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x49001100,9,0,1,1},
/*47*/	{48,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x4a001100,10,0,1,1},
/*48*/	{49,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x4b001100,11,0,1,1},
/*49*/	{50,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x4c001100,12,0,1,1},
/*50*/	{51,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x4d001100,13,0,1,1},
/*51*/	{52,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x4e001100,14,0,1,1},
/*52*/	{36,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x4f001100,15,0,1,1},
/*53*/	{70,54,69,G_IBOX,0x0,0x0,(void *)0x1101,0,3,16,1},
/*54*/	{55,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x50001100,0,0,1,1},
/*55*/	{56,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x51001100,1,0,1,1},
/*56*/	{57,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x52001100,2,0,1,1},
/*57*/	{58,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x53001100,3,0,1,1},
/*58*/	{59,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x54001100,4,0,1,1},
/*59*/	{60,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x55001100,5,0,1,1},
/*60*/	{61,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x56001100,6,0,1,1},
/*61*/	{62,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x57001100,7,0,1,1},
/*62*/	{63,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x58001100,8,0,1,1},
/*63*/	{64,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x59001100,9,0,1,1},
/*64*/	{65,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x5a001100,10,0,1,1},
/*65*/	{66,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x5b001100,11,0,1,1},
/*66*/	{67,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x5c001100,12,0,1,1},
/*67*/	{68,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x5d001100,13,0,1,1},
/*68*/	{69,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x5e001100,14,0,1,1},
/*69*/	{53,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x5f001100,15,0,1,1},
/*70*/	{87,71,86,G_IBOX,0x0,0x0,(void *)0x1101,0,4,16,1},
/*71*/	{72,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x60001100,0,0,1,1},
/*72*/	{73,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x61001100,1,0,1,1},
/*73*/	{74,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x62001100,2,0,1,1},
/*74*/	{75,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x63001100,3,0,1,1},
/*75*/	{76,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x64001100,4,0,1,1},
/*76*/	{77,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x65001100,5,0,1,1},
/*77*/	{78,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x66001100,6,0,1,1},
/*78*/	{79,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x67001100,7,0,1,1},
/*79*/	{80,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x68001100,8,0,1,1},
/*80*/	{81,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x69001100,9,0,1,1},
/*81*/	{82,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x6a001100,10,0,1,1},
/*82*/	{83,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x6b001100,11,0,1,1},
/*83*/	{84,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x6c001100,12,0,1,1},
/*84*/	{85,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x6d001100,13,0,1,1},
/*85*/	{86,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x6e001100,14,0,1,1},
/*86*/	{70,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x6f001100,15,0,1,1},
/*87*/	{104,88,103,G_IBOX,0x0,0x0,(void *)0x1101,0,5,16,1},
/*88*/	{89,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x70001100,0,0,1,1},
/*89*/	{90,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x71001100,1,0,1,1},
/*90*/	{91,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x72001100,2,0,1,1},
/*91*/	{92,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x73001100,3,0,1,1},
/*92*/	{93,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x74001100,4,0,1,1},
/*93*/	{94,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x75001100,5,0,1,1},
/*94*/	{95,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x76001100,6,0,1,1},
/*95*/	{96,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x77001100,7,0,1,1},
/*96*/	{97,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x78001100,8,0,1,1},
/*97*/	{98,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x79001100,9,0,1,1},
/*98*/	{99,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x7a001100,10,0,1,1},
/*99*/	{100,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x7b001100,11,0,1,1},
/*100*/	{101,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x7c001100,12,0,1,1},
/*101*/	{102,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x7d001100,13,0,1,1},
/*102*/	{103,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x7e001100,14,0,1,1},
/*103*/	{87,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x7f001100,15,0,1,1},
/*104*/	{121,105,120,G_IBOX,0x0,0x0,(void *)0x1101,0,6,16,1},
/*105*/	{106,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x80001100,0,0,1,1},
/*106*/	{107,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x81001100,1,0,1,1},
/*107*/	{108,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x82001100,2,0,1,1},
/*108*/	{109,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x83001100,3,0,1,1},
/*109*/	{110,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x84001100,4,0,1,1},
/*110*/	{111,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x85001100,5,0,1,1},
/*111*/	{112,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x86001100,6,0,1,1},
/*112*/	{113,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x87001100,7,0,1,1},
/*113*/	{114,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x88001100,8,0,1,1},
/*114*/	{115,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x89001100,9,0,1,1},
/*115*/	{116,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x8a001100,10,0,1,1},
/*116*/	{117,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x8b001100,11,0,1,1},
/*117*/	{118,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x8c001100,12,0,1,1},
/*118*/	{119,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x8d001100,13,0,1,1},
/*119*/	{120,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x8e001100,14,0,1,1},
/*120*/	{104,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x8f001100,15,0,1,1},
/*121*/	{138,122,137,G_IBOX,0x0,0x0,(void *)0x1101,0,7,16,1},
/*122*/	{123,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x90001100,0,0,1,1},
/*123*/	{124,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x91001100,1,0,1,1},
/*124*/	{125,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x92001100,2,0,1,1},
/*125*/	{126,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x93001100,3,0,1,1},
/*126*/	{127,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x94001100,4,0,1,1},
/*127*/	{128,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x95001100,5,0,1,1},
/*128*/	{129,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x96001100,6,0,1,1},
/*129*/	{130,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x97001100,7,0,1,1},
/*130*/	{131,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x98001100,8,0,1,1},
/*131*/	{132,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x99001100,9,0,1,1},
/*132*/	{133,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x9a001100,10,0,1,1},
/*133*/	{134,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x9b001100,11,0,1,1},
/*134*/	{135,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x9c001100,12,0,1,1},
/*135*/	{136,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x9d001100,13,0,1,1},
/*136*/	{137,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x9e001100,14,0,1,1},
/*137*/	{121,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0x9f001100,15,0,1,1},
/*138*/	{155,139,154,G_IBOX,0x0,0x0,(void *)0x1101,0,8,16,1},
/*139*/	{140,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa0001100,0,0,1,1},
/*140*/	{141,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa1001100,1,0,1,1},
/*141*/	{142,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa2001100,2,0,1,1},
/*142*/	{143,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa3001100,3,0,1,1},
/*143*/	{144,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa4001100,4,0,1,1},
/*144*/	{145,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa5001100,5,0,1,1},
/*145*/	{146,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa6001100,6,0,1,1},
/*146*/	{147,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa7001100,7,0,1,1},
/*147*/	{148,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa8001100,8,0,1,1},
/*148*/	{149,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xa9001100,9,0,1,1},
/*149*/	{150,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xaa001100,10,0,1,1},
/*150*/	{151,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xab001100,11,0,1,1},
/*151*/	{152,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xac001100,12,0,1,1},
/*152*/	{153,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xad001100,13,0,1,1},
/*153*/	{154,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xae001100,14,0,1,1},
/*154*/	{138,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xaf001100,15,0,1,1},
/*155*/	{172,156,171,G_IBOX,0x0,0x0,(void *)0x1101,0,9,16,1},
/*156*/	{157,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb0001100,0,0,1,1},
/*157*/	{158,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb1001100,1,0,1,1},
/*158*/	{159,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb2001100,2,0,1,1},
/*159*/	{160,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb3001100,3,0,1,1},
/*160*/	{161,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb4001100,4,0,1,1},
/*161*/	{162,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb5001100,5,0,1,1},
/*162*/	{163,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb6001100,6,0,1,1},
/*163*/	{164,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb7001100,7,0,1,1},
/*164*/	{165,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb8001100,8,0,1,1},
/*165*/	{166,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xb9001100,9,0,1,1},
/*166*/	{167,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xba001100,10,0,1,1},
/*167*/	{168,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xbb001100,11,0,1,1},
/*168*/	{169,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xbc001100,12,0,1,1},
/*169*/	{170,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xbd001100,13,0,1,1},
/*170*/	{171,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xbe001100,14,0,1,1},
/*171*/	{155,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xbf001100,15,0,1,1},
/*172*/	{189,173,188,G_IBOX,0x0,0x0,(void *)0x1101,0,10,16,1},
/*173*/	{174,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc0001100,0,0,1,1},
/*174*/	{175,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc1001100,1,0,1,1},
/*175*/	{176,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc2001100,2,0,1,1},
/*176*/	{177,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc3001100,3,0,1,1},
/*177*/	{178,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc4001100,4,0,1,1},
/*178*/	{179,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc5001100,5,0,1,1},
/*179*/	{180,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc6001100,6,0,1,1},
/*180*/	{181,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc7001100,7,0,1,1},
/*181*/	{182,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc8001100,8,0,1,1},
/*182*/	{183,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xc9001100,9,0,1,1},
/*183*/	{184,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xca001100,10,0,1,1},
/*184*/	{185,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xcb001100,11,0,1,1},
/*185*/	{186,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xcc001100,12,0,1,1},
/*186*/	{187,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xcd001100,13,0,1,1},
/*187*/	{188,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xce001100,14,0,1,1},
/*188*/	{172,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xcf001100,15,0,1,1},
/*189*/	{206,190,205,G_IBOX,0x0,0x0,(void *)0x1101,0,11,16,1},
/*190*/	{191,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd0001100,0,0,1,1},
/*191*/	{192,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd1001100,1,0,1,1},
/*192*/	{193,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd2000100,2,0,1,1},
/*193*/	{194,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd3001100,3,0,1,1},
/*194*/	{195,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd4001100,4,0,1,1},
/*195*/	{196,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd5001100,5,0,1,1},
/*196*/	{197,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd6001100,6,0,1,1},
/*197*/	{198,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd7001100,7,0,1,1},
/*198*/	{199,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd8001100,8,0,1,1},
/*199*/	{200,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xd9001100,9,0,1,1},
/*200*/	{201,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xda001100,10,0,1,1},
/*201*/	{202,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xdb001100,11,0,1,1},
/*202*/	{203,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xdc001100,12,0,1,1},
/*203*/	{204,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xdd001100,13,0,1,1},
/*204*/	{205,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xde001100,14,0,1,1},
/*205*/	{189,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xdf001100,15,0,1,1},
/*206*/	{223,207,222,G_IBOX,0x0,0x0,(void *)0x1101,0,12,16,1},
/*207*/	{208,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe0001100,0,0,1,1},
/*208*/	{209,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe1001100,1,0,1,1},
/*209*/	{210,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe2001100,2,0,1,1},
/*210*/	{211,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe3001100,3,0,1,1},
/*211*/	{212,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe4001100,4,0,1,1},
/*212*/	{213,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe5001100,5,0,1,1},
/*213*/	{214,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe6001100,6,0,1,1},
/*214*/	{215,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe7001100,7,0,1,1},
/*215*/	{216,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe8001100,8,0,1,1},
/*216*/	{217,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xe9001100,9,0,1,1},
/*217*/	{218,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xea001100,10,0,1,1},
/*218*/	{219,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xeb001100,11,0,1,1},
/*219*/	{220,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xec001100,12,0,1,1},
/*220*/	{221,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xed001100,13,0,1,1},
/*221*/	{222,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xee001100,14,0,1,1},
/*222*/	{206,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xef001100,15,0,1,1},
/*223*/	{1,224,239,G_IBOX,0x0,0x0,(void *)0x1101,0,13,16,1},
/*224*/	{225,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf0001100,0,0,1,1},
/*225*/	{226,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf1001100,1,0,1,1},
/*226*/	{227,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf2001100,2,0,1,1},
/*227*/	{228,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf3001100,3,0,1,1},
/*228*/	{229,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf4001100,4,0,1,1},
/*229*/	{230,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf5001100,5,0,1,1},
/*230*/	{231,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf6001100,6,0,1,1},
/*231*/	{232,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf7001100,7,0,1,1},
/*232*/	{233,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf8001100,8,0,1,1},
/*233*/	{234,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xf9001100,9,0,1,1},
/*234*/	{235,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xfa001100,10,0,1,1},
/*235*/	{236,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xfb001100,11,0,1,1},
/*236*/	{237,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xfc001100,12,0,1,1},
/*237*/	{238,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xfd001100,13,0,1,1},
/*238*/	{239,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xfe001100,14,0,1,1},
/*239*/	{223,-1,-1,G_BOXCHAR,0x5,0x0,(void *)0xff001100,15,0,1,1},
/*240*/	{241,-1,-1,G_BUTTON,0x7,0x0,"Cancel", 4,3598,1548,513},
/*241*/	{0,-1,-1,G_BUTTON,0x25,0x0,"\?", 1,15,1026,1},
};

OBJECT SETTINGS[] = {
/*0*/	{-1,1,12,G_BOX,0x0,0x0,(void *)0x21181,513,2304,18,2320},
/*1*/	{2,-1,-1,G_FBOXTEXT,0x8,0x0,&rs_tedinfo[0],6,12,5,2049},
/*2*/	{3,-1,-1,G_BUTTON,0x7,0x0,"OK", 1025,2062,15,1},
/*3*/	{4,-1,-1,G_STRING,0x0,0x0,"Many Programs", 1,2,13,1},
/*4*/	{5,-1,-1,G_STRING,0x0,0x0,"seem to mind if", 1,3,15,1},
/*5*/	{6,-1,-1,G_STRING,0x0,0x0,"a scancode is ", 1,4,14,1},
/*6*/	{7,-1,-1,G_STRING,0x0,0x0,"included or not.", 1,5,16,1},
/*7*/	{8,-1,-1,G_STRING,0x0,0x0,"The number below", 1,6,16,1},
/*8*/	{9,-1,-1,G_STRING,0x0,0x0,"lets you set a", 1,7,14,1},
/*9*/	{10,-1,-1,G_STRING,0x0,0x0,"a dummy figure", 1,8,14,1},
/*10*/	{11,-1,-1,G_STRING,0x0,0x0,"for characters", 1,9,14,1},
/*11*/	{12,-1,-1,G_STRING,0x0,0x0,"without a key.", 1,10,14,1},
/*12*/	{0,-1,-1,G_STRING,0x20,0x0,"Configure", 1027,2048,9,1},
};



static void fix_tree(OBJECT *s,int max)
{
	int i;

	for(i=0; i<=max; i++)
		rsrc_obfix(s,i);
}

void rsrc_init(void)
{
	fix_tree(CH_TABLE,241);
	fix_tree(SETTINGS,12);
}
