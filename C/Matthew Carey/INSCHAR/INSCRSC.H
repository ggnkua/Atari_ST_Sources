extern void rsrc_init(void);

extern OBJECT CH_TABLE[];
#define CANCEL 240
#define QUESTION 241
extern OBJECT SETTINGS[];
#define SCAN_DUMMY 1
#define OKAY 2
