extern void rsrc_init(void);

extern OBJECT MAINDIAL[];
#define TARGETBUT 7
#define LISTINGBUT 8
#define PATHTEXT 9
#define LISTTEXT 10
#define OKBUT 11
#define CANCELBUT 12
#define REPLACEBUT 15
#define APPENDBUT 16
#define DBASEBUT 17
extern OBJECT MAINMENU[];
#define FILEMENU 4
#define MNABOUT 7
#define MNTARG 17
#define MNLIST 18
#define MNREPLACE 20
#define MNAPPEND 21
#define MNDBASE 22
#define MNOK 24
#define MNQUIT 26
extern char ABORTMNSTR[];
extern char QUITMNSTR[];
extern char ABORTBUTSTR[];
extern char QUITBUTSTR[];
