/* resource set indicies for NAU_RSC */

#define MENU1    0	/* menu tree */
#define PROGINFO 7	/* STRING in tree MENU1 */
#define GRUND    16	/* STRING in tree MENU1 */
#define TTIME    17	/* STRING in tree MENU1 */
#define EDITME   18	/* STRING in tree MENU1 */
#define QUIT     20	/* STRING in tree MENU1 */

#define ZEITLMIT 1	/* form/dialog */
#define MIN15    7	/* BUTTON in tree ZEITLMIT */
#define MIN12    8	/* BUTTON in tree ZEITLMIT */
#define MIN10    9	/* BUTTON in tree ZEITLMIT */
#define MIN8     10	/* BUTTON in tree ZEITLMIT */
#define MIN5     11	/* BUTTON in tree ZEITLMIT */

#define SHAREMLD 2	/* form/dialog */

#define GRUNDAUF 3	/* form/dialog */
#define YEAHWEIT 1	/* BUTTON in tree GRUNDAUF */

#define NOSTONES 4	/* form/dialog */
#define ONCEMORE 1	/* BUTTON in tree NOSTONES */
#define KICKSHIT 7	/* BUTTON in tree NOSTONES */

#define HISCORE  5	/* form/dialog */
#define HSNAME   1	/* FTEXT in tree HISCORE */
#define SAVEIT   2	/* BUTTON in tree HISCORE */
#define HSNR     6	/* STRING in tree HISCORE */
#define HSPUNKTE 9	/* STRING in tree HISCORE */
#define FORGET   10	/* BUTTON in tree HISCORE */
