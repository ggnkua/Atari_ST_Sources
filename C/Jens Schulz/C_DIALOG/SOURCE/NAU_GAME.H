
void ende_meldung(int *abbruch);
void tournament_limit(OBJECT *menutree, int *t_stufe);
