void get_akt_path(char * pfad);
int hndl_dial (int baumindex,int anfangsfeld, int tiefe, int normal_set, int save_area);
char *get_dial_str_adr(int baumindex, int obj_nr, int mode);
void file_select(char *filename, char *path,char * ext,int *exit_button);

