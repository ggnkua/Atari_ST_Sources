/*
 *  GAME.H
 *
 * This file contains specific equates for the 
 * parsing language.
 *
 */

/* Game commands */

#define	NORTH	1
#define SOUTH	2
#define	EAST	3
#define	WEST	4
#define	TAKE	5
#define	DROP	6
#define	THROW	7
#define	READ	8
#define	EXAMINE	9
#define INVENTORY 10
#define LOOK	  11
#define QUIT	  12

/* Game objects */

#define BOOK	1
#define AXE	2
#define COIN	3
#define STICK	4
