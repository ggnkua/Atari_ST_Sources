
char *rs_strings[]={
"EXIT1",
"EXIT2",
"The first tree has two exit buttons",
"",
"",
"EXIT1",
"EXIT2",
"The second tree has two exit buttons",
"",
"",
"plus a bit image and editable field",
"",
"",
"_______________",
"Enter anything:_______________",
"XXXXXXXXXXXXXXX"
};

OBJECT rs_object[]={
-1,1,3,G_BOX,0x0,0x10,135424L,0x0,0x0,0x27,0x8,
2,-1,-1,G_BUTTON,0x15,0x0,0L,0x8,0x5,0x8,0x1,
3,-1,-1,G_BUTTON,0x15,0x0,1L,0x17,0x5,0x8,0x1,
0,-1,-1,G_TEXT,0x20,0x0,0L,0x2,0x2,0x23,0x1,
-1,1,6,G_BOX,0x0,0x10,135424L,0x0,0x0,0x2A,0xD,
2,-1,-1,G_BUTTON,0x15,0x0,5L,0x7,0xB,0x8,0x1,
3,-1,-1,G_BUTTON,0x15,0x0,6L,0x18,0xB,0x8,0x1,
4,-1,-1,G_TEXT,0x0,0x0,1L,0x2,0x2,0x24,0x1,
5,-1,-1,G_TEXT,0x0,0x0,2L,0x2,0x3,0x24,0x1,
6,-1,-1,G_IMAGE,0x0,0x0,0L,0x10,0x5,0x6,0x6,
0,-1,-1,G_FBOXTEXT,0x28,0x0,3L,0x2,0x6,0x23,0x1
};

int IMAG0[]={
0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0xF,
0xFFFF,0xFFFE,0x40,0x0,
0x8,0x100,0x0,0x20,
0x200,0x0,0x40,0x400,
0x0,0x80,0x3FFF,0xFFFF,
0xFFFE,0x2000,0x0,0x2,
0x2000,0x0,0x2,0x218C,
0x6000,0x2,0x2000,0x0,
0x2,0x3FFF,0xFFFF,0xFFFE,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0,0x0,
0x0,0x0,0x0
};
BITBLK rs_bitblk[]={
0L,6,48,0x0,0x0,0x1
};

ICONBLK rs_iconblk[]={
0L};

TEDINFO rs_tedinfo[]={
2L,3L,4L,3,6,0,4736,0,-1,36,1,
7L,8L,9L,3,6,0,4736,0,-1,37,1,
10L,11L,12L,3,6,0,4736,0,-1,36,1,
13L,14L,15L,3,6,2,4480,0,-1,16,31
};
long rs_trindex[]={
0L,
4L
};
rs_frstr[]={
0L};
long rs_frimg[]={
0L};
struct foobar {
        int dummy;
        int *image;
        } rs_imdope[] = {
0,&IMAG0[0]
};
#define NUM_TI 4
#define NUM_BB 1
#define NUM_OBS 11
#define NUM_IB 0
#define NUM_FRSTR 0
#define NUM_FRIMG 0
#define NUM_TREE 2
#define NUM_STRINGS 16
#define NUM_IMAGES  1
