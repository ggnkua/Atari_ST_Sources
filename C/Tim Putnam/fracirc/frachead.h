#include <mt_aes.h>
#include <transprt.h>
#include "vdiws.h"
#include <string.h>
#include <stdio.h>
#include <stdlib.h>
#include <time.h>
#include <dos.h>
#include <vdi.h>