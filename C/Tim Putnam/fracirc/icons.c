short BBDATA0[] = {
0x0000,0x03c0,0x0c30,0x1008,
0x23c4,0x27e4,0x4ff2,0x4ff2,
0x4ff2,0x4ff2,0x27e4,0x23c4,
0x1008,0x0c30,0x03c0,0x0000,
};

short BBDATA1[] = {
0x0000,0x03c0,0x0c30,0x1008,
0x2004,0x2004,0x4002,0x4002,
0x4002,0x4002,0x2004,0x2004,
0x1008,0x0c30,0x03c0,0x0000,
};

short BBDATA2[] = {
0x0000,0x07e0,0x1818,0x2004,
0x2004,0x2004,0x1818,0x07e0,
};

short BBDATA3[] = {
0x0000,0x07e0,0x1818,0x23c4,
0x27e4,0x23c4,0x1818,0x07e0,
};

BITBLK BBOB0 = {BBDATA0,2,16,0,0,1};
BITBLK BBOB1 = {BBDATA1,2,16,0,0,1};
BITBLK BBOB2 = {BBDATA2,2,8,0,0,1};
BITBLK BBOB3 = {BBDATA3,2,8,0,0,1};

OBJECT IMAGE_DIALOG[] = {
/*0*/	{-1,1,4,G_BOX,0x0,0x10,(void *)0x21100,0,0,52,9},
/*1*/	{2,-1,-1,G_IMAGE,0x0,0x0,&BBOB0,5,1,2,1},
/*2*/	{3,-1,-1,G_IMAGE,0x0,0x0,&BBOB1,2,1,2,1},
/*3*/	{4,-1,-1,G_IMAGE,0x0,0x0,&BBOB2,2,3,2,2048},
/*4*/	{0,-1,-1,G_IMAGE,0x20,0x0,&BBOB3,5,3,2,2048},
};

void init_icons(void)
	{
	 int i;

	 for(i=0; i<=4; i++)
		rsrc_obfix(IMAGE_DIALOG,i);
	}
