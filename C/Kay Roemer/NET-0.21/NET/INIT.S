		.globl	_init

		jmp	_init
