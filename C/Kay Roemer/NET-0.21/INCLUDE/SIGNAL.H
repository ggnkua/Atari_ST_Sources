/*
 *	Signal related definitions.
 *
 *	11/12/93, kay roemer
 */

#ifndef _SIGNAL_H
#define _SIGNAL_H

#define SIGPIPE		13	/* broken socket connection */	

#endif /* _SIGNAL_H */
