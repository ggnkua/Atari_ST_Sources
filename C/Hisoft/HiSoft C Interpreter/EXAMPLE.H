
#define	DIAL	    0

#define TEXT	    2
#define OK	    3
#define CANCEL	    4
#define CHOICE2	    6
#define CHOICE3	    8
#define CHOICE4	    9
#define DRIVEA	   10
#define DRIVEB	   11
#define CHOICE1	   12

#define	ALERT	    0

