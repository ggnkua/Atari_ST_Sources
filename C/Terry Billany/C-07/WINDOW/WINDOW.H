/* resource set indicies for WINDOW */

#define MAINMENU 0	/* menu tree */
#define FILEMENU 4	/* TITLE in tree MAINMENU */
#define INFOITEM 8	/* STRING in tree MAINMENU */
#define QUIT     17	/* STRING in tree MAINMENU */
#define WIND1    19	/* STRING in tree MAINMENU */
#define WIND2    20	/* STRING in tree MAINMENU */
#define WIND3    21	/* STRING in tree MAINMENU */
#define WIND4    22	/* STRING in tree MAINMENU */

#define INFOBOX  1	/* form/dialog */

