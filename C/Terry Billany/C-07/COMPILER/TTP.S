. _bstk 2048
. _estk 4
taa 7 6
lll 4 0
sgl 0 _estk
lag _estk 7
jsr _cttp
