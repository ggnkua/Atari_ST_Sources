. _bstk 2048
. _estk 4
taa 7 6
lll 4 0
sgl 0 _estk
lag _estk 7
jsr _cprg
. ct0 2
. ct1 2
. ct2 2
. ct3 2
. ct4 2
. ct5 2
. ct6 2
. ct7 2
. ct8 2
. ct9 2
. ct10 2
. ii0 2
. ii1 2
. ii2 2
. ii3 2
. ii4 2
. ii5 2
. ii6 2
. ii7 2
. ii8 2
. ii9 2
. ii10 2
. ii11 2
. ii12 2
. ii13 2
. ii14 2
. ii15 2
. io0 2
. io1 2
. io2 2
. io3 2
. io4 2
. io5 2
. io6 2
. iox 80
. pi0 2
. pi1 2
. pi2 2
. pi3 2
. pi4 2
. pi5 2
. pi6 2
. pi7 2
. pix 20
. po0 2
. po1 2
. po2 2
. po3 2
. po4 2
. po5 2
. pox 20
. ai0 4
. ai1 4
. ai2 4
. ao0 4
. ao1 4
. ao2 4
. aes0 4
. aes1 4
. aes2 4
. aes3 4
. aes4 4
. aes5 4
. vdi0 4
. vdi1 4
. vdi2 4
. vdi3 4
. vdi4 4
. vdi5 4
. global 32
