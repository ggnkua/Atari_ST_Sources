
#define	EXAMPLE	    0

#define DEFEXIT	    1
#define FOURBUTTONS	    5
#define ONE	    6
#define THREE	    7
#define FOUR	    8
#define TWO	    9
#define EDITFIELD	   10
