h[0][0] = 1;
 h[0][1] = 1;
 h[0][2] = 3;
 h[0][3] = 3;
 h[0][4] = 4;
 h[0][5] = 6;
 h[0][6] = 7;
 h[0][7] = 7;
 h[0][8] = 6;
 h[0][9] = 6;
 h[0][10] = 4;
 h[0][11] = 3;
 h[0][12] = 2;
 h[0][13] = 0;
 h[0][14] = 0;
 h[0][15] = 0;
 h[1][0] = 1;
 h[1][1] = 1;
 h[1][2] = 3;
 h[1][3] = 3;
 h[1][4] = 4;
 h[1][5] = 6;
 h[1][6] = 7;
 h[1][7] = 7;
 h[1][8] = 7;
 h[1][9] = 6;
 h[1][10] = 4;
 h[1][11] = 3;
 h[1][12] = 2;
 h[1][13] = 2;
 h[1][14] = 0;
 h[1][15] = 0;
 h[2][0] = 1;
 h[2][1] = 1;
 h[2][2] = 3;
 h[2][3] = 3;
 h[2][4] = 4;
 h[2][5] = 6;
 h[2][6] = 7;
 h[2][7] = 7;
 h[2][8] = 7;
 h[2][9] = 6;
 h[2][10] = 4;
 h[2][11] = 3;
 h[2][12] = 2;
 h[2][13] = 2;
 h[2][14] = 0;
 h[2][15] = 0;
 h[3][0] = 1;
 h[3][1] = 1;
 h[3][2] = 3;
 h[3][3] = 3;
 h[3][4] = 4;
 h[3][5] = 6;
 h[3][6] = 7;
 h[3][7] = 7;
 h[3][8] = 7;
 h[3][9] = 6;
 h[3][10] = 6;
 h[3][11] = 4;
 h[3][12] = 3;
 h[3][13] = 2;
 h[3][14] = 2;
 h[3][15] = 0;
 h[4][0] = 1;
 h[4][1] = 1;
 h[4][2] = 1;
 h[4][3] = 3;
 h[4][4] = 4;
 h[4][5] = 6;
 h[4][6] = 7;
 h[4][7] = 7;
 h[4][8] = 7;
 h[4][9] = 6;
 h[4][10] = 6;
 h[4][11] = 4;
 h[4][12] = 3;
 h[4][13] = 2;
 h[4][14] = 2;
 h[4][15] = 0;
 h[5][0] = 1;
 h[5][1] = 1;
 h[5][2] = 1;
 h[5][3] = 3;
 h[5][4] = 4;
 h[5][5] = 6;
 h[5][6] = 7;
 h[5][7] = 7;
 h[5][8] = 7;
 h[5][9] = 7;
 h[5][10] = 6;
 h[5][11] = 4;
 h[5][12] = 3;
 h[5][13] = 3;
 h[5][14] = 2;
 h[5][15] = 2;
 h[6][0] = 0;
 h[6][1] = 1;
 h[6][2] = 1;
 h[6][3] = 3;
 h[6][4] = 4;
 h[6][5] = 6;
 h[6][6] = 7;
 h[6][7] = 7;
 h[6][8] = 7;
 h[6][9] = 7;
 h[6][10] = 6;
 h[6][11] = 6;
 h[6][12] = 4;
 h[6][13] = 3;
 h[6][14] = 2;
 h[6][15] = 2;
 h[7][0] = 0;
 h[7][1] = 1;
 h[7][2] = 1;
 h[7][3] = 3;
 h[7][4] = 4;
 h[7][5] = 6;
 h[7][6] = 7;
 h[7][7] = 7;
 h[7][8] = 7;
 h[7][9] = 7;
 h[7][10] = 6;
 h[7][11] = 6;
 h[7][12] = 4;
 h[7][13] = 3;
 h[7][14] = 3;
 h[7][15] = 2;
 h[8][0] = 0;
 h[8][1] = 2;
 h[8][2] = 3;
 h[8][3] = 4;
 h[8][4] = 4;
 h[8][5] = 6;
 h[8][6] = 7;
 h[8][7] = 7;
 h[8][8] = 7;
 h[8][9] = 7;
 h[8][10] = 6;
 h[8][11] = 6;
 h[8][12] = 4;
 h[8][13] = 4;
 h[8][14] = 3;
 h[8][15] = 3;
 h[9][0] = 2;
 h[9][1] = 2;
 h[9][2] = 3;
 h[9][3] = 4;
 h[9][4] = 6;
 h[9][5] = 6;
 h[9][6] = 7;
 h[9][7] = 7;
 h[9][8] = 7;
 h[9][9] = 7;
 h[9][10] = 6;
 h[9][11] = 6;
 h[9][12] = 6;
 h[9][13] = 4;
 h[9][14] = 4;
 h[9][15] = 3;
 h[10][0] = 3;
 h[10][1] = 3;
 h[10][2] = 4;
 h[10][3] = 4;
 h[10][4] = 6;
 h[10][5] = 7;
 h[10][6] = 7;
 h[10][7] = 7;
 h[10][8] = 7;
 h[10][9] = 7;
 h[10][10] = 7;
 h[10][11] = 6;
 h[10][12] = 6;
 h[10][13] = 4;
 h[10][14] = 4;
 h[10][15] = 4;
 h[11][0] = 3;
 h[11][1] = 4;
 h[11][2] = 4;
 h[11][3] = 6;
 h[11][4] = 6;
 h[11][5] = 5;
 h[11][6] = 5;
 h[11][7] = 5;
 h[11][8] = 5;
 h[11][9] = 7;
 h[11][10] = 7;
 h[11][11] = 6;
 h[11][12] = 6;
 h[11][13] = 6;
 h[11][14] = 4;
 h[11][15] = 4;
 h[12][0] = 4;
 h[12][1] = 6;
 h[12][2] = 6;
 h[12][3] = 5;
 h[12][4] = 5;
 h[12][5] = 5;
 h[12][6] = 5;
 h[12][7] = 5;
 h[12][8] = 5;
 h[12][9] = 5;
 h[12][10] = 7;
 h[12][11] = 6;
 h[12][12] = 6;
 h[12][13] = 6;
 h[12][14] = 6;
 h[12][15] = 6;
 h[13][0] = 6;
 h[13][1] = 5;
 h[13][2] = 5;
 h[13][3] = 5;
 h[13][4] = 5;
 h[13][5] = 5;
 h[13][6] = 5;
 h[13][7] = 5;
 h[13][8] = 5;
 h[13][9] = 5;
 h[13][10] = 5;
 h[13][11] = 7;
 h[13][12] = 6;
 h[13][13] = 6;
 h[13][14] = 6;
 h[13][15] = 6;
 h[14][0] = 5;
 h[14][1] = 5;
 h[14][2] = 5;
 h[14][3] = 5;
 h[14][4] = 5;
 h[14][5] = 5;
 h[14][6] = 5;
 h[14][7] = 5;
 h[14][8] = 5;
 h[14][9] = 5;
 h[14][10] = 5;
 h[14][11] = 5;
 h[14][12] = 7;
 h[14][13] = 7;
 h[14][14] = 6;
 h[14][15] = 6;
 h[15][0] = 5;
 h[15][1] = 5;
 h[15][2] = 5;
 h[15][3] = 5;
 h[15][4] = 5;
 h[15][5] = 5;
 h[15][6] = 5;
 h[15][7] = 5;
 h[15][8] = 5;
 h[15][9] = 5;
 h[15][10] = 5;
 h[15][11] = 5;
 h[15][12] = 7;
 h[15][13] = 7;
 h[15][14] = 7;
 h[15][15] = 7;
 
