#if 0
0.40	first release (used 5.04.01)
0.41	longer command lines, used 5.06.02 fixed compiler
0.42	new malloc, residency, no cmdline
0.43	TT compatible, various releases
0.50	better TT, MMU, more features, released (used 5.06.02+)
0.51	fixed load kill in AUTO (works more than once)
		>> shifts right not left
0.55	various 9.2.91
0.55+	64k boundary
0.60	various improvements
0.61	long symbols OK
0.69	lots
0.70	never existed
0.71	shipped a bit
0.71+	shipped a bit more
#endif

#define VERSIONTX	"1.02"

word monversion = 0x0102;
