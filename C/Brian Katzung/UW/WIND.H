#define MENUBAR 0  	/* TREE */
#define ABOUT 1  	/* TREE */
#define NEWNAME 2  	/* TREE */
#define DABOUT 12  	/* OBJECT in TREE #0 */
#define FQUITUW 21  	/* OBJECT in TREE #0 */
#define FQUIT 26  	/* OBJECT in TREE #0 */
#define MFAST 33  	/* OBJECT in TREE #0 */
#define WRENAME 47  	/* OBJECT in TREE #0 */
#define FNTOWN 69  	/* OBJECT in TREE #0 */
#define FNTSYS 68  	/* OBJECT in TREE #0 */
#define BUTTON 5  	/* OBJECT in TREE #1 */
#define FLD1 1  	/* OBJECT in TREE #2 */
#define OKRENAME 3  	/* OBJECT in TREE #2 */
#define FNTALT 70  	/* OBJECT in TREE #0 */
#define DESK 3  	/* OBJECT in TREE #0 */
#define PRTBOTOM 74  	/* OBJECT in TREE #0 */
#define PRTSTOP 77  	/* OBJECT in TREE #0 */
#define FUNCTKEY 36  	/* OBJECT in TREE #0 */
#define PRTTOP 75  	/* OBJECT in TREE #0 */
#define RESETAUX 43  	/* OBJECT in TREE #0 */
#define AUDIBELL 37  	/* OBJECT in TREE #0 */
#define VISIBELL 38  	/* OBJECT in TREE #0 */
#define TOPONBEL 39  	/* OBJECT in TREE #0 */
#define ASSRD 40  	/* OBJECT in TREE #0 */
#define RESRD 41  	/* OBJECT in TREE #0 */
#define PRTWIND 76  	/* OBJECT in TREE #0 */
#define FUNCTEDT 3  	/* TREE */
#define FUNCEXIT 7  	/* OBJECT in TREE #3 */
#define FUNCSHOW 6  	/* OBJECT in TREE #3 */
#define FUNCPREV 5  	/* OBJECT in TREE #3 */
#define FUNCNEXT 4  	/* OBJECT in TREE #3 */
#define FUNCNAME 10  	/* OBJECT in TREE #3 */
#define FUNCBODY 12  	/* OBJECT in TREE #3 */
#define FUNCENT 16  	/* OBJECT in TREE #3 */
#define LOADCONF 23  	/* OBJECT in TREE #0 */
#define SAVECONF 24  	/* OBJECT in TREE #0 */
#define WINDSIZE 4  	/* TREE */
#define WINDROWS 7  	/* OBJECT in TREE #4 */
#define WINDCOLS 8  	/* OBJECT in TREE #4 */
#define WINDCANC 5  	/* OBJECT in TREE #4 */
#define WINDOK 6  	/* OBJECT in TREE #4 */
#define SHRNKWIN 48  	/* OBJECT in TREE #0 */
#define BOTTOMTO 50  	/* OBJECT in TREE #0 */
#define INPUTWIN 54  	/* OBJECT in TREE #0 */
#define HIDEWIN 49  	/* OBJECT in TREE #0 */
#define WINSTYLE 34  	/* OBJECT in TREE #0 */
#define MOREINF1 6  	/* OBJECT in TREE #1 */
#define INFO1 5  	/* TREE */
#define CONT1 4  	/* OBJECT in TREE #5 */
#define INFO2 6  	/* TREE */
#define CONT2 8  	/* OBJECT in TREE #6 */
#define INFO3 7  	/* TREE */
#define INFO4 8  	/* TREE */
#define INFO5 9  	/* TREE */
#define CONT3 2  	/* OBJECT in TREE #7 */
#define CONT4 2  	/* OBJECT in TREE #8 */
#define CONT5 2  	/* OBJECT in TREE #9 */
#define FNTBIG 67  	/* OBJECT in TREE #0 */
#define FNTTINY 71  	/* OBJECT in TREE #0 */
#define FNTUNKNW 72  	/* OBJECT in TREE #0 */
#define OSIZEWIN 51  	/* OBJECT in TREE #0 */
#define MOVEWIN 52  	/* OBJECT in TREE #0 */
#define CLOSEWIN 53  	/* OBJECT in TREE #0 */
#define WINTITLE 35  	/* OBJECT in TREE #0 */
#define PASTE 55  	/* OBJECT in TREE #0 */
#define CAPTURE 25  	/* OBJECT in TREE #0 */
#define RSCONF 10  	/* TREE */
#define BB1920 7  	/* OBJECT in TREE #10 */
#define BB960 8  	/* OBJECT in TREE #10 */
#define BB480 9  	/* OBJECT in TREE #10 */
#define BB360 10  	/* OBJECT in TREE #10 */
#define BB240 11  	/* OBJECT in TREE #10 */
#define BB200 12  	/* OBJECT in TREE #10 */
#define BB180 13  	/* OBJECT in TREE #10 */
#define BB120 14  	/* OBJECT in TREE #10 */
#define BB60 15  	/* OBJECT in TREE #10 */
#define BB30 16  	/* OBJECT in TREE #10 */
#define BB20 17  	/* OBJECT in TREE #10 */
#define BB15 18  	/* OBJECT in TREE #10 */
#define BB13 19  	/* OBJECT in TREE #10 */
#define BB11 20  	/* OBJECT in TREE #10 */
#define BB7 21  	/* OBJECT in TREE #10 */
#define BB5 22  	/* OBJECT in TREE #10 */
#define BCB5 24  	/* OBJECT in TREE #10 */
#define BCB6 25  	/* OBJECT in TREE #10 */
#define BCB7 26  	/* OBJECT in TREE #10 */
#define BCB8 27  	/* OBJECT in TREE #10 */
#define PBNONE 30  	/* OBJECT in TREE #10 */
#define PBEVEN 31  	/* OBJECT in TREE #10 */
#define PBODD 32  	/* OBJECT in TREE #10 */
#define FCBNONE 40  	/* OBJECT in TREE #10 */
#define FCBXON 41  	/* OBJECT in TREE #10 */
#define FCBRTS 42  	/* OBJECT in TREE #10 */
#define RCCAN 1  	/* OBJECT in TREE #10 */
#define RCOK 2  	/* OBJECT in TREE #10 */
#define SBB1 36  	/* OBJECT in TREE #10 */
#define SBB15 37  	/* OBJECT in TREE #10 */
#define SBB2 38  	/* OBJECT in TREE #10 */
#define SETCONF 42  	/* OBJECT in TREE #0 */
#define BUFSIZ1 44  	/* OBJECT in TREE #10 */
#define BUFSIZ2 45  	/* OBJECT in TREE #10 */
#define BUFSIZ32 46  	/* OBJECT in TREE #10 */
#define LOCKINFO 11  	/* TREE */
#define FLOCKKEY 27  	/* OBJECT in TREE #0 */
#define COMMAND 28  	/* OBJECT in TREE #0 */
#define SETPATH 29  	/* OBJECT in TREE #0 */
#define PARAM 12  	/* TREE */
#define PARAMSTR 3  	/* OBJECT in TREE #12 */
#define OKEXEC 1  	/* OBJECT in TREE #12 */
#define KERMIT 30  	/* OBJECT in TREE #0 */
#define KERMPARM 13  	/* TREE */
#define DEBUGENA 10  	/* OBJECT in TREE #13 */
#define DEBUG1 11  	/* OBJECT in TREE #13 */
#define DEBUG2 13  	/* OBJECT in TREE #13 */
#define DEBUG3 12  	/* OBJECT in TREE #13 */
#define IMAGEMOD 7  	/* OBJECT in TREE #13 */
#define ASCIIMOD 8  	/* OBJECT in TREE #13 */
#define CONVNAME 9  	/* OBJECT in TREE #13 */
#define SENDFILE 2  	/* OBJECT in TREE #13 */
#define RECFILE 3  	/* OBJECT in TREE #13 */
#define KERMEXIT 4  	/* OBJECT in TREE #13 */
#define REMSHELL 59  	/* OBJECT in TREE #0 */
#define SHELL32 60  	/* OBJECT in TREE #0 */
#define SHELL24 61  	/* OBJECT in TREE #0 */
#define SHELL12 62  	/* OBJECT in TREE #0 */
#define SHELL8 63  	/* OBJECT in TREE #0 */
#define SHELLOTH 64  	/* OBJECT in TREE #0 */
#define WINRESIZ 57  	/* OBJECT in TREE #0 */
#define WINCLEAR 56  	/* OBJECT in TREE #0 */
#define LOCCOPY 65  	/* OBJECT in TREE #0 */
#define OVERSTRI 45  	/* OBJECT in TREE #0 */
#define MFREE 31  	/* OBJECT in TREE #0 */
