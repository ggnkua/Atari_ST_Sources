/* GEM Icon Definition: */
#define rmbblk1_W 0x0010
#define rmbblk1_H 0x0028
#define rmbblk1SIZE 0x0028
short rmbmform[rmbblk1SIZE] = 
{ 0x000A, 0x0003, 0x0001, 0x0000,
  0x0001, 0xFFFF, 0x8037, 0xB82F,
  0xB801, 0xB82F, 0xB837, 0x803F,
  0xBFA0, 0xBFA0, 0xBFA0, 0xBBA0,
  0xB1A0, 0xAAA0, 0xBFA0, 0x8020,
  0xFFE0, 0x0000, 0x7FC8, 0x47D0,
  0x47FE, 0x47D0, 0x47C8, 0x7FC0,
  0x4040, 0x4040, 0x4040, 0x4440,
  0x4E40, 0x5540, 0x4040, 0x7FC0,
  0x0000, 0x0000, 0x0000, 0x0000
};
/* GEM Icon Definition: */
#define lckblk1_W 0x0010
#define lckblk1_H 0x0028
#define lckblk1SIZE 0x0028
short lckmform[lckblk1SIZE] = 
{ 0x0005, 0x0009, 0x0001, 0x0000,
  0x0001, 0x1FF8, 0x300C, 0x67E6,
  0x4C32, 0x581A, 0x500A, 0xDFFB,
  0x8001, 0x8001, 0x83C1, 0x83C1,
  0x8181, 0x8181, 0x8181, 0x8001,
  0xFFFF, 0x0000, 0x0FF0, 0x1818,
  0x300C, 0x2004, 0x2004, 0x2004,
  0x7FFE, 0x7FFE, 0x7C3E, 0x7C3E,
  0x7E7E, 0x7E7E, 0x7E7E, 0x7FFE,
  0x0000, 0x0000, 0x0000, 0x0000
};
