/* Indice du ressource pour EG_WORK */

#define FORM1    0   /* Formulaire/Dialogue */
#define TI_VISUALISE 5   /* USERDEF dans l'arbre FORM1 */
#define TI_GRAVITE 6   /* USERDEF dans l'arbre FORM1 */
