/* Indices du fichier ressource pour EGLIBTST */

#define FINFO            0   /* Formulaire/Dialogue */

#define PINFO            1   /* Formulaire/Dialogue */
#define PMAIN            1   /* STRING dans l'arbre PINFO */
#define PLIB             2   /* STRING dans l'arbre PINFO */
#define PQUIT            4   /* STRING dans l'arbre PINFO */

#define MENU             2   /* Menu */
#define MINFO            7   /* STRING dans l'arbre MENU */
#define MMAIN            16  /* STRING dans l'arbre MENU */
#define MLIB             17  /* STRING dans l'arbre MENU */
#define MQUIT            19  /* STRING dans l'arbre MENU */

#define POPUP            3   /* Formulaire/Dialogue */

#define FMAIN            4   /* Formulaire/Dialogue */
#define FMANOM           7   /* FBOXTEXT dans l'arbre FMAIN */
#define FMAPRE           8   /* FBOXTEXT dans l'arbre FMAIN */
#define FMAAGE           9   /* FBOXTEXT dans l'arbre FMAIN */
#define FMAMCH           14  /* BUTTON dans l'arbre FMAIN */
