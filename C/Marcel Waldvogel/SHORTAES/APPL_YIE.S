                EXPORT  appl_yield
                IMPORT  aes

appl_yield:	move.l	#$11000100,D0
		bra	aes


