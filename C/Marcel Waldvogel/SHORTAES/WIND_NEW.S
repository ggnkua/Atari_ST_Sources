                EXPORT  wind_new
                IMPORT  aes

wind_new:       move.l  #$6D000100,D0
                bra     aes


