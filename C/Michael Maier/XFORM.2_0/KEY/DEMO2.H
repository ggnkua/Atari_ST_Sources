#define USERIMG 0  	/* TREE */
#define TREE2 1  	/* TREE */
#define TREE3 2  	/* TREE */
#define TREE4 3  	/* TREE */
#define TREE5 4  	/* TREE */
#define TREE6 5  	/* TREE */
#define TREE7 6  	/* TREE */
#define TREE8 7  	/* TREE */
#define TREE9 8  	/* TREE */
#define TREE10 9  	/* TREE */
#define TREE11 10  	/* TREE */
#define RBHOFF 1  	/* OBJECT in TREE #0 */
#define RBHON 2  	/* OBJECT in TREE #0 */
#define RBLOFF 3  	/* OBJECT in TREE #0 */
#define RBLON 4  	/* OBJECT in TREE #0 */
#define CYCHIRES 5  	/* OBJECT in TREE #0 */
#define CYCLOW 6  	/* OBJECT in TREE #0 */
#define WMPFHI 7  	/* OBJECT in TREE #0 */
#define WMPFLO 8  	/* OBJECT in TREE #0 */
#define ALERT0 0  	/* STRING */
#define ALERT1 1  	/* STRING */
#define ALERT2 2  	/* STRING */
#define ALERT3 3  	/* STRING */
#define ALERT4 4  	/* STRING */
#define ALERT5 5  	/* STRING */
