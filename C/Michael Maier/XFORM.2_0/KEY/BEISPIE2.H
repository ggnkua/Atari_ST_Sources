#define USERIMG 0  	/* TREE */
#define NDM1 1  	/* TREE */
#define NDM2 2  	/* TREE */
#define NDM3 3  	/* TREE */
#define NDM4 4  	/* TREE */
#define NDM5 5  	/* TREE */
#define NDM6 6  	/* TREE */
#define NDM7 7  	/* TREE */
#define RBHOFF 1  	/* OBJECT in TREE #0 */
#define RBHON 2  	/* OBJECT in TREE #0 */
#define RBLOFF 3  	/* OBJECT in TREE #0 */
#define RBLON 4  	/* OBJECT in TREE #0 */
#define CYCHIRES 5  	/* OBJECT in TREE #0 */
#define CYCLOW 6  	/* OBJECT in TREE #0 */
#define WMPFHI 7  	/* OBJECT in TREE #0 */
#define WMPFLO 8  	/* OBJECT in TREE #0 */
#define CLEAR1 7  	/* OBJECT in TREE #3 */
#define ALERT1 0  	/* STRING */
#define ALERT2A 1  	/* STRING */
#define ALERT2B 2  	/* STRING */
#define ALERT3A 3  	/* STRING */
#define ALERT3B 4  	/* STRING */
#define HELP 5  	/* STRING */
