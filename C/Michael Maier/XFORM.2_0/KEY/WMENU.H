#define USERIMG 0  	/* TREE */
#define STARTUP 1  	/* TREE */
#define MENU1 2  	/* TREE */
#define MENU2 3  	/* TREE */
#define ARROWS1 4  	/* TREE */
#define ARROWS2 5  	/* TREE */
#define INTRO 6  	/* TREE */
#define INTRO1 7  	/* TREE */
#define ENDE 8  	/* TREE */
#define RBHOFF 1  	/* OBJECT in TREE #0 */
#define RBHON 2  	/* OBJECT in TREE #0 */
#define RBLOFF 3  	/* OBJECT in TREE #0 */
#define RBLON 4  	/* OBJECT in TREE #0 */
#define CYCHIRES 5  	/* OBJECT in TREE #0 */
#define CYCLOW 6  	/* OBJECT in TREE #0 */
#define WMPFHI 7  	/* OBJECT in TREE #0 */
#define WMPFLO 8  	/* OBJECT in TREE #0 */
#define SUB1 1  	/* OBJECT in TREE #4 */
#define ADD1 2  	/* OBJECT in TREE #4 */
#define SUB2 1  	/* OBJECT in TREE #5 */
#define ADD2 2  	/* OBJECT in TREE #5 */
#define ALERT1 0  	/* STRING */
#define ALERT2A 1  	/* STRING */
#define ALERT2B 2  	/* STRING */
#define ALERT3A 3  	/* STRING */
#define ALERT3B 4  	/* STRING */
#define HELP 5  	/* STRING */
