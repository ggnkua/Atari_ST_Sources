#define USERIMG 0  	/* TREE */
#define POPUPX3 1  	/* TREE */
#define POPUPX1 2  	/* TREE */
#define POPUPX2 3  	/* TREE */
#define WIE1 4  	/* TREE */
#define WIE2 5  	/* TREE */
#define RBHOFF 1  	/* OBJECT in TREE #0 */
#define RBHON 2  	/* OBJECT in TREE #0 */
#define RBLOFF 3  	/* OBJECT in TREE #0 */
#define RBLON 4  	/* OBJECT in TREE #0 */
#define CYCHIRES 5  	/* OBJECT in TREE #0 */
#define CYCLOW 6  	/* OBJECT in TREE #0 */
#define WMPFHI 7  	/* OBJECT in TREE #0 */
#define WMPFLO 8  	/* OBJECT in TREE #0 */
#define ALERT1 0  	/* STRING */
#define ALERT2A 1  	/* STRING */
#define ALERT2B 2  	/* STRING */
#define ALERT3A 3  	/* STRING */
#define ALERT3B 4  	/* STRING */
#define HELP 5  	/* STRING */
