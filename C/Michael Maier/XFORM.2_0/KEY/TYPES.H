#ifndef	__TYPES__
#define __TYPES__

#define	BYTE	char
#define	UBYTE	unsigned char

#define ID		id

#define	WORD	int
#define	UWORD	unsigned int

#define LONG	long
#define	ULONG	unsigned long

#define	FLOAT	float
#define	DOUBLE	double

#define	INT		int
#define	UINT	unsigned int

#define	AUTO	auto
#define	EXTERN	extern
#define	STATIC	static
#define LOCAL	static
#define GLOBAL
#define	REG		register

typedef enum { FAIL = -1, FALSE = 0, TRUE = 1 } BOOLEAN;

#define CONST		const
#define	VOLATILE	volatile
#define CDECL		cdecl
#define	PASCAL		pascal
#define	VOID		void

#endif /* __TYPES__ */
