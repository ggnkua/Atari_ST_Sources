#define TREE1 0  	/* TREE */
#define TREE3 1  	/* TREE */
#define ALERT1 0  	/* STRING */
#define ALERT2A 1  	/* STRING */
#define ALERT2B 2  	/* STRING */
#define ALERT3A 3  	/* STRING */
#define ALERT3B 4  	/* STRING */
#define HELP 5  	/* STRING */
