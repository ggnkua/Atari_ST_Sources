#define USERIMG 0  	/* TREE */
#define STARTUP 1  	/* TREE */
#define TEXT1 2  	/* TREE */
#define TEXT2 3  	/* TREE */
#define TEXT3 4  	/* TREE */
#define FLY 5  	/* TREE */
#define HOTKEY2 6  	/* TREE */
#define ALL 7  	/* TREE */
#define GRAFIK1 8  	/* TREE */
#define GRAFIK2 9  	/* TREE */
#define ALL2 10  	/* TREE */
#define ENDE 11  	/* TREE */
#define HOTKEY1 12  	/* TREE */
#define RBHOFF 1  	/* OBJECT in TREE #0 */
#define RBHON 2  	/* OBJECT in TREE #0 */
#define RBLON 3  	/* OBJECT in TREE #0 */
#define RBLOFF 4  	/* OBJECT in TREE #0 */
#define CLR1 6  	/* OBJECT in TREE #3 */
#define CLR2 2  	/* OBJECT in TREE #4 */
#define CLR3 5  	/* OBJECT in TREE #6 */
#define CLR4 4  	/* OBJECT in TREE #7 */
#define CLR5 5  	/* OBJECT in TREE #7 */
#define FARBE1 15  	/* OBJECT in TREE #10 */
#define FARBE2 16  	/* OBJECT in TREE #10 */
#define ALERT1 0  	/* STRING */
#define ALERT2A 1  	/* STRING */
#define ALERT2B 2  	/* STRING */
#define ALERT3A 3  	/* STRING */
#define ALERT3B 4  	/* STRING */
#define HELP 5  	/* STRING */
