#define USERIMG 0  	/* TREE */
#define STARTUP 1  	/* TREE */
#define EINF 2  	/* TREE */
#define HOTKEY1 3  	/* TREE */
#define HOTKEY2 4  	/* TREE */
#define RCSMSG 5  	/* TREE */
#define BEISPIE1 6  	/* TREE */
#define OPTION 7  	/* TREE */
#define DEFAULT2 8  	/* TREE */
#define RBCHK 9  	/* TREE */
#define NOFLY 10  	/* TREE */
#define RBHOFF 1  	/* OBJECT in TREE #0 */
#define RBHON 2  	/* OBJECT in TREE #0 */
#define RBLON 3  	/* OBJECT in TREE #0 */
#define RBLOFF 4  	/* OBJECT in TREE #0 */
#define VOR1 14  	/* OBJECT in TREE #2 */
#define OPT1 16  	/* OBJECT in TREE #2 */
#define VOR2 14  	/* OBJECT in TREE #3 */
#define IBOX1 17  	/* OBJECT in TREE #3 */
#define OPT2 19  	/* OBJECT in TREE #3 */
#define ZUR2 21  	/* OBJECT in TREE #3 */
#define IBOX2 18  	/* OBJECT in TREE #4 */
#define VOR3 19  	/* OBJECT in TREE #4 */
#define OPT3 21  	/* OBJECT in TREE #4 */
#define ZUR3 23  	/* OBJECT in TREE #4 */
#define CLR1 28  	/* OBJECT in TREE #6 */
#define SUCHE 29  	/* OBJECT in TREE #6 */
#define VOR4 31  	/* OBJECT in TREE #6 */
#define OPT4 33  	/* OBJECT in TREE #6 */
#define ZUR4 35  	/* OBJECT in TREE #6 */
#define GRSHR 8  	/* OBJECT in TREE #7 */
#define HOTALT 12  	/* OBJECT in TREE #7 */
#define HOTCTRL 15  	/* OBJECT in TREE #7 */
#define HOTNONE 18  	/* OBJECT in TREE #7 */
#define CENTER 22  	/* OBJECT in TREE #7 */
#define DOPPEL 25  	/* OBJECT in TREE #7 */
#define VOR5 9  	/* OBJECT in TREE #8 */
#define OPT5 11  	/* OBJECT in TREE #8 */
#define ZUR5 13  	/* OBJECT in TREE #8 */
#define VOR6 10  	/* OBJECT in TREE #9 */
#define OPT6 12  	/* OBJECT in TREE #9 */
#define ZUR6 14  	/* OBJECT in TREE #9 */
#define FLYOBJ 1  	/* OBJECT in TREE #10 */
#define ZUR7 5  	/* OBJECT in TREE #10 */
#define ALERT1 0  	/* STRING */
#define ALERT2A 1  	/* STRING */
#define ALERT2B 2  	/* STRING */
#define ALERT3A 3  	/* STRING */
#define ALERT3B 4  	/* STRING */
#define HELP 5  	/* STRING */
