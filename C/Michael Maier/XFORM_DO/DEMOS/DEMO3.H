#define USERIMG 0  	/* TREE */
#define STARTUP 1  	/* TREE */
#define AUSGABE 2  	/* TREE */
#define RBHOFF 1  	/* OBJECT in TREE #0 */
#define RBHON 2  	/* OBJECT in TREE #0 */
#define RBLON 3  	/* OBJECT in TREE #0 */
#define RBLOFF 4  	/* OBJECT in TREE #0 */
#define VHANDLE 3  	/* OBJECT in TREE #2 */
#define GRRES 4  	/* OBJECT in TREE #2 */
#define PLANES 5  	/* OBJECT in TREE #2 */
#define GRCW 6  	/* OBJECT in TREE #2 */
#define GRCH 7  	/* OBJECT in TREE #2 */
#define MAXH 8  	/* OBJECT in TREE #2 */
#define GRBW 9  	/* OBJECT in TREE #2 */
#define GRBH 10  	/* OBJECT in TREE #2 */
#define MAXW 11  	/* OBJECT in TREE #2 */
#define AKTIV 12  	/* OBJECT in TREE #2 */
#define ALERT1 0  	/* STRING */
#define ALERT2A 1  	/* STRING */
#define ALERT2B 2  	/* STRING */
#define ALERT3A 3  	/* STRING */
#define ALERT3B 4  	/* STRING */
#define HELP 5  	/* STRING */
