#define RCALC 0  	/* TREE */
#define RDISPLAY 1  	/* OBJECT in TREE #0 */
#define BZERO 6  	/* OBJECT in TREE #0 */
#define BONE 7  	/* OBJECT in TREE #0 */
#define BTWO 8  	/* OBJECT in TREE #0 */
#define BTHREE 9  	/* OBJECT in TREE #0 */
#define BFOUR 14  	/* OBJECT in TREE #0 */
#define BFIVE 15  	/* OBJECT in TREE #0 */
#define BSIX 16  	/* OBJECT in TREE #0 */
#define BSEVEN 17  	/* OBJECT in TREE #0 */
#define BEIGHT 22  	/* OBJECT in TREE #0 */
#define BNINE 23  	/* OBJECT in TREE #0 */
#define BA 24  	/* OBJECT in TREE #0 */
#define BB 25  	/* OBJECT in TREE #0 */
#define BC 30  	/* OBJECT in TREE #0 */
#define BD 31  	/* OBJECT in TREE #0 */
#define BE 32  	/* OBJECT in TREE #0 */
#define BF 33  	/* OBJECT in TREE #0 */
#define BDEC 2  	/* OBJECT in TREE #0 */
#define BOCT 3  	/* OBJECT in TREE #0 */
#define BHEX 4  	/* OBJECT in TREE #0 */
#define BCLEAR 5  	/* OBJECT in TREE #0 */
#define BEQUAL 10  	/* OBJECT in TREE #0 */
#define BOR 11  	/* OBJECT in TREE #0 */
#define BXOR 12  	/* OBJECT in TREE #0 */
#define BAND 13  	/* OBJECT in TREE #0 */
#define BLSH 18  	/* OBJECT in TREE #0 */
#define BRSH 19  	/* OBJECT in TREE #0 */
#define BADD 20  	/* OBJECT in TREE #0 */
#define BSUB 21  	/* OBJECT in TREE #0 */
#define BMULT 26  	/* OBJECT in TREE #0 */
#define BDIV 27  	/* OBJECT in TREE #0 */
#define BREM 28  	/* OBJECT in TREE #0 */
#define BLPAR 29  	/* OBJECT in TREE #0 */
#define BRPAR 34  	/* OBJECT in TREE #0 */
#define BMINUS 35  	/* OBJECT in TREE #0 */
#define BCOMP 36  	/* OBJECT in TREE #0 */
#define BCENTRY 37  	/* OBJECT in TREE #0 */
#define ASTACK 0  	/* STRING */
#define ASMALL 1  	/* STRING */
#define APAREN 2  	/* STRING */
