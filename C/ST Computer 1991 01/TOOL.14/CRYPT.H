/*
 * Listing 3.5, Datei : crypt.h
 * Modul              : CRYPT - Verschl�sselung
 *                      nach dem DES
 * Modifikationsdatum : 12-Dez-1990
 * Abh„ngigkeiten     : -
 */

extern char *crypt();

