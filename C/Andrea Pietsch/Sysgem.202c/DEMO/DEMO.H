/* Resource Datei Indizes f�r DEMO */

#define MENUE            0   /* Menuebaum */
#define ME_INFO          7   /* STRING in Baum MENUE */
#define ME_EDIT          9   /* STRING in Baum MENUE */
#define ME_SLIDER        10  /* STRING in Baum MENUE */
#define ME_TEXT          11  /* STRING in Baum MENUE */
#define ME_OBJECT        12  /* STRING in Baum MENUE */
#define ME_QUIT          14  /* STRING in Baum MENUE */

#define WIN_MENUE        1   /* Menuebaum */
#define WI_INFO          7   /* STRING in Baum WIN_MENUE */
#define WI_CLOSE         9   /* STRING in Baum WIN_MENUE */

#define MAIN             2   /* Formular/Dialog */
#define MA_3D            2   /* BUTTON in Baum MAIN */
#define MA_ROUND         3   /* BUTTON in Baum MAIN */
#define MA_LIST          5   /* TEXT in Baum MAIN */
#define MA_CIRC          6   /* TEXT in Baum MAIN */
#define MA_MOD           7   /* BUTTON in Baum MAIN */
#define MA_EXIT          8   /* BUTTON in Baum MAIN */

#define TEXTWIN1         3   /* Formular/Dialog */
#define TE_ICONS         2   /* BUTTON in Baum TEXTWIN1 */
#define TE_FONT          3   /* BUTTON in Baum TEXTWIN1 */

#define ICONS            4   /* Formular/Dialog */
#define IC_FOLDER        1   /* ICON in Baum ICONS */
#define IC_POP           2   /* BOX in Baum ICONS */
#define IC_FIRST         3   /* STRING in Baum ICONS */
#define IC_LAST          11  /* STRING in Baum ICONS */
#define IC_BAR           12  /* ICON in Baum ICONS */

#define EDIT             5   /* Formular/Dialog */

#define SGINFO           6   /* Formular/Dialog */

#define SLIDER           7   /* Formular/Dialog */
#define SL_ICONS         2   /* BUTTON in Baum SLIDER */
#define SL_BOX           3   /* BOX in Baum SLIDER */
#define SL_UP            4   /* BOXCHAR in Baum SLIDER */
#define SL_HIDE          5   /* BOX in Baum SLIDER */
#define SL_SHOW          6   /* BOX in Baum SLIDER */
#define SL_DN            7   /* BOXCHAR in Baum SLIDER */
#define SL_LF            8   /* BOXCHAR in Baum SLIDER */
#define SL_HHIDE         9   /* BOX in Baum SLIDER */
#define SL_HSHOW         10  /* BOX in Baum SLIDER */
#define SL_RT            11  /* BOXCHAR in Baum SLIDER */
#define SL_BOX2          13  /* BOX in Baum SLIDER */
#define SL_UP2           14  /* BOXCHAR in Baum SLIDER */
#define SL_HIDE2         15  /* BOX in Baum SLIDER */
#define SL_SHOW2         16  /* BOX in Baum SLIDER */
#define SL_DN2           17  /* BOXCHAR in Baum SLIDER */
#define SL_LF2           18  /* BOXCHAR in Baum SLIDER */
#define SL_HHIDE2        19  /* BOX in Baum SLIDER */
#define SL_HSHOW2        20  /* BOX in Baum SLIDER */
#define SL_RT2           21  /* BOXCHAR in Baum SLIDER */

#define REITER           8   /* Formular/Dialog */
#define RE_BUTTON1       1   /* BUTTON in Baum REITER */
#define RE_RAHMEN1       2   /* BUTTON in Baum REITER */
#define RE_RAHMEN2       3   /* BUTTON in Baum REITER */
#define RE_BOXCHAR       4   /* BUTTON in Baum REITER */
#define RE_TEXT          5   /* BUTTON in Baum REITER */
#define RE_FRAME         6   /* BUTTON in Baum REITER */

#define BUTTONS          9   /* Formular/Dialog */

#define RAHMEN1          10  /* Formular/Dialog */

#define RAHMEN2          11  /* Formular/Dialog */

#define BOXCHARS         12  /* Formular/Dialog */

#define TEXTE            13  /* Formular/Dialog */
#define TE_EDTEXT        19  /* FTEXT in Baum TEXTE */

#define FRAME            14  /* Formular/Dialog */
