
#define	FLK_ABT	    0

#define FLK_BOX	    1
#define ABT_ME	    2
#define ABT_TXT1	    3
#define ABT_TXT2	    4
#define ABT_OK	    5

#define	FLK_FRM	    1

#define DEP_BOX	    1
#define FLK_OK	    2

#define	FLK_MEN	    2

#define FLK_DSK	    7
#define QUIT	   16
#define SET_OPT	   17
#define SAVE	   18
