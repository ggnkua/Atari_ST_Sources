extern void rsrc_init(void);

extern OBJECT MAIN_FRM[];
#define MAIN_BOX 0
#define INF_BUT 1
#define QUI_BUT 2
#define OK_BUT 3
#define MAN_BUT 4
#define JUL_BUT 5
#define FZ_BOX 6
#define RMIN_BOX 7
#define RMAX_BOX 8
#define IMIN_BOX 9
#define IMAX_BOX 10
#define REU_BOX 11
#define IMU_BOX 12
#define CUT_BOX 13
#define MAXIT_BOX 14
extern OBJECT INF_FRM[];
#define INF_BOX 0
#define INF_1 1
#define INF_2 2
#define INF_3 3
#define INF 4
#define INF_4 5
#define INF_5 6
#define PICK1 7
#define PICK2 8
#define PJS1 9
#define PJS2 10
#define INF_OK 11
