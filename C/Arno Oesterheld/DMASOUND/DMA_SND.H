#define KHZ25 34
#define SLFREQ 27
#define POS_BOX 5
#define KHZ50 35
#define SLTIME 29
#define MARKE 1
#define BEREICH 37
#define OLDPOS 3
#define SEQ 2
#define SEQ1 2
#define ALLSEQS 1
#define POSA 39
#define OKAY2 5
#define SEQ2 3
#define POSC 41
#define POSB 40
#define NEWPOS 7
#define CANCEL2 6
#define SEQ3 4
#define POSD 42
#define SEQ5 6
#define SEQ4 5
#define POSE 43
#define SEQ6 7
#define POSG 45
#define POSF 44
#define SEQ7 8
#define POSH 46
#define SEQ9 10
#define SEQ8 9
#define MENUE 4
#define SEQ10 11
#define SEQ11 12
#define VDO 50
#define SEQ13 14
#define SEQ12 13
#define SEQ14 15
#define VOLUME 53
#define VUP 52
#define SEQ15 16
#define SEQ17 18
#define SEQ16 17
#define VLDO 55
#define MESSAGE 8
#define SEQ18 19
#define VLUP 57
#define VLINKS 58
#define SB 22
#define SA 21
#define SC 23
#define VRDO 60
#define SD 24
#define VRUP 62
#define SF 26
#define SE 25
#define VRECHTS 63
#define SAVESAM 17
#define SG 27
#define LOADSAM 18
#define SH 28
#define HDO 66
#define ERASEALL 30
#define PLAYSEQ 29
#define HUP 67
#define QUIT 20
#define ENDSEQ 31
#define HOEHEN 68
#define ZMS 22
#define ERASE 32
#define FORMAT 23
#define BDO 71
#define SEQUENZ 24
#define BAESSE 73
#define BUP 72
#define CPYRGHT 3
#define MO_ST 1
#define OKAY 3
#define CANCEL 4
#define ZA 6
#define ZB 7
#define ZC 8
#define ZE 10
#define ZD 9
#define ZF 11
#define ZG 12
#define ZH 13
#define BA 16
#define BC 18
#define BB 17
#define BD 19
#define BE 20
#define BG 22
#define BF 21
#define BH 23
#define DESK 0
#define MA1 3
#define MC1 5
#define MB1 4
#define MD1 6
#define GET_MARK 7
#define ME1 7
#define LOADSAVE 6
#define MG1 9
#define MF1 8
#define SLLEN 2
#define ENDA 3
#define MH1 10
#define ENDB 4
#define SLBIT 4
#define MA2 13
#define MB2 14
#define REM1 7
#define MC2 15
#define REM3 9
#define REM2 8
#define ME2 17
#define MD2 16
#define REM4 10
#define CANCEL4 11
#define ENDH 10
#define MF2 18
#define LTEXT 11
#define OKAY4 12
#define MG2 19
#define LOADA 13
#define LOADMS 12
#define MH2 20
#define PLAY 23
#define STOP 25
#define PNONSTOP 24
#define RECORD 26
#define OKAY3 21
#define LOADH 20
#define MONO 29
#define CANCEL3 22
#define STEREO 30
#define SLDATE 23
#define SLCH 25
#define KHZ12 33
#define KHZ6 32
