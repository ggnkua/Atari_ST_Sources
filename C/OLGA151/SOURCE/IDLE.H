/***************************
 * idle.h                  *
 ***************************
 * include file for idle.c *
 ***************************
 * [1998-06-02, tm]        *
 * - first C version       *
 ***************************/

#ifndef IDLE_H
#define IDLE_H

void olga_idle(int *pipe);

#endif
