/*****************************
 * getext.h                  *
 *****************************
 * include file for getext.c *
 *****************************
 * [1998-06-02, tm]          *
 * - first C version         *
 *****************************/

#ifndef GETEXT_H
#define GETEXT_H

void olga_getextension(int *pipe);

#endif
