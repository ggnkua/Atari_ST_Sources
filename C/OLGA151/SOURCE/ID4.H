/**************************
 * id4.h                  *
 **************************
 * include file for id4.c *
 **************************
 * [1998-06-02, tm]       *
 * - first C version      *
 **************************/

#ifndef ID4_H
#define ID4_H

void olga_getobjects(int *pipe);
void olga_activate(int *pipe);
void olga_embed(int *pipe);

#endif
