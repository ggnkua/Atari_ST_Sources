/******************************
 * initman.h                  *
 ******************************
 * include file for initman.c *
 ******************************
 * [1998-06-02, tm]           *
 * - first C version          *
 ******************************/

#ifndef INITMAN_H
#define INITMAN_H

void init_manager(void);

#endif
