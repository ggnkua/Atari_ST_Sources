/*****************************
 * getset.h                  *
 *****************************
 * include file for getset.c *
 *****************************
 * [1998-06-02, tm]          *
 * - first C version         *
 *****************************/

#ifndef GETSET_H
#define GETSET_H

void olga_getsettings(int *pipe);

#endif
