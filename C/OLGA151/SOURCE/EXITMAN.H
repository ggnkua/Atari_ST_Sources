/******************************
 * exitman.h                  *
 ******************************
 * include file for exitman.c *
 ******************************
 * [1998-06-02, tm]           *
 * - first C version          *
 ******************************/

#ifndef EXITMAN_H
#define EXITMAN_H

void exit_manager(void);

#endif
