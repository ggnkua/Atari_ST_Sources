/* drag.h */

void set_rect ( int index, int x, int y, int w, int h );

void move_rect ( int v_handle, int rect_anzahl, int *result_x, int *result_y, int work_x, int work_y, int work_w, int work_h );

void draw_boxes ( int v_handle, int anzahl );

