# include <portab.h>


WORD MenuCorrect( OBJECT *menuptr );

VOID MenuTune( OBJECT *menuptr, WORD v_handle );
