#define	saveALL	1
#define	saveHDR	2
#define	saveMSG	4
#define	FAST_MEMORY_NEEDS	2160