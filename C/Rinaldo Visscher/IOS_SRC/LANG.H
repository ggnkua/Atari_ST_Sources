/*
**	Message defines for language file.
*/

#if !defined (__LANG_H__)
#define __LANG_H__

#define M__DAILY_RAPPORT			0
#define M__RAPPORT_NOT_OPEN		1
#define M__LABEL_EXPECT			2
#define M__ILL_LABEL				3
#define M__SWITCH_MAIN				4
#define M__LOG_NOT_OPEN			5
#define M__LOG_DIR					6
#define M__NO_INBOUND				7
#define M__DIR_SEARCH				8
#define M__MESSAGES_IMPORTED		9
#define M__MESSAGES_CREATED		10
#define M__MESSAGES_TRASHED		11
#define M__AREAFIX_NORUN			12
#define M__ROUTE_OVERFLOW			13
#define M__MEMORY_ERROR			14
#define M__EVENT_ERROR				15
#define M__DATE_ERROR				16
#define M__HOUR_ERROR				17
#define M__AREAFIX_PWD				18
#define M__CANT_OPEN				19
#define M__READING					20
#define M__NO_REMOTE				21
#define M__NO_OPEN_CREATE			22
#define M__WRITE_LASTRD			23
#define M__CANT_OPEN_LR			24
#define M__CONFIG_NOT_FOUND		25
#define M__CANT_EXEC_LABEL			26
#define M__NO_HELP					27
#define M__SWITCH_CONF				28
#define M__NO_COMMAND				29
#define M__NO_LOGLEVEL				30
#define M__ARCHIVER_CMD_UNKN		31
#define M__EMPTY_DBASE				32
#define M__DBASE_KNOWN				33
#define M__NO_NAME_DBASE			34
#define M__DIRECTION_ERROR			35
#define M__NO_NAME_KILL			36
#define M__NO_QBBS					37
#define M__NO_NUMBER_DISKSPC		38
#define M__NO_NODE_MOVE_M			39
#define M__NO_NODE_FILE_M			40
#define M__UNKNOWN_COMMAND			41
#define M__DIR_NOT_SPECIFIED		42
#define M__ADDRESS_NOT_SPECIFIED	43
#define M__NO_DBASE_DIR			44
#define M__CANT_CREATE_TEMP_DIR	45
#define M__AREA_NOT_				46
#define M__DEST_AREA_ERROR			47
#define M__ARGUMENT_ERROR			48
#define M__AREA_LINE_2				49
#define M__NO_MESSAGE				50
#define M__MORE_AREA_LINES			51
#define M__INTL_ERROR				52
#define M__PATH_ERROR				53
#define M__PATH_HAS_NO_NODES		54
#define M__NO_MESSAGE_PACKET		55
#define M__IS_MESSAGE_PACKET		56
#define M__RECEIVED				57
#define M__SIZE_OF					58
#define M__TAKE_DEFAULT			59
#define M__EXECUTE_PRG				60
#define M__CANT_EXEC_PRG			61
#define M__NOT_UNPACKED			62
#define M__RETURNS_ERRORCODE		63
#define M__CANT_RENAME				64
#define M__CANT_ASK_DISKFREE		65
#define M__DISKSPACE_EXEEDED		66
#define M__PACKET_TYPE_ERROR		67
#define M__IMP_UNKNOWN				68
#define M__IMPORT_MESSAGES			69
#define M__ASSEMBLED_ON			70
#define M__PACKET_SIZE				71
#define M__DESTANATION_ERROR		72
#define M__PASSWORD_ERROR			73
#define M__BAD_PACKET_RENAME		74
#define M__ILLEGAL_MESSAGE_TYPE	75
#define M__UNEXPECTED_END_PKT		76
#define M__ERROR_MESSAGE			77
#define M__DAMAGED_PACKET			78
#define M__UNEXPECTED_END_MSG		79
#define M__MSG_TO_LONG				80
#define M__END_OF_PACKET			81
#define M__MSG_FOUND				82
#define M__NO_MSG_ANYMORE			83
#define M__NETMAIL_MSG				84
#define M__EMPTY_MSG				85
#define M__ORG_ADDRESS_UNKNOWN		86
#define M__NOT_CONNECTED			87
#define M__DUP_MSG					88
#define M__TRASH_MSG				89
#define M__MSG_TO_DATABASE			90
#define M__COPY_TO					91
#define M__COPY_TO_AREA			92
#define M__MOVE_AREA				93
#define M__CANT_OPEN_AREA			94
#define M__CANT_OPEN_HEADER		95
#define M__CANT_OPEN_PACKET		96
#define M__CANT_CREATE_PACKET		97
#define M__UNKNOWN_ERROR_PKT		98
#define M__WRITE_ERROR				99
#define M__NO_AREALINE				100
#define M__ILLEGAL_MSGID			101
#define M__MSG_TO_BIG_TO_ADD		102
#define M__CONFIG_ERROR_ADRES		103
#define M__NETMAIL_READ			104
#define M__NETMAIL_MSG_TO_BIG		105
#define M__CANT_OPEN_NETMAIL		106
#define M__FILE_PROBLEM			107
#define M__SEEK_ERROR				108
#define M__ARC_PACKETS				109
#define M__PACKET_TO_SMALL			110
#define M__FILENAME_PROBLEM		111
#define M__MSG_MOVED				112
#define M__UNKNOWN_POINT			113
#define M__MORE_MAILERS			114
#define M__PACKER_CHANGED			115
#define M__TAKE_OLD				116
#define M__NO_PACKER_SPEC			117
#define M__UNKNOWN_ERROR			118
#define M__SEND_MAIL				119
#define M__PACKET_NOT_ARCED		120
#define M__CANT_CREATE_POLL		121
#define M__CANT_CREATE_POLL_FILE	122
#define M__CREATED_POLL			123
#define M__SEND_UNPACKED			124
#define M__CANT_MOVE_PKT			125
#define M__READ_ERROR				126
#define M__GATEWAY_MSG				127
#define M__NO_GATEWAY				128
#define M__MSG_TO_BIG				129
#define M__HOLD_TO_POLL			130
#define M__CHECK_SIZE				131
#define M__HOLD_TO_POLL_POINT		132
#define M__CHANGE_TO_POLL			133
#define M__DELETE_PACKET			134
#define M__UNKNOWN_ERR_CHANGE		135
#define M__CANT_RENAME_POLL		136
#define M__CHECK_HOLD				137
#define M__HOLD_TO_POLL_FILE		138
#define M__CANT_CREATE_FOLDER		139
#define M__FILE_NOT_SENT			140
#define M__FILE_TO_BIG				141
#define M__GET_FILES				142
#define M__FILE_NOT_FOUND			143
#define M__FILE_DOESNT_EXIST		144
#define M__NO_FILE_SPECIFIED		145
#define M__SENT_FILE_TO			146
#define M__NO_DESTANATION			147
#define M__FOLLOW_ROUTE			148
#define M__MAIL_CRASHED			149
#define M__MAIL_REDIRECTED			150
#define M__MAIL_UNDER				151
#define M__MAIL_BOUNCED			152
#define M__NO_PATH					153
#define M__POINT_USES_BOSS			154
#define M__PVTBOX_UNKNOWN			155
#define M__NODE_UNKNOWN			156
#define M__CHECK_PWDS				157
#define M__NODE_UNKNOWN_NETMAIL	158
#define M__CHECK_CONFIG			159
#define M__COMPILER_ERROR			160
#define M__CANT_CRASH_POINT		161
#define M__CANT_OPEN_B_DBASE		162
#define M__CANT_OPEN_M_DBASE		163
#define M__UNKNOWN_AREA_NUMBER		164
#define M__ORG_LINE_TO_LONG		165
#define M__SER_PROBLEMS			166
#define M__READ_ONLY_AREA			167
#define M__VIA_NODE				168
#define M__VIA_NETMAIL				169
#define M__READING_AREA			170
#define M__READING_PVTBOX			171
#define M__FILESIZE_PROBLEM		172
#define M__MSG_TO_BIG_SIZE			173
#define M__SCAN_AREAS				174
#define M__DIR_TO_BIG				175
#define M__ERROR_OPENING_AREA		176
#define M__CANT_CREATE_BUFFER		177
#define M__HEADER_OVERFLOW			178
#define M__CANT_CLOSE_MSG			179
#define M__COMPACTING				180
#define M__MSGS_DELETED			181
#define M__NOTHING_DELETED			182
#define M__EMPTY_AREA				183
#define M__MINIMUM_MSGS			184
#define M__MAXIMUM_MSGS			185
#define M__FILE_IO_ERROR			186
#define M__NO_DISKSPACE			187
#define M__MSGS_RESUMEND			188
#define M__NO_HELP_FILE				189
#define M__AREADAYS					190
#define M__PACKETTYPE				191
#define M__NO_PRDCODE_LIST			192
#define M__MISSING_DOMAIN			193
#define M__NO_ORIGINFILE			194
#define M__AREAFIX_PARSE			195
#define M__AREAFIX_NODE_UNKNOWN		196
#define M__AREAFIX_WRITE_AREAS		197
#define M__AREAFIX_DISCONNECT		198
#define M__AREAFIX_NO_CONNECT		199
#define M__AREAFIX_NO_EXIST			200
#define M__AREAFIX_EXIST			201
#define M__AREAFIX_SORT				202
#define M__AREAFIX_CONNECTED		203
#define M__AREAFIX_RESCAN			204
#define M__AREAFIX_ILLEGAL_MSG		205
#define M__AREAFIX_RESCANNED		206
#define M__AREAFIX_QUERY			207
#define M__AREAFIX_TOTAL			208
#define M__READING_DUPES			209
#define M__WRITING_DUPES			210
#define M__F_ECHO_POINT_UNKNOWN		211
#define M__IMPORT_TIME				212
#define M__OVERAL_TIME				213
#define M__POINT_NOT_SYSTEM			214
#define M__NO_RANDOM_FILE			215
#define M__CALCULATE_ORIGIN			216
#define M__CANT_MAKE_UNCOM			217
#define M__CANT_CREATE_PASSTR		218
#define M__CANT_CREATE_BINAIR		219
#define M__RECOMPILE_AREAS			220
#define M__BODY_ERROR				221

#define LAST_MESSAGE				222

#endif