/*
**	Proto for WAREAS.C
*/

VOID write_bin_areas(VOID);
VOID uncompile(VOID);
BOOLEAN read_bin_areas(VOID);
BOOLEAN area_attrib(VOID);
