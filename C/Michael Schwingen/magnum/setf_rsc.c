#include "setflags.rsh"