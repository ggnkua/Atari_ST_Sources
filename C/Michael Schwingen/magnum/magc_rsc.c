#include "magnconf.rsh"