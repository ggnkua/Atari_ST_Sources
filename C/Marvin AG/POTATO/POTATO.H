/* resource set indicies for IDC__RSC */

#define ROMPORT  0	/* form/dialog */
#define ROM0     4	/* BUTTON in tree ROMPORT */
#define ROM3     5	/* BUTTON in tree ROMPORT */
#define ROM2     6	/* BUTTON in tree ROMPORT */
#define ROM1     7	/* BUTTON in tree ROMPORT */
#define RROM3    10	/* BOXTEXT in tree ROMPORT */
#define RROM2    11	/* BOXTEXT in tree ROMPORT */
#define RROM1    12	/* BOXTEXT in tree ROMPORT */
#define RROM0    14	/* BOXTEXT in tree ROMPORT */

