/* Indice du ressource pour STUT_3 */

#define MENU     0   /* Arbre menu */
#define DESK     3   /* TITLE dans l'arbre MENU */
#define FICHIERS 4   /* TITLE dans l'arbre MENU */
#define INFOS    12  /* STRING dans l'arbre MENU */
#define OUVRIR   21  /* STRING dans l'arbre MENU */
#define FERMER   22  /* STRING dans l'arbre MENU */
#define SAUVER   23  /* STRING dans l'arbre MENU */
#define SAVEAS   24  /* STRING dans l'arbre MENU */
#define SAVEDISK 25  /* STRING dans l'arbre MENU */
#define RENAME   26  /* STRING dans l'arbre MENU */
#define PREMPLAN 28  /* STRING dans l'arbre MENU */
#define QUITTER  30  /* STRING dans l'arbre MENU */
#define MENNEWLK 32  /* STRING dans l'arbre MENU */
#define MENNEWPG 33  /* STRING dans l'arbre MENU */
#define MENEWRUB 35  /* STRING dans l'arbre MENU */
#define MENEWTXT 37  /* STRING dans l'arbre MENU */
#define MENCOMPI 39  /* STRING dans l'arbre MENU */
#define MENDECMP 40  /* STRING dans l'arbre MENU */
#define STESTLOC 42  /* STRING dans l'arbre MENU */
#define SLANCER  43  /* STRING dans l'arbre MENU */
#define MINISERV 45  /* STRING dans l'arbre MENU */
#define MLOADINF 47  /* STRING dans l'arbre MENU */
#define MSAVEINF 48  /* STRING dans l'arbre MENU */
#define PARAMETR 50  /* STRING dans l'arbre MENU */
#define AFFICHAG 51  /* STRING dans l'arbre MENU */
#define SAFFECT  53  /* STRING dans l'arbre MENU */
#define MECOMPAT 55  /* STRING dans l'arbre MENU */
#define MSAVEINI 57  /* STRING dans l'arbre MENU */
#define VIDE     59  /* STRING dans l'arbre MENU */
#define DEBUG    60  /* STRING dans l'arbre MENU */
#define SYSTEMST 61  /* STRING dans l'arbre MENU */

#define APROPOS  1   /* Formulaire/Dialogue */
#define PRGNAME  1   /* TEXT dans l'arbre APROPOS */
#define RELEASE  2   /* TEXT dans l'arbre APROPOS */

#define NEWLINK  2   /* Formulaire/Dialogue */
#define LKFETS   3   /* IMAGE dans l'arbre NEWLINK */
#define LKFETWS  4   /* IMAGE dans l'arbre NEWLINK */
#define LKFNTWSE 5   /* IMAGE dans l'arbre NEWLINK */
#define LKFWTSE  6   /* IMAGE dans l'arbre NEWLINK */
#define LKFWTS   7   /* IMAGE dans l'arbre NEWLINK */
#define LKFNTWS  8   /* IMAGE dans l'arbre NEWLINK */
#define LKFNTS   9   /* IMAGE dans l'arbre NEWLINK */
#define LKFNTSE  10  /* IMAGE dans l'arbre NEWLINK */
#define LKFNTW   11  /* IMAGE dans l'arbre NEWLINK */
#define LKFETW   12  /* IMAGE dans l'arbre NEWLINK */
#define LKFNTWE  13  /* IMAGE dans l'arbre NEWLINK */
#define LKFWTE   14  /* IMAGE dans l'arbre NEWLINK */
#define LKFNTE   15  /* IMAGE dans l'arbre NEWLINK */
#define NEWLKANN 16  /* BUTTON dans l'arbre NEWLINK */

#define NEWLMED  3   /* Formulaire/Dialogue */

#define NEWPAGEA 4   /* Formulaire/Dialogue */
#define ARBOMENU 2   /* ICON dans l'arbre NEWPAGEA */
#define ARBOFSEL 3   /* ICON dans l'arbre NEWPAGEA */
#define DISPTEXT 4   /* ICON dans l'arbre NEWPAGEA */
#define ARBODWLD 5   /* ICON dans l'arbre NEWPAGEA */
#define AECRIMSG 6   /* ICON dans l'arbre NEWPAGEA */
#define ARBOID   7   /* ICON dans l'arbre NEWPAGEA */
#define ALECTMSG 8   /* ICON dans l'arbre NEWPAGEA */
#define ARBONACC 9   /* ICON dans l'arbre NEWPAGEA */
#define ARBOLIST 10  /* ICON dans l'arbre NEWPAGEA */
#define ARBODIR  11  /* ICON dans l'arbre NEWPAGEA */
#define NEWPAGAN 13  /* BUTTON dans l'arbre NEWPAGEA */

#define NEWPAMED 5   /* Formulaire/Dialogue */
#define MENUMED  2   /* ICON dans l'arbre NEWPAMED */
#define TEXTMED  4   /* ICON dans l'arbre NEWPAMED */
#define ECRIMED  6   /* ICON dans l'arbre NEWPAMED */
#define IDMED    7   /* ICON dans l'arbre NEWPAMED */
#define LECTMED  8   /* ICON dans l'arbre NEWPAMED */
#define NEWACMED 9   /* ICON dans l'arbre NEWPAMED */
#define LISTMED  10  /* ICON dans l'arbre NEWPAMED */
#define DIRMED   11  /* ICON dans l'arbre NEWPAMED */

#define AFFICTXT 6   /* Formulaire/Dialogue */
#define AFTXTCNF 1   /* BUTTON dans l'arbre AFFICTXT */
#define TEXTSIZE 5   /* FTEXT dans l'arbre AFFICTXT */
#define AFFLGMAX 7   /* FTEXT dans l'arbre AFFICTXT */

#define TERMCONF 7   /* Formulaire/Dialogue */
#define PORT     3   /* BOXTEXT dans l'arbre TERMCONF */
#define PORTUP   4   /* BOXTEXT dans l'arbre TERMCONF */
#define BUFIN    9   /* FBOXTEXT dans l'arbre TERMCONF */
#define BUFOUT   11  /* FBOXTEXT dans l'arbre TERMCONF */
#define PTERMVAL 13  /* BUTTON dans l'arbre TERMCONF */
#define PTERMANN 14  /* BUTTON dans l'arbre TERMCONF */

#define AFFECT   8   /* Formulaire/Dialogue */
#define AFFECAJ  14  /* BOXTEXT dans l'arbre AFFECT */
#define AFFECMOD 15  /* BOXTEXT dans l'arbre AFFECT */
#define AFFECSUP 16  /* BOXTEXT dans l'arbre AFFECT */
#define AFFECVAL 17  /* BUTTON dans l'arbre AFFECT */
#define AFFECANN 18  /* BUTTON dans l'arbre AFFECT */

#define PARAVOIE 9   /* Formulaire/Dialogue */
#define VOIENUM  3   /* TEXT dans l'arbre PARAVOIE */
#define VOIEPORT 5   /* BOXTEXT dans l'arbre PARAVOIE */
#define VOIPORUP 6   /* BOXTEXT dans l'arbre PARAVOIE */
#define VOIEMODE 8   /* BOXTEXT dans l'arbre PARAVOIE */
#define VOIMODUP 9   /* BOXTEXT dans l'arbre PARAVOIE */
#define VOIEVAL  13  /* BUTTON dans l'arbre PARAVOIE */
#define VOIEANN  14  /* BUTTON dans l'arbre PARAVOIE */

#define COMPATIB 10  /* Formulaire/Dialogue */
#define GFORMSTD 2   /* BOX dans l'arbre COMPATIB */
#define TESTCOMP 3   /* BOX dans l'arbre COMPATIB */
#define COMPVALI 7   /* BUTTON dans l'arbre COMPATIB */

#define PROGRESS 11  /* Formulaire/Dialogue */
#define PROGINFO 2   /* TEXT dans l'arbre PROGRESS */
#define PROGBOX  3   /* BOX dans l'arbre PROGRESS */
#define PROGBAR  4   /* BOX dans l'arbre PROGRESS */
#define PROGTITL 5   /* BOXTEXT dans l'arbre PROGRESS */
#define PROGANNU 6   /* BUTTON dans l'arbre PROGRESS */

#define RAMSELEC 12  /* Formulaire/Dialogue */
#define RSELTITR 1   /* TEXT dans l'arbre RAMSELEC */
#define RSELPATH 2   /* BOXTEXT dans l'arbre RAMSELEC */
#define RSELFIXP 3   /* BOXTEXT dans l'arbre RAMSELEC */
#define RSELSEL  23  /* FBOXTEXT dans l'arbre RAMSELEC */
#define RSELVALI 24  /* BUTTON dans l'arbre RAMSELEC */
#define RSELANNU 25  /* BUTTON dans l'arbre RAMSELEC */

#define NAMES    13  /* Formulaire/Dialogue */
#define RENTITLE 1   /* TEXT dans l'arbre NAMES */
#define NAME_OLD 3   /* STRING dans l'arbre NAMES */
#define RNOLDCMT 4   /* STRING dans l'arbre NAMES */
#define NAME_NEW 6   /* FBOXTEXT dans l'arbre NAMES */
#define RNNEWCMT 7   /* FBOXTEXT dans l'arbre NAMES */
#define NAMEVAL  8   /* BUTTON dans l'arbre NAMES */
#define NAMEANN  9   /* BUTTON dans l'arbre NAMES */

#define ARBOSOMM 14  /* Formulaire/Dialogue */
#define NOMARBO  5   /* TEXT dans l'arbre ARBOSOMM */
#define FNCTARBO 6   /* TEXT dans l'arbre ARBOSOMM */
#define COMENTAR 7   /* BOXTEXT dans l'arbre ARBOSOMM */
#define PGESECRA 9   /* ICON dans l'arbre ARBOSOMM */
#define PARAMS   10  /* ICON dans l'arbre ARBOSOMM */
#define AFFICHGS 11  /* ICON dans l'arbre ARBOSOMM */
#define ARBDATAS 12  /* ICON dans l'arbre ARBOSOMM */
#define SAISIES  13  /* ICON dans l'arbre ARBOSOMM */
#define ERREURS  14  /* ICON dans l'arbre ARBOSOMM */
#define MOTSCLEF 15  /* ICON dans l'arbre ARBOSOMM */
#define LIENSARB 16  /* ICON dans l'arbre ARBOSOMM */

#define COMMENT  15  /* Formulaire/Dialogue */
#define CMTETEXT 2   /* FBOXTEXT dans l'arbre COMMENT */
#define CMTPAGE  4   /* TEXT dans l'arbre COMMENT */
#define CMTVALID 5   /* BUTTON dans l'arbre COMMENT */
#define CMTANNUL 6   /* BUTTON dans l'arbre COMMENT */

#define EDT_EDIT 16  /* Formulaire/Dialogue */
#define EN_EDIT  1   /* BOX dans l'arbre EDT_EDIT */
#define EDEDIT_C 3   /* STRING dans l'arbre EDT_EDIT */
#define EDEDTVAL 4   /* BUTTON dans l'arbre EDT_EDIT */
#define EDEDTANN 5   /* BUTTON dans l'arbre EDT_EDIT */
#define POS_CHAM 7   /* BUTTON dans l'arbre EDT_EDIT */
#define TAIL_CHA 8   /* BUTTON dans l'arbre EDT_EDIT */
#define CHAMP_X  10  /* FTEXT dans l'arbre EDT_EDIT */
#define CHAMP_Y  12  /* FTEXT dans l'arbre EDT_EDIT */
#define CHAMP_L  14  /* FTEXT dans l'arbre EDT_EDIT */
#define CHAMP_H  16  /* FTEXT dans l'arbre EDT_EDIT */
#define EDITSUP  20  /* BOXTEXT dans l'arbre EDT_EDIT */
#define EDITCACH 22  /* BOXTEXT dans l'arbre EDT_EDIT */
#define COLSUP   26  /* BOXTEXT dans l'arbre EDT_EDIT */
#define COLTEXT  28  /* BOXTEXT dans l'arbre EDT_EDIT */
#define INVSUP   29  /* BOXCHAR dans l'arbre EDT_EDIT */
#define INVTEXT  30  /* BOXCHAR dans l'arbre EDT_EDIT */
#define EDMULTIP 33  /* BOX dans l'arbre EDT_EDIT */
#define EDOBLIGA 35  /* BOX dans l'arbre EDT_EDIT */
#define EDAFFIMM 38  /* BUTTON dans l'arbre EDT_EDIT */
#define EDAFFENT 39  /* BUTTON dans l'arbre EDT_EDIT */
#define EDAFFTJS 40  /* BUTTON dans l'arbre EDT_EDIT */
#define EDMAXLIN 42  /* FTEXT dans l'arbre EDT_EDIT */
#define EDFILTER 44  /* BOXTEXT dans l'arbre EDT_EDIT */
#define INFLCODE 46  /* FTEXT dans l'arbre EDT_EDIT */
#define EDEFAULT 49  /* FTEXT dans l'arbre EDT_EDIT */

#define EDT_AFFZ 17  /* Formulaire/Dialogue */
#define EN_DISP  1   /* BOX dans l'arbre EDT_AFFZ */
#define AFFZ_FLD 3   /* STRING dans l'arbre EDT_AFFZ */
#define AFFZ_POS 5   /* BUTTON dans l'arbre EDT_AFFZ */
#define AFFZSIZE 6   /* BUTTON dans l'arbre EDT_AFFZ */
#define AFFZ_X   8   /* FTEXT dans l'arbre EDT_AFFZ */
#define AFFZ_Y   10  /* FTEXT dans l'arbre EDT_AFFZ */
#define AFFZ_W   12  /* FTEXT dans l'arbre EDT_AFFZ */
#define AFFZ_H   14  /* FTEXT dans l'arbre EDT_AFFZ */
#define AFFZTCOL 18  /* BOXTEXT dans l'arbre EDT_AFFZ */
#define AFFZICOL 20  /* BOXTEXT dans l'arbre EDT_AFFZ */
#define AFFZINVT 21  /* BOXCHAR dans l'arbre EDT_AFFZ */
#define AFFZINVI 22  /* BOXCHAR dans l'arbre EDT_AFFZ */
#define AFFZFMT  26  /* BOXTEXT dans l'arbre EDT_AFFZ */
#define AFFCLEAR 27  /* BOX dans l'arbre EDT_AFFZ */
#define OUTFCODE 30  /* FTEXT dans l'arbre EDT_AFFZ */
#define OUTGRPID 32  /* FTEXT dans l'arbre EDT_AFFZ */
#define AFFZ_VAL 34  /* BUTTON dans l'arbre EDT_AFFZ */
#define AFFZ_ANN 35  /* BUTTON dans l'arbre EDT_AFFZ */

#define EDTKEYWD 18  /* Formulaire/Dialogue */
#define EDKEYTIT 4   /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDLISTE  18  /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDKEYPAG 22  /* TEXT dans l'arbre EDTKEYWD */
#define EDKEYFNC 23  /* TEXT dans l'arbre EDTKEYWD */
#define LISTPARS 24  /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDAPFIX  25  /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDAPSPEC 26  /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDAPADD  27  /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDAPSUPP 28  /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDAPUP   29  /* BOXTEXT dans l'arbre EDTKEYWD */
#define EDAPDW   30  /* BOXTEXT dans l'arbre EDTKEYWD */
#define ADAPVAL  31  /* BUTTON dans l'arbre EDTKEYWD */
#define EDAPANN  32  /* BUTTON dans l'arbre EDTKEYWD */

#define EDT_KEY  19  /* Formulaire/Dialogue */
#define EVKEYTIT 1   /* TEXT dans l'arbre EDT_KEY */
#define NOMEVENT 4   /* BOXTEXT dans l'arbre EDT_KEY */
#define MOTCLEF  6   /* FTEXT dans l'arbre EDT_KEY */
#define MCACTION 9   /* BOXTEXT dans l'arbre EDT_KEY */
#define MCACTBUT 10  /* BOXTEXT dans l'arbre EDT_KEY */
#define CACTION2 12  /* BOXTEXT dans l'arbre EDT_KEY */
#define CACTBUT2 13  /* BOXTEXT dans l'arbre EDT_KEY */
#define BTARBODE 14  /* BOXTEXT dans l'arbre EDT_KEY */
#define MCARBOD  15  /* BOXTEXT dans l'arbre EDT_KEY */
#define MOTCLVAL 16  /* BUTTON dans l'arbre EDT_KEY */
#define MOTCLANN 17  /* BUTTON dans l'arbre EDT_KEY */

#define EDT_LIST 20  /* Formulaire/Dialogue */
#define LISTNBL  3   /* FTEXT dans l'arbre EDT_LIST */
#define LISTNBC  5   /* FTEXT dans l'arbre EDT_LIST */
#define LISTINTL 7   /* FTEXT dans l'arbre EDT_LIST */
#define LISTINTC 9   /* FTEXT dans l'arbre EDT_LIST */
#define LISTVAL  11  /* BUTTON dans l'arbre EDT_LIST */
#define LISTANNU 12  /* BUTTON dans l'arbre EDT_LIST */

#define PARALECT 21  /* Formulaire/Dialogue */
#define ANNUEFFA 2   /* BOX dans l'arbre PARALECT */
#define PLECTVAL 4   /* BUTTON dans l'arbre PARALECT */
#define PLECTANN 5   /* BUTTON dans l'arbre PARALECT */

#define PARAFSEL 22  /* Formulaire/Dialogue */
#define FSELROOT 3   /* FBOXTEXT dans l'arbre PARAFSEL */
#define FSELIHID 5   /* BOX dans l'arbre PARAFSEL */
#define FSELISYS 7   /* BOX dans l'arbre PARAFSEL */
#define FSELISUB 9   /* BOX dans l'arbre PARAFSEL */
#define FSELVAL  11  /* BUTTON dans l'arbre PARAFSEL */
#define FSELANN  12  /* BUTTON dans l'arbre PARAFSEL */
