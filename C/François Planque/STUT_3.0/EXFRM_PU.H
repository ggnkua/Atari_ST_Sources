/*
 * Extended_FormDo_Public.h
 */
 
	int	ext_form_gest( OBJECT *tree, int *startfield, int allow_outside );

	void	extform_lastmpos( int *mx, int *my );

	int	ext_form_do( OBJECT *tree, int *startfield );
