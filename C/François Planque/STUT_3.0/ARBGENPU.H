/*
 * Arbo_General_Public.h
 */

	FNCTSPEC		*fnct_spec( FNCTSPEC *fnctspec, int fnct );

