/*
 * Display_Text_Public.h
 */
 
	void	DispText_ENPG(
			VOIE	*	pVoie_curr );		/* In: Voie concern‚e */
	void	DispText_DispData( 
			VOIE *	pVoie_curr );	/* In: Voie concern‚e */
	void	DispText_KeyAction( 
			KEYCODE	curr_keypress, /* In: Touche press‚e */
			VOIE	*	pVoie_curr );	/* In: Voie concern‚e */
