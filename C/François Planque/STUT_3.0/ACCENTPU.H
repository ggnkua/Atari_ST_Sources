/*
 * Accents:
 */
	extern	void	init_accents( void );
	extern	char	*convert_Asc2Vdt( 		/* Out: Ptr sur tampon de caractŠres ‚quivalents */
							char	c_ascii );		/* In:  caractŠre … traduire */
	extern	char	convert_G2toAsc( 			/* Out: caractŠre ‚quivalent */
							char	c_ascii );		/* In:  caractŠre … traduire */
	extern	char	convert_Compose2Asc( 	/* Out: caractŠre ‚quivalent */
							char	c_accent,		/* In:  accent … composer */
							char	c_car );			/* In:  caractŠre … composer */
