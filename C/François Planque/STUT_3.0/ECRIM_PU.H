/*
 * Ecriture_Message_Public.h
 */

	void	EcriMsg_ENPG(
			VOIE	*	pVoie_curr );		/* In: Voie concernВe */
	void	EcriMsg_DispData(
			VOIE *	pVoie_curr );	/* In: Voie concernВe */
	void	keyaction_ecri_msg( KEYCODE curr_keypress, VOIE *pVoie_curr );
