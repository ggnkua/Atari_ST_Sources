/*
 * ArboFile_Public.h
 */

ULONG	get_OutFieldCode(		/* Out: code correspondant au champ */
			int	n_fnct );		/* In: no de fonction */
ULONG	get_InFieldCode(		/* Out: code correspondant au champ */
			int	n_fnct );		/* In: no de fonction */
