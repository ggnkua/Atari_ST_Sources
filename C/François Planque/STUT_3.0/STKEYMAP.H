/* 
 * STKeymap.h
 *
 * Constantes symboliques relatives au 
 * clavier et aux caractŠres du ST
 *
 * History:
 * --------
 * 25.05.94: Created by fplanque
 */

/*
 * Codes ASCII de caractŠres sp‚ciaux: 
 */
	#define	ST_FLECHE_HAUT		0x01
	#define	ST_FLECHE_BAS		0x02
	#define	ST_FLECHE_DROITE	0x03
	#define	ST_FLECHE_GAUCHE	0x04
	#define	ST_OE_MIN			180
	#define	ST_OE_MAJ			181

/*
 * Scan-Codes des touches sp‚ciales
 */
	#define	STSCAN_BS		0x0E
	#define	STSCAN_UP		0x48
	#define	STSCAN_LEFT		0x4B
	#define	STSCAN_RIGHT	0x4D
	#define	STSCAN_DOWN		0x50
	#define	STSCAN_DEL		0x53
	#define	STSCAN_UNDO		0x61

 