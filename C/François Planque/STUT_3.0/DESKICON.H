/* Indice du ressource pour DESKICON */

#define DESKTOP  0   /* Formulaire/Dialogue */
#define LOGOBOX  1   /* IBOX dans l'arbre DESKTOP */
#define LOGSHADE 2   /* IMAGE dans l'arbre DESKTOP */
#define LOGSHAPE 3   /* IMAGE dans l'arbre DESKTOP */
#define VERTEXT  5   /* TEXT dans l'arbre DESKTOP */
#define DSTDISK  6   /* ICON dans l'arbre DESKTOP */
#define DSTTERM  7   /* ICON dans l'arbre DESKTOP */
#define DSTTRASH 8   /* ICON dans l'arbre DESKTOP */
#define DSTARBO  9   /* ICON dans l'arbre DESKTOP */
#define DSTPAGES 10  /* BOX dans l'arbre DESKTOP */
#define DSTDATAS 11  /* ICON dans l'arbre DESKTOP */
#define DSTTEXTS 12  /* ICON dans l'arbre DESKTOP */
#define DSTPICS  13  /* ICON dans l'arbre DESKTOP */

#define ICONS    1   /* Formulaire/Dialogue */

#define IMAGE1   0   /* Ic“ne libre */

#define IMAGE2   1   /* Ic“ne libre */
