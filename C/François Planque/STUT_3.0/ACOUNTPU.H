/*
 * Accounts Public Defs
 */

void	keyaction_Identification(
							KEYCODE	curr_keypress, 
							VOIE 	*	pVoie_curr );
void	keyaction_NewAccount(
							KEYCODE	curr_keypress, 
							VOIE 	*	pVoie_curr );

