/*
 * PopUp.h
 */

#ifndef _POPUP_H_
#define _POPUP_H_

typedef
	struct
	{
		char	*name;		/* Nom de l'option */
		int	value;		/* Valeur associВe */
	}
	POPUP_ENTRY;


#endif