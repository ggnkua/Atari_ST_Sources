/*
 * dfstruct.h
 *                                                                 
 * Purpose:
 * --------
 *	Ce fichier contient toutes les structures de donnВes inter-
 * dВpendantes utilisВes par STUT ONE (fenИtres+contenu etc.. )
 *
 * Notes:
 * ------
 * Diagramme de dВpendances:  
 *
 *       				       dxf.h           arbotree.h
 * 							      | 	   	      /      \				      
 * DATABLOCK	DEGASPIX  DATA_RECORDS  PAGEARBO   ARBO_TEXTPAR
 *    		\_________\____   |   ____/             / 
 *									\  |  /                 /
 *     						 {DATAUNION}              /
 *          				      |           DIRSPEC
 *								  DATAPAGE       /           TEXTLINE
 *			   	      	          \     /               /
 *											DATADIR           TEXTINFO          FNCTSPEC
 *											/	    \___   ___/       \
 *  		   	      	    DATAGROUP       \ /       TEXT_DRAWPAR
 *  		      	      	                 FTA
 *
 *          
 *
 * History:
 * --------
 * 25.11.93: Sortie des structures de gestion des fenъtres AES vers
 *					le fichier gemwdef.h   
 * 25.11.93: Sortie des structures de gestion des voies vers le
 *					fichier serveur.h
 */

/*
 * VВrifie si les prВsentes dВfinitions ont dВja ВtВ faites:
 */
#if  !defined( _DFSTRUCT_H_ )
#define _DFSTRUCT_H_

/* 
 * Headers indispensables:
 */
	#include	<aes.h>						/* header AES */


/*
 * Custom Types:
 */
	#include "DXF.H"     
	#include "ARBOTREE.H"


/*
 * Icon-extended-(datagroup)type (stocked in flags) definitions: 
 * Les DG_xxx sont les types utilisВs dans le champ type des DATAGROUPS
 * et DATAPAGES.
 * ils sont repris sous forme de DTYP_xxx
 */
typedef
	enum
	{
		STYP_NONE =0,			/* pas de type */
		DTYP_ARBO,
		DTYP_PAGES,
		DTYP_DATAS,
		DTYP_TEXTS,
		DTYP_PICS,
		DTYP_UNKNOWN
	}
	DATATYPE;

	#define	NB_DATAGROUPS		5		/* On va crВer un emplacement pour 5 datagroups */
	#define	RAMPATH_MAXLEN		107	/* Suffit pour 10 dossiers + 1 nom de fichier */



/*
 * DEGASPIX: Image DEGAS Elite
 */
typedef
	struct
	{
		unsigned	int	rez;					/* RВsolution */
		unsigned	int	color[16];			/* Palette des 16 Couleurs */
		unsigned	int	bitmap[ 32000 / sizeof(unsigned int) ]; /* Bitmap */
		unsigned int	rsvd[16];			/* Ce qu'il reste derriКre */
	}
	DEGASPIX;
                    

/*
 * TEXTLINE: Ligne intщgrщe р un texte avec ptrs next/prev & info
 */                  
typedef
	struct		textline
	{
		struct textline	*prev;		/* Ptr sur Ligne prВcВdente */
		struct textline	*next;		/* Ptr sur Ligne suivante */
		struct
		{
			int	bufsize	 : 15;		/* Taille du buffer d'Вdition contenant cette ligne (\0 non compris) */
			int	continued : 1;
		}						info1;
		int					length;		/* Longueur de cette ligne (\0 non compris) */
		char					*text;		/* Pointeur sur le texte */
	}
	TEXTLINE;
   

/*
 * TEXTINFO: Infos sur un texte
 *
 * Purpose:
 * --------
 * Fournit point d'accКs vers la 1ere et derniКre ligne au format
 * TEXTLINE d'un texte
 *
 * Notes:
 * ------
 *
 * Notes:
 * -----
 * En COURS:
 * Virer topline et le mettre dans une structure contenant aussi un
 * ptr sur le reste de TEXTINFO. Cette structure pourra alors etre
 * liee a WIPARAMS par l'intermediaire de WORK_DRAW (25.11.93)
 * MИme chose pour le curseur...
 * 
 * History:
 * --------
 * 1993: fplanque: Created
 * 25.05.94: fplanque: Ajout de variables de gestion du curseur
 * 25.05.94: fplanque: Sorti toutes variables concernant l'affichage ds fenetre GEM vers TEXT_DRAWPAR
 */
typedef
	struct
	{
		TEXTLINE		*	firstline;			/* Ptr sur 1Кre ligne du texte affichщ */
		TEXTLINE		*	lastline;			/* Ptr sur derniКre ligne du texte */
		long				nb_lignes;			/* Nombre total de lignes */
	}
	TEXTINFO;


/*
 * TEXT_DRAWPAR: paramКtres nВcessaires Е l'affichage d'un texte
 * dans une fenИtre.
 *
 * Purpose:
 * --------
 * Fournit toutes les informations pour l'affichage d'un texte
 * lorsque le texte est affichВ dans une fenИtre:
 * la ligne du haut de la fenetre, la fonte, couleur etc...
 * Position du curseur, etc...
 *
 * Notes:
 * ------
 * Du au pointeur *topline, le texte ne doit etre affiche que dans
 * une seule fenetre a la fois
 *
 * Suggest:
 * --------
 * Virer topline et le mettre dans une structure contenant aussi un
 * ptr sur le reste de TEXTINFO. Cette structure pourra alors etre
 * liee a WIPARAMS par l'intermediaire de WORK_DRAW (25.11.93)
 * MИme chose pour le curseur...
 * 
 * History:
 * --------
 * 25.05.94: fplanque: Created
 */
typedef
	struct
	{
		TEXTINFO		*	pTextInfo;		/* ptr sur les infos sur le texte en RAM */
		TEXTLINE		*	pTextLine_top;	/* Ptr sur 1Кre ligne affichВe en haut de la fenИtre */
		long				l_topline;		/* No de la ligne en haut de la fenetre [0...] */

		int				n_points;		/* Taille en "points" */
		int				n_char_h;		/* Hauteur d'un caractКre: */
		int				n_cell_w;		/* Largeur d'un emplacement caractКre */
		int				n_cell_h;		/* Hauteur d'un emplacement caractКre */

		/*
		 * Pour textes non Вditables seulement:
		 */
		long				l_nbLinesMax;	/* Nbre de lignes Е conserver en mВmoire, les plus vieilles sont dВtruites */

		/*
		 * Edition:
		 * Si le texte est Read Only, pTextLine_edit === NULL
		 */
		TEXTLINE		*	pTextLine_edit;	/* Ligne en cours d'Вdition; porte le curseur */
		long				l_LigneCsr;			/* No Ligne en cours d'Вdition */
		int				n_ColCsr;			/* Colonne ou se trouve le curseur [0...nb_cars] si nb_cars:apres dernier caractКre  */
	}
	TEXT_DRAWPAR;


/*
 * DATABLOCK: Bloc de donnВes
 *
 * History:
 * --------
 * 19.06.94: Created
 */
typedef
	struct
	{
		char				*	p_block;			/* DonnВes */
		unsigned	long		ul_length;		/* Longueur de ce bloc */
	}
	DATABLOCK;
   
/*
 * DATAUNION: Ptr sur une entitВ de donnВes
 *
 * History:
 * --------
 * 19.06.94: VirВ le ptr texte direct
 */
typedef
	union
	{
		PAGEARBO			*	pagearbo;	/* Page arborescence (DTYP_ARBO) */
		DATABLOCK		*	dataBlock;	/* Block de donnВes brutes (DTYP_PAGES, DTYP_TEXTS ) */
		DATA_RECORDS	*	records;		/* Enregistrements (DTYP_DATAS) */
		DEGASPIX			*	degaspix;	/* Image Degas (DTYP_PICS) */
		void				*	x;				/* GВnВrique */
	}
	DATAUNION;


/*
 * DATASTATE: Etat des donnВes:
 *
 * 06.08.94: fplanque: Created
 */                                    
typedef
	struct
	{
		BOOL				b_open	:	1;			/* != 0 si  fenИtre ouverte dessus */
		unsigned int	sstate	:	2;			/* indication de sauvegarde des donnВes */
	}
	DATASTATE;
           
                                    
/*
 * DATAPAGE: Page de donnВes
 *
 * Purpose:
 * --------
 * Ajoute Е une EntitВ de donnВes, un nom, un commentaire etc...
 * et l'insКre ds une liste chainВe
 *
 * Suggest:
 * --------
 * Peut Иtre un sous type pour prВciser le DATATYPE ?
 *
 * History:
 * --------
 * 11.07.94: fplanque: ajout du membre DATATYPE
 * 06.08.94: fplanque: remplace le int state par un DATASTATE
 * 15.12.94: ajoutВ backptr vers le DATADIR auqeulest reliВe la DATAPAGE
 */
typedef
	struct		datapage
	{
		struct datapage *	prev;			/* Ptr sur Page prВcВdente */
		struct datapage *	next;			/* Ptr sur Page suivante */
		struct datadir	 *	pDataDir;	/* Ptr sur le Dir auquel appartient la page */
		DATATYPE				DataType;	/* Type de donnВes */
		char					nom[13];		/* Nom de cette page */
		DATAUNION			data;			/* Pointeur sur les donnВes de la page */
		char					*comment;	/* Commentaire sur cette page (Е titre informatif) */
		DATASTATE			DataState;	/* Status */
	}
	DATAPAGE;


/*
 * DIRSPEC: SpВcifications d'un directory d'arborescence
 *
 * Purpose:
 * --------
 * Fournit des informations complВmentaires et spВcifiques au type 
 * de donnВes gВrВes sur un directory
 * pour l'arbo:
 * 	- nom du lien arbo servant de point d'entree dans le directory
 * 	- Autres rajoutВs le 14.02.95, pris dans DATADIR
 */
typedef
	struct
	{
		KEYWORD_LIST *	liens_in;		/* Liste des nomd des liens-arbo */
												/* d'entrВe dans ce dir */
		unsigned			max_objs;		/* Nombre d'objets maximum avant modification taille zone objects */
		unsigned			nb_objs;			/* Nombre d'objets */
		unsigned			max_iblks;		/* Nombres d'ICONBLOCKs maxi */
		unsigned			nb_iblks;		/* Nombres d'ICONBLOCKs */

		unsigned		*	dir_map;			/* Tableau reprВsentatif */
												/* Format:
												 *	- Largeur
												 *	- Hauteur
												 *	- Elements...
												 */	
	}
	DIRSPEC;


/*
 * DATADIR: Dossier de Pages de donnщes
 *
 * Purpose:
 * --------
 * Regroupe plusieurs pages de donnщes dans une sorte de dossier
 * en mщmoire.
 *
 * Suggest:
 * --------
 * Pour Вviter la redondance de ptrs sur le DATAGROUP, on pourait faire
 * en sorte que le ROOT pointe sur le DATAGROUP (son "pКre") et on
 * ferait la diffВrence datadir/datagroup grтce au fait que le pКre
 * du DATAGROUp serait NULL (crВer une UNION datadir/datagroup/generic 
 *
 * 15.07.94: Ajout de ptrs sur DATADIR parent et DATAGROUP
 * 07.08.94: fplanque: remplace le int state par un DATASTATE
 */
typedef
	struct	datadir
	{	
		/*
		 * Le ptr sur datagroup fut enlevВ
		 * puis remis le 15.07.94
		 */ 
		struct datadir 	*	pDataDir_parent;	/* Directory parent */
		struct datagroup 	*	pDataGroup;			/* Groupe de donnВes */

		ICONBLK	*	iconblks;			/* Pointe sur le tableau d'iconblk */

		unsigned		nb_elts;				/* Nombre d'ВlВments DATAPAGE */
		DATAPAGE	*	data_start;			/* Pointe sur premiКre page */
		DATAPAGE	*	data_end;			/* Pointe sur derniКre page */

		DIRSPEC	*	dir_spec;			/* SpВcifications complВmentaires */

		/* Ces variables ont ВtВ transfВrВes depuis le datagroup dans le datadir: */
		/* en plusieurs Вtapes jusqu'au 4 Mai 93 */
		DATASTATE	DataState;			/* Status. Note: Le bit OPEN n'est pas utilisВ puisk'on a carrВment un compteur de fens ouvertes */
		int			nb_dirs;				/* Nb de fenetres DIRs ouvertes sur ces donnВes */
		int			nb_edits;			/* Nb de donnВes ouvertes en Вdition */
	}
	DATADIR;


/*
 * DATAGROUP: UnitВ de donnВes contenant tous les dossiers de ce type
 *                                                                   
 * Purpose:
 * --------
 * Tous les dossiers contenant un certains types de donnщes sont
 * reliВes Е un ROOT.
 * La structure DATAGROUP donne un point d'accКs Е ce ROOT.  
 * Le datagroup correspond gВnВralement Е un fichier sur disque.
 */
typedef
	struct	datagroup
	{
		int			icon_no;				/* NumВro de l'icУne associВe */
		DATATYPE		DataType;			/* Type, ex: DTYP_ARBO */
		char			data_device[5];	/* Nom de l'unitВ de stockage virtuelle */
		DATADIR		*root_dir;			/* Ptr sur Directory ppal */
		char			filename[13];		/* Nom du fichier chargВ */
		char			*filepath;			/* Ptr sur RВpertoire de ce fichier */
	}
	DATAGROUP;
                           
                           
/*
 * FTA: File Transfer Area (Woaw Genial!) 
 *
 */                           
typedef
	union			
	{
		DATADIR	*	datadir;			/* Ptr sur un dossier */
		DATADIR	**	datadir_ptr;	/* Adr d'un Ptr sur un dossier */
		DATAPAGE	*	pDataPage;		/* Ptr sur DataPage */	
		TEXTINFO	*	textinfo;		/* Ptr sur infos texte */
		int			param;			/* ParamКtre */
	}
	FTA;
                           
                           
/*
 * Fin du test anti redВfinition:
 */
#endif
