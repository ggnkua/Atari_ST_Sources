/*
 * get_Keyboard_public.h
 */
	 KEYCODE	get_keyboard( VOIE * pVoie_curr );
