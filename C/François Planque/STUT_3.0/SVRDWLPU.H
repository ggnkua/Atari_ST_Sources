/*
 * Server_Download.h
 */

BOOL	DownLoad_ENPG(						/* Out: TRUE_1 s'il faut stopper la connexion */
			VOIE	*	pVoie_curr );		/* In: Voie concernВe */
BOOL	DownLoad_USLTP(					/* Out: TRUE_1 si fin_cnx */
			VOIE	*	pVoie_curr );		/* In: Voie concernВe */
