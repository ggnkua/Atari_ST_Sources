/* Codes ASCII de caractŠres sp‚ciaux REZO: */
	#define	REZO_CJCEDIL			0x80
	#define	REZO_INGRAVE			0x8D
	#define	REZO_OE_MIN				0xB4
	#define	REZO_OE_MAJ				0XB5
	#define	RESO_TRAIT_HAUT		0xC0
	#define	RESO_TRAIT_HORIZ		0xC1
	#define	RESO_TRAIT_BAS			0xC2
	#define	RESO_TRAIT_GAUCHE		0xC3
	#define	RESO_TRAIT_VERT		0xC4
	#define	RESO_TRAIT_DROIT		0xC5
	#define	REZO_FLECHE_GAUCHE	0xC6
	#define	REZO_FLECHE_HAUT		0xC7
	#define	REZO_FLECHE_DROITE	0xC8
	#define	REZO_FLECHE_BAS		0xC9
	#define	REZO_PARAGRAPHE		0xDD