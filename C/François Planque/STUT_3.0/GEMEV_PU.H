/*
 * Gem_Events_Public.h
 */

	void	msg_fulled( WIPARAMS	*wi_params_adr );
	void	msg_arrowed( WIPARAMS	*wi_params_adr );
	void	msg_vslid( WIPARAMS	*wi_params_adr );
	void	msg_hslid( WIPARAMS	*wi_params_adr );
	void	msg_sized( WIPARAMS	*wi_params_adr );
	void	msg_moved( WIPARAMS	*wi_params_adr );
