/* Indice du ressource pour DESK_MED */

#define DESKTOP  0   /* Formulaire/Dialogue */

#define ICONS    1   /* Formulaire/Dialogue */
#define AFFICHGS 1   /* ICON dans l'arbre ICONS */
#define SAISIES  2   /* ICON dans l'arbre ICONS */
#define PARAMS   3   /* ICON dans l'arbre ICONS */
#define LIENSARB 4   /* ICON dans l'arbre ICONS */
#define ERREURS  5   /* ICON dans l'arbre ICONS */
#define MOTSCLEF 6   /* ICON dans l'arbre ICONS */

#define IMAGE1   0   /* Ic“ne libre */

#define IMAGE2   1   /* Ic“ne libre */
