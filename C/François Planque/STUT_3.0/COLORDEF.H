/*
 * ColorDefs.h
 *
 * D‚finitions des couleurs et motifs utilis‚es pour les divers 
 * ‚l‚ments graphiques de l'interface utilisateur GEM
 *
 * History:
 * --------
 * Created by fplanque
 */ 
   
/*
 * Notes:
 * ------
 * Signification des suffixes des constantes:
 * _2  : a utiliser si monochrome!
 * _4  :            si  4 couleurs dispo au moins
 * _16 :            si 16 couleurs dispo au moins
 */


/*
 * Bureau:
 */
	#define	DESK_PATTERN_4			7
	#define	DESK_COLOR_4			GREEN
	#define	LOGO_COLOR_4			RED
	#define	VERSION_COLOR_16		LBLACK
	#define	ICON_PAPER_2			WHITE
	#define	ICON_PAPER_16			LCYAN
	
/* 
 * Fenetres Directories:
 */
	#define	DIR_PATTERN_4			4
	#define	DIR_PATTERN_16			7
	#define	DIR_COLOR_16			LYELLOW

/* 
 * Formulaires:
 */
	#define	FORM_PATTERN_16		7
	#define	FORM_COLOR_16			LWHITE
	
	#define	FORM_PATTERN_4			5
	#define	FORM_COLOR_4			GREEN	
