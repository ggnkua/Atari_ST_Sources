/*
 * Ligne0_Public.h
 */

	extern	void aff_msg_l0(
							VOIE *	pVoie_curr,	/* In: Voie vers laquelle envoyer */
							char *	pT_msg );	/* In: Message Е envoyer */
