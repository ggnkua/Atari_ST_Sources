int expl[6][142][8] = {{
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0x6000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0x3000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0x8c0e,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0x8e0e,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x81f2,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0xc1c6,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x6046,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x606e,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0x100c,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0037,0xf808,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001c,0x180e,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0006,0x0001,0x8000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0x8000,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0x803f,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0006,0x0020,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0006,0x0030,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0038,0x0010,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0073,0x0018,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01ff,0x0088,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0002,0x19cc,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0002,0x39ce,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0002,0x79e6,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0xd9b6,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0x190e,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000e,0x1903,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000e,0x1900,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x1b00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x1a00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0400,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000}
},{
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x00fc,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x00ee,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x006e,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0063,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0071,0xc000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x7801,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x7c03,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x3c07,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0030,0x03fe,0x3000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0038,0x03f8,0x7000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0018,0x03e0,0x6000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000e,0x0070,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000e,0x0030,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000e,0x0039,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xc00e,0x0019,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xffe1,0x8001,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xfff9,0x8001,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x77ff,0xc003,0x8000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x380f,0xe001,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3e01,0xe001,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x0000,0x3c00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x0000,0x1e00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f0,0x0000,0x0380,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x0007,0xffe0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x000f,0xffe0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01e0,0x001f,0xff80,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0380,0x0018,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x001c,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x001c,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xf800,0x0006,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xf800,0x0006,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xf1e0,0x0007,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x000f,0xffe0,0x0003,0x8000,0x0000,0x0000},
{0x0000,0x0000,0x001f,0xffe0,0x0081,0x8000,0x0000,0x0000},
{0x0000,0x0000,0x001f,0xf8c0,0x01c1,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0181,0xc1e1,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0183,0xc1f1,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0187,0xc1f0,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x018f,0xc1b8,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x03fd,0xc18e,0x6000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x03f9,0xc38e,0x7000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0671,0xc387,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0fe1,0xc301,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0fc1,0xc301,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0f81,0xc300,0x3800,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0f81,0xc300,0x1000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0601,0xc300,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0xc700,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0xc600,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0xcc00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0xfc00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x7c00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x7c00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x7800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x3800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x3800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x2000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x2000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000 }
},{
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3f00,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3f80,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3f80,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x1fe0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x1df0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x1ef0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0e78,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0e1e,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0f0f,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x070f,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0781,0xf000,0x3f00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0781,0xf800,0xff00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x7801,0xff00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x7e0f,0xff00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0380,0x07ff,0x8700,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x03c0,0x07fe,0x0f00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01c0,0x03f0,0x0e00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01e0,0x01f0,0x1e00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x007c,0x1c00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x001c,0x1c00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0070,0x001e,0x3c00,0x0000,0x0000},
{0x0000,0x0000,0x0070,0x0078,0x000e,0x3800,0x0000,0x0000},
{0x0000,0x0000,0x00ff,0xf01e,0x0000,0x3800,0x0000,0x0000},
{0x0000,0x0000,0x007f,0xfe0e,0x0000,0x3800,0x0000,0x0000},
{0x0000,0x0000,0x007f,0xffce,0x0000,0x7800,0x0000,0x0000},
{0x0000,0x0000,0x003d,0xffff,0x8000,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x000e,0x03ff,0xc000,0x7c00,0x0000,0x0000},
{0x0000,0x0000,0x000f,0x007f,0xc000,0x3e00,0x0000,0x0000},
{0x0000,0x0000,0x000f,0xc00f,0xc000,0x3f00,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xf800,0x0000,0x07e0,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xf800,0x0000,0x01f0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7c00,0x0000,0x00fc,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3f00,0x0000,0x003e,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x0001,0xffff,0x8000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x0007,0xffff,0x8000,0x0000},
{0x0000,0x0000,0x0000,0x0f80,0x000f,0xffff,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3e00,0x000f,0xfffe,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7800,0x000e,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xf800,0x000f,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xf000,0x000f,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0007,0xc000,0x0007,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x007f,0x0000,0x0001,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x00fe,0x0000,0x0001,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x03fc,0x3e00,0x0001,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x0ff1,0xff00,0x0000,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x1fff,0xfe00,0x0000,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x3fff,0xfe00,0x0080,0x7000,0x0000,0x0000},
{0x0000,0x0000,0x3fff,0x1c00,0x01e0,0x7800,0x0000,0x0000},
{0x0000,0x0000,0x3ff0,0x1c00,0x01e0,0x3800,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x380f,0x01f0,0x3800,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x381f,0x01f8,0x3c00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x383f,0x01fc,0x1c00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x387f,0x01de,0x1e00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x39f7,0x01cf,0x1e00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7fe7,0x01c7,0xce00,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x77c7,0x03c3,0xcf00,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xc787,0x0381,0xff00,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xcf07,0x0380,0xff00,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xfe07,0x8700,0x3f00,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xfc07,0x8700,0x3f00,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xf807,0x8700,0x0780,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xf007,0x8700,0x0300,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xc007,0x8700,0x0100,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xc007,0x8700,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0x8f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0x8e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0x9e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0x9c00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x4000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x4000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000 }
},{
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0007,0xe000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0007,0xf000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0007,0xf800,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0007,0xf800,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xfe00,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xff00,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xdf80,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0003,0xef80,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xe7c0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xe1f8,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xe0f8,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0001,0xf07c,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xf07f,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xf03f,0x8000,0x0060,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7807,0xf000,0x07f8,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7807,0xf800,0x1ff8,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7801,0xf800,0x7ff8,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7800,0xfe07,0xfff8,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7800,0x7f07,0xfff8,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3c00,0x07ff,0xf078,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x3e00,0x07ff,0x80f8,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x1e00,0x03fc,0x00f0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x1f00,0x01f8,0x01f0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0f00,0x00f8,0x01e0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x003f,0x03c0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x000f,0x03c0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0780,0x000f,0x87c0,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x07c0,0x0007,0x8780,0x0000,0x0000},
{0x0000,0x0000,0x7800,0x03c0,0x0007,0x8780,0x0000,0x0000},
{0x0000,0x0000,0xfffe,0x00f8,0x0000,0x0780,0x0000,0x0000},
{0x0000,0x0000,0x7fff,0xe078,0x0000,0x0780,0x0000,0x0000},
{0x0000,0x0000,0x7fff,0xfe78,0x0000,0x0f80,0x0000,0x0000},
{0x0000,0x0000,0x7fff,0xfffc,0x0000,0x0f00,0x0000,0x0000},
{0x0000,0x0000,0x3e7f,0xfffe,0x0000,0x1f00,0x0000,0x0000},
{0x0000,0x0000,0x0780,0x3fff,0x8000,0x0fc0,0x0000,0x0000},
{0x0000,0x0000,0x07c0,0x03ff,0x8000,0x07f0,0x0000,0x0000},
{0x0000,0x0000,0x07f0,0x007f,0x8000,0x07f8,0x0000,0x0000},
{0x0000,0x0000,0x03f8,0x001f,0x0000,0x07fc,0x0000,0x0000},
{0x0000,0x0000,0x007f,0x8000,0x0000,0x007f,0x8000,0x0000},
{0x0000,0x0000,0x007f,0x8000,0x0000,0x001f,0xc000,0x0000},
{0x0000,0x0000,0x001f,0xc000,0x0000,0x0007,0xf000,0x0000},
{0x0000,0x0000,0x0007,0xe000,0x0000,0x0007,0xf800,0x0000},
{0x0000,0x0000,0x0007,0xf000,0x0000,0x0001,0xf800,0x0000},
{0x0000,0x0000,0x0000,0x7800,0x0000,0x7fff,0xff00,0x0000},
{0x0000,0x0000,0x0000,0x7800,0x0001,0xffff,0xff00,0x0000},
{0x0000,0x0000,0x0001,0xf800,0x0003,0xffff,0xfe00,0x0000},
{0x0000,0x0000,0x0003,0xf000,0x0007,0xffff,0xfc00,0x0000},
{0x0000,0x0000,0x0007,0xe000,0x0007,0xffff,0xf800,0x0000},
{0x0000,0x0000,0x001f,0x8000,0x0007,0x8000,0x0000,0x0000},
{0x0000,0x0000,0x007f,0x0000,0x0007,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x007e,0x0000,0x0003,0xc000,0x0000,0x0000},
{0x0000,0x0000,0x00fc,0x0000,0x0003,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x03f8,0x0000,0x0001,0xe000,0x0000,0x0000},
{0x0000,0x0000,0x7fc0,0x0000,0x0000,0x7800,0x0000,0x0000},
{0x0000,0x0000,0xff80,0x0000,0x0000,0x7800,0x0000,0x0000},
{0x0000,0x0007,0xff83,0xc000,0x0000,0x7800,0x0000,0x0000},
{0x0000,0x0007,0xfe07,0xe000,0x0000,0x7c00,0x0000,0x0000},
{0x0000,0x001f,0xf87f,0xf000,0x0000,0x3c00,0x0000,0x0000},
{0x0000,0x007f,0xffff,0xe000,0x0000,0x1f00,0x0000,0x0000},
{0x0000,0x00ff,0xffff,0xe000,0x0040,0x0f00,0x0000,0x0000},
{0x0000,0x00ff,0xfffb,0xe000,0x00e0,0x0f00,0x0000,0x0000},
{0x0000,0x00ff,0xffc3,0xc000,0x01f0,0x0f80,0x0000,0x0000},
{0x0000,0x00ff,0xf803,0xc000,0x01f0,0x0780,0x0000,0x0000},
{0x0000,0x0000,0x0007,0x807c,0x01f8,0x0780,0x0000,0x0000},
{0x0000,0x0000,0x0007,0x807c,0x01fc,0x0780,0x0000,0x0000},
{0x0000,0x0000,0x0007,0x80fc,0x01fe,0x07c0,0x0000,0x0000},
{0x0000,0x0000,0x0007,0x81fc,0x01ff,0x03c0,0x0000,0x0000},
{0x0000,0x0000,0x0007,0x83fc,0x01ef,0x83e0,0x0000,0x0000},
{0x0000,0x0000,0x000f,0x9fbc,0x01e7,0xc1f0,0x0000,0x0000},
{0x0000,0x0000,0x000f,0x3fbc,0x01e3,0xf0f0,0x0000,0x0000},
{0x0000,0x0000,0x001f,0x7f3c,0x01e1,0xf8f0,0x0000,0x0000},
{0x0000,0x0000,0x001e,0x7e3c,0x03e0,0xf8f8,0x0000,0x0000},
{0x0000,0x0000,0x0078,0xf83c,0x03c0,0x7ff8,0x0000,0x0000},
{0x0000,0x0000,0x0079,0xf03c,0x03c0,0x1ff8,0x0000,0x0000},
{0x0000,0x0000,0x007b,0xe03c,0x07c0,0x0ff8,0x0000,0x0000},
{0x0000,0x0000,0x00ff,0xe03e,0x0780,0x07f8,0x0000,0x0000},
{0x0000,0x0000,0x00f7,0xc01e,0x0780,0x07f8,0x0000,0x0000},
{0x0000,0x0000,0x00ff,0x801e,0x0780,0x007c,0x0000,0x0000},
{0x0000,0x0000,0x00ff,0x001e,0x0780,0x007c,0x0000,0x0000},
{0x0000,0x0000,0x00fe,0x001e,0x0780,0x0038,0x0000,0x0000},
{0x0000,0x0000,0x00f8,0x001e,0x0780,0x0018,0x0000,0x0000},
{0x0000,0x0000,0x0078,0x001e,0x0780,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001e,0x0f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0x1f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0x1e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0x3e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0x3c00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0003,0xc000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0001,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000 }
},{
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x00f8,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x01fc,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x01fe,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x01ff,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x01ff,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x00ff,0xc000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x00ff,0xe000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x00ff,0xf000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x00fb,0xf800,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x00fd,0xfc00,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x007c,0xfe00,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x007c,0x3f80,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x007c,0x1fc0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x007c,0x0fe0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x007e,0x07f0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x003e,0x03fc,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x003e,0x01fe,0x0000,0x0007,0x0000,0x0000},
{0x0000,0x0000,0x001f,0x003f,0x8000,0x003f,0xc000,0x0000},
{0x0000,0x0000,0x001f,0x003f,0xe000,0x00ff,0xc000,0x0000},
{0x0000,0x0000,0x001f,0x001f,0xf000,0x03ff,0xc000,0x0000},
{0x0000,0x0000,0x001f,0x0007,0xf800,0x1fff,0xc000,0x0000},
{0x0000,0x0000,0x001f,0x0003,0xfe01,0xffff,0xc000,0x0000},
{0x0000,0x0000,0x001f,0x8001,0xff03,0xffff,0xc000,0x0000},
{0x0000,0x0000,0x000f,0xc000,0x3fcf,0xff87,0xc000,0x0000},
{0x0000,0x0000,0x0007,0xc000,0x0fff,0xfe07,0xc000,0x0000},
{0x0000,0x0000,0x0007,0xe000,0x0fff,0xe00f,0xc000,0x0000},
{0x0000,0x0000,0x0003,0xe000,0x03ff,0x000f,0x8000,0x0000},
{0x0000,0x0000,0x0003,0xf000,0x01fe,0x001f,0x8000,0x0000},
{0x0000,0x0000,0x0001,0xf000,0x00fe,0x001f,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xf800,0x003f,0x803f,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xf800,0x001f,0xc03e,0x0000,0x0000},
{0x0000,0x0000,0x0000,0xfc00,0x0007,0xc03e,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7c00,0x0007,0xe07e,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x7e00,0x0003,0xe07c,0x0000,0x0000},
{0x0000,0x01f8,0x0000,0x3e00,0x0003,0xe07c,0x0000,0x0000},
{0x0000,0x03ff,0xf800,0x1f80,0x0001,0x80f8,0x0000,0x0000},
{0x0000,0x03ff,0xff80,0x0fc0,0x0000,0x00f8,0x0000,0x0000},
{0x0000,0x01ff,0xfffc,0x07c0,0x0000,0x00f8,0x0000,0x0000},
{0x0000,0x01ff,0xffff,0xe7e0,0x0000,0x01f8,0x0000,0x0000},
{0x0000,0x00ff,0xffff,0xfff0,0x0000,0x01f0,0x0000,0x0000},
{0x0000,0x007e,0x7fff,0xfff8,0x0000,0x03f0,0x0000,0x0000},
{0x0000,0x001f,0x80ff,0xfffe,0x0000,0x03f8,0x0000,0x0000},
{0x0000,0x000f,0xc007,0xfffe,0x0000,0x01fe,0x0000,0x0000},
{0x0000,0x000f,0xe000,0x3ffe,0x0000,0x00ff,0x8000,0x0000},
{0x0000,0x0007,0xf800,0x07fe,0x0000,0x00ff,0xc000,0x0000},
{0x0000,0x0003,0xfc00,0x00fc,0x0000,0x007f,0xf000,0x0000},
{0x0000,0x0000,0x7fc0,0x0000,0x0000,0x000f,0xfe00,0x0000},
{0x0000,0x0000,0x7fe0,0x0000,0x0000,0x0003,0xff00,0x0000},
{0x0000,0x0000,0x3ff0,0x0000,0x0000,0x0000,0xff80,0x0000},
{0x0000,0x0000,0x0ff8,0x0000,0x0000,0x0000,0x3fe0,0x0000},
{0x0000,0x0000,0x03fc,0x0000,0x0000,0x0000,0x1ff0,0x0000},
{0x0000,0x0000,0x01fe,0x0000,0x0000,0x0000,0x07f8,0x0000},
{0x0000,0x0000,0x003f,0x0000,0x0000,0x01ff,0xfffe,0x0000},
{0x0000,0x0000,0x001f,0x0000,0x0000,0x1fff,0xffff,0x0000},
{0x0000,0x0000,0x001f,0x0000,0x0000,0x7fff,0xffff,0x0000},
{0x0000,0x0000,0x007f,0x0000,0x0000,0xffff,0xfffe,0x0000},
{0x0000,0x0000,0x00fe,0x0000,0x0001,0xffff,0xfffc,0x0000},
{0x0000,0x0000,0x01fc,0x0000,0x0003,0xffff,0xfff0,0x0000},
{0x0000,0x0000,0x07f0,0x0000,0x0003,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x0fe0,0x0000,0x0003,0xf000,0x0000,0x0000},
{0x0000,0x0000,0x3fc0,0x0000,0x0001,0xf800,0x0000,0x0000},
{0x0000,0x0000,0x7f80,0x0000,0x0000,0xf800,0x0000,0x0000},
{0x0000,0x0000,0xff00,0x0000,0x0000,0xfc00,0x0000,0x0000},
{0x0000,0x0003,0xfc00,0x0000,0x0000,0x7c00,0x0000,0x0000},
{0x0000,0x003f,0xf800,0x0000,0x0000,0x3f00,0x0000,0x0000},
{0x0000,0x00ff,0xe000,0x0000,0x0000,0x1f00,0x0000,0x0000},
{0x0000,0x03ff,0xc000,0x0000,0x0000,0x1f00,0x0000,0x0000},
{0x0000,0x1fff,0x80f8,0x0000,0x0000,0x1f80,0x0000,0x0000},
{0x0000,0x3ffe,0x03fc,0x0000,0x0000,0x0fc0,0x0000,0x0000},
{0x0000,0xfff0,0x3ffe,0x0000,0x0000,0x07c0,0x0000,0x0000},
{0x0003,0xffff,0xfffe,0x0000,0x0000,0x03e0,0x0000,0x0000},
{0x0007,0xffff,0xfffc,0x0000,0x0000,0x03f0,0x0000,0x0000},
{0x000f,0xffff,0xfffc,0x0000,0x0060,0x01f0,0x0000,0x0000},
{0x000f,0xffff,0xfcfc,0x0000,0x00f0,0x01f0,0x0000,0x0000},
{0x000f,0xffff,0xe0f8,0x0000,0x01f8,0x01f8,0x0000,0x0000},
{0x000f,0xfff0,0x00f8,0x0000,0x01f8,0x00f8,0x0000,0x0000},
{0x0000,0x0000,0x01f0,0x01e0,0x01fc,0x00f8,0x0000,0x0000},
{0x0000,0x0000,0x01f0,0x07f0,0x01fe,0x00fc,0x0000,0x0000},
{0x0000,0x0000,0x03f0,0x07f0,0x01ff,0x007c,0x0000,0x0000},
{0x0000,0x0000,0x03e0,0x0ff0,0x01ff,0x807e,0x0000,0x0000},
{0x0000,0x0000,0x03e0,0x1ff0,0x01ff,0xc03e,0x0000,0x0000},
{0x0000,0x0000,0x03e0,0x3ff0,0x01f7,0xe03f,0x0000,0x0000},
{0x0000,0x0000,0x03e0,0xfff0,0x01f3,0xf01f,0x0000,0x0000},
{0x0000,0x0000,0x07e3,0xfdf0,0x01f1,0xf81f,0x8000,0x0000},
{0x0000,0x0000,0x07c7,0xf9f0,0x01f0,0xfe0f,0x8000,0x0000},
{0x0000,0x0000,0x0fcf,0xf1f0,0x01f0,0x7f0f,0x8000,0x0000},
{0x0000,0x0000,0x0f9f,0xe1f0,0x03f0,0x3f0f,0xc000,0x0000},
{0x0000,0x0000,0x3f1f,0x01f0,0x03e0,0x1ff7,0xc000,0x0000},
{0x0000,0x0000,0x3e3f,0x01f0,0x03e0,0x0fff,0xc000,0x0000},
{0x0000,0x0000,0x7e7e,0x01f0,0x03e0,0x03ff,0xc000,0x0000},
{0x0000,0x0000,0x7cfc,0x01f0,0x07e0,0x01ff,0xc000,0x0000},
{0x0000,0x0000,0xfdfc,0x01f8,0x07c0,0x00ff,0xe000,0x0000},
{0x0000,0x0000,0xfbf8,0x00f8,0x07c0,0x007f,0xe000,0x0000},
{0x0000,0x0000,0xffe0,0x00f8,0x0fc0,0x000f,0xf000,0x0000},
{0x0000,0x0000,0xffe0,0x00f8,0x0f80,0x0007,0xf000,0x0000},
{0x0000,0x0000,0xffc0,0x00f8,0x0f80,0x0003,0xf000,0x0000},
{0x0000,0x0000,0xff80,0x00f8,0x0f80,0x0001,0xe000,0x0000},
{0x0000,0x0000,0xfc00,0x00f8,0x0f80,0x0000,0xc000,0x0000},
{0x0000,0x0000,0x7c00,0x00f8,0x0f80,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x00f8,0x1f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x00f8,0x1f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x00fc,0x3f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007c,0x3e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007c,0x7e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007c,0x7c00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007c,0xfc00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007e,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0xc000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0xc000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0007,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0002,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000 }
},{
{0x0000,0x0000,0x0f00,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x1f80,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x3fc0,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x3fe0,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x3ff0,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x3ff8,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x1ff8,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x1ffe,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x1fff,0x0000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x1fff,0x8000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x1fbf,0xc000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x1fdf,0xf000,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0fcf,0xf800,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0fc3,0xfc00,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0fc1,0xfe00,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0fc0,0xff80,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0fc0,0x7fc0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0fe0,0x1fe0,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x07e0,0x0ff8,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x07e0,0x07fc,0x0000,0x0000,0x3c00,0x0000},
{0x0000,0x0000,0x07f0,0x03ff,0x0000,0x0000,0x7e00,0x0000},
{0x0000,0x0000,0x03f0,0x00ff,0x8000,0x0001,0xff00,0x0000},
{0x0000,0x0000,0x03f0,0x007f,0xe000,0x0007,0xff00,0x0000},
{0x0000,0x0000,0x03f8,0x003f,0xf800,0x003f,0xff00,0x0000},
{0x0000,0x0000,0x01f8,0x000f,0xfc00,0x03ff,0xff00,0x0000},
{0x0000,0x0000,0x01f8,0x0007,0xff00,0x3fff,0xff00,0x0000},
{0x0000,0x0000,0x01fc,0x0001,0xff80,0xffff,0xff00,0x0000},
{0x0000,0x0000,0x00fc,0x0000,0xffc1,0xffff,0x3f00,0x0000},
{0x0000,0x0000,0x00fe,0x0000,0x3ff3,0xfffc,0x3f00,0x0000},
{0x0000,0x0000,0x007e,0x0000,0x0fff,0xffe0,0x3f00,0x0000},
{0x0000,0x0000,0x007f,0x0000,0x07ff,0xfe00,0x7f00,0x0000},
{0x0000,0x0000,0x003f,0x0000,0x01ff,0xe000,0x7e00,0x0000},
{0x0000,0x0000,0x003f,0x8000,0x00ff,0xc000,0xfe00,0x0000},
{0x0000,0x0000,0x001f,0x8000,0x007f,0xc000,0xfc00,0x0000},
{0x0000,0x0000,0x001f,0xc000,0x001f,0xe000,0xfc00,0x0000},
{0x0000,0x0000,0x000f,0xc000,0x000f,0xf001,0xfc00,0x0000},
{0x0000,0x0000,0x000f,0xe000,0x0007,0xf801,0xf800,0x0000},
{0x0000,0x0000,0x0007,0xf000,0x0001,0xf801,0xf800,0x0000},
{0x0000,0x0000,0x0003,0xf000,0x0001,0xfc03,0xf800,0x0000},
{0x0000,0x0000,0x0003,0xf800,0x0000,0xfc03,0xf000,0x0000},
{0x0001,0xfc00,0x0001,0xf800,0x0000,0xfc03,0xf000,0x0000},
{0x0003,0xffe0,0x0001,0xfc00,0x0000,0x7807,0xf000,0x0000},
{0x0007,0xfffe,0x0000,0xfe00,0x0000,0x3007,0xe000,0x0000},
{0x0007,0xffff,0xf000,0x7f00,0x0000,0x000f,0xe000,0x0000},
{0x0003,0xffff,0xffc0,0x3f80,0x0000,0x000f,0xc000,0x0000},
{0x0001,0xffff,0xffff,0x1fc0,0x0000,0x001f,0xc000,0x0000},
{0x0000,0xffff,0xffff,0xffe0,0x0000,0x001f,0x8000,0x0000},
{0x0000,0x7f3f,0xffff,0xfff0,0x0000,0x003f,0x8000,0x0000},
{0x0000,0x3f83,0xffff,0xfff8,0x0000,0x003f,0x8000,0x0000},
{0x0000,0x1fe0,0x1fff,0xfffc,0x0000,0x003f,0xc000,0x0000},
{0x0000,0x0ff0,0x007f,0xfffc,0x0000,0x001f,0xf800,0x0000},
{0x0000,0x07f8,0x0001,0xfffc,0x0000,0x000f,0xfe00,0x0000},
{0x0000,0x03fe,0x0000,0x1ffc,0x0000,0x0007,0xff80,0x0000},
{0x0000,0x01ff,0x8000,0x03f8,0x0000,0x0003,0xffe0,0x0000},
{0x0000,0x00ff,0xe000,0x0070,0x0000,0x0001,0xfff8,0x0000},
{0x0000,0x003f,0xf800,0x0000,0x0000,0x0000,0x7ffc,0x0000},
{0x0000,0x001f,0xfc00,0x0000,0x0000,0x0000,0x0fff,0x0000},
{0x0000,0x000f,0xff00,0x0000,0x0000,0x0000,0x03ff,0x8000},
{0x0000,0x0003,0xff80,0x0000,0x0000,0x0000,0x00ff,0xe000},
{0x0000,0x0000,0xffc0,0x0000,0x0000,0x0000,0x003f,0xf800},
{0x0000,0x0000,0x3fe0,0x0000,0x0000,0x0000,0x000f,0xfc00},
{0x0000,0x0000,0x0ff0,0x0000,0x0000,0x0000,0x0007,0xfe00},
{0x0000,0x0000,0x07f8,0x0000,0x0000,0x001f,0xffff,0xff00},
{0x0000,0x0000,0x03f8,0x0000,0x0000,0x03ff,0xffff,0xff80},
{0x0000,0x0000,0x03f8,0x0000,0x0000,0x0fff,0xffff,0xff80},
{0x0000,0x0000,0x0ff0,0x0000,0x0000,0x1fff,0xffff,0xff00},
{0x0000,0x0000,0x1fe0,0x0000,0x0000,0x3fff,0xffff,0xfe00},
{0x0000,0x0000,0x3fc0,0x0000,0x0000,0x7fff,0xffff,0xf000},
{0x0000,0x0000,0xff80,0x0000,0x0000,0x7ff0,0x0000,0x0000},
{0x0000,0x0001,0xff00,0x0000,0x0000,0x7f00,0x0000,0x0000},
{0x0000,0x0003,0xfe00,0x0000,0x0000,0x7f00,0x0000,0x0000},
{0x0000,0x000f,0xf800,0x0000,0x0000,0x3f80,0x0000,0x0000},
{0x0000,0x001f,0xf000,0x0000,0x0000,0x1f80,0x0000,0x0000},
{0x0000,0x007f,0xe000,0x0000,0x0000,0x1fc0,0x0000,0x0000},
{0x0000,0x01ff,0x8000,0x0000,0x0000,0x0fc0,0x0000,0x0000},
{0x0000,0x0fff,0x0000,0x0000,0x0000,0x0fe0,0x0000,0x0000},
{0x0000,0x3ffe,0x0000,0x0000,0x0000,0x07f0,0x0000,0x0000},
{0x0000,0xfff8,0x0000,0x0000,0x0000,0x03f0,0x0000,0x0000},
{0x0007,0xfff0,0x0000,0x0000,0x0000,0x03f8,0x0000,0x0000},
{0x003f,0xffc0,0x1f80,0x0000,0x0000,0x01fc,0x0000,0x0000},
{0x00ff,0xff00,0xffc0,0x0000,0x0000,0x00fe,0x0000,0x0000},
{0x03ff,0xf80f,0xffe0,0x0000,0x0000,0x007e,0x0000,0x0000},
{0x07ff,0xefff,0xffe0,0x0000,0x0000,0x007f,0x0000,0x0000},
{0x0fff,0xffff,0xffe0,0x0000,0x0000,0x003f,0x0000,0x0000},
{0x3fff,0xffff,0xffc0,0x0000,0x0000,0x003f,0x8000,0x0000},
{0x7fff,0xffff,0xffc0,0x0000,0x0038,0x001f,0x8000,0x0000},
{0x7fff,0xffff,0x9fc0,0x0000,0x007c,0x001f,0x8000,0x0000},
{0x7fff,0xfff8,0x1f80,0x0000,0x00fe,0x001f,0xc000,0x0000},
{0x7fff,0xf800,0x1f80,0x0000,0x00fe,0x000f,0xc000,0x0000},
{0x3fc0,0x0000,0x3f80,0x0380,0x00ff,0x000f,0xe000,0x0000},
{0x0000,0x0000,0x3f00,0x07c0,0x00ff,0x8007,0xe000,0x0000},
{0x0000,0x0000,0x3f00,0x1fe0,0x00ff,0xc007,0xf000,0x0000},
{0x0000,0x0000,0x7f00,0x3fe0,0x00ff,0xe003,0xf000,0x0000},
{0x0000,0x0000,0x7e00,0x7fe0,0x00ff,0xf003,0xf800,0x0000},
{0x0000,0x0000,0x7e00,0xffe0,0x00ff,0xf801,0xf800,0x0000},
{0x0000,0x0000,0x7e01,0xffe0,0x00fd,0xfc01,0xfc00,0x0000},
{0x0000,0x0000,0xfe07,0xffe0,0x00fc,0xfe00,0xfc00,0x0000},
{0x0000,0x0000,0xfc0f,0xffe0,0x00fc,0x7f00,0xfc00,0x0000},
{0x0000,0x0001,0xfc3f,0xf7e0,0x00fc,0x3f80,0xfe00,0x0000},
{0x0000,0x0001,0xf87f,0xe7e0,0x00fc,0x1fe0,0x7e00,0x0000},
{0x0000,0x0003,0xf8ff,0x87e0,0x00fc,0x0ff0,0x7e00,0x0000},
{0x0000,0x0003,0xf1ff,0x07e0,0x01fc,0x07f8,0x7f00,0x0000},
{0x0000,0x0007,0xf3fc,0x07e0,0x01f8,0x03fe,0x3f00,0x0000},
{0x0000,0x000f,0xe3f8,0x07e0,0x01f8,0x01ff,0xbf00,0x0000},
{0x0000,0x000f,0xc7f0,0x07e0,0x01f8,0x00ff,0xff80,0x0000},
{0x0000,0x001f,0xcfe0,0x07e0,0x01f8,0x003f,0xff80,0x0000},
{0x0000,0x003f,0x9fc0,0x07e0,0x03f8,0x001f,0xff80,0x0000},
{0x0000,0x007f,0x3fc0,0x07f0,0x03f0,0x000f,0xffc0,0x0000},
{0x0000,0x007e,0xff80,0x03f0,0x03f0,0x0003,0xffc0,0x0000},
{0x0000,0x007f,0xff00,0x03f0,0x03f0,0x0000,0xffe0,0x0000},
{0x0000,0x007f,0xfe00,0x03f0,0x07f0,0x0000,0x7fe0,0x0000},
{0x0000,0x007f,0xfc00,0x03f0,0x07e0,0x0000,0x1fe0,0x0000},
{0x0000,0x007f,0xf800,0x03f0,0x07e0,0x0000,0x0fe0,0x0000},
{0x0000,0x007f,0xf000,0x03f0,0x07e0,0x0000,0x07c0,0x0000},
{0x0000,0x007f,0x8000,0x03f0,0x0fe0,0x0000,0x0380,0x0000},
{0x0000,0x003f,0x0000,0x03f0,0x0fc0,0x0000,0x0000,0x0000},
{0x0000,0x001c,0x0000,0x03f0,0x1fc0,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x03f0,0x1f80,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x03f0,0x1f80,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x03f8,0x3f80,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f8,0x3f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f8,0x7f00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f8,0x7e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f8,0x7e00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01f8,0xfe00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x01fc,0xfc00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x00fd,0xfc00,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x00ff,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007f,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007f,0xf800,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x007f,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0xf000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x003f,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0xe000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0xc000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0xc000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x001f,0x8000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x000f,0x0000,0x0000,0x0000,0x0000},
{0x0000,0x0000,0x0000,0x0006,0x0000,0x0000,0x0000,0x0000}
}};
