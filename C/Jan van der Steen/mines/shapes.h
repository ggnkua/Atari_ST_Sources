unsigned int shape[6][PIXELS][2] =	/* PIXELS = 24 */
{
    {
	/* empty box */
	{ 0xffff, 0xff00 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0xffff, 0xff00 }
    },
    {
	/* gray */
	{ 0xffff, 0xff00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xd555, 0x5500 },
	{ 0xaaaa, 0xab00 },
	{ 0xffff, 0xff00 }
    },
    {
	/* bomb */
	{ 0xffff, 0xff00 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x80c0, 0x0100 },
	{ 0x8520, 0x0100 },
	{ 0x8010, 0x0100 },
	{ 0x8908, 0x0100 },
	{ 0x823e, 0x0100 },
	{ 0x803e, 0x0100 },
	{ 0x80ff, 0x8100 },
	{ 0x81ff, 0xc100 },
	{ 0x81bf, 0xc100 },
	{ 0x83ff, 0xe100 },
	{ 0x83fd, 0xe100 },
	{ 0x81fd, 0xc100 },
	{ 0x81fb, 0xc100 },
	{ 0x80ff, 0x8100 },
	{ 0x807f, 0x0100 },
	{ 0x801c, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0xffff, 0xff00 }
    },
    {
	/* ok */
	{ 0xffff, 0xff00 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x800c, 0x0100 },
	{ 0x800c, 0x0100 },
	{ 0x800c, 0x0100 },
	{ 0x83cc, 0xc100 },
	{ 0x87ed, 0xc100 },
	{ 0x866f, 0x8100 },
	{ 0x866f, 0x0100 },
	{ 0x866f, 0x8100 },
	{ 0x866d, 0x8100 },
	{ 0x866c, 0xc100 },
	{ 0x87ec, 0xe100 },
	{ 0x83cc, 0x6100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0xffff, 0xff00 }
    },
    {
	/* man */
	{ 0xffff, 0xff00 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8028, 0x0100 },
	{ 0x8054, 0x0100 },
	{ 0x8028, 0x0100 },
	{ 0x8028, 0x0100 },
	{ 0x8010, 0x0100 },
	{ 0x8010, 0x0100 },
	{ 0x8028, 0x0100 },
	{ 0x80c6, 0x0100 },
	{ 0x8145, 0x0100 },
	{ 0x8244, 0x8100 },
	{ 0x8044, 0x0100 },
	{ 0x8038, 0x0100 },
	{ 0x802c, 0x0100 },
	{ 0x8024, 0x0100 },
	{ 0x8024, 0x0100 },
	{ 0x80e7, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0x8000, 0x0100 },
	{ 0xffff, 0xff00 }
    },
    {
	/* PATH */
	{ 0xffff, 0xff00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0x8000, 0x0100 },
	{ 0xaaaa, 0xab00 },
	{ 0xffff, 0xff00 }
    }
};
