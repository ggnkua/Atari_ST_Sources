/***********************************************/
/* Datei: DISK.H                               */
/* ------------------------------------------- */
/* Modul: DISK.CPX                Version 1.00 */
/* (C) 1990 by MAXON Computer                  */
/* Autoren: Uwe Hax & Oliver Scholz            */
/* Vom RCS aus Resource-Datei erstellte        */
/* Include-Datei                               */
/***********************************************/


#define DISK 0          /* TREE */
#define CPU 2           /* OBJECT in TREE #0 */
#define STEPB 6         /* OBJECT in TREE #0 */
#define STEPA 5         /* OBJECT in TREE #0 */
#define VERIFY 11       /* OBJECT in TREE #0 */
#define UNIT0 14        /* OBJECT in TREE #0 */
#define UNIT1 15        /* OBJECT in TREE #0 */
#define FREQ 18         /* OBJECT in TREE #0 */
#define OK 20           /* OBJECT in TREE #0 */
#define CANCEL 21       /* OBJECT in TREE #0 */
#define SAVE 23         /* OBJECT in TREE #0 */
#define SWITCHOF 1      /* TREE */
#define SURE 2          /* TREE */
#define SUREOK 6        /* OBJECT in TREE #2 */
#define SURECANC 7      /* OBJECT in TREE #2 */
#define ERROR 3         /* TREE */
#define MIST 2          /* OBJECT in TREE #3 */


