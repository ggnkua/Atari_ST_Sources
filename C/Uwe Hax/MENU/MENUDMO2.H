#define MENU 0
#define ABOUT 7
#define DABOUT 1
#define OK 13
