#define SYSTEM16 26
#define COMP16 29
#define COMP8 28
#define FETT 31
#define BREIT 33
#define KURSIV 32
#define SUBMENU 0
#define NEO 19
#define PIC 21
#define DEGAS 20
#define IMG 22
#define SYSTEM8 25
#define SYSTEM6 24
