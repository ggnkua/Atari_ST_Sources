#define MENU 0  	/* TREE */
#define FONT 5  	/* OBJECT in TREE #0 */
#define DATEI 4  	/* OBJECT in TREE #0 */
#define BILDTYP 17  	/* OBJECT in TREE #0 */
#define LADEN 18  	/* OBJECT in TREE #0 */
#define SPEICHER 19  	/* OBJECT in TREE #0 */
#define ENDE 21  	/* OBJECT in TREE #0 */
#define SYSTEM 23  	/* OBJECT in TREE #0 */
#define COMPUTER 24  	/* OBJECT in TREE #0 */
#define STIL 26  	/* OBJECT in TREE #0 */
