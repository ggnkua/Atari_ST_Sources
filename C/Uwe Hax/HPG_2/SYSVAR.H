/*
 * SYSVAR.H
 *
 * Objektindizes, wie vom RCS geliefert
 *
 * Uwe Hax, M„rz 1992
 * (c) MAXON Computer
 */


#define SYSVAR 0        /* TREE */
#define CLOSE 1         /* OBJECT in TREE #0 */
#define TITLE 2         /* OBJECT in TREE #0 */
#define ADDRESS 4       /* OBJECT in TREE #0 */
#define MEANING 5       /* OBJECT in TREE #0 */
#define VALUE 6         /* OBJECT in TREE #0 */
#define SLIDER 8        /* OBJECT in TREE #0 */
#define BACKGRND 7      /* OBJECT in TREE #0 */
#define OFFSET 9        /* OBJECT in TREE #0 */
#define UP 10           /* OBJECT in TREE #0 */
#define DOWN 11         /* OBJECT in TREE #0 */
#define HARDWARE 13     /* OBJECT in TREE #0 */
#define HWTEXT 14       /* OBJECT in TREE #0 */
#define UETEXT 16       /* OBJECT in TREE #0 */
#define UNUSED 15       /* OBJECT in TREE #0 */
#define INTERUPT 17     /* OBJECT in TREE #0 */
#define IRTEXT 18       /* OBJECT in TREE #0 */
#define MFPTEXT 20      /* OBJECT in TREE #0 */
#define MFP 19          /* OBJECT in TREE #0 */
#define TRAPS 21        /* OBJECT in TREE #0 */
#define TRAPTEXT 22     /* OBJECT in TREE #0 */
#define VARIABLE 24     /* OBJECT in TREE #0 */
#define VARTEXT 23      /* OBJECT in TREE #0 */
#define SHOWN 25        /* OBJECT in TREE #0 */
#define SELECT 26       /* OBJECT in TREE #0 */
