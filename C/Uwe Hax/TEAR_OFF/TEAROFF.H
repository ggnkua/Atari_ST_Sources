/* Resource Datei Indizes f�r TEAROFF */

#define MENU     0   /* Menuebaum */
#define ABOUT    7   /* STRING in Baum MENU */
#define TEXT1    16  /* STRING in Baum MENU */
#define TEXT2    17  /* STRING in Baum MENU */
#define TEXT3    18  /* STRING in Baum MENU */
#define TEXT4    19  /* STRING in Baum MENU */
#define TEXT5    20  /* STRING in Baum MENU */
#define QUIT     22  /* STRING in Baum MENU */

#define DIALOG   1   /* Formular/Dialog */
#define OK       5   /* BUTTON in Baum DIALOG */
