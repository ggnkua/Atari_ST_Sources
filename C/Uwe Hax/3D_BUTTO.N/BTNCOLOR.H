/***********************************************/
/* BTNCOLOR.H                                  */
/*---------------------------------------------*/
/* Resource-Indices f�r BTNCOLOR.C             */
/* Autor: Uwe Hax                              */
/* (C) 1993 by MAXON                           */
/***********************************************/

#define DIALOG       0   /* Formular/Dialog    */
#define D_TYPE       2   /* BUTTON in DIALOG   */
#define D_COLOR      6   /* BOX in DIALOG      */
#define D_COLTEXT    7   /* BUTTON in DIALOG   */
#define D_FRAME      8   /* BOX in DIALOG      */
#define D_MOVETEXT   9   /* STRING in DIALOG   */
#define D_CHANGETEXT 10  /* STRING in DIALOG   */
#define D_CHANGE     11  /* BUTTON in DIALOG   */
#define D_MOVE       12  /* BUTTON in DIALOG   */
#define D_TEST       18  /* BUTTON in DIALOG   */
#define D_HORIZONTAL 22  /* STRING in DIALOG   */
#define D_VERTICAL   23  /* STRING in DIALOG   */
#define D_SAVE       25  /* BUTTON in DIALOG   */
#define D_OK         27  /* BUTTON in DIALOG   */
#define D_CANCEL     28  /* BUTTON in DIALOG   */

#define ALERT        1   /* Formular/Dialog    */

#define TEST         2   /* Formular/Dialog    */
#define T_ACTIVATOR  1   /* BUTTON in TEST     */
#define T_INDICATOR  2   /* BUTTON in TEST     */
#define T_OK         3   /* BUTTON in TEST     */

