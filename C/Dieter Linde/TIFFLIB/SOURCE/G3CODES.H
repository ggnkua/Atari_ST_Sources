#ifndef	__G3CODES_H__
#define	__G3CODES_H__

u_char	TIFFFax3btab[8192] = {
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*    0 -    9 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*   10 -   19 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*   20 -   29 */
	255, 255,  27, 255, 255, 255,  30, 255,  31, 255,	/*   30 -   39 */
	 32, 255,  33, 255,  34, 255,  35, 255,  28, 255,	/*   40 -   49 */
	255, 255,  29, 255, 255, 255,  36, 255,  37, 255,	/*   50 -   59 */
	 38, 255,  39, 255,  58, 255, 255, 255, 255, 255,	/*   60 -   69 */
	255, 255,  92, 255,   9,  10,  11,  12,  95, 255,	/*   70 -   79 */
	 96, 255,  19,  20,  21,  22,  99, 255, 100, 255,	/*   80 -   89 */
	 23,  24,  64, 255, 255, 255,  65, 255, 255, 255,	/*   90 -   99 */
	 25,  26,   4, 255,   5, 255,   6, 255,   7,   8,	/*  100 -  109 */
	 93, 255,  94, 255,  13,  14,  15,  16,  17,  18,	/*  110 -  119 */
	  0, 255, 255, 255, 255, 255, 255, 255,  53, 255,	/*  120 -  129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  130 -  139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  140 -  149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  150 -  159 */
	 63, 255, 255, 255,  90, 255,  91, 255,  84, 255,	/*  160 -  169 */
	 85, 255,  86, 255,  87, 255,  97, 255,  98, 255,	/*  170 -  179 */
	101, 255,   3, 255,  56, 255, 255, 255, 255, 255,	/*  180 -  189 */
	255, 255,  57, 255, 255, 255, 255, 255, 255, 255,	/*  190 -  199 */
	 88, 255,  89, 255, 102, 255, 103, 255,  70, 255,	/*  200 -  209 */
	 71, 255,  72, 255,  73, 255,  80, 255,  81, 255,	/*  210 -  219 */
	 62, 255, 255, 255,  54, 255, 255, 255, 255, 255,	/*  220 -  229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  230 -  239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  240 -  249 */
	255, 255, 255, 255, 255, 255,  50, 255, 255, 255,	/*  250 -  259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  260 -  269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  270 -  279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  280 -  289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  290 -  299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  300 -  309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  310 -  319 */
	 51, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  320 -  329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  330 -  339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  340 -  349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  350 -  359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  360 -  369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  370 -  379 */
	255, 255, 255, 255,  55, 255, 255, 255, 255, 255,	/*  380 -  389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  390 -  399 */
	  1, 255,   2, 255,  66, 255,  67, 255,  68, 255,	/*  400 -  409 */
	 69, 255,  59, 255, 255, 255,  60, 255, 255, 255,	/*  410 -  419 */
	 74, 255,  75, 255,  76, 255,  77, 255,  78, 255,	/*  420 -  429 */
	 79, 255,  61, 255, 255, 255,  82, 255,  83, 255,	/*  430 -  439 */
	 40, 255, 255, 255, 255, 255, 255, 255,  52, 255,	/*  440 -  449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  450 -  459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  460 -  469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  470 -  479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  480 -  489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  490 -  499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  500 -  509 */
	255, 255,  49, 255, 255, 255, 255, 255, 255, 255,	/*  510 -  519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  520 -  529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  530 -  539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  540 -  549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  550 -  559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  560 -  569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  570 -  579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  580 -  589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  590 -  599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  600 -  609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  610 -  619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  620 -  629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  630 -  639 */
	 48, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  640 -  649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  650 -  659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  660 -  669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  670 -  679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  680 -  689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  690 -  699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  700 -  709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  710 -  719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  720 -  729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  730 -  739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  740 -  749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  750 -  759 */
	255, 255, 255, 255, 255, 255, 255, 255,  47, 255,	/*  760 -  769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  770 -  779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  780 -  789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  790 -  799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  800 -  809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  810 -  819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  820 -  829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  830 -  839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  840 -  849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  850 -  859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  860 -  869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  870 -  879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  880 -  889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  890 -  899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  900 -  909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  910 -  919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  920 -  929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  930 -  939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  940 -  949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  950 -  959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  960 -  969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  970 -  979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  980 -  989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  990 -  999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1000 - 1009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1010 - 1019 */
	255, 255, 255, 255,  46, 255, 255, 255, 255, 255,	/* 1020 - 1029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1030 - 1039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1040 - 1049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1050 - 1059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1060 - 1069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1070 - 1079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1080 - 1089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1090 - 1099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1100 - 1109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1110 - 1119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1120 - 1129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1130 - 1139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1140 - 1149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1150 - 1159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1160 - 1169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1170 - 1179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1180 - 1189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1190 - 1199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1200 - 1209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1210 - 1219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1220 - 1229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1230 - 1239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1240 - 1249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1250 - 1259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1260 - 1269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1270 - 1279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1280 - 1289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1290 - 1299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1300 - 1309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1310 - 1319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1320 - 1329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1330 - 1339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1340 - 1349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1350 - 1359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1360 - 1369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1370 - 1379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1380 - 1389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1390 - 1399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1400 - 1409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1410 - 1419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1420 - 1429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1430 - 1439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1440 - 1449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1450 - 1459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1460 - 1469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1470 - 1479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1480 - 1489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1490 - 1499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1500 - 1509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1510 - 1519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1520 - 1529 */
	255, 255, 255, 255, 255, 255,  45, 255, 255, 255,	/* 1530 - 1539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1540 - 1549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1550 - 1559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1560 - 1569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1570 - 1579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1580 - 1589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1590 - 1599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1600 - 1609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1610 - 1619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1620 - 1629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1630 - 1639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1640 - 1649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1650 - 1659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1660 - 1669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1670 - 1679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1680 - 1689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1690 - 1699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1700 - 1709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1710 - 1719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1720 - 1729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1730 - 1739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1740 - 1749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1750 - 1759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1760 - 1769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1770 - 1779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1780 - 1789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1790 - 1799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1800 - 1809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1810 - 1819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1820 - 1829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1830 - 1839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1840 - 1849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1850 - 1859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1860 - 1869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1870 - 1879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1880 - 1889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1890 - 1899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1900 - 1909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1910 - 1919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1920 - 1929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1930 - 1939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1940 - 1949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1950 - 1959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1960 - 1969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1970 - 1979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1980 - 1989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1990 - 1999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2000 - 2009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2010 - 2019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2020 - 2029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2030 - 2039 */
	255, 255, 255, 255, 255, 255, 255, 255,  41, 255,	/* 2040 - 2049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2050 - 2059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2060 - 2069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2070 - 2079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2080 - 2089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2090 - 2099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2100 - 2109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2110 - 2119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2120 - 2129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2130 - 2139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2140 - 2149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2150 - 2159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2160 - 2169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2170 - 2179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2180 - 2189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2190 - 2199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2200 - 2209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2210 - 2219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2220 - 2229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2230 - 2239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2240 - 2249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2250 - 2259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2260 - 2269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2270 - 2279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2280 - 2289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2290 - 2299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2300 - 2309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2310 - 2319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2320 - 2329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2330 - 2339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2340 - 2349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2350 - 2359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2360 - 2369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2370 - 2379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2380 - 2389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2390 - 2399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2400 - 2409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2410 - 2419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2420 - 2429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2430 - 2439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2440 - 2449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2450 - 2459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2460 - 2469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2470 - 2479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2480 - 2489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2490 - 2499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2500 - 2509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2510 - 2519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2520 - 2529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2530 - 2539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2540 - 2549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2550 - 2559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2560 - 2569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2570 - 2579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2580 - 2589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2590 - 2599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2600 - 2609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2610 - 2619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2620 - 2629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2630 - 2639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2640 - 2649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2650 - 2659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2660 - 2669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2670 - 2679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2680 - 2689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2690 - 2699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2700 - 2709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2710 - 2719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2720 - 2729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2730 - 2739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2740 - 2749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2750 - 2759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2760 - 2769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2770 - 2779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2780 - 2789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2790 - 2799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2800 - 2809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2810 - 2819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2820 - 2829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2830 - 2839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2840 - 2849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2850 - 2859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2860 - 2869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2870 - 2879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2880 - 2889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2890 - 2899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2900 - 2909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2910 - 2919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2920 - 2929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2930 - 2939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2940 - 2949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2950 - 2959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2960 - 2969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2970 - 2979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2980 - 2989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2990 - 2999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3000 - 3009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3010 - 3019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3020 - 3029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3030 - 3039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3040 - 3049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3050 - 3059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3060 - 3069 */
	255, 255,  44, 255, 255, 255, 255, 255, 255, 255,	/* 3070 - 3079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3080 - 3089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3090 - 3099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3100 - 3109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3110 - 3119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3120 - 3129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3130 - 3139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3140 - 3149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3150 - 3159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3160 - 3169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3170 - 3179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3180 - 3189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3190 - 3199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3200 - 3209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3210 - 3219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3220 - 3229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3230 - 3239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3240 - 3249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3250 - 3259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3260 - 3269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3270 - 3279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3280 - 3289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3290 - 3299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3300 - 3309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3310 - 3319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3320 - 3329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3330 - 3339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3340 - 3349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3350 - 3359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3360 - 3369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3370 - 3379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3380 - 3389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3390 - 3399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3400 - 3409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3410 - 3419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3420 - 3429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3430 - 3439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3440 - 3449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3450 - 3459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3460 - 3469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3470 - 3479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3480 - 3489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3490 - 3499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3500 - 3509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3510 - 3519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3520 - 3529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3530 - 3539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3540 - 3549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3550 - 3559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3560 - 3569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3570 - 3579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3580 - 3589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3590 - 3599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3600 - 3609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3610 - 3619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3620 - 3629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3630 - 3639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3640 - 3649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3650 - 3659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3660 - 3669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3670 - 3679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3680 - 3689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3690 - 3699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3700 - 3709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3710 - 3719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3720 - 3729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3730 - 3739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3740 - 3749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3750 - 3759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3760 - 3769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3770 - 3779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3780 - 3789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3790 - 3799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3800 - 3809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3810 - 3819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3820 - 3829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3830 - 3839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3840 - 3849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3850 - 3859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3860 - 3869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3870 - 3879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3880 - 3889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3890 - 3899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3900 - 3909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3910 - 3919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3920 - 3929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3930 - 3939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3940 - 3949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3950 - 3959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3960 - 3969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3970 - 3979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3980 - 3989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3990 - 3999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4000 - 4009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4010 - 4019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4020 - 4029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4030 - 4039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4040 - 4049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4050 - 4059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4060 - 4069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4070 - 4079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4080 - 4089 */
	255, 255, 255, 255, 255, 255,  43, 255, 255, 255,	/* 4090 - 4099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4100 - 4109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4110 - 4119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4120 - 4129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4130 - 4139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4140 - 4149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4150 - 4159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4160 - 4169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4170 - 4179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4180 - 4189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4190 - 4199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4200 - 4209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4210 - 4219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4220 - 4229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4230 - 4239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4240 - 4249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4250 - 4259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4260 - 4269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4270 - 4279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4280 - 4289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4290 - 4299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4300 - 4309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4310 - 4319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4320 - 4329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4330 - 4339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4340 - 4349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4350 - 4359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4360 - 4369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4370 - 4379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4380 - 4389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4390 - 4399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4400 - 4409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4410 - 4419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4420 - 4429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4430 - 4439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4440 - 4449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4450 - 4459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4460 - 4469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4470 - 4479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4480 - 4489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4490 - 4499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4500 - 4509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4510 - 4519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4520 - 4529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4530 - 4539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4540 - 4549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4550 - 4559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4560 - 4569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4570 - 4579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4580 - 4589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4590 - 4599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4600 - 4609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4610 - 4619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4620 - 4629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4630 - 4639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4640 - 4649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4650 - 4659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4660 - 4669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4670 - 4679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4680 - 4689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4690 - 4699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4700 - 4709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4710 - 4719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4720 - 4729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4730 - 4739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4740 - 4749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4750 - 4759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4760 - 4769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4770 - 4779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4780 - 4789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4790 - 4799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4800 - 4809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4810 - 4819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4820 - 4829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4830 - 4839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4840 - 4849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4850 - 4859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4860 - 4869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4870 - 4879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4880 - 4889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4890 - 4899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4900 - 4909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4910 - 4919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4920 - 4929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4930 - 4939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4940 - 4949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4950 - 4959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4960 - 4969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4970 - 4979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4980 - 4989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4990 - 4999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5000 - 5009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5010 - 5019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5020 - 5029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5030 - 5039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5040 - 5049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5050 - 5059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5060 - 5069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5070 - 5079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5080 - 5089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5090 - 5099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5100 - 5109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5110 - 5119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5120 - 5129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5130 - 5139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5140 - 5149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5150 - 5159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5160 - 5169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5170 - 5179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5180 - 5189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5190 - 5199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5200 - 5209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5210 - 5219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5220 - 5229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5230 - 5239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5240 - 5249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5250 - 5259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5260 - 5269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5270 - 5279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5280 - 5289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5290 - 5299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5300 - 5309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5310 - 5319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5320 - 5329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5330 - 5339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5340 - 5349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5350 - 5359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5360 - 5369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5370 - 5379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5380 - 5389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5390 - 5399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5400 - 5409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5410 - 5419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5420 - 5429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5430 - 5439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5440 - 5449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5450 - 5459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5460 - 5469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5470 - 5479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5480 - 5489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5490 - 5499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5500 - 5509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5510 - 5519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5520 - 5529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5530 - 5539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5540 - 5549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5550 - 5559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5560 - 5569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5570 - 5579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5580 - 5589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5590 - 5599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5600 - 5609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5610 - 5619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5620 - 5629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5630 - 5639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5640 - 5649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5650 - 5659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5660 - 5669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5670 - 5679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5680 - 5689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5690 - 5699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5700 - 5709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5710 - 5719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5720 - 5729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5730 - 5739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5740 - 5749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5750 - 5759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5760 - 5769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5770 - 5779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5780 - 5789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5790 - 5799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5800 - 5809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5810 - 5819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5820 - 5829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5830 - 5839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5840 - 5849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5850 - 5859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5860 - 5869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5870 - 5879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5880 - 5889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5890 - 5899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5900 - 5909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5910 - 5919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5920 - 5929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5930 - 5939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5940 - 5949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5950 - 5959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5960 - 5969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5970 - 5979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5980 - 5989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5990 - 5999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6000 - 6009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6010 - 6019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6020 - 6029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6030 - 6039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6040 - 6049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6050 - 6059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6060 - 6069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6070 - 6079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6080 - 6089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6090 - 6099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6100 - 6109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6110 - 6119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6120 - 6129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6130 - 6139 */
	255, 255, 255, 255,  42, 255, 255, 255, 255, 255,	/* 6140 - 6149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6150 - 6159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6160 - 6169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6170 - 6179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6180 - 6189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6190 - 6199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6200 - 6209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6210 - 6219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6220 - 6229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6230 - 6239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6240 - 6249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6250 - 6259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6260 - 6269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6270 - 6279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6280 - 6289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6290 - 6299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6300 - 6309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6310 - 6319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6320 - 6329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6330 - 6339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6340 - 6349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6350 - 6359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6360 - 6369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6370 - 6379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6380 - 6389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6390 - 6399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6400 - 6409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6410 - 6419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6420 - 6429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6430 - 6439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6440 - 6449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6450 - 6459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6460 - 6469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6470 - 6479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6480 - 6489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6490 - 6499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6500 - 6509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6510 - 6519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6520 - 6529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6530 - 6539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6540 - 6549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6550 - 6559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6560 - 6569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6570 - 6579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6580 - 6589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6590 - 6599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6600 - 6609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6610 - 6619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6620 - 6629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6630 - 6639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6640 - 6649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6650 - 6659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6660 - 6669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6670 - 6679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6680 - 6689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6690 - 6699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6700 - 6709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6710 - 6719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6720 - 6729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6730 - 6739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6740 - 6749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6750 - 6759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6760 - 6769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6770 - 6779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6780 - 6789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6790 - 6799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6800 - 6809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6810 - 6819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6820 - 6829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6830 - 6839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6840 - 6849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6850 - 6859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6860 - 6869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6870 - 6879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6880 - 6889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6890 - 6899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6900 - 6909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6910 - 6919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6920 - 6929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6930 - 6939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6940 - 6949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6950 - 6959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6960 - 6969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6970 - 6979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6980 - 6989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6990 - 6999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7000 - 7009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7010 - 7019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7020 - 7029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7030 - 7039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7040 - 7049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7050 - 7059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7060 - 7069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7070 - 7079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7080 - 7089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7090 - 7099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7100 - 7109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7110 - 7119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7120 - 7129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7130 - 7139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7140 - 7149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7150 - 7159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7160 - 7169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7170 - 7179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7180 - 7189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7190 - 7199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7200 - 7209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7210 - 7219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7220 - 7229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7230 - 7239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7240 - 7249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7250 - 7259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7260 - 7269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7270 - 7279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7280 - 7289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7290 - 7299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7300 - 7309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7310 - 7319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7320 - 7329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7330 - 7339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7340 - 7349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7350 - 7359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7360 - 7369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7370 - 7379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7380 - 7389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7390 - 7399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7400 - 7409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7410 - 7419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7420 - 7429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7430 - 7439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7440 - 7449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7450 - 7459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7460 - 7469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7470 - 7479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7480 - 7489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7490 - 7499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7500 - 7509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7510 - 7519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7520 - 7529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7530 - 7539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7540 - 7549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7550 - 7559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7560 - 7569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7570 - 7579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7580 - 7589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7590 - 7599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7600 - 7609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7610 - 7619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7620 - 7629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7630 - 7639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7640 - 7649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7650 - 7659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7660 - 7669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7670 - 7679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7680 - 7689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7690 - 7699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7700 - 7709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7710 - 7719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7720 - 7729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7730 - 7739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7740 - 7749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7750 - 7759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7760 - 7769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7770 - 7779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7780 - 7789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7790 - 7799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7800 - 7809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7810 - 7819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7820 - 7829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7830 - 7839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7840 - 7849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7850 - 7859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7860 - 7869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7870 - 7879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7880 - 7889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7890 - 7899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7900 - 7909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7910 - 7919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7920 - 7929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7930 - 7939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7940 - 7949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7950 - 7959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7960 - 7969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7970 - 7979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7980 - 7989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7990 - 7999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8000 - 8009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8010 - 8019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8020 - 8029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8030 - 8039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8040 - 8049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8050 - 8059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8060 - 8069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8070 - 8079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8080 - 8089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8090 - 8099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8100 - 8109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8110 - 8119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8120 - 8129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8130 - 8139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8140 - 8149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8150 - 8159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8160 - 8169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8170 - 8179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8180 - 8189 */
	255, 255
};

static tableentry 	*g3mbtab = &TIFFFax3bcodes[0];
static tableentry	*g3tbtab = &TIFFFax3bcodes[40];

u_char	TIFFFax3wtab[8192] = {
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*    0 -    9 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*   10 -   19 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*   20 -   29 */
	255, 255,  27, 255, 255, 255,  30, 255,  31, 255,	/*   30 -   39 */
	 32, 255,  33, 255,  34, 255,  35, 255,  28, 255,	/*   40 -   49 */
	255, 255,  29, 255, 255, 255,  36, 255,  37, 255,	/*   50 -   59 */
	 38, 255,  39, 255,  69, 255, 255, 255, 255, 255,	/*   60 -   69 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*   70 -   79 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*   80 -   89 */
	255, 255, 255, 255, 255, 255,  70, 255, 255, 255,	/*   90 -   99 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  100 -  109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  110 -  119 */
	255, 255, 255, 255, 255, 255, 255, 255,  85, 255,	/*  120 -  129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  130 -  139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  140 -  149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  150 -  159 */
	 86, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  160 -  169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  170 -  179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  180 -  189 */
	255, 255,  62, 255, 255, 255, 255, 255, 255, 255,	/*  190 -  199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  200 -  209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  210 -  219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  220 -  229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  230 -  239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  240 -  249 */
	255, 255, 255, 255, 255, 255,  63, 255, 255, 255,	/*  250 -  259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  260 -  269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  270 -  279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  280 -  289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  290 -  299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  300 -  309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  310 -  319 */
	 87, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  320 -  329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  330 -  339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  340 -  349 */
	255, 255,  88, 255, 255, 255, 255, 255, 255, 255,	/*  350 -  359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  360 -  369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  370 -  379 */
	255, 255, 255, 255,  53, 255, 255, 255, 255, 255,	/*  380 -  389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  390 -  399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  400 -  409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  410 -  419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  420 -  429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  430 -  439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  440 -  449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  450 -  459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  460 -  469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  470 -  479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  480 -  489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  490 -  499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  500 -  509 */
	255, 255,  60, 255, 255, 255, 255, 255, 255, 255,	/*  510 -  519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  520 -  529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  530 -  539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  540 -  549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  550 -  559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  560 -  569 */
	255, 255, 255, 255, 255, 255,  73, 255, 255, 255,	/*  570 -  579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  580 -  589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  590 -  599 */
	255, 255, 255, 255, 255, 255, 255, 255,  74, 255,	/*  600 -  609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  610 -  619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  620 -  629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  630 -  639 */
	 75, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  640 -  649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  650 -  659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  660 -  669 */
	255, 255,  76, 255, 255, 255, 255, 255, 255, 255,	/*  670 -  679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  680 -  689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  690 -  699 */
	255, 255, 255, 255,  77, 255, 255, 255, 255, 255,	/*  700 -  709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  710 -  719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  720 -  729 */
	255, 255, 255, 255, 255, 255,  78, 255, 255, 255,	/*  730 -  739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  740 -  749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  750 -  759 */
	255, 255, 255, 255, 255, 255, 255, 255,  59, 255,	/*  760 -  769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  770 -  779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  780 -  789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  790 -  799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  800 -  809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  810 -  819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  820 -  829 */
	255, 255,  71, 255, 255, 255, 255, 255, 255, 255,	/*  830 -  839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  840 -  849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  850 -  859 */
	255, 255, 255, 255,  72, 255, 255, 255, 255, 255,	/*  860 -  869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  870 -  879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  880 -  889 */
	255, 255, 255, 255, 255, 255,  41, 255, 255, 255,	/*  890 -  899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  900 -  909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  910 -  919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  920 -  929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  930 -  939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  940 -  949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  950 -  959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  960 -  969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  970 -  979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  980 -  989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/*  990 -  999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1000 - 1009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1010 - 1019 */
	255, 255, 255, 255,  52, 255, 255, 255, 255, 255,	/* 1020 - 1029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1030 - 1039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1040 - 1049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1050 - 1059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1060 - 1069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1070 - 1079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1080 - 1089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1090 - 1099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1100 - 1109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1110 - 1119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1120 - 1129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1130 - 1139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1140 - 1149 */
	255, 255,  93, 255, 255, 255, 255, 255, 255, 255,	/* 1150 - 1159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1160 - 1169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1170 - 1179 */
	255, 255, 255, 255,  94, 255, 255, 255, 255, 255,	/* 1180 - 1189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1190 - 1199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1200 - 1209 */
	255, 255, 255, 255, 255, 255,  66, 255, 255, 255,	/* 1210 - 1219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1220 - 1229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1230 - 1239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1240 - 1249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1250 - 1259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1260 - 1269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1270 - 1279 */
	 79, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1280 - 1289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1290 - 1299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1300 - 1309 */
	255, 255,  80, 255, 255, 255, 255, 255, 255, 255,	/* 1310 - 1319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1320 - 1329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1330 - 1339 */
	255, 255, 255, 255,  81, 255, 255, 255, 255, 255,	/* 1340 - 1349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1350 - 1359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1360 - 1369 */
	255, 255, 255, 255, 255, 255,  82, 255, 255, 255,	/* 1370 - 1379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1380 - 1389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1390 - 1399 */
	255, 255, 255, 255, 255, 255, 255, 255,  83, 255,	/* 1400 - 1409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1410 - 1419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1420 - 1429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1430 - 1439 */
	 84, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1440 - 1449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1450 - 1459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1460 - 1469 */
	255, 255,  61, 255, 255, 255, 255, 255, 255, 255,	/* 1470 - 1479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1480 - 1489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1490 - 1499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1500 - 1509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1510 - 1519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1520 - 1529 */
	255, 255, 255, 255, 255, 255,  68, 255, 255, 255,	/* 1530 - 1539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1540 - 1549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1550 - 1559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1560 - 1569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1570 - 1579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1580 - 1589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1590 - 1599 */
	101, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1600 - 1609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1610 - 1619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1620 - 1629 */
	255, 255, 102, 255, 255, 255, 255, 255, 255, 255,	/* 1630 - 1639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1640 - 1649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1650 - 1659 */
	255, 255, 255, 255, 103, 255, 255, 255, 255, 255,	/* 1660 - 1669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1670 - 1679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1680 - 1689 */
	255, 255, 255, 255, 255, 255,  40, 255, 255, 255,	/* 1690 - 1699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1700 - 1709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1710 - 1719 */
	255, 255, 255, 255, 255, 255, 255, 255,   4, 255,	/* 1720 - 1729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1730 - 1739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1740 - 1749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1750 - 1759 */
	  5, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1760 - 1769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1770 - 1779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1780 - 1789 */
	255, 255,  50, 255, 255, 255, 255, 255, 255, 255,	/* 1790 - 1799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1800 - 1809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1810 - 1819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1820 - 1829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1830 - 1839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1840 - 1849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1850 - 1859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1860 - 1869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1870 - 1879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1880 - 1889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1890 - 1899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1900 - 1909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1910 - 1919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1920 - 1929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1930 - 1939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1940 - 1949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1950 - 1959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1960 - 1969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1970 - 1979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1980 - 1989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 1990 - 1999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2000 - 2009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2010 - 2019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2020 - 2029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2030 - 2039 */
	255, 255, 255, 255, 255, 255, 255, 255,  51, 255,	/* 2040 - 2049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2050 - 2059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2060 - 2069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2070 - 2079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2080 - 2089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2090 - 2099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2100 - 2109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2110 - 2119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2120 - 2129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2130 - 2139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2140 - 2149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2150 - 2159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2160 - 2169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2170 - 2179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2180 - 2189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2190 - 2199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2200 - 2209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2210 - 2219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2220 - 2229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2230 - 2239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2240 - 2249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2250 - 2259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2260 - 2269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2270 - 2279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2280 - 2289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2290 - 2299 */
	255, 255, 255, 255,  67, 255, 255, 255, 255, 255,	/* 2300 - 2309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2310 - 2319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2320 - 2329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2330 - 2339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2340 - 2349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2350 - 2359 */
	255, 255, 255, 255, 255, 255, 255, 255,  99, 255,	/* 2360 - 2369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2370 - 2379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2380 - 2389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2390 - 2399 */
	100, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2400 - 2409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2410 - 2419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2420 - 2429 */
	255, 255,  22, 255, 255, 255, 255, 255, 255, 255,	/* 2430 - 2439 */
	255, 255, 255, 255, 255, 255, 255, 255,  23, 255,	/* 2440 - 2449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2450 - 2459 */
	255, 255, 255, 255,  24, 255, 255, 255, 255, 255,	/* 2460 - 2469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2470 - 2479 */
	 26, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2480 - 2489 */
	255, 255, 255, 255, 255, 255,  58, 255, 255, 255,	/* 2490 - 2499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2500 - 2509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2510 - 2519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2520 - 2529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2530 - 2539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2540 - 2549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2550 - 2559 */
	 64, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2560 - 2569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2570 - 2579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2580 - 2589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2590 - 2599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2600 - 2609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2610 - 2619 */
	255, 255, 255, 255,  89, 255, 255, 255, 255, 255,	/* 2620 - 2629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2630 - 2639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2640 - 2649 */
	255, 255, 255, 255, 255, 255,  90, 255, 255, 255,	/* 2650 - 2659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2660 - 2669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2670 - 2679 */
	255, 255, 255, 255, 255, 255, 255, 255,  91, 255,	/* 2680 - 2689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2690 - 2699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2700 - 2709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2710 - 2719 */
	 92, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2720 - 2729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2730 - 2739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2740 - 2749 */
	255, 255,  65, 255, 255, 255, 255, 255, 255, 255,	/* 2750 - 2759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2760 - 2769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2770 - 2779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2780 - 2789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2790 - 2799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2800 - 2809 */
	255, 255, 255, 255, 255, 255,  95, 255, 255, 255,	/* 2810 - 2819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2820 - 2829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2830 - 2839 */
	255, 255, 255, 255, 255, 255, 255, 255,  96, 255,	/* 2840 - 2849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2850 - 2859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2860 - 2869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2870 - 2879 */
	 97, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2880 - 2889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2890 - 2899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2900 - 2909 */
	255, 255,  98, 255, 255, 255, 255, 255, 255, 255,	/* 2910 - 2919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2920 - 2929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2930 - 2939 */
	255, 255, 255, 255,   2, 255, 255, 255, 255, 255,	/* 2940 - 2949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2950 - 2959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2960 - 2969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2970 - 2979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2980 - 2989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 2990 - 2999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3000 - 3009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3010 - 3019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3020 - 3029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3030 - 3039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3040 - 3049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3050 - 3059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3060 - 3069 */
	255, 255,  25, 255, 255, 255, 255, 255, 255, 255,	/* 3070 - 3079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3080 - 3089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3090 - 3099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3100 - 3109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3110 - 3119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3120 - 3129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3130 - 3139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3140 - 3149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3150 - 3159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3160 - 3169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3170 - 3179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3180 - 3189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3190 - 3199 */
	  6, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3200 - 3209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3210 - 3219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3220 - 3229 */
	255, 255,   7, 255, 255, 255, 255, 255, 255, 255,	/* 3230 - 3239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3240 - 3249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3250 - 3259 */
	255, 255, 255, 255,  10, 255, 255, 255, 255, 255,	/* 3260 - 3269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3270 - 3279 */
	 11, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3280 - 3289 */
	255, 255, 255, 255, 255, 255,   9, 255, 255, 255,	/* 3290 - 3299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3300 - 3309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3310 - 3319 */
	255, 255, 255, 255, 255, 255, 255, 255,   8, 255,	/* 3320 - 3329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3330 - 3339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3340 - 3349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3350 - 3359 */
	 12, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3360 - 3369 */
	255, 255, 255, 255, 255, 255,  13, 255, 255, 255,	/* 3370 - 3379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3380 - 3389 */
	255, 255,  14, 255, 255, 255, 255, 255, 255, 255,	/* 3390 - 3399 */
	255, 255, 255, 255, 255, 255, 255, 255,  15, 255,	/* 3400 - 3409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3410 - 3419 */
	255, 255, 255, 255,  16, 255, 255, 255, 255, 255,	/* 3420 - 3429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3430 - 3439 */
	 17, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3440 - 3449 */
	255, 255, 255, 255, 255, 255,  18, 255, 255, 255,	/* 3450 - 3459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3460 - 3469 */
	255, 255,  19, 255, 255, 255, 255, 255, 255, 255,	/* 3470 - 3479 */
	255, 255, 255, 255, 255, 255, 255, 255,  20, 255,	/* 3480 - 3489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3490 - 3499 */
	255, 255, 255, 255,  21, 255, 255, 255, 255, 255,	/* 3500 - 3509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3510 - 3519 */
	  3, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3520 - 3529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3530 - 3539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3540 - 3549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3550 - 3559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3560 - 3569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3570 - 3579 */
	255, 255, 255, 255,  42, 255, 255, 255, 255, 255,	/* 3580 - 3589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3590 - 3599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3600 - 3609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3610 - 3619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3620 - 3629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3630 - 3639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3640 - 3649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3650 - 3659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3660 - 3669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3670 - 3679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3680 - 3689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3690 - 3699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3700 - 3709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3710 - 3719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3720 - 3729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3730 - 3739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3740 - 3749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3750 - 3759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3760 - 3769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3770 - 3779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3780 - 3789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3790 - 3799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3800 - 3809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3810 - 3819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3820 - 3829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3830 - 3839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3840 - 3849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3850 - 3859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3860 - 3869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3870 - 3879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3880 - 3889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3890 - 3899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3900 - 3909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3910 - 3919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3920 - 3929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3930 - 3939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3940 - 3949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3950 - 3959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3960 - 3969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3970 - 3979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3980 - 3989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 3990 - 3999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4000 - 4009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4010 - 4019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4020 - 4029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4030 - 4039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4040 - 4049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4050 - 4059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4060 - 4069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4070 - 4079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4080 - 4089 */
	255, 255, 255, 255, 255, 255,  43, 255, 255, 255,	/* 4090 - 4099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4100 - 4109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4110 - 4119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4120 - 4129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4130 - 4139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4140 - 4149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4150 - 4159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4160 - 4169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4170 - 4179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4180 - 4189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4190 - 4199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4200 - 4209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4210 - 4219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4220 - 4229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4230 - 4239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4240 - 4249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4250 - 4259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4260 - 4269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4270 - 4279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4280 - 4289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4290 - 4299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4300 - 4309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4310 - 4319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4320 - 4329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4330 - 4339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4340 - 4349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4350 - 4359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4360 - 4369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4370 - 4379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4380 - 4389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4390 - 4399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4400 - 4409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4410 - 4419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4420 - 4429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4430 - 4439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4440 - 4449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4450 - 4459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4460 - 4469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4470 - 4479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4480 - 4489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4490 - 4499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4500 - 4509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4510 - 4519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4520 - 4529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4530 - 4539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4540 - 4549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4550 - 4559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4560 - 4569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4570 - 4579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4580 - 4589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4590 - 4599 */
	255, 255, 255, 255, 255, 255, 255, 255,   1, 255,	/* 4600 - 4609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4610 - 4619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4620 - 4629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4630 - 4639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4640 - 4649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4650 - 4659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4660 - 4669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4670 - 4679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4680 - 4689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4690 - 4699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4700 - 4709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4710 - 4719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4720 - 4729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4730 - 4739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4740 - 4749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4750 - 4759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4760 - 4769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4770 - 4779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4780 - 4789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4790 - 4799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4800 - 4809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4810 - 4819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4820 - 4829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4830 - 4839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4840 - 4849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4850 - 4859 */
	255, 255, 255, 255,  48, 255, 255, 255, 255, 255,	/* 4860 - 4869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4870 - 4879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4880 - 4889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4890 - 4899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4900 - 4909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4910 - 4919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4920 - 4929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4930 - 4939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4940 - 4949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4950 - 4959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4960 - 4969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4970 - 4979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4980 - 4989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 4990 - 4999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5000 - 5009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5010 - 5019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5020 - 5029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5030 - 5039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5040 - 5049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5050 - 5059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5060 - 5069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5070 - 5079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5080 - 5089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5090 - 5099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5100 - 5109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5110 - 5119 */
	 49, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5120 - 5129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5130 - 5139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5140 - 5149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5150 - 5159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5160 - 5169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5170 - 5179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5180 - 5189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5190 - 5199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5200 - 5209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5210 - 5219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5220 - 5229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5230 - 5239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5240 - 5249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5250 - 5259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5260 - 5269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5270 - 5279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5280 - 5289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5290 - 5299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5300 - 5309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5310 - 5319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5320 - 5329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5330 - 5339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5340 - 5349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5350 - 5359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5360 - 5369 */
	255, 255, 255, 255, 255, 255,  56, 255, 255, 255,	/* 5370 - 5379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5380 - 5389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5390 - 5399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5400 - 5409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5410 - 5419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5420 - 5429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5430 - 5439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5440 - 5449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5450 - 5459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5460 - 5469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5470 - 5479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5480 - 5489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5490 - 5499 */
	255, 255, 255, 255,  57, 255, 255, 255, 255, 255,	/* 5500 - 5509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5510 - 5519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5520 - 5529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5530 - 5539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5540 - 5549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5550 - 5559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5560 - 5569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5570 - 5579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5580 - 5589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5590 - 5599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5600 - 5609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5610 - 5619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5620 - 5629 */
	255, 255,  44, 255, 255, 255, 255, 255, 255, 255,	/* 5630 - 5639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5640 - 5649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5650 - 5659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5660 - 5669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5670 - 5679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5680 - 5689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5690 - 5699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5700 - 5709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5710 - 5719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5720 - 5729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5730 - 5739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5740 - 5749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5750 - 5759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5760 - 5769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5770 - 5779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5780 - 5789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5790 - 5799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5800 - 5809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5810 - 5819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5820 - 5829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5830 - 5839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5840 - 5849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5850 - 5859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5860 - 5869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5870 - 5879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5880 - 5889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5890 - 5899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5900 - 5909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5910 - 5919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5920 - 5929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5930 - 5939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5940 - 5949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5950 - 5959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5960 - 5969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5970 - 5979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5980 - 5989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 5990 - 5999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6000 - 6009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6010 - 6019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6020 - 6029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6030 - 6039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6040 - 6049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6050 - 6059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6060 - 6069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6070 - 6079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6080 - 6089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6090 - 6099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6100 - 6109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6110 - 6119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6120 - 6129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6130 - 6139 */
	255, 255, 255, 255,  45, 255, 255, 255, 255, 255,	/* 6140 - 6149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6150 - 6159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6160 - 6169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6170 - 6179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6180 - 6189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6190 - 6199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6200 - 6209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6210 - 6219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6220 - 6229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6230 - 6239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6240 - 6249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6250 - 6259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6260 - 6269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6270 - 6279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6280 - 6289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6290 - 6299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6300 - 6309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6310 - 6319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6320 - 6329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6330 - 6339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6340 - 6349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6350 - 6359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6360 - 6369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6370 - 6379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6380 - 6389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6390 - 6399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6400 - 6409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6410 - 6419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6420 - 6429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6430 - 6439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6440 - 6449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6450 - 6459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6460 - 6469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6470 - 6479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6480 - 6489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6490 - 6499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6500 - 6509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6510 - 6519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6520 - 6529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6530 - 6539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6540 - 6549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6550 - 6559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6560 - 6569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6570 - 6579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6580 - 6589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6590 - 6599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6600 - 6609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6610 - 6619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6620 - 6629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6630 - 6639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6640 - 6649 */
	255, 255, 255, 255, 255, 255,  54, 255, 255, 255,	/* 6650 - 6659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6660 - 6669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6670 - 6679 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6680 - 6689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6690 - 6699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6700 - 6709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6710 - 6719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6720 - 6729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6730 - 6739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6740 - 6749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6750 - 6759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6760 - 6769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6770 - 6779 */
	255, 255, 255, 255,  55, 255, 255, 255, 255, 255,	/* 6780 - 6789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6790 - 6799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6800 - 6809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6810 - 6819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6820 - 6829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6830 - 6839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6840 - 6849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6850 - 6859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6860 - 6869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6870 - 6879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6880 - 6889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6890 - 6899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6900 - 6909 */
	255, 255,   0, 255, 255, 255, 255, 255, 255, 255,	/* 6910 - 6919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6920 - 6929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6930 - 6939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6940 - 6949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6950 - 6959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6960 - 6969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6970 - 6979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6980 - 6989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 6990 - 6999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7000 - 7009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7010 - 7019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7020 - 7029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7030 - 7039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7040 - 7049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7050 - 7059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7060 - 7069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7070 - 7079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7080 - 7089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7090 - 7099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7100 - 7109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7110 - 7119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7120 - 7129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7130 - 7139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7140 - 7149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7150 - 7159 */
	255, 255, 255, 255, 255, 255, 255, 255,  46, 255,	/* 7160 - 7169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7170 - 7179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7180 - 7189 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7190 - 7199 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7200 - 7209 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7210 - 7219 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7220 - 7229 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7230 - 7239 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7240 - 7249 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7250 - 7259 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7260 - 7269 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7270 - 7279 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7280 - 7289 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7290 - 7299 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7300 - 7309 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7310 - 7319 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7320 - 7329 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7330 - 7339 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7340 - 7349 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7350 - 7359 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7360 - 7369 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7370 - 7379 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7380 - 7389 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7390 - 7399 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7400 - 7409 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7410 - 7419 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7420 - 7429 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7430 - 7439 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7440 - 7449 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7450 - 7459 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7460 - 7469 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7470 - 7479 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7480 - 7489 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7490 - 7499 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7500 - 7509 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7510 - 7519 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7520 - 7529 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7530 - 7539 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7540 - 7549 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7550 - 7559 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7560 - 7569 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7570 - 7579 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7580 - 7589 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7590 - 7599 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7600 - 7609 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7610 - 7619 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7620 - 7629 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7630 - 7639 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7640 - 7649 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7650 - 7659 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7660 - 7669 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7670 - 7679 */
	 47, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7680 - 7689 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7690 - 7699 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7700 - 7709 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7710 - 7719 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7720 - 7729 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7730 - 7739 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7740 - 7749 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7750 - 7759 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7760 - 7769 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7770 - 7779 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7780 - 7789 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7790 - 7799 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7800 - 7809 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7810 - 7819 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7820 - 7829 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7830 - 7839 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7840 - 7849 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7850 - 7859 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7860 - 7869 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7870 - 7879 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7880 - 7889 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7890 - 7899 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7900 - 7909 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7910 - 7919 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7920 - 7929 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7930 - 7939 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7940 - 7949 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7950 - 7959 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7960 - 7969 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7970 - 7979 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7980 - 7989 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 7990 - 7999 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8000 - 8009 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8010 - 8019 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8020 - 8029 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8030 - 8039 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8040 - 8049 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8050 - 8059 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8060 - 8069 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8070 - 8079 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8080 - 8089 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8090 - 8099 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8100 - 8109 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8110 - 8119 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8120 - 8129 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8130 - 8139 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8140 - 8149 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8150 - 8159 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8160 - 8169 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8170 - 8179 */
	255, 255, 255, 255, 255, 255, 255, 255, 255, 255,	/* 8180 - 8189 */
	255, 255
};

static tableentry	*g3mwtab = &TIFFFax3wcodes[0];
static tableentry	*g3twtab = &TIFFFax3wcodes[40];

#endif	/* __G3CODES_H__ */
