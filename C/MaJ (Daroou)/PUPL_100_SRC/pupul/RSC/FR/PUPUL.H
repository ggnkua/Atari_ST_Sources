/* JMS RSC Builder 0.10 */


#define RSCBUILDER_MAJOR  0
#define RSCBUILDER_MINOR 10

#define DL_TITRE_W_COEUR  0 /* Dialog */

#define TITRE_INFO        1 /* STRING */
#define TITRE_PREFERENCE  2 /* STRING */



#define DL_INFO_PRG       1 /* Dialog */

#define INFO_CDR_INVISIB  1 /* IBOX */
#define INFO_CDR_OMBRE    2 /* BOX */
#define INFO_CDR_TITRE    3 /* BOX */
#define INFO_CDR_TEXTE    4 /* TEXT */
#define INFO_IMG_RENAIS   5 /* IMAGE */
#define INFO_TXT_LICENCE  6 /* STRING */
#define INFO_TXT_VERSION  7 /* STRING */
#define INFO_PRG_VERSION  8 /* STRING */
#define INFO_PRG_DATE     9 /* STRING */
#define INFO_DBUG        10 /* TEXT */
#define INFO_COMPIL_TXT  11 /* TEXT */
#define INFO_COMPIL_DATE 12 /* TEXT */
#define INFO_GCC_VER_TXT 13 /* TEXT */
#define INFO_GCC_VER     14 /* TEXT */
#define INFO_CPU_TXT     15 /* TEXT */
#define INFO_CPU_TARGET  16 /* TEXT */
#define INFO_GEMLIB_TXT  17 /* TEXT */
#define INFO_GEMLIB_VER  18 /* TEXT */
#define INFO_LIBC_TYPE   19 /* TEXT */
#define INFO_COEUR_TXT   20 /* TEXT */
#define INFO_COEUR_VER   21 /* TEXT */
#define INFO_RSCBUILD_TX 22 /* TEXT */
#define INFO_RSCBUILD_V  23 /* TEXT */



#define DL_MOIS           2 /* Dialog */

#define MOIS_JANVIER      1 /* STRING */



#define DL_ICON_INFO      3 /* Dialog */

#define ICN_INFO_FOND     0 /* BOX */
#define ICN_INFO_TEXT     1 /* STRING */



#define DL_OPT_PREF       4 /* Dialog */

#define CHK_SAVE_WINPOS   1 /* BOX */
#define PREF_SAVE_WINPOS  2 /* STRING */
#define CHK_CLOSE_QUIT    3 /* BOX */
#define PREF_CLOSE_QUIT   4 /* STRING */
#define CHK_SAVE_AUTO     5 /* BOX */
#define PREF_SAVE_AUTO    6 /* STRING */
#define PREF_SAVE_CONFIG  7 /* BUTTON */
#define PREF_POPUP_LABEL  8 /* STRING */
#define PREF_POPUP_LANG   9 /* BOXTEXT */



#define POPUP_PREF_LANG   5 /* Dialog */

#define PLANG_FOND        0 /* BOX */
#define PLANG_ANGLAIS     1 /* STRING */
#define PLANG_ALLEMAND    2 /* STRING */
#define PLANG_FRANCAIS    3 /* STRING */
#define PLANG_ESPAGNOL    4 /* STRING */
#define PLANG_ITALIEN     5 /* STRING */
#define PLANG_SUEDOIS     6 /* STRING */
#define PLANG_UKRAINIEN   7 /* STRING */
#define PLANG_RUSSE       8 /* STRING */



#define DL_ICON_PREF      6 /* Dialog */

#define ICN_PREF_FOND     0 /* BOX */
#define ICN_PREF_TEXT     1 /* TEXT */



#define DL_ALERTE_COEUR   7 /* Dialog */

#define ALC_NO_WINDOWS    1 /* STRING */
#define ALC_NORAMCONFIG   2 /* STRING */
#define ALC_NO_INF_FILE   3 /* STRING */
#define ALC_NO_MORE_RAM   4 /* STRING */
#define ALC_ERR_SAVE_INF  5 /* STRING */
#define ALC_ERR_NOFUNC    6 /* STRING */
#define ALC_AV_BAD_FILE   7 /* STRING */
#define ALC_AV_NO_FILE    8 /* STRING */
#define ALC_BAD_CONFIG    9 /* STRING */
#define ALC_DEBUGVERSION 10 /* STRING */



#define DL_FORM_ALERT     8 /* Dialog */

#define FORM_CADRE_IMAGE  1 /* IBOX */
#define FORM_BT_EXCLA     2 /* IMAGE */
#define FORM_BT_INTERRO   3 /* IMAGE */
#define FORM_BT_STOP      4 /* IMAGE */
#define FORM_LIGNE1       5 /* STRING */
#define FORM_LIGNE2       6 /* STRING */
#define FORM_LIGNE3       7 /* STRING */
#define FORM_LIGNE4       8 /* STRING */
#define FORM_LIGNE5       9 /* STRING */
#define FORM_BOUTON1     10 /* BUTTON */
#define FORM_BOUTON2     11 /* BUTTON */
#define FORM_BOUTON3     12 /* BUTTON */



#define BARRE_MENU        9 /* Menu */

#define TMN_FENETRE       5 /* TITLE */
#define TMN_PREFERENCE    6 /* TITLE */
#define MN_INFO_PRG       9 /* STRING */
#define MN_QUITTER       18 /* STRING */
#define MN_PUPUL         20 /* STRING */
#define MN_BAR_OPTIONS   21 /* STRING */
#define MN_OPTIONS       22 /* STRING */
#define MN_MOD_OPTIONS   23 /* STRING */
#define MN_PREFERENCE    25 /* STRING */
#define MN_CONSOLE       27 /* STRING */
#define MN_SAUVER_CONFIG 29 /* STRING */



#define DL_TITRE_W_APPLI 10 /* Dialog */

#define TITRE_LAUNCH      1 /* STRING */
#define TITRE_PUPUL       2 /* STRING */
#define TITRE_MODLDG      3 /* STRING */



#define DL_ICON_EQUINOX  11 /* Dialog */




#define DL_ALERTE_APPLI  12 /* Dialog */

#define ALT_ERR_INCONNU   1 /* STRING */
#define ALT_ERR_RES_RAM   2 /* STRING */
#define ALT_ERR_INITSND   3 /* STRING */
#define ALT_ERR_DATA_PTH  4 /* STRING */
#define ALT_ERR_DATAFILE  5 /* STRING */
#define ALT_BAD_REZ       6 /* STRING */
#define ALT_BAD_REZ_256C  7 /* STRING */
#define ALT_ERR_ANIMSIZE  8 /* STRING */
#define ALT_ERR_ANIM_RAM  9 /* STRING */
#define ALT_ANIM_LOAD    10 /* STRING */
#define ALT_ERR_OPEN_TGA 11 /* STRING */
#define ALT_ERR_BAD_TGA  12 /* STRING */
#define ALT_ERR_TGALOAD  13 /* STRING */
#define ALT_ERR_SURFACE  14 /* STRING */
#define ALT_ERR_MOD_SIZE 15 /* STRING */
#define ALT_ERR_MOD_PATH 16 /* STRING */
#define ALT_ERR_CYBERMOD 17 /* STRING */
#define ALT_ERR_OPEN_MOD 18 /* STRING */
#define ALT_ERR_MODINIT  19 /* STRING */
#define ALT_ERR_LOAD_MOD 20 /* STRING */
#define ALT_ERR_DMA_LOCK 21 /* STRING */
#define ALT_ERR_XBIOSDMA 22 /* STRING */
#define ALT_REDEMARRAGE  23 /* STRING */



#define DL_LAUNCH        13 /* Dialog */

#define LAUNCH_FOND       0 /* BOX */
#define LAUNCH_IMAGE      1 /* IMAGE */
#define LAUNCH_BOX        2 /* BOX */
#define LAUNCH_BAR        3 /* BOX */
#define LAUNCH_TEXTE      4 /* STRING */



#define DL_LAUNCH_TEXTE  14 /* Dialog */

#define LH_INIT_PUPUL     2 /* STRING */
#define LH_VERIF_FICHIER  3 /* STRING */
#define LH_CHARGE_ANIM    4 /* STRING */
#define LH_CHERCHE_GRIS   5 /* STRING */
#define LH_OUVRE_TGA_LDG  6 /* STRING */
#define LH_INIT_SURFACE1  7 /* STRING */
#define LH_INIT_SURFACE2  8 /* STRING */
#define LH_INIT_SURFACE3  9 /* STRING */
#define LH_INIT_SURFACE4 10 /* STRING */
#define LH_INIT_SURFACE5 11 /* STRING */
#define LH_FERME_TGA_LDG 12 /* STRING */
#define LH_OUVRE_MOD_LDG 13 /* STRING */
#define LH_INIT_AUDIO    14 /* STRING */
#define LH_FERME_MOD_LDG 15 /* STRING */
#define LH_INIT_TERMINE  16 /* STRING */



#define DL_MODLDG        15 /* Dialog */

#define MODLDG_FOND       0 /* BOX */
#define MOD_UPDATE_LABEL  1 /* STRING */
#define MOD_UPDATE_POPUP  2 /* BOXTEXT */
#define MOD_FREQ_LABEL    3 /* STRING */
#define MOD_FREQ_POPUP    4 /* BOXTEXT */
#define MOD_BT_SAUVER     5 /* BUTTON */



#define POPUP_MODPOLLING 16 /* Dialog */

#define POPUP_MAJ_POLL    1 /* STRING */
#define POPUP_MAJ_TIMERA  2 /* STRING */
#define POPUP_MAJ_MFPI7   3 /* STRING */
#define POPUP_MAJ_GSXB    4 /* STRING */



#define POPUP_MOD_FREQ   17 /* Dialog */

#define POPUP_FREQ_12KHZ  1 /* STRING */
#define POPUP_FREQ_25KHZ  2 /* STRING */
#define POPUP_FREQ_50KHZ  3 /* STRING */



#define DL_ICON_MODLDG   18 /* Dialog */




#define DL_PIXEL_XFORMAT 19 /* Dialog */

#define PIXEL_LIGNE1      1 /* STRING */
#define PIXEL_LIGNE2      2 /* STRING */
#define PIXEL_LIGNE3      3 /* STRING */
#define PIXEL_REF_RED     4 /* BOX */
#define PIXEL_REF_GREEN   5 /* BOX */
#define PIXEL_REF_BLUE    6 /* BOX */
#define PIXEL_XFMT_MIRE1  7 /* BOX */
#define PIXEL_XFMT_MIRE2  8 /* BOX */
#define PIXEL_XFMT_MIRE3  9 /* BOX */
#define PIXEL_XFMT_MIRE4 10 /* BOX */
#define PIXEL_XFMT_MIRE5 11 /* BOX */



#define DL_OPTIONS       20 /* Dialog */

#define OPTION_FOND       0 /* BOX */
#define CHECK_CACHEIMG    1 /* BOX */
#define OPTION_CACHEIMG   2 /* STRING */
#define OPTION_PATHCACHE  3 /* BOXTEXT */
#define CHECK_FORCEMONO   4 /* BOX */
#define OPTION_FORCEMONO  5 /* STRING */
#define CHECK_MAXFPS      6 /* BOX */
#define OPTION_MAXFPS     7 /* STRING */
#define CHECK_MUTESOUND   8 /* BOX */
#define OPTION_MUTESOUND  9 /* STRING */
#define CHECK_PALETTE    10 /* BOX */
#define OPTION_PALETTE   11 /* STRING */
#define CHECK_FRAME_BUF  12 /* BOX */
#define OPTION_FRAME_BUF 13 /* STRING */
#define RAM_TYPE_RAM     14 /* STRING */
#define RAM_POPUP_RAM    15 /* BOXTEXT */
#define OPTION_PIXEL_TXT 16 /* STRING */
#define OPTION_POPUP_PIX 17 /* BOXTEXT */
#define OPTION_SAUVER    18 /* BUTTON */



#define DL_ICON_OPTIONS  21 /* Dialog */

#define ICN_OPTIONS       1 /* TEXT */



#define POPUP_RAM        22 /* Dialog */

#define POP_RAM_FOND      0 /* BOX */
#define POPUP_RAM_AUTO    1 /* STRING */
#define POPUP_RAM_STRAM   2 /* STRING */
#define POPUP_RAM_TTRAM   3 /* STRING */
#define POPUP_RAM_CT60    4 /* STRING */
#define POPUP_RAM_MILAN   5 /* STRING */



#define POPUP_PIXEL      23 /* Dialog */

#define POP_PIXEL_AUTO    1 /* STRING */
#define POP_PIX_1B        2 /* STRING */
#define POP_PIX_2B        3 /* STRING */
#define POP_PIX_4B        4 /* STRING */
#define POP_PIX_8B_PLAN   5 /* STRING */
#define POP_PIX_8B_PACK   6 /* STRING */
#define POP_PIX_15B_FAL   7 /* STRING */
#define POP_PIX_15B_INT   8 /* STRING */
#define POP_PIX_15B_MOT   9 /* STRING */
#define POP_PIX_16B_INT  10 /* STRING */
#define POP_PIX_16B_MOT  11 /* STRING */
#define POP_PIX_24B_INT  12 /* STRING */
#define POP_PIX_24B_MOT  13 /* STRING */
#define POP_PIX_32B_INT  14 /* STRING */
#define POP_PIX_32B_MOT  15 /* STRING */



#define TITRE_OPTIONS     0 /* R_STRING free_string */




/* (C) 2024 Renaissance */

