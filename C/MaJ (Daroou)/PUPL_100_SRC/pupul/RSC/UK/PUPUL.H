/* JMS RSC Builder 0.10 */


#define RSCBUILDER_MAJOR  0
#define RSCBUILDER_MINOR 10

#define DL_TITRE_W_COEUR  0 /* Dialog */




#define DL_INFO_PRG       1 /* Dialog */

#define INFO_CDR_TEXTE    4 /* TEXT */
#define INFO_LIBC_TYPE   19 /* TEXT */
#define INFO_RSCBUILD_TX 22 /* TEXT */
#define INFO_RSCBUILD_V  23 /* TEXT */



#define DL_MOIS           2 /* Dialog */

#define MOIS_JANVIER      1 /* STRING */



#define DL_ICON_INFO      3 /* Dialog */

#define ICN_INFO_FOND     0 /* BOX */
#define ICN_INFO_TEXT     1 /* STRING */



#define DL_OPT_PREF       4 /* Dialog */

#define CHK_SAVE_WINPOS   1 /* BOX */
#define PREF_SAVE_WINPOS  2 /* STRING */
#define CHK_CLOSE_QUIT    3 /* BOX */
#define PREF_CLOSE_QUIT   4 /* STRING */
#define CHK_SAVE_AUTO     5 /* BOX */
#define PREF_SAVE_AUTO    6 /* STRING */
#define PREF_SAVE_CONFIG  7 /* BUTTON */
#define PREF_POPUP_LANG   9 /* BOXTEXT */



#define POPUP_PREF_LANG   5 /* Dialog */

#define PLANG_FOND        0 /* BOX */
#define PLANG_ANGLAIS     1 /* STRING */
#define PLANG_ALLEMAND    2 /* STRING */
#define PLANG_FRANCAIS    3 /* STRING */
#define PLANG_ESPAGNOL    4 /* STRING */
#define PLANG_ITALIEN     5 /* STRING */
#define PLANG_SUEDOIS     6 /* STRING */
#define PLANG_UKRAINIEN   7 /* STRING */
#define PLANG_RUSSE       8 /* STRING */



#define DL_ICON_PREF      6 /* Dialog */

#define ICN_PREF_FOND     0 /* BOX */
#define ICN_PREF_TEXT     1 /* TEXT */



#define DL_ALERTE_COEUR   7 /* Dialog */

#define ALC_DEBUGVERSION 10 /* STRING */



#define DL_FORM_ALERT     8 /* Dialog */

#define FORM_BT_EXCLA     2 /* IMAGE */
#define FORM_BT_INTERRO   3 /* IMAGE */
#define FORM_BT_STOP      4 /* IMAGE */
#define FORM_LIGNE1       5 /* STRING */
#define FORM_BOUTON1     10 /* BUTTON */



#define BARRE_MENU        9 /* Menu */

#define TMN_FENETRE       5 /* TITLE */
#define TMN_PREFERENCE    6 /* TITLE */
#define MN_BAR_OPTIONS   21 /* STRING */
#define MN_OPTIONS       22 /* STRING */
#define MN_PREFERENCE    25 /* STRING */
#define MN_CONSOLE       27 /* STRING */
#define MN_SAUVER_CONFIG 29 /* STRING */



#define DL_TITRE_W_APPLI 10 /* Dialog */

#define TITRE_LAUNCH      1 /* STRING */
#define TITRE_PUPUL       2 /* STRING */
#define TITRE_MODLDG      3 /* STRING */



#define DL_ICON_EQUINOX  11 /* Dialog */




#define DL_ALERTE_APPLI  12 /* Dialog */

#define ALT_ERR_INCONNU   1 /* STRING */
#define ALT_ERR_RES_RAM   2 /* STRING */
#define ALT_ERR_DATA_PTH  4 /* STRING */
#define ALT_ERR_DATAFILE  5 /* STRING */
#define ALT_BAD_REZ       6 /* STRING */
#define ALT_BAD_REZ_256C  7 /* STRING */
#define ALT_ERR_ANIMSIZE  8 /* STRING */
#define ALT_ERR_ANIM_RAM  9 /* STRING */
#define ALT_ANIM_LOAD    10 /* STRING */
#define ALT_ERR_OPEN_TGA 11 /* STRING */
#define ALT_ERR_TGALOAD  13 /* STRING */
#define ALT_ERR_SURFACE  14 /* STRING */
#define ALT_ERR_MOD_SIZE 15 /* STRING */
#define ALT_ERR_MOD_PATH 16 /* STRING */
#define ALT_ERR_CYBERMOD 17 /* STRING */
#define ALT_ERR_OPEN_MOD 18 /* STRING */
#define ALT_ERR_MODINIT  19 /* STRING */
#define ALT_ERR_LOAD_MOD 20 /* STRING */
#define ALT_FORCEMONO    23 /* STRING */



#define DL_LAUNCH        13 /* Dialog */

#define LAUNCH_FOND       0 /* BOX */
#define LAUNCH_IMAGE      1 /* IMAGE */
#define LAUNCH_BOX        2 /* BOX */
#define LAUNCH_BAR        3 /* BOX */
#define LAUNCH_TEXTE      4 /* STRING */



#define DL_LAUNCH_TEXTE  14 /* Dialog */




#define DL_MODLDG        15 /* Dialog */




#define POPUP_MODPOLLING 16 /* Dialog */

#define POPUP_MAJ_POLL    1 /* STRING */
#define POPUP_MAJ_TIMERA  2 /* STRING */
#define POPUP_MAJ_MFPI7   3 /* STRING */
#define POPUP_MAJ_GSXB    4 /* STRING */



#define POPUP_MOD_FREQ   17 /* Dialog */

#define POPUP_FREQ_12KHZ  1 /* STRING */
#define POPUP_FREQ_25KHZ  2 /* STRING */
#define POPUP_FREQ_50KHZ  3 /* STRING */



#define DL_ICON_MODLDG   18 /* Dialog */




#define DL_PIXEL_XFORMAT 19 /* Dialog */

#define PIXEL_XFMT_MIRE1  7 /* BOX */
#define PIXEL_XFMT_MIRE2  8 /* BOX */
#define PIXEL_XFMT_MIRE3  9 /* BOX */
#define PIXEL_XFMT_MIRE4 10 /* BOX */
#define PIXEL_XFMT_MIRE5 11 /* BOX */



#define DL_OPTIONS       20 /* Dialog */

#define CHECK_FORCEMONO   4 /* BOX */
#define OPTION_FORCEMONO  5 /* STRING */
#define CHECK_MAXFPS      6 /* BOX */
#define OPTION_MAXFPS     7 /* STRING */
#define CHECK_FRAME_BUF  12 /* BOX */
#define OPTION_FRAME_BUF 13 /* STRING */
#define RAM_TYPE_RAM     14 /* STRING */
#define RAM_POPUP_RAM    15 /* BOXTEXT */
#define RAM_PIXEL_TXT    16 /* STRING */
#define RAM_PIXEL_POPUP  17 /* BOXTEXT */
#define OPTION_SAUVER    18 /* BUTTON */



#define DL_ICON_OPTIONS  21 /* Dialog */

#define ICN_OPTIONS       1 /* TEXT */



#define POPUP_RAM        22 /* Dialog */

#define POP_RAM_FOND      0 /* BOX */
#define POPUP_RAM_AUTO    1 /* STRING */
#define POPUP_RAM_STRAM   2 /* STRING */
#define POPUP_RAM_TTRAM   3 /* STRING */
#define POPUP_RAM_CT60    4 /* STRING */
#define POPUP_RAM_MILAN   5 /* STRING */



#define POPUP_PIXEL      23 /* Dialog */

#define POP_PIXEL_AUTO    1 /* STRING */
#define POP_PIX_1B        2 /* STRING */
#define POP_PIX_2B        3 /* STRING */
#define POP_PIX_4B        4 /* STRING */
#define POP_PIX_8B_PLAN   5 /* STRING */
#define POP_PIX_8B_PACK   6 /* STRING */
#define POP_PIX_15B_FAL   7 /* STRING */
#define POP_PIX_15B_INT   8 /* STRING */
#define POP_PIX_15B_MOT   9 /* STRING */
#define POP_PIX_16B_INT  10 /* STRING */
#define POP_PIX_16B_MOT  11 /* STRING */
#define POP_PIX_24B_INT  12 /* STRING */
#define POP_PIX_24B_MOT  13 /* STRING */
#define POP_PIX_32B_INT  14 /* STRING */
#define POP_PIX_32B_MOT  15 /* STRING */



#define TITRE_OPTIONS     0 /* R_STRING free_string */




/* (C) 2024 Renaissance */

