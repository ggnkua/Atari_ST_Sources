#ifndef ___COSTABLE_H___
#define ___COSTABLE_H___

int16 costable[]={
/*   0 000 */ 20,
/*   1 001 */ 19,
/*   2 002 */ 19,
/*   3 003 */ 19,
/*   4 004 */ 19,
/*   5 005 */ 19,
/*   6 006 */ 19,
/*   7 007 */ 19,
/*   8 008 */ 19,
/*   9 009 */ 19,
/*  10 010 */ 19,
/*  11 011 */ 19,
/*  12 012 */ 19,
/*  13 013 */ 19,
/*  14 014 */ 19,
/*  15 015 */ 19,
/*  16 016 */ 19,
/*  17 017 */ 19,
/*  18 018 */ 19,
/*  19 019 */ 18,
/*  20 020 */ 18,
/*  21 021 */ 18,
/*  22 022 */ 18,
/*  23 023 */ 18,
/*  24 024 */ 18,
/*  25 025 */ 18,
/*  26 026 */ 17,
/*  27 027 */ 17,
/*  28 028 */ 17,
/*  29 029 */ 17,
/*  30 030 */ 17,
/*  31 031 */ 17,
/*  32 032 */ 16,
/*  33 033 */ 16,
/*  34 034 */ 16,
/*  35 035 */ 16,
/*  36 036 */ 16,
/*  37 037 */ 15,
/*  38 038 */ 15,
/*  39 039 */ 15,
/*  40 040 */ 15,
/*  41 041 */ 15,
/*  42 042 */ 14,
/*  43 043 */ 14,
/*  44 044 */ 14,
/*  45 045 */ 14,
/*  46 046 */ 13,
/*  47 047 */ 13,
/*  48 048 */ 13,
/*  49 049 */ 13,
/*  50 050 */ 12,
/*  51 051 */ 12,
/*  52 052 */ 12,
/*  53 053 */ 12,
/*  54 054 */ 11,
/*  55 055 */ 11,
/*  56 056 */ 11,
/*  57 057 */ 10,
/*  58 058 */ 10,
/*  59 059 */ 10,
/*  60 060 */ 10,
/*  61 061 */ 9,
/*  62 062 */ 9,
/*  63 063 */ 9,
/*  64 064 */ 8,
/*  65 065 */ 8,
/*  66 066 */ 8,
/*  67 067 */ 7,
/*  68 068 */ 7,
/*  69 069 */ 7,
/*  70 070 */ 6,
/*  71 071 */ 6,
/*  72 072 */ 6,
/*  73 073 */ 5,
/*  74 074 */ 5,
/*  75 075 */ 5,
/*  76 076 */ 4,
/*  77 077 */ 4,
/*  78 078 */ 4,
/*  79 079 */ 3,
/*  80 080 */ 3,
/*  81 081 */ 3,
/*  82 082 */ 2,
/*  83 083 */ 2,
/*  84 084 */ 2,
/*  85 085 */ 1,
/*  86 086 */ 1,
/*  87 087 */ 1,
/*  88 088 */ 0,
/*  89 089 */ 0,
/*  90 090 */ 0,
/*  91 091 */ 0,
/*  92 092 */ 0,
/*  93 093 */ -1,
/*  94 094 */ -1,
/*  95 095 */ -1,
/*  96 096 */ -2,
/*  97 097 */ -2,
/*  98 098 */ -2,
/*  99 099 */ -3,
/* 100 100 */ -3,
/* 101 101 */ -3,
/* 102 102 */ -4,
/* 103 103 */ -4,
/* 104 104 */ -4,
/* 105 105 */ -5,
/* 106 106 */ -5,
/* 107 107 */ -5,
/* 108 108 */ -6,
/* 109 109 */ -6,
/* 110 110 */ -6,
/* 111 111 */ -7,
/* 112 112 */ -7,
/* 113 113 */ -7,
/* 114 114 */ -8,
/* 115 115 */ -8,
/* 116 116 */ -8,
/* 117 117 */ -9,
/* 118 118 */ -9,
/* 119 119 */ -9,
/* 120 120 */ -9,
/* 121 121 */ -10,
/* 122 122 */ -10,
/* 123 123 */ -10,
/* 124 124 */ -11,
/* 125 125 */ -11,
/* 126 126 */ -11,
/* 127 127 */ -12,
/* 128 128 */ -12,
/* 129 129 */ -12,
/* 130 130 */ -12,
/* 131 131 */ -13,
/* 132 132 */ -13,
/* 133 133 */ -13,
/* 134 134 */ -13,
/* 135 135 */ -14,
/* 136 136 */ -14,
/* 137 137 */ -14,
/* 138 138 */ -14,
/* 139 139 */ -15,
/* 140 140 */ -15,
/* 141 141 */ -15,
/* 142 142 */ -15,
/* 143 143 */ -15,
/* 144 144 */ -16,
/* 145 145 */ -16,
/* 146 146 */ -16,
/* 147 147 */ -16,
/* 148 148 */ -16,
/* 149 149 */ -17,
/* 150 150 */ -17,
/* 151 151 */ -17,
/* 152 152 */ -17,
/* 153 153 */ -17,
/* 154 154 */ -17,
/* 155 155 */ -18,
/* 156 156 */ -18,
/* 157 157 */ -18,
/* 158 158 */ -18,
/* 159 159 */ -18,
/* 160 160 */ -18,
/* 161 161 */ -18,
/* 162 162 */ -19,
/* 163 163 */ -19,
/* 164 164 */ -19,
/* 165 165 */ -19,
/* 166 166 */ -19,
/* 167 167 */ -19,
/* 168 168 */ -19,
/* 169 169 */ -19,
/* 170 170 */ -19,
/* 171 171 */ -19,
/* 172 172 */ -19,
/* 173 173 */ -19,
/* 174 174 */ -19,
/* 175 175 */ -19,
/* 176 176 */ -19,
/* 177 177 */ -19,
/* 178 178 */ -19,
/* 179 179 */ -19,
/* 180 180 */ -20,
/* 181 181 */ -19,
/* 182 182 */ -19,
/* 183 183 */ -19,
/* 184 184 */ -19,
/* 185 185 */ -19,
/* 186 186 */ -19,
/* 187 187 */ -19,
/* 188 188 */ -19,
/* 189 189 */ -19,
/* 190 190 */ -19,
/* 191 191 */ -19,
/* 192 192 */ -19,
/* 193 193 */ -19,
/* 194 194 */ -19,
/* 195 195 */ -19,
/* 196 196 */ -19,
/* 197 197 */ -19,
/* 198 198 */ -19,
/* 199 199 */ -18,
/* 200 200 */ -18,
/* 201 201 */ -18,
/* 202 202 */ -18,
/* 203 203 */ -18,
/* 204 204 */ -18,
/* 205 205 */ -18,
/* 206 206 */ -17,
/* 207 207 */ -17,
/* 208 208 */ -17,
/* 209 209 */ -17,
/* 210 210 */ -17,
/* 211 211 */ -17,
/* 212 212 */ -16,
/* 213 213 */ -16,
/* 214 214 */ -16,
/* 215 215 */ -16,
/* 216 216 */ -16,
/* 217 217 */ -15,
/* 218 218 */ -15,
/* 219 219 */ -15,
/* 220 220 */ -15,
/* 221 221 */ -15,
/* 222 222 */ -14,
/* 223 223 */ -14,
/* 224 224 */ -14,
/* 225 225 */ -14,
/* 226 226 */ -13,
/* 227 227 */ -13,
/* 228 228 */ -13,
/* 229 229 */ -13,
/* 230 230 */ -12,
/* 231 231 */ -12,
/* 232 232 */ -12,
/* 233 233 */ -12,
/* 234 234 */ -11,
/* 235 235 */ -11,
/* 236 236 */ -11,
/* 237 237 */ -10,
/* 238 238 */ -10,
/* 239 239 */ -10,
/* 240 240 */ -10,
/* 241 241 */ -9,
/* 242 242 */ -9,
/* 243 243 */ -9,
/* 244 244 */ -8,
/* 245 245 */ -8,
/* 246 246 */ -8,
/* 247 247 */ -7,
/* 248 248 */ -7,
/* 249 249 */ -7,
/* 250 250 */ -6,
/* 251 251 */ -6,
/* 252 252 */ -6,
/* 253 253 */ -5,
/* 254 254 */ -5,
/* 255 255 */ -5,
/* 256 256 */ -4,
/* 257 257 */ -4,
/* 258 258 */ -4,
/* 259 259 */ -3,
/* 260 260 */ -3,
/* 261 261 */ -3,
/* 262 262 */ -2,
/* 263 263 */ -2,
/* 264 264 */ -2,
/* 265 265 */ -1,
/* 266 266 */ -1,
/* 267 267 */ -1,
/* 268 268 */ 0,
/* 269 269 */ 0,
/* 270 270 */ 0,
/* 271 271 */ 0,
/* 272 272 */ 0,
/* 273 273 */ 1,
/* 274 274 */ 1,
/* 275 275 */ 1,
/* 276 276 */ 2,
/* 277 277 */ 2,
/* 278 278 */ 2,
/* 279 279 */ 3,
/* 280 280 */ 3,
/* 281 281 */ 3,
/* 282 282 */ 4,
/* 283 283 */ 4,
/* 284 284 */ 4,
/* 285 285 */ 5,
/* 286 286 */ 5,
/* 287 287 */ 5,
/* 288 288 */ 6,
/* 289 289 */ 6,
/* 290 290 */ 6,
/* 291 291 */ 7,
/* 292 292 */ 7,
/* 293 293 */ 7,
/* 294 294 */ 8,
/* 295 295 */ 8,
/* 296 296 */ 8,
/* 297 297 */ 9,
/* 298 298 */ 9,
/* 299 299 */ 9,
/* 300 300 */ 10,
/* 301 301 */ 10,
/* 302 302 */ 10,
/* 303 303 */ 10,
/* 304 304 */ 11,
/* 305 305 */ 11,
/* 306 306 */ 11,
/* 307 307 */ 12,
/* 308 308 */ 12,
/* 309 309 */ 12,
/* 310 310 */ 12,
/* 311 311 */ 13,
/* 312 312 */ 13,
/* 313 313 */ 13,
/* 314 314 */ 13,
/* 315 315 */ 14,
/* 316 316 */ 14,
/* 317 317 */ 14,
/* 318 318 */ 14,
/* 319 319 */ 15,
/* 320 320 */ 15,
/* 321 321 */ 15,
/* 322 322 */ 15,
/* 323 323 */ 15,
/* 324 324 */ 16,
/* 325 325 */ 16,
/* 326 326 */ 16,
/* 327 327 */ 16,
/* 328 328 */ 16,
/* 329 329 */ 17,
/* 330 330 */ 17,
/* 331 331 */ 17,
/* 332 332 */ 17,
/* 333 333 */ 17,
/* 334 334 */ 17,
/* 335 335 */ 18,
/* 336 336 */ 18,
/* 337 337 */ 18,
/* 338 338 */ 18,
/* 339 339 */ 18,
/* 340 340 */ 18,
/* 341 341 */ 18,
/* 342 342 */ 19,
/* 343 343 */ 19,
/* 344 344 */ 19,
/* 345 345 */ 19,
/* 346 346 */ 19,
/* 347 347 */ 19,
/* 348 348 */ 19,
/* 349 349 */ 19,
/* 350 350 */ 19,
/* 351 351 */ 19,
/* 352 352 */ 19,
/* 353 353 */ 19,
/* 354 354 */ 19,
/* 355 355 */ 19,
/* 356 356 */ 19,
/* 357 357 */ 19,
/* 358 358 */ 19,
/* 359 359 */ 19,
/* 360 360 */ 20,
/* 361 361 */ 19,
/* 362 362 */ 19,
/* 363 363 */ 19,
/* 364 364 */ 19,
/* 365 365 */ 19,
/* 366 366 */ 19,
/* 367 367 */ 19,
/* 368 368 */ 19,
/* 369 369 */ 19,
/* 370 370 */ 19,
/* 371 371 */ 19,
/* 372 372 */ 19,
/* 373 373 */ 19,
/* 374 374 */ 19,
/* 375 375 */ 19,
/* 376 376 */ 19,
/* 377 377 */ 19,
/* 378 378 */ 19,
/* 379 379 */ 18,
/* 380 380 */ 18,
/* 381 381 */ 18,
/* 382 382 */ 18,
/* 383 383 */ 18,
/* 384 384 */ 18,
/* 385 385 */ 18,
/* 386 386 */ 17,
/* 387 387 */ 17,
/* 388 388 */ 17,
/* 389 389 */ 17,
/* 390 390 */ 17,
/* 391 391 */ 17,
/* 392 392 */ 16,
/* 393 393 */ 16,
/* 394 394 */ 16,
/* 395 395 */ 16,
/* 396 396 */ 16,
/* 397 397 */ 15,
/* 398 398 */ 15,
/* 399 399 */ 15,
/* 400 400 */ 15,
/* 401 401 */ 15,
/* 402 402 */ 14,
/* 403 403 */ 14,
/* 404 404 */ 14,
/* 405 405 */ 14,
/* 406 406 */ 13,
/* 407 407 */ 13,
/* 408 408 */ 13,
/* 409 409 */ 13,
/* 410 410 */ 12,
/* 411 411 */ 12,
/* 412 412 */ 12,
/* 413 413 */ 12,
/* 414 414 */ 11,
/* 415 415 */ 11,
/* 416 416 */ 11,
/* 417 417 */ 10,
/* 418 418 */ 10,
/* 419 419 */ 10,
/* 420 420 */ 9,
/* 421 421 */ 9,
/* 422 422 */ 9,
/* 423 423 */ 9,
/* 424 424 */ 8,
/* 425 425 */ 8,
/* 426 426 */ 8,
/* 427 427 */ 7,
/* 428 428 */ 7,
/* 429 429 */ 7,
/* 430 430 */ 6,
/* 431 431 */ 6,
/* 432 432 */ 6,
/* 433 433 */ 5,
/* 434 434 */ 5,
/* 435 435 */ 5,
/* 436 436 */ 4,
/* 437 437 */ 4,
/* 438 438 */ 4,
/* 439 439 */ 3,
/* 440 440 */ 3,
/* 441 441 */ 3,
/* 442 442 */ 2,
/* 443 443 */ 2,
/* 444 444 */ 2,
/* 445 445 */ 1,
/* 446 446 */ 1,
/* 447 447 */ 1,
/* 448 448 */ 0,
/* 449 449 */ 0,
/* 450 450 */ 0,
/* 451 451 */ 0,
/* 452 452 */ 0,
/* 453 453 */ -1,
/* 454 454 */ -1,
/* 455 455 */ -1,
/* 456 456 */ -2,
/* 457 457 */ -2,
/* 458 458 */ -2,
/* 459 459 */ -3,
/* 460 460 */ -3,
/* 461 461 */ -3,
/* 462 462 */ -4,
/* 463 463 */ -4,
/* 464 464 */ -4,
/* 465 465 */ -5,
/* 466 466 */ -5,
/* 467 467 */ -5,
/* 468 468 */ -6,
/* 469 469 */ -6,
/* 470 470 */ -6,
/* 471 471 */ -7,
/* 472 472 */ -7,
/* 473 473 */ -7,
/* 474 474 */ -8,
/* 475 475 */ -8,
/* 476 476 */ -8,
/* 477 477 */ -9,
/* 478 478 */ -9,
/* 479 479 */ -9,
/* 480 480 */ -9,
/* 481 481 */ -10,
/* 482 482 */ -10,
/* 483 483 */ -10,
/* 484 484 */ -11,
/* 485 485 */ -11,
/* 486 486 */ -11,
/* 487 487 */ -12,
/* 488 488 */ -12,
/* 489 489 */ -12,
/* 490 490 */ -12,
/* 491 491 */ -13,
/* 492 492 */ -13,
/* 493 493 */ -13,
/* 494 494 */ -13,
/* 495 495 */ -14,
/* 496 496 */ -14,
/* 497 497 */ -14,
/* 498 498 */ -14,
/* 499 499 */ -15,
/* 500 500 */ -15,
/* 501 501 */ -15,
/* 502 502 */ -15,
/* 503 503 */ -15,
/* 504 504 */ -16,
/* 505 505 */ -16,
/* 506 506 */ -16,
/* 507 507 */ -16,
/* 508 508 */ -16,
/* 509 509 */ -17,
/* 510 510 */ -17,
/* 511 511 */ -17,
/* 512 512 */ -17,
/* 513 513 */ -17,
/* 514 514 */ -17,
/* 515 515 */ -18,
/* 516 516 */ -18,
/* 517 517 */ -18,
/* 518 518 */ -18,
/* 519 519 */ -18,
/* 520 520 */ -18,
/* 521 521 */ -18,
/* 522 522 */ -19,
/* 523 523 */ -19,
/* 524 524 */ -19,
/* 525 525 */ -19,
/* 526 526 */ -19,
/* 527 527 */ -19,
/* 528 528 */ -19,
/* 529 529 */ -19,
/* 530 530 */ -19,
/* 531 531 */ -19,
/* 532 532 */ -19,
/* 533 533 */ -19,
/* 534 534 */ -19,
/* 535 535 */ -19,
/* 536 536 */ -19,
/* 537 537 */ -19,
/* 538 538 */ -19,
/* 539 539 */ -19,
/* 540 540 */ -20,
/* 541 541 */ -19,
/* 542 542 */ -19,
/* 543 543 */ -19,
/* 544 544 */ -19,
/* 545 545 */ -19,
/* 546 546 */ -19,
/* 547 547 */ -19,
/* 548 548 */ -19,
/* 549 549 */ -19,
/* 550 550 */ -19,
/* 551 551 */ -19,
/* 552 552 */ -19,
/* 553 553 */ -19,
/* 554 554 */ -19,
/* 555 555 */ -19,
/* 556 556 */ -19,
/* 557 557 */ -19,
/* 558 558 */ -19,
/* 559 559 */ -18,
/* 560 560 */ -18,
/* 561 561 */ -18,
/* 562 562 */ -18,
/* 563 563 */ -18,
/* 564 564 */ -18,
/* 565 565 */ -18,
/* 566 566 */ -17,
/* 567 567 */ -17,
/* 568 568 */ -17,
/* 569 569 */ -17,
/* 570 570 */ -17,
/* 571 571 */ -17,
/* 572 572 */ -16,
/* 573 573 */ -16,
/* 574 574 */ -16,
/* 575 575 */ -16,
/* 576 576 */ -16,
/* 577 577 */ -15,
/* 578 578 */ -15,
/* 579 579 */ -15,
/* 580 580 */ -15,
/* 581 581 */ -15,
/* 582 582 */ -14,
/* 583 583 */ -14,
/* 584 584 */ -14,
/* 585 585 */ -14,
/* 586 586 */ -13,
/* 587 587 */ -13,
/* 588 588 */ -13,
/* 589 589 */ -13,
/* 590 590 */ -12,
/* 591 591 */ -12,
/* 592 592 */ -12,
/* 593 593 */ -12,
/* 594 594 */ -11,
/* 595 595 */ -11,
/* 596 596 */ -11,
/* 597 597 */ -10,
/* 598 598 */ -10,
/* 599 599 */ -10,
/* 600 600 */ -9,
/* 601 601 */ -9,
/* 602 602 */ -9,
/* 603 603 */ -9,
/* 604 604 */ -8,
/* 605 605 */ -8,
/* 606 606 */ -8,
/* 607 607 */ -7,
/* 608 608 */ -7,
/* 609 609 */ -7,
/* 610 610 */ -6,
/* 611 611 */ -6,
/* 612 612 */ -6,
/* 613 613 */ -5,
/* 614 614 */ -5,
/* 615 615 */ -5,
/* 616 616 */ -4,
/* 617 617 */ -4,
/* 618 618 */ -4,
/* 619 619 */ -3,
/* 620 620 */ -3,
/* 621 621 */ -3,
/* 622 622 */ -2,
/* 623 623 */ -2,
/* 624 624 */ -2,
/* 625 625 */ -1,
/* 626 626 */ -1,
/* 627 627 */ -1,
/* 628 628 */ 0,
/* 629 629 */ 0,
/* 630 630 */ 0,
/* 631 631 */ 0,
/* 632 632 */ 0,
/* 633 633 */ 1,
/* 634 634 */ 1,
/* 635 635 */ 1,
/* 636 636 */ 2,
/* 637 637 */ 2,
/* 638 638 */ 2,
/* 639 639 */ 3,
/* 640 640 */ 3,
/* 641 641 */ 3,
/* 642 642 */ 4,
/* 643 643 */ 4,
/* 644 644 */ 4,
/* 645 645 */ 5,
/* 646 646 */ 5,
/* 647 647 */ 5,
/* 648 648 */ 6,
/* 649 649 */ 6,
/* 650 650 */ 6,
/* 651 651 */ 7,
/* 652 652 */ 7,
/* 653 653 */ 7,
/* 654 654 */ 8,
/* 655 655 */ 8,
/* 656 656 */ 8,
/* 657 657 */ 9,
/* 658 658 */ 9,
/* 659 659 */ 9,
/* 660 660 */ 9,
/* 661 661 */ 10,
/* 662 662 */ 10,
/* 663 663 */ 10,
/* 664 664 */ 11,
/* 665 665 */ 11,
/* 666 666 */ 11,
/* 667 667 */ 12,
/* 668 668 */ 12,
/* 669 669 */ 12,
/* 670 670 */ 12,
/* 671 671 */ 13,
/* 672 672 */ 13,
/* 673 673 */ 13,
/* 674 674 */ 13,
/* 675 675 */ 14,
/* 676 676 */ 14,
/* 677 677 */ 14,
/* 678 678 */ 14,
/* 679 679 */ 15,
/* 680 680 */ 15,
/* 681 681 */ 15,
/* 682 682 */ 15,
/* 683 683 */ 15,
/* 684 684 */ 16,
/* 685 685 */ 16,
/* 686 686 */ 16,
/* 687 687 */ 16,
/* 688 688 */ 16,
/* 689 689 */ 17,
/* 690 690 */ 17,
/* 691 691 */ 17,
/* 692 692 */ 17,
/* 693 693 */ 17,
/* 694 694 */ 17,
/* 695 695 */ 18,
/* 696 696 */ 18,
/* 697 697 */ 18,
/* 698 698 */ 18,
/* 699 699 */ 18,
/* 700 700 */ 18,
/* 701 701 */ 18,
/* 702 702 */ 19,
/* 703 703 */ 19,
/* 704 704 */ 19,
/* 705 705 */ 19,
/* 706 706 */ 19,
/* 707 707 */ 19,
/* 708 708 */ 19,
/* 709 709 */ 19,
/* 710 710 */ 19,
/* 711 711 */ 19,
/* 712 712 */ 19,
/* 713 713 */ 19,
/* 714 714 */ 19,
/* 715 715 */ 19,
/* 716 716 */ 19,
/* 717 717 */ 19,
/* 718 718 */ 19,
/* 719 719 */ 19,
};
#endif /* ___COSTABLE_H___ */
