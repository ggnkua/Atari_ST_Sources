#ifndef ___COSTABLE_H___
#define ___COSTABLE_H___

int16 costable[]={
/*   0 000 */ 20,
/*   1 002 */ 19,
/*   2 004 */ 19,
/*   3 006 */ 19,
/*   4 008 */ 19,
/*   5 010 */ 19,
/*   6 012 */ 19,
/*   7 014 */ 19,
/*   8 016 */ 19,
/*   9 018 */ 19,
/*  10 020 */ 18,
/*  11 022 */ 18,
/*  12 024 */ 18,
/*  13 026 */ 17,
/*  14 028 */ 17,
/*  15 030 */ 17,
/*  16 032 */ 16,
/*  17 034 */ 16,
/*  18 036 */ 16,
/*  19 038 */ 15,
/*  20 040 */ 15,
/*  21 042 */ 14,
/*  22 044 */ 14,
/*  23 046 */ 13,
/*  24 048 */ 13,
/*  25 050 */ 12,
/*  26 052 */ 12,
/*  27 054 */ 11,
/*  28 056 */ 11,
/*  29 058 */ 10,
/*  30 060 */ 10,
/*  31 062 */ 9,
/*  32 064 */ 8,
/*  33 066 */ 8,
/*  34 068 */ 7,
/*  35 070 */ 6,
/*  36 072 */ 6,
/*  37 074 */ 5,
/*  38 076 */ 4,
/*  39 078 */ 4,
/*  40 080 */ 3,
/*  41 082 */ 2,
/*  42 084 */ 2,
/*  43 086 */ 1,
/*  44 088 */ 0,
/*  45 090 */ 0,
/*  46 092 */ 0,
/*  47 094 */ -1,
/*  48 096 */ -2,
/*  49 098 */ -2,
/*  50 100 */ -3,
/*  51 102 */ -4,
/*  52 104 */ -4,
/*  53 106 */ -5,
/*  54 108 */ -6,
/*  55 110 */ -6,
/*  56 112 */ -7,
/*  57 114 */ -8,
/*  58 116 */ -8,
/*  59 118 */ -9,
/*  60 120 */ -9,
/*  61 122 */ -10,
/*  62 124 */ -11,
/*  63 126 */ -11,
/*  64 128 */ -12,
/*  65 130 */ -12,
/*  66 132 */ -13,
/*  67 134 */ -13,
/*  68 136 */ -14,
/*  69 138 */ -14,
/*  70 140 */ -15,
/*  71 142 */ -15,
/*  72 144 */ -16,
/*  73 146 */ -16,
/*  74 148 */ -16,
/*  75 150 */ -17,
/*  76 152 */ -17,
/*  77 154 */ -17,
/*  78 156 */ -18,
/*  79 158 */ -18,
/*  80 160 */ -18,
/*  81 162 */ -19,
/*  82 164 */ -19,
/*  83 166 */ -19,
/*  84 168 */ -19,
/*  85 170 */ -19,
/*  86 172 */ -19,
/*  87 174 */ -19,
/*  88 176 */ -19,
/*  89 178 */ -19,
/*  90 180 */ -20,
/*  91 182 */ -19,
/*  92 184 */ -19,
/*  93 186 */ -19,
/*  94 188 */ -19,
/*  95 190 */ -19,
/*  96 192 */ -19,
/*  97 194 */ -19,
/*  98 196 */ -19,
/*  99 198 */ -19,
/* 100 200 */ -18,
/* 101 202 */ -18,
/* 102 204 */ -18,
/* 103 206 */ -17,
/* 104 208 */ -17,
/* 105 210 */ -17,
/* 106 212 */ -16,
/* 107 214 */ -16,
/* 108 216 */ -16,
/* 109 218 */ -15,
/* 110 220 */ -15,
/* 111 222 */ -14,
/* 112 224 */ -14,
/* 113 226 */ -13,
/* 114 228 */ -13,
/* 115 230 */ -12,
/* 116 232 */ -12,
/* 117 234 */ -11,
/* 118 236 */ -11,
/* 119 238 */ -10,
/* 120 240 */ -10,
/* 121 242 */ -9,
/* 122 244 */ -8,
/* 123 246 */ -8,
/* 124 248 */ -7,
/* 125 250 */ -6,
/* 126 252 */ -6,
/* 127 254 */ -5,
/* 128 256 */ -4,
/* 129 258 */ -4,
/* 130 260 */ -3,
/* 131 262 */ -2,
/* 132 264 */ -2,
/* 133 266 */ -1,
/* 134 268 */ 0,
/* 135 270 */ 0,
/* 136 272 */ 0,
/* 137 274 */ 1,
/* 138 276 */ 2,
/* 139 278 */ 2,
/* 140 280 */ 3,
/* 141 282 */ 4,
/* 142 284 */ 4,
/* 143 286 */ 5,
/* 144 288 */ 6,
/* 145 290 */ 6,
/* 146 292 */ 7,
/* 147 294 */ 8,
/* 148 296 */ 8,
/* 149 298 */ 9,
/* 150 300 */ 10,
/* 151 302 */ 10,
/* 152 304 */ 11,
/* 153 306 */ 11,
/* 154 308 */ 12,
/* 155 310 */ 12,
/* 156 312 */ 13,
/* 157 314 */ 13,
/* 158 316 */ 14,
/* 159 318 */ 14,
/* 160 320 */ 15,
/* 161 322 */ 15,
/* 162 324 */ 16,
/* 163 326 */ 16,
/* 164 328 */ 16,
/* 165 330 */ 17,
/* 166 332 */ 17,
/* 167 334 */ 17,
/* 168 336 */ 18,
/* 169 338 */ 18,
/* 170 340 */ 18,
/* 171 342 */ 19,
/* 172 344 */ 19,
/* 173 346 */ 19,
/* 174 348 */ 19,
/* 175 350 */ 19,
/* 176 352 */ 19,
/* 177 354 */ 19,
/* 178 356 */ 19,
/* 179 358 */ 19,
/* 180 360 */ 20,
/* 181 362 */ 19,
/* 182 364 */ 19,
/* 183 366 */ 19,
/* 184 368 */ 19,
/* 185 370 */ 19,
/* 186 372 */ 19,
/* 187 374 */ 19,
/* 188 376 */ 19,
/* 189 378 */ 19,
/* 190 380 */ 18,
/* 191 382 */ 18,
/* 192 384 */ 18,
/* 193 386 */ 17,
/* 194 388 */ 17,
/* 195 390 */ 17,
/* 196 392 */ 16,
/* 197 394 */ 16,
/* 198 396 */ 16,
/* 199 398 */ 15,
/* 200 400 */ 15,
/* 201 402 */ 14,
/* 202 404 */ 14,
/* 203 406 */ 13,
/* 204 408 */ 13,
/* 205 410 */ 12,
/* 206 412 */ 12,
/* 207 414 */ 11,
/* 208 416 */ 11,
/* 209 418 */ 10,
/* 210 420 */ 9,
/* 211 422 */ 9,
/* 212 424 */ 8,
/* 213 426 */ 8,
/* 214 428 */ 7,
/* 215 430 */ 6,
/* 216 432 */ 6,
/* 217 434 */ 5,
/* 218 436 */ 4,
/* 219 438 */ 4,
/* 220 440 */ 3,
/* 221 442 */ 2,
/* 222 444 */ 2,
/* 223 446 */ 1,
/* 224 448 */ 0,
/* 225 450 */ 0,
/* 226 452 */ 0,
/* 227 454 */ -1,
/* 228 456 */ -2,
/* 229 458 */ -2,
/* 230 460 */ -3,
/* 231 462 */ -4,
/* 232 464 */ -4,
/* 233 466 */ -5,
/* 234 468 */ -6,
/* 235 470 */ -6,
/* 236 472 */ -7,
/* 237 474 */ -8,
/* 238 476 */ -8,
/* 239 478 */ -9,
/* 240 480 */ -9,
/* 241 482 */ -10,
/* 242 484 */ -11,
/* 243 486 */ -11,
/* 244 488 */ -12,
/* 245 490 */ -12,
/* 246 492 */ -13,
/* 247 494 */ -13,
/* 248 496 */ -14,
/* 249 498 */ -14,
/* 250 500 */ -15,
/* 251 502 */ -15,
/* 252 504 */ -16,
/* 253 506 */ -16,
/* 254 508 */ -16,
/* 255 510 */ -17,
/* 256 512 */ -17,
/* 257 514 */ -17,
/* 258 516 */ -18,
/* 259 518 */ -18,
/* 260 520 */ -18,
/* 261 522 */ -19,
/* 262 524 */ -19,
/* 263 526 */ -19,
/* 264 528 */ -19,
/* 265 530 */ -19,
/* 266 532 */ -19,
/* 267 534 */ -19,
/* 268 536 */ -19,
/* 269 538 */ -19,
/* 270 540 */ -20,
/* 271 542 */ -19,
/* 272 544 */ -19,
/* 273 546 */ -19,
/* 274 548 */ -19,
/* 275 550 */ -19,
/* 276 552 */ -19,
/* 277 554 */ -19,
/* 278 556 */ -19,
/* 279 558 */ -19,
/* 280 560 */ -18,
/* 281 562 */ -18,
/* 282 564 */ -18,
/* 283 566 */ -17,
/* 284 568 */ -17,
/* 285 570 */ -17,
/* 286 572 */ -16,
/* 287 574 */ -16,
/* 288 576 */ -16,
/* 289 578 */ -15,
/* 290 580 */ -15,
/* 291 582 */ -14,
/* 292 584 */ -14,
/* 293 586 */ -13,
/* 294 588 */ -13,
/* 295 590 */ -12,
/* 296 592 */ -12,
/* 297 594 */ -11,
/* 298 596 */ -11,
/* 299 598 */ -10,
/* 300 600 */ -9,
/* 301 602 */ -9,
/* 302 604 */ -8,
/* 303 606 */ -8,
/* 304 608 */ -7,
/* 305 610 */ -6,
/* 306 612 */ -6,
/* 307 614 */ -5,
/* 308 616 */ -4,
/* 309 618 */ -4,
/* 310 620 */ -3,
/* 311 622 */ -2,
/* 312 624 */ -2,
/* 313 626 */ -1,
/* 314 628 */ 0,
/* 315 630 */ 0,
/* 316 632 */ 0,
/* 317 634 */ 1,
/* 318 636 */ 2,
/* 319 638 */ 2,
/* 320 640 */ 3,
/* 321 642 */ 4,
/* 322 644 */ 4,
/* 323 646 */ 5,
/* 324 648 */ 6,
/* 325 650 */ 6,
/* 326 652 */ 7,
/* 327 654 */ 8,
/* 328 656 */ 8,
/* 329 658 */ 9,
/* 330 660 */ 9,
/* 331 662 */ 10,
/* 332 664 */ 11,
/* 333 666 */ 11,
/* 334 668 */ 12,
/* 335 670 */ 12,
/* 336 672 */ 13,
/* 337 674 */ 13,
/* 338 676 */ 14,
/* 339 678 */ 14,
/* 340 680 */ 15,
/* 341 682 */ 15,
/* 342 684 */ 16,
/* 343 686 */ 16,
/* 344 688 */ 16,
/* 345 690 */ 17,
/* 346 692 */ 17,
/* 347 694 */ 17,
/* 348 696 */ 18,
/* 349 698 */ 18,
/* 350 700 */ 18,
/* 351 702 */ 19,
/* 352 704 */ 19,
/* 353 706 */ 19,
/* 354 708 */ 19,
/* 355 710 */ 19,
/* 356 712 */ 19,
/* 357 714 */ 19,
/* 358 716 */ 19,
/* 359 718 */ 19,
/* 360 720 */ 20,
/* 361 722 */ 19,
/* 362 724 */ 19,
/* 363 726 */ 19,
/* 364 728 */ 19,
/* 365 730 */ 19,
/* 366 732 */ 19,
/* 367 734 */ 19,
/* 368 736 */ 19,
/* 369 738 */ 19,
/* 370 740 */ 18,
/* 371 742 */ 18,
/* 372 744 */ 18,
/* 373 746 */ 17,
/* 374 748 */ 17,
/* 375 750 */ 17,
/* 376 752 */ 16,
/* 377 754 */ 16,
/* 378 756 */ 16,
/* 379 758 */ 15,
/* 380 760 */ 15,
/* 381 762 */ 14,
/* 382 764 */ 14,
/* 383 766 */ 13,
/* 384 768 */ 13,
/* 385 770 */ 12,
/* 386 772 */ 12,
/* 387 774 */ 11,
/* 388 776 */ 11,
/* 389 778 */ 10,
/* 390 780 */ 9,
/* 391 782 */ 9,
/* 392 784 */ 8,
/* 393 786 */ 8,
/* 394 788 */ 7,
/* 395 790 */ 6,
/* 396 792 */ 6,
/* 397 794 */ 5,
/* 398 796 */ 4,
/* 399 798 */ 4,
/* 400 800 */ 3,
/* 401 802 */ 2,
/* 402 804 */ 2,
/* 403 806 */ 1,
/* 404 808 */ 0,
/* 405 810 */ 0,
/* 406 812 */ 0,
/* 407 814 */ -1,
/* 408 816 */ -2,
/* 409 818 */ -2,
/* 410 820 */ -3,
/* 411 822 */ -4,
/* 412 824 */ -4,
/* 413 826 */ -5,
/* 414 828 */ -6,
/* 415 830 */ -6,
/* 416 832 */ -7,
/* 417 834 */ -8,
/* 418 836 */ -8,
/* 419 838 */ -9,
/* 420 840 */ -10,
/* 421 842 */ -10,
/* 422 844 */ -11,
/* 423 846 */ -11,
/* 424 848 */ -12,
/* 425 850 */ -12,
/* 426 852 */ -13,
/* 427 854 */ -13,
/* 428 856 */ -14,
/* 429 858 */ -14,
/* 430 860 */ -15,
/* 431 862 */ -15,
/* 432 864 */ -16,
/* 433 866 */ -16,
/* 434 868 */ -16,
/* 435 870 */ -17,
/* 436 872 */ -17,
/* 437 874 */ -17,
/* 438 876 */ -18,
/* 439 878 */ -18,
/* 440 880 */ -18,
/* 441 882 */ -19,
/* 442 884 */ -19,
/* 443 886 */ -19,
/* 444 888 */ -19,
/* 445 890 */ -19,
/* 446 892 */ -19,
/* 447 894 */ -19,
/* 448 896 */ -19,
/* 449 898 */ -19,
/* 450 900 */ -20,
/* 451 902 */ -19,
/* 452 904 */ -19,
/* 453 906 */ -19,
/* 454 908 */ -19,
/* 455 910 */ -19,
/* 456 912 */ -19,
/* 457 914 */ -19,
/* 458 916 */ -19,
/* 459 918 */ -19,
/* 460 920 */ -18,
/* 461 922 */ -18,
/* 462 924 */ -18,
/* 463 926 */ -17,
/* 464 928 */ -17,
/* 465 930 */ -17,
/* 466 932 */ -16,
/* 467 934 */ -16,
/* 468 936 */ -16,
/* 469 938 */ -15,
/* 470 940 */ -15,
/* 471 942 */ -14,
/* 472 944 */ -14,
/* 473 946 */ -13,
/* 474 948 */ -13,
/* 475 950 */ -12,
/* 476 952 */ -12,
/* 477 954 */ -11,
/* 478 956 */ -11,
/* 479 958 */ -10,
/* 480 960 */ -10,
/* 481 962 */ -9,
/* 482 964 */ -8,
/* 483 966 */ -8,
/* 484 968 */ -7,
/* 485 970 */ -6,
/* 486 972 */ -6,
/* 487 974 */ -5,
/* 488 976 */ -4,
/* 489 978 */ -4,
/* 490 980 */ -3,
/* 491 982 */ -2,
/* 492 984 */ -2,
/* 493 986 */ -1,
/* 494 988 */ 0,
/* 495 990 */ 0,
/* 496 992 */ 0,
/* 497 994 */ 1,
/* 498 996 */ 2,
/* 499 998 */ 2,
/* 500 1000 */ 3,
/* 501 1002 */ 4,
/* 502 1004 */ 4,
/* 503 1006 */ 5,
/* 504 1008 */ 6,
/* 505 1010 */ 6,
/* 506 1012 */ 7,
/* 507 1014 */ 8,
/* 508 1016 */ 8,
/* 509 1018 */ 9,
/* 510 1020 */ 10,
/* 511 1022 */ 10,
/* 512 1024 */ 11,
/* 513 1026 */ 11,
/* 514 1028 */ 12,
/* 515 1030 */ 12,
/* 516 1032 */ 13,
/* 517 1034 */ 13,
/* 518 1036 */ 14,
/* 519 1038 */ 14,
/* 520 1040 */ 15,
/* 521 1042 */ 15,
/* 522 1044 */ 16,
/* 523 1046 */ 16,
/* 524 1048 */ 16,
/* 525 1050 */ 17,
/* 526 1052 */ 17,
/* 527 1054 */ 17,
/* 528 1056 */ 18,
/* 529 1058 */ 18,
/* 530 1060 */ 18,
/* 531 1062 */ 19,
/* 532 1064 */ 19,
/* 533 1066 */ 19,
/* 534 1068 */ 19,
/* 535 1070 */ 19,
/* 536 1072 */ 19,
/* 537 1074 */ 19,
/* 538 1076 */ 19,
/* 539 1078 */ 19,
/* 540 1080 */ 20,
/* 541 1082 */ 19,
/* 542 1084 */ 19,
/* 543 1086 */ 19,
/* 544 1088 */ 19,
/* 545 1090 */ 19,
/* 546 1092 */ 19,
/* 547 1094 */ 19,
/* 548 1096 */ 19,
/* 549 1098 */ 19,
/* 550 1100 */ 18,
/* 551 1102 */ 18,
/* 552 1104 */ 18,
/* 553 1106 */ 17,
/* 554 1108 */ 17,
/* 555 1110 */ 17,
/* 556 1112 */ 16,
/* 557 1114 */ 16,
/* 558 1116 */ 16,
/* 559 1118 */ 15,
/* 560 1120 */ 15,
/* 561 1122 */ 14,
/* 562 1124 */ 14,
/* 563 1126 */ 13,
/* 564 1128 */ 13,
/* 565 1130 */ 12,
/* 566 1132 */ 12,
/* 567 1134 */ 11,
/* 568 1136 */ 11,
/* 569 1138 */ 10,
/* 570 1140 */ 10,
/* 571 1142 */ 9,
/* 572 1144 */ 8,
/* 573 1146 */ 8,
/* 574 1148 */ 7,
/* 575 1150 */ 6,
/* 576 1152 */ 6,
/* 577 1154 */ 5,
/* 578 1156 */ 4,
/* 579 1158 */ 4,
/* 580 1160 */ 3,
/* 581 1162 */ 2,
/* 582 1164 */ 2,
/* 583 1166 */ 1,
/* 584 1168 */ 0,
/* 585 1170 */ 0,
/* 586 1172 */ 0,
/* 587 1174 */ -1,
/* 588 1176 */ -2,
/* 589 1178 */ -2,
/* 590 1180 */ -3,
/* 591 1182 */ -4,
/* 592 1184 */ -4,
/* 593 1186 */ -5,
/* 594 1188 */ -6,
/* 595 1190 */ -6,
/* 596 1192 */ -7,
/* 597 1194 */ -8,
/* 598 1196 */ -8,
/* 599 1198 */ -9,
/* 600 1200 */ -10,
/* 601 1202 */ -10,
/* 602 1204 */ -11,
/* 603 1206 */ -11,
/* 604 1208 */ -12,
/* 605 1210 */ -12,
/* 606 1212 */ -13,
/* 607 1214 */ -13,
/* 608 1216 */ -14,
/* 609 1218 */ -14,
/* 610 1220 */ -15,
/* 611 1222 */ -15,
/* 612 1224 */ -16,
/* 613 1226 */ -16,
/* 614 1228 */ -16,
/* 615 1230 */ -17,
/* 616 1232 */ -17,
/* 617 1234 */ -17,
/* 618 1236 */ -18,
/* 619 1238 */ -18,
/* 620 1240 */ -18,
/* 621 1242 */ -19,
/* 622 1244 */ -19,
/* 623 1246 */ -19,
/* 624 1248 */ -19,
/* 625 1250 */ -19,
/* 626 1252 */ -19,
/* 627 1254 */ -19,
/* 628 1256 */ -19,
/* 629 1258 */ -19,
/* 630 1260 */ -20,
/* 631 1262 */ -19,
/* 632 1264 */ -19,
/* 633 1266 */ -19,
/* 634 1268 */ -19,
/* 635 1270 */ -19,
/* 636 1272 */ -19,
/* 637 1274 */ -19,
/* 638 1276 */ -19,
/* 639 1278 */ -19,
/* 640 1280 */ -18,
/* 641 1282 */ -18,
/* 642 1284 */ -18,
/* 643 1286 */ -17,
/* 644 1288 */ -17,
/* 645 1290 */ -17,
/* 646 1292 */ -16,
/* 647 1294 */ -16,
/* 648 1296 */ -16,
/* 649 1298 */ -15,
/* 650 1300 */ -15,
/* 651 1302 */ -14,
/* 652 1304 */ -14,
/* 653 1306 */ -13,
/* 654 1308 */ -13,
/* 655 1310 */ -12,
/* 656 1312 */ -12,
/* 657 1314 */ -11,
/* 658 1316 */ -11,
/* 659 1318 */ -10,
/* 660 1320 */ -10,
/* 661 1322 */ -9,
/* 662 1324 */ -8,
/* 663 1326 */ -8,
/* 664 1328 */ -7,
/* 665 1330 */ -6,
/* 666 1332 */ -6,
/* 667 1334 */ -5,
/* 668 1336 */ -4,
/* 669 1338 */ -4,
/* 670 1340 */ -3,
/* 671 1342 */ -2,
/* 672 1344 */ -2,
/* 673 1346 */ -1,
/* 674 1348 */ 0,
/* 675 1350 */ 0,
/* 676 1352 */ 0,
/* 677 1354 */ 1,
/* 678 1356 */ 2,
/* 679 1358 */ 2,
/* 680 1360 */ 3,
/* 681 1362 */ 4,
/* 682 1364 */ 4,
/* 683 1366 */ 5,
/* 684 1368 */ 6,
/* 685 1370 */ 6,
/* 686 1372 */ 7,
/* 687 1374 */ 8,
/* 688 1376 */ 8,
/* 689 1378 */ 9,
/* 690 1380 */ 10,
/* 691 1382 */ 10,
/* 692 1384 */ 11,
/* 693 1386 */ 11,
/* 694 1388 */ 12,
/* 695 1390 */ 12,
/* 696 1392 */ 13,
/* 697 1394 */ 13,
/* 698 1396 */ 14,
/* 699 1398 */ 14,
/* 700 1400 */ 15,
/* 701 1402 */ 15,
/* 702 1404 */ 16,
/* 703 1406 */ 16,
/* 704 1408 */ 16,
/* 705 1410 */ 17,
/* 706 1412 */ 17,
/* 707 1414 */ 17,
/* 708 1416 */ 18,
/* 709 1418 */ 18,
/* 710 1420 */ 18,
/* 711 1422 */ 19,
/* 712 1424 */ 19,
/* 713 1426 */ 19,
/* 714 1428 */ 19,
/* 715 1430 */ 19,
/* 716 1432 */ 19,
/* 717 1434 */ 19,
/* 718 1436 */ 19,
/* 719 1438 */ 19,
};
#endif /* ___COSTABLE_H___ */
