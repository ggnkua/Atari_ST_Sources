#ifndef ___COSTABLE_H___
#define ___COSTABLE_H___

int16 costable[]={
/*   0 000 */ 20,
/*   1 003 */ 19,
/*   2 006 */ 19,
/*   3 009 */ 19,
/*   4 012 */ 19,
/*   5 015 */ 19,
/*   6 018 */ 19,
/*   7 021 */ 18,
/*   8 024 */ 18,
/*   9 027 */ 17,
/*  10 030 */ 17,
/*  11 033 */ 16,
/*  12 036 */ 16,
/*  13 039 */ 15,
/*  14 042 */ 14,
/*  15 045 */ 14,
/*  16 048 */ 13,
/*  17 051 */ 12,
/*  18 054 */ 11,
/*  19 057 */ 10,
/*  20 060 */ 10,
/*  21 063 */ 9,
/*  22 066 */ 8,
/*  23 069 */ 7,
/*  24 072 */ 6,
/*  25 075 */ 5,
/*  26 078 */ 4,
/*  27 081 */ 3,
/*  28 084 */ 2,
/*  29 087 */ 1,
/*  30 090 */ 0,
/*  31 093 */ -1,
/*  32 096 */ -2,
/*  33 099 */ -3,
/*  34 102 */ -4,
/*  35 105 */ -5,
/*  36 108 */ -6,
/*  37 111 */ -7,
/*  38 114 */ -8,
/*  39 117 */ -9,
/*  40 120 */ -9,
/*  41 123 */ -10,
/*  42 126 */ -11,
/*  43 129 */ -12,
/*  44 132 */ -13,
/*  45 135 */ -14,
/*  46 138 */ -14,
/*  47 141 */ -15,
/*  48 144 */ -16,
/*  49 147 */ -16,
/*  50 150 */ -17,
/*  51 153 */ -17,
/*  52 156 */ -18,
/*  53 159 */ -18,
/*  54 162 */ -19,
/*  55 165 */ -19,
/*  56 168 */ -19,
/*  57 171 */ -19,
/*  58 174 */ -19,
/*  59 177 */ -19,
/*  60 180 */ -20,
/*  61 183 */ -19,
/*  62 186 */ -19,
/*  63 189 */ -19,
/*  64 192 */ -19,
/*  65 195 */ -19,
/*  66 198 */ -19,
/*  67 201 */ -18,
/*  68 204 */ -18,
/*  69 207 */ -17,
/*  70 210 */ -17,
/*  71 213 */ -16,
/*  72 216 */ -16,
/*  73 219 */ -15,
/*  74 222 */ -14,
/*  75 225 */ -14,
/*  76 228 */ -13,
/*  77 231 */ -12,
/*  78 234 */ -11,
/*  79 237 */ -10,
/*  80 240 */ -10,
/*  81 243 */ -9,
/*  82 246 */ -8,
/*  83 249 */ -7,
/*  84 252 */ -6,
/*  85 255 */ -5,
/*  86 258 */ -4,
/*  87 261 */ -3,
/*  88 264 */ -2,
/*  89 267 */ -1,
/*  90 270 */ 0,
/*  91 273 */ 1,
/*  92 276 */ 2,
/*  93 279 */ 3,
/*  94 282 */ 4,
/*  95 285 */ 5,
/*  96 288 */ 6,
/*  97 291 */ 7,
/*  98 294 */ 8,
/*  99 297 */ 9,
/* 100 300 */ 10,
/* 101 303 */ 10,
/* 102 306 */ 11,
/* 103 309 */ 12,
/* 104 312 */ 13,
/* 105 315 */ 14,
/* 106 318 */ 14,
/* 107 321 */ 15,
/* 108 324 */ 16,
/* 109 327 */ 16,
/* 110 330 */ 17,
/* 111 333 */ 17,
/* 112 336 */ 18,
/* 113 339 */ 18,
/* 114 342 */ 19,
/* 115 345 */ 19,
/* 116 348 */ 19,
/* 117 351 */ 19,
/* 118 354 */ 19,
/* 119 357 */ 19,
/* 120 360 */ 20,
/* 121 363 */ 19,
/* 122 366 */ 19,
/* 123 369 */ 19,
/* 124 372 */ 19,
/* 125 375 */ 19,
/* 126 378 */ 19,
/* 127 381 */ 18,
/* 128 384 */ 18,
/* 129 387 */ 17,
/* 130 390 */ 17,
/* 131 393 */ 16,
/* 132 396 */ 16,
/* 133 399 */ 15,
/* 134 402 */ 14,
/* 135 405 */ 14,
/* 136 408 */ 13,
/* 137 411 */ 12,
/* 138 414 */ 11,
/* 139 417 */ 10,
/* 140 420 */ 9,
/* 141 423 */ 9,
/* 142 426 */ 8,
/* 143 429 */ 7,
/* 144 432 */ 6,
/* 145 435 */ 5,
/* 146 438 */ 4,
/* 147 441 */ 3,
/* 148 444 */ 2,
/* 149 447 */ 1,
/* 150 450 */ 0,
/* 151 453 */ -1,
/* 152 456 */ -2,
/* 153 459 */ -3,
/* 154 462 */ -4,
/* 155 465 */ -5,
/* 156 468 */ -6,
/* 157 471 */ -7,
/* 158 474 */ -8,
/* 159 477 */ -9,
/* 160 480 */ -9,
/* 161 483 */ -10,
/* 162 486 */ -11,
/* 163 489 */ -12,
/* 164 492 */ -13,
/* 165 495 */ -14,
/* 166 498 */ -14,
/* 167 501 */ -15,
/* 168 504 */ -16,
/* 169 507 */ -16,
/* 170 510 */ -17,
/* 171 513 */ -17,
/* 172 516 */ -18,
/* 173 519 */ -18,
/* 174 522 */ -19,
/* 175 525 */ -19,
/* 176 528 */ -19,
/* 177 531 */ -19,
/* 178 534 */ -19,
/* 179 537 */ -19,
/* 180 540 */ -20,
/* 181 543 */ -19,
/* 182 546 */ -19,
/* 183 549 */ -19,
/* 184 552 */ -19,
/* 185 555 */ -19,
/* 186 558 */ -19,
/* 187 561 */ -18,
/* 188 564 */ -18,
/* 189 567 */ -17,
/* 190 570 */ -17,
/* 191 573 */ -16,
/* 192 576 */ -16,
/* 193 579 */ -15,
/* 194 582 */ -14,
/* 195 585 */ -14,
/* 196 588 */ -13,
/* 197 591 */ -12,
/* 198 594 */ -11,
/* 199 597 */ -10,
/* 200 600 */ -9,
/* 201 603 */ -9,
/* 202 606 */ -8,
/* 203 609 */ -7,
/* 204 612 */ -6,
/* 205 615 */ -5,
/* 206 618 */ -4,
/* 207 621 */ -3,
/* 208 624 */ -2,
/* 209 627 */ -1,
/* 210 630 */ 0,
/* 211 633 */ 1,
/* 212 636 */ 2,
/* 213 639 */ 3,
/* 214 642 */ 4,
/* 215 645 */ 5,
/* 216 648 */ 6,
/* 217 651 */ 7,
/* 218 654 */ 8,
/* 219 657 */ 9,
/* 220 660 */ 9,
/* 221 663 */ 10,
/* 222 666 */ 11,
/* 223 669 */ 12,
/* 224 672 */ 13,
/* 225 675 */ 14,
/* 226 678 */ 14,
/* 227 681 */ 15,
/* 228 684 */ 16,
/* 229 687 */ 16,
/* 230 690 */ 17,
/* 231 693 */ 17,
/* 232 696 */ 18,
/* 233 699 */ 18,
/* 234 702 */ 19,
/* 235 705 */ 19,
/* 236 708 */ 19,
/* 237 711 */ 19,
/* 238 714 */ 19,
/* 239 717 */ 19,
/* 240 720 */ 20,
/* 241 723 */ 19,
/* 242 726 */ 19,
/* 243 729 */ 19,
/* 244 732 */ 19,
/* 245 735 */ 19,
/* 246 738 */ 19,
/* 247 741 */ 18,
/* 248 744 */ 18,
/* 249 747 */ 17,
/* 250 750 */ 17,
/* 251 753 */ 16,
/* 252 756 */ 16,
/* 253 759 */ 15,
/* 254 762 */ 14,
/* 255 765 */ 14,
/* 256 768 */ 13,
/* 257 771 */ 12,
/* 258 774 */ 11,
/* 259 777 */ 10,
/* 260 780 */ 9,
/* 261 783 */ 9,
/* 262 786 */ 8,
/* 263 789 */ 7,
/* 264 792 */ 6,
/* 265 795 */ 5,
/* 266 798 */ 4,
/* 267 801 */ 3,
/* 268 804 */ 2,
/* 269 807 */ 1,
/* 270 810 */ 0,
/* 271 813 */ -1,
/* 272 816 */ -2,
/* 273 819 */ -3,
/* 274 822 */ -4,
/* 275 825 */ -5,
/* 276 828 */ -6,
/* 277 831 */ -7,
/* 278 834 */ -8,
/* 279 837 */ -9,
/* 280 840 */ -10,
/* 281 843 */ -10,
/* 282 846 */ -11,
/* 283 849 */ -12,
/* 284 852 */ -13,
/* 285 855 */ -14,
/* 286 858 */ -14,
/* 287 861 */ -15,
/* 288 864 */ -16,
/* 289 867 */ -16,
/* 290 870 */ -17,
/* 291 873 */ -17,
/* 292 876 */ -18,
/* 293 879 */ -18,
/* 294 882 */ -19,
/* 295 885 */ -19,
/* 296 888 */ -19,
/* 297 891 */ -19,
/* 298 894 */ -19,
/* 299 897 */ -19,
/* 300 900 */ -20,
/* 301 903 */ -19,
/* 302 906 */ -19,
/* 303 909 */ -19,
/* 304 912 */ -19,
/* 305 915 */ -19,
/* 306 918 */ -19,
/* 307 921 */ -18,
/* 308 924 */ -18,
/* 309 927 */ -17,
/* 310 930 */ -17,
/* 311 933 */ -16,
/* 312 936 */ -16,
/* 313 939 */ -15,
/* 314 942 */ -14,
/* 315 945 */ -14,
/* 316 948 */ -13,
/* 317 951 */ -12,
/* 318 954 */ -11,
/* 319 957 */ -10,
/* 320 960 */ -10,
/* 321 963 */ -9,
/* 322 966 */ -8,
/* 323 969 */ -7,
/* 324 972 */ -6,
/* 325 975 */ -5,
/* 326 978 */ -4,
/* 327 981 */ -3,
/* 328 984 */ -2,
/* 329 987 */ -1,
/* 330 990 */ 0,
/* 331 993 */ 1,
/* 332 996 */ 2,
/* 333 999 */ 3,
/* 334 1002 */ 4,
/* 335 1005 */ 5,
/* 336 1008 */ 6,
/* 337 1011 */ 7,
/* 338 1014 */ 8,
/* 339 1017 */ 9,
/* 340 1020 */ 10,
/* 341 1023 */ 10,
/* 342 1026 */ 11,
/* 343 1029 */ 12,
/* 344 1032 */ 13,
/* 345 1035 */ 14,
/* 346 1038 */ 14,
/* 347 1041 */ 15,
/* 348 1044 */ 16,
/* 349 1047 */ 16,
/* 350 1050 */ 17,
/* 351 1053 */ 17,
/* 352 1056 */ 18,
/* 353 1059 */ 18,
/* 354 1062 */ 19,
/* 355 1065 */ 19,
/* 356 1068 */ 19,
/* 357 1071 */ 19,
/* 358 1074 */ 19,
/* 359 1077 */ 19,
/* 360 1080 */ 20,
/* 361 1083 */ 19,
/* 362 1086 */ 19,
/* 363 1089 */ 19,
/* 364 1092 */ 19,
/* 365 1095 */ 19,
/* 366 1098 */ 19,
/* 367 1101 */ 18,
/* 368 1104 */ 18,
/* 369 1107 */ 17,
/* 370 1110 */ 17,
/* 371 1113 */ 16,
/* 372 1116 */ 16,
/* 373 1119 */ 15,
/* 374 1122 */ 14,
/* 375 1125 */ 14,
/* 376 1128 */ 13,
/* 377 1131 */ 12,
/* 378 1134 */ 11,
/* 379 1137 */ 10,
/* 380 1140 */ 10,
/* 381 1143 */ 9,
/* 382 1146 */ 8,
/* 383 1149 */ 7,
/* 384 1152 */ 6,
/* 385 1155 */ 5,
/* 386 1158 */ 4,
/* 387 1161 */ 3,
/* 388 1164 */ 2,
/* 389 1167 */ 1,
/* 390 1170 */ 0,
/* 391 1173 */ -1,
/* 392 1176 */ -2,
/* 393 1179 */ -3,
/* 394 1182 */ -4,
/* 395 1185 */ -5,
/* 396 1188 */ -6,
/* 397 1191 */ -7,
/* 398 1194 */ -8,
/* 399 1197 */ -9,
/* 400 1200 */ -10,
/* 401 1203 */ -10,
/* 402 1206 */ -11,
/* 403 1209 */ -12,
/* 404 1212 */ -13,
/* 405 1215 */ -14,
/* 406 1218 */ -14,
/* 407 1221 */ -15,
/* 408 1224 */ -16,
/* 409 1227 */ -16,
/* 410 1230 */ -17,
/* 411 1233 */ -17,
/* 412 1236 */ -18,
/* 413 1239 */ -18,
/* 414 1242 */ -19,
/* 415 1245 */ -19,
/* 416 1248 */ -19,
/* 417 1251 */ -19,
/* 418 1254 */ -19,
/* 419 1257 */ -19,
/* 420 1260 */ -20,
/* 421 1263 */ -19,
/* 422 1266 */ -19,
/* 423 1269 */ -19,
/* 424 1272 */ -19,
/* 425 1275 */ -19,
/* 426 1278 */ -19,
/* 427 1281 */ -18,
/* 428 1284 */ -18,
/* 429 1287 */ -17,
/* 430 1290 */ -17,
/* 431 1293 */ -16,
/* 432 1296 */ -16,
/* 433 1299 */ -15,
/* 434 1302 */ -14,
/* 435 1305 */ -14,
/* 436 1308 */ -13,
/* 437 1311 */ -12,
/* 438 1314 */ -11,
/* 439 1317 */ -10,
/* 440 1320 */ -10,
/* 441 1323 */ -9,
/* 442 1326 */ -8,
/* 443 1329 */ -7,
/* 444 1332 */ -6,
/* 445 1335 */ -5,
/* 446 1338 */ -4,
/* 447 1341 */ -3,
/* 448 1344 */ -2,
/* 449 1347 */ -1,
/* 450 1350 */ 0,
/* 451 1353 */ 1,
/* 452 1356 */ 2,
/* 453 1359 */ 3,
/* 454 1362 */ 4,
/* 455 1365 */ 5,
/* 456 1368 */ 6,
/* 457 1371 */ 7,
/* 458 1374 */ 8,
/* 459 1377 */ 9,
/* 460 1380 */ 10,
/* 461 1383 */ 10,
/* 462 1386 */ 11,
/* 463 1389 */ 12,
/* 464 1392 */ 13,
/* 465 1395 */ 14,
/* 466 1398 */ 14,
/* 467 1401 */ 15,
/* 468 1404 */ 16,
/* 469 1407 */ 16,
/* 470 1410 */ 17,
/* 471 1413 */ 17,
/* 472 1416 */ 18,
/* 473 1419 */ 18,
/* 474 1422 */ 19,
/* 475 1425 */ 19,
/* 476 1428 */ 19,
/* 477 1431 */ 19,
/* 478 1434 */ 19,
/* 479 1437 */ 19,
/* 480 1440 */ 20,
/* 481 1443 */ 19,
/* 482 1446 */ 19,
/* 483 1449 */ 19,
/* 484 1452 */ 19,
/* 485 1455 */ 19,
/* 486 1458 */ 19,
/* 487 1461 */ 18,
/* 488 1464 */ 18,
/* 489 1467 */ 17,
/* 490 1470 */ 17,
/* 491 1473 */ 16,
/* 492 1476 */ 16,
/* 493 1479 */ 15,
/* 494 1482 */ 14,
/* 495 1485 */ 14,
/* 496 1488 */ 13,
/* 497 1491 */ 12,
/* 498 1494 */ 11,
/* 499 1497 */ 10,
/* 500 1500 */ 10,
/* 501 1503 */ 9,
/* 502 1506 */ 8,
/* 503 1509 */ 7,
/* 504 1512 */ 6,
/* 505 1515 */ 5,
/* 506 1518 */ 4,
/* 507 1521 */ 3,
/* 508 1524 */ 2,
/* 509 1527 */ 1,
/* 510 1530 */ 0,
/* 511 1533 */ -1,
/* 512 1536 */ -2,
/* 513 1539 */ -3,
/* 514 1542 */ -4,
/* 515 1545 */ -5,
/* 516 1548 */ -6,
/* 517 1551 */ -7,
/* 518 1554 */ -8,
/* 519 1557 */ -9,
/* 520 1560 */ -10,
/* 521 1563 */ -10,
/* 522 1566 */ -11,
/* 523 1569 */ -12,
/* 524 1572 */ -13,
/* 525 1575 */ -14,
/* 526 1578 */ -14,
/* 527 1581 */ -15,
/* 528 1584 */ -16,
/* 529 1587 */ -16,
/* 530 1590 */ -17,
/* 531 1593 */ -17,
/* 532 1596 */ -18,
/* 533 1599 */ -18,
/* 534 1602 */ -19,
/* 535 1605 */ -19,
/* 536 1608 */ -19,
/* 537 1611 */ -19,
/* 538 1614 */ -19,
/* 539 1617 */ -19,
/* 540 1620 */ -20,
/* 541 1623 */ -19,
/* 542 1626 */ -19,
/* 543 1629 */ -19,
/* 544 1632 */ -19,
/* 545 1635 */ -19,
/* 546 1638 */ -19,
/* 547 1641 */ -18,
/* 548 1644 */ -18,
/* 549 1647 */ -17,
/* 550 1650 */ -17,
/* 551 1653 */ -16,
/* 552 1656 */ -16,
/* 553 1659 */ -15,
/* 554 1662 */ -14,
/* 555 1665 */ -14,
/* 556 1668 */ -13,
/* 557 1671 */ -12,
/* 558 1674 */ -11,
/* 559 1677 */ -10,
/* 560 1680 */ -9,
/* 561 1683 */ -9,
/* 562 1686 */ -8,
/* 563 1689 */ -7,
/* 564 1692 */ -6,
/* 565 1695 */ -5,
/* 566 1698 */ -4,
/* 567 1701 */ -3,
/* 568 1704 */ -2,
/* 569 1707 */ -1,
/* 570 1710 */ 0,
/* 571 1713 */ 1,
/* 572 1716 */ 2,
/* 573 1719 */ 3,
/* 574 1722 */ 4,
/* 575 1725 */ 5,
/* 576 1728 */ 6,
/* 577 1731 */ 7,
/* 578 1734 */ 8,
/* 579 1737 */ 9,
/* 580 1740 */ 10,
/* 581 1743 */ 10,
/* 582 1746 */ 11,
/* 583 1749 */ 12,
/* 584 1752 */ 13,
/* 585 1755 */ 14,
/* 586 1758 */ 14,
/* 587 1761 */ 15,
/* 588 1764 */ 16,
/* 589 1767 */ 16,
/* 590 1770 */ 17,
/* 591 1773 */ 17,
/* 592 1776 */ 18,
/* 593 1779 */ 18,
/* 594 1782 */ 19,
/* 595 1785 */ 19,
/* 596 1788 */ 19,
/* 597 1791 */ 19,
/* 598 1794 */ 19,
/* 599 1797 */ 19,
/* 600 1800 */ 20,
/* 601 1803 */ 19,
/* 602 1806 */ 19,
/* 603 1809 */ 19,
/* 604 1812 */ 19,
/* 605 1815 */ 19,
/* 606 1818 */ 19,
/* 607 1821 */ 18,
/* 608 1824 */ 18,
/* 609 1827 */ 17,
/* 610 1830 */ 17,
/* 611 1833 */ 16,
/* 612 1836 */ 16,
/* 613 1839 */ 15,
/* 614 1842 */ 14,
/* 615 1845 */ 14,
/* 616 1848 */ 13,
/* 617 1851 */ 12,
/* 618 1854 */ 11,
/* 619 1857 */ 10,
/* 620 1860 */ 10,
/* 621 1863 */ 9,
/* 622 1866 */ 8,
/* 623 1869 */ 7,
/* 624 1872 */ 6,
/* 625 1875 */ 5,
/* 626 1878 */ 4,
/* 627 1881 */ 3,
/* 628 1884 */ 2,
/* 629 1887 */ 1,
/* 630 1890 */ 0,
/* 631 1893 */ -1,
/* 632 1896 */ -2,
/* 633 1899 */ -3,
/* 634 1902 */ -4,
/* 635 1905 */ -5,
/* 636 1908 */ -6,
/* 637 1911 */ -7,
/* 638 1914 */ -8,
/* 639 1917 */ -9,
/* 640 1920 */ -9,
/* 641 1923 */ -10,
/* 642 1926 */ -11,
/* 643 1929 */ -12,
/* 644 1932 */ -13,
/* 645 1935 */ -14,
/* 646 1938 */ -14,
/* 647 1941 */ -15,
/* 648 1944 */ -16,
/* 649 1947 */ -16,
/* 650 1950 */ -17,
/* 651 1953 */ -17,
/* 652 1956 */ -18,
/* 653 1959 */ -18,
/* 654 1962 */ -19,
/* 655 1965 */ -19,
/* 656 1968 */ -19,
/* 657 1971 */ -19,
/* 658 1974 */ -19,
/* 659 1977 */ -19,
/* 660 1980 */ -20,
/* 661 1983 */ -19,
/* 662 1986 */ -19,
/* 663 1989 */ -19,
/* 664 1992 */ -19,
/* 665 1995 */ -19,
/* 666 1998 */ -19,
/* 667 2001 */ -18,
/* 668 2004 */ -18,
/* 669 2007 */ -17,
/* 670 2010 */ -17,
/* 671 2013 */ -16,
/* 672 2016 */ -16,
/* 673 2019 */ -15,
/* 674 2022 */ -14,
/* 675 2025 */ -14,
/* 676 2028 */ -13,
/* 677 2031 */ -12,
/* 678 2034 */ -11,
/* 679 2037 */ -10,
/* 680 2040 */ -9,
/* 681 2043 */ -9,
/* 682 2046 */ -8,
/* 683 2049 */ -7,
/* 684 2052 */ -6,
/* 685 2055 */ -5,
/* 686 2058 */ -4,
/* 687 2061 */ -3,
/* 688 2064 */ -2,
/* 689 2067 */ -1,
/* 690 2070 */ 0,
/* 691 2073 */ 1,
/* 692 2076 */ 2,
/* 693 2079 */ 3,
/* 694 2082 */ 4,
/* 695 2085 */ 5,
/* 696 2088 */ 6,
/* 697 2091 */ 7,
/* 698 2094 */ 8,
/* 699 2097 */ 9,
/* 700 2100 */ 9,
/* 701 2103 */ 10,
/* 702 2106 */ 11,
/* 703 2109 */ 12,
/* 704 2112 */ 13,
/* 705 2115 */ 14,
/* 706 2118 */ 14,
/* 707 2121 */ 15,
/* 708 2124 */ 16,
/* 709 2127 */ 16,
/* 710 2130 */ 17,
/* 711 2133 */ 17,
/* 712 2136 */ 18,
/* 713 2139 */ 18,
/* 714 2142 */ 19,
/* 715 2145 */ 19,
/* 716 2148 */ 19,
/* 717 2151 */ 19,
/* 718 2154 */ 19,
/* 719 2157 */ 19,
};
#endif /* ___COSTABLE_H___ */
