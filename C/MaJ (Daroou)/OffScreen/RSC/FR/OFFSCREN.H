/* Indices du fichier ressource pour OFFSCREN: */

#define DL_TITRE_FENETRE 0   /* Formulaire/Dialogue: */
#define TITRE_INFO       2   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_PREFERENCE 3   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_LAUNCH     4   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_OFFSCREEN  5   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_STATS      6   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_SPRITE_OFF 7   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_ADRESSE    8   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_BENCH      9   /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_INFO_SYS   10  /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_PIXEL_XFMT 11  /* STRING dans l'arbre DL_TITRE_FENETRE */
#define TITRE_SAVE_STATS 14  /* STRING dans l'arbre DL_TITRE_FENETRE */

#define DL_INFO_PRG      1   /* Formulaire/Dialogue: */
#define INFO_CDR_TITRE   3   /* BOX dans l'arbre DL_INFO_PRG */
#define INFO_PRG_VERSION 9   /* STRING dans l'arbre DL_INFO_PRG */
#define INFO_PRG_DATE    10  /* STRING dans l'arbre DL_INFO_PRG */
#define INFO_DBUG        11  /* TEXT dans l'arbre DL_INFO_PRG */
#define INFO_COMPIL_DATE 13  /* TEXT dans l'arbre DL_INFO_PRG */
#define INFO_GCC_VER     15  /* TEXT dans l'arbre DL_INFO_PRG */
#define INFO_COEUR_VER   17  /* TEXT dans l'arbre DL_INFO_PRG */
#define INFO_CPU_TARGET  19  /* TEXT dans l'arbre DL_INFO_PRG */
#define INFO_GEMLIB_VER  21  /* TEXT dans l'arbre DL_INFO_PRG */

#define DL_ICON_INFO     2   /* Formulaire/Dialogue: */
#define ICN_INFO_FOND    0   /* BOX dans l'arbre DL_ICON_INFO */
#define ICN_INFO_TEXT    1   /* STRING dans l'arbre DL_ICON_INFO */

#define DL_OPT_PREF      3   /* Formulaire/Dialogue: */
#define PREF_SAVE_WINPOS 1   /* BUTTON dans l'arbre DL_OPT_PREF */
#define PREF_SAVE_CONFIG 2   /* BUTTON dans l'arbre DL_OPT_PREF */
#define PREF_SAVE_AUTO   3   /* BUTTON dans l'arbre DL_OPT_PREF */
#define PREF_CLOSE_QUIT  4   /* BUTTON dans l'arbre DL_OPT_PREF */
#define PREF_POPUP_LANG  6   /* BOXTEXT dans l'arbre DL_OPT_PREF */

#define POPUP_PREF_LANG  4   /* Formulaire/Dialogue: */
#define PLANG_FOND       0   /* BOX dans l'arbre POPUP_PREF_LANG */
#define PLANG_ANGLAIS    1   /* TEXT dans l'arbre POPUP_PREF_LANG */
#define PLANG_ALLEMAND   2   /* TEXT dans l'arbre POPUP_PREF_LANG */
#define PLANG_FRANCAIS   3   /* TEXT dans l'arbre POPUP_PREF_LANG */
#define PLANG_ESPAGNOL   4   /* TEXT dans l'arbre POPUP_PREF_LANG */
#define PLANG_ITALIEN    5   /* TEXT dans l'arbre POPUP_PREF_LANG */
#define PLANG_SUEDOIS    6   /* TEXT dans l'arbre POPUP_PREF_LANG */
#define PLANG_UKRAINIEN  7   /* TEXT dans l'arbre POPUP_PREF_LANG */
#define PLANG_RUSSE      8   /* TEXT dans l'arbre POPUP_PREF_LANG */

#define DL_ICON_PREF     5   /* Formulaire/Dialogue: */
#define ICN_PREF_FOND    0   /* BOX dans l'arbre DL_ICON_PREF */
#define ICN_PREF_TEXT    1   /* TEXT dans l'arbre DL_ICON_PREF */

#define DL_ALERTE_COEUR  6   /* Formulaire/Dialogue: */
#define ALC_NO_WINDOWS   1   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_NORAMCONFIG  2   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_NO_INF_FILE  3   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_NO_MORE_RAM  4   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_ERR_SAVE_INF 5   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_ERR_NOFUNC   6   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_AV_BAD_FILE  7   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_AV_NO_FILE   8   /* STRING dans l'arbre DL_ALERTE_COEUR */
#define ALC_BAD_CONFIG   9   /* STRING dans l'arbre DL_ALERTE_COEUR */

#define BARRE_MENU       7   /* Menu: */
#define MN_INFO_PRG      9   /* STRING dans l'arbre BARRE_MENU */
#define MN_SAVE_STATS    18  /* STRING dans l'arbre BARRE_MENU */
#define MN_QUITTER       20  /* STRING dans l'arbre BARRE_MENU */
#define MN_OFFSCREEN     22  /* STRING dans l'arbre BARRE_MENU */
#define MN_SPRITE_OFFSCR 23  /* STRING dans l'arbre BARRE_MENU */
#define MN_STATISTIQUE   25  /* STRING dans l'arbre BARRE_MENU */
#define MN_ADRESSE       26  /* STRING dans l'arbre BARRE_MENU */
#define MN_INFO          27  /* STRING dans l'arbre BARRE_MENU */
#define MN_BENCH         29  /* STRING dans l'arbre BARRE_MENU */
#define MN_PREFERENCE    31  /* STRING dans l'arbre BARRE_MENU */
#define MN_SAUVER_CONFIG 33  /* STRING dans l'arbre BARRE_MENU */

#define DL_ALERTE_APPLI  8   /* Formulaire/Dialogue: */
#define ALT_ERR_DATAFILE 1   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_DATA_PTH 2   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_INCONNU  3   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_F_EXIST  4   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_OPEN_TGA 5   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_SURFACE  6   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_BAD_REZ_256C 7   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_REZ_LIT  8   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_MODESTRM 9   /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_MODETTRM 10  /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_ANIMSIZE 11  /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ERR_ANIM_RAM 12  /* STRING dans l'arbre DL_ALERTE_APPLI */
#define ALT_ANIM_LOAD    13  /* STRING dans l'arbre DL_ALERTE_APPLI */

#define DL_PIXEL_XFORMAT 9   /* Formulaire/Dialogue: */
#define PIXEL_XFMT_MIRE1 7   /* BOX dans l'arbre DL_PIXEL_XFORMAT */
#define PIXEL_XFMT_MIRE2 8   /* BOX dans l'arbre DL_PIXEL_XFORMAT */
#define PIXEL_XFMT_MIRE3 9   /* BOX dans l'arbre DL_PIXEL_XFORMAT */
#define PIXEL_XFMT_MIRE4 10  /* BOX dans l'arbre DL_PIXEL_XFORMAT */
#define PIXEL_XFMT_MIRE5 11  /* BOX dans l'arbre DL_PIXEL_XFORMAT */

#define DL_LAUNCH        10  /* Formulaire/Dialogue: */
#define BOX_LAUNCH       2   /* BOX dans l'arbre DL_LAUNCH */
#define STRING_LAUNCH    3   /* STRING dans l'arbre DL_LAUNCH */

#define DL_LAUNCH_TEXTE  11  /* Formulaire/Dialogue: */
#define LH_INIT_BOING    2   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_VERIF_FICHIER 3   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_CHARGE_ANIM   4   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_OUVRE_TGA_LDG 5   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_INIT_SURFACE1 6   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_INIT_SURFACE2 7   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_INIT_SURFACE3 8   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_INIT_SURFACE4 9   /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_INIT_SURFACE5 10  /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_FERME_TGA_LDG 11  /* STRING dans l'arbre DL_LAUNCH_TEXTE */
#define LH_INIT_TERMINE  12  /* STRING dans l'arbre DL_LAUNCH_TEXTE */

#define DL_ICN_OFFSCR    12  /* Formulaire/Dialogue: */
#define ICN_FD_OFFSCREEN 0   /* BOX dans l'arbre DL_ICN_OFFSCR */
#define ICN_TX_OFFSCREEN 1   /* TEXT dans l'arbre DL_ICN_OFFSCR */

#define DL_STATS         13  /* Formulaire/Dialogue: */
#define RB_STAT_OFF_VDI  2   /* BUTTON dans l'arbre DL_STATS */
#define RB_STAT_OFF_VRAM 3   /* BUTTON dans l'arbre DL_STATS */
#define RB_STAT_OFF_STRM 4   /* BUTTON dans l'arbre DL_STATS */
#define RB_STAT_OFF_TTRM 5   /* BUTTON dans l'arbre DL_STATS */
#define RB_STAT_CT60_VRM 6   /* BUTTON dans l'arbre DL_STATS */
#define BT_STATS_BEE_MN  7   /* BUTTON dans l'arbre DL_STATS */
#define FD_STATS_NB_BEE  8   /* BOX dans l'arbre DL_STATS */
#define TXT_STATS_NB_BEE 9   /* STRING dans l'arbre DL_STATS */
#define BT_STATS_BEE_PL  10  /* BUTTON dans l'arbre DL_STATS */
#define BT_STATS_DEC_MN  11  /* BUTTON dans l'arbre DL_STATS */
#define FD_STATS_DECAL   12  /* BOX dans l'arbre DL_STATS */
#define TXT_STATS_DECAL  13  /* STRING dans l'arbre DL_STATS */
#define BT_STATS_DEC_PL  14  /* BUTTON dans l'arbre DL_STATS */
#define FD_STAT_FPS      17  /* BOX dans l'arbre DL_STATS */
#define TXT_STAT_FPS     18  /* STRING dans l'arbre DL_STATS */
#define FD_STAT_FRAME    22  /* BOX dans l'arbre DL_STATS */
#define TXT_STAT_FRAME   23  /* STRING dans l'arbre DL_STATS */
#define FD_STAT_REDRAW   25  /* BOX dans l'arbre DL_STATS */
#define TXT_STAT_REDRAW  26  /* STRING dans l'arbre DL_STATS */
#define FD_STAT_TOTALE   28  /* BOX dans l'arbre DL_STATS */
#define TXT_STAT_TOTALE  29  /* STRING dans l'arbre DL_STATS */
#define FD_STAT_TRANS    32  /* BOX dans l'arbre DL_STATS */
#define TXT_STAT_TRANS   33  /* STRING dans l'arbre DL_STATS */

#define DL_ICN_STATS     14  /* Formulaire/Dialogue: */
#define ICN_STATS_FOND   0   /* BOX dans l'arbre DL_ICN_STATS */
#define ICN_STATS_TEXT   1   /* TEXT dans l'arbre DL_ICN_STATS */

#define DL_ADRESSE       15  /* Formulaire/Dialogue: */
#define AD_FOND_ADRESSE  0   /* BOX dans l'arbre DL_ADRESSE */
#define AD_POPUP         1   /* BOXTEXT dans l'arbre DL_ADRESSE */
#define AD_TITRE         3   /* TEXT dans l'arbre DL_ADRESSE */
#define AD_OFFSCREEN     5   /* TEXT dans l'arbre DL_ADRESSE */
#define AD_FOND          7   /* TEXT dans l'arbre DL_ADRESSE */
#define AD_BAR1          9   /* TEXT dans l'arbre DL_ADRESSE */
#define AD_BEE           23  /* TEXT dans l'arbre DL_ADRESSE */
#define AD_BEE_MASK      25  /* TEXT dans l'arbre DL_ADRESSE */

#define POPUP_ADRESSE    16  /* Formulaire/Dialogue: */
#define POPUP_ADR_FOND   0   /* BOX dans l'arbre POPUP_ADRESSE */
#define POP_MODE_AD_1    1   /* TEXT dans l'arbre POPUP_ADRESSE */
#define POP_MODE_AD_2    2   /* TEXT dans l'arbre POPUP_ADRESSE */
#define POP_MODE_AD_3    3   /* TEXT dans l'arbre POPUP_ADRESSE */
#define POP_MODE_AD_4    4   /* TEXT dans l'arbre POPUP_ADRESSE */

#define DL_ICN_ADRESSE   17  /* Formulaire/Dialogue: */
#define ICN_FD_ADRESSE   0   /* BOX dans l'arbre DL_ICN_ADRESSE */
#define ICN_TX_ADRESSE   1   /* TEXT dans l'arbre DL_ICN_ADRESSE */

#define DL_BENCH         18  /* Formulaire/Dialogue: */
#define BC_FOND          0   /* BOX dans l'arbre DL_BENCH */
#define BC_FOND_RAM_ECR  1   /* BOX dans l'arbre DL_BENCH */
#define BC_STRAM_ECR_R   4   /* STRING dans l'arbre DL_BENCH */
#define BC_STRAM_ECR     5   /* BUTTON dans l'arbre DL_BENCH */
#define BC_TTRAM_ECR_R   8   /* STRING dans l'arbre DL_BENCH */
#define BC_TTRAM_ECR     9   /* BUTTON dans l'arbre DL_BENCH */
#define BC_OFF_ECR_R     12  /* STRING dans l'arbre DL_BENCH */
#define BC_OFF_ECR       13  /* BUTTON dans l'arbre DL_BENCH */
#define BC_CT60_ECR_R    16  /* STRING dans l'arbre DL_BENCH */
#define BC_CT060_ECR     17  /* BUTTON dans l'arbre DL_BENCH */
#define BC_FOND_RAM_RAM  18  /* BOX dans l'arbre DL_BENCH */
#define BC_STRAM_STRAM_R 21  /* STRING dans l'arbre DL_BENCH */
#define BC_STRAM_STRAM   22  /* BUTTON dans l'arbre DL_BENCH */
#define BC_TTRAM_TTRAM_R 25  /* STRING dans l'arbre DL_BENCH */
#define BC_TTRAM_TTRAM   26  /* BUTTON dans l'arbre DL_BENCH */
#define BC_OFF_OFF_R     29  /* STRING dans l'arbre DL_BENCH */
#define BC_OFF_OFF       30  /* BUTTON dans l'arbre DL_BENCH */
#define BC_OFF_OFF2_R    33  /* STRING dans l'arbre DL_BENCH */
#define BC_OFF_OFF2      34  /* BUTTON dans l'arbre DL_BENCH */
#define BC_ECR_ECR_R     37  /* STRING dans l'arbre DL_BENCH */
#define BC_ECR_ECR       38  /* BUTTON dans l'arbre DL_BENCH */
#define BC_CT60_CT60_R   41  /* STRING dans l'arbre DL_BENCH */
#define BC_CT060_CT060   42  /* BUTTON dans l'arbre DL_BENCH */
#define BC_ALL_TEST      43  /* BUTTON dans l'arbre DL_BENCH */

#define DL_ICN_BENCH     19  /* Formulaire/Dialogue: */
#define ICN_FD_BENCH     0   /* BOX dans l'arbre DL_ICN_BENCH */
#define ICN_TX_BENCH     1   /* TEXT dans l'arbre DL_ICN_BENCH */

#define DL_INFO_SYSTEM   20  /* Formulaire/Dialogue: */
#define INFO_COOKIE_EDDI 4   /* STRING dans l'arbre DL_INFO_SYSTEM */
#define INFO_COOKIE_NVDI 6   /* STRING dans l'arbre DL_INFO_SYSTEM */
#define INFO_COOKIE_CT60 8   /* STRING dans l'arbre DL_INFO_SYSTEM */
#define INFO_COOKIE_SUPV 10  /* STRING dans l'arbre DL_INFO_SYSTEM */
#define INFO_COOKIE_PCI  12  /* STRING dans l'arbre DL_INFO_SYSTEM */
#define INFO_SYS_REZ     15  /* STRING dans l'arbre DL_INFO_SYSTEM */
#define INFO_VRAM_FREE   18  /* STRING dans l'arbre DL_INFO_SYSTEM */
#define INFO_SYS_ATI     21  /* STRING dans l'arbre DL_INFO_SYSTEM */

#define DL_ICN_INFO      21  /* Formulaire/Dialogue: */
#define ICN_FD_INFO      0   /* BOX dans l'arbre DL_ICN_INFO */
#define ICN_TX_INFO      1   /* TEXT dans l'arbre DL_ICN_INFO */
