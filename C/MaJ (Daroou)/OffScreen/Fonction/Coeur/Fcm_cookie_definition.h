
#ifndef __COOKIE_DEFINITION__
#define __COOKIE_DEFINITION__




#define COOKIE__AKP		0x5F414B50UL
#define COOKIE__MCH		0x5F4D4348UL
#define COOKIE__CPU		0x5F435055UL
#define COOKIE__SND		0x5F534E44UL
#define COOKIE__MIL		0x5F4D494CUL


#define COOKIE_EdDI		0x45644449UL
#define COOKIE_NVDI		0x4E564449UL

#define COOKIE_GSXB		0x47535842UL
#define COOKIE_McSn		0x4D63536EUL
#define COOKIE_STFA		0x53544641UL


#define COOKIE__PCI		0x5F504349UL
#define COOKIE_XPCI		0x58504349UL


#define COOKIE_MagX		0x4D616758UL
#define COOKIE_MiNT		0x4D694E54UL
#define COOKIE_MgPC		0x4D675043UL


#define COOKIE_CT60		0x43543630UL
#define COOKIE_SupV		0x53757056UL



#define COOKIE_LDGM		0x4C44474DUL




#endif  /* __COOKIE_DEFINITION__ */

