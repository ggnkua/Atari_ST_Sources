[EQUIVALENT] KEYWORD.C
