

#define COOKIE_EdDI		0x45644449

#define COOKIE__CPU		0x5F435055
#define COOKIE__PCI		0x5F504349
#define COOKIE__AKP		0x5F414B50

#define COOKIE_MAGX		0x4D616758
#define COOKIE_MINT		0x4D694E54

#define COOKIE_LDGM		0x4C44674D

