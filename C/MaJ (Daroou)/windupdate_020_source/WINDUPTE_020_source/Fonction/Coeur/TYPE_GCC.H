/* --------------------------------------------------------------- */
/* CrВe le: 09.06.2014                                             */
/* modification le: 09.06.2014                                     */
/*******************************************************************/


#ifndef  __TYPE_GCC__
 #define __TYPE_GCC__


 /* Quelques DВfines */
 #ifndef	TRUE
  #define	TRUE	(1)
 #endif

 #ifndef FALSE
  #define	FALSE	(0)
 #endif

 #ifndef  CRLF
 #define	CRLF	"\015\012"
 #endif


 #ifndef int32
  #define int32	long
 #endif
 #ifndef uint32
  #define uint32 unsigned long
 #endif
 #ifndef int16
  #define int16	short
 #endif
 #ifndef uint16
  #define uint16 unsigned short
 #endif
 #ifndef int8
  #define int8	char
 #endif
 #ifndef uint8
  #define uint8	unsigned char
 #endif


 #ifndef WORD
  #define WORD	short
 #endif

 #ifndef UWORD
  #define UWORD	unsigned short
 #endif

 #ifndef LONG
  #define LONG	long
 #endif

 #ifndef ULONG
  #define ULONG	unsigned long
 #endif

 #ifndef INT
  #define INT		int
 #endif

 #ifndef INT16
  #define INT16	short
 #endif

 #ifndef CHAR
  #define CHAR	char
 #endif

 #ifndef UCHAR
  #define UCHAR	unsigned char
 #endif

 #ifndef UBYTE
  #define UBYTE	unsigned char
 #endif

 #ifndef BYTE
  #define BYTE	char
 #endif

 #ifndef VOID
  #define VOID	void
 #endif









#endif	/* #ifndef __TYPE_GCC__ */


