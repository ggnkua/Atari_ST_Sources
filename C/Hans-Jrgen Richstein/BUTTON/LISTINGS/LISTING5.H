/* BUT_DSGN.H mit den Definitionen  */

#define MAINFORM 0  /* Formula/Dialog */
#define BUTNAUS  5  /* IMAGE in Baum MAINFORM */
#define BUTNEIN  6  /* IMAGE in Baum MAINFORM */
#define AUSTEXT  7  /* STRING in Baum MAINFORM */
#define EINTEXT  8  /* STRING in  MAINFORM */
#define TESTAREA 9  /* IMAGE in  MAINFORM */
#define TEST     10 /* STRING in  MAINFORM */
#define SWTCHNME 13 /* FTEXT in  MAINFORM */
#define NEWCODE  14 /* BUTTON in  MAINFORM */
#define APPEND   15 /* BUTTON in  MAINFORM */
#define SAVEIMG  16 /* BUTTON in  MAINFORM */
#define LOADIMG  17 /* BUTTON in  MAINFORM */
#define ENDE     18 /* BUTTON in  MAINFORM */
#define RASTER   19 /* BOX in  MAINFORM */
#define ORSWITCH 21 /* BUTTON in  MAINFORM */
#define MOVEUP   22 /* BOXCHAR in  MAINFORM */
#define MOVEDOWN 23 /* BOXCHAR in  MAINFORM */
#define MOVELEFT 24 /* BOXCHAR in  MAINFORM */
#define MOVERGHT 25 /* BOXCHAR in  MAINFORM */
#define CLEARALL 26 /* BUTTON in  MAINFORM */
