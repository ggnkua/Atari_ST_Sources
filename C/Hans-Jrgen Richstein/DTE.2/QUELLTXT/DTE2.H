/*****************************************/
/* RSC-File Headerdatei                  */
/* erzeugt durch den LST - H - Konverter */
/* (c) Michael Haar Juli 1993            */
/*****************************************/

#define HAUPTMEN 0 /* RSC_TREE */
#define PRGINFO 1 /* RSC_TREE */
#define HISCOREB 2 /* RSC_TREE */
#define ALLGEMEI 3 /* RSC_TREE */
#define SPIELANL 4 /* RSC_TREE */
#define NAMENEIN 5 /* RSC_TREE */
#define SCHWIERB 6 /* RSC_TREE */
#define GESCHWIB 7 /* RSC_TREE */
#define INFOA 9 /* Obj in #0 */
#define PRGENDE 18 /* Obj in #0 */
#define NEUESSPI 20 /* Obj in #0 */
#define SPIELABB 22 /* Obj in #0 */
#define HIGHSCOR 24 /* Obj in #0 */
#define SCHWIERI 26 /* Obj in #0 */
#define GESCHWIN 27 /* Obj in #0 */
#define ALLGHELP 29 /* Obj in #0 */
#define ANLEITHE 30 /* Obj in #0 */
#define PUNKTE1 13 /* Obj in #2 */
#define NAME1 23 /* Obj in #2 */
#define NAMESTR 2 /* Obj in #5 */
#define SCHWER1 2 /* Obj in #6 */
#define GESCHWI1 2 /* Obj in #7 */
