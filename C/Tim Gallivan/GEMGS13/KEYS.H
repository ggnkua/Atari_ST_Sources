/*
 * Key definitions.
 */

#define	ALT_R	0x1300
#define	ALT_I	0x1700
#define	ALT_O	0x1800
#define	ALT_Q	0x1000
#define	ALT_G	0x2200
#define	ALT_C	0x2e00
#define	ALT_P	0x1900
