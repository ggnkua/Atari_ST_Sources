#define TREE1 0  	/* TREE */
#define IMAGE 10  	/* OBJECT in TREE #0 */
#define TSTRING 11  	/* OBJECT in TREE #0 */
