#define CARDMENU 0  	/* TREE */
#define INFOBOX 1  	/* TREE */
#define QUITRUSR 2  	/* TREE */
#define WHICHMRK 3  	/* TREE */
#define SHOWMODE 4  	/* TREE */
#define FUNKEYS 5  	/* TREE */
#define SRCHNAME 6  	/* TREE */
#define SRCHTYPE 7  	/* TREE */
#define DOFAST 8  	/* TREE */
#define SRCCOLOR 9  	/* TREE */
#define CARDINFO 9  	/* OBJECT in TREE #0 */
#define LOADCARD 18  	/* OBJECT in TREE #0 */
#define MERGCARD 19  	/* OBJECT in TREE #0 */
#define MERGEAT 20  	/* OBJECT in TREE #0 */
#define SAVECARD 22  	/* OBJECT in TREE #0 */
#define SAVEMARK 23  	/* OBJECT in TREE #0 */
#define CLERCARD 25  	/* OBJECT in TREE #0 */
#define QUITCARD 27  	/* OBJECT in TREE #0 */
#define SRCHCARD 29  	/* OBJECT in TREE #0 */
#define FASTSRCH 30  	/* OBJECT in TREE #0 */
#define SORT 31  	/* OBJECT in TREE #0 */
#define COMPRESS 32  	/* OBJECT in TREE #0 */
#define GETMARK 34  	/* OBJECT in TREE #0 */
#define MARKCARD 35  	/* OBJECT in TREE #0 */
#define UNMARK 36  	/* OBJECT in TREE #0 */
#define UNMKALL 37  	/* OBJECT in TREE #0 */
#define CUTCARD 39  	/* OBJECT in TREE #0 */
#define PASTCARD 40  	/* OBJECT in TREE #0 */
#define DELTCARD 42  	/* OBJECT in TREE #0 */
#define SLCTMARK 44  	/* OBJECT in TREE #0 */
#define SORTATOZ 46  	/* OBJECT in TREE #0 */
#define SORTZTOA 47  	/* OBJECT in TREE #0 */
#define LOOKRITE 49  	/* OBJECT in TREE #0 */
#define LOOKLEFT 50  	/* OBJECT in TREE #0 */
#define ABSOLUTE 51  	/* OBJECT in TREE #0 */
#define SHOWFUNK 53  	/* OBJECT in TREE #0 */
#define PRNTUSNG 55  	/* OBJECT in TREE #0 */
#define PRNTCARD 56  	/* OBJECT in TREE #0 */
#define PRINTALL 57  	/* OBJECT in TREE #0 */
#define YESQUIT 3  	/* OBJECT in TREE #2 */
#define MARK1 3  	/* OBJECT in TREE #3 */
#define MARK2 4  	/* OBJECT in TREE #3 */
#define MARK3 5  	/* OBJECT in TREE #3 */
#define MARK4 6  	/* OBJECT in TREE #3 */
#define MARK5 7  	/* OBJECT in TREE #3 */
#define MARK6 8  	/* OBJECT in TREE #3 */
#define CNCLMARK 9  	/* OBJECT in TREE #3 */
#define ORMODE 2  	/* OBJECT in TREE #4 */
#define XORMODE 5  	/* OBJECT in TREE #4 */
#define ANDMODE 8  	/* OBJECT in TREE #4 */
#define SRMDABOR 11  	/* OBJECT in TREE #4 */
#define EDITBOX 3  	/* OBJECT in TREE #6 */
#define SRCHOK 7  	/* OBJECT in TREE #6 */
#define SRCHABRT 8  	/* OBJECT in TREE #6 */
#define GRTRSRCH 8  	/* OBJECT in TREE #7 */
#define DONESRCH 9  	/* OBJECT in TREE #7 */
#define ABRTSRCH 10  	/* OBJECT in TREE #7 */
#define LESSSRCH 11  	/* OBJECT in TREE #7 */
#define EQUALSRC 12  	/* OBJECT in TREE #7 */
#define FASTBOX 1  	/* OBJECT in TREE #8 */
#define LESSCOLR 8  	/* OBJECT in TREE #9 */
#define EQULCOLR 9  	/* OBJECT in TREE #9 */
#define GRTRCOLR 10  	/* OBJECT in TREE #9 */
#define DONECOLR 11  	/* OBJECT in TREE #9 */
#define ABRTCOLR 12  	/* OBJECT in TREE #9 */

#define T0OBJ 0
#define T1OBJ 58
#define T2OBJ 73
#define T3OBJ 78
#define T4OBJ 88
#define T5OBJ 101
#define T6OBJ 114
#define T7OBJ 123
#define T8OBJ 136
#define T9OBJ 138
#define FREEBB 1
#define FREEIMG 1
#define FREESTR 149

