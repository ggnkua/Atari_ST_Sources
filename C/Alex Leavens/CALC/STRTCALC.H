#define CALCPAD 0  	/* TREE */
#define ABOUTCAL 1  	/* TREE */
#define FILERROR 2  	/* TREE */
#define CDISPLAY 1  	/* OBJECT in TREE #0 */
#define LEARN 2  	/* OBJECT in TREE #0 */
#define KGOTO 3  	/* OBJECT in TREE #0 */
#define SUBROUTI 4  	/* OBJECT in TREE #0 */
#define RESET 5  	/* OBJECT in TREE #0 */
#define RUNSTOP 6  	/* OBJECT in TREE #0 */
#define EE 7  	/* OBJECT in TREE #0 */
#define KSEVENA 8  	/* OBJECT in TREE #0 */
#define KFOURA 9  	/* OBJECT in TREE #0 */
#define KONEA 10  	/* OBJECT in TREE #0 */
#define KZEROA 11  	/* OBJECT in TREE #0 */
#define OPENPARN 12  	/* OBJECT in TREE #0 */
#define KEIGHTA 13  	/* OBJECT in TREE #0 */
#define KFIVEA 14  	/* OBJECT in TREE #0 */
#define KTWOA 15  	/* OBJECT in TREE #0 */
#define KPOINT 16  	/* OBJECT in TREE #0 */
#define CLOSPARN 17  	/* OBJECT in TREE #0 */
#define KNINEA 18  	/* OBJECT in TREE #0 */
#define KSIXA 19  	/* OBJECT in TREE #0 */
#define KTHREEA 20  	/* OBJECT in TREE #0 */
#define PLUSMINU 21  	/* OBJECT in TREE #0 */
#define DIVIDED 22  	/* OBJECT in TREE #0 */
#define TIMES 23  	/* OBJECT in TREE #0 */
#define MINUS 24  	/* OBJECT in TREE #0 */
#define KPLUS 25  	/* OBJECT in TREE #0 */
#define EQUALS 26  	/* OBJECT in TREE #0 */
#define HAPPY 27  	/* OBJECT in TREE #0 */
#define KEYA 28  	/* OBJECT in TREE #0 */
#define SECOND 29  	/* OBJECT in TREE #0 */
#define LNX 30  	/* OBJECT in TREE #0 */
#define XXCHANGT 31  	/* OBJECT in TREE #0 */
#define KEYB 32  	/* OBJECT in TREE #0 */
#define INVERSE 33  	/* OBJECT in TREE #0 */
#define LOGX 34  	/* OBJECT in TREE #0 */
#define STO 35  	/* OBJECT in TREE #0 */
#define CLEAR 37  	/* OBJECT in TREE #0 */
#define CE 38  	/* OBJECT in TREE #0 */
#define CALCOFF 39  	/* OBJECT in TREE #0 */
#define KEYC 40  	/* OBJECT in TREE #0 */
#define KEYSIN 41  	/* OBJECT in TREE #0 */
#define XSQUARED 42  	/* OBJECT in TREE #0 */
#define RCL 43  	/* OBJECT in TREE #0 */
#define KEYD 44  	/* OBJECT in TREE #0 */
#define KEYCOS 45  	/* OBJECT in TREE #0 */
#define ROOTX 46  	/* OBJECT in TREE #0 */
#define SUM 47  	/* OBJECT in TREE #0 */
#define KEYE 48  	/* OBJECT in TREE #0 */
#define KEYTAN 49  	/* OBJECT in TREE #0 */
#define ONEOVERX 50  	/* OBJECT in TREE #0 */
#define YTOTHEX 51  	/* OBJECT in TREE #0 */

#define T0OBJ 0
#define T1OBJ 52
#define T2OBJ 68
#define FREEBB 51
#define FREEIMG 51
#define FREESTR 21

