/*
 * CALCSTRN.C
 *
 */

#include "calcdefn.h"
#include "strtcalc.h"

int	label_offset[]={
 KEYA,
 KEYA,
 KEYB,
 KEYB,
 KEYC,
 KEYC,
 KEYD,
 KEYD,
 KEYE,
 KEYE,
 KEYSIN,
 KEYCOS,
 KEYTAN,
 LNX,
 LOGX,
 XSQUARED,
 ROOTX,
 ONEOVERX,
 XXCHANGT,
 STO,
 RCL,
 SUM,
 YTOTHEX,
 EQUALS,
 KPLUS,
 MINUS,
 TIMES,
 DIVIDED,
 PLUSMINU,
 KPOINT,
 KZEROA,
 KONEA,
 KTWOA,
 KTHREEA,
 KFOURA,
 KFIVEA,
 KSIXA,
 KSEVENA,
 KEIGHTA,
 KNINEA,
 OPENPARN,
 CLOSPARN,
 EE
};

char   *operands[]={
	"NO_OP",
	"RN_ST",
	"STFLG",
	"SUBRT",
	"LABEL",
	"GO TO",
	"PAUSE",
	"XEQT ",
	"XNET ",
	"XLTT ",
	"XGTT ",
	"IFFLG",
	" DSZ ",
	"A_LBL",
	"B_LBL",
	"C_LBL",
	"D_LBL",
	"E_LBL",
	"A'LBL",
	"B'LBL",
	"C'LBL",
	"D'LBL",
	"E'LBL",
	"IFNOT",
	"RETRN",
	"CRFLG",
	"DSNZ ",
	"XLET ",
	"XGET "
};

char	*oper_codes[]={
	"  0  ",
	"  1  ",
	"  2  ",
	"  3  ",
	"  4  ",
	"  5  ",
	"  6  ",
	"  7  ",
	"  8  ",
	"  9  ",
	" EE  ",
	"  (  ",
	"  )  ",
	"  .  ",
	" +/- ",
	"  /  ",
	"  x  ",
	"  -  ",
	"  +  ",
	" 2nd ",
	" INV ",
	" SIN ",
	" COS ",
	" TAN ",
	" lnx ",
	" log ",
	" x^2 ",
	"sqrtx",
	" 1/x ",
	"x<->t",
	" STO ",
	" RCL ",
	" SUM ",
	" y^x ",
	"CLEAR",
	" CE  ",
	"  =  ",
	"NO_OP",
	"  A  ",
	"  A' ",
	"  B  ",
	"  B' ",
	"  C  ",
	"  C' ",
	"  D  ",
	"  D' ",
	"  E  ",
	"  E' "
};

char	*label_display[]={
	"  A  ",
	"  A' ",
	"  B  ",
	"  B' ",
	"  C  ",
	"  C' ",
	"  D  ",
	"  D' ",
	"  E  ",
	"  E' ",
	" SIN ",
	" COS ",
	" TAN ",
	" LNX ",
	" LOG ",
	" X^2 ",
	"SQRTX",
	" 1/X ",
	"X<->T",
	" STO ",
	" RCL ",
	" SUM ",
	" Y^X ",
	"  =  ",
	"  +  ",
	"  -  ",
	"  X  ",
	"  /  ",
	" +/- ",
	"  .  ",
	"  0  ",
	"  1  ",
	"  2  ",
	"  3  ",
	"  4  ",
	"  5  ",
	"  6  ",
	"  7  ",
	"  8  ",
	"  9  ",
	"  (  ",
	"  )  ",
	"  EE "
};
	
