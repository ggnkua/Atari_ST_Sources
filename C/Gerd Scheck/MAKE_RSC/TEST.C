#define T0OBJ 0
#define T1OBJ 22
#define FREEBB 1
#define FREEIMG 3
#define FREESTR 22

BYTE *rs_strings[] = {
" Desk ",
"  Datei ",
"  Info...",
"--------------------",
"  Desk Accessory 1  ",
"  Desk Accessory 2  ",
"  Desk Accessory 3  ",
"  Desk Accessory 4  ",
"  Desk Accessory 5  ",
"  Desk Accessory 6  ",
"  ”ffnen... ",
"-----------------",
"  sichern ",
"  sichern als... ",
"-----------------",
"  Ende ",
"Dies ist eine Testdialogbox",
"______",
"EDIT:______",
"XXXXXX",
"",
"OK",
"[1][Alertline 1|Alertline 2][OK|CANCEL]"};

WORD IMAG0[] = {
0xFF, 0xFFFF, 0xFE00, 0xFF, 
0xFFFF, 0xFE00, 0xFF, 0xFFFF, 
0xFE00, 0xFF, 0xFFFF, 0xFE00, 
0xFF, 0xFFFF, 0xFE00, 0xFF, 
0xFFFF, 0xFE00, 0xFF, 0xFFFF, 
0xFE00, 0xFF, 0xFFFF, 0xFE00, 
0xFF, 0xFFFF, 0xFE00, 0xFF, 
0xFFFF, 0xFE00, 0xFF, 0xFFFF, 
0xFE00, 0xFF, 0xFFFF, 0xFE00, 
0xFF, 0xFFFF, 0xFE00, 0xFF, 
0xFFFF, 0xFE00, 0xFF, 0xFFFF, 
0xFE00, 0xFFF, 0xFFFF, 0xFFF0, 
0xFFF, 0xFFFF, 0xFFF0, 0xFFF, 
0xFFFF, 0xFFF0, 0xFFF, 0xFFFF, 
0xFFF0, 0xFFF, 0xFFFF, 0xFFF0, 
0xFFF, 0xFFFF, 0xFFF0, 0xFFF, 
0xFFFF, 0xFFF0, 0xFFF, 0xFFFF, 
0xFFF0, 0x0, 0x0, 0x0};

WORD IMAG1[] = {
0xFF, 0xFFFF, 0xFE00, 0xC0, 
0x0, 0x600, 0xC0, 0x7FFF, 
0x8600, 0xC0, 0xC000, 0x8600, 
0xC1, 0x4000, 0x8600, 0xC3, 
0xC000, 0x8600, 0xC2, 0x0, 
0x8600, 0xC2, 0x0, 0x8600, 
0xC2, 0x0, 0x8600, 0xC2, 
0x0, 0x8600, 0xC2, 0x0, 
0x8600, 0xC2, 0x0, 0x8600, 
0xC2, 0x0, 0x8600, 0xC2, 
0x0, 0x8600, 0xC2, 0x0, 
0x8600, 0xFC3, 0xFFFF, 0x87F0, 
0xC00, 0x0, 0x30, 0xC1C, 
0xF9F9, 0x8830, 0xC08, 0x8109, 
0x4830, 0xC08, 0x8109, 0x2830, 
0xC1C, 0xF9F9, 0x1830, 0xC00, 
0x0, 0x30, 0xFFF, 0xFFFF, 
0xFFF0, 0x0, 0x0, 0x0};

WORD IMAG2[] = {
0x7FF, 0xFFFF, 0xFF80, 0xC00, 
0x0, 0xC0, 0x183F, 0xF03F, 
0xF060, 0x187F, 0xF860, 0x1860, 
0x187F, 0xF860, 0x1860, 0x187F, 
0xF860, 0x1860, 0x187F, 0xF860, 
0x1860, 0x187F, 0xF860, 0x1860, 
0x187F, 0xF860, 0x1860, 0x187F, 
0xF860, 0x1860, 0x187F, 0xF860, 
0x1860, 0x187F, 0xF860, 0x1860, 
0x187F, 0xF860, 0x1860, 0x187F, 
0xF860, 0x1860, 0x183F, 0xF03F, 
0xF060, 0xC00, 0x0, 0xC0, 
0x7FF, 0xFFFF, 0xFF80, 0x0, 
0x0, 0x0, 0x3F30, 0xC787, 
0x8FE0, 0xC39, 0xCCCC, 0xCC00, 
0xC36, 0xCFCC, 0xF80, 0xC30, 
0xCCCD, 0xCC00, 0x3F30, 0xCCC7, 
0xCFE0, 0x0, 0x0, 0x0};

LONG rs_frstr[] = {
22L};

BITBLK rs_bitblk[] = {
2L, 6, 24, 0, 0, 1};

LONG rs_frimg[] = {
0};

ICONBLK rs_iconblk[] = {
0L, 1L, 20L, 4096,0,0, 0,0,48,24, 0,24,48,8};

TEDINFO rs_tedinfo[] = {
17L, 18L, 19L, 3, 6, 0, 0x1180, 0x0, -1, 7,12};

OBJECT rs_object[] = {
-1, 1, 5, G_IBOX, NONE, NORMAL, 0x0L, 0,0, 80,25,
5, 2, 2, G_BOX, NONE, NORMAL, 0x1100L, 0,0, 80,513,
1, 3, 4, G_IBOX, NONE, NORMAL, 0x0L, 2,0, 14,769,
4, -1, -1, G_TITLE, NONE, NORMAL, 0x0L, 0,0, 6,769,
2, -1, -1, G_TITLE, NONE, NORMAL, 0x1L, 6,0, 8,769,
0, 6, 15, G_IBOX, NONE, NORMAL, 0x0L, 0,769, 80,19,
15, 7, 14, G_BOX, NONE, NORMAL, 0xFF1100L, 2,0, 20,8,
8, -1, -1, G_STRING, NONE, NORMAL, 0x2L, 0,0, 20,1,
9, -1, -1, G_STRING, NONE, DISABLED, 0x3L, 0,1, 20,1,
10, -1, -1, G_STRING, NONE, NORMAL, 0x4L, 0,2, 20,1,
11, -1, -1, G_STRING, NONE, NORMAL, 0x5L, 0,3, 20,1,
12, -1, -1, G_STRING, NONE, NORMAL, 0x6L, 0,4, 20,1,
13, -1, -1, G_STRING, NONE, NORMAL, 0x7L, 0,5, 20,1,
14, -1, -1, G_STRING, NONE, NORMAL, 0x8L, 0,6, 20,1,
6, -1, -1, G_STRING, NONE, NORMAL, 0x9L, 0,7, 20,1,
5, 16, 21, G_BOX, NONE, NORMAL, 0xFF1100L, 8,0, 17,6,
17, -1, -1, G_STRING, NONE, NORMAL, 0xAL, 0,0, 17,1,
18, -1, -1, G_STRING, NONE, DISABLED, 0xBL, 0,1, 17,1,
19, -1, -1, G_STRING, NONE, NORMAL, 0xCL, 0,2, 17,1,
20, -1, -1, G_STRING, NONE, NORMAL, 0xDL, 0,3, 17,1,
21, -1, -1, G_STRING, NONE, DISABLED, 0xEL, 0,4, 17,1,
15, -1, -1, G_STRING, LASTOB, NORMAL, 0xFL, 0,5, 17,1,
-1, 1, 5, G_BOX, NONE, OUTLINED, 0x21100L, 0,0, 36,11,
2, -1, -1, G_STRING, NONE, NORMAL, 0x10L, 4,1, 27,1,
3, -1, -1, G_FBOXTEXT, EDITABLE, NORMAL, 0x0L, 4,3, 11,1,
4, -1, -1, G_ICON, NONE, NORMAL, 0x0L, 5,5, 6,2049,
5, -1, -1, G_IMAGE, NONE, NORMAL, 0x0L, 22,5, 6,2049,
0, -1, -1, G_BUTTON, 0x27, NORMAL, 0x15L, 12,9, 8,1};

LONG rs_trindex[] = {
0L,
22L};

struct foobar {
	WORD	dummy;
	WORD	*image;
	} rs_imdope[] = {
0, &IMAG0[0],
0, &IMAG1[0],
0, &IMAG2[0]};

#define NUM_STRINGS 23
#define NUM_FRSTR 1
#define NUM_IMAGES 3
#define NUM_BB 1
#define NUM_FRIMG 0
#define NUM_IB 1
#define NUM_TI 1
#define NUM_OBS 28
#define NUM_TREE 2

BYTE pname[] = "TEST.RSC";