/*
 *	patchlev.h - variables identifying the version
 *
 *	version defines as: VerLevel.RevLevel.PatchLevel
 *
 *	this is included in version.h, which is included in nroff.h only in
 *	main.
 */

int	VerLevel   = 1;
int	RevLevel   = 1;
int	PatchLevel = 4;

