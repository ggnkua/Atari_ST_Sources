
#ifndef lint
static char *rcsid_reverse_h = "$Id: reverse.h,v 1.0 1991/09/12 20:29:08 rosenkra Exp $";
#endif

/*
 * $Log: reverse.h,v $
 * Revision 1.0  1991/09/12  20:29:08  rosenkra
 * Initial revision
 *
 */

/*
 *	8x16 reverse
 */
short	f8x16rv[] =
{
0xffff,0xffff,0xffff,0xffff,0xff03,0x01c7,0xc7ff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,
0xc7c7,0xffff,0xff81,0x01c7,0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xc7c7,0xc7c7,0xc7c7,0xff81,0xffff,0xffff,0xefff,0xffff,0xfbdf,0xffff,
0xffff,0xfffe,0xffff,0xffff,0xf7ff,0xf3ff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffc3,0xbfc3,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xfff1,
0xf78f,0xff1f,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,
0xff03,0x01c7,0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,
0xc7c7,0xff03,0xfff7,0xdbed,0xefcf,0xe7fb,0xf7ef,0xffff,0xffff,0xfffd,
0xe3f7,0xc3e3,0xf7c1,0xef81,0xc3c3,0xffff,0xfdff,0xbfc3,0xf3f7,0x83e5,
0x8380,0x80e5,0x88c1,0xe08c,0x8f7c,0x38e3,0x81e3,0x83c5,0x8018,0x881c,
0x8888,0x81df,0xdffb,0xffff,0xefff,0x9fff,0xf9ff,0xf3ff,0x9ff7,0xfb9f,
0xc7ff,0xffff,0xffff,0xffff,0xefff,0xffff,0xffff,0xffef,0xf7f7,0xff6f,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,0xff81,0x01c7,
0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff81,
0xfff7,0xdbed,0xc5b7,0xdbfb,0xeff7,0xf7ff,0xffff,0xfffd,0xdde7,0xb9d9,
0xefdf,0xdfbd,0xb9b9,0xffff,0xfbff,0xdf9d,0xcdf7,0xd9d9,0xddde,0xded9,
0xddf7,0xfbdd,0xdfbd,0x9dd9,0xdcd9,0xddb9,0xb6bd,0xddbe,0xdddd,0xbbdf,
0xdffb,0xf7ff,0xefff,0xdfff,0xfdff,0xedff,0xdff7,0xfbdf,0xf7ff,0xffff,
0xffff,0xffff,0xefff,0xffff,0xffff,0xffef,0xf7f7,0xcd6f,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,0xff03,0x01c7,0xc7ff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff03,0xfff7,0xdbed,
0xb9b6,0xdff7,0xeff7,0xf7f7,0xffff,0xfffb,0xddd7,0xbdfd,0xefdf,0xdffd,
0xbdbd,0xffff,0xf7ff,0xefbd,0xdeeb,0xddbd,0xdedf,0xdfbd,0xddf7,0xfbdb,
0xdfb9,0x9dbd,0xdebd,0xddbd,0xf7bd,0xddb6,0xebdd,0xfbdf,0xeffb,0xebff,
0xf7ff,0xdfff,0xfdff,0xefff,0xdfff,0xffdf,0xf7ff,0xffff,0xffff,0xffff,
0xefff,0xffff,0xffff,0xffef,0xf7f7,0xa51f,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffc7,0xc7c7,0xc7c7,0xffff,0xff81,0x01c7,0xc7ff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff81,0xfff7,0xdb80,0xbdb5,0xdfef,
0xdffb,0xa2f7,0xffff,0xfffb,0xddf7,0xfdfd,0xdbdf,0xbffb,0x9dbd,0xe7e7,
0xefff,0xf7fd,0xb8eb,0xddbf,0xdedf,0xdfbf,0xddf7,0xfbd7,0xdf99,0xadbd,
0xdebd,0xdd9f,0xf7bd,0xddb6,0xebeb,0xf7df,0xeffb,0xddff,0xfbe3,0xd1e5,
0xe5e3,0x83e2,0xd3c7,0xe3d9,0xf76d,0x93e3,0x91e4,0x93c1,0x8399,0x8818,
0x8888,0x81ef,0xf7f7,0xb36f,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,
0xc7c7,0xffff,0xff03,0x01c7,0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xc7c7,0xc7c7,0xc7c7,0xff03,0xfff7,0xffdb,0xcfcb,0xefff,0xdffb,0xc1f7,
0xffff,0xfff7,0xddf7,0xfbe3,0xdbc3,0xa3fb,0xc3b9,0xe7e7,0xdf81,0xfbfb,
0xb6eb,0xc3bf,0xdec1,0xc3bf,0xc1f7,0xfbc7,0xdf95,0xadbd,0xddbd,0xc3c7,
0xf7bd,0xebb5,0xf7eb,0xf7df,0xf7fb,0xffff,0xffd9,0xccd9,0xd9d9,0xefcd,
0xcdf7,0xfbdb,0xf792,0xcdd9,0xccd9,0xcdbd,0xefdd,0xddbd,0xdddd,0xbbef,
0xf7f7,0xff6f,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,
0xff81,0x01c7,0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,
0xc7c7,0xff81,0xfff7,0xffdb,0xf3f7,0xd6ff,0xdffb,0xe380,0xff81,0xfff7,
0xddf7,0xf7f9,0xbbf9,0x9df7,0xb9c5,0xffff,0xbfff,0xfdf7,0xb6dd,0xddbf,
0xdedf,0xdfb8,0xddf7,0xfbdb,0xdfa5,0xb5bd,0xd3bd,0xd7f3,0xf7bd,0xeba5,
0xf7f7,0xefdf,0xf7fb,0xffff,0xfffd,0xdebd,0xbdbd,0xefdd,0xddf7,0xfbd7,
0xf7b6,0xddbd,0xdebd,0xdfbf,0xefdd,0xdda5,0xebdd,0xf79f,0xfff9,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,0xff03,0x01c7,
0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff03,
0xffff,0xff01,0xfde9,0xb9ff,0xdffb,0xebf7,0xffff,0xffef,0xddf7,0xeffd,
0x81fd,0xbdf7,0xbdfd,0xffff,0xdf81,0xfbe7,0xb9dd,0xdebf,0xdedf,0xdfbd,
0xddf7,0xfbdb,0xdfad,0xb5bd,0xdfbd,0xdbf9,0xf7bd,0xebd5,0xebf7,0xefdf,
0xfbfb,0xffff,0xffc1,0xdebf,0xbd81,0xefd9,0xddf7,0xfbc7,0xf7b6,0xddbd,
0xdebd,0xdfc3,0xefdd,0xeba5,0xf7eb,0xefef,0xf7f7,0xfff9,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,0xff81,0x01c7,0xc7ff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff81,0xffff,0xffb7,
0xbdd6,0xbbff,0xdffb,0xddf7,0xffff,0xffef,0xddf7,0xdfbd,0xfbbd,0xbdef,
0xbdfb,0xffff,0xefff,0xf7ff,0xdfc1,0xdebd,0xdedf,0xdfbd,0xddf7,0xbbdd,
0xdfbd,0xb9bd,0xdfbd,0xdbbd,0xf7bd,0xf7db,0xebf7,0xdfdf,0xfbfb,0xffff,
0xffbd,0xdebf,0xbdbf,0xefc3,0xddf7,0xfbdb,0xf7b6,0xddbd,0xdebd,0xdffd,
0xefdd,0xebdb,0xebeb,0xdfef,0xf7f7,0xfff6,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffc7,0xc7c7,0xc7c7,0xffff,0xff03,0x01c7,0xc7ff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff03,0xfff7,0xffb7,0x9db6,0xb1ff,
0xeff7,0xfff7,0xe7ff,0xe7df,0xddf7,0xbd9d,0xfb9d,0x9def,0x9dfb,0xe7e7,
0xf7ff,0xefff,0xcebe,0xdc9b,0xddde,0xdf99,0xddf7,0x9bdd,0xdebd,0xb99b,
0xdf9b,0xdd9d,0xf79b,0xf7db,0xddf7,0xdddf,0xfdfb,0xffff,0xffb9,0xcd9d,
0x999d,0xefbf,0xddf7,0xfbdd,0xf7b6,0xdd9b,0xcd99,0xdfbd,0xedd9,0xf7db,
0xddf3,0xbdef,0xf7f7,0xfff6,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,
0xc7c7,0xffff,0xff81,0x01c7,0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xc7c7,0xc7c7,0xc7c7,0xff81,0xfff7,0xffb7,0xa3f6,0xc6ff,0xeff7,0xffff,
0xe7ff,0xe7df,0xe3c1,0x81c3,0xfbc3,0xc3ef,0xc3f7,0xe7e7,0xfbff,0xdfe7,
0xf19c,0x81c7,0x8380,0x8fc5,0x88c1,0xc78c,0x8018,0x1dc7,0x8fc7,0x8ca3,
0xe3c7,0xf7db,0x88e3,0x81df,0xfdfb,0xffff,0xffc4,0xd3c3,0xc4c3,0xc7c1,
0x8cc1,0xfb98,0xc1b6,0x8cc7,0xd3c5,0x8f83,0xf3e4,0xf7db,0x88f7,0x81ef,
0xf7f7,0xfff6,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,
0xff03,0x01c7,0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,
0xc7c7,0xff03,0xffff,0xffff,0xf7f9,0xffff,0xf7ef,0xffff,0xf7ff,0xffbf,
0xffff,0xffff,0xffff,0xffff,0xffcf,0xfff7,0xfdff,0xbfff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffef,0xffff,0xffff,0xffff,
0xffff,0xffdf,0xfefb,0xff80,0xffff,0xffff,0xffff,0xff9e,0xffff,0xfbff,
0xffff,0xffff,0xdffd,0xffff,0xffff,0xffff,0xfff7,0xffef,0xf7f7,0xfff6,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,0xff81,0x01c7,
0xc7ff,0xffff,0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff81,
0xffff,0xffff,0xf7ff,0xffff,0xfbdf,0xffff,0xefff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffef,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xfff7,0xffff,0xffff,0xffff,0xffff,0xffc3,
0xffc3,0xffff,0xffff,0xffff,0xffff,0xffbc,0xffff,0xb7ff,0xffff,0xffff,
0xdffd,0xffff,0xffff,0xffff,0xffef,0xfff1,0xf78f,0xfff9,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffc7,0xc7c7,0xc7c7,0xffff,0xff03,0x01c7,0xc7ff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff03,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xdfff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffdf,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xfff9,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffc1,0xffff,0xcfff,0xffff,0xffff,0x8ff8,0xffff,
0xffff,0xffff,0xff9f,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffc7,0xc7c7,0xc7c7,0xffff,0xff81,0x01c7,0xc7ff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xc7c7,0xc7c7,0xc7c7,0xff81,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000

};


