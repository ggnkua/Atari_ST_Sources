/*
 *	version.h for pi1tomon
 */

#define VERSION		100

char			version_G[] = "pi1tomon v1.0 (mono) wjr 4/90";
char			CoPyRiTe[]  = "(c) 1989 Bill Rosenkranz";

