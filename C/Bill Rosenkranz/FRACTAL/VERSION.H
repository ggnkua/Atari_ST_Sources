/*
 *	version.h for fract
 */

#define VERSION		100

char			version_G[] = "fract v1.0 (mono) wjr 10/89";
char			copyrite[]  = "(c) 1989 Bill Rosenkranz";

