/*
 *	8x16 roman
 */
int	f8x16ro[] =
{
0x0000,0x0000,0x0000,0x0000,0x00FC,0xFE38,0x3800,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,
0x3838,0x0000,0x007E,0xFE38,0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,
0x3838,0x3838,0x3838,0x007E,0x0000,0x0000,0x1000,0x0000,0x0420,0x0000,
0x0000,0x0001,0x0000,0x0000,0x0800,0x0C00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x003C,0x403C,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x000E,
0x0870,0x00E0,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,
0x00FC,0xFE38,0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,
0x3838,0x00FC,0x0008,0x2412,0x1030,0x1804,0x0810,0x0000,0x0000,0x0002,
0x1C08,0x3C1C,0x083E,0x107E,0x3C3C,0x0000,0x0200,0x403C,0x0C08,0x7C1A,
0x7C7F,0x7F1A,0x773E,0x1F73,0x7083,0xC71C,0x7E1C,0x7C3A,0x7FE7,0x77E3,
0x7777,0x7E20,0x2004,0x0000,0x1000,0x6000,0x0600,0x0C00,0x6008,0x0460,
0x3800,0x0000,0x0000,0x0000,0x1000,0x0000,0x0000,0x0010,0x0808,0x0090,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,0x007E,0xFE38,
0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,0x3838,0x007E,
0x0008,0x2412,0x3A48,0x2404,0x1008,0x0800,0x0000,0x0002,0x2218,0x4626,
0x1020,0x2042,0x4646,0x0000,0x0400,0x2062,0x3208,0x2626,0x2221,0x2126,
0x2208,0x0422,0x2042,0x6226,0x2326,0x2246,0x4942,0x2241,0x2222,0x4420,
0x2004,0x0800,0x1000,0x2000,0x0200,0x1200,0x2008,0x0420,0x0800,0x0000,
0x0000,0x0000,0x1000,0x0000,0x0000,0x0010,0x0808,0x3290,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,0x00FC,0xFE38,0x3800,0x0000,
0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,0x3838,0x00FC,0x0008,0x2412,
0x4649,0x2008,0x1008,0x0808,0x0000,0x0004,0x2228,0x4202,0x1020,0x2002,
0x4242,0x0000,0x0800,0x1042,0x2114,0x2242,0x2120,0x2042,0x2208,0x0424,
0x2046,0x6242,0x2142,0x2242,0x0842,0x2249,0x1422,0x0420,0x1004,0x1400,
0x0800,0x2000,0x0200,0x1000,0x2000,0x0020,0x0800,0x0000,0x0000,0x0000,
0x1000,0x0000,0x0000,0x0010,0x0808,0x5AE0,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0038,0x3838,0x3838,0x0000,0x007E,0xFE38,0x3800,0x0000,0x0000,0x0000,
0x0000,0x0000,0x3838,0x3838,0x3838,0x007E,0x0008,0x247F,0x424A,0x2010,
0x2004,0x5D08,0x0000,0x0004,0x2208,0x0202,0x2420,0x4004,0x6242,0x1818,
0x1000,0x0802,0x4714,0x2240,0x2120,0x2040,0x2208,0x0428,0x2066,0x5242,
0x2142,0x2260,0x0842,0x2249,0x1414,0x0820,0x1004,0x2200,0x041C,0x2E1A,
0x1A1C,0x7C1D,0x2C38,0x1C26,0x0892,0x6C1C,0x6E1B,0x6C3E,0x7C66,0x77E7,
0x7777,0x7E10,0x0808,0x4C90,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,
0x3838,0x0000,0x00FC,0xFE38,0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,
0x3838,0x3838,0x3838,0x00FC,0x0008,0x0024,0x3034,0x1000,0x2004,0x3E08,
0x0000,0x0008,0x2208,0x041C,0x243C,0x5C04,0x3C46,0x1818,0x207E,0x0404,
0x4914,0x3C40,0x213E,0x3C40,0x3E08,0x0438,0x206A,0x5242,0x2242,0x3C38,
0x0842,0x144A,0x0814,0x0820,0x0804,0x0000,0x0026,0x3326,0x2626,0x1032,
0x3208,0x0424,0x086D,0x3226,0x3326,0x3242,0x1022,0x2242,0x2222,0x4410,
0x0808,0x0090,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,
0x007E,0xFE38,0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,
0x3838,0x007E,0x0008,0x0024,0x0C08,0x2900,0x2004,0x1C7F,0x007E,0x0008,
0x2208,0x0806,0x4406,0x6208,0x463A,0x0000,0x4000,0x0208,0x4922,0x2240,
0x2120,0x2047,0x2208,0x0424,0x205A,0x4A42,0x2C42,0x280C,0x0842,0x145A,
0x0808,0x1020,0x0804,0x0000,0x0002,0x2142,0x4242,0x1022,0x2208,0x0428,
0x0849,0x2242,0x2142,0x2040,0x1022,0x225A,0x1422,0x0860,0x0006,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,0x00FC,0xFE38,
0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,0x3838,0x00FC,
0x0000,0x00FE,0x0216,0x4600,0x2004,0x1408,0x0000,0x0010,0x2208,0x1002,
0x7E02,0x4208,0x4202,0x0000,0x207E,0x0418,0x4622,0x2140,0x2120,0x2042,
0x2208,0x0424,0x2052,0x4A42,0x2042,0x2406,0x0842,0x142A,0x1408,0x1020,
0x0404,0x0000,0x003E,0x2140,0x427E,0x1026,0x2208,0x0438,0x0849,0x2242,
0x2142,0x203C,0x1022,0x145A,0x0814,0x1010,0x0808,0x0006,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,0x007E,0xFE38,0x3800,0x0000,
0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,0x3838,0x007E,0x0000,0x0048,
0x4229,0x4400,0x2004,0x2208,0x0000,0x0010,0x2208,0x2042,0x0442,0x4210,
0x4204,0x0000,0x1000,0x0800,0x203E,0x2142,0x2120,0x2042,0x2208,0x4422,
0x2042,0x4642,0x2042,0x2442,0x0842,0x0824,0x1408,0x2020,0x0404,0x0000,
0x0042,0x2140,0x4240,0x103C,0x2208,0x0424,0x0849,0x2242,0x2142,0x2002,
0x1022,0x1424,0x1414,0x2010,0x0808,0x0009,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0038,0x3838,0x3838,0x0000,0x00FC,0xFE38,0x3800,0x0000,0x0000,0x0000,
0x0000,0x0000,0x3838,0x3838,0x3838,0x00FC,0x0008,0x0048,0x6249,0x4E00,
0x1008,0x0008,0x1800,0x1820,0x2208,0x4262,0x0462,0x6210,0x6204,0x1818,
0x0800,0x1000,0x3141,0x2364,0x2221,0x2066,0x2208,0x6422,0x2142,0x4664,
0x2064,0x2262,0x0864,0x0824,0x2208,0x2220,0x0204,0x0000,0x0046,0x3262,
0x6662,0x1040,0x2208,0x0422,0x0849,0x2264,0x3266,0x2042,0x1226,0x0824,
0x220C,0x4210,0x0808,0x0009,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,
0x3838,0x0000,0x007E,0xFE38,0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,
0x3838,0x3838,0x3838,0x007E,0x0008,0x0048,0x5C09,0x3900,0x1008,0x0000,
0x1800,0x1820,0x1C3E,0x7E3C,0x043C,0x3C10,0x3C08,0x1818,0x0400,0x2018,
0x0E63,0x7E38,0x7C7F,0x703A,0x773E,0x3873,0x7FE7,0xE238,0x7038,0x735C,
0x1C38,0x0824,0x771C,0x7E20,0x0204,0x0000,0x003B,0x2C3C,0x3B3C,0x383E,
0x733E,0x0467,0x3E49,0x7338,0x2C3A,0x707C,0x0C1B,0x0824,0x7708,0x7E10,
0x0808,0x0009,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,
0x00FC,0xFE38,0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,
0x3838,0x00FC,0x0000,0x0000,0x0806,0x0000,0x0810,0x0000,0x0800,0x0040,
0x0000,0x0000,0x0000,0x0000,0x0030,0x0008,0x0200,0x4000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0010,0x0000,0x0000,0x0000,
0x0000,0x0020,0x0104,0x007F,0x0000,0x0000,0x0000,0x0061,0x0000,0x0400,
0x0000,0x0000,0x2002,0x0000,0x0000,0x0000,0x0008,0x0010,0x0808,0x0009,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,0x007E,0xFE38,
0x3800,0x0000,0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,0x3838,0x007E,
0x0000,0x0000,0x0800,0x0000,0x0420,0x0000,0x1000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0010,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0008,0x0000,0x0000,0x0000,0x0000,0x003C,
0x003C,0x0000,0x0000,0x0000,0x0000,0x0043,0x0000,0x4800,0x0000,0x0000,
0x2002,0x0000,0x0000,0x0000,0x0010,0x000E,0x0870,0x0006,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0038,0x3838,0x3838,0x0000,0x00FC,0xFE38,0x3800,0x0000,
0x0000,0x0000,0x0000,0x0000,0x3838,0x3838,0x3838,0x00FC,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x2000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0020,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0006,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x003E,0x0000,0x3000,0x0000,0x0000,0x7007,0x0000,
0x0000,0x0000,0x0060,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0038,0x3838,0x3838,0x0000,0x007E,0xFE38,0x3800,0x0000,0x0000,0x0000,
0x0000,0x0000,0x3838,0x3838,0x3838,0x007E,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000

};


