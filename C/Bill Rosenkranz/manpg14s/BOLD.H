/*
 *	8x16 bold (everything is bold)
 */
int	f8x16bo[] =
{
0x0000,0x0000,0x0000,0x0000,0x00FE,0xFF3C,0x3C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,
0x3C3C,0x0000,0x007F,0xFF3C,0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x3C3C,0x3C3C,0x3C3C,0x007F,0x0000,0x0000,0x3000,0x0000,0x0C60,0x0000,
0x0000,0x0003,0x0000,0x0000,0x1800,0x1C00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x007C,0xC07C,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001E,
0x18F0,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,
0x00FE,0xFF3C,0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,
0x3C3C,0x00FE,0x0018,0x6C1B,0x3070,0x380C,0x1830,0x0000,0x0000,0x0006,
0x3C18,0x7C3C,0x187E,0x30FE,0x7C7C,0x0000,0x0600,0xC07C,0x1C18,0xFC3E,
0xFCFF,0xFF3E,0xFF7E,0x3FF7,0xF087,0xCF3C,0xFE3C,0xFC7E,0xFFEF,0xFFE7,
0xFFFF,0xFE60,0x600C,0x0000,0x3000,0xE000,0x0E00,0x0E00,0xE018,0x0CE0,
0x7800,0x0000,0x0000,0x0000,0x3000,0x0000,0x0000,0x0030,0x1818,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,0x007F,0xFF3C,
0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x007F,
0x0018,0x6C1B,0x7ED9,0x6C0C,0x3018,0x1800,0x0000,0x0006,0x6638,0xCE6E,
0x3060,0x60C6,0xCECE,0x0000,0x0C00,0x60E6,0x7618,0x6E6E,0x6663,0x636E,
0x6618,0x0C66,0x60C6,0xE66E,0x676E,0x66CE,0xDBC6,0x66C3,0x6666,0xCC60,
0x600C,0x1800,0x3000,0x6000,0x0600,0x1B00,0x6018,0x0C60,0x1800,0x0000,
0x0000,0x0000,0x3000,0x0000,0x0000,0x0030,0x1818,0x7600,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,0x00FE,0xFF3C,0x3C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x00FE,0x0018,0x6C1B,
0xCEDA,0x6018,0x3018,0x1818,0x0000,0x000C,0x6678,0xC606,0x3060,0x6006,
0xC6C6,0x0000,0x1800,0x30C6,0x633C,0x66C6,0x6360,0x60C6,0x6618,0x0C6C,
0x60CE,0xE6C6,0x63C6,0x66C6,0x18C6,0x66DB,0x3C66,0x0C60,0x300C,0x3C00,
0x1800,0x6000,0x0600,0x1800,0x6000,0x0060,0x1800,0x0000,0x0000,0x0000,
0x3000,0x0000,0x0000,0x0030,0x1818,0xFE00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x003C,0x3C3C,0x3C3C,0x0000,0x007F,0xFF3C,0x3C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x007F,0x0018,0x6C7F,0xC6DE,0x6030,
0x600C,0xFF18,0x0000,0x000C,0x6618,0x0606,0x6C60,0xC00C,0xE6C6,0x3838,
0x3000,0x1806,0xCF3C,0x66C0,0x6360,0x60C0,0x6618,0x0C78,0x60EE,0xF6C6,
0x63C6,0x66E0,0x18C6,0x66DB,0x3C3C,0x1860,0x300C,0x6600,0x0C3C,0x7E3E,
0x3E3C,0x7E3F,0x7C78,0x3C6E,0x18DB,0xFC3C,0xFE3F,0xFC7E,0xFCEE,0xFFEF,
0xFFFF,0xFE30,0x1818,0xDC00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,
0x3C3C,0x0000,0x00FE,0xFF3C,0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x3C3C,0x3C3C,0x3C3C,0x00FE,0x0018,0x0036,0x707C,0x3000,0x600C,0x7E18,
0x0000,0x0018,0x6618,0x0C3C,0x6C7C,0xFC0C,0x7CCE,0x3838,0x60FE,0x0C0C,
0xDB3C,0x7CC0,0x637E,0x7CC0,0x7E18,0x0C78,0x60FE,0xF6C6,0x66C6,0x7C78,
0x18C6,0x3CDE,0x183C,0x1860,0x180C,0x0000,0x006E,0x776E,0x6E6E,0x1876,
0x7618,0x0C6C,0x187F,0x766E,0x776E,0x76C6,0x3066,0x66C6,0x6666,0xCC30,
0x1818,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,
0x007F,0xFF3C,0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,
0x3C3C,0x007F,0x0018,0x0036,0x1C18,0x7B00,0x600C,0x3CFF,0x00FE,0x0018,
0x6618,0x180E,0xCC0E,0xE618,0xCE7E,0x0000,0xC000,0x0618,0xDB66,0x66C0,
0x6360,0x60CF,0x6618,0x0C6C,0x60FE,0xDEC6,0x7CC6,0x781C,0x18C6,0x3CFE,
0x1818,0x3060,0x180C,0x0000,0x0006,0x63C6,0xC6C6,0x1866,0x6618,0x0C78,
0x186D,0x66C6,0x63C6,0x60C0,0x3066,0x66FE,0x3C66,0x18E0,0x000E,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,0x00FE,0xFF3C,
0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x00FE,
0x0000,0x00FF,0x063E,0xCE00,0x600C,0x3C18,0x0000,0x0030,0x6618,0x3006,
0xFE06,0xC618,0xC606,0x0000,0x60FE,0x0C38,0xCE66,0x63C0,0x6360,0x60C6,
0x6618,0x0C6C,0x60F6,0xDEC6,0x60C6,0x6C0E,0x18C6,0x3C7E,0x3C18,0x3060,
0x0C0C,0x0000,0x007E,0x63C0,0xC6FE,0x186E,0x6618,0x0C78,0x186D,0x66C6,
0x63C6,0x607C,0x3066,0x3CFE,0x183C,0x3030,0x1818,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,0x007F,0xFF3C,0x3C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x007F,0x0000,0x006C,
0xC67B,0xCC00,0x600C,0x6618,0x0000,0x0030,0x6618,0x60C6,0x0CC6,0xC630,
0xC60C,0x0000,0x3000,0x1800,0x607E,0x63C6,0x6360,0x60C6,0x6618,0xCC66,
0x60C6,0xCEC6,0x60C6,0x6CC6,0x18C6,0x186C,0x3C18,0x6060,0x0C0C,0x0000,
0x00C6,0x63C0,0xC6C0,0x187C,0x6618,0x0C6C,0x186D,0x66C6,0x63C6,0x6006,
0x3066,0x3C6C,0x3C3C,0x6030,0x1818,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x003C,0x3C3C,0x3C3C,0x0000,0x00FE,0xFF3C,0x3C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x00FE,0x0018,0x006C,0xE6DB,0xDE00,
0x3018,0x0018,0x3800,0x3860,0x6618,0xC6E6,0x0CE6,0xE630,0xE60C,0x3838,
0x1800,0x3000,0x73C3,0x67EC,0x6663,0x60EE,0x6618,0xEC66,0x63C6,0xCEEC,
0x60EC,0x66E6,0x18EC,0x186C,0x6618,0x6660,0x060C,0x0000,0x00CE,0x76E6,
0xEEE6,0x18C0,0x6618,0x0C66,0x186D,0x66EC,0x76EE,0x60C6,0x366E,0x186C,
0x661C,0xC630,0x1818,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,
0x3C3C,0x0000,0x007F,0xFF3C,0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x3C3C,0x3C3C,0x3C3C,0x007F,0x0018,0x006C,0xFC1B,0x7B00,0x3018,0x0000,
0x3800,0x3860,0x3C7E,0xFE7C,0x0C7C,0x7C30,0x7C18,0x3838,0x0C00,0x6038,
0x1EE7,0xFE78,0xFCFF,0xF07E,0xFF7E,0x78F7,0xFFEF,0xE778,0xF078,0xF7FC,
0x3C78,0x186C,0xFF3C,0xFE60,0x060C,0x0000,0x007F,0x7C7C,0x7F7C,0x3C7E,
0xF77E,0x0CEF,0x7E6D,0xF778,0x7C7E,0xF0FC,0x1C3F,0x186C,0xFF18,0xFE30,
0x1818,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,
0x00FE,0xFF3C,0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,
0x3C3C,0x00FE,0x0000,0x0000,0x180E,0x0000,0x1830,0x0000,0x1800,0x00C0,
0x0000,0x0000,0x0000,0x0000,0x0070,0x0018,0x0600,0xC000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0030,0x0000,0x0000,0x0000,
0x0000,0x0060,0x030C,0x00FF,0x0000,0x0000,0x0000,0x00E3,0x0000,0x0C00,
0x0000,0x0000,0x6006,0x0000,0x0000,0x0000,0x0018,0x0030,0x1818,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,0x007F,0xFF3C,
0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x007F,
0x0000,0x0000,0x1800,0x0000,0x0C60,0x0000,0x3000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0030,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0018,0x0000,0x0000,0x0000,0x0000,0x007C,
0x007C,0x0000,0x0000,0x0000,0x0000,0x00C7,0x0000,0xD800,0x0000,0x0000,
0x6006,0x0000,0x0000,0x0000,0x0030,0x001E,0x18F0,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x003C,0x3C3C,0x3C3C,0x0000,0x00FE,0xFF3C,0x3C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x00FE,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x6000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0060,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x000E,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x007E,0x0000,0x7000,0x0000,0x0000,0xF00F,0x0000,
0x0000,0x0000,0x00E0,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x003C,0x3C3C,0x3C3C,0x0000,0x007F,0xFF3C,0x3C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x3C3C,0x3C3C,0x3C3C,0x007F,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000

};
