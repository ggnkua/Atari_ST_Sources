/*
 *	8x16 special characters (box, greek, etc)
 */
int	f8x16sp[] =
{
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x1104,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1810,0x183C,0x083C,0x183C,0x1818,0x00FF,
0x0000,0x0000,0xFF00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x001E,0x0078,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x000E,0x1870,0x0000,0x1810,0x1000,0x0010,0x0000,0x0010,0x1000,
0x1010,0x1010,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0060,0x60E0,0x0000,0x0000,0x0000,
0x0000,0x6032,0x3200,0x0000,0x0000,0x00F1,0x6600,0x0000,0x6666,0x6666,
0x6666,0x0066,0x6666,0x1800,0x1800,0x0000,0x1818,0x1818,0x1818,0x00AA,
0xCC00,0xFF00,0x0718,0xE018,0x1818,0x1818,0x181F,0xF800,0x0E00,0x0000,
0x0000,0x0000,0x0018,0x0000,0x0000,0x0001,0x0000,0x0000,0x0010,0x1000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x05A0,0x7C00,0x7C7C,0x007C,0x7C7C,
0x7C7C,0x0000,0x0000,0x0B28,0x0022,0x3300,0x0000,0x000C,0x0000,0x0000,
0x0000,0x0002,0x2430,0x2408,0x1820,0x2004,0x2424,0x0000,0x0000,0x0000,
0x0000,0x0002,0x0000,0x0000,0x0000,0x0000,0x1000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x001E,0x4078,0x0000,0x0800,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0018,
0x1818,0x0000,0x1838,0x1000,0x0010,0x0000,0x0010,0x1000,0x1010,0x1010,
0x0000,0x0000,0x0000,0x0070,0x0000,0x0010,0x0E00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0020,0x2020,0x0000,0x3232,0x0100,0x0000,0x307A,
0x7A66,0x1010,0x7A7C,0x7C5B,0x6600,0x0000,0x6666,0x6666,0x6666,0x0066,
0x6666,0x1800,0x1800,0x0000,0x1818,0x1818,0x1818,0x0055,0xCC1C,0xFF00,
0x0C18,0x3018,0x1818,0x1818,0x181F,0xF81C,0x1E00,0x0000,0x0000,0x0000,
0x0E18,0x0000,0x3824,0x0001,0x0000,0x00FE,0x0038,0x1000,0x007C,0xFEEE,
0x0100,0x0008,0x7838,0x05A0,0xBA02,0x3A3A,0x82B8,0xB8BA,0xBABA,0x0078,
0x0000,0x0DD8,0x0044,0x3300,0x0800,0x000C,0x0000,0x0000,0x0000,0x0002,
0x2410,0x0418,0x2838,0x3808,0x1824,0x0000,0x0400,0x2000,0x0008,0xF87C,
0x10FE,0x38FE,0x3838,0x06E6,0x10C3,0xC71C,0xFFD6,0xFCFE,0xFEC6,0x2438,
0xEEEE,0x7E18,0x4018,0x0000,0x1000,0x0020,0x1C00,0x0000,0x0000,0x0C00,
0x2000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x2018,0x1818,0x0000,
0x187C,0x1000,0x0010,0x0000,0x0010,0x1000,0x1010,0x1010,0x3C81,0x00FF,
0x0000,0x00D8,0x0000,0x0010,0x1E00,0x0180,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFE20,0x2040,0x0000,0x7A7A,0x3D00,0x007E,0x184C,0x4C66,0x7C7C,
0xCAC6,0xC65F,0x6600,0x0000,0x6666,0x6666,0x6666,0x0066,0x6666,0x1800,
0x1800,0x0000,0x1818,0x1818,0x1818,0x00AA,0x3336,0xFF00,0x1818,0x1818,
0x1818,0x1818,0x1818,0x1830,0x1010,0x0000,0x0000,0x0000,0x1F18,0x0000,
0x6C18,0x0002,0x1830,0x78FE,0x007C,0x1000,0x0038,0xFEC6,0x013C,0x000E,
0x4040,0x05A0,0xC606,0x0606,0xC6C0,0xC0C6,0xC6C6,0x0040,0x0000,0x0628,
0x0088,0x1181,0x0800,0x1004,0x0002,0x0000,0x0000,0x0004,0x2410,0x0804,
0x7C04,0x2410,0x241C,0x0000,0x0800,0x1000,0x0008,0x4480,0x1842,0x1042,
0x4410,0x0644,0x3846,0x6226,0x2454,0x4642,0x9244,0x2444,0x4444,0x4418,
0x2018,0x0000,0x2000,0x383C,0x2600,0x1002,0x1000,0x0C42,0x2000,0x0000,
0x0010,0x0000,0x0000,0x0000,0x0000,0x2E18,0x1818,0x2200,0x1810,0x1000,
0x0010,0x0000,0x0010,0x1000,0x1010,0x1010,0x4281,0x0081,0x3FFC,0x1E8C,
0x003F,0xFC10,0x3800,0xFFFF,0x0000,0x0000,0x0000,0x0000,0x0000,0x0223,
0x2323,0x0000,0x4C4C,0x7E00,0x00FE,0x0000,0x0000,0x1010,0xCA82,0x8255,
0x6600,0x0000,0x6666,0x6666,0x6666,0x0066,0x6666,0x1800,0x1800,0x0000,
0x1818,0x1818,0x1818,0x0055,0x3332,0xE700,0x1818,0x1818,0x1818,0x1818,
0x1818,0x1820,0x1010,0x3CFF,0x0010,0x2004,0x1918,0x0022,0x443C,0x0002,
0x3C48,0x1800,0x0010,0x1000,0x00BA,0xFED6,0x0366,0x180F,0x7040,0x05A0,
0xC606,0x0606,0xC6C0,0xC0C6,0xC6C6,0x0070,0x0000,0x07D0,0x00CC,0x2242,
0x3E00,0x1008,0x2204,0x0010,0x0000,0x0004,0x2410,0x1024,0x0824,0x2410,
0x2404,0x0000,0x1000,0x0800,0x0014,0x4400,0x2840,0x3842,0x8210,0x0648,
0x2866,0x6242,0x2454,0x4222,0x1044,0x2482,0x2844,0x0418,0x2018,0x0000,
0x3000,0x4462,0x2200,0x1042,0x2800,0x0044,0x1000,0x0000,0x01D6,0x0000,
0x0000,0x0000,0xC108,0x3E18,0x1818,0x7218,0xFF10,0x1000,0x0010,0x0000,
0x0010,0x1000,0x1010,0x1010,0x8181,0x3DC3,0x4002,0x2004,0x0040,0x0210,
0x3000,0x8181,0x0000,0x0000,0x0000,0x0000,0x0000,0x0226,0x2626,0x1AB0,
0x0000,0x6601,0x00D8,0x3C3C,0x3C00,0x1010,0xCABA,0xBA51,0x6600,0x0000,
0x6666,0x6666,0x6666,0x0066,0x6666,0x1800,0x1800,0x0000,0x1818,0x1818,
0x1818,0x00AA,0xCC18,0xDB00,0x1818,0x1818,0x1818,0x1818,0x1818,0x1830,
0x107C,0x4281,0x7E10,0x1008,0x1818,0x1872,0x6C7E,0x0004,0x2418,0x3000,
0x0010,0x1008,0x1092,0xFC92,0x03C3,0x3C09,0x4040,0x0DB0,0xC606,0x0606,
0xC6C0,0xC0C6,0xC6C6,0x7C40,0x0000,0x2E10,0x00CC,0x4424,0x6800,0x1010,
0x727E,0x3C10,0x0000,0x0008,0x1838,0x3C18,0x0818,0x1810,0x1838,0x0000,
0x207E,0x0400,0x0014,0x4400,0x2444,0x5440,0x8210,0x0650,0x246A,0x5242,
0x2454,0x4210,0x1028,0x2482,0x2844,0x0818,0x1018,0x0000,0x3032,0x4420,
0x183E,0x38A4,0x4410,0x0C48,0x1022,0x663C,0x7E54,0x1C3F,0x3E62,0x6624,
0x2254,0x1018,0x1818,0x9C18,0xFF10,0x1000,0x0010,0x0000,0x0010,0x1000,
0x1010,0x1010,0x8181,0x4242,0x8001,0x407E,0x7780,0x0110,0x3000,0xF99F,
0x0000,0x0000,0x0000,0x0000,0x0000,0x002C,0x2CCC,0x36D8,0x3C3C,0x663D,
0x7ED8,0x7E7E,0x7E00,0x7C10,0xCAA2,0xAA00,0x66FF,0x7FFE,0xE667,0x67E6,
0xE7E7,0xFF66,0x6666,0xFFFF,0x1800,0x0000,0x1818,0x1818,0x1818,0x0055,
0xCC3C,0xFB6C,0x1818,0x1818,0x1818,0x1818,0x1818,0x1818,0x10D6,0x8181,
0x0010,0x0810,0x1818,0x189C,0x383C,0x0004,0x2430,0x1800,0x0010,0x100C,
0x30D6,0xFCBA,0x0691,0x3C08,0x4038,0x0DB0,0x8202,0x3A3A,0xBAB8,0xB882,
0xBABA,0x7E78,0x0000,0x39E0,0x0000,0x0018,0x4800,0x1000,0x9C08,0x7E10,
0x0000,0x1808,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x4000,0x0200,
0x0014,0x787C,0x247C,0x5440,0xBA10,0x0670,0x645A,0x5242,0x2454,0x4408,
0x1028,0x2682,0x107C,0x0818,0x1018,0x0000,0x006A,0x481C,0x3C60,0x5414,
0x4430,0x0C50,0x0822,0x2266,0xA454,0x2664,0x48A2,0x6666,0x14A2,0x2030,
0x180C,0x883C,0x0010,0x1004,0x2010,0x0000,0x0010,0x1000,0x1010,0x1010,
0x8181,0x8566,0x8001,0x40C6,0x9C80,0x0110,0x3000,0x2184,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0018,0x1818,0x6C6C,0x3E7E,0x6E7E,0xFFDE,0x6666,
0x6600,0x1010,0xCAA2,0xB200,0x66FF,0x7FFE,0xE667,0x67E6,0xE7E7,0xFF66,
0x6666,0xFFFF,0x1800,0x0000,0x1818,0x1818,0x1818,0x00AA,0x3366,0xFB92,
0x1818,0x1818,0x381C,0x1818,0x1818,0x183C,0x1092,0x8181,0x007C,0x0420,
0x1818,0x0088,0x0018,0x00C8,0x2460,0x4800,0x0010,0x10FE,0x7FC6,0xF838,
0x0691,0x3C08,0x0000,0x1DB8,0x0000,0x7C7C,0x7C7C,0x7C00,0x7C7C,0x0600,
0x0000,0x3800,0x0000,0x0018,0x487E,0xFE00,0x8810,0x7E10,0x3C7E,0x1810,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x2000,0x0400,0x0022,0x4400,
0x4444,0x5440,0x8210,0x0648,0x4452,0x4A42,0x2438,0x7808,0x1010,0x2644,
0x1044,0x1018,0x0818,0x0000,0x0044,0x7C20,0x6640,0x5408,0x7C10,0x0C60,
0x0422,0x2242,0x2454,0x4242,0x0822,0x6642,0x1822,0x60E0,0x1807,0x0024,
0x0010,0x1006,0x6010,0x0000,0x0010,0x1000,0x1010,0x1010,0x8181,0x8924,
0x8001,0x7E82,0x8880,0x0110,0x3000,0x399C,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0030,0x3232,0xD836,0x0666,0x6E66,0xDBDE,0x6666,0x6600,0x1010,
0x7AA2,0xBA00,0x6600,0x6006,0x0660,0x6006,0x0000,0x0067,0xE6E7,0x0000,
0x18FF,0x1FF8,0xF81F,0x1FF8,0xFFFF,0xFF55,0x3366,0xF792,0x1818,0x1818,
0xF00F,0x1818,0x1818,0x1866,0x1092,0x8181,0x7E10,0x0810,0x1818,0x7E22,
0x0024,0x00C8,0x2478,0x3000,0x0010,0x100C,0x30D6,0xFABA,0x8C9D,0x3C78,
0x1E1C,0x399C,0x8202,0xB83A,0x3A3A,0xBA02,0xBA3A,0x060E,0x07F0,0x0000,
0x0000,0x0024,0x6800,0x1000,0x007E,0x7EFE,0x0000,0x0010,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x107E,0x0800,0x0022,0x4200,0x4240,0x5440,
0x8210,0x0644,0x4242,0x4A42,0x2410,0x4010,0x1010,0x266C,0x2844,0x1018,
0x0818,0x0000,0x0044,0x4660,0x427E,0x5408,0x4410,0x0C50,0x0C22,0x2442,
0x2438,0x4242,0x0822,0x665A,0x1822,0x40E0,0x1807,0x0066,0xFF10,0x10FF,
0xFF10,0xFFF0,0x1FF0,0x1FFF,0xFF1F,0xF0FF,0x8181,0x912C,0x8001,0x4082,
0x9C80,0x0110,0xFE00,0x2184,0x0000,0x0000,0x0000,0x0000,0x0000,0x006E,
0x6666,0x6C6C,0x3E66,0x766E,0xDBD8,0x7E7E,0x6600,0x0000,0x0ABA,0xAA00,
0x6600,0x6006,0x0660,0x6006,0x0000,0x0067,0xE6E7,0x0000,0x18FF,0x1FF8,
0xF81F,0x1FF8,0xFFFF,0xFFAA,0xCC3C,0xEF92,0x1818,0x1818,0xF00F,0x1818,
0x1818,0x1842,0x1092,0x8181,0x0010,0x1008,0x1818,0x0072,0x0000,0x0050,
0x0000,0x0000,0x0010,0x1008,0x1092,0xF292,0x8C81,0x3CF8,0x1012,0x799E,
0xC606,0xC006,0x0606,0xC606,0xC606,0x7E10,0x0FF8,0x0000,0x0000,0x0042,
0x3E00,0x1000,0xFE20,0x7E10,0x0000,0x0020,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0800,0x1000,0x003E,0x4202,0x8240,0x3840,0x8210,0x0644,
0xC242,0x4642,0x2410,0x4022,0x1010,0x2428,0x2844,0x2018,0x0418,0x0000,
0x004C,0x4230,0x4240,0x3810,0x4410,0x0C48,0x1222,0x2842,0x2410,0x6642,
0x0822,0x665A,0x2422,0x4030,0x180C,0x0042,0xFF10,0x1006,0x6010,0x0010,
0x1000,0x0010,0x0010,0x1010,0x8181,0xA118,0x4002,0x4082,0x7780,0x0110,
0x3000,0x399C,0x0000,0x0000,0x0000,0x0000,0x0000,0x00D3,0xCECE,0x36D8,
0x7E66,0x767E,0xDFD8,0x7E7E,0x6600,0x0000,0x0A82,0x8200,0x66FF,0x67E6,
0xFE7F,0x67E6,0xE7FF,0xE766,0x6666,0xFFFF,0x1800,0x1818,0x0000,0x1818,
0x1800,0x1855,0xCC18,0xEF6C,0x1818,0x1818,0x381C,0x1818,0x1818,0x1842,
0x1092,0x4281,0x0010,0x2004,0x1818,0x189C,0x0000,0x0070,0x0000,0x0000,
0x0010,0x1000,0x00BA,0xF6D6,0xD8C3,0x7E70,0x1C1C,0x718E,0xC606,0xC006,
0x0606,0xC606,0xC606,0x660C,0x1FEC,0x0000,0x0000,0x0081,0x0800,0x1000,
0x0040,0x3C10,0x0000,0x0020,0x0000,0x0000,0x0000,0x0000,0x0000,0xDB00,
0x0400,0x2000,0x0041,0x427C,0x8142,0x1040,0x4410,0x6642,0x8342,0x4664,
0x2410,0x4042,0x1010,0x3CAA,0x4444,0x2218,0x0418,0x0000,0x0054,0x621C,
0x6660,0x1010,0x2810,0x0C44,0x2277,0x3066,0x2410,0x5C66,0x0836,0x3C7E,
0x4322,0x6018,0x1818,0x00C3,0x1810,0x1004,0x2010,0x0010,0x1000,0x0010,
0x0010,0x1010,0x8181,0x4218,0x3FFC,0x20C6,0x0040,0x0210,0x3000,0x2184,
0x1810,0x183C,0x083C,0x183C,0x1818,0x0006,0x1A1A,0x1AB0,0x6666,0x6676,
0xD8D8,0x6666,0x6600,0x0000,0x0AC6,0xC600,0x66FF,0x67E6,0xFE7F,0x67E6,
0xE7FF,0xE766,0x6666,0xFFFF,0x1800,0x1818,0x0000,0x1818,0x1800,0x18AA,
0x334C,0xEF00,0x1818,0x1818,0x1818,0x1818,0x1818,0x1866,0x10D6,0x3CFF,
0x7E00,0x0000,0x1818,0x1888,0x0000,0x0020,0x0000,0x0000,0x0010,0x1000,
0x0038,0xE6C6,0x5866,0xFF00,0x1014,0x718E,0xC606,0xC006,0x0606,0xC606,
0xC606,0x6602,0x1804,0x0000,0x0000,0x0000,0x0800,0x1000,0x0000,0x0010,
0x0000,0x0040,0x0000,0x0000,0x0000,0x0000,0x0000,0xDB00,0x0000,0x00FF,
0x0063,0xFC80,0xFFFE,0x38E0,0x3838,0x66E3,0x81E7,0xE238,0x6638,0xE0FE,
0x3838,0x18EE,0xEEEE,0x7E18,0x0218,0x00FF,0x0022,0x5C02,0x3C3E,0x1020,
0x1038,0x0C42,0x41DD,0x203C,0x2410,0x403C,0x081C,0x3C24,0x8022,0x3C18,
0x1818,0x00FF,0x1810,0x1000,0x0010,0x0010,0x1000,0x0010,0x0010,0x1010,
0x8181,0xBC10,0x0000,0x1E6C,0x003F,0xFC10,0x3000,0x3FFC,0x2430,0x2408,
0x1820,0x2004,0x2424,0x000C,0x3232,0x0000,0x6666,0x6666,0xD8D8,0x6666,
0x6600,0x0000,0x0A7C,0x7C00,0x6600,0x6666,0x0000,0x6666,0x6600,0x6666,
0x6666,0x0018,0x1800,0x1818,0x0000,0x1818,0x1800,0x1855,0x336C,0xFF00,
0x1818,0x1818,0x1818,0x1818,0x1818,0x183C,0x107C,0x0000,0x007C,0x7E7E,
0x1818,0x0000,0x0000,0x0000,0x0000,0x0000,0x0010,0x7C00,0x007C,0xEEEE,
0x703C,0x1000,0x1012,0x6186,0xBA02,0xB83A,0x023A,0xBA02,0xBA3A,0x7E1C,
0x1804,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0010,0x0000,0x0040,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x7E00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1800,
0x0000,0x0018,0x0218,0x0000,0x0000,0x4022,0x0000,0x0000,0x0000,0x0C00,
0x0080,0x0000,0x0000,0x4000,0x0000,0x1800,0x0002,0x0418,0x1818,0x0000,
0x1810,0x1000,0x0010,0x0010,0x1000,0x0010,0x0010,0x1010,0x8142,0x0000,
0x7FFE,0x0038,0x0000,0x0010,0x7F00,0x0180,0x2410,0x0418,0x2838,0x3808,
0x1824,0x0018,0x3F3F,0x0000,0x7E7E,0x7E7E,0xFFFE,0x6666,0x7E00,0x0000,
0x0A00,0x0000,0x6600,0x6666,0x0000,0x6666,0x6600,0x6666,0x6666,0x0018,
0x1800,0x1818,0x0000,0x1818,0x1800,0x18AA,0xCC38,0xEF00,0x1818,0x1818,
0x1818,0x1818,0x1818,0x1800,0x1010,0x0000,0x0000,0x0000,0x1898,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0010,0x3800,0x0000,0x0000,0x3000,0x3800,
0x0000,0x4182,0x7C00,0x7C7C,0x007C,0x7C00,0x7C7C,0x3C00,0x1004,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x3C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0018,
0x0018,0x0000,0x0000,0x401C,0x0000,0x0000,0x0000,0x0C00,0x0000,0x0000,
0x0000,0x4000,0x0000,0x1800,0x0002,0x1C18,0x1818,0x0000,0x1810,0x7C00,
0x0010,0x0010,0x1000,0x0010,0x0010,0x1010,0x813C,0x0000,0x0000,0x0000,
0x0000,0x0010,0xFF00,0x0000,0x2410,0x0804,0x7C04,0x2410,0x241C,0x001F,
0x0202,0x0000,0x3E3C,0xBCBC,0x7F7E,0x6666,0x3C00,0x0000,0x0000,0x0000,
0x6600,0x6666,0x0000,0x6666,0x6600,0x6666,0x6666,0x0018,0x1800,0x1818,
0x0000,0x1818,0x1800,0x1855,0xCC00,0xEF00,0x1818,0x1818,0x1818,0x1818,
0x1818,0x1800,0x1010,0x0000,0x0000,0x0000,0x18F8,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0010,0x1000,0x0000,0x0000,0x2000,0x1000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x1E3C,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001E,0x0078,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x7C00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0018,0x1818,0x0000,0x1810,0x3800,0x0010,0x0010,
0x1000,0x0010,0x0010,0x1010,0x0000,0x0000,0x0000,0x0000,0x0000,0x0010,
0x0000,0x0000,0x2410,0x1024,0x0824,0x2410,0x2404,0x0000,0x0000,0x0000,
0x0000,0x8080,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x6600,0x6666,
0x0000,0x6666,0x6600,0x6666,0x6666,0x0018,0x1800,0x1818,0x0000,0x1818,
0x1800,0x18AA,0x3300,0xFF00,0x180C,0x1830,0x1818,0x181F,0xF818,0x1800,
0xF000,0x0000,0x0000,0x0000,0x1870,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1754,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x001E,0x0078,0xFF00,0x0000,0x0000,
0x0000,0x0000,0x0000,0x7800,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x000E,0x1870,0x0000,0x1810,0x1000,0x0010,0x0010,0x1000,0x0010,
0x0010,0x1010,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x00FF,0x0000,
0x1838,0x3C18,0x0818,0x1810,0x1838,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x6600,0x6666,0x0000,0x6666,
0x6600,0x6666,0x6666,0x0018,0x1800,0x1818,0x0000,0x1818,0x1800,0x1855,
0x3300,0xFF00,0x1807,0x18E0,0x1818,0x181F,0xF818,0x1800,0xE000,0x0000,
0x0000,0x0000,0x1800,0x0000,0x0000,0xFF00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000

};


