/*
 *	8x16 "small" font, based on 6x12 MGR font (cour6x12r.fnt), expanded
 *	to 8x16 with "fnt2fed -w 8 -h 16 -b 5 ..."
 */
int	f8x16sm[] =
{
/* 2 fonts, one serif, the other sans serif... */
#ifdef SM_SERIF
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x007E,0x7E1C,
0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0420,0x0000,0x0000,0x0002,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,
0x2038,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x000C,0x0830,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,0x0008,0x1414,
0x0810,0x1004,0x0810,0x0000,0x0000,0x0002,0x1808,0x1818,0x043C,0x0C3C,
0x1818,0x0000,0x0000,0x0018,0x0C18,0x3C1E,0x3C3E,0x3E1E,0x763E,0x1E6C,
0x3863,0x671C,0x3C1C,0x781E,0x3E76,0x7777,0x3677,0x3E10,0x2008,0x0000,
0x1000,0x6000,0x0C00,0x0C00,0x6008,0x0830,0x3800,0x0000,0x0000,0x0000,
0x1000,0x0000,0x0000,0x0010,0x0808,0x0070,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x001C,0x1C1C,0x1C1C,0x0000,0x007E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x007E,0x0008,0x1414,0x1E28,0x2804,
0x0810,0x0800,0x0000,0x0004,0x2418,0x2424,0x0C20,0x1024,0x2424,0x0000,
0x0400,0x2024,0x1208,0x1222,0x1212,0x1222,0x2408,0x0428,0x1022,0x3232,
0x1232,0x2422,0x2A24,0x2222,0x1422,0x2210,0x1008,0x0800,0x1000,0x2000,
0x0400,0x1000,0x2000,0x0010,0x0800,0x0000,0x0000,0x0000,0x1000,0x0000,
0x0000,0x0010,0x0808,0x1248,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,
0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x1C1C,0x1C1C,0x1C1C,0x003E,0x0008,0x143E,0x222A,0x2808,0x1008,0x2A08,
0x0000,0x0004,0x2408,0x2404,0x1420,0x2004,0x2424,0x1818,0x0800,0x1004,
0x2618,0x1220,0x1210,0x1020,0x2408,0x0430,0x1036,0x3222,0x1222,0x2420,
0x0824,0x2222,0x1414,0x0410,0x1008,0x1400,0x0818,0x3818,0x1C18,0x101A,
0x3838,0x3812,0x0854,0x5818,0x581A,0x361C,0x3C6C,0x3677,0x3676,0x3C10,
0x0808,0x2A70,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,
0x007E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,
0x1C1C,0x007E,0x0008,0x0014,0x2014,0x1000,0x1008,0x1C08,0x0000,0x0008,
0x2408,0x0418,0x1438,0x3808,0x1824,0x1818,0x103C,0x0808,0x2A14,0x1C20,
0x121C,0x1C20,0x3C08,0x0430,0x1036,0x2A22,0x1222,0x2418,0x0824,0x142A,
0x0814,0x0810,0x0808,0x2200,0x0004,0x2424,0x2424,0x3C24,0x2408,0x0814,
0x082A,0x2424,0x2424,0x1A24,0x1024,0x1422,0x1424,0x2410,0x0808,0x2450,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,
0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,
0x0008,0x0014,0x1C08,0x2C00,0x1008,0x2A3E,0x003E,0x0008,0x2408,0x0804,
0x2404,0x2408,0x241C,0x0000,0x2000,0x0410,0x2A14,0x1220,0x1210,0x1026,
0x2408,0x0428,0x102A,0x2A22,0x1C22,0x3804,0x0824,0x142A,0x0808,0x1010,
0x0808,0x0000,0x001C,0x2420,0x243C,0x1024,0x2408,0x0818,0x082A,0x2424,
0x2424,0x1010,0x1024,0x142A,0x0814,0x0820,0x0004,0x0048,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x007E,0x7E1C,0x1C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x007E,0x0000,0x003E,
0x0214,0x4800,0x1008,0x0808,0x0000,0x0010,0x2408,0x1024,0x3E04,0x2410,
0x2404,0x0000,0x103C,0x0810,0x243C,0x1220,0x1210,0x1022,0x2408,0x2428,
0x102A,0x2622,0x1022,0x2802,0x0824,0x1414,0x1408,0x2010,0x0408,0x0000,
0x0024,0x2420,0x2420,0x1024,0x2408,0x0814,0x082A,0x2424,0x2424,0x1008,
0x1024,0x142A,0x0818,0x1010,0x0808,0x000C,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,0x0000,0x0014,0x222A,0x4800,
0x1008,0x0008,0x1800,0x1810,0x2408,0x2424,0x0424,0x2410,0x2408,0x1818,
0x0800,0x1000,0x1024,0x1222,0x1212,0x1022,0x2408,0x2424,0x1222,0x2626,
0x1022,0x2422,0x0824,0x0814,0x1408,0x2210,0x0408,0x0000,0x0024,0x2424,
0x2424,0x1024,0x2408,0x0814,0x082A,0x2424,0x2424,0x1024,0x1024,0x0814,
0x1408,0x2410,0x0808,0x0012,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,
0x1C1C,0x0000,0x007E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x1C1C,0x1C1C,0x1C1C,0x007E,0x0008,0x0014,0x3C0A,0x3400,0x0810,0x0000,
0x1800,0x1820,0x181C,0x3C18,0x0E18,0x1810,0x1830,0x1818,0x0400,0x2010,
0x0E66,0x3C1C,0x3C3E,0x381C,0x763E,0x186E,0x3E63,0x621C,0x381C,0x663C,
0x1C18,0x0814,0x361C,0x3E10,0x0208,0x003E,0x001A,0x5818,0x1A18,0x3C1C,
0x763E,0x0832,0x3E2A,0x7618,0x381C,0x3838,0x0C1A,0x0814,0x3610,0x3C10,
0x0808,0x0012,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,
0x003E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,
0x1C1C,0x003E,0x0000,0x0000,0x0804,0x0000,0x0810,0x0000,0x0800,0x0020,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0008,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0008,0x0000,0x0000,0x0000,
0x0000,0x0010,0x0208,0x0000,0x0000,0x0000,0x0000,0x0004,0x0000,0x0800,
0x0000,0x0000,0x2004,0x0000,0x0000,0x0000,0x0010,0x0010,0x0808,0x0012,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x007E,0x7E1C,
0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x007E,
0x0000,0x0000,0x0000,0x0000,0x0420,0x0000,0x1000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0010,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0016,0x0000,0x0000,0x0000,0x0000,0x001C,
0x0038,0x0000,0x0000,0x0000,0x0000,0x0038,0x0000,0x3000,0x0000,0x0000,
0x700E,0x0000,0x0000,0x0000,0x0038,0x000C,0x0830,0x000C,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000

#else
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x007E,0x7E1C,
0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0420,0x0000,0x0000,0x0002,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,
0x2038,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x000C,0x0830,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,0x0008,0x1414,
0x0810,0x1004,0x0810,0x0000,0x0000,0x0002,0x1808,0x1818,0x043C,0x0C3C,
0x1818,0x0000,0x0000,0x0018,0x0C08,0x381C,0x383C,0x3C1C,0x241C,0x0E24,
0x1022,0x221C,0x1C1C,0x381C,0x3E24,0x2222,0x2222,0x3E10,0x2008,0x0000,
0x1000,0x2000,0x0400,0x0C00,0x2008,0x0810,0x1800,0x0000,0x0000,0x0000,
0x1000,0x0000,0x0000,0x0010,0x0808,0x0070,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x001C,0x1C1C,0x1C1C,0x0000,0x007E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x007E,0x0008,0x1414,0x1E28,0x2804,
0x0810,0x0800,0x0000,0x0004,0x2418,0x2424,0x0C20,0x1024,0x2424,0x0000,
0x0400,0x2024,0x1208,0x2422,0x2420,0x2022,0x2408,0x0428,0x1022,0x3232,
0x1232,0x2422,0x0824,0x2222,0x1422,0x0210,0x1008,0x0800,0x1000,0x2000,
0x0400,0x1000,0x2000,0x0010,0x0800,0x0000,0x0000,0x0000,0x1000,0x0000,
0x0000,0x0010,0x0808,0x1248,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,
0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x1C1C,0x1C1C,0x1C1C,0x003E,0x0008,0x143E,0x222A,0x2808,0x1008,0x2A08,
0x0000,0x0004,0x2408,0x2404,0x1420,0x2004,0x2424,0x1818,0x0800,0x1004,
0x2618,0x2420,0x2420,0x2020,0x2408,0x0430,0x1036,0x3222,0x1222,0x2420,
0x0824,0x2222,0x1414,0x0410,0x1008,0x1400,0x0818,0x3818,0x1C18,0x101C,
0x3818,0x1812,0x0854,0x5818,0x381C,0x2C18,0x3C24,0x2222,0x2242,0x3C10,
0x0808,0x2A70,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,
0x007E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,
0x1C1C,0x007E,0x0008,0x0014,0x2014,0x1000,0x1008,0x1C08,0x0000,0x0008,
0x2408,0x0418,0x1438,0x3808,0x1824,0x1818,0x103C,0x0808,0x2A14,0x3820,
0x2438,0x3820,0x3C08,0x0430,0x1036,0x2A22,0x1222,0x2418,0x0824,0x142A,
0x0814,0x0810,0x0808,0x2200,0x0004,0x2424,0x2424,0x3C24,0x2408,0x0814,
0x082A,0x2424,0x2424,0x3224,0x1024,0x2222,0x1424,0x0410,0x0808,0x2450,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,
0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,
0x0008,0x0014,0x1C08,0x2C00,0x1008,0x2A3E,0x003E,0x0008,0x2408,0x0804,
0x2404,0x2408,0x241C,0x0000,0x2000,0x0410,0x2A14,0x2420,0x2420,0x2026,
0x2408,0x0428,0x102A,0x2A22,0x1C22,0x3804,0x0824,0x142A,0x0808,0x1010,
0x0808,0x0000,0x001C,0x2420,0x243C,0x1024,0x2408,0x0818,0x082A,0x2424,
0x2424,0x2010,0x1024,0x142A,0x0814,0x0820,0x0004,0x0048,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x007E,0x7E1C,0x1C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x007E,0x0000,0x003E,
0x0214,0x4800,0x1008,0x0808,0x0000,0x0010,0x2408,0x1024,0x3E04,0x2410,
0x2404,0x0000,0x103C,0x0810,0x243C,0x2420,0x2420,0x2022,0x2408,0x2428,
0x102A,0x2622,0x1022,0x2802,0x0824,0x1414,0x1408,0x2010,0x0408,0x0000,
0x0024,0x2420,0x2420,0x1024,0x2408,0x0814,0x082A,0x2424,0x2424,0x2008,
0x1024,0x142A,0x0818,0x1010,0x0808,0x000C,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,
0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,0x0000,0x0014,0x222A,0x4800,
0x1008,0x0008,0x1800,0x1810,0x2408,0x2024,0x0424,0x2410,0x2408,0x1818,
0x0800,0x1000,0x1024,0x2422,0x2420,0x2022,0x2408,0x2424,0x1022,0x2626,
0x1022,0x2422,0x0824,0x0814,0x1408,0x2010,0x0408,0x0000,0x0024,0x2424,
0x2424,0x1024,0x2408,0x0814,0x082A,0x2424,0x2424,0x2024,0x1024,0x0814,
0x1408,0x2010,0x0808,0x0012,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,
0x1C1C,0x0000,0x007E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x1C1C,0x1C1C,0x1C1C,0x007E,0x0008,0x0014,0x3C0A,0x3400,0x0810,0x0000,
0x1800,0x1820,0x181C,0x3C18,0x0418,0x1810,0x1830,0x1818,0x0400,0x2010,
0x0E66,0x381C,0x383C,0x201C,0x241C,0x1824,0x1E22,0x221C,0x101C,0x221C,
0x0818,0x0814,0x2208,0x3E10,0x0208,0x003E,0x001C,0x3818,0x1C18,0x101C,
0x241C,0x0812,0x1C2A,0x2418,0x381C,0x2018,0x0C1A,0x0814,0x2210,0x3C10,
0x0808,0x0012,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,
0x003E,0x7E1C,0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,
0x1C1C,0x003E,0x0000,0x0000,0x0804,0x0000,0x0810,0x0000,0x0800,0x0020,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0008,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0008,0x0000,0x0000,0x0000,
0x0000,0x0010,0x0208,0x0000,0x0000,0x0000,0x0000,0x0004,0x0000,0x0800,
0x0000,0x0000,0x2004,0x0000,0x0000,0x0000,0x0010,0x0010,0x0808,0x0012,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x007E,0x7E1C,
0x1C00,0x0000,0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x007E,
0x0000,0x0000,0x0000,0x0000,0x0420,0x0000,0x1000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0010,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0016,0x0000,0x0000,0x0000,0x0000,0x001C,
0x0038,0x0000,0x0000,0x0000,0x0000,0x0038,0x0000,0x3000,0x0000,0x0000,
0x2004,0x0000,0x0000,0x0000,0x0020,0x000C,0x0830,0x000C,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x001C,0x1C1C,0x1C1C,0x0000,0x003E,0x7E1C,0x1C00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x1C1C,0x1C1C,0x1C1C,0x003E,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000

#endif
};


