/*
 *	8x16 standout (everything is reverse video)
 */
int	f8x16so[] =
{
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFF03,0x01C7,0xC7FF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFF00,0x00FF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFFC7,0xC7C7,
0xC7C7,0xFFFF,0xFF81,0x01C7,0xC7FF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xC7C7,0xC7C7,0xC7C7,0xFF7E,0x00FF,0xFFFF,0xEFFF,0xFFFF,0xFBDF,0xFFFF,
0xFFFF,0xFFFE,0xFFFF,0xFFFF,0xF7FF,0xF3FF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFC3,0xBFC3,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFF1,
0xF78F,0xFF1F,0xFFFF,0xFFFF,0xFFFF,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x002C,0x0100,0x000C,0x9C84,0x000A,0x0000,0x02D0,0x0104,
0x0000,0x0000,0x0101,0x000C,0xAE4E,0x0202,0x0000,0x0534,0x0300,0x0000,
0x0023,0x0200,0x0000,0x0008,0x0300,0x0000,0x002C,0x0300,0x0000,0x0028,
0x0100,0x000C,0x9C84,0x0300,0x0000,0x0029,0x0005,0x0000,0x02D1,0x0104,
0x0000,0x0000,0x0102,0x000C,0xAAF4,0x0202,0x0000,0x0538,0x0100,0x000C,
0xD2D4,0x000A,0x0000,0x02D2,0x0104,0x0000,0x0000,0x0103,0x000C,0xC0B2,
0x0202,0x0000,0x053C,0x0200,0xFFFF,0xFF90,0x0300,0x0000,0x0028,0x0100,
0x000C,0x9D08,0x0300,0x0000,0x0029,0x0300,0x0000,0x002C,0x0100,0x000C,
0x9C84,0x000A,0x0000,0x02D3,0x0104,0x0000,0x0000,0x0101,0x000C,0xAE4E,
0x0202,0x0000,0x0540,0x0300,0x0000,0x0023,0x0200,0x0000,0x007F,0x0300,
0x0000,0x002C,0x0300,0x0000,0x0028,0x0100,0x000C,0x9C84,0x0300,0x0000,
0x0029,0x0005,0x0000,0x02D4,0x0104,0x0000,0x0000,0x0102,0x000C,0xAC12,
0x0202,0x0000,0x0544,0x0100,0x000C,0xD2EA,0x000A,0x0000,0x02D6,0x0104,
0x000C,0xD2D4,0x0103,0x000C,0xC0B2,0x0202,0x0000,0x0548,0x0200,0xFFFF,
0xFF90,0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,
0x0300,0x0000,0x002C,0x0100,0x000C,0x9C84,0x0007,0x0000,0x02D7,0x0102,
0x0000,0x0000,0x0101,0x000C,0xAE38,0x0202,0x0000,0x054C,0x0300,0x0000,
0x0028,0x0100,0x000C,0x9C84,0x0300,0x0000,0x0029,0x000B,0x0000,0x02D8,
0x0104,0x0000,0x0000,0x0103,0x000C,0xC540,0x0202,0x0000,0x054E,0x0300,
0x0000,0x0023,0x0200,0x0000,0x0001,0x0300,0x0000,0x002C,0x0200,0xFFFF,
0xFF90,0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,
0x000B,0x0000,0x02DB,0x0106,0x0000,0x0000,0x0102,0x000C,0xAE4E,0x0202,
0x0000,0x0552,0x0300,0x0000,0x0023,0x0200,0x0000,0x0001,0x0300,0x0000,
0x002C,0x0200,0xFFFF,0xFF8C,0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,
0x0300,0x0000,0x0029,0x0005,0x0000,0x02DC,0x0104,0x0000,0x0000,0x0102,
0x000C,0xABE6,0x0202,0x0000,0x0558,0x0100,0x000C,0xD300,0x0005,0x0000,
0x02DF,0x0106,0x0000,0x0000,0x0102,0x000C,0xC02E,0x0202,0x0000,0x055C,
0x0100,0x000C,0xD1B6,0x000B,0x0000,0x02E1,0x0104,0x0000,0x0000,0x0102,
0x000C,0xC540,0x0202,0x0000,0x0562,0x0300,0x0000,0x0023,0x0200,0x0000,
0x0001,0x0300,0x0000,0x002C,0x0200,0xFFFF,0xFF8C,0x0300,0x0000,0x0028,
0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,0x0008,0x0000,0x02E6,0x0104,
0x000C,0xD300,0x0102,0x000C,0xC792,0x0202,0x0000,0x0566,0x0200,0xFFFF,
0xFF8C,0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,
0x0005,0x0000,0x02E7,0x0104,0x0000,0x0000,0x0102,0x000C,0xAB20,0x0202,
0x0000,0x056A,0x0100,0x000C,0xD316,0x0008,0x0000,0x02E9,0x0104,0x0000,
0x0000,0x0102,0x000C,0xAE38,0x0202,0x0000,0x056E,0x0200,0xFFFF,0xFF8C,
0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,0x0007,
0x0000,0x02EF,0x0102,0x000C,0xD316,0x0103,0x000C,0xC0B2,0x0202,0x0000,
0x0572,0x0100,0x000C,0x9D08,0x0300,0x0000,0x002C,0x0100,0x000C,0x9BD4,
0x0009,0x0000,0x02F0,0x0106,0x0000,0x0000,0x0103,0x000C,0xA9D6,0x0202,
0x0000,0x0574,0x0300,0x0000,0x0023,0x0300,0x0000,0x002D,0x0200,0x0000,
0x006C,0x0300,0x0000,0x002C,0x0100,0x000C,0x9BD4,0x000A,0x0000,0x02F1,
0x0104,0x0000,0x0000,0x0103,0x000C,0xAE4E,0x0202,0x0000,0x057A,0x0200,
0xFFFF,0xFF90,0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,0x0300,0x0000,
0x0029,0x0300,0x0000,0x002C,0x0100,0x000C,0x9BD4,0x0005,0x0000,0x02F2,
0x0104,0x0000,0x0000,0x0102,0x000C,0xAB8E,0x0202,0x0000,0x057E,0x0100,
0x000C,0xD32C,0x000A,0x0000,0x02F4,0x0104,0x0000,0x0000,0x0102,0x000C,
0xC05A,0x0202,0x0000,0x0582,0x0200,0xFFFF,0xFF94,0x0300,0x0000,0x0028,
0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,0x0300,0x0000,0x002C,0x0100,
0x000C,0x9C84,0x000A,0x0000,0x02F5,0x0104,0x0000,0x0000,0x0103,0x000C,
0xC0B2,0x0202,0x0000,0x0586,0x0100,0x000C,0x9C84,0x0300,0x0000,0x002C,
0x0200,0xFFFF,0xFF90,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0x0001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0x0001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,0x0000,0xE001,
0x0000,0xE000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x110C,0x000A,0x4E53,0x3858,0x3136,
0x5249,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x00FF,0x000D,0x000B,0x0008,0x0002,0x0002,
0x0007,0x0008,0x0001,0x0007,0x0001,0x0001,0x5555,0x5555,0x000C,0x0000,
0x0000,0x0006,0x6452,0x0006,0x6656,0x0100,0x0010,0x0000,0x0000,0x0000,
0x0008,0x0010,0x0018,0x0020,0x0028,0x0030,0x0038,0x0040,0x0048,0x0050,
0x0058,0x0060,0x0068,0x0070,0x0078,0x0080,0x0088,0x0090,0x0098,0x00A0,
0x00A8,0x00B0,0x00B8,0x00C0,0x00C8,0x00D0,0x00D8,0x00E0,0x00E8,0x00F0,
0x00F8,0x0100,0x0108,0x0110,0x0118,0x0120,0x0128,0x0130,0x0138,0x0140,
0x0148,0x0150,0x0158,0x0160,0x0168,0x0170,0x0178,0x0180,0x0188,0x0190,
0x0198,0x01A0,0x01A8,0x01B0,0x01B8,0x01C0,0x01C8,0x01D0,0x01D8,0x01E0,
0x01E8,0x01F0,0x01F8,0x0200,0x0208,0x0210,0x0218,0x0220,0x0228,0x0230,
0x0238,0x0240,0x0248,0x0250,0x0258,0x0260,0x0268,0x0270,0x0278,0x0280,
0x0288,0x0290,0x0298,0x02A0,0x02A8,0x02B0,0x02B8,0x02C0,0x02C8,0x02D0,
0x02D8,0x02E0,0x02E8,0x02F0,0x02F8,0x0300,0x0308,0x0310,0x0318,0x0320,
0x0328,0x0330,0x0338,0x0340,0x0348,0x0350,0x0358,0x0360,0x0368,0x0370,
0x0378,0x0380,0x0388,0x0390,0x0398,0x03A0,0x03A8,0x03B0,0x03B8,0x03C0,
0x03C8,0x03D0,0x03D8,0x03E0,0x03E8,0x03F0,0x03F8,0x0400,0x0408,0x0410,
0x0418,0x0420,0x0428,0x0430,0x0438,0x0440,0x0448,0x0450,0x0458,0x0460,
0x0468,0x0470,0x0478,0x0480,0x0488,0x0490,0x0498,0x04A0,0x04A8,0x04B0,
0x04B8,0x04C0,0x04C8,0x04D0,0x04D8,0x04E0,0x04E8,0x04F0,0x04F8,0x0500,
0x0508,0x0510,0x0518,0x0520,0x0528,0x0530,0x0538,0x0540,0x0548,0x0550,
0x0558,0x0560,0x0568,0x0570,0x0578,0x0580,0x0588,0x0590,0x0598,0x05A0,
0x05A8,0x05B0,0x05B8,0x05C0,0x05C8,0x05D0,0x05D8,0x05E0,0x05E8,0x05F0,
0x05F8,0x0600,0x0608,0x0610,0x0618,0x0620,0x0628,0x0630,0x0638,0x0640,
0x0648,0x0650,0x0658,0x0660,0x0668,0x0670,0x0678,0x0680,0x0688,0x0690,
0x0698,0x06A0,0x06A8,0x06B0,0x06B8,0x06C0,0x06C8,0x06D0,0x06D8,0x06E0,
0x06E8,0x06F0,0x06F8,0x0700,0x0708,0x0710,0x0718,0x0720,0x0728,0x0730,
0x0738,0x0740,0x0748,0x0750,0x0758,0x0760,0x0768,0x0770,0x0778,0x0780,
0x0788,0x0790,0x0798,0x07A0,0x07A8,0x07B0,0x07B8,0x07C0,0x07C8,0x07D0,
0x07D8,0x07E0,0x07E8,0x07F0,0x07F8,0x0800,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFF03,0x01C7,0xC7FF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFF00,0x00FF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0xFFC7,0xC7C7,0xC7C7,0xFFFF,0xFF81,0x01C7,
0xC7FF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xC7C7,0xC7C7,0xC7C7,0xFF7E,
0x00FF,0xFFFF,0xEFFF,0xFFFF,0xFBDF,0xFFFF,0xFFFF,0xFFFE,0xFFFF,0xFFFF,
0xF7FF,0xF3FF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFC3,
0xBFC3,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,
0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFF1,0xF78F,0xFF1F,0xFFFF,0xFFFF,
0xFFFF,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x002C,0x0100,
0x000C,0x9C84,0x000A,0x0000,0x02D0,0x0104,0x0000,0x0000,0x0101,0x000C,
0xAE4E,0x0202,0x0000,0x0534,0x0300,0x0000,0x0023,0x0200,0x0000,0x0008,
0x0300,0x0000,0x002C,0x0300,0x0000,0x0028,0x0100,0x000C,0x9C84,0x0300,
0x0000,0x0029,0x0005,0x0000,0x02D1,0x0104,0x0000,0x0000,0x0102,0x000C,
0xAAF4,0x0202,0x0000,0x0538,0x0100,0x000C,0xD2D4,0x000A,0x0000,0x02D2,
0x0104,0x0000,0x0000,0x0103,0x000C,0xC0B2,0x0202,0x0000,0x053C,0x0200,
0xFFFF,0xFF90,0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,0x0300,0x0000,
0x0029,0x0300,0x0000,0x002C,0x0100,0x000C,0x9C84,0x000A,0x0000,0x02D3,
0x0104,0x0000,0x0000,0x0101,0x000C,0xAE4E,0x0202,0x0000,0x0540,0x0300,
0x0000,0x0023,0x0200,0x0000,0x007F,0x0300,0x0000,0x002C,0x0300,0x0000,
0x0028,0x0100,0x000C,0x9C84,0x0300,0x0000,0x0029,0x0005,0x0000,0x02D4,
0x0104,0x0000,0x0000,0x0102,0x000C,0xAC12,0x0202,0x0000,0x0544,0x0100,
0x000C,0xD2EA,0x000A,0x0000,0x02D6,0x0104,0x000C,0xD2D4,0x0103,0x000C,
0xC0B2,0x0202,0x0000,0x0548,0x0200,0xFFFF,0xFF90,0x0300,0x0000,0x0028,
0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,0x0300,0x0000,0x002C,0x0100,
0x000C,0x9C84,0x0007,0x0000,0x02D7,0x0102,0x0000,0x0000,0x0101,0x000C,
0xAE38,0x0202,0x0000,0x054C,0x0300,0x0000,0x0028,0x0100,0x000C,0x9C84,
0x0300,0x0000,0x0029,0x000B,0x0000,0x02D8,0x0104,0x0000,0x0000,0x0103,
0x000C,0xC540,0x0202,0x0000,0x054E,0x0300,0x0000,0x0023,0x0200,0x0000,
0x0001,0x0300,0x0000,0x002C,0x0200,0xFFFF,0xFF90,0x0300,0x0000,0x0028,
0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,0x000B,0x0000,0x02DB,0x0106,
0x0000,0x0000,0x0102,0x000C,0xAE4E,0x0202,0x0000,0x0552,0x0300,0x0000,
0x0023,0x0200,0x0000,0x0001,0x0300,0x0000,0x002C,0x0200,0xFFFF,0xFF8C,
0x0300,0x0000,0x0028,0x0100,0x000C,0x9D08,0x0300,0x0000,0x0029,0x0005,
0x0000,0x02DC,0x0104,0x0000,0x0000,0x0102,0x000C,0xABE6,0x0202,0x0000,
0x0558,0x0100,0x000C,0xD300,0x0005,0x0000,0x02DF,0x0106,0x0000,0x0000,
0x0102,0x000C,0xC02E,0x0202,0x0000,0x055C,0x0100,0x000C,0xD1B6,0x000B,
0x0000,0x02E1,0x0104,0x0000,0x0000,0x0102,0x000C,0xC540,0x0202,0x0000,
0x0562,0x0300,0x0000,0x0023,0x0200,0x0000,0x0001,0x0300,0x0000,0x002C,
0x0200,0xFFFF,0xFF8C,0x0300,0x0000,0x0028,0x0100,0x000C,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000

};


