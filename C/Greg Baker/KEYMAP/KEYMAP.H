char normal[128] = {           /* @FC2034 */
	0x00,0x1B,0x31,0x32,0x33,0x34,0x35,0x36	/* 00 - 07 */
	0x37,0x38,0x39,0x30,0x2D,0x3D,0x08,0x09	/* 08 - 0F */
	0x71,0x77,0x65,0x72,0x74,0x79,0x75,0x69	/* 10 - 17 */
	0x6F,0x70,0x5B,0x5D,0x0D,0x00,0x61,0x73	/* 18 - 1F */
	0x64,0x66,0x67,0x68,0x6A,0x6B,0x6C,0x3B	/* 20 - 27 */
	0x27,0x60,0x00,0x5C,0x7A,0x78,0x63,0x76	/* 28 - 2F */
	0x62,0x6E,0x6D,0x2C,0x2E,0x2F,0x00,0x00	/* 30 - 37 */
	0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00	/* 38 - 3F */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 40 - 47 */
	0x00,0x00,0x2D,0x00,0x00,0x00,0x2B,0x00	/* 48 - 4F */
	0x00,0x00,0x00,0x7F,0x00,0x00,0x00,0x00	/* 50 - 57 */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 58 - 5F */
	0x00,0x00,0x00,0x28,0x29,0x2F,0x2A,0x37	/* 60 - 67 */
	0x38,0x39,0x34,0x35,0x36,0x31,0x32,0x33	/* 68 - 6F */
	0x30,0x2E,0x0D,0x00,0x00,0x00,0x00,0x00	/* 70 - 77 */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 78 - 7F */
};
char shifted[128] = {           /* @FC20B4 */
	0x00,0x1B,0x21,0x40,0x23,0x24,0x25,0x5E	/* 00 - 07 */
	0x26,0x2A,0x28,0x29,0x5F,0x2B,0x08,0x09	/* 08 - 0F */
	0x51,0x57,0x45,0x52,0x54,0x59,0x55,0x49	/* 10 - 17 */
	0x4F,0x50,0x7B,0x7D,0x0D,0x00,0x41,0x53	/* 18 - 1F */
	0x44,0x46,0x47,0x48,0x4A,0x4B,0x4C,0x3A	/* 20 - 27 */
	0x22,0x7E,0x00,0x7C,0x5A,0x58,0x43,0x56	/* 28 - 2F */
	0x42,0x4E,0x4D,0x3C,0x3E,0x3F,0x00,0x00	/* 30 - 37 */
	0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00	/* 38 - 3F */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x37	/* 40 - 47 */
	0x38,0x00,0x2D,0x34,0x00,0x36,0x2B,0x00	/* 48 - 4F */
	0x32,0x00,0x30,0x7F,0x00,0x00,0x00,0x00	/* 50 - 57 */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 58 - 5F */
	0x00,0x00,0x00,0x28,0x29,0x2F,0x2A,0x37	/* 60 - 67 */
	0x38,0x39,0x34,0x35,0x36,0x31,0x32,0x33	/* 68 - 6F */
	0x30,0x2E,0x0D,0x00,0x00,0x00,0x00,0x00	/* 70 - 77 */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 78 - 7F */
};
char capslock[128] = {           /* @FC2134 */
	0x00,0x1B,0x31,0x32,0x33,0x34,0x35,0x36	/* 00 - 07 */
	0x37,0x38,0x39,0x30,0x2D,0x3D,0x08,0x09	/* 08 - 0F */
	0x51,0x57,0x45,0x52,0x54,0x59,0x55,0x49	/* 10 - 17 */
	0x4F,0x50,0x5B,0x5D,0x0D,0x00,0x41,0x53	/* 18 - 1F */
	0x44,0x46,0x47,0x48,0x4A,0x4B,0x4C,0x3B	/* 20 - 27 */
	0x27,0x60,0x00,0x5C,0x5A,0x58,0x43,0x56	/* 28 - 2F */
	0x42,0x4E,0x4D,0x2C,0x2E,0x2F,0x00,0x00	/* 30 - 37 */
	0x00,0x20,0x00,0x00,0x00,0x00,0x00,0x00	/* 38 - 3F */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 40 - 47 */
	0x00,0x00,0x2D,0x00,0x00,0x00,0x2B,0x00	/* 48 - 4F */
	0x00,0x00,0x00,0x7F,0x00,0x00,0x00,0x00	/* 50 - 57 */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 58 - 5F */
	0x00,0x00,0x00,0x28,0x29,0x2F,0x2A,0x37	/* 60 - 67 */
	0x38,0x39,0x34,0x35,0x36,0x31,0x32,0x33	/* 68 - 6F */
	0x30,0x2E,0x0D,0x00,0x00,0x00,0x00,0x00	/* 70 - 77 */
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00	/* 78 - 7F */
};
