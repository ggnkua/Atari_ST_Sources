/*----------------------------------------------------------------------------------------
	tos.h, part of TOS Linker for CodeWarrior

	all system calls for TOS
	
	20.1.2000 by Manfred Lippert

	last change: 20.1.2000

	Don't edit this file.

	If you have to make any changes on this file, please contact:
	mani@mani.de
----------------------------------------------------------------------------------------*/

#ifndef __TOS_h__
#define __TOS_h__

#include <.\bios\bios.h>
#include <xbios.h>
#include <gemdos.h>
#include <vdi.h>
#include <aes.h>

#endif
