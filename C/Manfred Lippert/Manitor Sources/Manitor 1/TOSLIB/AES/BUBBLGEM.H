/*----------------------------------------------------------------------------------------
	bubblgem.h, part of TOS Linker for CodeWarrior

	BubbleGEM protocol messages and defines
	
	08.11.1998 by Manfred Lippert

	last change: 17.11.1998

	Don't edit this file.

	If you have to make any changes on this file, please contact:
	mani@mani.de
----------------------------------------------------------------------------------------*/

#ifndef __BUBBLEGEM_MSG_H__
#define __BUBBLEGEM_MSG_H__

#define BUBBLEGEM_REQUEST	0xBABA
#define BUBBLEGEM_SHOW 	 	0xBABB
#define BUBBLEGEM_ACK   	0xBABC
#define BUBBLEGEM_ASKFONT	0xBABD
#define BUBBLEGEM_FONT		0xBABE

#define BGS7_USRHIDE		0x0001
#define BGS7_MOUSE			0x0004

#endif
