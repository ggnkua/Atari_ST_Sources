#ifndef __Manitor_GemdosTrace_h__
#define __Manitor_GemdosTrace_h__

#include <trapper.h>

extern int32 CDECL GemdosCallTrace(int16 *para, int16 *call_original, int16 super_called);
extern int32 CDECL GemdosReturnTrace(int32 ret, int16 *para, int16 is_super);

#endif
