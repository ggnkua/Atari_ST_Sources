/*----------------------------------------------------------------------------------------
	StdAllocator.h, standard allocator (normally uses Std-C malloc/free/realloc)
	
	20.7.2001 by Manfred Lippert, mani@mani.de

	last change: 20.7.2001
----------------------------------------------------------------------------------------*/

#ifndef __ManiLibs_StdAllocator_h__
#define __ManiLibs_StdAllocator_h__

#include <Allocator.h>

class StdAllocator : public Allocator {
public:
	virtual void *allocate(size_t bytes);
	virtual void deallocate(void *addr);
	virtual void *reallocate(void *addr, size_t bytes);
};

#endif
