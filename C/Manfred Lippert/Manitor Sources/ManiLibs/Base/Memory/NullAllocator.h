/*----------------------------------------------------------------------------------------
	NullAllocator.h, null allocator (does nothing)
	
	20.7.2001 by Manfred Lippert, mani@mani.de

	last change: 20.7.2001
----------------------------------------------------------------------------------------*/

#ifndef __ManiLibs_NullAllocator_h__
#define __ManiLibs_NullAllocator_h__

#include <Allocator.h>

class NullAllocator : public Allocator {
public:
	virtual void *allocate(size_t bytes);
	virtual void deallocate(void *addr);
	virtual void *reallocate(void *addr, size_t bytes);
};

#endif
