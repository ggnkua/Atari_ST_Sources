/*----------------------------------------------------------------------------------------
	StdMemBlock.h, class for handling memory blocks, using malloc/free/realloc
	
	4.6.2000 by Manfred Lippert, mani@mani.de

	last change: 13.6.2000
----------------------------------------------------------------------------------------*/

#ifndef __ManiLibs_StdMemBlock_h__
#define __ManiLibs_StdMemBlock_h__

#include <MemBlock.h>

class StdMemBlock : public MemBlock {
	void *adr;
	size_t size;
public:
	StdMemBlock();
	virtual ~StdMemBlock();
	virtual void *get_adr();
	virtual size_t get_size();
	virtual void *set_size(size_t size);
	virtual void free();
};

#endif
