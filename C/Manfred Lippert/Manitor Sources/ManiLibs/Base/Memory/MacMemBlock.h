/*----------------------------------------------------------------------------------------
	MacMemBlock.h, class for handling memory blocks, using Mac Handles
	
	20.6.2000 by Manfred Lippert, mani@mani.de

	last change: 20.6.2000
----------------------------------------------------------------------------------------*/

#ifndef __ManiLibs_MacMemBlock_h__
#define __ManiLibs_MacMemBlock_h__

#include <Types2B.h>
#include <MemBlock.h>
#include <MacMemory.h>

#if !TARGET_MACOS
	#error MacMemBlock.h used in Non-Mac Project
#endif

class MacMemBlock : public MemBlock {
	Handle hnd;
	bool locked;
public:
	MacMemBlock();
	virtual ~MacMemBlock();
	virtual void *get_adr();
	virtual size_t get_size();
	virtual void *set_size(size_t size);
	virtual void free();
	void lock();
	void unlock();
	bool is_locked() const {return locked;};
};

#endif
