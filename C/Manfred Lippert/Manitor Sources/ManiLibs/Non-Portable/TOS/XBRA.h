/*----------------------------------------------------------------------------------------
	XBRA.h, hanging in vectors via XBRA method
	
	?.?.1998 by Manfred Lippert, mani@mani.de

	last change: 20.1.2000
----------------------------------------------------------------------------------------*/

#ifndef __ManiLibs_XBRA_H__
#define __ManiLibs_XBRA_H__

/*
	ACHTUNG!!! Einige Funktionen nicht reentrant!!! (also nicht thread-fest)
*/

#ifndef __PORTAB__
#include <portab.h>
#endif

typedef void (*xbra_function)();

typedef struct {
	int32 xbra;
	int32 id;
	xbra_function old;
} XBRA;

/* Aus Supermode Funktion installieren: */
extern C_CALL void install_XBRA_super(XBRA *the_xbra, xbra_function *the_vector);

/* Aus Usermode Funktion installieren: (Nicht reentrant!) */
extern C_CALL void install_XBRA_user(XBRA *the_xbra, xbra_function *the_vector);

/* Aus Supermode checken, ob Funktion noch per XBRA eingeklinkt ist: */
extern C_CALL bool check_XBRA_super(XBRA *the_xbra, xbra_function *vector);

/* Aus Usermode checken, ob Funktion noch per XBRA eingeklinkt ist: (Nicht reentrant!) */
extern C_CALL bool check_XBRA_user(XBRA *the_xbra, xbra_function *vector);

/* XBRA-Funktion aus Supermode ausklinken: */
extern C_CALL bool remove_XBRA_super(XBRA *the_xbra, xbra_function *vector);

/* XBRA-Funktion aus Usermode ausklinken: (Nicht reentrant!) */
extern C_CALL bool remove_XBRA_user(XBRA *the_xbra, xbra_function *vector);

#endif
