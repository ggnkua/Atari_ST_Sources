/* Resource Datei Indizes f�r X_LOGO */

#define LOGO     0   /* Formular/Dialog */
