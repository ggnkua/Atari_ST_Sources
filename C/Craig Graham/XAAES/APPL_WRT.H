#ifndef _APPL_WRT_H_
#define _APPL_WRT_H_

unsigned long XA_appl_write(short clnt_pid, AESPB *pb);

#endif
