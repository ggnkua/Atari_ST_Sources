#ifndef _RESZWIDG_H_
#define _RESZWIDG_H_

short drag_resize(XA_WINDOW *wind, XA_WIDGET *widg);
short display_resize(XA_WINDOW *wind, XA_WIDGET *widg);

#endif