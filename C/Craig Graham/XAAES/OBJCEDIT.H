#ifndef _OBJCEDIT_H_
#define _OBJCEDIT_H_

#include "K_DEFS.H"

unsigned long XA_objc_edit(short clnt_pid, AESPB *pb);

#endif