#ifndef _APPL_INI_H_
#define _APPL_INI_H_
#include "K_DEFS.H"

unsigned long XA_appl_init(short clnt_pid, AESPB *pb);
unsigned long XA_appl_exit(short clnt_pid, AESPB *pb);

#endif
