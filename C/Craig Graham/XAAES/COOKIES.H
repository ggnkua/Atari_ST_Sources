#ifndef _COOKIES_H_
#define _COOKIES_H_

short GetCookie(long code,long *value);

#endif
