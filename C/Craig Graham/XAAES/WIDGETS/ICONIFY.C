/* GEM Icon Definition: */
#define ICON_W 0x0010
#define ICON_H 0x0010
#define DATASIZE 0x0010
UWORD iconify[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x9FE3, 
  0x9023, 0x9023, 0x9023, 0x91F3, 
  0x9113, 0x9113, 0x9F13, 0x81F3, 
  0x8003, 0x8003, 0xBFFF, 0xFFFF
};
