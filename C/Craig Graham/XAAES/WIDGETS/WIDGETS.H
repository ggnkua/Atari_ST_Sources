/* Resource Datei Indizes f�r WIDGETS */

#define WIDGETS  0   /* Formular/Dialog */
#define WIDG_SIZER 1   /* USERDEF in Baum WIDGETS */
#define WIDG_XAAES 2   /* USERDEF in Baum WIDGETS */
#define WIDG_CLOSE 3   /* USERDEF in Baum WIDGETS */
#define WIDG_UP_ARROW 5   /* USERDEF in Baum WIDGETS */
#define WIDG_DOWN_ARROW 6   /* USERDEF in Baum WIDGETS */
#define WIDG_LEFT_ARROW 7   /* USERDEF in Baum WIDGETS */
#define WIDG_RIGHT_ARROW 8   /* USERDEF in Baum WIDGETS */
#define WIDG_ICONIFY 9   /* USERDEF in Baum WIDGETS */
#define WIDG_HSLIDER 10  /* USERDEF in Baum WIDGETS */
#define WIDG_VSLIDER 11  /* USERDEF in Baum WIDGETS */
#define WIDG_FULL 13  /* USERDEF in Baum WIDGETS */
#define HSL      31  /* USERDEF in Baum WIDGETS */

#define WIDGETS_MONO 1   /* Formular/Dialog */
