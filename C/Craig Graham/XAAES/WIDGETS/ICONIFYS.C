/* GEM Icon Definition: */
#define ICON_W 0x0010
#define ICON_H 0x0010
#define DATASIZE 0x0010
UWORD iconifys[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC001, 
  0xCFF1, 0xC811, 0xC811, 0xC811, 
  0xC8F9, 0xC889, 0xC889, 0xCF89, 
  0xC0F9, 0xC001, 0xC001, 0xFFFF
};
