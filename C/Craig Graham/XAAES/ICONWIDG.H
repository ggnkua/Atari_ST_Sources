#ifndef _ICONWIDG_H_
#define _ICONWIDG_H_

short click_iconify(XA_WINDOW *wind, XA_WIDGET *widg);
short display_iconify(XA_WINDOW *wind, XA_WIDGET *widg);

#endif