#ifndef _DRAG_BOX_H_
#define _DRAG_BOX_H_

void drag_box(short w, short h, short xs, short ys, short bx, short by, short bw, short bh, short *xe, short *ye);
void rubber_box(short sx, short sy, short minw, short minh, short *lastw, short *lasth);

#endif
