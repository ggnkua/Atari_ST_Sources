#ifndef _EVNT_MES_H_
#define _EVNT_MES_H_

unsigned long XA_evnt_mesag(short clnt_pid, AESPB *pb);

#endif