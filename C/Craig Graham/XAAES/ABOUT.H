#ifndef _ABOUT_H_
#define _ABOUT_H_

void open_about(void);

#endif