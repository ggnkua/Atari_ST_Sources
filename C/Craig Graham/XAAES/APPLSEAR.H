#ifndef _APPLSEAR_H_
#define _APPLSEAR_H_

unsigned long XA_appl_search(short clnt_pid, AESPB *pb);

#endif
