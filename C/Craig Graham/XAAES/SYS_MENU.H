#ifndef _SYS_MENU_H_
#define _SYS_MENU_H_

void do_system_menu(short clicked_title, short menu_item);

#endif