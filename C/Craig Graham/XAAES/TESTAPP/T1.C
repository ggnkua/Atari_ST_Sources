#include <aes.h>

OBJECT FORM1[] = {
/*0*/	{-1,1,18,G_BOX,0x0,0x0,(void *)0x11178,0,0,1041,14},
/*1*/	{2,-1,-1,G_BOX,0x0,0x0,(void *)0xff1141,1,2048,2,1},
/*2*/	{3,-1,-1,G_BOX,0x0,0x0,(void *)0xff1142,1,2,2,1},
/*3*/	{4,-1,-1,G_BOX,0x0,0x0,(void *)0xff1153,1,2051,2,1},
/*4*/	{5,-1,-1,G_BOX,0x0,0x0,(void *)0xff1144,1,5,2,1},
/*5*/	{6,-1,-1,G_BOX,0x0,0x0,(void *)0xff1145,1,2054,2,1},
/*6*/	{7,-1,-1,G_BOX,0x0,0x0,(void *)0xff1146,1,8,2,1},
/*7*/	{8,-1,-1,G_BOX,0x0,0x0,(void *)0xff1147,1,2057,2,1},
/*8*/	{9,-1,-1,G_BOX,0x0,0x0,(void *)0xff1148,1,11,2,1},
/*9*/	{10,-1,-1,G_BOX,0x0,0x0,(void *)0xff1149,1,2060,2,1},
/*10*/	{11,-1,-1,G_BOX,0x0,0x0,(void *)0xff117a,1038,2048,2,1},
/*11*/	{12,-1,-1,G_BOX,0x0,0x0,(void *)0xff114b,1038,2,2,1},
/*12*/	{13,-1,-1,G_BOX,0x0,0x0,(void *)0xff114c,1038,2051,2,1},
/*13*/	{14,-1,-1,G_BOX,0x0,0x0,(void *)0xff112d,1038,5,2,1},
/*14*/	{15,-1,-1,G_BOX,0x0,0x0,(void *)0xff114e,1038,2054,2,1},
/*15*/	{16,-1,-1,G_BOX,0x0,0x0,(void *)0xff113f,1038,8,2,1},
/*16*/	{17,-1,-1,G_BOX,0x0,0x0,(void *)0xff1162,1038,2057,2,1},
/*17*/	{18,-1,-1,G_BOX,0x0,0x0,(void *)0xff1153,1038,11,2,1},
/*18*/	{0,-1,-1,G_BOX,0x20,0x0,(void *)0xff1114,1038,2060,2,1},
};

OBJECT FORM2[] = {
/*0*/	{-1,-1,-1,G_BOX,0x20,0x10,(void *)0x21100,0,0,52,9},
};



static void fix_tree(OBJECT *s,int max)
{
	int i;

	for(i=0; i<=max; i++)
		rsrc_obfix(s,i);
}

void rsrc_init(void)
{
	fix_tree(FORM1,18);
	fix_tree(FORM2,0);
}
