/* Resource Datei Indizes f�r T1 */

#define FORM1    0   /* Formular/Dialog */
