/*
 * XaAES - XaAES Ain't the AES
 *
 * A multitasking AES replacement for MiNT
 *
 */
#ifndef _MOUSE_CL_H_
#define _MOUSE_CL_H_
#include "KERNAL.H"

short XA_button_event(MOUSE_DATA *pb);

#endif

