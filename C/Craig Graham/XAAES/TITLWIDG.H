#ifndef _TITLWIDG_H_
#define _TITLWIDG_H_

short display_title(XA_WINDOW *wind, XA_WIDGET *widg);
short drag_title(XA_WINDOW *wind, XA_WIDGET *widg);
short click_title(XA_WINDOW *wind, XA_WIDGET *widg);
short dclick_title(XA_WINDOW *wind, XA_WIDGET *widg);

#endif