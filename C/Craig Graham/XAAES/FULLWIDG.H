#ifndef _FULLWIDG_H_
#define _FULLWIDG_H_

short click_full(XA_WINDOW *wind, XA_WIDGET *widg);
short display_full(XA_WINDOW *wind, XA_WIDGET *widg);

#endif