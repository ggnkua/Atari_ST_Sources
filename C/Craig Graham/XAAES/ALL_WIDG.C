/*
 * XaAES - XaAES Ain't the AES
 *
 * A multitasking AES replacement for MiNT
 *
 */

/*
	Bitmaps for the standard GEM window widgets
	- now mono & colour sets
*/

#include "ALL_WIDG.H"

#if MONO_WIDGETS

/* Mario Becroft's mono widget set */

unsigned short widget_bitmap_close[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x8003, 
  0x8003, 0x8663, 0x87E3, 0x83C3, 
  0x83C3, 0x87E3, 0x8663, 0x8003, 
  0x8003, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_close_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC1C1, 
  0xC7F1, 0xCF79, 0xCE39, 0xDE3D, 
  0xDE3D, 0xDF7D, 0xCFF9, 0xCE39, 
  0xC771, 0xC1C1, 0xC001, 0xFFFF
};

unsigned short widget_bitmap_full[DATASIZE] =
{ 0xFFFF, 0x8003, 0xB83B, 0xA44B, 
  0xA28B, 0x9113, 0x8823, 0x8443, 
  0x8823, 0x9113, 0xA28B, 0xA44B, 
  0xB83B, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_full_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xDC1D, 
  0xD225, 0xD145, 0xC889, 0xC411, 
  0xC221, 0xC411, 0xC889, 0xD145, 
  0xD225, 0xDC1D, 0xC001, 0xFFFF
};

unsigned short widget_bitmap_size[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x8003, 
  0x8F83, 0x8F03, 0x8F03, 0x8F93, 
  0x89F3, 0x80F3, 0x80F3, 0x81F3, 
  0x8003, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_size_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC001, 
  0xC001, 0xC7C1, 0xC781, 0xC781, 
  0xC7C9, 0xC4F9, 0xC079, 0xC079, 
  0xC0F9, 0xC001, 0xC001, 0xFFFF
};

unsigned short widget_bitmap_left[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x8063, 
  0x80E3, 0x81E3, 0x83E3, 0x87E3, 
  0x87E3, 0x83E3, 0x81E3, 0x80E3, 
  0x8063, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_left_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC001, 
  0xC031, 0xC071, 0xC0F1, 0xC1F1, 
  0xC3F1, 0xC3F1, 0xC1F1, 0xC0F1, 
  0xC071, 0xC031, 0xC001, 0xFFFF
};

unsigned short widget_bitmap_right[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x8603, 
  0x8703, 0x8783, 0x87C3, 0x87E3, 
  0x87E3, 0x87C3, 0x8783, 0x8703, 
  0x8603, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_right_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC001, 
  0xC301, 0xC381, 0xC3C1, 0xC3E1, 
  0xC3F1, 0xC3F1, 0xC3E1, 0xC3C1, 
  0xC381, 0xC301, 0xC001, 0xFFFF
};

unsigned short widget_bitmap_up[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x8003, 
  0x8003, 0x8183, 0x83C3, 0x87E3, 
  0x8FF3, 0x9FFB, 0x9FFB, 0x8003, 
  0x8003, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_up_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC001, 
  0xC001, 0xC001, 0xC0C1, 0xC1E1, 
  0xC3F1, 0xC7F9, 0xCFFD, 0xCFFD, 
  0xC001, 0xC001, 0xC001, 0xFFFF
};

unsigned short widget_bitmap_down[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x8003, 
  0x8003, 0x9FFB, 0x9FFB, 0x8FF3, 
  0x87E3, 0x83C3, 0x8183, 0x8003, 
  0x8003, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_down_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC001, 
  0xC001, 0xC001, 0xCFFD, 0xCFFD, 
  0xC7F9, 0xC3F1, 0xC1E1, 0xC0C1, 
  0xC001, 0xC001, 0xC001, 0xFFFF
};

unsigned short widget_bitmap_iconify[DATASIZE] =
{ 0xFFFF, 0x8001, 0x8003, 0x9FE3, 
  0x9023, 0x9023, 0x9023, 0x91F3, 
  0x9113, 0x9113, 0x9F13, 0x81F3, 
  0x8003, 0x8003, 0xBFFF, 0xFFFF
};

unsigned short widget_bitmap_iconify_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xC001, 0xC001, 
  0xCFF1, 0xC811, 0xC811, 0xC811, 
  0xC8F9, 0xC889, 0xC889, 0xCF89, 
  0xC0F9, 0xC001, 0xC001, 0xFFFF
};


unsigned short bitmap_xaaes16[DATASIZE] =
{ 0x0000, 0x7006, 0x480A, 0x5416, 
  0x7A2E, 0x3F5E, 0x1FBC, 0x0FF8, 
  0x05F0, 0x05F8, 0x0BF4, 0x17FA, 
  0x2F7E, 0x5E3E, 0x7C1E, 0x0000
};

unsigned short bitmap_xaaes16_s[DATASIZE] =
{ 0x0000, 0x7006, 0x480A, 0x5416, 
  0x7A2E, 0x3F5E, 0x1FBC, 0x0FF8, 
  0x05F0, 0x05F8, 0x0BF4, 0x17FA, 
  0x2F7E, 0x5E3E, 0x7C1E, 0x0000
};

#else

/* Close widget (normal) */
unsigned short widget_bitmap_close[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x500A, 0x57EA, 0x57EA, 0x57EA, 
  0x57EA, 0x57EA, 0x57EA, 0x500A, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x500A, 0x57EA, 0x55AA, 0x566A, 
  0x566A, 0x55AA, 0x57EA, 0x500A, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x500A, 0x57EA, 0x55AA, 0x566A, 
  0x566A, 0x55AA, 0x57EA, 0x500A, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2001, 
  0x2001, 0x2011, 0x2011, 0x2011, 
  0x2011, 0x2011, 0x2011, 0x27F1, 
  0x2001, 0x0001, 0x0001, 0xFFFF
};


/* Close widget (selected) */
unsigned short widget_bitmap_close_s[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x5FFA, 0x5FFA, 0x5FFA, 0x5FFA, 
  0x5FFA, 0x5FFA, 0x5FFA, 0x5FFA, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x5C3A, 0x599A, 0x518A, 0x518A, 
  0x518A, 0x500A, 0x599A, 0x5C3A, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x5C3A, 0x599A, 0x518A, 0x518A, 
  0x518A, 0x500A, 0x599A, 0x5C3A, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2001, 
  0x2001, 0x2181, 0x2181, 0x2181, 
  0x2181, 0x2001, 0x2181, 0x2001, 
  0x2001, 0x0001, 0x0001, 0xFFFF
};

/* Sizer widget (normal) */
unsigned short widget_bitmap_size[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x4002, 
  0x4FF2, 0x4872, 0x48F2, 0x4852, 
  0x4A12, 0x4F12, 0x4E12, 0x4FF2, 
  0x4002, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x4002, 
  0x4FF2, 0x4FF2, 0x4FF2, 0x4FF2, 
  0x4FF2, 0x4FF2, 0x4FF2, 0x4FF2, 
  0x4002, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x4002, 
  0x4FF2, 0x4872, 0x48F2, 0x4852, 
  0x4A12, 0x4F12, 0x4E12, 0x4FF2, 
  0x4002, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2009, 
  0x2009, 0x2789, 0x2709, 0x27A9, 
  0x25E9, 0x20E9, 0x21E9, 0x2009, 
  0x3FF9, 0x0001, 0x0001, 0xFFFF
};

/* Sizer widget (selected) */
unsigned short widget_bitmap_size_s[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x581A, 0x500A, 0x500A, 0x500A, 
  0x500A, 0x500A, 0x500A, 0x581A, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x5FFA, 0x5FFA, 0x5FFA, 0x5FFA, 
  0x5FFA, 0x5FFA, 0x5FFA, 0x5FFA, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5FFA, 
  0x581A, 0x500A, 0x500A, 0x500A, 
  0x500A, 0x500A, 0x500A, 0x581A, 
  0x5FFA, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FFD, 0x2001, 
  0x2001, 0x2781, 0x2701, 0x27A1, 
  0x25E1, 0x20E1, 0x21E1, 0x2001, 
  0x2001, 0x2001, 0x0001, 0xFFFF
};

/* Fuller widget (normal) */
unsigned short widget_bitmap_full[DATASIZE] =
{ 0x0000, 0x0000, 0x03C0, 0x1BD8, 
  0x1DB8, 0x0E70, 0x37EC, 0x3BDC, 
  0x3BDC, 0x37EC, 0x0E70, 0x1DB8, 
  0x1BD8, 0x03C0, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x03C0, 0x1BD8, 
  0x1DB8, 0x0E70, 0x37EC, 0x3BDC, 
  0x3BDC, 0x37EC, 0x0E70, 0x1DB8, 
  0x1BD8, 0x03C0, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x03C0, 0x1BD8, 
  0x1DB8, 0x0E70, 0x37EC, 0x3BDC, 
  0x3BDC, 0x37EC, 0x0E70, 0x1DB8, 
  0x1BD8, 0x03C0, 0x0000, 0x0000, 
  0x0000, 0x7FFF, 0x4001, 0x4405, 
  0x4205, 0x710D, 0x4811, 0x4021, 
  0x4021, 0x4011, 0x4181, 0x4245, 
  0x4405, 0x7C3D, 0x0001, 0xFFFF
};

/* Fuller widget (selected) */
unsigned short widget_bitmap_full_s[DATASIZE] =
{ 0x0000, 0x0000, 0x03C0, 0x1BD8, 
  0x1DB8, 0x0E70, 0x37EC, 0x3BDC, 
  0x3BDC, 0x37EC, 0x0E70, 0x1DB8, 
  0x1BD8, 0x03C0, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x03C0, 0x1BD8, 
  0x1DB8, 0x0E70, 0x37EC, 0x3BDC, 
  0x3BDC, 0x37EC, 0x0E70, 0x1DB8, 
  0x1BD8, 0x03C0, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x03C0, 0x03C0, 
  0x0180, 0x0000, 0x300C, 0x381C, 
  0x381C, 0x300C, 0x0000, 0x0180, 
  0x03C0, 0x03C0, 0x0000, 0x0000, 
  0x0000, 0x7FFF, 0x7C3D, 0x6421, 
  0x6241, 0x6181, 0x4001, 0x4001, 
  0x4401, 0x4811, 0x700D, 0x6001, 
  0x6001, 0x4001, 0x0001, 0xFFFF
};

/* Left Scroll widget (normal) */
unsigned short widget_bitmap_left[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5D7A, 0x5B02, 0x57F2, 0x4FF2, 
  0x4FF2, 0x57F2, 0x5B02, 0x5D7A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5D7A, 0x5B02, 0x57F2, 0x4FF2, 
  0x4FF2, 0x57F2, 0x5B02, 0x5D7A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5D7A, 0x5B02, 0x57F2, 0x4FF2, 
  0x4FF2, 0x57F2, 0x5B02, 0x5D7A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2001, 
  0x2081, 0x2081, 0x2009, 0x2009, 
  0x3009, 0x2809, 0x24F9, 0x2281, 
  0x2181, 0x0001, 0x0001, 0xFFFF
};

/* Left Scroll widget (selected) */
unsigned short widget_bitmap_left_s[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5C7A, 0x5802, 0x5002, 0x4002, 
  0x4002, 0x5002, 0x5802, 0x5C7A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5D7A, 0x5B02, 0x57F2, 0x4FF2, 
  0x4FF2, 0x57F2, 0x5B02, 0x5D7A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5C7A, 0x5802, 0x5002, 0x4002, 
  0x4002, 0x5002, 0x5802, 0x5C7A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2181, 
  0x2201, 0x2479, 0x2801, 0x3001, 
  0x3001, 0x2801, 0x2401, 0x2201, 
  0x2101, 0x0001, 0x0001, 0xFFFF
};

/* Right Scroll widget (normal) */
unsigned short widget_bitmap_right[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5EBA, 0x40DA, 0x4FEA, 0x4FF2, 
  0x4FF2, 0x4FEA, 0x40DA, 0x5EBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5EBA, 0x40DA, 0x4FEA, 0x4FF2, 
  0x4FF2, 0x4FEA, 0x40DA, 0x5EBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5EBA, 0x40DA, 0x4FEA, 0x4FF2, 
  0x4FF2, 0x4FEA, 0x40DA, 0x5EBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2081, 
  0x2041, 0x2021, 0x2011, 0x2009, 
  0x2009, 0x2011, 0x2F21, 0x2041, 
  0x2081, 0x0001, 0x0001, 0xFFFF
};

/* Right Scroll widget (selected) */
unsigned short widget_bitmap_right_s[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5E3A, 0x401A, 0x400A, 0x4002, 
  0x4002, 0x400A, 0x401A, 0x5E3A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5EBA, 0x40DA, 0x4FEA, 0x4FF2, 
  0x4FF2, 0x4FEA, 0x40DA, 0x5EBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5E3A, 0x401A, 0x400A, 0x4002, 
  0x4002, 0x400A, 0x401A, 0x5E3A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2181, 
  0x2141, 0x3F21, 0x3011, 0x3009, 
  0x3001, 0x3001, 0x3001, 0x2101, 
  0x2101, 0x0001, 0x0001, 0xFFFF
};

/* Scroll Up widget (normal) */
unsigned short widget_bitmap_up[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5DBA, 0x5BDA, 0x57EA, 0x4FF2, 
  0x43C2, 0x5BDA, 0x5BDA, 0x5BDA, 
  0x581A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5DBA, 0x5BDA, 0x57EA, 0x4FF2, 
  0x43C2, 0x5BDA, 0x5BDA, 0x5BDA, 
  0x581A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5DBA, 0x5BDA, 0x57EA, 0x4FF2, 
  0x43C2, 0x5BDA, 0x5BDA, 0x5BDA, 
  0x581A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2001, 
  0x2041, 0x2021, 0x2011, 0x2009, 
  0x3C39, 0x2021, 0x2021, 0x2021, 
  0x27E1, 0x0001, 0x0001, 0xFFFF
};

/* Scroll Up widget (selected) */
unsigned short widget_bitmap_up_s[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5C3A, 0x581A, 0x500A, 0x4002, 
  0x4002, 0x581A, 0x581A, 0x581A, 
  0x581A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5DBA, 0x5BDA, 0x57EA, 0x4FF2, 
  0x43C2, 0x5BDA, 0x5BDA, 0x5BDA, 
  0x581A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x5E7A, 
  0x5C3A, 0x581A, 0x500A, 0x4002, 
  0x4002, 0x581A, 0x581A, 0x581A, 
  0x581A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2181, 
  0x2241, 0x2421, 0x2811, 0x3009, 
  0x2001, 0x2401, 0x2401, 0x2401, 
  0x2401, 0x0001, 0x0001, 0xFFFF
};

/* Scroll Down widget (normal) */
unsigned short widget_bitmap_down[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x581A, 
  0x5BDA, 0x5BDA, 0x5BDA, 0x43C2, 
  0x4FF2, 0x57EA, 0x5BDA, 0x5DBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x581A, 
  0x5BDA, 0x5BDA, 0x5BDA, 0x43C2, 
  0x4FF2, 0x57EA, 0x5BDA, 0x5DBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x581A, 
  0x5BDA, 0x5BDA, 0x5BDA, 0x43C2, 
  0x4FF2, 0x57EA, 0x5BDA, 0x5DBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2001, 
  0x2021, 0x2021, 0x2021, 0x2001, 
  0x3009, 0x2811, 0x2421, 0x2241, 
  0x2181, 0x0001, 0x0001, 0xFFFF
};

/* Scroll Down widget (selected) */
unsigned short widget_bitmap_down_s[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x581A, 
  0x581A, 0x581A, 0x581A, 0x4002, 
  0x4002, 0x500A, 0x581A, 0x5C3A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x581A, 
  0x5BDA, 0x5BDA, 0x5BDA, 0x43C2, 
  0x4FF2, 0x57EA, 0x5BDA, 0x5DBA, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x581A, 
  0x581A, 0x581A, 0x581A, 0x4002, 
  0x4002, 0x500A, 0x581A, 0x5C3A, 
  0x5E7A, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x27E1, 
  0x2401, 0x2401, 0x2401, 0x3C19, 
  0x2001, 0x2001, 0x2001, 0x2001, 
  0x2001, 0x0001, 0x0001, 0xFFFF
};

/* Iconify widget (normal) */
unsigned short widget_bitmap_iconify[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x400A, 
  0x4FEA, 0x4FEA, 0x4FEA, 0x4FEA, 
  0x4F02, 0x4F02, 0x4F02, 0x4002, 
  0x5F02, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x400A, 
  0x400A, 0x400A, 0x400A, 0x400A, 
  0x4002, 0x4072, 0x4072, 0x4072, 
  0x5F02, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x400A, 
  0x400A, 0x400A, 0x400A, 0x400A, 
  0x4002, 0x4002, 0x4002, 0x4002, 
  0x5F02, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x2001, 
  0x2011, 0x2011, 0x2011, 0x2011, 
  0x2009, 0x2009, 0x2009, 0x3F09, 
  0x20F9, 0x0001, 0x0001, 0xFFFF
};

/* Iconify widget (selected) */
unsigned short widget_bitmap_iconify_s[DATASIZE] =
{ 0x0000, 0x7FFE, 0x4002, 0x400A, 
  0x4FEA, 0x4FEA, 0x4FEA, 0x4FEA, 
  0x4F02, 0x4F02, 0x4F02, 0x4002, 
  0x5F02, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x400A, 
  0x400A, 0x400A, 0x400A, 0x400A, 
  0x4002, 0x4072, 0x4072, 0x4072, 
  0x5F02, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x7FFE, 0x4002, 0x400A, 
  0x400A, 0x400A, 0x400A, 0x400A, 
  0x4002, 0x4002, 0x4002, 0x4002, 
  0x5F02, 0x4002, 0x7FFE, 0x0000, 
  0x0000, 0x0001, 0x3FF9, 0x3FF1, 
  0x3001, 0x3001, 0x3001, 0x3001, 
  0x30F1, 0x3081, 0x3081, 0x3081, 
  0x2001, 0x0001, 0x0001, 0xFFFF
};

/*====================================== */
/* XaAES Logo (16*16, Normal) */
unsigned short bitmap_xaaes16[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xCFFB, 0xC7F3, 
  0xC3E3, 0xE1C3, 0xF087, 0xFAAF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xEFFB, 
  0xD7F7, 0xE1C3, 0xF087, 0xF80F, 
  0xFC1F, 0xFC0F, 0xF807, 0xF083, 
  0xF5D7, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFC0F, 0xF807, 0xF083, 
  0xE1C3, 0xC3E3, 0xFFFF, 0xFFFF, 
  0x0000, 0x7006, 0x480A, 0x4412, 
  0x4222, 0x2B6A, 0x1FFC, 0x0FF8, 
  0x07F0, 0x07F8, 0x0D54, 0x1082, 
  0x2142, 0x4222, 0x7C1E, 0x0000
};

/* XaAES Logo (16*16, Selected) */
unsigned short bitmap_xaaes16_s[DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xCFFB, 0xC7F3, 
  0xC3E3, 0xE1C3, 0xF1C7, 0xF96F, 
  0xFE3F, 0xFF7F, 0xF987, 0xF083, 
  0xE1C3, 0xC3E3, 0xFFFF, 0xFFFF, 
  0xFE3F, 0xFF7F, 0xCFFB, 0xC7F3, 
  0xC3E3, 0xE1C3, 0xF1C7, 0x79EF, 
  0x3FFE, 0x7FFC, 0xF986, 0xF083, 
  0xE1C3, 0xC3E3, 0xFF7F, 0xFE3F, 
  0xFE3F, 0xFE3F, 0xCEFB, 0xC673, 
  0xC363, 0xE143, 0xF007, 0x388F, 
  0x11D0, 0x0484, 0xF804, 0xF003, 
  0xE103, 0xC3A3, 0xFE3F, 0xFE3F, 
  0x0000, 0x7006, 0x780E, 0x7C1E, 
  0x7E3E, 0x3F7E, 0x1E3C, 0x0E18, 
  0x0010, 0x0400, 0x0E7C, 0x1F7E, 
  0x3F3E, 0x7E3E, 0x7C1E, 0x0000
};

#endif