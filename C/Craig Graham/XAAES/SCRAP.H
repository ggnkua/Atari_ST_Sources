#ifndef _SCRAP_H_
#define _SCRAP_H_

unsigned long XA_scrap_read(short clnt_pid, AESPB *pb);
unsigned long XA_scrap_write(short clnt_pid, AESPB *pb);

#endif