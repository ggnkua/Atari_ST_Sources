/*
 * XaAES - XaAES Ain't the AES
 *
 * A multitasking AES replacement for MiNT
 *
 */

#ifndef _BOX3D_H_
#define _BOX3D_H_

void XA_3D_rect(short x, short y, short w, short h, short b, short b1);
void XA_3D_pushbutton(short x, short y, short w, short h, short selected);

#endif