#ifndef _GRAF_BOX_H_
#define _GRAF_BOX_H_

unsigned long XA_graf_rubberbox(short clnt_pid, AESPB *pb);
unsigned long XA_graf_dragbox(short clnt_pid, AESPB *pb);
unsigned long XA_graf_watchbox(short clnt_pid, AESPB *pb);

#endif
