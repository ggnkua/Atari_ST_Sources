#ifndef _APP_MAN_H_
#define _APP_MAN_H_

void next_app_menu(void);
void list_apps(void);
void recover(void);
void find_dead_clients(void);
void status_dump(void);

#endif

