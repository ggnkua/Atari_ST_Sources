#ifndef _WATCHBOX_H_
#define _WATCHBOX_H_

#include "K_DEFS.H"

short watch_object(OBJECT *dial, short ob, short in_state, short out_state);

#endif
