#ifndef _SHELLWRT_H_
#define _SHELLWRT_H_

short shell_write(short mode, short wisgr, short wiscr, char *parm, char *tail);

#endif
