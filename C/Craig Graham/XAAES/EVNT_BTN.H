#ifndef _EVNT_BTN_H_
#define _EVNT_BTN_H_

#include "EVENT_Q.H"

unsigned long XA_evnt_button(short clnt_pid,AESPB *pb);

#endif
