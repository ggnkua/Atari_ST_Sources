#ifndef _EXTEND_H_
#define _EXTEND_H_

unsigned long XA_appl_pipe(short clnt_pid, AESPB *pb);

#endif