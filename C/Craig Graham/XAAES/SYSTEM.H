/* Resource Datei Indizes f�r SYSTEM */

#define SYSTEM_MENU 0   /* Menuebaum */
#define XA_SYSTEM_ABOUT 7   /* STRING in Baum SYSTEM_MENU */
#define XA_SYSTEM_LAUNCH 17  /* STRING in Baum SYSTEM_MENU */
#define SHUTDOWN 19  /* STRING in Baum SYSTEM_MENU */

#define ALERT_ICONS 1   /* Formular/Dialog */
#define ALR_IC_DRIVE 1   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_STOP 2   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_WARNING 3   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_QUESTION 4   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_INFO 5   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_SYSTEM 6   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_BOMB 7   /* USERDEF in Baum ALERT_ICONS */

#define ALERT_BOX 2   /* Formular/Dialog */
#define ALERT_BACK 0   /* BOX in Baum ALERT_BOX */
#define ALERT_D_ICON 1   /* USERDEF in Baum ALERT_BOX */
#define ALERT_BUT1 2   /* BUTTON in Baum ALERT_BOX */
#define ALERT_BUT2 3   /* BUTTON in Baum ALERT_BOX */
#define ALERT_BUT3 4   /* BUTTON in Baum ALERT_BOX */
#define ALERT_T1 5   /* TEXT in Baum ALERT_BOX */
#define ALERT_T2 6   /* TEXT in Baum ALERT_BOX */
#define ALERT_T3 7   /* TEXT in Baum ALERT_BOX */
#define ALERT_T4 8   /* TEXT in Baum ALERT_BOX */
#define ALERT_T5 9   /* TEXT in Baum ALERT_BOX */

#define FILE_SELECT 3   /* Formular/Dialog */
#define FSEL_EXT 2   /* BOXTEXT in Baum FILE_SELECT */
#define FSEL_PATH 4   /* TEXT in Baum FILE_SELECT */
#define FSEL_PATH_LEFT 5   /* BOXCHAR in Baum FILE_SELECT */
#define FSEL_PATH_RIGHT 6   /* BOXCHAR in Baum FILE_SELECT */
#define FSEL_NAME1 8   /* TEXT in Baum FILE_SELECT */
#define FSEL_UP  11  /* BOXCHAR in Baum FILE_SELECT */
#define FSEL_DOWN 12  /* BOXCHAR in Baum FILE_SELECT */
#define FSEL_FILE 14  /* BOXTEXT in Baum FILE_SELECT */
#define FSEL_BACK 15  /* BOX in Baum FILE_SELECT */
#define FSEL_DIR 17  /* BOXTEXT in Baum FILE_SELECT */
#define FSEL_DRIVE 18  /* BOXTEXT in Baum FILE_SELECT */

#define ABOUT_XAAES 4   /* Formular/Dialog */
#define ABOUT_DATE 16  /* TEXT in Baum ABOUT_XAAES */

#define DEF_DESKTOP 5   /* Formular/Dialog */
#define DESKTOP  0   /* BOX in Baum DEF_DESKTOP */
#define DESKTOP_LOGO 1   /* ICON in Baum DEF_DESKTOP */

#define TASK_MANAGER 6   /* Formular/Dialog */
#define PROC_1   8   /* TEXT in Baum TASK_MANAGER */
#define PROC_9   17  /* TEXT in Baum TASK_MANAGER */
#define ATTR_A1  18  /* BOX in Baum TASK_MANAGER */
#define ATTR_A9  27  /* BOX in Baum TASK_MANAGER */
#define ATTR_B1  28  /* BOX in Baum TASK_MANAGER */
#define ATTR_B9  37  /* BOX in Baum TASK_MANAGER */
#define KILL_PROC 38  /* BUTTON in Baum TASK_MANAGER */
#define LIST_DEL1 39  /* USERDEF in Baum TASK_MANAGER */
