#ifndef _OBJCWIDG_H_
#define _OBJCWIDG_H_

short display_menu_widget(XA_WINDOW *wind, XA_WIDGET *widg);
short display_object_widget(XA_WINDOW *wind, XA_WIDGET *widg);
short click_menu_widget(XA_WINDOW *wind, XA_WIDGET *widg);

#endif
