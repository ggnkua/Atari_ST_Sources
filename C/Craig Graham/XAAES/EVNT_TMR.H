#ifndef _EVNT_TMR_H_
#define _EVNT_TMR_H_

unsigned long XA_evnt_timer(short clnt_pid, AESPB *pb);

#endif
