#ifndef _FORM_DO_H_
#define _FORM_DO_H_

short click_object_widget(XA_WINDOW *wind, XA_WIDGET *widg);
short handle_form_key(XA_WINDOW *wind, unsigned short keycode);
void Radio_b(OBJECT *d, short object);


#endif