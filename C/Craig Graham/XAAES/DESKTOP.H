#ifndef _DESKTOP_H_
#define _DESKTOP_H_

#include "XA_TYPES.H"
#include "K_DEFS.H"

short redraw_desktop(XA_WINDOW *wind);
void set_desktop(OBJECT *new_desktop);

#endif