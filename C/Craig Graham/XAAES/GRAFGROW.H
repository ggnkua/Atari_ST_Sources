#ifndef _GRAFGROW_H_
#define _GRAFGROW_H_

unsigned long XA_graf_growbox(short clnt_pid, AESPB *pb);
unsigned long XA_graf_movebox(short clnt_pid, AESPB *pb);

#endif