#ifndef _MESSAGES_H_
#define _MESSAGES_H_

void send_app_message(short dest_id, short mesg, short source_id, short a, short b, short c, short d, short e);

#endif