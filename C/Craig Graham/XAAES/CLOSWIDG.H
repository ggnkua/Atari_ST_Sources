#ifndef _CLOSWIDG_H_
#define _CLOSWIDG_H_

short display_close_widget(XA_WINDOW *wind, XA_WIDGET *widg);
short click_close(XA_WINDOW *wind, XA_WIDGET *widg);


#endif