#ifndef _SIGNALS_H_
#define _SIGNALS_H_

void __saveds HandleSIGCHLD(long signo);
void __saveds HandleSIGINT(long signo);

#endif