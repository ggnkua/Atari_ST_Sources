#ifndef _FRM_UTIL_H_
#define _FRM_UTIL_H_

OBJECT *CloneForm(OBJECT *form);
void DeleteClone(OBJECT *form);

#endif
