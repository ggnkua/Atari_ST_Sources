#ifndef _EVNT_KBD_H_
#define _EVNT_KBD_H_

unsigned long XA_evnt_keybd(short clnt_pid,AESPB *pb);

#endif