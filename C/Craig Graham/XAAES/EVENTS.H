#ifndef _EVENTS_H_
#define _EVENTS_H_

void redraw_area(short x, short y, short w, short h);

#endif
