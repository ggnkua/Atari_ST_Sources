#ifndef _GETINFO_H_
#define _GETINFO_H_

unsigned long XA_appl_getinfo(short clnt_pid, AESPB *pb);
unsigned long XA_appl_find(short clnt_pid, AESPB *pb);

#endif