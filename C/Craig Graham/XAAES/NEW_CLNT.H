#ifndef _NEW_CLNT_H_
#define _NEW_CLNT_H_

unsigned long XA_new_client(short clnt_pid,AESPB *pb);
unsigned long XA_client_exit(short clnt_pid,AESPB *pb);

#endif

