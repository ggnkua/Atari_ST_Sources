#ifndef _HANDLER_H_
#define _HANDLER_H_

void hook_into_vector(void);
void asm_hook_into_vector(void);
void unhook_from_vector(void);

#endif