#ifndef _OBJC_DRW_H_
#define _OBJC_DRW_H_

unsigned long XA_objc_draw(short clnt_pid, AESPB *pb);
unsigned long XA_objc_offset(short clnt_pid, AESPB *pb);
unsigned long XA_objc_find(short clnt_pid, AESPB *pb);
unsigned long XA_objc_change(short clnt_pid, AESPB *pb);

#endif
