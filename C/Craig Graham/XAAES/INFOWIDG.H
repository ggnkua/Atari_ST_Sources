#ifndef _INFOWIDG_H_
#define _INFOWIDG_H_

short display_info(XA_WINDOW *wind, XA_WIDGET *widg);

#endif

