/*........................ external variables ................................*/

extern int contrl[]; 
extern int intin[]; 
extern int ptsin[];        
extern int intout[];       
extern int ptsout[];       
extern int gl_hand;           
extern long menuaddr;         
extern int messbuf[];        
extern int dummy;             
extern int rez;               
extern int wba_hand;          
extern int wbb_hand;          
extern int ws_hand;           
extern int cz_hand;           
extern char bankset;
extern int syntype;
extern int midi_ch;           
extern long midiaddr,bankaddr,fmtaddr,infoaddr,safeaddr,lineaddr,envsaddr;
extern long helpaddr;
extern char dir_def[];      
extern char dir_temp[];     
extern char file_temp[];    
extern char wba_dat[]; 
extern char wbb_dat[]; 
extern char tempbuf[];
extern char czbuf[];
extern char ws_dat[];   
extern int drive;             
extern char diskbuf[];    
extern int top_hand;          
extern int act_slot;          
extern int work_x,work_y,work_w,work_h;
extern int ws_x,ws_y,ws_w,ws_h;
extern int midijack[];
extern int saf_alls,saf_cz,saf_x;
extern char initvoic[];
extern char fromcz1[],fromcz2[],fromcz3[],tocz1[],tocz2[];
extern long midiptr;
extern long saveptr;
extern int midierr;
extern char pvdltabl[];
extern char pvsdtabl[];
extern char mamdtabl[],mwmdtabl[],mwhvtabl[];
extern char pvktabl[];
extern int editmode,editmon,edited;
extern char edittitl[],editline[];
extern char filecode[];
extern FDB scrfdb;
extern char *numtyp1[],*numtyp2[],*numtyp3[],*numtyp4[],*numtyp5[];
extern char *numtyp6[];
extern long *numtype;
