#define MENUTREE 0  	/* TREE */
#define INFOTREE 1  	/* TREE */
#define GEDESK 3  	/* OBJECT in TREE #0 */
#define GEFILE 4  	/* OBJECT in TREE #0 */
#define GEABOUT 11  	/* OBJECT in TREE #0 */
#define GESWITCH 34  	/* OBJECT in TREE #0 */
#define GEQUIT 35  	/* OBJECT in TREE #0 */
#define GEEDIT 5  	/* OBJECT in TREE #0 */
#define GEWINDS 6  	/* OBJECT in TREE #0 */
#define GEDELETE 20  	/* OBJECT in TREE #0 */
#define GEFORMAT 32  	/* OBJECT in TREE #0 */
#define GEMULTI 27  	/* OBJECT in TREE #0 */
#define GECLEAR 52  	/* OBJECT in TREE #0 */
#define FMTTREE 2  	/* TREE */
#define SIDE1 3  	/* OBJECT in TREE #2 */
#define SIDE2 4  	/* OBJECT in TREE #2 */
#define DRIVEA 6  	/* OBJECT in TREE #2 */
#define DRIVEB 7  	/* OBJECT in TREE #2 */
#define OKFMT 8  	/* OBJECT in TREE #2 */
#define CANFMT 9  	/* OBJECT in TREE #2 */
#define MIDITREE 3  	/* TREE */
#define OKMIDI 41  	/* OBJECT in TREE #3 */
#define THRUON 8  	/* OBJECT in TREE #3 */
#define THRUCHAN 12  	/* OBJECT in TREE #3 */
#define MONITREE 4  	/* TREE */
#define MONIEXIT 13  	/* OBJECT in TREE #4 */
#define MONIMONI 12  	/* OBJECT in TREE #4 */
#define ANNOMONI 10  	/* OBJECT in TREE #4 */
#define ABBRMONI 11  	/* OBJECT in TREE #4 */
#define PATHTREE 5  	/* TREE */
#define MACRTREE 6  	/* TREE */
#define MACRDOWN 11  	/* OBJECT in TREE #6 */
#define MACRUPUP 12  	/* OBJECT in TREE #6 */
#define MACRFIND 16  	/* OBJECT in TREE #6 */
#define MACRHEX 18  	/* OBJECT in TREE #6 */
#define MACRDEC 19  	/* OBJECT in TREE #6 */
#define MACRBIN 20  	/* OBJECT in TREE #6 */
#define MACRASCI 21  	/* OBJECT in TREE #6 */
#define MACRCOPY 23  	/* OBJECT in TREE #6 */
#define MACRCUT 24  	/* OBJECT in TREE #6 */
#define MACRPSTE 25  	/* OBJECT in TREE #6 */
#define MACREXIT 26  	/* OBJECT in TREE #6 */
#define MACRRULE 14  	/* OBJECT in TREE #6 */
#define MACRAREA 15  	/* OBJECT in TREE #6 */
#define GECLOAD 37  	/* OBJECT in TREE #0 */
#define GECSAVE 38  	/* OBJECT in TREE #0 */
#define GECEDIT 39  	/* OBJECT in TREE #0 */
#define GEMLOAD 42  	/* OBJECT in TREE #0 */
#define GEMSAVE 43  	/* OBJECT in TREE #0 */
#define GEMEDIT 44  	/* OBJECT in TREE #0 */
#define GETLOAD 47  	/* OBJECT in TREE #0 */
#define GETSAVE 48  	/* OBJECT in TREE #0 */
#define GETEDIT 49  	/* OBJECT in TREE #0 */
#define MACRUSED 5  	/* OBJECT in TREE #6 */
#define MACRLEFT 7  	/* OBJECT in TREE #6 */
#define MACRUP 13  	/* OBJECT in TREE #6 */
#define MACRPRNT 22  	/* OBJECT in TREE #6 */
#define MACRCLIP 9  	/* OBJECT in TREE #6 */
#define FLT1MONI 6  	/* OBJECT in TREE #4 */
#define FLT2MONI 5  	/* OBJECT in TREE #4 */
#define FLT3MONI 4  	/* OBJECT in TREE #4 */
#define MACRFIX1 3  	/* OBJECT in TREE #6 */
#define MACRFIX2 10  	/* OBJECT in TREE #6 */
#define CNXLTREE 7  	/* TREE */
#define CNXLEXIT 8  	/* OBJECT in TREE #7 */
#define CNXLTRSH 2  	/* OBJECT in TREE #7 */
#define CNXLCLIP 6  	/* OBJECT in TREE #7 */
#define CNXLLEFT 4  	/* OBJECT in TREE #7 */
#define CNXLRGHT 5  	/* OBJECT in TREE #7 */
#define CNXLICON 1  	/* OBJECT in TREE #7 */
#define CNXLNAM1 10  	/* OBJECT in TREE #7 */
#define CNXLNAM2 11  	/* OBJECT in TREE #7 */
#define CNXLNAM3 12  	/* OBJECT in TREE #7 */
#define CNXLPRNT 3  	/* OBJECT in TREE #7 */
#define CNXLTITL 9  	/* OBJECT in TREE #7 */
#define MACRTITL 1  	/* OBJECT in TREE #6 */
#define CNXLALL 7  	/* OBJECT in TREE #7 */
#define VERYTREE 8  	/* TREE */
#define VERYEXP 4  	/* OBJECT in TREE #8 */
#define VERYGOT 6  	/* OBJECT in TREE #8 */
#define VERYSTOP 8  	/* OBJECT in TREE #8 */
#define VERYCONT 9  	/* OBJECT in TREE #8 */
#define VERYEXIT 10  	/* OBJECT in TREE #8 */
#define MIDIRATE 23  	/* OBJECT in TREE #3 */
#define FNAMTREE 9  	/* TREE */
#define FNAMTITL 1  	/* OBJECT in TREE #9 */
#define OKFNAM 3  	/* OBJECT in TREE #9 */
#define CANFNAM 4  	/* OBJECT in TREE #9 */
#define FNAMNAME 2  	/* OBJECT in TREE #9 */
#define OKPATH 16  	/* OBJECT in TREE #5 */
#define CANPATH 17  	/* OBJECT in TREE #5 */
#define FINDCNX 2  	/* OBJECT in TREE #5 */
#define FINDMAC 4  	/* OBJECT in TREE #5 */
#define FINDTEM 6  	/* OBJECT in TREE #5 */
#define FINDLDAT 8  	/* OBJECT in TREE #5 */
#define FINDRDAT 10  	/* OBJECT in TREE #5 */
#define PATHCNX 3  	/* OBJECT in TREE #5 */
#define PATHMAC 5  	/* OBJECT in TREE #5 */
#define PATHTEM 7  	/* OBJECT in TREE #5 */
#define PATHLDAT 9  	/* OBJECT in TREE #5 */
#define PATHRDAT 11  	/* OBJECT in TREE #5 */
#define GEPATHS 29  	/* OBJECT in TREE #0 */
#define FINDMIDI 12  	/* OBJECT in TREE #5 */
#define PATHMIDI 13  	/* OBJECT in TREE #5 */
#define VERYRTRY 11  	/* OBJECT in TREE #8 */
#define MULTTREE 10  	/* TREE */
#define MULTEXIT 7  	/* OBJECT in TREE #10 */
#define MULTADD 2  	/* OBJECT in TREE #10 */
#define MULTEXTR 3  	/* OBJECT in TREE #10 */
#define MULTDEL 5  	/* OBJECT in TREE #10 */
#define MULTREPL 4  	/* OBJECT in TREE #10 */
#define MULTNAME 6  	/* OBJECT in TREE #10 */
#define QUITTREE 11  	/* TREE */
#define OKQUIT 12  	/* OBJECT in TREE #11 */
#define CANQUIT 13  	/* OBJECT in TREE #11 */
#define QUIT1 4  	/* OBJECT in TREE #11 */
#define GEPREFS 30  	/* OBJECT in TREE #0 */
#define MIDIFILT 43  	/* OBJECT in TREE #3 */
#define TEM1TREE 12  	/* TREE */
#define TEM1ICN1 12  	/* OBJECT in TREE #12 */
#define TEM1ICN3 18  	/* OBJECT in TREE #12 */
#define TEM1ICN4 21  	/* OBJECT in TREE #12 */
#define TEM1ICN5 24  	/* OBJECT in TREE #12 */
#define TEM1LINE 13  	/* OBJECT in TREE #12 */
#define TEM1RECT 14  	/* OBJECT in TREE #12 */
#define TEM1KNOB 19  	/* OBJECT in TREE #12 */
#define TEM1SLID 20  	/* OBJECT in TREE #12 */
#define TEM1JOY 22  	/* OBJECT in TREE #12 */
#define TEM1CBUT 25  	/* OBJECT in TREE #12 */
#define TEM1GRPH 23  	/* OBJECT in TREE #12 */
#define TEM1EXIT 31  	/* OBJECT in TREE #12 */
#define TEM1PAGE 3  	/* OBJECT in TREE #12 */
#define EBDTTREE 13  	/* TREE */
#define EBDTEXIT 2  	/* OBJECT in TREE #13 */
#define EBDTCOL1 15  	/* OBJECT in TREE #13 */
#define EBDTCOL2 16  	/* OBJECT in TREE #13 */
#define EBDTCOL3 17  	/* OBJECT in TREE #13 */
#define TEM1EBDT 1  	/* OBJECT in TREE #12 */
#define GETINIT 50  	/* OBJECT in TREE #0 */
#define GEMINIT 45  	/* OBJECT in TREE #0 */
#define GECINIT 40  	/* OBJECT in TREE #0 */
#define TEM1SWAP 29  	/* OBJECT in TREE #12 */
#define GECOPY 21  	/* OBJECT in TREE #0 */
#define GERENAME 22  	/* OBJECT in TREE #0 */
#define GECREATF 24  	/* OBJECT in TREE #0 */
#define GEDELETF 25  	/* OBJECT in TREE #0 */
#define NONGTREE 14  	/* TREE */
#define OKNONG 7  	/* OBJECT in TREE #14 */
#define CANNONG 8  	/* OBJECT in TREE #14 */
#define NONGHEAD 2  	/* OBJECT in TREE #14 */
#define NONGDATA 4  	/* OBJECT in TREE #14 */
#define NONGTOTL 6  	/* OBJECT in TREE #14 */
#define NONGFIND 3  	/* OBJECT in TREE #14 */
#define CNXETREE 15  	/* TREE */
#define CNXEEXIT 13  	/* OBJECT in TREE #15 */
#define CNXEWNDL 14  	/* OBJECT in TREE #15 */
#define CNXETITL 3  	/* OBJECT in TREE #15 */
#define CNXEVRTL 20  	/* OBJECT in TREE #15 */
#define CNXEHORL 25  	/* OBJECT in TREE #15 */
#define CNXESEGL 16  	/* OBJECT in TREE #15 */
#define CNXEMODL 19  	/* OBJECT in TREE #15 */
#define CNXECLRL 17  	/* OBJECT in TREE #15 */
#define CNXESLVL 22  	/* OBJECT in TREE #15 */
#define CNXESLHL 27  	/* OBJECT in TREE #15 */
#define CNXECURL 24  	/* OBJECT in TREE #15 */
#define SEGTREE 16  	/* TREE */
#define CNXETOPL 15  	/* OBJECT in TREE #15 */
#define CNXEUPL 21  	/* OBJECT in TREE #15 */
#define CNXEDWNL 23  	/* OBJECT in TREE #15 */
#define CNXERITL 28  	/* OBJECT in TREE #15 */
#define CNXELFTL 26  	/* OBJECT in TREE #15 */
#define CNXEWNDR 29  	/* OBJECT in TREE #15 */
#define CNXESEGR 31  	/* OBJECT in TREE #15 */
#define PNAMTREE 17  	/* TREE */
#define PNAMNAME 2  	/* OBJECT in TREE #17 */
#define OKPNAM 4  	/* OBJECT in TREE #17 */
#define CANPNAM 5  	/* OBJECT in TREE #17 */
#define CNXEUNDL 18  	/* OBJECT in TREE #15 */
#define CNXEPRNT 6  	/* OBJECT in TREE #15 */
#define EBDTCOL4 18  	/* OBJECT in TREE #13 */
#define EBDTUP 14  	/* OBJECT in TREE #13 */
#define EBDTVSLD 21  	/* OBJECT in TREE #13 */
#define EBDTVSCR 20  	/* OBJECT in TREE #13 */
#define EBDTDOWN 22  	/* OBJECT in TREE #13 */
#define EBDTCURS 8  	/* OBJECT in TREE #13 */
#define EBDTCOL5 19  	/* OBJECT in TREE #13 */
#define EBDTINIT 3  	/* OBJECT in TREE #13 */
#define EBDTUNDO 4  	/* OBJECT in TREE #13 */
#define EBDTPACK 5  	/* OBJECT in TREE #13 */
#define LINETREE 18  	/* TREE */
#define OKLINE 17  	/* OBJECT in TREE #18 */
#define LINESTL0 4  	/* OBJECT in TREE #18 */
#define LINESTL1 5  	/* OBJECT in TREE #18 */
#define LINECLR0 9  	/* OBJECT in TREE #18 */
#define RECTTREE 19  	/* TREE */
#define OKRECT 16  	/* OBJECT in TREE #19 */
#define RECTCLR0 8  	/* OBJECT in TREE #19 */
#define GEEXPORT 55  	/* OBJECT in TREE #0 */
#define KNFDTREE 20  	/* TREE */
#define KNFDTITL 1  	/* OBJECT in TREE #20 */
#define KNFDCLR0 5  	/* OBJECT in TREE #20 */
#define OKKNFD 15  	/* OBJECT in TREE #20 */
#define TEM1OPTS 28  	/* OBJECT in TREE #12 */
#define TOPTTREE 21  	/* TREE */
#define TOPTSNPX 3  	/* OBJECT in TREE #21 */
#define TOPTSNPY 5  	/* OBJECT in TREE #21 */
#define TOPTOUTL 7  	/* OBJECT in TREE #21 */
#define OKTOPT 11  	/* OBJECT in TREE #21 */
#define CANTOPT 12  	/* OBJECT in TREE #21 */
#define TOPTSNX 4  	/* OBJECT in TREE #21 */
#define TOPTSNY 6  	/* OBJECT in TREE #21 */
#define TEM1ICN2 15  	/* OBJECT in TREE #12 */
#define TEM1TEXT 16  	/* OBJECT in TREE #12 */
#define TEM1NUMB 17  	/* OBJECT in TREE #12 */
#define TEM1IBUT 26  	/* OBJECT in TREE #12 */
#define KNFDVAL 17  	/* OBJECT in TREE #20 */
#define VALTREE 22  	/* TREE */
#define VALTITL 1  	/* OBJECT in TREE #22 */
#define VALLOW 16  	/* OBJECT in TREE #22 */
#define VALPARM 3  	/* OBJECT in TREE #22 */
#define VALCODE 13  	/* OBJECT in TREE #22 */
#define VALHIGH 17  	/* OBJECT in TREE #22 */
#define VALINVRT 18  	/* OBJECT in TREE #22 */
#define VALEXIT 19  	/* OBJECT in TREE #22 */
#define NUMBTREE 23  	/* TREE */
#define NUMBFNT0 15  	/* OBJECT in TREE #23 */
#define OKNUMB 19  	/* OBJECT in TREE #23 */
#define NUMBTEXT 21  	/* OBJECT in TREE #23 */
#define NUMBCLR0 5  	/* OBJECT in TREE #23 */
#define BUTNTREE 24  	/* TREE */
#define BUTNTITL 1  	/* OBJECT in TREE #24 */
#define BUTNCLR0 6  	/* OBJECT in TREE #24 */
#define BUTNFNT0 16  	/* OBJECT in TREE #24 */
#define OKBUTN 23  	/* OBJECT in TREE #24 */
#define BUTNAREA 18  	/* OBJECT in TREE #24 */
#define BUTNNCOL 2  	/* OBJECT in TREE #24 */
#define BUTNNROW 19  	/* OBJECT in TREE #24 */
#define BUTNFLAG 20  	/* OBJECT in TREE #24 */
#define GRPHTREE 25  	/* TREE */
#define GRPHCLR0 5  	/* OBJECT in TREE #25 */
#define OKGRPH 51  	/* OBJECT in TREE #25 */
#define GRPHVALX 43  	/* OBJECT in TREE #25 */
#define JOYTREE 26  	/* TREE */
#define JOYCLR0 5  	/* OBJECT in TREE #26 */
#define OKJOY 16  	/* OBJECT in TREE #26 */
#define JOYVALX 15  	/* OBJECT in TREE #26 */
#define JOYVALY 18  	/* OBJECT in TREE #26 */
#define GRPHVALY 44  	/* OBJECT in TREE #25 */
#define CANLINE 18  	/* OBJECT in TREE #18 */
#define CANRECT 17  	/* OBJECT in TREE #19 */
#define CANKNFD 16  	/* OBJECT in TREE #20 */
#define CANNUMB 20  	/* OBJECT in TREE #23 */
#define CANBUTN 24  	/* OBJECT in TREE #24 */
#define CANGRPH 52  	/* OBJECT in TREE #25 */
#define CANJOY 17  	/* OBJECT in TREE #26 */
#define NUMBTITL 1  	/* OBJECT in TREE #23 */
#define VALSTRNG 15  	/* OBJECT in TREE #22 */
#define NUMBVAL 22  	/* OBJECT in TREE #23 */
#define TEXTTREE 27  	/* TREE */
#define TEXTEXIT 11  	/* OBJECT in TREE #27 */
#define TEXTCOL1 3  	/* OBJECT in TREE #27 */
#define TEXTCOL2 4  	/* OBJECT in TREE #27 */
#define TEXTCOL3 5  	/* OBJECT in TREE #27 */
#define TEXTCLR 12  	/* OBJECT in TREE #27 */
#define VALMLOW 10  	/* OBJECT in TREE #22 */
#define VALMHIGH 11  	/* OBJECT in TREE #22 */
#define VALMUPD 12  	/* OBJECT in TREE #22 */
#define VALSTRG 14  	/* OBJECT in TREE #22 */
#define TOPTSAFE 8  	/* OBJECT in TREE #21 */
#define TEM1REGN 27  	/* OBJECT in TREE #12 */
#define TEM1HIDE 30  	/* OBJECT in TREE #12 */
#define EDITTREE 28  	/* TREE */
#define EDITEXIT 1  	/* OBJECT in TREE #28 */
#define EDITUNDO 3  	/* OBJECT in TREE #28 */
#define EDITORIG 5  	/* OBJECT in TREE #28 */
#define EDITSEND 23  	/* OBJECT in TREE #28 */
#define EDITPLAY 18  	/* OBJECT in TREE #28 */
#define EDITTCHN 20  	/* OBJECT in TREE #28 */
#define EDITNAME 28  	/* OBJECT in TREE #28 */
#define EDITNUMB 27  	/* OBJECT in TREE #28 */
#define EDITPAGE 9  	/* OBJECT in TREE #28 */
#define CNXEPCLP 9  	/* OBJECT in TREE #15 */
#define CNXECCLP 10  	/* OBJECT in TREE #15 */
#define RECTFILL 4  	/* OBJECT in TREE #19 */
#define TOPTFIT 9  	/* OBJECT in TREE #21 */
#define POPTREE 29  	/* TREE */
#define OKPOP 7  	/* OBJECT in TREE #29 */
#define CANPOP 8  	/* OBJECT in TREE #29 */
#define POPUP 2  	/* OBJECT in TREE #29 */
#define POPDOWN 6  	/* OBJECT in TREE #29 */
#define POPSLIDE 5  	/* OBJECT in TREE #29 */
#define POPSCROL 4  	/* OBJECT in TREE #29 */
#define POPAREA 3  	/* OBJECT in TREE #29 */
#define POPTITL 1  	/* OBJECT in TREE #29 */
#define WOPTTREE 30  	/* TREE */
#define OKWOPT 26  	/* OBJECT in TREE #30 */
#define WOPTSAVC 4  	/* OBJECT in TREE #30 */
#define WOPTSAVD 5  	/* OBJECT in TREE #30 */
#define WOPTLODC 8  	/* OBJECT in TREE #30 */
#define WOPTLODD 9  	/* OBJECT in TREE #30 */
#define GEWNDOPT 60  	/* OBJECT in TREE #0 */
#define VALPARM2 5  	/* OBJECT in TREE #22 */
#define VALPARM3 7  	/* OBJECT in TREE #22 */
#define VALPARM4 8  	/* OBJECT in TREE #22 */
#define VALLH 6  	/* OBJECT in TREE #22 */
#define EBDTIMPT 6  	/* OBJECT in TREE #13 */
#define WINDTREE 31  	/* TREE */
#define WINDTITL 1  	/* OBJECT in TREE #31 */
#define WINDFNAM 3  	/* OBJECT in TREE #31 */
#define WINDSIZE 4  	/* OBJECT in TREE #31 */
#define OKWIND 10  	/* OBJECT in TREE #31 */
#define CANWIND 11  	/* OBJECT in TREE #31 */
#define GEPRINT 56  	/* OBJECT in TREE #0 */
#define GEMIDI 7  	/* OBJECT in TREE #0 */
#define GEMONITR 62  	/* OBJECT in TREE #0 */
#define GEMIDOPT 69  	/* OBJECT in TREE #0 */
#define GERECSEQ 64  	/* OBJECT in TREE #0 */
#define GEPLYSEQ 65  	/* OBJECT in TREE #0 */
#define GELODSEQ 66  	/* OBJECT in TREE #0 */
#define GESAVSEQ 67  	/* OBJECT in TREE #0 */
#define GRPHNPTS 15  	/* OBJECT in TREE #25 */
#define GRPHPT 16  	/* OBJECT in TREE #25 */
#define GRPHXAXI 46  	/* OBJECT in TREE #25 */
#define GRPHACTV 20  	/* OBJECT in TREE #25 */
#define GRPHXFIX 24  	/* OBJECT in TREE #25 */
#define GRPHXMOV 25  	/* OBJECT in TREE #25 */
#define GRPHVLIN 37  	/* OBJECT in TREE #25 */
#define GRPHHLIN 39  	/* OBJECT in TREE #25 */
#define GRPHYFIX 28  	/* OBJECT in TREE #25 */
#define GRPHYLNK 29  	/* OBJECT in TREE #25 */
#define GRPHYFUL 30  	/* OBJECT in TREE #25 */
#define GRPHXFAC 33  	/* OBJECT in TREE #25 */
#define GRPHYFXN 32  	/* OBJECT in TREE #25 */
#define GRPHAREA 18  	/* OBJECT in TREE #25 */
#define GRPHYMOD 35  	/* OBJECT in TREE #25 */
#define EBDTEXPT 7  	/* OBJECT in TREE #13 */
#define GRPHYAXI 47  	/* OBJECT in TREE #25 */
#define PNAMTITL 1  	/* OBJECT in TREE #17 */
#define TEM1GLOB 11  	/* OBJECT in TREE #12 */
#define TEXTUP 2  	/* OBJECT in TREE #27 */
#define TEXTDOWN 9  	/* OBJECT in TREE #27 */
#define TEXTVSCR 7  	/* OBJECT in TREE #27 */
#define TEXTSCRL 6  	/* OBJECT in TREE #27 */
#define CNXEIMPT 11  	/* OBJECT in TREE #15 */
#define CNXEEXPT 12  	/* OBJECT in TREE #15 */
#define TEXTVSLD 8  	/* OBJECT in TREE #27 */
#define THRUBOX0 5  	/* OBJECT in TREE #3 */
#define THRUBOX1 29  	/* OBJECT in TREE #3 */
#define FILTBOX1 39  	/* OBJECT in TREE #3 */
#define EDITEDTD 7  	/* OBJECT in TREE #28 */
#define EDITSCHN 25  	/* OBJECT in TREE #28 */
#define MIDIITHR 9  	/* OBJECT in TREE #3 */
#define MIDIOTHR 10  	/* OBJECT in TREE #3 */
#define MIDIIPRT 16  	/* OBJECT in TREE #3 */
#define MIDIOPRT 17  	/* OBJECT in TREE #3 */
#define CNXELINK 5  	/* OBJECT in TREE #15 */
#define WINDCNAM 7  	/* OBJECT in TREE #31 */
#define WINDTNAM 9  	/* OBJECT in TREE #31 */
#define WOPTLINK 12  	/* OBJECT in TREE #30 */
#define GEPATCH 8  	/* OBJECT in TREE #0 */
#define GERANDP 77  	/* OBJECT in TREE #0 */
#define GEDISTP 78  	/* OBJECT in TREE #0 */
#define GEAVERP 79  	/* OBJECT in TREE #0 */
#define GEEDITP 75  	/* OBJECT in TREE #0 */
#define GENAMEP 76  	/* OBJECT in TREE #0 */
#define RESTPNAM 6  	/* OBJECT in TREE #17 */
#define SKIPPNAM 7  	/* OBJECT in TREE #17 */
#define PNAMBOX 3  	/* OBJECT in TREE #17 */
#define WOPTPATL 21  	/* OBJECT in TREE #30 */
#define WOPTPATR 24  	/* OBJECT in TREE #30 */
#define WOPTCHNL 22  	/* OBJECT in TREE #30 */
#define WOPTCHNR 25  	/* OBJECT in TREE #30 */
#define GEDUPLIC 53  	/* OBJECT in TREE #0 */
#define GEINFO 57  	/* OBJECT in TREE #0 */
#define GESORT 58  	/* OBJECT in TREE #0 */
#define TEXTIMPT 10  	/* OBJECT in TREE #27 */
#define PREFTREE 32  	/* TREE */
#define PREFEXIT 19  	/* OBJECT in TREE #32 */
#define PREFLOAD 18  	/* OBJECT in TREE #32 */
#define PREFSAVE 20  	/* OBJECT in TREE #32 */
#define PREFDLY 4  	/* OBJECT in TREE #32 */
#define PREFDLY2 3  	/* OBJECT in TREE #32 */
#define PREFRPT 7  	/* OBJECT in TREE #32 */
#define PREFRPT2 6  	/* OBJECT in TREE #32 */
#define GETNTREE 33  	/* TREE */
#define GETNTITL 1  	/* OBJECT in TREE #33 */
#define GETNVAL 3  	/* OBJECT in TREE #33 */
#define GETNEXIT 5  	/* OBJECT in TREE #33 */
#define GETNLOW 2  	/* OBJECT in TREE #33 */
#define GETNHIGH 4  	/* OBJECT in TREE #33 */
#define SEGSEG0 1  	/* OBJECT in TREE #16 */
#define PREFFILE 8  	/* OBJECT in TREE #32 */
#define PREFTONE 10  	/* OBJECT in TREE #32 */
#define PREFCHAS 12  	/* OBJECT in TREE #32 */
#define FINDMULT 14  	/* OBJECT in TREE #5 */
#define PATHMULT 15  	/* OBJECT in TREE #5 */
#define PREFQUIT 14  	/* OBJECT in TREE #32 */
#define PREFEDIT 16  	/* OBJECT in TREE #32 */
#define WOPT1PRT 16  	/* OBJECT in TREE #30 */
#define KNFDOUTP 13  	/* OBJECT in TREE #20 */
#define NUMBOUTP 17  	/* OBJECT in TREE #23 */
#define BUTNOUTP 21  	/* OBJECT in TREE #24 */
#define GRPHOUTP 49  	/* OBJECT in TREE #25 */
#define JOYOUTP 13  	/* OBJECT in TREE #26 */
#define TOPTBUG 10  	/* OBJECT in TREE #21 */
#define KNFDVLDT 14  	/* OBJECT in TREE #20 */
#define NUMBVLDT 18  	/* OBJECT in TREE #23 */
#define BUTNVLDT 22  	/* OBJECT in TREE #24 */
#define GRPHVLDT 50  	/* OBJECT in TREE #25 */
#define JOYVLDT 14  	/* OBJECT in TREE #26 */
#define GESTLOAD 71  	/* OBJECT in TREE #0 */
#define GESTSAVE 72  	/* OBJECT in TREE #0 */
#define GESTINIT 73  	/* OBJECT in TREE #0 */
#define STUTREE 34  	/* TREE */
#define OKSTU 39  	/* OBJECT in TREE #34 */
#define CANSTU 40  	/* OBJECT in TREE #34 */
#define STUNAME 2  	/* OBJECT in TREE #34 */
#define STUCHAN 7  	/* OBJECT in TREE #34 */
#define STUIPORT 11  	/* OBJECT in TREE #34 */
#define STUOPORT 12  	/* OBJECT in TREE #34 */
#define STUSPEED 18  	/* OBJECT in TREE #34 */
#define STUISTRG 27  	/* OBJECT in TREE #34 */
#define STUXSTRG 30  	/* OBJECT in TREE #34 */
#define STUFILT 33  	/* OBJECT in TREE #34 */
#define STUCONFG 38  	/* OBJECT in TREE #34 */
#define MIDIPPRT 33  	/* OBJECT in TREE #3 */
#define MIDIPCHN 35  	/* OBJECT in TREE #3 */
#define MIDIPDLY 37  	/* OBJECT in TREE #3 */
#define FILTBOX0 42  	/* OBJECT in TREE #3 */
#define STUITEST 26  	/* OBJECT in TREE #34 */
#define STUXTEST 29  	/* OBJECT in TREE #34 */
#define STUCONF2 37  	/* OBJECT in TREE #34 */
#define STUNUMB 1  	/* OBJECT in TREE #34 */
#define EDITTPRT 21  	/* OBJECT in TREE #28 */
