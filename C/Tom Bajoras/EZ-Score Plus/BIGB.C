/* bigb.c - crd 870928, 880110, 880203 - copyright 1988 hybrid arts inc. */

overlay "ezpdat"

extern   brace216i(), brace231i(), brace246i();

asm {
brace216i:
   dc.b  0x00,0x00,0x00,0x18
   dc.b  0x00,0x00,0x00,0x60
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x78,0x00,0x00
   dc.b  0x00,0x78,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x1F,0xC0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x0F,0xE0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x07,0xF0,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x03,0xF8,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x01,0xFC,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x00,0xFE,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0x7F,0x00
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x3F,0x80
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x1F,0xC0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x70
   dc.b  0x00,0x00,0x00,0x70
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x30,0x00
   dc.b  0x00,0x00,0xC0,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x00,0xC0,0x00
   dc.b  0x00,0x00,0x30,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x70
   dc.b  0x00,0x00,0x00,0x70
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x03,0xF0
   dc.b  0x00,0x00,0x03,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xC0
   dc.b  0x00,0x00,0x1F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0xFE,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x01,0xFC,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x03,0xF8,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x07,0xF0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x0F,0xE0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x1F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x3C,0x00,0x00
   dc.b  0x00,0x3C,0x00,0x00
   dc.b  0x00,0x3C,0x00,0x00
   dc.b  0x00,0x3C,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x00,0x60
   dc.b  0x00,0x00,0x00,0x18

brace231i:
   dc.b  0x00,0x00,0x00,0x18
   dc.b  0x00,0x00,0x00,0x60
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x10,0x00,0x00
   dc.b  0x00,0x10,0x00,0x00
   dc.b  0x00,0x30,0x00,0x00
   dc.b  0x00,0x30,0x00,0x00
   dc.b  0x00,0x30,0x00,0x00
   dc.b  0x00,0x30,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x78,0x00,0x00
   dc.b  0x00,0x78,0x00,0x00
   dc.b  0x00,0x78,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x80,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x3F,0x80,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xF0
   dc.b  0x00,0x00,0x0F,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x07,0xF0
   dc.b  0x00,0x00,0x07,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x38
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x60,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x06,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x06,0x00,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x00,0x60,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x40
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x20
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x30
   dc.b  0x00,0x00,0x00,0x38
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0x78
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x00,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x01,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x03,0xF8
   dc.b  0x00,0x00,0x07,0xF8
   dc.b  0x00,0x00,0x07,0xF8
   dc.b  0x00,0x00,0x07,0xF8
   dc.b  0x00,0x00,0x0F,0xF0
   dc.b  0x00,0x00,0x0F,0xF0
   dc.b  0x00,0x00,0x0F,0xF0
   dc.b  0x00,0x00,0x1F,0xF0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x3F,0xE0
   dc.b  0x00,0x00,0x3F,0xE0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x7F,0xC0
   dc.b  0x00,0x00,0x7F,0xC0
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0xFF,0x80
   dc.b  0x00,0x00,0xFF,0x80
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x01,0xFF,0x00
   dc.b  0x00,0x01,0xFF,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x03,0xFE,0x00
   dc.b  0x00,0x03,0xFE,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x07,0xFC,0x00
   dc.b  0x00,0x07,0xFC,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x0F,0xF8,0x00
   dc.b  0x00,0x0F,0xF8,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x1F,0xF0,0x00
   dc.b  0x00,0x1F,0xF0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x3F,0xE0,0x00
   dc.b  0x00,0x3F,0xE0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x7F,0x80,0x00
   dc.b  0x00,0x7F,0x80,0x00
   dc.b  0x00,0x7F,0x80,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7F,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7E,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x7C,0x00,0x00
   dc.b  0x00,0x3C,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x38,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x18,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x00,0x60
   dc.b  0x00,0x00,0x00,0x18

brace246i:
   dc.b  0x00,0x00,0x00,0x70
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x06,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x10,0x00,0x00
   dc.b  0x00,0x10,0x00,0x00
   dc.b  0x00,0x20,0x00,0x00
   dc.b  0x00,0x20,0x00,0x00
   dc.b  0x00,0x40,0x00,0x00
   dc.b  0x00,0x40,0x00,0x00
   dc.b  0x00,0xC0,0x00,0x00
   dc.b  0x00,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x03,0x80,0x00,0x00
   dc.b  0x03,0x80,0x00,0x00
   dc.b  0x03,0x80,0x00,0x00
   dc.b  0x03,0x80,0x00,0x00
   dc.b  0x07,0x80,0x00,0x00
   dc.b  0x07,0xC0,0x00,0x00
   dc.b  0x07,0xC0,0x00,0x00
   dc.b  0x07,0xC0,0x00,0x00
   dc.b  0x07,0xC0,0x00,0x00
   dc.b  0x07,0xE0,0x00,0x00
   dc.b  0x07,0xE0,0x00,0x00
   dc.b  0x07,0xE0,0x00,0x00
   dc.b  0x07,0xF0,0x00,0x00
   dc.b  0x07,0xF0,0x00,0x00
   dc.b  0x07,0xF0,0x00,0x00
   dc.b  0x07,0xF8,0x00,0x00
   dc.b  0x03,0xF8,0x00,0x00
   dc.b  0x03,0xF8,0x00,0x00
   dc.b  0x03,0xFC,0x00,0x00
   dc.b  0x03,0xFC,0x00,0x00
   dc.b  0x03,0xFC,0x00,0x00
   dc.b  0x03,0xFE,0x00,0x00
   dc.b  0x01,0xFE,0x00,0x00
   dc.b  0x01,0xFE,0x00,0x00
   dc.b  0x01,0xFF,0x00,0x00
   dc.b  0x01,0xFF,0x00,0x00
   dc.b  0x00,0xFF,0x00,0x00
   dc.b  0x00,0xFF,0x80,0x00
   dc.b  0x00,0xFF,0x80,0x00
   dc.b  0x00,0x7F,0x80,0x00
   dc.b  0x00,0x7F,0xC0,0x00
   dc.b  0x00,0x7F,0xC0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x3F,0xE0,0x00
   dc.b  0x00,0x3F,0xE0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x1F,0xF0,0x00
   dc.b  0x00,0x1F,0xF0,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x0F,0xF8,0x00
   dc.b  0x00,0x0F,0xF8,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x07,0xFC,0x00
   dc.b  0x00,0x07,0xFC,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x03,0xFE,0x00
   dc.b  0x00,0x03,0xFE,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x01,0xFF,0x00
   dc.b  0x00,0x01,0xFF,0x00
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x00,0xFF,0x80
   dc.b  0x00,0x00,0xFF,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x07,0xE0
   dc.b  0x00,0x00,0x07,0xE0
   dc.b  0x00,0x00,0x07,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x01,0xC0
   dc.b  0x00,0x00,0x01,0xC0
   dc.b  0x00,0x00,0x01,0xC0
   dc.b  0x00,0x00,0x01,0xC0
   dc.b  0x00,0x00,0x01,0xC0
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x0C,0x00,0x00
   dc.b  0x00,0x70,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x00,0x70,0x00,0x00
   dc.b  0x00,0x0C,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x01,0xC0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x07,0xE0
   dc.b  0x00,0x00,0x07,0xE0
   dc.b  0x00,0x00,0x07,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x0F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xE0
   dc.b  0x00,0x00,0x1F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x3F,0xC0
   dc.b  0x00,0x00,0x7F,0xC0
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0x7F,0x80
   dc.b  0x00,0x00,0xFF,0x80
   dc.b  0x00,0x00,0xFF,0x80
   dc.b  0x00,0x00,0xFF,0x00
   dc.b  0x00,0x01,0xFF,0x00
   dc.b  0x00,0x01,0xFF,0x00
   dc.b  0x00,0x01,0xFE,0x00
   dc.b  0x00,0x03,0xFE,0x00
   dc.b  0x00,0x03,0xFE,0x00
   dc.b  0x00,0x03,0xFC,0x00
   dc.b  0x00,0x07,0xFC,0x00
   dc.b  0x00,0x07,0xFC,0x00
   dc.b  0x00,0x07,0xF8,0x00
   dc.b  0x00,0x0F,0xF8,0x00
   dc.b  0x00,0x0F,0xF8,0x00
   dc.b  0x00,0x0F,0xF0,0x00
   dc.b  0x00,0x1F,0xF0,0x00
   dc.b  0x00,0x1F,0xF0,0x00
   dc.b  0x00,0x1F,0xE0,0x00
   dc.b  0x00,0x3F,0xE0,0x00
   dc.b  0x00,0x3F,0xE0,0x00
   dc.b  0x00,0x3F,0xC0,0x00
   dc.b  0x00,0x7F,0xC0,0x00
   dc.b  0x00,0x7F,0xC0,0x00
   dc.b  0x00,0x7F,0x80,0x00
   dc.b  0x00,0xFF,0x80,0x00
   dc.b  0x00,0xFF,0x80,0x00
   dc.b  0x00,0xFF,0x00,0x00
   dc.b  0x01,0xFF,0x00,0x00
   dc.b  0x01,0xFF,0x00,0x00
   dc.b  0x01,0xFE,0x00,0x00
   dc.b  0x01,0xFE,0x00,0x00
   dc.b  0x03,0xFE,0x00,0x00
   dc.b  0x03,0xFC,0x00,0x00
   dc.b  0x03,0xFC,0x00,0x00
   dc.b  0x03,0xFC,0x00,0x00
   dc.b  0x03,0xF8,0x00,0x00
   dc.b  0x07,0xF8,0x00,0x00
   dc.b  0x07,0xF8,0x00,0x00
   dc.b  0x07,0xF0,0x00,0x00
   dc.b  0x07,0xF0,0x00,0x00
   dc.b  0x07,0xF0,0x00,0x00
   dc.b  0x07,0xE0,0x00,0x00
   dc.b  0x07,0xE0,0x00,0x00
   dc.b  0x07,0xE0,0x00,0x00
   dc.b  0x07,0xE0,0x00,0x00
   dc.b  0x07,0xC0,0x00,0x00
   dc.b  0x03,0xC0,0x00,0x00
   dc.b  0x03,0xC0,0x00,0x00
   dc.b  0x03,0xC0,0x00,0x00
   dc.b  0x03,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x01,0x80,0x00,0x00
   dc.b  0x00,0x80,0x00,0x00
   dc.b  0x00,0x80,0x00,0x00
   dc.b  0x00,0xC0,0x00,0x00
   dc.b  0x00,0x40,0x00,0x00
   dc.b  0x00,0x40,0x00,0x00
   dc.b  0x00,0x20,0x00,0x00
   dc.b  0x00,0x20,0x00,0x00
   dc.b  0x00,0x10,0x00,0x00
   dc.b  0x00,0x10,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x08,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x04,0x00,0x00
   dc.b  0x00,0x02,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x06,0x00
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x00,0x70
}

/* EOF */
