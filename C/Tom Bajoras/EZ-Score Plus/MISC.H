/* misc.h -- miscellaneous c definitions and macros
 *
 * by Craig Dickson
 * Hybrid Arts, Inc.
 * 27 June 1987
 */

#define	FALSE	0
#define	TRUE	1

#define	max(a,b)	((a)>(b)?(a):(b))
#define	min(a,b)	((a)<(b)?(a):(b))

#define	abs(a)	((a)>0?(a):-(a))
