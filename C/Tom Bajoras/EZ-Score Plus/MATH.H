
extern double log(), log10(), log2();
extern double sin(), cos(), tan(), sqrt();
extern double putexp();
extern double exp2(), exp10(), exp();
extern double atan(), asin(), acos();
