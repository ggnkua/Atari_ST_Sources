/* EZ-Score Plus
 * bit images of small braces for printer
 */

overlay "ezpdat"

extern   brace056i(), brace066i(), brace081i(), brace096i(), brace111i(),
         brace126i(), brace141i();

asm {
brace056i:
   dc.b  0x00,0x30
   dc.b  0x00,0x40
   dc.b  0x00,0x80
   dc.b  0x01,0x00
   dc.b  0x03,0x00
   dc.b  0x02,0x00
   dc.b  0x06,0x00
   dc.b  0x06,0x00
   dc.b  0x06,0x00
   dc.b  0x06,0x00
   dc.b  0x07,0x00
   dc.b  0x07,0x00
   dc.b  0x03,0x80
   dc.b  0x03,0x80
   dc.b  0x01,0xC0
   dc.b  0x01,0xC0
   dc.b  0x00,0xE0
   dc.b  0x00,0xE0
   dc.b  0x00,0x70
   dc.b  0x00,0x70
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x20
   dc.b  0x00,0x60
   dc.b  0x00,0x40
   dc.b  0x00,0x80
   dc.b  0x03,0x00
   dc.b  0x03,0x00
   dc.b  0x00,0x80
   dc.b  0x00,0x40
   dc.b  0x00,0x60
   dc.b  0x00,0x20
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x70
   dc.b  0x00,0x70
   dc.b  0x00,0xE0
   dc.b  0x00,0xE0
   dc.b  0x01,0xC0
   dc.b  0x01,0xC0
   dc.b  0x03,0x80
   dc.b  0x03,0x80
   dc.b  0x07,0x00
   dc.b  0x07,0x00
   dc.b  0x06,0x00
   dc.b  0x06,0x00
   dc.b  0x06,0x00
   dc.b  0x06,0x00
   dc.b  0x02,0x00
   dc.b  0x03,0x00
   dc.b  0x01,0x00
   dc.b  0x00,0x80
   dc.b  0x00,0x40
   dc.b  0x00,0x30

brace066i:
   dc.b  0x00,0x30
   dc.b  0x00,0x40
   dc.b  0x00,0x80
   dc.b  0x01,0x00
   dc.b  0x02,0x00
   dc.b  0x06,0x00
   dc.b  0x04,0x00
   dc.b  0x0C,0x00
   dc.b  0x0C,0x00
   dc.b  0x0C,0x00
   dc.b  0x0C,0x00
   dc.b  0x0E,0x00
   dc.b  0x0E,0x00
   dc.b  0x07,0x00
   dc.b  0x07,0x00
   dc.b  0x03,0x80
   dc.b  0x03,0x80
   dc.b  0x01,0xC0
   dc.b  0x01,0xC0
   dc.b  0x00,0xE0
   dc.b  0x00,0xE0
   dc.b  0x00,0x70
   dc.b  0x00,0x70
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x20
   dc.b  0x00,0x20
   dc.b  0x00,0x40
   dc.b  0x00,0x40
   dc.b  0x00,0x80
   dc.b  0x01,0x00
   dc.b  0x06,0x00
   dc.b  0x06,0x00
   dc.b  0x01,0x00
   dc.b  0x00,0x80
   dc.b  0x00,0x40
   dc.b  0x00,0x40
   dc.b  0x00,0x20
   dc.b  0x00,0x20
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x70
   dc.b  0x00,0x70
   dc.b  0x00,0xE0
   dc.b  0x00,0xE0
   dc.b  0x01,0xC0
   dc.b  0x01,0xC0
   dc.b  0x03,0x80
   dc.b  0x03,0x80
   dc.b  0x07,0x00
   dc.b  0x07,0x00
   dc.b  0x0E,0x00
   dc.b  0x0E,0x00
   dc.b  0x0C,0x00
   dc.b  0x0C,0x00
   dc.b  0x0C,0x00
   dc.b  0x0C,0x00
   dc.b  0x04,0x00
   dc.b  0x06,0x00
   dc.b  0x02,0x00
   dc.b  0x01,0x00
   dc.b  0x00,0x80
   dc.b  0x00,0x40
   dc.b  0x00,0x30

brace081i:
   dc.b  0x00,0x30
   dc.b  0x00,0xC0
   dc.b  0x01,0x00
   dc.b  0x02,0x00
   dc.b  0x04,0x00
   dc.b  0x08,0x00
   dc.b  0x18,0x00
   dc.b  0x10,0x00
   dc.b  0x30,0x00
   dc.b  0x30,0x00
   dc.b  0x38,0x00
   dc.b  0x38,0x00
   dc.b  0x3C,0x00
   dc.b  0x3C,0x00
   dc.b  0x1E,0x00
   dc.b  0x1E,0x00
   dc.b  0x0F,0x00
   dc.b  0x0F,0x00
   dc.b  0x07,0x80
   dc.b  0x07,0x80
   dc.b  0x03,0xC0
   dc.b  0x03,0xC0
   dc.b  0x01,0xE0
   dc.b  0x01,0xE0
   dc.b  0x00,0xF0
   dc.b  0x00,0xF0
   dc.b  0x00,0x70
   dc.b  0x00,0x70
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x20
   dc.b  0x00,0x60
   dc.b  0x00,0x40
   dc.b  0x00,0x40
   dc.b  0x00,0x80
   dc.b  0x01,0x00
   dc.b  0x02,0x00
   dc.b  0x0C,0x00
   dc.b  0x30,0x00
   dc.b  0x0C,0x00
   dc.b  0x02,0x00
   dc.b  0x01,0x00
   dc.b  0x00,0x80
   dc.b  0x00,0x40
   dc.b  0x00,0x40
   dc.b  0x00,0x60
   dc.b  0x00,0x20
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x30
   dc.b  0x00,0x70
   dc.b  0x00,0x70
   dc.b  0x00,0xF0
   dc.b  0x00,0xF0
   dc.b  0x01,0xE0
   dc.b  0x01,0xE0
   dc.b  0x03,0xC0
   dc.b  0x03,0xC0
   dc.b  0x07,0x80
   dc.b  0x07,0x80
   dc.b  0x0F,0x00
   dc.b  0x0F,0x00
   dc.b  0x1E,0x00
   dc.b  0x1E,0x00
   dc.b  0x3C,0x00
   dc.b  0x3C,0x00
   dc.b  0x38,0x00
   dc.b  0x38,0x00
   dc.b  0x30,0x00
   dc.b  0x30,0x00
   dc.b  0x10,0x00
   dc.b  0x18,0x00
   dc.b  0x08,0x00
   dc.b  0x04,0x00
   dc.b  0x02,0x00
   dc.b  0x01,0x00
   dc.b  0x00,0xC0
   dc.b  0x00,0x30

brace096i:
   dc.b  0x00,0x18
   dc.b  0x00,0x60
   dc.b  0x01,0x80
   dc.b  0x02,0x00
   dc.b  0x04,0x00
   dc.b  0x08,0x00
   dc.b  0x10,0x00
   dc.b  0x10,0x00
   dc.b  0x20,0x00
   dc.b  0x20,0x00
   dc.b  0x60,0x00
   dc.b  0x70,0x00
   dc.b  0x70,0x00
   dc.b  0x70,0x00
   dc.b  0x78,0x00
   dc.b  0x78,0x00
   dc.b  0x3C,0x00
   dc.b  0x3C,0x00
   dc.b  0x3E,0x00
   dc.b  0x1E,0x00
   dc.b  0x1F,0x00
   dc.b  0x0F,0x00
   dc.b  0x0F,0x80
   dc.b  0x07,0x80
   dc.b  0x07,0xC0
   dc.b  0x03,0xC0
   dc.b  0x03,0xE0
   dc.b  0x01,0xE0
   dc.b  0x01,0xF0
   dc.b  0x00,0xF0
   dc.b  0x00,0xF0
   dc.b  0x00,0x78
   dc.b  0x00,0x78
   dc.b  0x00,0x38
   dc.b  0x00,0x38
   dc.b  0x00,0x38
   dc.b  0x00,0x18
   dc.b  0x00,0x18
   dc.b  0x00,0x18
   dc.b  0x00,0x10
   dc.b  0x00,0x10
   dc.b  0x00,0x20
   dc.b  0x00,0x20
   dc.b  0x00,0x40
   dc.b  0x00,0x80
   dc.b  0x01,0x00
   dc.b  0x06,0x00
   dc.b  0x18,0x00
   dc.b  0x18,0x00
   dc.b  0x06,0x00
   dc.b  0x01,0x00
   dc.b  0x00,0x80
   dc.b  0x00,0x40
   dc.b  0x00,0x20
   dc.b  0x00,0x20
   dc.b  0x00,0x10
   dc.b  0x00,0x10
   dc.b  0x00,0x18
   dc.b  0x00,0x18
   dc.b  0x00,0x18
   dc.b  0x00,0x38
   dc.b  0x00,0x38
   dc.b  0x00,0x38
   dc.b  0x00,0x78
   dc.b  0x00,0x78
   dc.b  0x00,0xF0
   dc.b  0x00,0xF0
   dc.b  0x01,0xF0
   dc.b  0x01,0xE0
   dc.b  0x03,0xE0
   dc.b  0x03,0xC0
   dc.b  0x07,0xC0
   dc.b  0x07,0x80
   dc.b  0x0F,0x80
   dc.b  0x0F,0x00
   dc.b  0x1F,0x00
   dc.b  0x1E,0x00
   dc.b  0x3E,0x00
   dc.b  0x3C,0x00
   dc.b  0x3C,0x00
   dc.b  0x78,0x00
   dc.b  0x78,0x00
   dc.b  0x70,0x00
   dc.b  0x70,0x00
   dc.b  0x70,0x00
   dc.b  0x60,0x00
   dc.b  0x20,0x00
   dc.b  0x20,0x00
   dc.b  0x10,0x00
   dc.b  0x10,0x00
   dc.b  0x08,0x00
   dc.b  0x04,0x00
   dc.b  0x02,0x00
   dc.b  0x01,0x80
   dc.b  0x00,0x60
   dc.b  0x00,0x18

brace111i:
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x0C,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x03,0xC0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x03,0xC0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x30,0x00
   dc.b  0x00,0x00,0xC0,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x00,0xC0,0x00
   dc.b  0x00,0x00,0x30,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x01,0x00
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x00,0x80
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xC0,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x0C,0x00
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x00,0xE0

brace126i:
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x0C,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x03,0xC0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x03,0xC0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xC0,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x0C,0x00
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x00,0xE0

brace141i:
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x0C,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x03,0xC0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x03,0xC0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x03,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x08,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x04,0x00
   dc.b  0x00,0x00,0x02,0x00
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x01,0x80
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xC0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x00,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x01,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xE0
   dc.b  0x00,0x00,0x03,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x07,0xC0
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x0F,0x80
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x1F,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x3E,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0x7C,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x00,0xF8,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x01,0xF0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xE0,0x00
   dc.b  0x00,0x03,0xC0,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x07,0xC0,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x80,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x07,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x03,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x00,0x00
   dc.b  0x00,0x01,0x80,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x80,0x00
   dc.b  0x00,0x00,0x40,0x00
   dc.b  0x00,0x00,0x20,0x00
   dc.b  0x00,0x00,0x10,0x00
   dc.b  0x00,0x00,0x0C,0x00
   dc.b  0x00,0x00,0x03,0x00
   dc.b  0x00,0x00,0x00,0xE0
}

/* EOF */
