extern char *strcat();
extern char *strncat();
extern char *strcpy();
extern char *strncpy();
extern char *index();
extern char *rindex();
