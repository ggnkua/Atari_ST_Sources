#define MENUTREE 1  	/* TREE */
#define LUDESK 3  	/* OBJECT in TREE #1 */
#define LUINFO 10  	/* OBJECT in TREE #1 */
#define LUFILE 4  	/* OBJECT in TREE #1 */
#define LULOAD 19  	/* OBJECT in TREE #1 */
#define LUSAVE 20  	/* OBJECT in TREE #1 */
#define LUSNG 22  	/* OBJECT in TREE #1 */
#define LUDRIVE 24  	/* OBJECT in TREE #1 */
#define LUDELETE 25  	/* OBJECT in TREE #1 */
#define LUFORMAT 26  	/* OBJECT in TREE #1 */
#define LUSWITCH 28  	/* OBJECT in TREE #1 */
#define LUQUIT 29  	/* OBJECT in TREE #1 */
#define LUPATTRN 5  	/* OBJECT in TREE #1 */
#define LUPITCH 31  	/* OBJECT in TREE #1 */
#define LURHYTHM 32  	/* OBJECT in TREE #1 */
#define LUOPTION 7  	/* OBJECT in TREE #1 */
#define LUTRACKS 6  	/* OBJECT in TREE #1 */
#define LUSCALES 36  	/* OBJECT in TREE #1 */
#define LUVELMAP 37  	/* OBJECT in TREE #1 */
#define LUCOPY 39  	/* OBJECT in TREE #1 */
#define LUSYNC 45  	/* OBJECT in TREE #1 */
#define LUPLAY 52  	/* OBJECT in TREE #1 */
#define LUAGAIN 53  	/* OBJECT in TREE #1 */
#define INFMTREE 0  	/* TREE */
#define FMTTREE 2  	/* TREE */
#define SIDE1 4  	/* OBJECT in TREE #2 */
#define SIDE2 3  	/* OBJECT in TREE #2 */
#define DRIVEA 6  	/* OBJECT in TREE #2 */
#define DRIVEB 7  	/* OBJECT in TREE #2 */
#define OKFMT 8  	/* OBJECT in TREE #2 */
#define CANFMT 9  	/* OBJECT in TREE #2 */
#define DRIVTREE 3  	/* TREE */
#define ADRIVE 2  	/* OBJECT in TREE #3 */
#define LDSVTREE 4  	/* TREE */
#define LDSVTITL 1  	/* OBJECT in TREE #4 */
#define LDSVFILE 2  	/* OBJECT in TREE #4 */
#define OKLDSV 17  	/* OBJECT in TREE #4 */
#define CANLDSV 18  	/* OBJECT in TREE #4 */
#define LUINIT 55  	/* OBJECT in TREE #1 */
#define GRPTREE 5  	/* TREE */
#define GRPTITL 1  	/* OBJECT in TREE #5 */
#define GRPCOPY 66  	/* OBJECT in TREE #5 */
#define GRPEXIT 65  	/* OBJECT in TREE #5 */
#define GRPPREV 63  	/* OBJECT in TREE #5 */
#define GRPNEXT 64  	/* OBJECT in TREE #5 */
#define GRPFROM 67  	/* OBJECT in TREE #5 */
#define GRPTO 68  	/* OBJECT in TREE #5 */
#define GRPBOX 2  	/* OBJECT in TREE #5 */
#define GRPNUMB 3  	/* OBJECT in TREE #5 */
#define GRPNAME 13  	/* OBJECT in TREE #5 */
#define COPYTREE 7  	/* TREE */
#define COPYEXIT 26  	/* OBJECT in TREE #7 */
#define FROMSEQA 4  	/* OBJECT in TREE #7 */
#define SCALTREE 8  	/* TREE */
#define KEYEXIT 24  	/* OBJECT in TREE #8 */
#define KEYMAJOR 5  	/* OBJECT in TREE #8 */
#define KEYMINOR 6  	/* OBJECT in TREE #8 */
#define TONIC 12  	/* OBJECT in TREE #8 */
#define KEYBOX 11  	/* OBJECT in TREE #8 */
#define EDPTREE 9  	/* TREE */
#define CANEDP 17  	/* OBJECT in TREE #9 */
#define EDPPREV 14  	/* OBJECT in TREE #9 */
#define OKEDP 16  	/* OBJECT in TREE #9 */
#define EDPAREA 42  	/* OBJECT in TREE #9 */
#define EDPEDIT 25  	/* OBJECT in TREE #9 */
#define EDPEND 59  	/* OBJECT in TREE #9 */
#define EDPENDS 58  	/* OBJECT in TREE #9 */
#define EDRTREE 10  	/* TREE */
#define EDRVALUA 31  	/* OBJECT in TREE #10 */
#define EDRNTRTA 48  	/* OBJECT in TREE #10 */
#define EDRENDA 65  	/* OBJECT in TREE #10 */
#define OKEDR 17  	/* OBJECT in TREE #10 */
#define CANEDR 18  	/* OBJECT in TREE #10 */
#define LUTEMPO 49  	/* OBJECT in TREE #1 */
#define TEMPTREE 11  	/* TREE */
#define TEMPEXIT 3  	/* OBJECT in TREE #11 */
#define TEMPTEMP 2  	/* OBJECT in TREE #11 */
#define TOSEQA 14  	/* OBJECT in TREE #7 */
#define KEYSHARP 9  	/* OBJECT in TREE #8 */
#define KEYFLAT 10  	/* OBJECT in TREE #8 */
#define KEYSEQ 2  	/* OBJECT in TREE #8 */
#define EDPACCID 13  	/* OBJECT in TREE #9 */
#define COPYTYPE 23  	/* OBJECT in TREE #7 */
#define VELOTREE 6  	/* TREE */
#define VELATTAC 23  	/* OBJECT in TREE #6 */
#define VELRELEA 26  	/* OBJECT in TREE #6 */
#define VELSEQ 2  	/* OBJECT in TREE #6 */
#define VELMAP0 13  	/* OBJECT in TREE #6 */
#define VELDEFAT 24  	/* OBJECT in TREE #6 */
#define VELDEFRL 27  	/* OBJECT in TREE #6 */
#define VELACCNT 28  	/* OBJECT in TREE #6 */
#define VELEXIT 29  	/* OBJECT in TREE #6 */
#define LDSVBUT0 6  	/* OBJECT in TREE #4 */
#define TRAKTREE 12  	/* TREE */
#define TRAKINF1 9  	/* OBJECT in TREE #12 */
#define TRAKEXIT 96  	/* OBJECT in TREE #12 */
#define TRAKINF2 20  	/* OBJECT in TREE #12 */
#define TRAKINF3 31  	/* OBJECT in TREE #12 */
#define TRAKINF4 42  	/* OBJECT in TREE #12 */
#define TRAKINF5 53  	/* OBJECT in TREE #12 */
#define TRAKINF6 64  	/* OBJECT in TREE #12 */
#define TRAKINF7 75  	/* OBJECT in TREE #12 */
#define TRAKINF8 86  	/* OBJECT in TREE #12 */
#define LUSUMARY 34  	/* OBJECT in TREE #1 */
#define FILLTREE 13  	/* TREE */
#define FILLTRK1 6  	/* OBJECT in TREE #13 */
#define FILLTYPE 16  	/* OBJECT in TREE #13 */
#define FILLTO 20  	/* OBJECT in TREE #13 */
#define OKFILL 22  	/* OBJECT in TREE #13 */
#define CANFILL 23  	/* OBJECT in TREE #13 */
#define LUFILL 40  	/* OBJECT in TREE #1 */
#define EDPNAME 20  	/* OBJECT in TREE #9 */
#define EDRNAME 21  	/* OBJECT in TREE #10 */
#define SYNCTREE 14  	/* TREE */
#define SYNCTRAK 20  	/* OBJECT in TREE #14 */
#define SYNCTYPE 36  	/* OBJECT in TREE #14 */
#define SYNCEXIT 52  	/* OBJECT in TREE #14 */
#define LUTSYNC 35  	/* OBJECT in TREE #1 */
#define EDPNEXT 15  	/* OBJECT in TREE #9 */
#define EDPRECRD 12  	/* OBJECT in TREE #9 */
#define EDPTHRU 6  	/* OBJECT in TREE #9 */
#define EDPCHAN 10  	/* OBJECT in TREE #9 */
#define EDPPLAY 5  	/* OBJECT in TREE #9 */
#define EDPJUST 2  	/* OBJECT in TREE #9 */
#define EDPRAND 3  	/* OBJECT in TREE #9 */
#define EDPTRANS 4  	/* OBJECT in TREE #9 */
#define EDPSPEED 8  	/* OBJECT in TREE #9 */
#define EDRVALUB 99  	/* OBJECT in TREE #10 */
#define EDRNTRTB 116  	/* OBJECT in TREE #10 */
#define EDRENDB 133  	/* OBJECT in TREE #10 */
#define EDRTNOTE 4  	/* OBJECT in TREE #10 */
#define EDRCOND 2  	/* OBJECT in TREE #10 */
#define EDRPLAY 3  	/* OBJECT in TREE #10 */
#define EDRSPEED 11  	/* OBJECT in TREE #10 */
#define EDRTHRU 6  	/* OBJECT in TREE #10 */
#define EDRTCHAN 5  	/* OBJECT in TREE #10 */
#define EDRRECRD 14  	/* OBJECT in TREE #10 */
#define EDRNTR1 47  	/* OBJECT in TREE #10 */
#define EDRNTR2 115  	/* OBJECT in TREE #10 */
#define EDRMETRO 7  	/* OBJECT in TREE #10 */
#define EDRQUANT 16  	/* OBJECT in TREE #10 */
#define EDRMNOTE 8  	/* OBJECT in TREE #10 */
#define EDRMCHAN 9  	/* OBJECT in TREE #10 */
#define EDRCOUNT 13  	/* OBJECT in TREE #10 */
#define LUTHRU 50  	/* OBJECT in TREE #1 */
#define THRUTREE 15  	/* TREE */
#define THRUON 2  	/* OBJECT in TREE #15 */
#define THRUCHON 3  	/* OBJECT in TREE #15 */
#define OKTHRU 6  	/* OBJECT in TREE #15 */
#define THRUCHAN 4  	/* OBJECT in TREE #15 */
#define TRAKTHRU 98  	/* OBJECT in TREE #12 */
#define LUPATCH 46  	/* OBJECT in TREE #1 */
#define SHARTREE 16  	/* TREE */
#define SHARBUT0 4  	/* OBJECT in TREE #16 */
#define OKSHAR 12  	/* OBJECT in TREE #16 */
#define CANSHAR 13  	/* OBJECT in TREE #16 */
#define ALLLDSV 3  	/* OBJECT in TREE #4 */
#define NONELDSV 4  	/* OBJECT in TREE #4 */
#define EDPLINK 21  	/* OBJECT in TREE #9 */
#define EDPWITH 22  	/* OBJECT in TREE #9 */
#define EDRLINK 22  	/* OBJECT in TREE #10 */
#define EDRWITH 23  	/* OBJECT in TREE #10 */
#define EDPNUMB 19  	/* OBJECT in TREE #9 */
#define EDRNUMB 20  	/* OBJECT in TREE #10 */
#define EDPNAMER 23  	/* OBJECT in TREE #9 */
#define EDRNAMEP 24  	/* OBJECT in TREE #10 */
#define SHARINFO 14  	/* OBJECT in TREE #16 */
#define EDPRULER 76  	/* OBJECT in TREE #9 */
#define EDPRULES 75  	/* OBJECT in TREE #9 */
#define EDRRULE1 81  	/* OBJECT in TREE #10 */
#define EDRRULE2 149  	/* OBJECT in TREE #10 */
#define LUSAFE 42  	/* OBJECT in TREE #1 */
#define LULAZY 43  	/* OBJECT in TREE #1 */
#define THRUPLEX 5  	/* OBJECT in TREE #15 */
#define TRAKPLEX 99  	/* OBJECT in TREE #12 */
#define EDPPLEX 11  	/* OBJECT in TREE #9 */
#define INFCTREE 17  	/* TREE */
#define TONGUEC 8  	/* OBJECT in TREE #17 */
#define TONGUEM 7  	/* OBJECT in TREE #0 */
#define LU_LINK 47  	/* OBJECT in TREE #1 */
#define FROMSCAL 26  	/* OBJECT in TREE #8 */
#define TO_SCAL 27  	/* OBJECT in TREE #8 */
#define COPYSCAL 25  	/* OBJECT in TREE #8 */
#define INTGRDUR 26  	/* OBJECT in TREE #10 */
#define FRACTDUR 28  	/* OBJECT in TREE #10 */
