#ifndef CONFIG_H

#define CONFIG_H

	/* General name */
#define GENERAL_NAME		"BFED"

	/* Executable name */
#define PRG_NAME	GENERAL_NAME##".PRG"

	/* Info file name */
#define INFO_NAME	GENERAL_NAME##".INF"

	/* Type of processor M68000, M68030, M68K (68030+68882) */
/* dans le PRJ */

	/* Revision of the executable */
#define VERSION	"10"

#endif