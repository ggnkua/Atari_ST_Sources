/* Indice du ressource pour BFED_FR */

#define MENU     0   /* Arbre menu */
#define DESK     3   /* TITLE dans l'arbre MENU */
#define FILE     4   /* TITLE dans l'arbre MENU */
#define EDIT     5   /* TITLE dans l'arbre MENU */
#define SEARCH   6   /* TITLE dans l'arbre MENU */
#define OPTIONS  7   /* TITLE dans l'arbre MENU */
#define WINDOWS  8   /* TITLE dans l'arbre MENU */
#define ABOUT    11  /* STRING dans l'arbre MENU */
#define NEW      20  /* STRING dans l'arbre MENU */
#define OPEN     21  /* STRING dans l'arbre MENU */
#define CLOSE    22  /* STRING dans l'arbre MENU */
#define SAVE     23  /* STRING dans l'arbre MENU */
#define SAVEAS   24  /* STRING dans l'arbre MENU */
#define DELETE   26  /* STRING dans l'arbre MENU */
#define SPACE    27  /* STRING dans l'arbre MENU */
#define SETPRINT 29  /* STRING dans l'arbre MENU */
#define PRINT    30  /* STRING dans l'arbre MENU */
#define QUIT     32  /* STRING dans l'arbre MENU */
#define START    34  /* STRING dans l'arbre MENU */
#define END      35  /* STRING dans l'arbre MENU */
#define SELECT_ALL 36  /* STRING dans l'arbre MENU */
#define CLEAR    37  /* STRING dans l'arbre MENU */
#define CUT      39  /* STRING dans l'arbre MENU */
#define COPY     40  /* STRING dans l'arbre MENU */
#define PASTE    41  /* STRING dans l'arbre MENU */
#define ERASE    42  /* STRING dans l'arbre MENU */
#define INSERT   44  /* STRING dans l'arbre MENU */
#define PROTECT  45  /* STRING dans l'arbre MENU */
#define GO_POS   47  /* STRING dans l'arbre MENU */
#define FIND     49  /* STRING dans l'arbre MENU */
#define FINDAGAIN 50  /* STRING dans l'arbre MENU */
#define REPLACE  52  /* STRING dans l'arbre MENU */
#define REPLACEAGAIN 53  /* STRING dans l'arbre MENU */
#define GROW_SHRINK 55  /* STRING dans l'arbre MENU */
#define BLACK_WHITE 56  /* STRING dans l'arbre MENU */
#define INFO_HEXA 57  /* STRING dans l'arbre MENU */
#define CLIPBOARD 58  /* STRING dans l'arbre MENU */
#define SAVEOPTS 60  /* STRING dans l'arbre MENU */
#define LOADOPTS 61  /* STRING dans l'arbre MENU */
#define ROTATE   63  /* STRING dans l'arbre MENU */
#define STACK    64  /* STRING dans l'arbre MENU */
#define TILE_HORIZ 65  /* STRING dans l'arbre MENU */
#define TILE_VERTIC 66  /* STRING dans l'arbre MENU */
#define ICONIFY  68  /* STRING dans l'arbre MENU */
#define ICONIFY_ALL 69  /* STRING dans l'arbre MENU */
#define UNICONIFY 70  /* STRING dans l'arbre MENU */

#define DINFO    1   /* Formulaire/Dialogue */
#define DINFO_NAME 1   /* STRING dans l'arbre DINFO */
#define XXED_ICONE 3   /* IMAGE dans l'arbre DINFO */
#define DINFO_VERSION 9   /* FTEXT dans l'arbre DINFO */

#define DSEARCH  2   /* Formulaire/Dialogue */
#define DSEARCH_NAME 1   /* STRING dans l'arbre DSEARCH */
#define SSTRING  3   /* FBOXTEXT dans l'arbre DSEARCH */
#define RSTRING  5   /* FBOXTEXT dans l'arbre DSEARCH */
#define SBUT     6   /* BUTTON dans l'arbre DSEARCH */
#define CANCEL1  7   /* BUTTON dans l'arbre DSEARCH */
#define RBUT     8   /* BUTTON dans l'arbre DSEARCH */
#define NBUT     9   /* BUTTON dans l'arbre DSEARCH */
#define SBACK    12  /* BUTTON dans l'arbre DSEARCH */
#define SFORWARD 13  /* BUTTON dans l'arbre DSEARCH */
#define SCUTBUF  14  /* BUTTON dans l'arbre DSEARCH */
#define SHEXA    15  /* BUTTON dans l'arbre DSEARCH */
#define RALL     17  /* BUTTON dans l'arbre DSEARCH */
#define RVER     18  /* BUTTON dans l'arbre DSEARCH */
#define RCUTBUF  19  /* BUTTON dans l'arbre DSEARCH */
#define RHEXA    20  /* BUTTON dans l'arbre DSEARCH */

#define DDISK    3   /* Formulaire/Dialogue */
#define DDISK_NAME 1   /* STRING dans l'arbre DDISK */
#define D4_TXT1  2   /* STRING dans l'arbre DDISK */
#define AA       4   /* BUTTON dans l'arbre DDISK */
#define BB       5   /* BUTTON dans l'arbre DDISK */
#define CC       6   /* BUTTON dans l'arbre DDISK */
#define DD       7   /* BUTTON dans l'arbre DDISK */
#define EE       8   /* BUTTON dans l'arbre DDISK */
#define FF       9   /* BUTTON dans l'arbre DDISK */
#define GG       10  /* BUTTON dans l'arbre DDISK */
#define HH       11  /* BUTTON dans l'arbre DDISK */
#define II       12  /* BUTTON dans l'arbre DDISK */
#define JJ       13  /* BUTTON dans l'arbre DDISK */
#define KK       14  /* BUTTON dans l'arbre DDISK */
#define LL       15  /* BUTTON dans l'arbre DDISK */
#define MM       16  /* BUTTON dans l'arbre DDISK */
#define NN       17  /* BUTTON dans l'arbre DDISK */
#define OO       18  /* BUTTON dans l'arbre DDISK */
#define PP       19  /* BUTTON dans l'arbre DDISK */
#define DRBOX    20  /* BOX dans l'arbre DDISK */
#define DRSTR1   21  /* TEXT dans l'arbre DDISK */
#define DRSTR2   22  /* TEXT dans l'arbre DDISK */
#define DRSTR3   23  /* TEXT dans l'arbre DDISK */

#define DPRINT   4   /* Formulaire/Dialogue */
#define DPRINT_NAME 1   /* STRING dans l'arbre DPRINT */
#define D7_TXT2  3   /* STRING dans l'arbre DPRINT */
#define PRINT_ID 4   /* FTEXT dans l'arbre DPRINT */
#define PRINT_ID_PLUS 5   /* BUTTON dans l'arbre DPRINT */
#define PRINT_ID_MOINS 6   /* BUTTON dans l'arbre DPRINT */
#define D7_TXT3  7   /* STRING dans l'arbre DPRINT */
#define PRINT_FN_PLUS 8   /* BUTTON dans l'arbre DPRINT */
#define FONT_ID  9   /* FTEXT dans l'arbre DPRINT */
#define PRINT_FN_MOINS 10  /* BUTTON dans l'arbre DPRINT */
#define PRINT_NAME 11  /* STRING dans l'arbre DPRINT */
#define FONT_NAME 12  /* STRING dans l'arbre DPRINT */
#define PRINT_GDOS 13  /* BUTTON dans l'arbre DPRINT */
#define PRINT_OK 14  /* BUTTON dans l'arbre DPRINT */
#define PRINT_ANN 15  /* BUTTON dans l'arbre DPRINT */

#define DPOS     5   /* Formulaire/Dialogue */
#define DPOS_NAME 1   /* STRING dans l'arbre DPOS */
#define GO_POS_IDX 2   /* FBOXTEXT dans l'arbre DPOS */
#define GO_POS_HEXA 4   /* BUTTON dans l'arbre DPOS */
#define GO_POS_OK 5   /* BUTTON dans l'arbre DPOS */
#define GO_POS_ANN 6   /* BUTTON dans l'arbre DPOS */

#define LOW_RES  0   /* Chaine d'alerte */

#define SAVE_CLOSE 1   /* Chaine d'alerte */

#define SAVE_ERR 2   /* Chaine d'alerte */

#define SAVE_NULL 3   /* Chaine d'alerte */

#define READ_ERR 4   /* Chaine d'alerte */

#define READ_ERR2 5   /* Chaine d'alerte */

#define FILE_EXIST 6   /* Chaine d'alerte */

#define MEMB_LIST 7   /* Chaine d'alerte */

#define NOMEM_BUF 8   /* Chaine d'alerte */

#define NOMEM_1  9   /* Chaine d'alerte */

#define NOMEM_2  10  /* Chaine d'alerte */

#define NOMEM_3  11  /* Chaine d'alerte */

#define NOMEM_4  12  /* Chaine d'alerte */

#define NOMEM_5  13  /* Chaine d'alerte */

#define PROTECTED 14  /* Chaine d'alerte */

#define NO_LASTBYTE 15  /* Chaine d'alerte */

#define ENTER_HEX 16  /* Chaine d'alerte */

#define LAST_BYTE2 17  /* Chaine d'alerte */

#define LAST_BYTE 18  /* Chaine d'alerte */

#define PASTEMODE 19  /* Chaine d'alerte */

#define WRONG_POS 20  /* Chaine d'alerte */

#define PRN_OFF  21  /* Chaine d'alerte */

#define PRN_BLK  22  /* Chaine d'alerte */

#define PRN_FILE 23  /* Chaine d'alerte */

#define SEARCH_NULL 24  /* Chaine d'alerte */

#define REPL_NULL 25  /* Chaine d'alerte */

#define NO_OCCUR 26  /* Chaine d'alerte */

#define NOT_FOUND 27  /* Chaine d'alerte */

#define NOWIND   28  /* Chaine d'alerte */

#define NOWIND_2 29  /* Chaine d'alerte */

#define NOWIND_3 30  /* Chaine d'alerte */

#define NOWIND_4 31  /* Chaine d'alerte */

#define S_UNTITLED 32  /* Chaine libre */

#define S_NOINFO 33  /* Chaine libre */

#define S_FREEBYTE 34  /* Chaine libre */

#define S_MODERP 35  /* Chaine libre */

#define S_MODEIN 36  /* Chaine libre */

#define S_POSSTR 37  /* Chaine libre */

#define S_LOADFILE 38  /* Chaine libre */

#define S_DELFILE 39  /* Chaine libre */

#define S_SAVEFILE 40  /* Chaine libre */

#define S_PROTECTED 41  /* Chaine libre */

#define S_NOTPROTECTED 42  /* Chaine libre */
