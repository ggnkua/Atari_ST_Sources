/*********************************************
	file: main.h
	utility: header file of main.c
	date: 14 dec 96
	author: C. Moreau
	modifications:
	comments: 
*********************************************/

#ifndef _MAIN_H
#define _MAIN_H

/*********************************************
	includes
*********************************************/

/*********************************************
	defines
*********************************************/

/*********************************************
	types definitions
*********************************************/

/*********************************************
	globals variables declarations
*********************************************/
extern int gl_apid;	/* global application identifier */

/*********************************************
	globals functions declarations
*********************************************/
extern void shutdown(int code);

#endif