#ifndef XXED_RSC_H
#define XXED_RSC_H

#include "bfed_fr.h"

#endif