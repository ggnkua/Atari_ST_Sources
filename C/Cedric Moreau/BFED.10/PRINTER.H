#ifndef PRINTER_H
#define PRINTER_H

extern void print(windowptr thewin);

#endif