/*********************************************
	file: button.h
	utility: header file of button.c
	date: 14 nov. 96
	author: C.Moreau
	modifications:
	comments: 
*********************************************/

#ifndef _BUTTON_H
#define _BUTTON_H

/*********************************************
	includes
*********************************************/

/*********************************************
	defines
*********************************************/

/*********************************************
	types definitions
*********************************************/

/*********************************************
	globals variables declarations
*********************************************/

/*********************************************
	globals functions declarations
*********************************************/

extern void do_button(int	mousex, int mousey);

#endif