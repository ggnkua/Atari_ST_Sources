/* compatibility with TC and some other compilers */
#include <malloc.h>
