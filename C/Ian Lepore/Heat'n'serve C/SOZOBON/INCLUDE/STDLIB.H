#pragma idempotent

/*****************************************************************************
 * STDLIB.H -- This is really bogus, non-ANSI to the max.
 *			   But, it's better than nothing, which is what sozobon had before.
 ****************************************************************************/

#ifndef STDLIB_H
#define STDLIB_H

#ifndef TYPES_H
  #include <types.h>
#endif

#ifndef STRING_H
  #include <string.h>
#endif

#ifndef MALLOC_H
  #include <malloc.h>
#endif

#ifndef MACROS_H
  #include <macros.h>
#endif

#endif
