
/* keyboard scancodes for common non-alnum keys */

#ifndef KEYDEFS_H
#define KEYDEFS_H

#define   FUNKEY1   0x3B
#define   FUNKEY2   0x3C
#define   FUNKEY3   0x3D
#define   FUNKEY4   0x3E
#define   FUNKEY5   0x3F
#define   FUNKEY6   0x40
#define   FUNKEY7   0x41
#define   FUNKEY8   0x42
#define   FUNKEY9   0x43
#define   FUNKEY10  0x44
#define   HELPKEY   0x62
#define   UNDOKEY   0x61
#define   INSKEY    0x52
#define   CLRKEY    0x47
#define   RETKEY    0x1C
#define   ENTKEY    0x72
#define   UPKEY     0x48
#define   DWNKEY    0x50
#define   LEFTKEY   0x4B
#define   RGHTKEY   0x4D
#define   ESCKEY    0x01

#endif
