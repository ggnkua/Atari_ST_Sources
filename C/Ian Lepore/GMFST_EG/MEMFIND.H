/* resource set indicies for MEMFIND */

#define MAINTREE 0	/* form/dialog */

