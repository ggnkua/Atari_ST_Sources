;*========================================================================
;* VDIFAST Public Domain VDI bindings.
;*========================================================================

	.include	"vdimacro.s"

;*------------------------------------------------------------------------
;* Bar.
;*------------------------------------------------------------------------

_v_bar::
	.cargs	#4,.handle.w,.pxy.l
	moveq.l	#11,d0
	moveq.l	#1,d1
	moveq.l	#2,d2
	move.l	.pxy(sp),a0
	jmp	vout_pxy

	end
