
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"
          
;*************************************************************************
;*
;* Form Manager routines 1 of 3.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; form_do
;-------------------------------------------------------------------------

_form_do::
          .cargs    #4,.ptree.l,.obj
          AControl  50,1,1,1
          lea       .obj(sp),a1         ; -> intin
          lea       .ptree(sp),a0       ; -> addrin
          ACall     RET2USER  

;-------------------------------------------------------------------------
; form_error
; form_dial
;-------------------------------------------------------------------------

_form_error::
          AControl  53,1,1,0
          bra.s     form_erdi
_form_dial::
          AControl  51,9,1,0
form_erdi:
          .cargs    #4,.intin
          lea       .intin(sp),a1       ; -> intin 
          ACall     RET2USER  

;-------------------------------------------------------------------------
; form_center
;-------------------------------------------------------------------------

_form_center::
          .cargs    #8,.ptree.l,.px.l,.py.l,.pw.l,.ph.l

          link      a6,#-10
          
          AControl  54,0,5,1

          moveq.l   #-10,d2       
          lea       .ptree(a6),a0
          ACall     RET2HERE

          moveq.l   #-10,d1
          lea       .px(a6),a1
          jmp       (a0)
          
;         end of code

