
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"
          
;*************************************************************************
;*
;* Scrap manager routines.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; scrp_read
; scrp_write
;-------------------------------------------------------------------------

_scrp_read::
          AControl  80,0,1,1
          bra.s     scrp_do
_scrp_write::
          AControl  81,0,1,1
scrp_do:
          .cargs    #4,.ptr.l
          lea       .ptr(sp),a0       ; -> addrin
          ACall     RET2USER
          
;         end of code

