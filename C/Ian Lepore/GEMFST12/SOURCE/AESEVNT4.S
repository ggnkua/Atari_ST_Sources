
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"

;*************************************************************************
;*
;* Event manager routines 4 of n.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; evnt_message 
;-------------------------------------------------------------------------

_evnt_mesag::
          .cargs    #4,.pbuf.l
          AControl  23,0,1,1
          lea       .pbuf(sp),a0        ; -> addrin
          ACall     RET2USER

;         end of code

