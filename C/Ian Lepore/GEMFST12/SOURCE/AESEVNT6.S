
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"

;*************************************************************************
;*
;* Event manager routines 6 of n.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; evnt_dclick
;-------------------------------------------------------------------------

_evnt_dclick::
          .cargs    #4,.new,.flag
          AControl  26,2,1,0
          lea       .new(sp),a1         ; -> intin
          ACall     RET2USER
          
;         end of code

