
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"
          
;*************************************************************************
;*
;* Graphics Library routines 1 of 5.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; graf_rubberbox
;-------------------------------------------------------------------------

_graf_rubberbox::
          .cargs    #8,.mx,.my,.mw,.mh,.pw.l,.ph.l
          link      a6,#-6
          
          AControl  70,4,3,0

          moveq.l   #-6,d2              ;  = intout        
          lea       .mx(a6),a1          ; -> intin
          ACall     RET2HERE

          moveq.l   #-6,d1
          lea       .pw(a6),a1
          jmp       (a0)
          
;-------------------------------------------------------------------------
; graf_dragbox
;-------------------------------------------------------------------------

_graf_dragbox::
          .cargs    #8,.sw,.sh,.sx,.sy,.bx,.by,.bw,.bh,.px.l,.py.l
          link      a6,#-6
          AControl  71,8,3,0
          
          moveq.l   #-6,d2              ;  = intout
          lea       .sw(a6),a1          ; -> intin
          ACall     RET2HERE

          moveq.l   #-6,d1
          lea       .px(a6),a1
          jmp       (a0)

;         end of code

