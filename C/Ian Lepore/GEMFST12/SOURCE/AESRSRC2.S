
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"
          
;*************************************************************************
;*
;* Resource manager routines 2 of 2.
;*
;*************************************************************************
          
;-------------------------------------------------------------------------
; rsrc_saddr
;-------------------------------------------------------------------------

_rsrc_saddr::
          .cargs    #4,.type,.idx,.addr.l
          AControl  113,2,1,1
          lea       .type(sp),a1
          lea       .addr(sp),a0
          ACall     RET2USER
          
;-------------------------------------------------------------------------
; rsrc_obfix
;-------------------------------------------------------------------------

_rsrc_obfix::
          .cargs    #4,.ptree.l,.obj
          AControl  114,1,1,1
          lea       .obj(sp),a1
          lea       .ptree(sp),a0
          ACall     RET2USER
          
;         end of code

