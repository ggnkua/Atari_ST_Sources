
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"

;*************************************************************************
;*
;* Event manager routines 1 of n.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; evnt_keybd (The easy one).
;-------------------------------------------------------------------------

_evnt_keybd::
          AControl  20,0,1,0
          ACall     RET2USER
         
;-------------------------------------------------------------------------
; evnt_button
;-------------------------------------------------------------------------

_evnt_button::
          .cargs    #8,.bclicks,.mask,.state,.px.l,.py.l,.pbutton.l,.pstate.l
          
          link      a6,#-10             ; allocate intout[5].
          
          AControl  21,3,5,0

          moveq.l   #-10,d2             ; =  intout
          lea       .bclicks(a6),a1     ; -> intin
          
          ACall     RET2HERE

          moveq.l   #-10,d1
          lea       .px(a6),a1
          jmp       (a0)

;         end of code

