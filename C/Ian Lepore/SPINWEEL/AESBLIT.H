
/* written by Ian Lepore
** Copyright 1990 by Antic Publishing, Inc.
*/

#ifndef AESBLIT_H

#define AESBLIT_H 1

#define AESBLIT_SAVESCRN 0
#define AESBLIT_RSTRSCRN 1

extern int aes_blit();

#endif
