
/* written by Ian Lepore
** Copyright 1990 by Antic Publishing, Inc.
*/

/* resource set indicies for SPINWEEL */

#define MENUTREE 0	/* menu tree */
#define MENUDESK 3	/* TITLE in tree MENUTREE */
#define MENUCMDS 4	/* TITLE in tree MENUTREE */
#define MENUOPTS 5	/* TITLE in tree MENUTREE */
#define MDSKINFO 8	/* STRING in tree MENUTREE */
#define MCMDDRAW 17	/* STRING in tree MENUTREE */
#define MCMDNEW  18	/* STRING in tree MENUTREE */
#define MCMDCLRS 20	/* STRING in tree MENUTREE */
#define MCMDSAVE 22	/* STRING in tree MENUTREE */
#define MCMDLOAD 23	/* STRING in tree MENUTREE */
#define MCMDHELP 25	/* STRING in tree MENUTREE */
#define MCMDQUIT 27	/* STRING in tree MENUTREE */
#define MOPTSMTH 29	/* STRING in tree MENUTREE */
#define MOPTPFMT 31	/* STRING in tree MENUTREE */
#define MOPTSSAM 33	/* STRING in tree MENUTREE */
#define MOPTRBGC 35	/* STRING in tree MENUTREE */
#define MOPTPALT 36	/* STRING in tree MENUTREE */
#define MOPTSPEN 37	/* STRING in tree MENUTREE */

#define INFOTREE 1	/* form/dialog */

#define COLRTREE 2	/* form/dialog */
#define COLRBXDF 3	/* BOX in tree COLRTREE */

#define SPEDTREE 3	/* form/dialog */
#define SPEDSCAL 1	/* BOX in tree SPEDTREE */
#define SPEDSLID 2	/* BOX in tree SPEDTREE */

#define SMTHTREE 4	/* form/dialog */
#define SMTHPBSL 3	/* IBOX in tree SMTHTREE */
#define SMTHPBCA 6	/* BOX in tree SMTHTREE */
#define SMTHPTCA 8	/* BOXCHAR in tree SMTHTREE */
#define SMTHPBFA 12	/* BOX in tree SMTHTREE */
#define SMTHPTFA 14	/* BOXCHAR in tree SMTHTREE */
#define SMTHPBVL 18	/* BOX in tree SMTHTREE */
#define SMTHSTCA 19	/* STRING in tree SMTHTREE */
#define SMTHSTFA 21	/* STRING in tree SMTHTREE */
#define SMTHBXOK 22	/* BUTTON in tree SMTHTREE */

#define SIZETREE 5	/* form/dialog */
#define SIZEBRFX 1	/* BUTTON in tree SIZETREE */
#define SIZEBRRL 2	/* BUTTON in tree SIZETREE */
#define SIZEBRPP 3	/* BUTTON in tree SIZETREE */
#define SIZEBXDN 4	/* BUTTON in tree SIZETREE */

#define HELPTREE 6	/* form/dialog */

#define SSAMTREE 7	/* form/dialog */
#define SSAMBRFP 2	/* BUTTON in tree SSAMTREE */
#define SSAMBRVP 4	/* BUTTON in tree SSAMTREE */


