;*========================================================================
;* VDIFAST Public Domain VDI bindings.
;*========================================================================

	.include	"vdimacro.s"

;*------------------------------------------------------------------------
;* Show cursor.
;*------------------------------------------------------------------------

_v_show_c::
	.cargs	#8,.handle.w,.reset.w
	link	a6,#0

	VContrl	#122,,,#1

	lea	-12(sp),sp	;* -> ptsout, intout, ptsin
	pea	.reset(a6)	;* -> intin
	pea	16(sp)		;* -> contrl

	jmp	vdicall

;*------------------------------------------------------------------------
;* Hide cursor.
;*------------------------------------------------------------------------

_v_hide_c::
	.cargs	#8,.handle.w
	link	a6,#0

	VContrl	#123
	pea	(sp)	        ;* -> contrl
	jmp	vdicall

	end
