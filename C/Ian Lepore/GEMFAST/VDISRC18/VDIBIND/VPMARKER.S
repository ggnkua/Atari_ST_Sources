;*========================================================================
;* VDIFAST Public Domain VDI bindings.
;*========================================================================

	.include	"vdimacro.s"

;*------------------------------------------------------------------------
;* Polymarker.
;*------------------------------------------------------------------------

_v_pmarker::
	.cargs	#4,.handle.w,.count.w,.pxy.l

	moveq.l	#7,d0
	moveq.l	#0,d1
	move.w	.count(sp),d2
	move.l	.pxy(sp),a0
	jmp	vout_pxy

	end
