/* resource set indicies for FORMDEMO */

#define MAINTREE 0	/* form/dialog */
#define RSCCUBUT 8	/* STRING in tree MAINTREE */
#define RSCRRBUT 9	/* STRING in tree MAINTREE */
#define FRMEFLAG 10	/* STRING in tree MAINTREE */
#define FRMQTEXT 11	/* STRING in tree MAINTREE */
#define FRMQERRO 12	/* STRING in tree MAINTREE */
#define FRMQUEST 13	/* STRING in tree MAINTREE */
#define FRMQMENU 14	/* STRING in tree MAINTREE */
#define FRMQCHOI 15	/* STRING in tree MAINTREE */
#define FRMPROGR 16	/* STRING in tree MAINTREE */
#define FRMDESKT 17	/* STRING in tree MAINTREE */
#define FRMMKMOV 18	/* STRING in tree MAINTREE */
#define MAINBXCD 20	/* BUTTON in tree MAINTREE */
#define MAINBXEX 21	/* BUTTON in tree MAINTREE */

#define MOVETREE 1	/* form/dialog */
#define MOVEBAR  1	/* BOXTEXT in tree MOVETREE */
#define MOVEEXIT 6	/* BUTTON in tree MOVETREE */

#define CBTNTREE 2	/* form/dialog */

#define RBTNTREE 3	/* form/dialog */

#define DEFLTREE 4	/* form/dialog */
#define DEFLPBB1 4	/* IBOX in tree DEFLTREE */
#define DEFLPBD1 11	/* IBOX in tree DEFLTREE */

#define FLAGTREE 5	/* form/dialog */
#define FLAGPBOD 8	/* IBOX in tree FLAGTREE */
#define FLAGPBIN 12	/* IBOX in tree FLAGTREE */
#define FLAGTEIF 16	/* FTEXT in tree FLAGTREE */
#define FLAGBXHM 17	/* BUTTON in tree FLAGTREE */
#define FLAGBXCN 18	/* BUTTON in tree FLAGTREE */
#define FLAGBXOK 19	/* BUTTON in tree FLAGTREE */

#define DESKTREE 6	/* form/dialog */

#define MENUTREE 7	/* menu tree */
#define MENDINFO 7	/* STRING in tree MENUTREE */
#define MENFFSEL 16	/* STRING in tree MENUTREE */
#define MENFQUIT 17	/* STRING in tree MENUTREE */

