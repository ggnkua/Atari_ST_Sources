/* resource set indicies for BROWSE */

#define MENUTREE 0	/* menu tree */
#define DESKINFO 7	/* STRING in tree MENUTREE */
#define MENFOPEN 16	/* STRING in tree MENUTREE */
#define MENFCLOS 17	/* STRING in tree MENUTREE */
#define MENFQUIT 19	/* STRING in tree MENUTREE */

