
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"
          
;*************************************************************************
;*
;* Form Manager routines 3 of 3.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; form_alert
;-------------------------------------------------------------------------

_form_alert::
          .cargs    #4,.def,.ptext
          AControl  52,1,1,1
          lea       .def(sp),a1         ; -> intin
          lea       .ptext(sp),a0       ; -> addrin
          ACall     RET2USER

;         end of code

