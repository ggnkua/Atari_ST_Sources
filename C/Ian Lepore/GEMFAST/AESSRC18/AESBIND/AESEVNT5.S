
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"

;*************************************************************************
;*
;* Event manager routines 5 of n.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; evnt_mouse
;-------------------------------------------------------------------------

_evnt_mouse::
          .cargs    #8,.flags,.mx,.my,.mw,.mh,.px.l,.py.l,.pbutton.l,.pstate.l
          
          link      a6,#-10
          
          AControl  22,5,5,0
          
          moveq.l   #-10,d2             ; -> intout
          lea       .flags(a6),a1       ; -> intin
          sub.l     a2,a2
          
          ACall     RET2HERE

          moveq.l   #-10,d1
          lea       .px(a6),a1
          jmp       (a0)

          
;         end of code

