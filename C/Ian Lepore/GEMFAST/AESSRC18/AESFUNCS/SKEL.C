/**************************************************************************
 * 
 *************************************************************************/

#include "gemfast.h"

/*-------------------------------------------------------------------------
 *
 *-----------------------------------------------------------------------*/

void func()
{
}

