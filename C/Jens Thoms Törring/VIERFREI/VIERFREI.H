/* resource set indices for VIERFREI */

#define MENU       0 /* menu */
#define T0         3 /* TITLE in tree MENU */
#define T1         4 /* TITLE in tree MENU */
#define T0E0       7 /* STRING in tree MENU */
#define T1E0      16 /* STRING in tree MENU */
#define T1E1      17 /* STRING in tree MENU */
#define T1E2      19 /* STRING in tree MENU */
#define T1E3      21 /* STRING in tree MENU */
#define T1E4      22 /* STRING in tree MENU */
#define T1E5      24 /* STRING in tree MENU */

#define GETNUM     1 /* free form */
#define NUMBER     2 /* FTEXT in tree GETNUM */
#define QUIT       3 /* BUTTON in tree GETNUM */
#define NREADY     4 /* BUTTON in tree GETNUM */

#define GRAT       2 /* free form */
#define GNUMBER    4 /* FTEXT in tree GRAT */
#define GREADY     2 /* BUTTON in tree GRAT */

#define ABOUT      3 /* free form */
#define AREADY     4 /* BUTTON in tree ABOUT */

#define WIND       4 /* free form */