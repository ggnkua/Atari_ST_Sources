/*  Deklarationsfile */
int dj_grafprint (int res, int w, int h, char *imgbase);
