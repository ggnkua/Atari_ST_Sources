
#define form1          0

#define sourcebox          1
#define destbox          2
#define tucbox          3
#define ok          4
#define cancel          5
#define boxtitle          6
#define fsel1          7
#define fsel2          8
#define fsel3          9
