/* Resource Datei Indizes f�r COGITO */

#define PACKMENU 0   /* Menuebaum */
#define MENUABOUT 8   /* STRING in Baum PACKMENU */
#define MENUSAVE 17  /* STRING in Baum PACKMENU */
#define MENUQUIT 19  /* STRING in Baum PACKMENU */
#define MENUORDNER 21  /* STRING in Baum PACKMENU */
#define MENUALLES 22  /* STRING in Baum PACKMENU */
#define MENUTASTE 23  /* STRING in Baum PACKMENU */
#define MENUMERKEN 24  /* STRING in Baum PACKMENU */
#define MENUOPT  26  /* STRING in Baum PACKMENU */

#define PACKDIAL 1   /* Formular/Dialog */
#define PACKZOO  1   /* BUTTON in Baum PACKDIAL */
#define PACKLZH  2   /* BUTTON in Baum PACKDIAL */
#define PACKZIP  3   /* BUTTON in Baum PACKDIAL */
#define PACKARJ  4   /* BUTTON in Baum PACKDIAL */
#define PACKARC  5   /* BUTTON in Baum PACKDIAL */
#define PACKXY2  6   /* BUTTON in Baum PACKDIAL */
#define PACKGREY 7   /* BOX in Baum PACKDIAL */
#define PACKEIN  8   /* BOXTEXT in Baum PACKDIAL */
#define PACKAUS  9   /* BOXTEXT in Baum PACKDIAL */
#define PACKINHALT 10  /* BOXTEXT in Baum PACKDIAL */
#define PACKOPT  11  /* BOXTEXT in Baum PACKDIAL */

#define SET2DIAL 2   /* Formular/Dialog */
#define SET2PACKEIN 4   /* BOXCHAR in Baum SET2DIAL */
#define SET2PACKAUS 6   /* BOXCHAR in Baum SET2DIAL */
#define SET2SHOW 8   /* BOXCHAR in Baum SET2DIAL */
#define SET2TYP  10  /* FTEXT in Baum SET2DIAL */
#define SET2EIN  11  /* FTEXT in Baum SET2DIAL */
#define SET2AUS  12  /* FTEXT in Baum SET2DIAL */
#define SET2INHALT 13  /* FTEXT in Baum SET2DIAL */
#define SET2OK   14  /* BUTTON in Baum SET2DIAL */

#define SETDIAL  3   /* Formular/Dialog */
#define SETTYP   2   /* TEXT in Baum SETDIAL */
#define SETORDNER 5   /* BOXCHAR in Baum SETDIAL */
#define SETALLES 7   /* BOXCHAR in Baum SETDIAL */
#define SETTASTE 9   /* BOXCHAR in Baum SETDIAL */
#define SETMERKEN 11  /* BOXCHAR in Baum SETDIAL */
#define SETEIN   13  /* FTEXT in Baum SETDIAL */
#define SETAUS   14  /* FTEXT in Baum SETDIAL */
#define SETINHALT 15  /* FTEXT in Baum SETDIAL */
#define SETINFO  16  /* BOXTEXT in Baum SETDIAL */
#define SETSAVE  17  /* BUTTON in Baum SETDIAL */
#define SETOK    18  /* BUTTON in Baum SETDIAL */
