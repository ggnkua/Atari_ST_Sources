/* Resource Datei Indizes f�r 7UP */

#define WINMENU  0   /* Menuebaum */
#define WINFILE  4   /* TITLE in Baum WINMENU */
#define WINEDIT  5   /* TITLE in Baum WINMENU */
#define WINSEAR  6   /* TITLE in Baum WINMENU */
#define WINBLK   7   /* TITLE in Baum WINMENU */
#define WINFORM  8   /* TITLE in Baum WINMENU */
#define WINMAC   9   /* TITLE in Baum WINMENU */
#define WINWIN   10  /* TITLE in Baum WINMENU */
#define WINOPT   11  /* TITLE in Baum WINMENU */
#define WINABOUT 14  /* STRING in Baum WINMENU */
#define WINNEW   23  /* STRING in Baum WINMENU */
#define WINOPEN  24  /* STRING in Baum WINMENU */
#define WINPICK  25  /* STRING in Baum WINMENU */
#define WINREAD  26  /* STRING in Baum WINMENU */
#define WININFO  27  /* STRING in Baum WINMENU */
#define WINCLOSE 29  /* STRING in Baum WINMENU */
#define WINSAVE  30  /* STRING in Baum WINMENU */
#define WINSAVAS 31  /* STRING in Baum WINMENU */
#define WINABORT 32  /* STRING in Baum WINMENU */
#define WINSHELL 34  /* STRING in Baum WINMENU */
#define WINLAY   36  /* STRING in Baum WINMENU */
#define WINPRINT 37  /* STRING in Baum WINMENU */
#define WINQUIT  39  /* STRING in Baum WINMENU */
#define EDITUNDO 41  /* STRING in Baum WINMENU */
#define EDITCUT  43  /* STRING in Baum WINMENU */
#define EDITCOPY 44  /* STRING in Baum WINMENU */
#define EDITPAST 45  /* STRING in Baum WINMENU */
#define EDITALL  46  /* STRING in Baum WINMENU */
#define EDITSHLF 48  /* STRING in Baum WINMENU */
#define EDITSHRT 49  /* STRING in Baum WINMENU */
#define EDITFORM 51  /* STRING in Baum WINMENU */
#define EDITSORT 52  /* STRING in Baum WINMENU */
#define EDITTOGL 53  /* STRING in Baum WINMENU */
#define EDITBIG  54  /* STRING in Baum WINMENU */
#define EDITSMAL 55  /* STRING in Baum WINMENU */
#define EDITCAPS 56  /* STRING in Baum WINMENU */
#define SEARFIND 58  /* STRING in Baum WINMENU */
#define SEARNEXT 59  /* STRING in Baum WINMENU */
#define SEARSEL  60  /* STRING in Baum WINMENU */
#define SEARBEG  62  /* STRING in Baum WINMENU */
#define SEAREND  63  /* STRING in Baum WINMENU */
#define SEARSMRK 65  /* STRING in Baum WINMENU */
#define SEARGMRK 66  /* STRING in Baum WINMENU */
#define SEARPAGE 68  /* STRING in Baum WINMENU */
#define SEARGOTO 69  /* STRING in Baum WINMENU */
#define SEARFILE 71  /* STRING in Baum WINMENU */
#define BLKCNT   73  /* STRING in Baum WINMENU */
#define BLKSUM   74  /* STRING in Baum WINMENU */
#define BLKMEAN  75  /* STRING in Baum WINMENU */
#define BLKSDEV  76  /* STRING in Baum WINMENU */
#define BLKMWST  77  /* STRING in Baum WINMENU */
#define BLKINTER 78  /* STRING in Baum WINMENU */
#define BLKALL   80  /* STRING in Baum WINMENU */
#define BLKKONF  82  /* STRING in Baum WINMENU */
#define FORMTAB  84  /* STRING in Baum WINMENU */
#define FORMUMBR 85  /* STRING in Baum WINMENU */
#define FORMBLK  86  /* STRING in Baum WINMENU */
#define BLKCOL   87  /* STRING in Baum WINMENU */
#define FORMINS  88  /* STRING in Baum WINMENU */
#define FORMIND  89  /* STRING in Baum WINMENU */
#define MACOPEN  91  /* STRING in Baum WINMENU */
#define MACSAVE  92  /* STRING in Baum WINMENU */
#define MACREC   94  /* STRING in Baum WINMENU */
#define MACSTOP  95  /* STRING in Baum WINMENU */
#define MACPLAY  96  /* STRING in Baum WINMENU */
#define MACSCT   98  /* STRING in Baum WINMENU */
#define WINOPALL 100 /* STRING in Baum WINMENU */
#define WINCLALL 101 /* STRING in Baum WINMENU */
#define WINNEXT2 102 /* STRING in Baum WINMENU */
#define WINARR1  104 /* STRING in Baum WINMENU */
#define WINARR2  105 /* STRING in Baum WINMENU */
#define WINARR3  106 /* STRING in Baum WINMENU */
#define WINFULL  108 /* STRING in Baum WINMENU */
#define WINDAT1  110 /* STRING in Baum WINMENU */
#define WINDAT2  111 /* STRING in Baum WINMENU */
#define WINDAT3  112 /* STRING in Baum WINMENU */
#define WINDAT4  113 /* STRING in Baum WINMENU */
#define WINDAT5  114 /* STRING in Baum WINMENU */
#define WINDAT6  115 /* STRING in Baum WINMENU */
#define WINDAT7  116 /* STRING in Baum WINMENU */
#define OPTHELP  118 /* STRING in Baum WINMENU */
#define OPTFONT  120 /* STRING in Baum WINMENU */
#define OPTCHARS 121 /* STRING in Baum WINMENU */
#define OPTFKT   123 /* STRING in Baum WINMENU */
#define OPTVIEW  124 /* STRING in Baum WINMENU */
#define OPTLIN   125 /* STRING in Baum WINMENU */
#define OPTBRACE 126 /* STRING in Baum WINMENU */
#define OPTCOMP  127 /* STRING in Baum WINMENU */
#define OPTDIV   129 /* STRING in Baum WINMENU */
#define OPTSAVE  130 /* STRING in Baum WINMENU */

#define DESKTOP  1   /* Formular/Dialog */
#define DESKICN1 1   /* ICON in Baum DESKTOP */
#define DESKICN2 2   /* ICON in Baum DESKTOP */
#define DESKICN3 3   /* ICON in Baum DESKTOP */
#define DESKICN4 4   /* ICON in Baum DESKTOP */
#define DESKICN5 5   /* ICON in Baum DESKTOP */
#define DESKICN6 6   /* ICON in Baum DESKTOP */
#define DESKICN7 7   /* ICON in Baum DESKTOP */
#define DESKICN8 8   /* ICON in Baum DESKTOP */
#define DESKICN9 9   /* ICON in Baum DESKTOP */
#define DESKICNA 10  /* ICON in Baum DESKTOP */
#define DESKICNB 11  /* ICON in Baum DESKTOP */
#define DESKICNC 12  /* ICON in Baum DESKTOP */
#define DESKICND 13  /* ICON in Baum DESKTOP */

#define FINDMENU 2   /* Formular/Dialog */
#define FINDSTR  4   /* FTEXT in Baum FINDMENU */
#define FINDREPL 6   /* FTEXT in Baum FINDMENU */
#define FINDNORM 9   /* BOXTEXT in Baum FINDMENU */
#define FINDMAT  10  /* BOXTEXT in Baum FINDMENU */
#define FINDGREP 11  /* BOXTEXT in Baum FINDMENU */
#define FINDSUCH 14  /* BOXTEXT in Baum FINDMENU */
#define FINDBLK  15  /* BOXTEXT in Baum FINDMENU */
#define FINDANF  16  /* BOXTEXT in Baum FINDMENU */
#define FINDIGNO 17  /* BOXTEXT in Baum FINDMENU */
#define FINDWORD 18  /* BOXTEXT in Baum FINDMENU */
#define FINDFORW 21  /* BOXTEXT in Baum FINDMENU */
#define FINDBACK 22  /* BOXTEXT in Baum FINDMENU */
#define FINDERS  23  /* BOXTEXT in Baum FINDMENU */
#define FINDASK  24  /* BOXTEXT in Baum FINDMENU */
#define FINDALL  25  /* BOXTEXT in Baum FINDMENU */
#define FINDALLQ 27  /* FTEXT in Baum FINDMENU */
#define FINDSINQ 29  /* FTEXT in Baum FINDMENU */
#define FINDHELP 30  /* BOXTEXT in Baum FINDMENU */
#define FINDABBR 31  /* BOXTEXT in Baum FINDMENU */
#define FINDOK   32  /* BOXTEXT in Baum FINDMENU */

#define GOTOMENU 3   /* Formular/Dialog */
#define GOTOLINE 4   /* FTEXT in Baum GOTOMENU */
#define GOTOABBR 5   /* BOXTEXT in Baum GOTOMENU */
#define GOTOOK   6   /* BOXTEXT in Baum GOTOMENU */

#define TABMENU  4   /* Formular/Dialog */
#define TABULAT  4   /* FTEXT in Baum TABMENU */
#define TABABBR  5   /* BOXTEXT in Baum TABMENU */
#define TABOK    6   /* BOXTEXT in Baum TABMENU */

#define COPYINFO 5   /* Formular/Dialog */
#define CDATE    5   /* STRING in Baum COPYINFO */
#define CNAME    9   /* TEXT in Baum COPYINFO */
#define THEOLOGO 10  /* IMAGE in Baum COPYINFO */
#define CINFO    11  /* BOXTEXT in Baum COPYINFO */
#define COPYOK   12  /* BOXTEXT in Baum COPYINFO */

#define SHELMENU 6   /* Formular/Dialog */
#define SHELCOMM 4   /* FTEXT in Baum SHELMENU */
#define SHELLGEM 5   /* BOXTEXT in Baum SHELMENU */
#define SHELHELP 6   /* BOXTEXT in Baum SHELMENU */
#define SHELABBR 7   /* BOXTEXT in Baum SHELMENU */
#define SHELLOK  8   /* BOXTEXT in Baum SHELMENU */

#define CHARTBL  7   /* Formular/Dialog */
#define FCHAR    3   /* STRING in Baum CHARTBL */
#define CHARHELP 259 /* BOXTEXT in Baum CHARTBL */
#define CHAROK   260 /* BOXTEXT in Baum CHARTBL */

#define FSELBOX  8   /* Formular/Dialog */
#define FSELTEXT 1   /* TEXT in Baum FSELBOX */

#define SHARWARE 9   /* Formular/Dialog */
#define SHAREREGIST 14  /* BOXTEXT in Baum SHARWARE */
#define SHAREOK  15  /* BOXTEXT in Baum SHARWARE */

#define FONTSEL  10  /* Formular/Dialog */
#define FSSHOW   3   /* BOXTEXT in Baum FONTSEL */
#define FNTITLE  4   /* BOXTEXT in Baum FONTSEL */
#define FSTITLE  5   /* BOXTEXT in Baum FONTSEL */
#define FTYPE1   7   /* TEXT in Baum FONTSEL */
#define FTYPE5   11  /* TEXT in Baum FONTSEL */
#define FTUP     13  /* BOXCHAR in Baum FONTSEL */
#define FTDN     14  /* BOXCHAR in Baum FONTSEL */
#define FTBOX    15  /* BOX in Baum FONTSEL */
#define FTSLIDE  16  /* BOX in Baum FONTSEL */
#define FSIZE1   18  /* TEXT in Baum FONTSEL */
#define FSIZE5   22  /* TEXT in Baum FONTSEL */
#define FSUP     24  /* BOXCHAR in Baum FONTSEL */
#define FSDN     25  /* BOXCHAR in Baum FONTSEL */
#define FSBOX    26  /* BOX in Baum FONTSEL */
#define FSSLIDE  27  /* BOX in Baum FONTSEL */
#define FTLF     29  /* BOXCHAR in Baum FONTSEL */
#define FTRT     30  /* BOXCHAR in Baum FONTSEL */
#define FTHBOX   31  /* BOX in Baum FONTSEL */
#define FTHSLD   32  /* BOX in Baum FONTSEL */
#define FSARBPT  34  /* FBOXTEXT in Baum FONTSEL */
#define FSHELP   35  /* BOXTEXT in Baum FONTSEL */
#define FSABBR   36  /* BOXTEXT in Baum FONTSEL */
#define FSOK     37  /* BOXTEXT in Baum FONTSEL */

#define PRTMENU  11  /* Formular/Dialog */
#define PRTNAME  3   /* TEXT in Baum PRTMENU */
#define PRTCOPY  4   /* FTEXT in Baum PRTMENU */
#define PRTPAGE  5   /* FTEXT in Baum PRTMENU */
#define PRTESC   6   /* BOXTEXT in Baum PRTMENU */

#define USERIMG  12  /* Formular/Dialog */
#define RBLNORM  1   /* IMAGE in Baum USERIMG */
#define RBLSEL   2   /* IMAGE in Baum USERIMG */
#define RBHNORM  3   /* IMAGE in Baum USERIMG */
#define RBHSEL   4   /* IMAGE in Baum USERIMG */
#define RBBNORM  5   /* IMAGE in Baum USERIMG */
#define RBBSEL   6   /* IMAGE in Baum USERIMG */
#define OBJ0     7   /* TEXT in Baum USERIMG */
#define RADIO    8   /* BOX in Baum USERIMG */
#define CHECK    9   /* BOX in Baum USERIMG */
#define CIRCLEL  11  /* IMAGE in Baum USERIMG */
#define CIRCLEH  12  /* IMAGE in Baum USERIMG */
#define CIRCLEB  13  /* IMAGE in Baum USERIMG */
#define WICON    20  /* IMAGE in Baum USERIMG */
#define RBHNORM3D 21  /* IMAGE in Baum USERIMG */
#define RBHSEL3D 22  /* IMAGE in Baum USERIMG */
#define CIRCLEHDIS 23  /* IMAGE in Baum USERIMG */
#define RBHBG3D  24  /* IMAGE in Baum USERIMG */

#define SHELL2   13  /* Formular/Dialog */
#define SH2PRG   4   /* BOXTEXT in Baum SHELL2 */
#define SH2PARAM 6   /* BOXTEXT in Baum SHELL2 */
#define SH2GEM   9   /* BOXTEXT in Baum SHELL2 */
#define SH2DOS   10  /* BOXTEXT in Baum SHELL2 */
#define SH2ALLR  11  /* BOXTEXT in Baum SHELL2 */
#define SH2NOP   14  /* BOXTEXT in Baum SHELL2 */
#define SH2AKTP  15  /* BOXTEXT in Baum SHELL2 */
#define SH2SAVE  18  /* BOXTEXT in Baum SHELL2 */
#define SH2BACK  19  /* BOXTEXT in Baum SHELL2 */
#define SH2OK    20  /* BUTTON in Baum SHELL2 */
#define SH2ABBR  21  /* BUTTON in Baum SHELL2 */

#define FKEYMENU 14  /* Formular/Dialog */
#define FKSHIFT  3   /* BOX in Baum FKEYMENU */
#define SFKEY1   4   /* FTEXT in Baum FKEYMENU */
#define SFKEY10  13  /* FTEXT in Baum FKEYMENU */
#define FKNORM   14  /* BOX in Baum FKEYMENU */
#define FKEY1    15  /* FTEXT in Baum FKEYMENU */
#define FKEY10   24  /* FTEXT in Baum FKEYMENU */
#define FKEYLOAD 25  /* BOXTEXT in Baum FKEYMENU */
#define FKEYSHFT 26  /* BOXTEXT in Baum FKEYMENU */
#define FKEYHELP 27  /* BOXTEXT in Baum FKEYMENU */
#define FKEYSAVE 28  /* BOXTEXT in Baum FKEYMENU */
#define FKEYABBR 29  /* BOXTEXT in Baum FKEYMENU */
#define FKEYOK   30  /* BOXTEXT in Baum FKEYMENU */

#define UMBRMENU 15  /* Formular/Dialog */
#define UMBRUCH  4   /* FTEXT in Baum UMBRMENU */
#define UMBRABBR 5   /* BOXTEXT in Baum UMBRMENU */
#define UMBROK   6   /* BOXTEXT in Baum UMBRMENU */

#define PRNINST  16  /* Formular/Dialog */
#define PRNLAY   4   /* TEXT in Baum PRNINST */
#define PRNKZSTR 6   /* FTEXT in Baum PRNINST */
#define PRNKZL   8   /* BOXTEXT in Baum PRNINST */
#define PRNKZM   9   /* BOXTEXT in Baum PRNINST */
#define PRNKZR   10  /* BOXTEXT in Baum PRNINST */
#define PRNFZSTR 13  /* FTEXT in Baum PRNINST */
#define PRNFZL   15  /* BOXTEXT in Baum PRNINST */
#define PRNFZM   16  /* BOXTEXT in Baum PRNINST */
#define PRNFZR   17  /* BOXTEXT in Baum PRNINST */
#define PRNPAPER 21  /* BUTTON in Baum PRNINST */
#define PRNCIRC1 22  /* BOXTEXT in Baum PRNINST */
#define PRNDIST  23  /* BUTTON in Baum PRNINST */
#define PRNCIRC3 24  /* BOXTEXT in Baum PRNINST */
#define PRNDRUCK 25  /* BUTTON in Baum PRNINST */
#define PRNCIRC2 26  /* BOXCHAR in Baum PRNINST */
#define PRNZLDN  31  /* BOXCHAR in Baum PRNINST */
#define PRNZL    32  /* TEXT in Baum PRNINST */
#define PRNZLUP  33  /* BOXCHAR in Baum PRNINST */
#define PRNLRDN  34  /* BOXCHAR in Baum PRNINST */
#define PRNLR    35  /* TEXT in Baum PRNINST */
#define PRNLRUP  36  /* BOXCHAR in Baum PRNINST */
#define PRNBLDN  37  /* BOXCHAR in Baum PRNINST */
#define PRNBL    38  /* TEXT in Baum PRNINST */
#define PRNBLUP  39  /* BOXCHAR in Baum PRNINST */
#define PRNORDN  40  /* BOXCHAR in Baum PRNINST */
#define PRNOR    41  /* TEXT in Baum PRNINST */
#define PRNORUP  42  /* BOXCHAR in Baum PRNINST */
#define PRNKZDN  43  /* BOXCHAR in Baum PRNINST */
#define PRNKZ    44  /* TEXT in Baum PRNINST */
#define PRNKZUP  45  /* BOXCHAR in Baum PRNINST */
#define PRNFZDN  46  /* BOXCHAR in Baum PRNINST */
#define PRNFZ    47  /* TEXT in Baum PRNINST */
#define PRNFZUP  48  /* BOXCHAR in Baum PRNINST */
#define PRNURDN  49  /* BOXCHAR in Baum PRNINST */
#define PRNUR    50  /* TEXT in Baum PRNINST */
#define PRNURUP  51  /* BOXCHAR in Baum PRNINST */
#define PRNZZ    52  /* TEXT in Baum PRNINST */
#define PRNLOAD  61  /* BOXTEXT in Baum PRNINST */
#define PRNSAVE  62  /* BOXTEXT in Baum PRNINST */
#define PRNHELP  63  /* BOXTEXT in Baum PRNINST */
#define PRNABBR  64  /* BOXTEXT in Baum PRNINST */
#define PRNOK    65  /* BOXTEXT in Baum PRNINST */

#define PRNINST2 17  /* Formular/Dialog */
#define PRNPGOFF 6   /* FTEXT in Baum PRNINST2 */
#define PRNFROM  7   /* FTEXT in Baum PRNINST2 */
#define PRNTO    8   /* FTEXT in Baum PRNINST2 */
#define PRNFCOL  9   /* FTEXT in Baum PRNINST2 */
#define PRNLCOL  10  /* FTEXT in Baum PRNINST2 */
#define PRNNUM   16  /* BOXTEXT in Baum PRNINST2 */
#define PRNKFBEG 19  /* BOXTEXT in Baum PRNINST2 */
#define PRNALT   20  /* BOXTEXT in Baum PRNINST2 */
#define PRNCUT   21  /* BOXTEXT in Baum PRNINST2 */
#define PRNALLP  22  /* BOXTEXT in Baum PRNINST2 */
#define PRNPAIR  23  /* BOXTEXT in Baum PRNINST2 */
#define PRNUNPA  24  /* BOXTEXT in Baum PRNINST2 */
#define PRNFF    25  /* BOXTEXT in Baum PRNINST2 */
#define PRNPAUSE 26  /* BOXTEXT in Baum PRNINST2 */
#define PRNNOFORM 27  /* BOXTEXT in Baum PRNINST2 */
#define PRNFILE  30  /* BOXTEXT in Baum PRNINST2 */
#define PRNBACK  31  /* BOXTEXT in Baum PRNINST2 */
#define PRNDEL   32  /* BOXTEXT in Baum PRNINST2 */
#define PRNCOPY  34  /* FTEXT in Baum PRNINST2 */
#define PRN2HELP 35  /* BOXTEXT in Baum PRNINST2 */
#define PRN2ABBR 36  /* BOXTEXT in Baum PRNINST2 */
#define PRN2OK   37  /* BOXTEXT in Baum PRNINST2 */

#define PREVIEW  18  /* Formular/Dialog */
#define PREVNAME 3   /* TEXT in Baum PREVIEW */
#define PREVPAGE 4   /* BOX in Baum PREVIEW */
#define PREVHELP 5   /* BOXTEXT in Baum PREVIEW */
#define PREVABBR 6   /* BOXTEXT in Baum PREVIEW */
#define PREVOK   7   /* BOXTEXT in Baum PREVIEW */

#define REPLMENU 19  /* Formular/Dialog */
#define REPLSTR  4   /* FTEXT in Baum REPLMENU */
#define REPLNEIN 5   /* BOXTEXT in Baum REPLMENU */
#define REPLABBR 6   /* BOXTEXT in Baum REPLMENU */
#define REPLJA   7   /* BOXTEXT in Baum REPLMENU */

#define INFOMENU 20  /* Formular/Dialog */
#define INFOTITL 2   /* BOXTEXT in Baum INFOMENU */
#define INFOEDIT 3   /* STRING in Baum INFOMENU */
#define INFOZUR  5   /* BOXCHAR in Baum INFOMENU */
#define INFOTNAME 6   /* FTEXT in Baum INFOMENU */
#define INFOMNAME 7   /* FTEXT in Baum INFOMENU */
#define INFOVOR  8   /* BOXCHAR in Baum INFOMENU */
#define INFODATE 10  /* FTEXT in Baum INFOMENU */
#define INFOTIME 12  /* FTEXT in Baum INFOMENU */
#define INFOSIZE 14  /* FTEXT in Baum INFOMENU */
#define INFOLINE 17  /* FTEXT in Baum INFOMENU */
#define INFOPAGE 19  /* FTEXT in Baum INFOMENU */
#define INFOLONG 21  /* FTEXT in Baum INFOMENU */
#define INFOTOTL 24  /* FTEXT in Baum INFOMENU */
#define INFOTBYT 27  /* FTEXT in Baum INFOMENU */
#define INFOFRAM 31  /* FTEXT in Baum INFOMENU */
#define INFOHELP 33  /* BOXTEXT in Baum INFOMENU */
#define INFOABBR 34  /* BOXTEXT in Baum INFOMENU */
#define INFOOK   35  /* BOXTEXT in Baum INFOMENU */

#define MARKMENU 21  /* Formular/Dialog */
#define MARKTITL 2   /* BOXTEXT in Baum MARKMENU */
#define MARK1    3   /* BOXTEXT in Baum MARKMENU */
#define MARK1MEM 4   /* FTEXT in Baum MARKMENU */
#define MARK2    5   /* BOXTEXT in Baum MARKMENU */
#define MARK2MEM 6   /* FTEXT in Baum MARKMENU */
#define MARK3    7   /* BOXTEXT in Baum MARKMENU */
#define MARK3MEM 8   /* FTEXT in Baum MARKMENU */
#define MARK4    9   /* BOXTEXT in Baum MARKMENU */
#define MARK4MEM 10  /* FTEXT in Baum MARKMENU */
#define MARK5    11  /* BOXTEXT in Baum MARKMENU */
#define MARK5MEM 12  /* FTEXT in Baum MARKMENU */
#define MARKABBR 13  /* BOXTEXT in Baum MARKMENU */

#define POPMENU  22  /* Formular/Dialog */
#define POPF1    1   /* STRING in Baum POPMENU */
#define POPF10   10  /* STRING in Baum POPMENU */

#define DIVERSES 23  /* Formular/Dialog */
#define DIVPATH  5   /* BOXTEXT in Baum DIVERSES */
#define DIVINFO  6   /* BOXTEXT in Baum DIVERSES */
#define DIVSTOOL 7   /* BOXTEXT in Baum DIVERSES */
#define DIVTABBAR 8   /* BOXTEXT in Baum DIVERSES */
#define DIVSCROLL 9   /* BOXTEXT in Baum DIVERSES */
#define DIVZENT  12  /* BOXTEXT in Baum DIVERSES */
#define DIVFREE  13  /* BOXTEXT in Baum DIVERSES */
#define DIVMAUS  14  /* BOXTEXT in Baum DIVERSES */
#define DIVDWIN  15  /* BOXTEXT in Baum DIVERSES */
#define DIVTABEX 18  /* BOXTEXT in Baum DIVERSES */
#define DIVKONV  19  /* BOXTEXT in Baum DIVERSES */
#define DIVUMLAUT 20  /* BOXTEXT in Baum DIVERSES */
#define DIVWRET  21  /* BOXTEXT in Baum DIVERSES */
#define DIVBLANK 22  /* BOXTEXT in Baum DIVERSES */
#define DIVCRLF  23  /* BOXTEXT in Baum DIVERSES */
#define DIVLF    24  /* BOXTEXT in Baum DIVERSES */
#define DIVCR    25  /* BOXTEXT in Baum DIVERSES */
#define DIVBACK  26  /* BOXTEXT in Baum DIVERSES */
#define DIVBUTIM 27  /* BOXTEXT in Baum DIVERSES */
#define DIVBACK2 28  /* FTEXT in Baum DIVERSES */
#define DIVDESK  32  /* BOXTEXT in Baum DIVERSES */
#define DIVPAPER 33  /* BOXTEXT in Baum DIVERSES */
#define DIVCLIP  34  /* BOXTEXT in Baum DIVERSES */
#define DIVVAST  35  /* BOXTEXT in Baum DIVERSES */
#define DIVNAME  36  /* BOXTEXT in Baum DIVERSES */
#define DIVSAVE  37  /* BOXTEXT in Baum DIVERSES */
#define DIVHDA   39  /* BUTTON in Baum DIVERSES */
#define DIVHELP  40  /* BOXTEXT in Baum DIVERSES */
#define DIVABBR  41  /* BOXTEXT in Baum DIVERSES */
#define DIVOK    42  /* BOXTEXT in Baum DIVERSES */

#define BRACES   24  /* Formular/Dialog */
#define CBRACE   5   /* BOXTEXT in Baum BRACES */
#define SBRACE   6   /* BOXTEXT in Baum BRACES */
#define RBRACE   7   /* BOXTEXT in Baum BRACES */
#define PBRACE   8   /* BOXTEXT in Baum BRACES */
#define PKOMBRAC 9   /* BOXTEXT in Baum BRACES */
#define CKOMBRAC 10  /* BOXTEXT in Baum BRACES */
#define FREE1BRACE 11  /* BOXTEXT in Baum BRACES */
#define FREE1BEG 12  /* FTEXT in Baum BRACES */
#define FREE1END 13  /* FTEXT in Baum BRACES */
#define FREE2BRACE 14  /* BOXTEXT in Baum BRACES */
#define FREE2BEG 15  /* FTEXT in Baum BRACES */
#define FREE2END 16  /* FTEXT in Baum BRACES */
#define FREE3BRACE 17  /* BOXTEXT in Baum BRACES */
#define FREE3BEG 18  /* FTEXT in Baum BRACES */
#define FREE3END 19  /* FTEXT in Baum BRACES */
#define FREE4BRACE 20  /* BOXTEXT in Baum BRACES */
#define FREE4BEG 21  /* FTEXT in Baum BRACES */
#define FREE4END 22  /* FTEXT in Baum BRACES */
#define FREE5BRACE 23  /* BOXTEXT in Baum BRACES */
#define FREE5BEG 24  /* FTEXT in Baum BRACES */
#define FREE5END 25  /* FTEXT in Baum BRACES */
#define BRACHELP 26  /* BOXTEXT in Baum BRACES */
#define BRACABBR 27  /* BOXTEXT in Baum BRACES */
#define BRACOK   28  /* BOXTEXT in Baum BRACES */

#define SORTMENU 25  /* Formular/Dialog */
#define SORTFROM 6   /* FTEXT in Baum SORTMENU */
#define SORTTO   8   /* FTEXT in Baum SORTMENU */
#define SORTCOL  10  /* FTEXT in Baum SORTMENU */
#define SORTUP   13  /* BOXTEXT in Baum SORTMENU */
#define SORTDN   14  /* BOXTEXT in Baum SORTMENU */
#define SORTLINE 17  /* BOXTEXT in Baum SORTMENU */
#define SORTGROUP 18  /* BOXTEXT in Baum SORTMENU */
#define SORTKRIT 19  /* BOXTEXT in Baum SORTMENU */
#define SORTEXTRA 20  /* BOXTEXT in Baum SORTMENU */
#define SORTIGNO 23  /* BOXTEXT in Baum SORTMENU */
#define SORTHELP 24  /* BOXTEXT in Baum SORTMENU */
#define SORTABBR 25  /* BOXTEXT in Baum SORTMENU */
#define SORTOK   26  /* BOXTEXT in Baum SORTMENU */

#define POPPRN   26  /* Formular/Dialog */
#define POPNO    1   /* STRING in Baum POPPRN */
#define POPEPS   2   /* STRING in Baum POPPRN */
#define POPIBM   3   /* STRING in Baum POPPRN */
#define POP21    4   /* STRING in Baum POPPRN */
#define POP22    5   /* STRING in Baum POPPRN */
#define POP23    6   /* STRING in Baum POPPRN */
#define POP24    7   /* STRING in Baum POPPRN */
#define POP25    8   /* STRING in Baum POPPRN */
#define POP26    9   /* STRING in Baum POPPRN */
#define POP27    10  /* STRING in Baum POPPRN */
#define POP28    11  /* STRING in Baum POPPRN */
#define POP29    12  /* STRING in Baum POPPRN */
#define POP30    13  /* STRING in Baum POPPRN */

#define POPPAPER 27  /* Formular/Dialog */
#define POPBASIS 1   /* STRING in Baum POPPAPER */
#define POPLETT  2   /* STRING in Baum POPPAPER */
#define POPLEGA  3   /* STRING in Baum POPPAPER */
#define POPHALF  4   /* STRING in Baum POPPAPER */
#define POPLEDG  5   /* STRING in Baum POPPAPER */
#define POPA3    6   /* STRING in Baum POPPAPER */
#define POPA4    7   /* STRING in Baum POPPAPER */
#define POPA5    8   /* STRING in Baum POPPAPER */
#define POPB5    9   /* STRING in Baum POPPAPER */
#define POPWIDE  10  /* STRING in Baum POPPAPER */

#define GREPMENU 28  /* Formular/Dialog */
#define GREPPATT 4   /* FTEXT in Baum GREPMENU */
#define GREPGREP 7   /* BOXTEXT in Baum GREPMENU */
#define GREPALL  8   /* BOXTEXT in Baum GREPMENU */
#define GREPFOLD 9   /* BOXTEXT in Baum GREPMENU */
#define GREPMARK 10  /* BOXTEXT in Baum GREPMENU */
#define GREPNAME 12  /* FTEXT in Baum GREPMENU */
#define GREPHELP 13  /* BOXTEXT in Baum GREPMENU */
#define GREPABBR 14  /* BOXTEXT in Baum GREPMENU */
#define GREPOK   15  /* BOXTEXT in Baum GREPMENU */

#define POPDIST  29  /* Formular/Dialog */
#define POPD1    1   /* STRING in Baum POPDIST */
#define POD2     3   /* STRING in Baum POPDIST */

#define NUMMENU  30  /* Formular/Dialog */
#define NUMNDT   5   /* BOXTEXT in Baum NUMMENU */
#define NUMNAMI  6   /* BOXTEXT in Baum NUMMENU */
#define NUMTSEP  7   /* BOXTEXT in Baum NUMMENU */
#define NUMNORM  10  /* BOXTEXT in Baum NUMMENU */
#define NUMMWSTN 11  /* FTEXT in Baum NUMMENU */
#define NUMERM   13  /* BOXTEXT in Baum NUMMENU */
#define NUMMWSTE 14  /* FTEXT in Baum NUMMENU */
#define NUMKOMMA 17  /* FTEXT in Baum NUMMENU */
#define NUMHELP  18  /* BOXTEXT in Baum NUMMENU */
#define NUMABBR  19  /* BOXTEXT in Baum NUMMENU */
#define NUMOK    20  /* BOXTEXT in Baum NUMMENU */

#define PICKLIST 31  /* Formular/Dialog */
#define PICKFIRST 4   /* TEXT in Baum PICKLIST */
#define PICKLAST 11  /* TEXT in Baum PICKLIST */
#define PICKUP   12  /* BOXCHAR in Baum PICKLIST */
#define PICKDN   13  /* BOXCHAR in Baum PICKLIST */
#define PICKBOX  14  /* BOX in Baum PICKLIST */
#define PICKSLID 15  /* BOX in Baum PICKLIST */
#define PICKINFO 16  /* BOXTEXT in Baum PICKLIST */
#define PICKCOMMENT 18  /* FTEXT in Baum PICKLIST */
#define PICKAKTIV 19  /* BOXTEXT in Baum PICKLIST */
#define PICKCLEAN 20  /* BOXTEXT in Baum PICKLIST */
#define PICKDEL  21  /* BOXTEXT in Baum PICKLIST */
#define PICKHELP 22  /* BOXTEXT in Baum PICKLIST */
#define PICKABBR 23  /* BOXTEXT in Baum PICKLIST */
#define PICKOK   24  /* BOXTEXT in Baum PICKLIST */

#define MENUEDITOR 32  /* Formular/Dialog */
#define MENUMVOR 6   /* BOXCHAR in Baum MENUEDITOR */
#define MENUMNAME 7   /* FBOXTEXT in Baum MENUEDITOR */
#define MENUMIDX 9   /* FBOXTEXT in Baum MENUEDITOR */
#define MENUMFILE 10  /* TEXT in Baum MENUEDITOR */
#define MENUMHELP 11  /* BOXTEXT in Baum MENUEDITOR */
#define MENUMSAVE 12  /* BOXTEXT in Baum MENUEDITOR */
#define MENUMLOAD 13  /* BOXTEXT in Baum MENUEDITOR */
#define MENUTAKTIV 16  /* BOXTEXT in Baum MENUEDITOR */
#define MENUTFILE 17  /* TEXT in Baum MENUEDITOR */
#define MENUTHELP 18  /* BOXTEXT in Baum MENUEDITOR */
#define MENUTSAVE 19  /* BOXTEXT in Baum MENUEDITOR */
#define MENUTLOAD 20  /* BOXTEXT in Baum MENUEDITOR */
#define MENUOK   21  /* BOXTEXT in Baum MENUEDITOR */

#define REGISTER 33  /* Formular/Dialog */
#define REGISTNAME 7   /* FTEXT in Baum REGISTER */
#define REGISTKEY 9   /* FTEXT in Baum REGISTER */
#define REGISTABBR 12  /* BOXTEXT in Baum REGISTER */
#define REGISTOK 13  /* BOXTEXT in Baum REGISTER */

#define TEXTFORMAT 34  /* Formular/Dialog */
#define FORMLEFT 5   /* BOXTEXT in Baum TEXTFORMAT */
#define FORMCENTER 6   /* BOXTEXT in Baum TEXTFORMAT */
#define FORMRIGHT 7   /* BOXTEXT in Baum TEXTFORMAT */
#define FORMBLOCK 8   /* BOXTEXT in Baum TEXTFORMAT */
#define FORMCURSOR 11  /* BOXTEXT in Baum TEXTFORMAT */
#define FORMPARA 12  /* BOXTEXT in Baum TEXTFORMAT */
#define FORMMARK 13  /* BOXTEXT in Baum TEXTFORMAT */
#define FORMLENGHT 15  /* FTEXT in Baum TEXTFORMAT */
#define FORMHELP 16  /* BOXTEXT in Baum TEXTFORMAT */
#define FORMABBR 17  /* BOXTEXT in Baum TEXTFORMAT */
#define FORMOK   18  /* BOXTEXT in Baum TEXTFORMAT */

#define SLISTBOX 35  /* Formular/Dialog */
#define SLBT1    1   /* TEXT in Baum SLISTBOX */
#define SLBT5    5   /* TEXT in Baum SLISTBOX */
#define SLBUP    6   /* BOXCHAR in Baum SLISTBOX */
#define SLBDN    7   /* BOXCHAR in Baum SLISTBOX */
#define SLBGR    8   /* BOX in Baum SLISTBOX */
#define SLBSL    9   /* BOX in Baum SLISTBOX */
