/* Resource Datei Indizes f�r FALERT3D */

#define FORM1    0   /* Formular/Dialog */
#define IMAGE0M  2   /* IMAGE in Baum FORM1 */
#define IMAGE0D  3   /* IMAGE in Baum FORM1 */
#define IMAGE1M  4   /* IMAGE in Baum FORM1 */
#define IMAGE1D  5   /* IMAGE in Baum FORM1 */
#define IMAGE2M  6   /* IMAGE in Baum FORM1 */
#define IMAGE2D  7   /* IMAGE in Baum FORM1 */
#define IMAGE3M  8   /* IMAGE in Baum FORM1 */
#define IMAGE3D  9   /* IMAGE in Baum FORM1 */
#define ASTRING0 11  /* STRING in Baum FORM1 */
#define ASTRING1 12  /* STRING in Baum FORM1 */
#define ASTRING2 13  /* STRING in Baum FORM1 */
#define ASTRING3 14  /* STRING in Baum FORM1 */
#define ASTRING4 15  /* STRING in Baum FORM1 */
#define BUTTON0  16  /* BOXTEXT in Baum FORM1 */
#define BUTTON1  17  /* BOXTEXT in Baum FORM1 */
#define BUTTON2  18  /* BOXTEXT in Baum FORM1 */
