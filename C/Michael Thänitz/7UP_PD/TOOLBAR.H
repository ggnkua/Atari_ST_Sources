#define EXOB_TYPE(x) (x>>8)
#define TABBAR 0xFF
#define TABSIGN '+' /*127*/
#define DEZTAB '#'

