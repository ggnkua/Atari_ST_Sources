/* Resource Datei Indizes f�r WORD */

#define FORM19   0   /* Formular/Dialog */
