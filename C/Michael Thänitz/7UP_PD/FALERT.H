/* Resource Datei Indizes f�r FALERT */

#define FALERT   0   /* Formular/Dialog */
#define IMAGE1   3   /* IMAGE in Baum FALERT */
#define STRING1  7   /* STRING in Baum FALERT */
#define BUTTON1  12  /* BOXTEXT in Baum FALERT */
