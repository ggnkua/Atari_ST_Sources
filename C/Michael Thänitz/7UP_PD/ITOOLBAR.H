/* Resource Datei Indizes f�r ITOOLBAR */

#define FORM1    0   /* Formular/Dialog */

#define FORM2    1   /* Formular/Dialog */
