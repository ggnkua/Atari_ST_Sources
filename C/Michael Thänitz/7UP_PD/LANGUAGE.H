#ifndef ENGLISH

#define NAMENLOS "NAMENLOS"

#define EMPTYTRASH "Datei aus dem M�ll holen"

#define SONNTAG    "Sonntag"
#define MONTAG     "Montag"
#define DIENSTAG   "Dienstag"
#define MITTWOCH   "Mittwoch"
#define DONNERSTAG "Donnerstag"
#define FREITAG    "Freitag"
#define SONNABEND  "Sonnabend"
#define MIT_SHIFT  "_mit "
#define OHNE_SHIFT "_ohne "


#define KHILFE   "Hilfe"
#define KABBRUCH "Abbruch"
#define KNEIN    "Nein"

#define SUCHE_SEITE "Seite suchen"
#define SEITE_____  "Seite:"
#define SUCHE_ZEILE "Zeile suchen"
#define ZEILE_____  "Zeile:"

#define KOMMANDO    "Kommando: "
#define PRESSANYKEY "\r\n-Bitte Taste dr�cken-"

#define MARKE_SETZEN "Marke setzen"
#define SUCHE_MARKE  "Marke suchen"

#define BENUTZER "BENUTZER: "

#define BLOCKINFO "Blockinformation"
#define DATEIINFO "Dateiinformation"

#define CALCLOCKMSG "\"Meldung von CALCLOCK: Druckauftrag erhalten.\""

#define PICKFILES "  %d Dateien"
#define PICKFILESSELECTED "  %d Dateien, 1 Datei selektiert"

#else

#define NAMENLOS "NONAME"

#define EMPTYTRASH "Pick file from trash"

#define SONNTAG    "Sunday"
#define MONTAG     "Monday"
#define DIENSTAG   "Tuesday"
#define MITTWOCH   "Wednesday"
#define DONNERSTAG "Thursday"
#define FREITAG    "Friday"
#define SONNABEND  "Saturday"
#define MIT_SHIFT  "with "
#define OHNE_SHIFT "no "

#define KHILFE   "Help"
#define KABBRUCH "Cancel"
#define KNEIN    "No"


#define SUCHE_SEITE "Goto page"
#define SEITE_____  "Page:"
#define SUCHE_ZEILE "Goto line"
#define ZEILE_____  "Line:"

#define KOMMANDO "Command: "
#define PRESSANYKEY "\r\n-Press any key to continue-"

#define MARKE_SETZEN "Set mark"
#define SUCHE_MARKE  "Goto mark"

#define BENUTZER "USER: "

#define BLOCKINFO "Block information"
#define DATEIINFO "File  information"

#define CALCLOCKMSG "\"Message from CALCLOCK: printjob received.\""

#define PICKFILES "  %d files"
#define PICKFILESSELECTED "  %d files, 1 file selected"

#endif