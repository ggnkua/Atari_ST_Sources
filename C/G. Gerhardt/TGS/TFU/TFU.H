#define UP 31
#define FBOX2 33
#define DOWN 32
#define IBOX 55
#define INFOLINE 57
#define FREELINE 67
#define OK 68
#define TFUBOX 0
#define TFU 2
#define RBOX 3
#define BBOX 5
#define GG 4
#define DELETE 6
#define COPY 7
#define INFO 9
#define RENAME 8
#define EXIT 10
#define FBOX1 11
#define FILE 13
#define PATH 12
#define DRIVE 23
#define CLOSE 30
