#define MENU 0
#define DESK 3
#define TGS 6
#define FTOP 2
#define DTOP 1
#define EDNAME 1
#define EDITBOX 3
#define EXECUTE 2
#define MOVE 4
#define EDIT 3
#define EDFIRST 3
#define PARAMS 5
#define SAVE 6
#define QUIT 7
#define THE 9
#define EDEDIT 13
#define EDDELETE 14
#define EDINSERT 15
#define EDUP 17
#define EDDOWN 18
#define EDCANCEL 19
#define EDOK 20
#define PARMBOX 4
#define FIRST 24
#define SHELL 23
#define PAFIRST 14
#define PAFSEL 24
#define PACANCEL 25
#define PAOK 26
#define TGSBOX 5
#define TGSOK 4
