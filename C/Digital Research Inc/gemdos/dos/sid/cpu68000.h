/********************************************************/
/*							*/
/*	Include file for SID-68K -- MC68000 Version	*/
/*							*/
/********************************************************/

#define MC68000 1

