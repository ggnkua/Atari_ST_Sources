   /* external function declarations for rcsread.c */
/*************************************************************
 * Copyright 1999 by Caldera Thin Clients, Inc.              *
 * This software is licensed under the GNU Public License.   *
 * Please see LICENSE.TXT for further information.           *
 *************************************************************/
#ifndef RSCREAD_H

#define RCSREAD_H

EXTERN	WORD	open_files(WORD def);
EXTERN	WORD	read_files(VOID);
EXTERN	WORD	merge_files(VOID);

#endif
