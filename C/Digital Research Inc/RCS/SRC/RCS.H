#define MENUTREE 0  	/* TREE */
#define TOOLBOX 1  	/* TREE */
#define FILEPBX 2  	/* TREE */
#define TYPETREE 3  	/* TREE */
#define DIALPBX 4  	/* TREE */
#define ICNPBX 5  	/* TREE */
#define NOBJTREE 6  	/* TREE */
#define MENUPBX 7  	/* TREE */
#define NEWMENU 8  	/* TREE */
#define ABOUTREE 9  	/* TREE */
#define SORTTREE 10  	/* TREE */
#define NEWALRT 11  	/* TREE */
#define ALRTPBX 12  	/* TREE */
#define NEWDIAL 13  	/* TREE */
#define NEWPANEL 14  	/* TREE */
#define OUTPTREE 15  	/* TREE */
#define STRDIAL 16  	/* TREE */
#define BITDIAL 17  	/* TREE */
#define ICONDIAL 18  	/* TREE */
#define BOXDIAL 19  	/* TREE */
#define TEXTDIAL 20  	/* TREE */
#define LOADDIAL 21  	/* TREE */
#define SAFEDIAL 22  	/* TREE */
#define INFODIAL 23  	/* TREE */
#define ICONTOOL 24  	/* TREE */
#define FREEPBX 25  	/* TREE */
#define POPSWTCH 26  	/* TREE */
#define POPRULE 27  	/* TREE */
#define POPPOSN 28  	/* TREE */
#define POPTHICK 29  	/* TREE */
#define POPPATRN 30  	/* TREE */
#define POPCOLOR 31  	/* TREE */
#define NAMETREE 32  	/* TREE */
#define PROGRESS 33  	/* TREE */
#define GRID 34  	/* TREE */
#define NEWICNSZ 35  	/* TREE */
#define DESKMENU 3  	/* OBJECT in TREE #0 */
#define FILEMENU 4  	/* OBJECT in TREE #0 */
#define GLOBMENU 5  	/* OBJECT in TREE #0 */
#define EDITMENU 6  	/* OBJECT in TREE #0 */
#define OPTNMENU 7  	/* OBJECT in TREE #0 */
#define ARRMENU 8  	/* OBJECT in TREE #0 */
#define SCREEN 9  	/* OBJECT in TREE #0 */
#define ABOUITEM 11  	/* OBJECT in TREE #0 */
#define ACCLINE 12  	/* OBJECT in TREE #0 */
#define NEWITEM 20  	/* OBJECT in TREE #0 */
#define OPENITEM 21  	/* OBJECT in TREE #0 */
#define MERGITEM 22  	/* OBJECT in TREE #0 */
#define CLOSITEM 24  	/* OBJECT in TREE #0 */
#define SAVEITEM 25  	/* OBJECT in TREE #0 */
#define SVASITEM 26  	/* OBJECT in TREE #0 */
#define RVRTITEM 27  	/* OBJECT in TREE #0 */
#define QUITITEM 29  	/* OBJECT in TREE #0 */
#define OUTPITEM 31  	/* OBJECT in TREE #0 */
#define SAFEITEM 32  	/* OBJECT in TREE #0 */
#define SVOSITEM 33  	/* OBJECT in TREE #0 */
#define PARTITEM 35  	/* OBJECT in TREE #0 */
#define TOOLITEM 36  	/* OBJECT in TREE #0 */
#define CUTITEM 38  	/* OBJECT in TREE #0 */
#define COPYITEM 39  	/* OBJECT in TREE #0 */
#define PASTITEM 40  	/* OBJECT in TREE #0 */
#define DELITEM 42  	/* OBJECT in TREE #0 */
#define INVITEM 44  	/* OBJECT in TREE #0 */
#define SOLIDIMG 45  	/* OBJECT in TREE #0 */
#define SIZEITEM 46  	/* OBJECT in TREE #0 */
#define INFITEM 48  	/* OBJECT in TREE #0 */
#define RNAMITEM 49  	/* OBJECT in TREE #0 */
#define TYPEITEM 50  	/* OBJECT in TREE #0 */
#define LOADITEM 51  	/* OBJECT in TREE #0 */
#define ICNEDITM 52  	/* OBJECT in TREE #0 */
#define SRTITEM 54  	/* OBJECT in TREE #0 */
#define UNHDITEM 55  	/* OBJECT in TREE #0 */
#define FLTITEM 57  	/* OBJECT in TREE #0 */
#define HOTBGCOL 1  	/* OBJECT in TREE #1 */
#define HOTPATRN 2  	/* OBJECT in TREE #1 */
#define HOTFGCOL 3  	/* OBJECT in TREE #1 */
#define HOTRULE 4  	/* OBJECT in TREE #1 */
#define HOTPOSN 5  	/* OBJECT in TREE #1 */
#define HOTSWTCH 6  	/* OBJECT in TREE #1 */
#define HOTBDCOL 7  	/* OBJECT in TREE #1 */
#define HOTTHICK 8  	/* OBJECT in TREE #1 */
#define CLIPBORD 9  	/* OBJECT in TREE #1 */
#define TRASHCAN 10  	/* OBJECT in TREE #1 */
#define UNKNICON 1  	/* OBJECT in TREE #2 */
#define MENUICON 2  	/* OBJECT in TREE #2 */
#define DIALICON 3  	/* OBJECT in TREE #2 */
#define PANLICON 4  	/* OBJECT in TREE #2 */
#define ALRTICON 5  	/* OBJECT in TREE #2 */
#define FREEICON 6  	/* OBJECT in TREE #2 */
#define OKITEM 6  	/* OBJECT in TREE #3 */
#define CANCITEM 7  	/* OBJECT in TREE #3 */
#define UNKNITEM 9  	/* OBJECT in TREE #3 */
#define PANLITEM 10  	/* OBJECT in TREE #3 */
#define MENUITEM 11  	/* OBJECT in TREE #3 */
#define DIALITEM 12  	/* OBJECT in TREE #3 */
#define ALRTITEM 13  	/* OBJECT in TREE #3 */
#define FREEITEM 14  	/* OBJECT in TREE #3 */
#define ICONSTRG 1  	/* OBJECT in TREE #5 */
#define DATASTRG 2  	/* OBJECT in TREE #5 */
#define MASKSTRG 3  	/* OBJECT in TREE #5 */
#define ICONWIND 4  	/* OBJECT in TREE #5 */
#define DATAWIND 5  	/* OBJECT in TREE #5 */
#define MASKWIND 6  	/* OBJECT in TREE #5 */
#define NOOKITEM 2  	/* OBJECT in TREE #6 */
#define NOCNITEM 3  	/* OBJECT in TREE #6 */
#define STRTYPES 8  	/* OBJECT in TREE #6 */
#define STRTYPE0 10  	/* OBJECT in TREE #6 */
#define TXTTYPES 12  	/* OBJECT in TREE #6 */
#define TXTTYPE0 13  	/* OBJECT in TREE #6 */
#define BOXTYPES 14  	/* OBJECT in TREE #6 */
#define BOXTYPE0 15  	/* OBJECT in TREE #6 */
#define XTYPE 16  	/* OBJECT in TREE #6 */
#define AOKITEM 5  	/* OBJECT in TREE #9 */
#define STOKITEM 13  	/* OBJECT in TREE #10 */
#define STCNITEM 14  	/* OBJECT in TREE #10 */
#define SRTXITEM 16  	/* OBJECT in TREE #10 */
#define SRTYITEM 17  	/* OBJECT in TREE #10 */
#define STXYITEM 18  	/* OBJECT in TREE #10 */
#define STYXITEM 19  	/* OBJECT in TREE #10 */
#define ALRTIMG 1  	/* OBJECT in TREE #11 */
#define ALRTSTR0 2  	/* OBJECT in TREE #11 */
#define ALRTBTN0 7  	/* OBJECT in TREE #11 */
#define APBXBTN 1  	/* OBJECT in TREE #12 */
#define APBXSTR 2  	/* OBJECT in TREE #12 */
#define APBXIMG0 3  	/* OBJECT in TREE #12 */
#define OUTPOK 2  	/* OBJECT in TREE #15 */
#define OUTPCANC 3  	/* OBJECT in TREE #15 */
#define CITEM 5  	/* OBJECT in TREE #15 */
#define PASCITEM 6  	/* OBJECT in TREE #15 */
#define CBITEM 7  	/* OBJECT in TREE #15 */
#define F77ITEM 8  	/* OBJECT in TREE #15 */
#define SRCITEM 18  	/* OBJECT in TREE #15 */
#define FSRTITEM 21  	/* OBJECT in TREE #15 */
#define OOKITEM 1  	/* OBJECT in TREE #16 */
#define OCNITEM 2  	/* OBJECT in TREE #16 */
#define OSTRITEM 4  	/* OBJECT in TREE #16 */
#define STRNAME 6  	/* OBJECT in TREE #16 */
#define BITNAME 2  	/* OBJECT in TREE #17 */
#define IBTEXT 2  	/* OBJECT in TREE #18 */
#define IBCHAR 3  	/* OBJECT in TREE #18 */
#define IBTPOS0 5  	/* OBJECT in TREE #18 */
#define IBCPOS0 9  	/* OBJECT in TREE #18 */
#define ICONNAME 19  	/* OBJECT in TREE #18 */
#define OCHRITEM 2  	/* OBJECT in TREE #19 */
#define BOXNAME 3  	/* OBJECT in TREE #19 */
#define TMPLTTAG 4  	/* OBJECT in TREE #20 */
#define OTMPITEM 5  	/* OBJECT in TREE #20 */
#define VALIDTAG 6  	/* OBJECT in TREE #20 */
#define OVALITEM 7  	/* OBJECT in TREE #20 */
#define OTEXITEM 9  	/* OBJECT in TREE #20 */
#define TEXTNAME 11  	/* OBJECT in TREE #20 */
#define LOADCANC 2  	/* OBJECT in TREE #21 */
#define LOADOK 3  	/* OBJECT in TREE #21 */
#define LOADDATA 4  	/* OBJECT in TREE #21 */
#define LOADMASK 5  	/* OBJECT in TREE #21 */
#define SAFEOK 12  	/* OBJECT in TREE #22 */
#define SAVECANC 14  	/* OBJECT in TREE #22 */
#define SAFEXPRT 15  	/* OBJECT in TREE #22 */
#define SAFENORM 16  	/* OBJECT in TREE #22 */
#define SAFELOCK 17  	/* OBJECT in TREE #22 */
#define INFOOBJ 5  	/* OBJECT in TREE #23 */
#define INFOIB 6  	/* OBJECT in TREE #23 */
#define INFOBB 7  	/* OBJECT in TREE #23 */
#define INFONAME 10  	/* OBJECT in TREE #23 */
#define INFOTI 14  	/* OBJECT in TREE #23 */
#define INFOIMG 15  	/* OBJECT in TREE #23 */
#define INFOSTR 16  	/* OBJECT in TREE #23 */
#define INFOTOT 17  	/* OBJECT in TREE #23 */
#define INFOLEFT 18  	/* OBJECT in TREE #23 */
#define INFOPANL 19  	/* OBJECT in TREE #23 */
#define INFOTREE 21  	/* OBJECT in TREE #23 */
#define INFOOK 22  	/* OBJECT in TREE #23 */
#define HRCTGBOX 2  	/* OBJECT in TREE #24 */
#define SRCTGBOX 3  	/* OBJECT in TREE #24 */
#define LINEBOX 4  	/* OBJECT in TREE #24 */
#define HPLYGBOX 5  	/* OBJECT in TREE #24 */
#define SPLYGBOX 6  	/* OBJECT in TREE #24 */
#define HARCBOX 7  	/* OBJECT in TREE #24 */
#define SARCBOX 8  	/* OBJECT in TREE #24 */
#define DOTBOX 9  	/* OBJECT in TREE #24 */
#define HOVALBOX 10  	/* OBJECT in TREE #24 */
#define SOVALBOX 11  	/* OBJECT in TREE #24 */
#define ERASEBOX 13  	/* OBJECT in TREE #24 */
#define FCLORBOX 14  	/* OBJECT in TREE #24 */
#define BCLORBOX 15  	/* OBJECT in TREE #24 */
#define GRIDBOX 17  	/* OBJECT in TREE #24 */
#define UNDOBOX 18  	/* OBJECT in TREE #24 */
#define RUBERBOX 19  	/* OBJECT in TREE #24 */
#define CLIPBOX 21  	/* OBJECT in TREE #24 */
#define CLIPSHOW 22  	/* OBJECT in TREE #24 */
#define PBXSTR 1  	/* OBJECT in TREE #25 */
#define PBXIMG 2  	/* OBJECT in TREE #25 */
#define SBLEPOP 1  	/* OBJECT in TREE #26 */
#define EXITPOP 2  	/* OBJECT in TREE #26 */
#define DFLTPOP 3  	/* OBJECT in TREE #26 */
#define RDIOPOP 4  	/* OBJECT in TREE #26 */
#define TCHXPOP 5  	/* OBJECT in TREE #26 */
#define EDBLPOP 6  	/* OBJECT in TREE #26 */
#define HDDNPOP 7  	/* OBJECT in TREE #26 */
#define SHADPOP 9  	/* OBJECT in TREE #26 */
#define CHEKPOP 10  	/* OBJECT in TREE #26 */
#define OUTLPOP 11  	/* OBJECT in TREE #26 */
#define CROSPOP 12  	/* OBJECT in TREE #26 */
#define DSBLPOP 13  	/* OBJECT in TREE #26 */
#define SLCTPOP 14  	/* OBJECT in TREE #26 */
#define ESCPOP 15  	/* OBJECT in TREE #26 */
#define BITBPOP 16  	/* OBJECT in TREE #26 */
#define SCCTRPOP 17  	/* OBJECT in TREE #26 */
#define D3INDPOP 18  	/* OBJECT in TREE #26 */
#define SYCOLPOP 19  	/* OBJECT in TREE #26 */
#define SUBMPOP 20  	/* OBJECT in TREE #26 */
#define WBAKPOP 21  	/* OBJECT in TREE #26 */
#define EXT3DPOP 22  	/* OBJECT in TREE #26 */
#define HIGHLPOP 23  	/* OBJECT in TREE #26 */
#define UHIGLPOP 24  	/* OBJECT in TREE #26 */
#define D3BAKPOP 25  	/* OBJECT in TREE #26 */
#define TRANSPOP 1  	/* OBJECT in TREE #27 */
#define RPLACPOP 2  	/* OBJECT in TREE #27 */
#define LARGEPOP 4  	/* OBJECT in TREE #27 */
#define SMALLPOP 5  	/* OBJECT in TREE #27 */
#define LEFTPOP 7  	/* OBJECT in TREE #27 */
#define RIGHTPOP 8  	/* OBJECT in TREE #27 */
#define CENTPOP 9  	/* OBJECT in TREE #27 */
#define JLFTPOP 1  	/* OBJECT in TREE #28 */
#define JCENPOP 2  	/* OBJECT in TREE #28 */
#define JRGTPOP 3  	/* OBJECT in TREE #28 */
#define JTOPPOP 5  	/* OBJECT in TREE #28 */
#define JMIDPOP 6  	/* OBJECT in TREE #28 */
#define JBOTPOP 7  	/* OBJECT in TREE #28 */
#define HFILLPOP 9  	/* OBJECT in TREE #28 */
#define VFILLPOP 10  	/* OBJECT in TREE #28 */
#define SNAPPOP 12  	/* OBJECT in TREE #28 */
#define OUT3POP 8  	/* OBJECT in TREE #29 */
#define OUT2POP 9  	/* OBJECT in TREE #29 */
#define OUT1POP 10  	/* OBJECT in TREE #29 */
#define NONEPOP 11  	/* OBJECT in TREE #29 */
#define IN1POP 12  	/* OBJECT in TREE #29 */
#define IN2POP 13  	/* OBJECT in TREE #29 */
#define IN3POP 14  	/* OBJECT in TREE #29 */
#define PAT0POP 1  	/* OBJECT in TREE #30 */
#define COL0POP 1  	/* OBJECT in TREE #31 */
#define NAMEITEM 3  	/* OBJECT in TREE #32 */
#define WRITING 3  	/* OBJECT in TREE #33 */
#define GRIDWIND 1  	/* OBJECT in TREE #34 */
#define BEGWDSZ 4  	/* OBJECT in TREE #35 */
#define LASTWDSZ 7  	/* OBJECT in TREE #35 */
#define BEGHTSZ 10  	/* OBJECT in TREE #35 */
#define LASTHTSZ 25  	/* OBJECT in TREE #35 */
#define SCALESZ 29  	/* OBJECT in TREE #35 */
#define KEEPSZ 31  	/* OBJECT in TREE #35 */
#define CLEARSZ 33  	/* OBJECT in TREE #35 */
#define OKCHNGSZ 34  	/* OBJECT in TREE #35 */
#define CNCLCHGS 35  	/* OBJECT in TREE #35 */
#define STNODEF 21  	/* STRING */
#define STMOVED 22  	/* STRING */
#define STLOMEM 23  	/* STRING */
#define STNMDUP 24  	/* STRING */
#define STNONAM 25  	/* STRING */
#define STLOCKED 26  	/* STRING */
#define STSIZEP 27  	/* STRING */
#define STNFULL 28  	/* STRING */
#define STPANIC 29  	/* STRING */
#define STNROOM 30  	/* STRING */
#define STNWNDW 31  	/* STRING */
#define STNMEM 32  	/* STRING */
#define SNDSPACE 33  	/* STRING */
#define STOOLONG 34  	/* STRING */
#define NOFNAME 35  	/* STRING */
#define ABNDCHGS 36  	/* STRING */
#define NOOVLERR 37  	/* STRING */
#define NOEDMEM 38  	/* STRING */
#define STTITLE 0		/* FREE STRING */
#define HIDEPART 1		/* FREE STRING */
#define SHOWPART 2		/* FREE STRING */
#define HIDETOOL 3		/* FREE STRING */
#define SHOWTOOL 4		/* FREE STRING */
#define STSTR 6		/* FREE STRING */
#define STIMG 7		/* FREE STRING */
#define STFRSTR 8		/* FREE STRING */
#define STBB 9		/* FREE STRING */
#define STFRIMG 10		/* FREE STRING */
#define STIB 11		/* FREE STRING */
#define STTI 12		/* FREE STRING */
#define STOBJ 13		/* FREE STRING */
#define STTRIND 14		/* FREE STRING */
#define STHDR 15		/* FREE STRING */
#define STNAME 16		/* FREE STRING */
#define STLDRES 17		/* FREE STRING */
#define STSASRES 18		/* FREE STRING */
#define STLDICN 19		/* FREE STRING */
#define STSASICN 20		/* FREE STRING */
#define CLIPMPTY 0		/* FREE IMAGE */
#define CLIPFULL 1		/* FREE IMAGE */
