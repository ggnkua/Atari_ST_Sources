#ifndef DESKRSRC_H

#define DESKRSRC_H

EXTERN	BYTE *ini_str(WORD stnum);
EXTERN	LONG obaddr(LONG tree, WORD obj, WORD fld_off);

#endif
