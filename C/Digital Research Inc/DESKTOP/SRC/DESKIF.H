#ifndef DESKIF_F

#define DESKIF_H

EXTERN	VOID gsx_moff(VOID);
EXTERN	VOID gsx_mon(VOID);
EXTERN	LONG obaddr(LONG tree, WORD obj, WORD fld_off);

#endif
