#ifndef DEWSKGLOB_H

#define DESKGLOB_H

/* this has been pulled out of GLOBES & moved here from DESKBIND.H */
EXTERN ICONBLK	gl_icons[NUM_WOBS];

EXTERN GLOBES	G;  

#endif
