#define ADMENU 0  	/* TREE */
#define ADFILEIN 1  	/* TREE */
#define ADDISKIN 2  	/* TREE */
#define ADFOLDIN 3  	/* TREE */
#define ADDINFO 4  	/* TREE */
#define ADNFINFO 5  	/* TREE */
#define ADOPENAP 6  	/* TREE */
#define ADINSDIS 7  	/* TREE */
#define ADINSAPP 8  	/* TREE */
#define ADCOPYDI 9  	/* TREE */
#define ADDELEDI 10  	/* TREE */
#define ADCPALER 11  	/* TREE */
#define ADMKDBOX 12  	/* TREE */
#define ADSETPRE 13  	/* TREE */
#define DESKMENU 3  	/* OBJECT in TREE #0 */
#define FILEMENU 4  	/* OBJECT in TREE #0 */
#define OPTNMENU 5  	/* OBJECT in TREE #0 */
#define VIEWMENU 6  	/* OBJECT in TREE #0 */
#define ABOUITEM 9  	/* OBJECT in TREE #0 */
#define OPENITEM 18  	/* OBJECT in TREE #0 */
#define SHOWITEM 19  	/* OBJECT in TREE #0 */
#define L2ITEM 20  	/* OBJECT in TREE #0 */
#define DELTITEM 21  	/* OBJECT in TREE #0 */
#define FORMITEM 22  	/* OBJECT in TREE #0 */
#define L3ITEM 23  	/* OBJECT in TREE #0 */
#define OUTPITEM 24  	/* OBJECT in TREE #0 */
#define QUITITEM 25  	/* OBJECT in TREE #0 */
#define IDSKITEM 27  	/* OBJECT in TREE #0 */
#define IAPPITEM 28  	/* OBJECT in TREE #0 */
#define L5ITEM 29  	/* OBJECT in TREE #0 */
#define PREFITEM 30  	/* OBJECT in TREE #0 */
#define SAVEITEM 31  	/* OBJECT in TREE #0 */
#define DOSITEM 32  	/* OBJECT in TREE #0 */
#define ICONITEM 34  	/* OBJECT in TREE #0 */
#define L4ITEM 35  	/* OBJECT in TREE #0 */
#define NAMEITEM 36  	/* OBJECT in TREE #0 */
#define TYPEITEM 37  	/* OBJECT in TREE #0 */
#define SIZEITEM 38  	/* OBJECT in TREE #0 */
#define DATEITEM 39  	/* OBJECT in TREE #0 */
#define FITITLE 1  	/* OBJECT in TREE #1 */
#define FINAME 2  	/* OBJECT in TREE #1 */
#define FISIZE 3  	/* OBJECT in TREE #1 */
#define FIDATE 4  	/* OBJECT in TREE #1 */
#define FITIME 5  	/* OBJECT in TREE #1 */
#define FIATTRS 6  	/* OBJECT in TREE #1 */
#define FIRWRITE 8  	/* OBJECT in TREE #1 */
#define FIRONLY 9  	/* OBJECT in TREE #1 */
#define FIOK 10  	/* OBJECT in TREE #1 */
#define FICNCL 11  	/* OBJECT in TREE #1 */
#define DITITLE 1  	/* OBJECT in TREE #2 */
#define DIDRIVE 2  	/* OBJECT in TREE #2 */
#define DIVOLUME 3  	/* OBJECT in TREE #2 */
#define DINFOLDS 4  	/* OBJECT in TREE #2 */
#define DINFILES 5  	/* OBJECT in TREE #2 */
#define DIUSED 6  	/* OBJECT in TREE #2 */
#define DIAVAIL 7  	/* OBJECT in TREE #2 */
#define DIOK 8  	/* OBJECT in TREE #2 */
#define FOLDINFO 1  	/* OBJECT in TREE #3 */
#define FOLNAME 2  	/* OBJECT in TREE #3 */
#define FOLDATE 3  	/* OBJECT in TREE #3 */
#define FOLTIME 4  	/* OBJECT in TREE #3 */
#define FOLNFOLD 5  	/* OBJECT in TREE #3 */
#define FOLNFILE 6  	/* OBJECT in TREE #3 */
#define FOLSIZE 7  	/* OBJECT in TREE #3 */
#define FOLOK 8  	/* OBJECT in TREE #3 */
#define DEICON 7  	/* OBJECT in TREE #4 */
#define DEOK 11  	/* OBJECT in TREE #4 */
#define NFINOK 7  	/* OBJECT in TREE #5 */
#define APPLOPEN 1  	/* OBJECT in TREE #6 */
#define APPLNAME 2  	/* OBJECT in TREE #6 */
#define APPLPARM 3  	/* OBJECT in TREE #6 */
#define APPLOK 4  	/* OBJECT in TREE #6 */
#define APPLCNCL 5  	/* OBJECT in TREE #6 */
#define DRDINS 1  	/* OBJECT in TREE #7 */
#define DRID 2  	/* OBJECT in TREE #7 */
#define DRLABEL 3  	/* OBJECT in TREE #7 */
#define DRTYPE 4  	/* OBJECT in TREE #7 */
#define DRBUTNS 5  	/* OBJECT in TREE #7 */
#define DRFLOPPY 6  	/* OBJECT in TREE #7 */
#define DRHARD 7  	/* OBJECT in TREE #7 */
#define DRINST 8  	/* OBJECT in TREE #7 */
#define DRREM 9  	/* OBJECT in TREE #7 */
#define DRCNCL 10  	/* OBJECT in TREE #7 */
#define INSAPP 1  	/* OBJECT in TREE #8 */
#define APNAME 2  	/* OBJECT in TREE #8 */
#define APDOCU 3  	/* OBJECT in TREE #8 */
#define APDFTYPE 4  	/* OBJECT in TREE #8 */
#define APTYPE 12  	/* OBJECT in TREE #8 */
#define APGEM 14  	/* OBJECT in TREE #8 */
#define APDOS 15  	/* OBJECT in TREE #8 */
#define APPARMS 16  	/* OBJECT in TREE #8 */
#define APMEM 17  	/* OBJECT in TREE #8 */
#define APMEMBOX 18  	/* OBJECT in TREE #8 */
#define APYMEM 19  	/* OBJECT in TREE #8 */
#define APNMEM 20  	/* OBJECT in TREE #8 */
#define APICON 21  	/* OBJECT in TREE #8 */
#define APFTITLE 22  	/* OBJECT in TREE #8 */
#define APFILEBO 23  	/* OBJECT in TREE #8 */
#define APF1NAME 24  	/* OBJECT in TREE #8 */
#define APF2NAME 25  	/* OBJECT in TREE #8 */
#define APSCRLBA 26  	/* OBJECT in TREE #8 */
#define APFUPARO 27  	/* OBJECT in TREE #8 */
#define APFDNARO 28  	/* OBJECT in TREE #8 */
#define APFSVSLI 29  	/* OBJECT in TREE #8 */
#define APFSVELE 30  	/* OBJECT in TREE #8 */
#define APINST 31  	/* OBJECT in TREE #8 */
#define APREMV 32  	/* OBJECT in TREE #8 */
#define APCNCL 33  	/* OBJECT in TREE #8 */
#define CDCOPY 1  	/* OBJECT in TREE #9 */
#define CDFOLDS 2  	/* OBJECT in TREE #9 */
#define CDFILES 3  	/* OBJECT in TREE #9 */
#define CDOK 4  	/* OBJECT in TREE #9 */
#define CDCNCL 5  	/* OBJECT in TREE #9 */
#define DDDELETE 1  	/* OBJECT in TREE #10 */
#define DDFOLDS 2  	/* OBJECT in TREE #10 */
#define DDFILES 3  	/* OBJECT in TREE #10 */
#define DDOK 4  	/* OBJECT in TREE #10 */
#define DDCNCL 5  	/* OBJECT in TREE #10 */
#define CACOPY 1  	/* OBJECT in TREE #11 */
#define CACURRNA 2  	/* OBJECT in TREE #11 */
#define CACOPYNA 3  	/* OBJECT in TREE #11 */
#define CAOK 4  	/* OBJECT in TREE #11 */
#define CACNCL 5  	/* OBJECT in TREE #11 */
#define CASTOP 6  	/* OBJECT in TREE #11 */
#define MKNAME 2  	/* OBJECT in TREE #12 */
#define MKOK 3  	/* OBJECT in TREE #12 */
#define MKCNCL 4  	/* OBJECT in TREE #12 */
#define SPTITLE 1  	/* OBJECT in TREE #13 */
#define SPCNFDEL 2  	/* OBJECT in TREE #13 */
#define SPCDYES 4  	/* OBJECT in TREE #13 */
#define SPCDNO 5  	/* OBJECT in TREE #13 */
#define SPCNFCOP 6  	/* OBJECT in TREE #13 */
#define SPCCYES 8  	/* OBJECT in TREE #13 */
#define SPCCNO 9  	/* OBJECT in TREE #13 */
#define SPCOWYES 12  	/* OBJECT in TREE #13 */
#define SPCOWNO 13  	/* OBJECT in TREE #13 */
#define SPDCLICK 14  	/* OBJECT in TREE #13 */
#define SPDC1 16  	/* OBJECT in TREE #13 */
#define SPDC2 17  	/* OBJECT in TREE #13 */
#define SPDC3 18  	/* OBJECT in TREE #13 */
#define SPDC4 19  	/* OBJECT in TREE #13 */
#define SPDC5 20  	/* OBJECT in TREE #13 */
#define SPMNCLKY 22  	/* OBJECT in TREE #13 */
#define SPMNCLKN 23  	/* OBJECT in TREE #13 */
#define SPSEYES 27  	/* OBJECT in TREE #13 */
#define SPSENO 28  	/* OBJECT in TREE #13 */
#define SPTF12HR 31  	/* OBJECT in TREE #13 */
#define SPTF24HR 32  	/* OBJECT in TREE #13 */
#define SPDFMMDD 35  	/* OBJECT in TREE #13 */
#define SPDFDDMM 36  	/* OBJECT in TREE #13 */
#define SPOK 37  	/* OBJECT in TREE #13 */
#define SPCNCL 38  	/* OBJECT in TREE #13 */
#define STNOAPPL 24  	/* STRING */
#define STNOWIND 25  	/* STRING */
#define STNOFRMT 26  	/* STRING */
#define STFORMAT 27  	/* STRING */
#define STBADCOP 28  	/* STRING */
#define STDELDIS 29  	/* STRING */
#define STAPGONE 30  	/* STRING */
#define STFOEXIS 31  	/* STRING */
#define STDISKFU 32  	/* STRING */
#define STNOFILE 33  	/* STRING */
#define STNOINF 34  	/* STRING */
#define STFO8DEE 35  	/* STRING */
#define STDEEPPA 36  	/* STRING */
#define STINFOST 0		/* FREE STRING */
#define STASICON 1		/* FREE STRING */
#define STAPPL 2		/* FREE STRING */
#define STDOCU 3		/* FREE STRING */
#define STDKFRM1 4		/* FREE STRING */
#define STASTEXT 5		/* FREE STRING */
#define STGEMHIC 6		/* FREE STRING */
#define STGEMAPP 7		/* FREE STRING */
#define STGEMLOI 8		/* FREE STRING */
#define STGEMOUT 9		/* FREE STRING */
#define STGEMBAT 10		/* FREE STRING */
#define ST1STD 11		/* FREE STRING */
#define ST2STD 12		/* FREE STRING */
#define ST3STD 13		/* FREE STRING */
#define ST4STD 14		/* FREE STRING */
#define ST5STD 15		/* FREE STRING */
#define ST6STD 16		/* FREE STRING */
#define STDKFRM2 17		/* FREE STRING */
#define STNEWFOL 18		/* FREE STRING */
#define STDSKDRV 19		/* FREE STRING */
#define STAM 20		/* FREE STRING */
#define STPM 21		/* FREE STRING */
