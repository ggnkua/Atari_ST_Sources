/* 8x12 font */

#include "portab.h"
#include "fontdef.h"

EXTERN	UWORD	off_f8x12[],dat_f8x12[];

struct font_head f8x12 ={
    1,			/*   WORD font_id	*/
    10,			/*   WORD point		*/
"System",		/*   BYTE name[32]	*/
    0,			/*   UWORD first_ade	*/
    255,		/*   UWORD last_ade	*/
    8,	    		/*   UWORD top		*/
    6,	    		/*   UWORD ascent	*/
    4,	    		/*   UWORD half		*/
    1,	    		/*   UWORD descent	*/		
    3,			/*   UWORD bottom	*/
    7,			/*   UWORD max_char_width*/
    8,			/*   UWORD max_cell_width*/
    1,			/*   UWORD left_offset	*/
    4,			/*   UWORD right_offset	*/
    1,			/*   UWORD thicken	*/
    1,			/*   UWORD ul_size	*/
    0x5555,		/*   UWORD lighten	*/
    0x5555,		/*   UWORD skew		*/
  STDFORM | MONOSPACE | DEFAULT,/*   UWORD flags        */

    0,			/*   UBYTE *hor_table	*/
    off_f8x12,		/*   UWORD *off_table	*/
    dat_f8x12,		/*   UWORD *dat_table	*/
    256,		/*   UWORD form_width	*/
    12,			/*   UWORD form_height	*/

    0,    		/*   UWORD next_font	*/
    0			/*   UWORD next_seg	*/
};

UWORD off_f8x12[257] =
{
	0x0, 0x8, 0x10, 0x18, 0x20, 0x28, 0x30, 0x38, 
	0x40, 0x48, 0x50, 0x58, 0x60, 0x68, 0x70, 0x78, 
	0x80, 0x88, 0x90, 0x98, 0xA0, 0xA8, 0xB0, 0xB8, 
	0xC0, 0xC8, 0xD0, 0xD8, 0xE0, 0xE8, 0xF0, 0xF8, 
	0x100, 0x108, 0x110, 0x118, 0x120, 0x128, 0x130, 0x138, 
	0x140, 0x148, 0x150, 0x158, 0x160, 0x168, 0x170, 0x178, 
	0x180, 0x188, 0x190, 0x198, 0x1A0, 0x1A8, 0x1B0, 0x1B8, 
	0x1C0, 0x1C8, 0x1D0, 0x1D8, 0x1E0, 0x1E8, 0x1F0, 0x1F8, 
	0x200, 0x208, 0x210, 0x218, 0x220, 0x228, 0x230, 0x238, 
	0x240, 0x248, 0x250, 0x258, 0x260, 0x268, 0x270, 0x278, 
	0x280, 0x288, 0x290, 0x298, 0x2A0, 0x2A8, 0x2B0, 0x2B8, 
	0x2C0, 0x2C8, 0x2D0, 0x2D8, 0x2E0, 0x2E8, 0x2F0, 0x2F8, 
	0x300, 0x308, 0x310, 0x318, 0x320, 0x328, 0x330, 0x338, 
	0x340, 0x348, 0x350, 0x358, 0x360, 0x368, 0x370, 0x378, 
	0x380, 0x388, 0x390, 0x398, 0x3A0, 0x3A8, 0x3B0, 0x3B8, 
	0x3C0, 0x3C8, 0x3D0, 0x3D8, 0x3E0, 0x3E8, 0x3F0, 0x3F8, 
	0x400, 0x408, 0x410, 0x418, 0x420, 0x428, 0x430, 0x438, 
	0x440, 0x448, 0x450, 0x458, 0x460, 0x468, 0x470, 0x478, 
	0x480, 0x488, 0x490, 0x498, 0x4A0, 0x4A8, 0x4B0, 0x4B8, 
	0x4C0, 0x4C8, 0x4D0, 0x4D8, 0x4E0, 0x4E8, 0x4F0, 0x4F8, 
	0x500, 0x508, 0x510, 0x518, 0x520, 0x528, 0x530, 0x538, 
	0x540, 0x548, 0x550, 0x558, 0x560, 0x568, 0x570, 0x578, 
	0x580, 0x588, 0x590, 0x598, 0x5A0, 0x5A8, 0x5B0, 0x5B8, 
	0x5C0, 0x5C8, 0x5D0, 0x5D8, 0x5E0, 0x5E8, 0x5F0, 0x5F8, 
	0x600, 0x608, 0x610, 0x618, 0x620, 0x628, 0x630, 0x638, 
	0x640, 0x648, 0x650, 0x658, 0x660, 0x668, 0x670, 0x678, 
	0x680, 0x688, 0x690, 0x698, 0x6A0, 0x6A8, 0x6B0, 0x6B8, 
	0x6C0, 0x6C8, 0x6D0, 0x6D8, 0x6E0, 0x6E8, 0x6F0, 0x6F8, 
	0x700, 0x708, 0x710, 0x718, 0x720, 0x728, 0x730, 0x738, 
	0x740, 0x748, 0x750, 0x758, 0x760, 0x768, 0x770, 0x778, 
	0x780, 0x788, 0x790, 0x798, 0x7A0, 0x7A8, 0x7B0, 0x7B8, 
	0x7C0, 0x7C8, 0x7D0, 0x7D8, 0x7E0, 0x7E8, 0x7F0, 0x7F8, 
	0x800
};

UWORD dat_f8x12[1536] =
{
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x3E, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x631C, 
	0xE00, 0x0, 0x0, 0x0, 0x63, 0x6300, 0x0, 0x0, 
	0x0, 0x0, 0x3B, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x703B, 0x3B00, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x18, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x1C00, 0xFF, 0xF800, 0x0, 0xF, 0x0, 0x7F18, 
	0x4001, 0x1833, 0x7F63, 0x18, 0x1818, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1800, 0x0, 
	0x0, 0x71E, 0x38, 0x1E00, 0x1C00, 0x3800, 0x1C38, 0x36, 
	0x1800, 0x1C, 0x38, 0x1C38, 0x0, 0x8, 0x0, 0x0, 
	0x70E, 0x707, 0x3B6E, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x1B3B, 0x300, 0x0, 0x186E, 0x6E00, 0xE00, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x18, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x8, 0x1C08, 0x10FF, 0xF808, 0x100, 0x180F, 0x3C3F, 0x6318, 
	0x6003, 0x3C33, 0xDB30, 0x3C, 0x3C18, 0x0, 0x0, 0x87F, 
	0x18, 0x6622, 0x830, 0x3C1C, 0xC18, 0x0, 0x0, 0x1, 
	0x3E0C, 0x3C7F, 0xE7F, 0xC7F, 0x3E3E, 0x0, 0x600, 0x303E, 
	0x3E1C, 0x7E3E, 0x7C7F, 0x7F3E, 0x633C, 0x663, 0x6063, 0x633E, 
	0x7E3E, 0x7E3E, 0xFF63, 0x6363, 0x63C3, 0x7F3E, 0x403E, 0xC00, 
	0x1C00, 0x6000, 0x300, 0xF00, 0x600C, 0x660, 0x3C00, 0x0, 
	0x0, 0x0, 0x3000, 0x0, 0x0, 0xE, 0x1838, 0x3B08, 
	0x3E63, 0xC33, 0x330C, 0x3300, 0x3636, 0xC36, 0x360C, 0x1C1C, 
	0x0, 0x1F36, 0x630C, 0x360C, 0x633E, 0x6308, 0x1E63, 0x7C0F, 
	0xC18, 0xC0C, 0x6E00, 0x3E3E, 0x0, 0x20, 0x2000, 0x0, 
	0x366E, 0x3E00, 0x3F, 0x0, 0x33, 0x1818, 0x3F7E, 0x7EF1, 
	0x337B, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x3C, 0x7F00, 0x7F00, 0x0, 0x3C3E, 0x3E1F, 0xE18, 0x3E3E, 
	0x8, 0x6003, 0xE18, 0x0, 0x1E1C, 0x7, 0x3E3C, 0x3C00, 
	0x1C, 0x1C0C, 0x30FF, 0xF81C, 0x31C, 0x240E, 0x6633, 0x7FDB, 
	0x7007, 0x7E33, 0xDB1C, 0x7E, 0x7E18, 0xC18, 0x24, 0x1C7F, 
	0x18, 0x6622, 0x3E33, 0x660C, 0x180C, 0x3608, 0x0, 0x3, 
	0x633C, 0x6606, 0x1E60, 0x1803, 0x6363, 0x1C1C, 0xC00, 0x1863, 
	0x4336, 0x6363, 0x6660, 0x6063, 0x6318, 0x666, 0x6077, 0x7363, 
	0x6363, 0x6363, 0x1863, 0x6363, 0x63C3, 0x630, 0x6006, 0x1E00, 
	0x1800, 0x6000, 0x300, 0x1800, 0x6000, 0x60, 0xC00, 0x0, 
	0x0, 0x0, 0x3000, 0x0, 0x0, 0x18, 0x180C, 0x6E1C, 
	0x6300, 0x0, 0x0, 0x1E00, 0x0, 0x0, 0x0, 0x361C, 
	0x7F00, 0x3C00, 0x0, 0x0, 0x63, 0x633E, 0x3363, 0x6618, 
	0x0, 0x0, 0x63, 0x363, 0xC00, 0x60, 0x6018, 0x0, 
	0x0, 0x6303, 0x6C, 0x1C1C, 0x3E00, 0x18, 0x7E81, 0x815B, 
	0x33, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x66, 0x3300, 0x3300, 0x0, 0x1863, 0x630C, 0x1818, 0x6063, 
	0x7F08, 0x180C, 0x1B18, 0xC3B, 0x333E, 0x4, 0x3306, 0x3C00, 
	0x3E, 0x1CFE, 0x7FFF, 0xF83E, 0x62A, 0x2408, 0x663F, 0x633C, 
	0x7C1F, 0x1833, 0xDB36, 0x18, 0x1818, 0x630, 0x6066, 0x1C3E, 
	0x18, 0x667F, 0x6806, 0x6418, 0x3006, 0x1C08, 0x0, 0x6, 
	0x670C, 0x60C, 0x367E, 0x3006, 0x6363, 0x1C1C, 0x187F, 0xC03, 
	0x4F63, 0x6360, 0x6360, 0x6060, 0x6318, 0x66C, 0x606B, 0x7B63, 
	0x6363, 0x6360, 0x1863, 0x636B, 0x3666, 0xC30, 0x3006, 0x3300, 
	0xC3E, 0x7E3E, 0x3F3E, 0x183F, 0x7E3C, 0x1E63, 0xC76, 0x7E3E, 
	0x7E3F, 0x6E3E, 0x7E63, 0x6363, 0x6363, 0x7E18, 0x180C, 0x36, 
	0x6063, 0x3E3E, 0x3E3E, 0x3E3F, 0x3E3E, 0x3E3C, 0x3C3C, 0x6336, 
	0x607E, 0x6C3E, 0x3E3E, 0x6363, 0x6363, 0x636B, 0x3036, 0x7C18, 
	0x3E3C, 0x3E63, 0x7E73, 0x3F63, 0x0, 0x60, 0x6000, 0x3366, 
	0x3E3E, 0x673E, 0x7E6C, 0x3636, 0x6300, 0x7E, 0x7E9D, 0xB955, 
	0x7733, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x3B66, 0x30FF, 0x183F, 0x667E, 0x7E63, 0x6306, 0x7E7E, 0x6063, 
	0x7F, 0x630, 0x1818, 0x6E, 0x333E, 0x4, 0x330C, 0x3C00, 
	0x7F, 0x1CFF, 0xFFFF, 0xF87F, 0x649, 0x2408, 0x6630, 0x63E7, 
	0x7F7F, 0x1833, 0x5B63, 0x18, 0x1818, 0x7F7F, 0x60FF, 0x3E3E, 
	0x18, 0x22, 0x3E0C, 0x3800, 0x3006, 0x7F7F, 0x7F, 0xC, 
	0x6B0C, 0xC1E, 0x6603, 0x7E0C, 0x3E3F, 0x0, 0x3000, 0x60E, 
	0x5B63, 0x7E60, 0x637E, 0x7E6F, 0x7F18, 0x678, 0x606B, 0x6F63, 
	0x7E63, 0x7E3E, 0x1863, 0x636B, 0x1C3C, 0x1830, 0x1806, 0x0, 
	0x3, 0x6363, 0x6363, 0x7F63, 0x630C, 0x666, 0xC6B, 0x6363, 
	0x6363, 0x7360, 0x3063, 0x636B, 0x3663, 0xC70, 0x7, 0x63, 
	0x6063, 0x6303, 0x303, 0x360, 0x6363, 0x630C, 0xC0C, 0x6363, 
	0x7E1B, 0x6F63, 0x6363, 0x6363, 0x6363, 0x6368, 0x7C1C, 0x663E, 
	0x30C, 0x6363, 0x637B, 0x6363, 0xC7F, 0x7F6E, 0x6300, 0x6633, 
	0x363, 0x6B67, 0xDB6F, 0x6363, 0x6300, 0x18, 0x3EA1, 0xA551, 
	0x3333, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x666C, 0x3066, 0xC64, 0x6618, 0xDB7F, 0x633F, 0xDBDB, 0x7E63, 
	0x7F08, 0x180C, 0x1818, 0x3F00, 0x1E1C, 0xC24, 0x3318, 0x3C00, 
	0x1C, 0x7FFF, 0xFFFF, 0xF93E, 0xCC49, 0x2408, 0x3C30, 0x633C, 
	0x7C1F, 0x1833, 0x1B63, 0x7F18, 0x1818, 0x630, 0x6066, 0x3E1C, 
	0x0, 0x7F, 0xB18, 0x6D00, 0x3006, 0x1C08, 0x1C00, 0x18, 
	0x730C, 0x1803, 0x7F03, 0x6318, 0x6306, 0x1C, 0x187F, 0xC18, 
	0x4F7F, 0x6360, 0x6360, 0x6063, 0x6318, 0x666C, 0x6063, 0x6763, 
	0x607B, 0x6C03, 0x1863, 0x366B, 0x3618, 0x3030, 0xC06, 0x0, 
	0x3F, 0x6360, 0x637F, 0x1863, 0x630C, 0x67C, 0xC6B, 0x6363, 
	0x6363, 0x603E, 0x3063, 0x366B, 0x1C36, 0x1818, 0x180C, 0x63, 
	0x6363, 0x7F3F, 0x3F3F, 0x3F60, 0x7F7F, 0x7F0C, 0xC0C, 0x7F7F, 
	0x607F, 0x7C63, 0x6363, 0x6363, 0x3663, 0x636B, 0x307F, 0x6F18, 
	0x3F0C, 0x6363, 0x636F, 0x3F3E, 0x3860, 0x363, 0x6718, 0x6633, 
	0x3F63, 0x736B, 0xDF6C, 0x7F7F, 0x6300, 0x18, 0x6A1, 0xB900, 
	0x337B, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x6663, 0x3066, 0x1866, 0x6618, 0x7E63, 0x6363, 0xDBDB, 0x6063, 
	0x8, 0x6003, 0x1818, 0x3B, 0x0, 0x74, 0x333E, 0x3C00, 
	0x1C, 0x3EFE, 0x7FFF, 0x51C, 0x6C45, 0x2408, 0x1830, 0x67DB, 
	0x7007, 0x7E00, 0x1B36, 0x7F7E, 0x187E, 0xC18, 0x7F24, 0x7F1C, 
	0x0, 0x22, 0x7E33, 0x6600, 0x180C, 0x3608, 0xC00, 0x1C30, 
	0x630C, 0x3063, 0x663, 0x6330, 0x630C, 0x1C0C, 0xC00, 0x1800, 
	0x4063, 0x6363, 0x6660, 0x6063, 0x6318, 0x6666, 0x6063, 0x6363, 
	0x606F, 0x6663, 0x1863, 0x1C36, 0x6318, 0x6030, 0x606, 0x0, 
	0x63, 0x6363, 0x6360, 0x183F, 0x630C, 0x666, 0xC6B, 0x6363, 
	0x7E3F, 0x6003, 0x3363, 0x1C6B, 0x361C, 0x3018, 0x180C, 0x63, 
	0x3E63, 0x6063, 0x6363, 0x633F, 0x6060, 0x600C, 0xC0C, 0x6363, 
	0x60D8, 0x6C63, 0x6363, 0x6363, 0x1C63, 0x633E, 0x6018, 0x6618, 
	0x630C, 0x6363, 0x6367, 0x0, 0x6060, 0x306, 0xB18, 0x6633, 
	0x6363, 0x6373, 0xD86C, 0x6363, 0x6300, 0x18, 0x69D, 0xA500, 
	0x3303, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x6663, 0x3066, 0x3366, 0x6618, 0x1863, 0x3663, 0x7E7E, 0x6063, 
	0x7F00, 0x0, 0x1818, 0xC6E, 0x0, 0x1C, 0x0, 0x3C00, 
	0x1C, 0x1C0C, 0x30FF, 0x308, 0x3822, 0x7E38, 0x7E70, 0xE718, 
	0x6003, 0x3C33, 0x1B1C, 0x7F3C, 0x183C, 0x0, 0x0, 0x7F08, 
	0x18, 0x22, 0x803, 0x3B00, 0xC18, 0x0, 0xC00, 0x1C60, 
	0x3E3F, 0x7E3E, 0x63E, 0x3E30, 0x3E18, 0x1C0C, 0x600, 0x3018, 
	0x3E63, 0x7E3E, 0x7C7F, 0x603D, 0x633C, 0x3C63, 0x7F63, 0x633E, 
	0x603E, 0x633E, 0x183E, 0x836, 0x6318, 0x7F3E, 0x33E, 0x0, 
	0x3F, 0x7E3E, 0x3F3E, 0x1803, 0x633F, 0x6663, 0x3F63, 0x633E, 
	0x6003, 0x607E, 0x1E3F, 0x836, 0x6318, 0x7F0E, 0x1838, 0x7F, 
	0xC3F, 0x3E3F, 0x3F3F, 0x3F0C, 0x3E3E, 0x3E3F, 0x3F3F, 0x6363, 
	0x7F6E, 0x6F3E, 0x3E3E, 0x3F3F, 0x183E, 0x3E08, 0x7F18, 0x6318, 
	0x3F3F, 0x3E3F, 0x6363, 0x7F7F, 0x6300, 0xC, 0x1F18, 0x3366, 
	0x3F3E, 0x3E3E, 0x7E3F, 0x6363, 0x3E00, 0x18, 0x681, 0x8100, 
	0x733E, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x3B7E, 0x7863, 0x7F3C, 0x7B0E, 0x3C3E, 0x773E, 0x1818, 0x3E63, 
	0x7F, 0x7E3F, 0x18D8, 0x0, 0x0, 0xC, 0x0, 0x3C00, 
	0x1C, 0x808, 0x10FF, 0xF00, 0x181C, 0x1878, 0x18F0, 0xE618, 
	0x4001, 0x1833, 0x1B06, 0x18, 0x1818, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x800, 0x0, 0x0, 0x0, 0x1800, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x18, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x3, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0xFF, 
	0x0, 0x0, 0x0, 0x3E, 0x0, 0x3C00, 0x0, 0x0, 
	0x6003, 0x0, 0x0, 0x0, 0x70, 0x0, 0x1800, 0x0, 
	0x3800, 0x0, 0x0, 0x38, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x7000, 0x8, 0x0, 0x70, 
	0x0, 0x0, 0x0, 0x0, 0x3E00, 0xF, 0x318, 0x0, 
	0x0, 0x6060, 0x0, 0x0, 0x0, 0x0, 0x7E, 0x7E00, 
	0xE00, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x60, 0x0, 0x0, 0xC000, 0x0, 0x0, 0x7018, 0x0, 
	0x0, 0x0, 0x1870, 0x0, 0x0, 0x4, 0x0, 0x3C00, 
	0x1C, 0x0, 0xFF, 0x1F00, 0x800, 0x30, 0x18E0, 0xC000, 
	0x0, 0x0, 0x63, 0x7E, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x1800, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x3E, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x1800, 0x0, 0x0, 0x0, 0x0, 0x0, 
};

