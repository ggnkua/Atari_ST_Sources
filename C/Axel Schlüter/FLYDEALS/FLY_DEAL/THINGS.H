#define THINGS 0  	/* TREE */
#define MOVEBOX 1  	/* OBJECT in TREE #0 */
#define RAHMEN 10  	/* OBJECT in TREE #0 */
