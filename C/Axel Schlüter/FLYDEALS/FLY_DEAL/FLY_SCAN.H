/*
	Tastaturcodes in  Scan- und Ascii- Codes
	
	written '92 by Axel Schl�ter
	(c)1992 by ASC
*/

#ifndef __FLYSCAN__
#define __FLYSCAN__
	
int SCAN_TO_ASCII[][3]={
{0x78,0x31,0x31},		/* 1 1 */
{0x79,0x32,0x32},		/* 2 2 */
{0x7A,0x33,0x33},		/* 3 3 */
{0x7B,0x34,0x34},		/* 4 4 */
{0x7C,0x35,0x35},		/* 5 5 */
{0x7D,0x36,0x36},		/* 6 6 */
{0x7E,0x37,0x37},		/* 7 7 */
{0x7F,0x38,0x38},		/* 8 8 */
{0xff80,0x39,0x39},		/* 9 9 */
{0xff81,0x30,0x30},		/* 0 0 */

{0x1A,0x9A,0x81},		/* š � */
{0x28,0x8E,0x84},		/* Ž „ */
{0x27,0x99,0x94},		/* ™ ” */

{0x1e,0x41,0x61},       /* A a */
{0x30,0x42,0x62},		/* B b */ 
{0x2e,0x43,0x63},		/* C c */
{0x20,0x44,0x64},		/* D d */
{0x12,0x45,0x65},		/* E e */
{0x21,0x46,0x66},		/* F f */
{0x22,0x47,0x67},		/* G g */
{0x23,0x48,0x68},		/* H h */
{0x17,0x49,0x69},		/* I i */
{0x24,0x4a,0x6a},		/* J j */
{0x25,0x4b,0x6b},		/* K k */
{0x26,0x4c,0x6c},		/* L l */
{0x32,0x4d,0x6d},		/* M m */
{0x31,0x4e,0x6e},		/* N n */
{0x18,0x4f,0x6f},		/* O o */
{0x19,0x50,0x70},		/* P p */
{0x10,0x51,0x71},		/* Q q */
{0x13,0x52,0x72},		/* R r */
{0x1f,0x53,0x73},		/* S s */
{0x14,0x54,0x74},		/* T t */
{0x16,0x55,0x75},		/* U u */
{0x2f,0x56,0x76},		/* V v */
{0x11,0x57,0x77},		/* W w */
{0x2d,0x58,0x78},		/* X x */
{0x2c,0x59,0x79},		/* Y y */
{0x15,0x5A,0x7a}};		/* Z z */

#endif