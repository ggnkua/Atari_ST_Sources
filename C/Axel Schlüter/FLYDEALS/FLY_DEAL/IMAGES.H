#ifndef __FLYIMAGES__
#define __FLYIMAGES__

int IMchange[]={
0x0000,0x0000,0x13C0,0x1C30,0x1C08,0x0008,0x2004,0x2004,
0x2004,0x2004,0x1000,0x1038,0x0C38,0x03C8,0x0000,0x0000,0x0000,0x0000};

int IMbuttOff[]={
0x0000,0x03C0,0x0C30,0x1008,0x2004,0x2004,0x4002,0x4002,
0x4002,0x4002,0x2004,0x2004,0x1008,0x0C30,0x03C0,0x0000,0x0000,0x0000};

int IMbuttOn[]={
0x0000,0x03C0,0x0C30,0x1188,0x27E4,0x2FF4,0x4FF2,0x5FFA,
0x5FFA,0x4FF2,0x2FF4,0x27E4,0x1188,0x0C30,0x03C0,0x0000,0x0000,0x0000};

int FAchange[]={
0x13C0,0x1C38,0x1804,0x0004,0x2000,0x2018,0x1C38,0x03C8,0x0000,0x0000};

int FAbuttOff[]={
0x03C0,0x0C30,0x13C8,0x2FF4,0x2FF4,0x13C8,0x0C30,0x03C0,0x0000};

int FAbuttOn[]={
0x03C0,0x0C30,0x1008,0x2004,0x2004,0x1008,0x0C30,0x03C0,0x0000};

BITBLK IMarray[]={
IMchange ,2,15,0,0,1,
IMbuttOff,2,15,0,0,1,
IMbuttOn ,2,15,0,0,1};

OBJECT ImageTree[] = {
-1, 1, 3,G_BOX,  LASTOB,NORMAL,0x21100L,0,0,24,7,
 2,-1,-1,G_IMAGE,LASTOB,NORMAL,(long)&IMarray[0],2,2,2,1,
 3,-1,-1,G_IMAGE,LASTOB,NORMAL,(long)&IMarray[1],9,2,2,1,
 0,-1,-1,G_IMAGE,LASTOB,NORMAL,(long)&IMarray[2],16,2,2,1};
 
#endif __FLYIMAGES__