#define INFOBOX 0  	/* TREE */
#define POPUPBOX 1  	/* TREE */
#define COLOR 2  	/* TREE */
#define MENU 3  	/* TREE */
#define INFOEXIT 3  	/* OBJECT in TREE #0 */
#define POPUPOK 1  	/* OBJECT in TREE #1 */
#define POPUPMOV 2  	/* OBJECT in TREE #1 */
#define COLSHOW 14  	/* OBJECT in TREE #1 */
#define COLCIRCL 15  	/* OBJECT in TREE #1 */
#define COLSLECT 16  	/* OBJECT in TREE #1 */
#define POPUPABR 17  	/* OBJECT in TREE #1 */
#define ROT 3  	/* OBJECT in TREE #2 */
#define ZYAN 6  	/* OBJECT in TREE #2 */
#define HELLZYAN 14  	/* OBJECT in TREE #2 */
#define INFOMEN 10  	/* OBJECT in TREE #3 */
#define QUIT 27  	/* OBJECT in TREE #3 */
