/*
**    Copyright 1990 by Antic Publishing, Inc.
** resource file indicies for CHAOS 
*/

#define MENUBAR  0	/* menu tree */
#define MENUDESK 3	/* TITLE in tree MENUBAR */
#define MENUFILE 4	/* TITLE in tree MENUBAR */
#define MENUOPTS 5	/* TITLE in tree MENUBAR */
#define ABOUT    8	/* STRING in tree MENUBAR */
#define SAVE     17	/* STRING in tree MENUBAR */
#define LOAD     18	/* STRING in tree MENUBAR */
#define PRINT    20	/* STRING in tree MENUBAR */
#define QUIT     22	/* STRING in tree MENUBAR */
#define CLEAR    24	/* STRING in tree MENUBAR */
#define NVERTICE 26	/* STRING in tree MENUBAR */
#define PVERTICE 27	/* STRING in tree MENUBAR */
#define DISTANCE 28	/* STRING in tree MENUBAR */
#define NITER    29	/* STRING in tree MENUBAR */
#define COLOURS  30	/* STRING in tree MENUBAR */
#define START    32	/* STRING in tree MENUBAR */

#define FRMNITER 1	/* form/dialog */
#define NITERCAN 2	/* BUTTON in tree FRMNITER */
#define NITERDN3 4	/* BOXCHAR in tree FRMNITER */
#define NITERDN4 5	/* BOXCHAR in tree FRMNITER */
#define NITERDN5 6	/* BOXCHAR in tree FRMNITER */
#define NITERDN6 7	/* BOXCHAR in tree FRMNITER */
#define NITERDN7 8	/* BOXCHAR in tree FRMNITER */
#define NITERDN8 9	/* BOXCHAR in tree FRMNITER */
#define NITERUP8 10	/* BOXCHAR in tree FRMNITER */
#define NITERUP7 11	/* BOXCHAR in tree FRMNITER */
#define NITERUP6 12	/* BOXCHAR in tree FRMNITER */
#define NITERUP5 13	/* BOXCHAR in tree FRMNITER */
#define NITERUP4 14	/* BOXCHAR in tree FRMNITER */
#define NITERUP3 15	/* BOXCHAR in tree FRMNITER */
#define NITERSTR 16	/* BOXTEXT in tree FRMNITER */
#define NITEROK  18	/* BUTTON in tree FRMNITER */

#define FRMNVERT 2	/* form/dialog */
#define NVERTCAN 2	/* BUTTON in tree FRMNVERT */
#define NVERTOK  3	/* BUTTON in tree FRMNVERT */
#define NVERTUP1 5	/* BOXCHAR in tree FRMNVERT */
#define NVERTUP0 6	/* BOXCHAR in tree FRMNVERT */
#define NVERTDN1 7	/* BOXCHAR in tree FRMNVERT */
#define NVERTDN0 8	/* BOXCHAR in tree FRMNVERT */
#define NVERTSTR 9	/* BOXTEXT in tree FRMNVERT */

#define FRMDIST  3	/* form/dialog */
#define DISTCAN  5	/* BUTTON in tree FRMDIST */
#define DISTUP1  7	/* BOXCHAR in tree FRMDIST */
#define DISTUP0  8	/* BOXCHAR in tree FRMDIST */
#define DISTDN1  9	/* BOXCHAR in tree FRMDIST */
#define DISTDN0  10	/* BOXCHAR in tree FRMDIST */
#define DISTSTR  11	/* TEXT in tree FRMDIST */
#define DISTOK   13	/* BUTTON in tree FRMDIST */

#define FRMABTH  4	/* form/dialog */
#define ABTHSCRN 18	/* BOX in tree FRMABTH */

#define FRMABTM  5	/* form/dialog */
#define ABTMSCRN 18	/* BOX in tree FRMABTM */

#define FRMABTL  6	/* form/dialog */
#define ABTLSCRN 17	/* BOX in tree FRMABTL */

