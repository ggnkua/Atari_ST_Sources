void	SetIKBD(short);