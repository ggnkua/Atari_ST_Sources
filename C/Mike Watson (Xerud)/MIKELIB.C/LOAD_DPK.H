int	load (char *);
void Depackice (void *,void *);
void Depackatm5 (void *,void *);