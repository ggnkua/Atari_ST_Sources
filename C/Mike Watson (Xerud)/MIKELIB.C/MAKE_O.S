	xdef	COORDS,CIRCS
COORDS	incbin	d:\incbins\coords
CIRCS	incbin	d:\incbins\crap
