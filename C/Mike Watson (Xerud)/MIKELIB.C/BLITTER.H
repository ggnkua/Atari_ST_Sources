#define	HALFTONE	(*(short *)0xffff8a00l)
#define	SRCXINC		(*(short *)0xffff8a20l)
#define	SRCYINC		(*(short *)0xffff8a22l)
#define	SRCADDR		(*(long *)0xffff8a24l)
#define	ENDMASK1	(*(short *)0xffff8a28l)
#define	ENDMASK2	(*(short *)0xffff8a2al)
#define	ENDMASK3	(*(short *)0xffff8a2cl)
#define	DSTXINC		(*(short *)0xffff8a2el)
#define	DSTYINC		(*(short *)0xffff8a30l)
#define	DSTADDR		(*(long *)0xffff8a32l)
#define	XCOUNT		(*(short *)0xffff8a36l)
#define	YCOUNT		(*(short *)0xffff8a38l)
#define	HOP			(*(char *)0xffff8a3al)
#define	LOGIC		(*(char *)0xffff8a3bl)
#define	BLITOP		(*(char *)0xffff8a3cl)
#define	SKEW		(*(char *)0xffff8a3dl)
