#define	__jar		(*(long **)0x5a0l)
#define	_MCH_030	0x30000l
long	in_cookie(long);