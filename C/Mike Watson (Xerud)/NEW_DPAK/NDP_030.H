/* Resource file indices for NDP_030 */

#define MAIN_MENU 0   /* Form/Dialog box */
#define MAIN_MEN_BOX 0   /* BOX in Tree MAIN_MENU */
#define STATS_BOX 1   /* BOX in Tree MAIN_MENU */
#define MENU_FNAME 3   /* STRING in Tree MAIN_MENU */
#define MENU_FTYPE 5   /* STRING in Tree MAIN_MENU */
#define MENU_PAKSIZE 7   /* STRING in Tree MAIN_MENU */
#define MENU_UNPAKSIZE 9   /* STRING in Tree MAIN_MENU */
#define MENU_FRAM 11  /* STRING in Tree MAIN_MENU */
#define BUTT_BOX 12  /* BOX in Tree MAIN_MENU */
#define LOAD_BUTT 13  /* BUTTON in Tree MAIN_MENU */
#define PREFS_BUTT 14  /* BUTTON in Tree MAIN_MENU */
#define EXIT_BUTT 15  /* BUTTON in Tree MAIN_MENU */
#define SAVE_BUTT 16  /* BUTTON in Tree MAIN_MENU */
#define INFO_BUTT 17  /* BUTTON in Tree MAIN_MENU */
#define SINISTERD1992 18  /* TEXT in Tree MAIN_MENU */
#define FILE_THINGS_BOX 19  /* BOX in Tree MAIN_MENU */
#define FINFO1   21  /* STRING in Tree MAIN_MENU */
#define FINFO2   22  /* STRING in Tree MAIN_MENU */
#define FINFO3   23  /* STRING in Tree MAIN_MENU */

#define PREFERENCES 1   /* Form/Dialog box */
#define PREF_OK  1   /* BUTTON in Tree PREFERENCES */
#define PREF_CANCEL 2   /* BUTTON in Tree PREFERENCES */
#define PREF_SAVE 3   /* BUTTON in Tree PREFERENCES */
#define DUMP_NAME 9   /* BOXTEXT in Tree PREFERENCES */
#define RECURSIVE_BUTTON 11  /* BOX in Tree PREFERENCES */
#define SAVEPATH_BUTTON 12  /* BOX in Tree PREFERENCES */
#define BATCHSAVE_BUTTON 13  /* BOX in Tree PREFERENCES */
#define BATCHREPT_BUTTON 14  /* BOX in Tree PREFERENCES */

#define INFORMATION 2   /* Form/Dialog box */
#define INFO_EXIT 8   /* BUTTON in Tree INFORMATION */

#define PACK_ICE_CLASH 3   /* Form/Dialog box */
#define ICE_PISS_OFF 1   /* BUTTON in Tree PACK_ICE_CLASH */
#define ICE_FNAME 7   /* STRING in Tree PACK_ICE_CLASH */
#define V2_BUTT  8   /* BUTTON in Tree PACK_ICE_CLASH */
#define V2_2_BUTT 9   /* BUTTON in Tree PACK_ICE_CLASH */

#define ATOM_CLASH 4   /* Form/Dialog box */
#define THUN_BUTT2 1   /* BUTTON in Tree ATOM_CLASH */
#define V3_3_BUTT 2   /* BUTTON in Tree ATOM_CLASH */
#define ATOM_FNAME 8   /* STRING in Tree ATOM_CLASH */
#define PISS_OFF_ATOM 9   /* BUTTON in Tree ATOM_CLASH */
#define THUN_BUTT11 10  /* BUTTON in Tree ATOM_CLASH */
#define THUN_BUTT1 11  /* BUTTON in Tree ATOM_CLASH */
#define V3_1_BUTT 12  /* BUTTON in Tree ATOM_CLASH */

#define POMPEY_CLASH 5   /* Form/Dialog box */
#define POMPEY_PISS_OFF 1   /* BUTTON in Tree POMPEY_CLASH */
#define POMPEY_FNAME 9   /* STRING in Tree POMPEY_CLASH */
#define V1_5_BUTT 10  /* BUTTON in Tree POMPEY_CLASH */
#define V1_9_BUTT 11  /* BUTTON in Tree POMPEY_CLASH */

#define RNC_CLASH 6   /* Form/Dialog box */
#define RNC_BYE  1   /* BUTTON in Tree RNC_CLASH */
#define RNC_FNAME 9   /* STRING in Tree RNC_CLASH */
#define TYPE1_BUTT 10  /* BUTTON in Tree RNC_CLASH */
#define TYPE2_BUTT 11  /* BUTTON in Tree RNC_CLASH */
