#define	FALCON030
/* #define	STSTETT */