long	f4pak_prog(void *packed_ptr,void *unpacked_ptr);
void	auto_dat(void *packed_ptr,void *unpacked_ptr);
void	auto_chunk(void *packed_ptr,void *unpacked_ptr);
void	auto_chunk2(void *packed_ptr,void *unpacked_ptr);
void	auto2_prog(void *packed_ptr,void *unpacked_ptr);
void	auto501_prog(void *packed_ptr,void *unpacked_ptr);
void	a31_data(void *packed_ptr,void *unpacked_ptr);
void	a31_prog(void *packed_ptr,void *unpacked_ptr);
void	a33_data(void *packed_ptr,void *unpacked_ptr);
void	a33_prog(void *packed_ptr,void *unpacked_ptr);
void	a35_data(void *packed_ptr,void *unpacked_ptr);
void	a35_prog(void *packed_ptr,void *unpacked_ptr);
void	bkill2_prog(void *packed_ptr,void *unpacked_ptr);
void	bkill3_prog(void *packed_ptr,void *unpacked_ptr);
void	bkillrp_prog(void *packed_ptr,void *unpacked_ptr);
void	bkilljpm_data(void *le_end,void *unpacked_ptr);
void	bkilljpm_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	bmt_prog(void *packed_ptr,void *unpacked_ptr);
void	bras_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	deg_data(void *packed_ptr,void *unpacked_ptr);
void	fir1_data(void *packed_ptr,void *unpacked_ptr,long file_length);
void	fir1_prog(void *packed_ptr,void *unpacked_ptr);
void	fir2_data(void *packed_ptr,void *unpacked_ptr);
void	fir2_prog(void *packed_ptr,void *unpacked_ptr);
void	gremlin_data(void *le_end,void *unpacked_ptr);
void	gol_prog(void *packed_ptr,void *unpacked_ptr);
void	golh_prog(void *packed_ptr,long file_length);
void	happy_prog(void *unpacked_ptr);
void	ice1_1_data(void *packed_ptr,void *unpacked_ptr,long file_length);
void	ice1_1_prog(void *packed_ptr,void *unpacked_ptr);
void	ice2_0_data(void *packed_ptr,void *unpacked_ptr);
void	ice2_0_prog(void *packed_ptr,void *unpacked_ptr);
void	ice2_2_data(void *packed_ptr,void *unpacked_ptr);
void	ice2_2_3_4_prog(void *packed_ptr,void *unpacked_ptr);
void	ice2_3_4_data(void *packed_ptr,void *unpacked_ptr);
void	idrag_data(void *le_end,void *unpacked_ptr);
void	imp_data(void *packed_ptr,void *unpacked_ptr);
void	jpak_prog(void *packed_ptr,void *unpacked_ptr);
void	jam1_prog(void *packed_ptr,void *unpacked_ptr, long depacked_length);
void	jam3_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_v2_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_lzh_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_lzw_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_ice_prog(void *packed_ptr,void *unpacked_ptr);
void	jam_lzh_data(void *packed_ptr,void *unpacked_ptr);
void	jam_lzw_data(void *packed_ptr,void *unpacked_ptr);
void	jam1_prog(void *packed_ptr,void *unpacked_ptr, long depacked_length);
void	jam3_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_v2_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_lzh_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_lzw_prog(void *packed_ptr,void *unpacked_ptr);
void	jam4_ice_prog(void *packed_ptr,void *unpacked_ptr);
void	jam_lzh_data(void *packed_ptr,void *unpacked_ptr);
void	jam_lzw_data(void *packed_ptr,void *unpacked_ptr);
void	lecr_data(void *packed_ptr,void *unpacked_ptr);
void	lsdjek_data(void *le_end,void *unpacked_ptr);
void	lsd1_2_prog(void *packed_ptr,void *unpacked_ptr, long depacked_length);
void	mcode1_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	mcode2_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	mcode3_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
long	pfxget_length(void *le_end);
long	pa_prog(void *packed_ptr,void *unpacked_ptr);
void	pfx_prog(void *packed_ptr,void *unpacked_ptr);
void	pomp1_5_data(void *le_end,void *unpacked_ptr);
void	pomp1_9_data(void *le_end,void *unpacked_ptr);
void	pomp1_5_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	pomp1_9_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	pomp1_9_prog1(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	pomp1_9_prog2(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	pomp2_3_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	pomp2_6_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
void	pomp3_0_prog(void *packed_ptr,void *unpacked_ptr,void *le_end);
long	ppget_length(void *le_end);
void	pp2_data(void *le_end,void *unpacked_ptr,void *start);
void	qp2_data(void *packed_ptr,void *unpacked_ptr);
void	rnc1_data1(void *packed_ptr,void *unpacked_ptr);
void	rnc1_data2(void *packed_ptr,void *unpacked_ptr);
void	rnc2_data(void *packed_ptr,void *unpacked_ptr);
void	rnc2_prog(void *packed_ptr,void *unpacked_ptr);
void	rncc_prog(void *packed_ptr,void *unpacked_ptr);
void	sent2_5_data(void *packed_pointer,void *unpacked_pointer,long length);
void	sent2_5_prog(void *packed_ptr,void *unpacked_ptr);
void	sent2_11_prog(void *packed_ptr,void *unpacked_ptr);
void	speed2_data(void *packed_ptr,void *unpacked_ptr);
void	speed3_data(void *unpacked_ptr);
void	speed2_prog(void *packed_ptr,void *unpacked_ptr);
void	speed3_prog(void *unpacked_ptr);
void	speed3_2_prog(void *unpacked_ptr);
void	squish1_prog(void *packed_ptr,void *unpacked_ptr,long packed_length);
void	squish1_24_prog(void *packed_ptr,void *unpacked_ptr);
void	squish2_prog(void *packed_ptr,void *unpacked_ptr);
void	sup_prog(void *packed_ptr,void *unpacked_ptr);
void	stos_prog(void *packed_ptr,void *unpacked_ptr);
void	thun1_data(void *packed_ptr,void *unpacked_ptr);
void	thun1_prog(void *packed_ptr,void *unpacked_ptr);
void	thun2_data(void *packed_ptr,void *unpacked_ptr);
void	unknown_prog2(void *le_end,void *unpacked_ptr,void *packed_pointer);
void	unknown_prog3(void *packed_ptr,void *unpacked_ptr);
void	unknown_prog4(void *packed_ptr,void *unpacked_ptr);
void	unknown_prog5(void *le_end,void *unpacked_ptr,void *packed_pointer);
void	vic2_data(void *packed_ptr,void *unpacked_ptr);