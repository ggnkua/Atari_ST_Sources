/* resource set indices for BLOWENG */

#define TREE1      0 /* form/dialog */
#define SUUS       0 /* BOX in tree TREE1 */
#define MONTV     10 /* BUTTON in tree TREE1 */
#define MONSM     11 /* BUTTON in tree TREE1 */
#define MONVG     12 /* BUTTON in tree TREE1 */
#define MONSVGA   13 /* BUTTON in tree TREE1 */
#define MONM2     14 /* BUTTON in tree TREE1 */
#define COLSELEC  15 /* BOX in tree TREE1 */
#define COL2      17 /* BUTTON in tree TREE1 */
#define COL4      18 /* BUTTON in tree TREE1 */
#define COL16     19 /* BUTTON in tree TREE1 */
#define COL256    20 /* BUTTON in tree TREE1 */
#define COL32     21 /* BUTTON in tree TREE1 */
#define COL2RES   22 /* TEXT in tree TREE1 */
#define COL4RES1  23 /* TEXT in tree TREE1 */
#define COL16RE1  24 /* TEXT in tree TREE1 */
#define SECRES    28 /* BOXCHAR in tree TREE1 */
#define CO2RES2   30 /* TEXT in tree TREE1 */
#define SAVE      36 /* BOXTEXT in tree TREE1 */
#define UNDO      37 /* BOXTEXT in tree TREE1 */
#define CLOCK     38 /* BOXTEXT in tree TREE1 */
#define INTERLAC  39 /* BOXTEXT in tree TREE1 */
#define HPARA     40 /* BOX in tree TREE1 */
#define LSMINUS   47 /* BOXCHAR in tree TREE1 */
#define LSSLIDER  48 /* BOX in tree TREE1 */
#define LS        49 /* BOXTEXT in tree TREE1 */
#define LSPLUS    50 /* BOXCHAR in tree TREE1 */
#define LEMINUS   52 /* BOXCHAR in tree TREE1 */
#define LESLIDER  53 /* BOX in tree TREE1 */
#define LE        54 /* BOXTEXT in tree TREE1 */
#define LEPLUS    55 /* BOXCHAR in tree TREE1 */
#define HMINUS    57 /* BOXCHAR in tree TREE1 */
#define HSLIDER   58 /* BOX in tree TREE1 */
#define HSYNC     59 /* BOXTEXT in tree TREE1 */
#define HPLUS     60 /* BOXCHAR in tree TREE1 */
#define VPARA     61 /* BOX in tree TREE1 */
#define FSMINUS   68 /* BOXCHAR in tree TREE1 */
#define FSSLIDER  69 /* BOX in tree TREE1 */
#define FS        70 /* BOXTEXT in tree TREE1 */
#define FSPLUS    71 /* BOXCHAR in tree TREE1 */
#define FEMINUS   73 /* BOXCHAR in tree TREE1 */
#define FESLIDER  74 /* BOX in tree TREE1 */
#define FE        75 /* BOXTEXT in tree TREE1 */
#define FEPLUS    76 /* BOXCHAR in tree TREE1 */
#define VMINUS    78 /* BOXCHAR in tree TREE1 */
#define VSLIDER   79 /* BOX in tree TREE1 */
#define VSYNC     80 /* BOXTEXT in tree TREE1 */
#define VPLUS     81 /* BOXCHAR in tree TREE1 */
#define RESOLUT   82 /* BOX in tree TREE1 */
#define XMINUS    86 /* BOXCHAR in tree TREE1 */
#define XSLIDER   87 /* BOX in tree TREE1 */
#define XRES      88 /* BOXTEXT in tree TREE1 */
#define XPLUS     89 /* BOXCHAR in tree TREE1 */
#define YMINUS    91 /* BOXCHAR in tree TREE1 */
#define YSLIDER   92 /* BOX in tree TREE1 */
#define YRES      93 /* BOXTEXT in tree TREE1 */
#define YPLUS     94 /* BOXCHAR in tree TREE1 */
#define INFO      95 /* BOXTEXT in tree TREE1 */
#define LOAD      96 /* BOXTEXT in tree TREE1 */
#define QUIT      97 /* BOXTEXT in tree TREE1 */
#define CLKPARA   98 /* BOX in tree TREE1 */
#define CLOCKMIN 102 /* BOXCHAR in tree TREE1 */
#define CLOCKSLI 103 /* BOX in tree TREE1 */
#define CLOCKS   104 /* BOXTEXT in tree TREE1 */
#define CLOCKPLU 105 /* BOXCHAR in tree TREE1 */
#define VSCREEN  106 /* BOXTEXT in tree TREE1 */
#define VSRES    107 /* FBOXTEXT in tree TREE1 */
#define CRITICAL 108 /* BOXTEXT in tree TREE1 */
#define HFREQU   110 /* BOXTEXT in tree TREE1 */
#define VFREQU   111 /* BOXTEXT in tree TREE1 */
#define WIDTH    112 /* BOXTEXT in tree TREE1 */
#define HEIGHT   113 /* BOXTEXT in tree TREE1 */
#define SAVER    114 /* BOXTEXT in tree TREE1 */
#define SAVTIME  115 /* FBOXTEXT in tree TREE1 */
#define SUPER78  117 /* BOXTEXT in tree TREE1 */
#define SAVECONF 118 /* BOXTEXT in tree TREE1 */

#define TREE2      1 /* form/dialog */

#define TREE3      2 /* form/dialog */
#define LIST       1 /* IBOX in tree TREE3 */
#define CNFTY1     2 /* TEXT in tree TREE3 */
#define CNFTY2     3 /* TEXT in tree TREE3 */
#define CNFTY3     4 /* TEXT in tree TREE3 */
#define CNFTY4     5 /* TEXT in tree TREE3 */
#define CNFTY5     6 /* TEXT in tree TREE3 */
#define CNFTY6     7 /* TEXT in tree TREE3 */
#define CNFTY7     8 /* TEXT in tree TREE3 */
#define CNFTY8     9 /* TEXT in tree TREE3 */
#define CNFCANCE  11 /* BOXTEXT in tree TREE3 */
#define CNFOK     12 /* BOXTEXT in tree TREE3 */
#define CNFMINUS  16 /* BOXCHAR in tree TREE3 */
#define CNFSLIDE  17 /* BOX in tree TREE3 */
#define CNFTYPE   18 /* BOX in tree TREE3 */
#define CNFPLUS   19 /* BOXCHAR in tree TREE3 */

#define ERROR1     0 /* Alert string */

#define ERROR2     1 /* Alert string */

#define ERROR3     2 /* Alert string */

#define ERROR4     3 /* Alert string */

#define ERROR5     4 /* Alert string */

#define ERROR6     5 /* Alert string */

#define ERROR7     6 /* Alert string */

#define ERROR8     7 /* Alert string */

#define ERROR9     8 /* Alert string */

#define ERROR10    9 /* Alert string */

#define ERROR11   10 /* Alert string */

#define ERROR12   11 /* Alert string */

#define ERROR13   12 /* Alert string */

#define ERROR14   13 /* Alert string */

#define ERROR15   14 /* Alert string */

#define ERROR16   15 /* Alert string */

#define ERROR17   16 /* Alert string */

