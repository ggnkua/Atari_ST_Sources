
#define	MAIN	    0

#define ADD	    1
#define EDIT	    2
#define SEARCH	    3
#define QUIT	    4

#define	ADDRESS	    1

#define Term	    0
#define NAME	    1
#define Psuedo	    2
#define NUMBER1	    4
#define Street1	    5
#define TOWN1	    6
#define COUNTY1	    7
#define POSTCODE1	    8
#define TEL1	    9
#define NUMBER2	   11
#define STREET2	   12
#define TOWN2	   13
#define COUNTY2	   14
#define POSTCODE2	   15
#define TEL2	   16
#define GROUP1	   17
#define GROUP2	   18
#define GROUP3	   19
#define GROUP4	   20
#define OK	   21
#define CANCEL	   22
