/*****************************************************************************/
/*                                                                           */
/* EXPORT.H                                                                  */
/* Datum: 06/03/89                                                           */
/*                                                                           */
/*****************************************************************************/

#ifndef __EXPORT__
#define __EXPORT__

#ifdef GLOBAL
#undef GLOBAL
#endif

#define GLOBAL

#endif /* __EXPORT __ */

