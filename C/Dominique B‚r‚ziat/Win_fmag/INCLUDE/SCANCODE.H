/*
 *
 *   SCANCODE ATARI KEYBOARD   by Dominique B‚r‚ziat
 *
 */

#ifndef __SCANCODE
#define __SCANCODE


#define SC_ESC  	0x01
#define SC_HELP		0x62
#define SC_UNDO 	0x61
#define SC_DEL		0x53
#define SC_BACK		0x0E
#define SC_TAB		0x0F
#define SC_SPACE	0x39

/* Pav‚ num‚rique */
#define SC_PLUS		0x4E
#define SC_MOINS	0x4A

#define SC_F1		0x3B
#define SC_F2		0x3C
#define SC_F3		0x3D
#define SC_F4		0x3E
#define SC_F5		0x3F
#define SC_F6		0x40
#define SC_F7		0x41
#define SC_F8		0x42
#define SC_F9		0x43
#define SC_F10		0x44
#define SC_LFARW	0x4B
#define SC_RTARW	0x4D
#define SC_UPARW	0x48
#define SC_DWARW	0x50
#define SC_INSERT	0x52
#define SC_HOME		0x47
#define SC_RETURN	0x1C
#define SC_ENTER	0x72

#endif