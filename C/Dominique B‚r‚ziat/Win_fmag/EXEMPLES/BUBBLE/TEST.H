/* Indices du fichier ressource pour TEST */

#define FORM1            0   /* Formulaire/Dialogue */
#define OK               1   /* BUTTON dans l'arbre FORM1 */
