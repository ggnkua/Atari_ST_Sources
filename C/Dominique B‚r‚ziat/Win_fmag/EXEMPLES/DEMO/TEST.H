/* Indices du fichier ressource pour TEST */

#define MENU1            0   /* Menu */
#define ACTION           5   /* TITLE dans l'arbre MENU1 */
#define MN1_INFO         10  /* STRING dans l'arbre MENU1 */
#define MN1_FS           20  /* STRING dans l'arbre MENU1 */
#define MN1_FD           21  /* STRING dans l'arbre MENU1 */
#define MN1_FM           22  /* STRING dans l'arbre MENU1 */
#define MN1_FT           23  /* STRING dans l'arbre MENU1 */
#define MN1_FTM          24  /* STRING dans l'arbre MENU1 */
#define MN1_FMODAL       25  /* STRING dans l'arbre MENU1 */
#define MN1_QUIT         27  /* STRING dans l'arbre MENU1 */
#define MN1_CLOSE        29  /* STRING dans l'arbre MENU1 */
#define MN1_ICONIFY      30  /* STRING dans l'arbre MENU1 */
#define MN1_REDRAW       31  /* STRING dans l'arbre MENU1 */
#define MN1_EXT          32  /* STRING dans l'arbre MENU1 */
#define MN1_WINFO        33  /* STRING dans l'arbre MENU1 */
#define MN1_CREATE       35  /* STRING dans l'arbre MENU1 */
#define MN1_ATTR         36  /* STRING dans l'arbre MENU1 */
#define MN1_MENU         37  /* STRING dans l'arbre MENU1 */
#define MN1_TOOL         38  /* STRING dans l'arbre MENU1 */
#define MN1_EXTRA        39  /* STRING dans l'arbre MENU1 */
#define MN1_END          40  /* STRING dans l'arbre MENU1 */
#define MN1_OP2          42  /* STRING dans l'arbre MENU1 */
#define MN1_READCONF     43  /* STRING dans l'arbre MENU1 */
#define MN1_OP3          44  /* STRING dans l'arbre MENU1 */

#define DIAL1            1   /* Formulaire/Dialogue */

#define MENU2            2   /* Menu */
#define MN2_INFO         9   /* STRING dans l'arbre MENU2 */
#define MN2_PLUS         11  /* STRING dans l'arbre MENU2 */
#define MN2_MOINS        12  /* STRING dans l'arbre MENU2 */
#define CERCLE           14  /* STRING dans l'arbre MENU2 */
#define CARRE            15  /* STRING dans l'arbre MENU2 */
#define ELLIPSE          16  /* STRING dans l'arbre MENU2 */
#define MN2_BLANC        18  /* STRING dans l'arbre MENU2 */
#define MN2_NOIR         19  /* STRING dans l'arbre MENU2 */
#define MN2_GRIS         20  /* STRING dans l'arbre MENU2 */

#define DIAL2            3   /* Formulaire/Dialogue */
#define DIAL2_OK         1   /* BUTTON dans l'arbre DIAL2 */
#define DIAL2_ED2        3   /* FTEXT dans l'arbre DIAL2 */
#define DIAL2_ED1        10  /* FTEXT dans l'arbre DIAL2 */
#define DIAL2_ANNUL      12  /* BUTTON dans l'arbre DIAL2 */
#define DIAL2_BUSY       13  /* BUTTON dans l'arbre DIAL2 */

#define ALR_QUIT         4   /* Formulaire/Dialogue */
#define ALR1_NON         4   /* BUTTON dans l'arbre ALR_QUIT */
#define ALR1_OUI         5   /* BUTTON dans l'arbre ALR_QUIT */

#define ALR2             5   /* Formulaire/Dialogue */

#define TOOL2            6   /* Formulaire/Dialogue */
#define TL2_FERM         1   /* BUTTON dans l'arbre TOOL2 */

#define DIAL3            7   /* Formulaire/Dialogue */
#define DL3_GEM          3   /* STRING dans l'arbre DIAL3 */
#define DL3_TYPE         5   /* STRING dans l'arbre DIAL3 */
#define DL3_ICON         7   /* STRING dans l'arbre DIAL3 */
#define DL3_MENU         9   /* STRING dans l'arbre DIAL3 */
#define DL3_TOOL         11  /* STRING dans l'arbre DIAL3 */
#define DL3_OUI          12  /* BUTTON dans l'arbre DIAL3 */

#define DIAL4            8   /* Formulaire/Dialogue */
#define DL4_OK           1   /* BUTTON dans l'arbre DIAL4 */
#define DL4_APPL         2   /* BUTTON dans l'arbre DIAL4 */
#define DL4_ANNUL        3   /* BUTTON dans l'arbre DIAL4 */
#define CIRCLE_TRAME     5   /* BOXCHAR dans l'arbre DIAL4 */
#define CALL_TRAME       6   /* BOX dans l'arbre DIAL4 */
#define CALL_RAC         9   /* BOX dans l'arbre DIAL4 */
#define CIRCLE_RAC       10  /* BOXCHAR dans l'arbre DIAL4 */
#define CALL_COULEUR     13  /* BOX dans l'arbre DIAL4 */
#define CIRCLE_COULEUR   14  /* BOXCHAR dans l'arbre DIAL4 */
#define DL4_BR1          16  /* BUTTON dans l'arbre DIAL4 */
#define DL4_BR2          17  /* BUTTON dans l'arbre DIAL4 */
#define DL4_AUTO         19  /* BUTTON dans l'arbre DIAL4 */
#define DL4_SAVEWIN      20  /* BUTTON dans l'arbre DIAL4 */
#define DL4_INSTALL      21  /* BUTTON dans l'arbre DIAL4 */

#define FORM11           9   /* Formulaire/Dialogue */

#define ICONE_MONO       10  /* Formulaire/Dialogue */

#define ICONE_COUL       11  /* Formulaire/Dialogue */

#define COULEUR          12  /* Formulaire/Dialogue */

#define TRAME            13  /* Formulaire/Dialogue */
#define POP_TRAME1       1   /* BOX dans l'arbre TRAME */

#define ATTRIBUT         14  /* Formulaire/Dialogue */
#define ATTR_ANNUL       1   /* BUTTON dans l'arbre ATTRIBUT */
#define ATTR_APPL        2   /* BUTTON dans l'arbre ATTRIBUT */
#define ATTR_OK          3   /* BUTTON dans l'arbre ATTRIBUT */
#define ATTR_FOND        5   /* BOX dans l'arbre ATTRIBUT */
#define ATTR_CLOSER      6   /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_FULLER      7   /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_RIGHT       8   /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_LEFT        9   /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_UP          10  /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_DOWN        11  /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_SIZER       12  /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_SMALLER     13  /* BOXCHAR dans l'arbre ATTRIBUT */
#define ATTR_NAME        14  /* FBOXTEXT dans l'arbre ATTRIBUT */
#define ATTR_INFO        15  /* FBOXTEXT dans l'arbre ATTRIBUT */
#define ATTR_HSLIDER     17  /* BOX dans l'arbre ATTRIBUT */
#define ATTR_VSLIDER     19  /* BOX dans l'arbre ATTRIBUT */

#define EXTRA            15  /* Formulaire/Dialogue */
#define EXTRA_ANNUL      2   /* BUTTON dans l'arbre EXTRA */
#define EXTRA_APPL       3   /* BUTTON dans l'arbre EXTRA */
#define EXTRA_OK         4   /* BUTTON dans l'arbre EXTRA */
#define EXTRA_GROW       5   /* BUTTON dans l'arbre EXTRA */
#define EXTRA_RIEN       7   /* BUTTON dans l'arbre EXTRA */
#define EXTRA_TIMER      8   /* BUTTON dans l'arbre EXTRA */
#define EXTRA_FORM       9   /* BUTTON dans l'arbre EXTRA */

#define TOOL1            16  /* Formulaire/Dialogue */
#define TL1_FERM         1   /* BUTTON dans l'arbre TOOL1 */

#define POPUP1           17  /* Formulaire/Dialogue */
