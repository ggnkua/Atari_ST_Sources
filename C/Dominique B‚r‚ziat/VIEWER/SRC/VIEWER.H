/* Indices du fichier ressource pour VIEWER */

#define VIEW_ICON        0   /* Formulaire/Dialogue */

#define VIEW_MENU        1   /* Formulaire/Dialogue */
#define MENU_NEW_BUFFER  2   /* STRING dans l'arbre VIEW_MENU */
#define MENU_NEW_FRAME   3   /* STRING dans l'arbre VIEW_MENU */
#define MENU_CLOSE       4   /* STRING dans l'arbre VIEW_MENU */
#define MENU_CYCLE       5   /* STRING dans l'arbre VIEW_MENU */
#define MENU_ICONIFY     6   /* STRING dans l'arbre VIEW_MENU */
#define MENU_FULLER      7   /* STRING dans l'arbre VIEW_MENU */
#define MENU_EDIT        8   /* STRING dans l'arbre VIEW_MENU */
#define MENU_COPY        9   /* STRING dans l'arbre VIEW_MENU */
#define MENU_PRINT       10  /* STRING dans l'arbre VIEW_MENU */
#define MENU_FIND        11  /* STRING dans l'arbre VIEW_MENU */
#define MENU_FIND_AGAIN  12  /* STRING dans l'arbre VIEW_MENU */
#define MENU_MODE        13  /* STRING dans l'arbre VIEW_MENU */
#define MENU_CLPBD       14  /* STRING dans l'arbre VIEW_MENU */
#define MENU_HELP        15  /* STRING dans l'arbre VIEW_MENU */
#define MENU_LINE        16  /* STRING dans l'arbre VIEW_MENU */
#define MENU_QUIT        17  /* STRING dans l'arbre VIEW_MENU */

#define MENU_ACC         2   /* Menu */
#define MENU_ACC_INFO    7   /* STRING dans l'arbre MENU_ACC */
#define MENU_ACC_QUIT    16  /* STRING dans l'arbre MENU_ACC */

#define ERR_MULTITASK    0   /* Chaine d'alerte */

#define ERR_BUFF_LOAD    1   /* Chaine d'alerte */

#define USAGE            2   /* Chaine d'alerte */

#define MENU_TITLE       3   /* Chaine libre */

#define INFO_BUFFER      4   /* Chaine libre */

#define INFO_HELP1       5   /* Chaine libre */

#define INFO_HELP2       6   /* Chaine libre */

#define INFO_HELP3       7   /* Chaine libre */

#define ICON_TITLE       8   /* Chaine libre */

#define INFO_BLOC        9   /* Chaine libre */

#define INFO_COPY        10  /* Chaine libre */

#define FIND_MESSAGE     11  /* Chaine libre */

#define HELP_ERROR       12  /* Chaine libre */
