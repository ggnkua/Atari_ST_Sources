/*
 *	Erreurs
 */

#define NO_ERROR			 0
#define MALLOC_STRUCT_ERR	-1
#define MALLOC_BUFFER_ERR	-2
#define MALLOC_LINE_ERR		-3
#define FILE_READ_ERR		-10
#define FILE_NOT_FOUND		-33