/******************************
 * getserv.h                  *
 ******************************
 * include file for getserv.c *
 ******************************
 * [1998-06-02, tm]           *
 * - first C version          *
 ******************************/

#ifndef GETSERV_H
#define GETSERV_H

void olga_ack(int *pipe);
void olga_getserverpath(int *pipe);

#endif
