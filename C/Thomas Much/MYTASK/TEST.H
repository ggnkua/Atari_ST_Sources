/* Resource Datei Indizes f�r TEST */

#define 1                0   /* Formular/Dialog */
