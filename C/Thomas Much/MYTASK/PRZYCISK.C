/* GEM Resource C Source */

#include <portab.h>
#include <aes.h>
#include "PRZYCISK.H"

#if !defined(WHITEBAK)
#define WHITEBAK    0x0040
#endif
#if !defined(DRAW3D)
#define DRAW3D      0x0080
#endif

#define FLAGS9  0x0200
#define FLAGS10 0x0400
#define FLAGS11 0x0800
#define FLAGS12 0x1000
#define FLAGS13 0x2000
#define FLAGS14 0x4000
#define FLAGS15 0x8000
#define STATE8  0x0100
#define STATE9  0x0200
#define STATE10 0x0400
#define STATE11 0x0800
#define STATE12 0x1000
#define STATE13 0x2000
#define STATE14 0x4000
#define STATE15 0x8000

WORD RS0_MMASK[] =
{ 0x0000, 0x07C0, 0x0FE0, 0x1FF0, 
  0x3FF8, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x3FF8, 0x1FF0, 
  0x0FE0, 0x07C0, 0x0000, 0x0000
};

WORD RS0_MDATA[] =
{ 0x0000, 0x07C0, 0x0820, 0x1010, 
  0x2008, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x2008, 0x1010, 
  0x0820, 0x07C0, 0x0000, 0x0000
};

WORD RS0_8CMASK[] =
{ 0x0000, 0x0FE0, 0x3FF8, 0x3FF8, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x3FF8, 
  0x3FF8, 0x0FE0, 0x0000, 0x0000
};

WORD RS0_8CDATA[] =
{ 0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x5014, 0x5014, 0x701C, 
  0x5014, 0x5014, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x5014, 0x5014, 0x701C, 
  0x5014, 0x5014, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x5014, 0x5014, 0x701C, 
  0x5014, 0x5014, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x0FE0, 0x3C78, 0x3018, 
  0x700C, 0x600C, 0x600C, 0x4004, 
  0x600C, 0x600C, 0x600C, 0x3018, 
  0x3C78, 0x0FE0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x2008, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x2008, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x2008, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x2008, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x2008, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x2008, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x2008, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x2008, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000
};

WORD RS0_2CMASK[] =
{ 0x0000, 0x07C0, 0x0FE0, 0x1FF0, 
  0x3FF8, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x3FF8, 0x1FF0, 
  0x0FE0, 0x07C0, 0x0000, 0x0000
};

WORD RS0_2CDATA[] =
{ 0x0000, 0x07C0, 0x0820, 0x1010, 
  0x2008, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x2008, 0x1010, 
  0x0820, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x0820, 0x1010, 
  0x2008, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x2008, 0x1010, 
  0x0820, 0x07C0, 0x0000, 0x0000
};

WORD RS0_4CMASK[] =
{ 0x0000, 0x0FE0, 0x3FF8, 0x3FF8, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x3FF8, 
  0x3FF8, 0x0FE0, 0x0000, 0x0000
};

WORD RS0_4CDATA[] =
{ 0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x5014, 0x5014, 0x701C, 
  0x5014, 0x5014, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x5014, 0x5014, 0x701C, 
  0x5014, 0x5014, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x5014, 0x5014, 0x701C, 
  0x5014, 0x5014, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x0FE0, 0x3C78, 0x3018, 
  0x700C, 0x600C, 0x600C, 0x4004, 
  0x600C, 0x600C, 0x600C, 0x3018, 
  0x3C78, 0x0FE0, 0x0000, 0x0000
};

WORD RS1_MMASK[] =
{ 0x0000, 0x07C0, 0x0FE0, 0x1FF0, 
  0x3FF8, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x3FF8, 0x1FF0, 
  0x0FE0, 0x07C0, 0x0000, 0x0000
};

WORD RS1_MDATA[] =
{ 0x0000, 0x07C0, 0x0820, 0x1010, 
  0x2008, 0x4384, 0x47C4, 0x47C4, 
  0x47C4, 0x4384, 0x2008, 0x1010, 
  0x0820, 0x07C0, 0x0000, 0x0000
};

WORD RS1_2CMASK[] =
{ 0x0000, 0x07C0, 0x0FE0, 0x1FF0, 
  0x3FF8, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x3FF8, 0x1FF0, 
  0x0FE0, 0x07C0, 0x0000, 0x0000
};

WORD RS1_2CDATA[] =
{ 0x0000, 0x07C0, 0x0820, 0x1010, 
  0x2008, 0x4384, 0x47C4, 0x47C4, 
  0x47C4, 0x4384, 0x2008, 0x1010, 
  0x0820, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x0820, 0x1010, 
  0x2008, 0x4384, 0x47C4, 0x47C4, 
  0x47C4, 0x4384, 0x2008, 0x1010, 
  0x0820, 0x07C0, 0x0000, 0x0000
};

WORD RS1_8CMASK[] =
{ 0x0000, 0x0FE0, 0x3FF8, 0x3FF8, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x3FF8, 
  0x3FF8, 0x0FE0, 0x0000, 0x0000
};

WORD RS1_8CDATA[] =
{ 0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x57D4, 0x57D4, 0x77DC, 
  0x57D4, 0x57D4, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2FF8, 0x5FF4, 0x5FF4, 0x7FFC, 
  0x5FF4, 0x5FF4, 0x3FF8, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x57D4, 0x57D4, 0x77DC, 
  0x57D4, 0x57D4, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x0FE0, 0x3C78, 0x3018, 
  0x77CC, 0x6BAC, 0x6FEC, 0x4FE4, 
  0x6FEC, 0x6BAC, 0x67CC, 0x3018, 
  0x3C78, 0x0FE0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x27C8, 0x4BA4, 0x4FE4, 0x4FE4, 
  0x4FE4, 0x4BA4, 0x27C8, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x27C8, 0x4BA4, 0x4FE4, 0x4FE4, 
  0x4FE4, 0x4BA4, 0x27C8, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x27C8, 0x4BA4, 0x4FE4, 0x4FE4, 
  0x4FE4, 0x4BA4, 0x27C8, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1830, 0x2008, 
  0x27C8, 0x4BA4, 0x4FE4, 0x4FE4, 
  0x4FE4, 0x4BA4, 0x27C8, 0x2008, 
  0x1830, 0x07C0, 0x0000, 0x0000
};

WORD RS1_4CMASK[] =
{ 0x0000, 0x0FE0, 0x3FF8, 0x3FF8, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x3FF8, 
  0x3FF8, 0x0FE0, 0x0000, 0x0000
};

WORD RS1_4CDATA[] =
{ 0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x57D4, 0x57D4, 0x77DC, 
  0x57D4, 0x57D4, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x57D4, 0x57D4, 0x77DC, 
  0x57D4, 0x57D4, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x07C0, 0x1BB0, 0x2FE8, 
  0x2838, 0x57D4, 0x57D4, 0x77DC, 
  0x57D4, 0x57D4, 0x3838, 0x2FE8, 
  0x1BB0, 0x07C0, 0x0000, 0x0000, 
  0x0000, 0x0FE0, 0x3C78, 0x3018, 
  0x700C, 0x638C, 0x67CC, 0x47C4, 
  0x67CC, 0x638C, 0x600C, 0x3018, 
  0x3C78, 0x0FE0, 0x0000, 0x0000
};

WORD RS2_MMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS2_MDATA[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS2_8CMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS2_8CDATA[] =
{ 0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x4004, 0x4004, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000
};

WORD RS2_2CMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS2_2CDATA[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS2_4CMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS2_4CDATA[] =
{ 0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x5004, 0x5004, 0x5004, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x600C, 0x600C, 0x600C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_MMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_MDATA[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x602C, 0x607C, 0x60EC, 0x69CC, 
  0x7F8C, 0x6F0C, 0x660C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_2CMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_2CDATA[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x602C, 0x607C, 0x60EC, 0x69CC, 
  0x7F8C, 0x6F0C, 0x660C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x602C, 0x607C, 0x60EC, 0x69CC, 
  0x7F8C, 0x6F0C, 0x660C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_8CMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_8CDATA[] =
{ 0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5034, 0x5064, 0x58C4, 
  0x5D84, 0x5F04, 0x5604, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5034, 0x5064, 0x58C4, 
  0x5D84, 0x5F04, 0x5604, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5034, 0x5064, 0x58C4, 
  0x5D84, 0x5F04, 0x5604, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x602C, 0x607C, 0x60EC, 0x6DCC, 
  0x7F8C, 0x6F0C, 0x660C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4034, 0x4064, 0x48C4, 
  0x5D84, 0x4F04, 0x4604, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4034, 0x4064, 0x48C4, 
  0x5D84, 0x4F04, 0x4604, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4034, 0x4064, 0x48C4, 
  0x5D84, 0x4F04, 0x4604, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x4004, 
  0x4004, 0x4034, 0x4064, 0x48C4, 
  0x5D84, 0x4F04, 0x4604, 0x4004, 
  0x4004, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_4CMASK[] =
{ 0x0000, 0x3FF8, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x7FFC, 0x7FFC, 0x7FFC, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

WORD RS3_4CDATA[] =
{ 0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5034, 0x5064, 0x58C4, 
  0x5D84, 0x5F04, 0x5604, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5034, 0x5064, 0x58C4, 
  0x5D84, 0x5F04, 0x5604, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x4004, 0x5FF4, 
  0x5004, 0x5034, 0x5064, 0x58C4, 
  0x5D84, 0x5F04, 0x5604, 0x5004, 
  0x4004, 0x3FF8, 0x0000, 0x0000, 
  0x0000, 0x3FF8, 0x7FFC, 0x600C, 
  0x602C, 0x607C, 0x60EC, 0x6DCC, 
  0x7F8C, 0x6F0C, 0x660C, 0x600C, 
  0x7FFC, 0x3FF8, 0x0000, 0x0000
};

CICON rs_cicon_przycisk[] =
{ 8, RS0_8CDATA, RS0_8CMASK, NULL, NULL, &rs_cicon_przycisk[1],
  2, RS0_2CDATA, RS0_2CMASK, NULL, NULL, &rs_cicon_przycisk[2],
  4, RS0_4CDATA, RS0_4CMASK, NULL, NULL, NULL,
  2, RS1_2CDATA, RS1_2CMASK, NULL, NULL, &rs_cicon_przycisk[4],
  8, RS1_8CDATA, RS1_8CMASK, NULL, NULL, &rs_cicon_przycisk[5],
  4, RS1_4CDATA, RS1_4CMASK, NULL, NULL, NULL,
  8, RS2_8CDATA, RS2_8CMASK, NULL, NULL, &rs_cicon_przycisk[7],
  2, RS2_2CDATA, RS2_2CMASK, NULL, NULL, &rs_cicon_przycisk[8],
  4, RS2_4CDATA, RS2_4CMASK, NULL, NULL, NULL,
  2, RS3_2CDATA, RS3_2CMASK, NULL, NULL, &rs_cicon_przycisk[10],
  8, RS3_8CDATA, RS3_8CMASK, NULL, NULL, &rs_cicon_przycisk[11],
  4, RS3_4CDATA, RS3_4CMASK, NULL, NULL, NULL
};

CICONBLK rs_ciconblk_przycisk[] =
{ RS0_MMASK, RS0_MDATA, "\0\000", 0x1000|'\0',
   14,  21,   0,   0,  16,  16,  13,  11,   0,   0, &rs_cicon_przycisk[0],
  RS1_MMASK, RS1_MDATA, "\0\000", 0x1000|'\0',
   14,  21,   0,   0,  16,  16,  13,  11,   0,   0, &rs_cicon_przycisk[3],
  RS2_MMASK, RS2_MDATA, "\0\000", 0x1000|'\0',
   14,  21,   0,   0,  16,  16,  13,  11,   0,   0, &rs_cicon_przycisk[6],
  RS3_MMASK, RS3_MDATA, "\0\000", 0x1000|'\0',
   14,  21,   0,   0,  16,  16,  13,  11,   0,   0, &rs_cicon_przycisk[9]
};

WORD rgb_palette[][4] =
{ 0x03E8, 0x03E8, 0x03E8, 0x0000, 
  0x03B5, 0x0000, 0x0000, 0x0002, 
  0x0000, 0x0386, 0x0000, 0x0003, 
  0x03E8, 0x03E8, 0x0000, 0x0006, 
  0x0000, 0x0000, 0x03B5, 0x0004, 
  0x0386, 0x00C8, 0x0258, 0x0007, 
  0x0066, 0x031C, 0x02DD, 0x0005, 
  0x0353, 0x0353, 0x0353, 0x0008, 
  0x01F6, 0x01F6, 0x01F6, 0x0009, 
  0x01F6, 0x0000, 0x0000, 0x000A, 
  0x0000, 0x01F6, 0x0000, 0x000B, 
  0x02CA, 0x027B, 0x00E0, 0x000E, 
  0x0000, 0x0000, 0x01F6, 0x000C, 
  0x01F6, 0x0000, 0x01F6, 0x000F, 
  0x0000, 0x01F6, 0x01F6, 0x000D, 
  0x0066, 0x0066, 0x0066, 0x00FF, 
  0x0000, 0x0000, 0x00C8, 0x0010, 
  0x0000, 0x0000, 0x0190, 0x0011, 
  0x0000, 0x0000, 0x0258, 0x0012, 
  0x0000, 0x0000, 0x0320, 0x0013, 
  0x0000, 0x0000, 0x03E8, 0x0014, 
  0x0000, 0x00C8, 0x0000, 0x0015, 
  0x0000, 0x00C8, 0x00C8, 0x0016, 
  0x0000, 0x00C8, 0x0190, 0x0017, 
  0x0000, 0x00C8, 0x0258, 0x0018, 
  0x0000, 0x00C8, 0x0320, 0x0019, 
  0x0000, 0x00C8, 0x03E8, 0x001A, 
  0x0000, 0x0190, 0x0000, 0x001B, 
  0x0000, 0x0190, 0x00C8, 0x001C, 
  0x0000, 0x0190, 0x0190, 0x001D, 
  0x0000, 0x0190, 0x0258, 0x001E, 
  0x0000, 0x0190, 0x0320, 0x001F, 
  0x0000, 0x0190, 0x03E8, 0x0020, 
  0x0000, 0x0258, 0x0000, 0x0021, 
  0x0000, 0x0258, 0x00C8, 0x0022, 
  0x0000, 0x0258, 0x0190, 0x0023, 
  0x0000, 0x0258, 0x0258, 0x0024, 
  0x0000, 0x0258, 0x0320, 0x0025, 
  0x0000, 0x0258, 0x03E8, 0x0026, 
  0x0000, 0x0320, 0x0000, 0x0027, 
  0x0000, 0x0320, 0x00C8, 0x0028, 
  0x0000, 0x0320, 0x0190, 0x0029, 
  0x0000, 0x0320, 0x0258, 0x002A, 
  0x0000, 0x0320, 0x0320, 0x002B, 
  0x0000, 0x0320, 0x03E8, 0x002C, 
  0x0000, 0x03E8, 0x0000, 0x002D, 
  0x0000, 0x03E8, 0x00C8, 0x002E, 
  0x0000, 0x03E8, 0x0190, 0x002F, 
  0x0000, 0x03E8, 0x0258, 0x0030, 
  0x0000, 0x03E8, 0x0320, 0x0031, 
  0x0000, 0x03E8, 0x03E8, 0x0032, 
  0x00C8, 0x0000, 0x0000, 0x0033, 
  0x00C8, 0x0000, 0x00C8, 0x0034, 
  0x00C8, 0x0000, 0x0190, 0x0035, 
  0x00C8, 0x0000, 0x0258, 0x0036, 
  0x00C8, 0x0000, 0x0320, 0x0037, 
  0x00C8, 0x0000, 0x03E8, 0x0038, 
  0x00C8, 0x00C8, 0x0000, 0x0039, 
  0x00C8, 0x00C8, 0x00C8, 0x003A, 
  0x00C8, 0x00C8, 0x0190, 0x003B, 
  0x0000, 0x0000, 0x02F1, 0x003C, 
  0x00C8, 0x00C8, 0x0320, 0x003D, 
  0x00C8, 0x00C8, 0x03E8, 0x003E, 
  0x00C8, 0x0190, 0x0000, 0x003F, 
  0x00C8, 0x0190, 0x00C8, 0x0040, 
  0x00C8, 0x0190, 0x0190, 0x0041, 
  0x00C8, 0x0190, 0x0258, 0x0042, 
  0x00C8, 0x0190, 0x0320, 0x0043, 
  0x00C8, 0x0190, 0x03E8, 0x0044, 
  0x00C8, 0x0258, 0x0000, 0x0045, 
  0x00C8, 0x0258, 0x00C8, 0x0046, 
  0x00C8, 0x0258, 0x0190, 0x0047, 
  0x00C8, 0x0258, 0x0258, 0x0048, 
  0x00C8, 0x0258, 0x0320, 0x0049, 
  0x00C8, 0x0258, 0x03E8, 0x004A, 
  0x00C8, 0x0320, 0x0000, 0x004B, 
  0x00C8, 0x0320, 0x00C8, 0x004C, 
  0x00C8, 0x0320, 0x0190, 0x004D, 
  0x00C8, 0x0320, 0x0258, 0x004E, 
  0x00C8, 0x0320, 0x0320, 0x004F, 
  0x00C8, 0x0320, 0x03E8, 0x0050, 
  0x00C8, 0x03E8, 0x0000, 0x0051, 
  0x00C8, 0x03E8, 0x00C8, 0x0052, 
  0x00C8, 0x03E8, 0x0190, 0x0053, 
  0x00C8, 0x03E8, 0x0258, 0x0054, 
  0x00C8, 0x03E8, 0x0320, 0x0055, 
  0x00C8, 0x03E8, 0x03E8, 0x0056, 
  0x0190, 0x0000, 0x0000, 0x0057, 
  0x0190, 0x0000, 0x00C8, 0x0058, 
  0x0190, 0x0000, 0x0190, 0x0059, 
  0x0190, 0x0000, 0x0258, 0x005A, 
  0x0190, 0x0000, 0x0320, 0x005B, 
  0x0190, 0x0000, 0x03E8, 0x005C, 
  0x0190, 0x00C8, 0x0000, 0x005D, 
  0x0190, 0x00C8, 0x00C8, 0x005E, 
  0x0190, 0x00C8, 0x0190, 0x005F, 
  0x0190, 0x00C8, 0x0258, 0x0060, 
  0x0190, 0x00C8, 0x0320, 0x0061, 
  0x0190, 0x00C8, 0x03E8, 0x0062, 
  0x0190, 0x0190, 0x0000, 0x0063, 
  0x0190, 0x0190, 0x00C8, 0x0064, 
  0x0190, 0x0190, 0x0190, 0x0065, 
  0x0190, 0x0190, 0x0258, 0x0066, 
  0x0190, 0x0190, 0x0320, 0x0067, 
  0x0190, 0x0190, 0x03E8, 0x0068, 
  0x0190, 0x0258, 0x0000, 0x0069, 
  0x0190, 0x0258, 0x00C8, 0x006A, 
  0x0190, 0x0258, 0x0190, 0x006B, 
  0x0190, 0x0258, 0x0258, 0x006C, 
  0x0190, 0x0258, 0x0320, 0x006D, 
  0x0190, 0x0258, 0x03E8, 0x006E, 
  0x0190, 0x0320, 0x0000, 0x006F, 
  0x0190, 0x0320, 0x00C8, 0x0070, 
  0x0190, 0x0320, 0x0190, 0x0071, 
  0x0190, 0x0320, 0x0258, 0x0072, 
  0x0190, 0x0320, 0x0320, 0x0073, 
  0x0190, 0x0320, 0x03E8, 0x0074, 
  0x0190, 0x03E8, 0x0000, 0x0075, 
  0x0190, 0x03E8, 0x00C8, 0x0076, 
  0x0190, 0x03E8, 0x0190, 0x0077, 
  0x0190, 0x03E8, 0x0258, 0x0078, 
  0x0190, 0x03E8, 0x0320, 0x0079, 
  0x0190, 0x03E8, 0x03E8, 0x007A, 
  0x0258, 0x0000, 0x0000, 0x007B, 
  0x0258, 0x0000, 0x00C8, 0x007C, 
  0x0258, 0x0000, 0x0190, 0x007D, 
  0x0258, 0x0000, 0x0258, 0x007E, 
  0x0258, 0x0000, 0x0320, 0x007F, 
  0x0258, 0x0000, 0x03E8, 0x0080, 
  0x0258, 0x00C8, 0x0000, 0x0081, 
  0x0258, 0x00C8, 0x00C8, 0x0082, 
  0x0258, 0x00C8, 0x0190, 0x0083, 
  0x0258, 0x00C8, 0x0258, 0x0084, 
  0x0258, 0x00C8, 0x0320, 0x0085, 
  0x0258, 0x00C8, 0x03E8, 0x0086, 
  0x0258, 0x0190, 0x0000, 0x0087, 
  0x0258, 0x0190, 0x00C8, 0x0088, 
  0x0258, 0x0190, 0x0190, 0x0089, 
  0x0258, 0x0190, 0x0258, 0x008A, 
  0x0258, 0x0190, 0x0320, 0x008B, 
  0x0258, 0x0190, 0x03E8, 0x008C, 
  0x0258, 0x0258, 0x0000, 0x008D, 
  0x0258, 0x0258, 0x00C8, 0x008E, 
  0x0258, 0x0258, 0x0190, 0x008F, 
  0x0258, 0x0258, 0x0258, 0x0090, 
  0x0258, 0x0258, 0x0320, 0x0091, 
  0x0258, 0x0258, 0x03E8, 0x0092, 
  0x0258, 0x0320, 0x0000, 0x0093, 
  0x0258, 0x0320, 0x00C8, 0x0094, 
  0x0258, 0x0320, 0x0190, 0x0095, 
  0x0258, 0x0320, 0x0258, 0x0096, 
  0x0258, 0x0320, 0x0320, 0x0097, 
  0x0258, 0x0320, 0x03E8, 0x0098, 
  0x0258, 0x03E8, 0x0000, 0x0099, 
  0x0258, 0x03E8, 0x00C8, 0x009A, 
  0x0258, 0x03E8, 0x0190, 0x009B, 
  0x0258, 0x03E8, 0x0258, 0x009C, 
  0x0258, 0x03E8, 0x0320, 0x009D, 
  0x0258, 0x03E8, 0x03E8, 0x009E, 
  0x0320, 0x0000, 0x0000, 0x009F, 
  0x0320, 0x0000, 0x00C8, 0x00A0, 
  0x0320, 0x0000, 0x0190, 0x00A1, 
  0x0320, 0x0000, 0x0258, 0x00A2, 
  0x0320, 0x0000, 0x0320, 0x00A3, 
  0x0320, 0x0000, 0x03E8, 0x00A4, 
  0x0320, 0x00C8, 0x0000, 0x00A5, 
  0x0320, 0x00C8, 0x00C8, 0x00A6, 
  0x0320, 0x00C8, 0x0190, 0x00A7, 
  0x0320, 0x00C8, 0x0258, 0x00A8, 
  0x0320, 0x00C8, 0x0320, 0x00A9, 
  0x0320, 0x00C8, 0x03E8, 0x00AA, 
  0x0320, 0x0190, 0x0000, 0x00AB, 
  0x0320, 0x0190, 0x00C8, 0x00AC, 
  0x0320, 0x0190, 0x0190, 0x00AD, 
  0x0320, 0x0190, 0x0258, 0x00AE, 
  0x0320, 0x0190, 0x0320, 0x00AF, 
  0x0320, 0x0190, 0x03E8, 0x00B0, 
  0x0320, 0x0258, 0x0000, 0x00B1, 
  0x0320, 0x0258, 0x00C8, 0x00B2, 
  0x0320, 0x0258, 0x0190, 0x00B3, 
  0x0320, 0x0258, 0x0258, 0x00B4, 
  0x0320, 0x0258, 0x0320, 0x00B5, 
  0x0320, 0x0258, 0x03E8, 0x00B6, 
  0x0320, 0x0320, 0x0000, 0x00B7, 
  0x0320, 0x0320, 0x00C8, 0x00B8, 
  0x0320, 0x0320, 0x0190, 0x00B9, 
  0x0320, 0x0320, 0x0258, 0x00BA, 
  0x0320, 0x0320, 0x0320, 0x00BB, 
  0x0320, 0x0320, 0x03E8, 0x00BC, 
  0x0320, 0x03E8, 0x0000, 0x00BD, 
  0x0320, 0x03E8, 0x00C8, 0x00BE, 
  0x0320, 0x03E8, 0x0190, 0x00BF, 
  0x0320, 0x03E8, 0x0258, 0x00C0, 
  0x0320, 0x03E8, 0x0320, 0x00C1, 
  0x0320, 0x03E8, 0x03E8, 0x00C2, 
  0x03E8, 0x0000, 0x0000, 0x00C3, 
  0x03E8, 0x0000, 0x00C8, 0x00C4, 
  0x03E8, 0x0000, 0x0190, 0x00C5, 
  0x03E8, 0x0000, 0x0258, 0x00C6, 
  0x03E8, 0x0000, 0x0320, 0x00C7, 
  0x03E8, 0x0000, 0x03E8, 0x00C8, 
  0x03E8, 0x00C8, 0x0000, 0x00C9, 
  0x03E8, 0x00C8, 0x00C8, 0x00CA, 
  0x03E8, 0x00C8, 0x0190, 0x00CB, 
  0x03E8, 0x00C8, 0x0258, 0x00CC, 
  0x03E8, 0x00C8, 0x0320, 0x00CD, 
  0x03E8, 0x00C8, 0x03E8, 0x00CE, 
  0x03E8, 0x0190, 0x0000, 0x00CF, 
  0x03E8, 0x0190, 0x00C8, 0x00D0, 
  0x03E8, 0x0190, 0x0190, 0x00D1, 
  0x03E8, 0x0190, 0x0258, 0x00D2, 
  0x03E8, 0x0190, 0x0320, 0x00D3, 
  0x03E8, 0x0190, 0x03E8, 0x00D4, 
  0x03E8, 0x0258, 0x0000, 0x00D5, 
  0x03E8, 0x0258, 0x00C8, 0x00D6, 
  0x03E8, 0x0258, 0x0190, 0x00D7, 
  0x03E8, 0x0258, 0x0258, 0x00D8, 
  0x03E8, 0x0258, 0x0320, 0x00D9, 
  0x03E8, 0x0258, 0x03E8, 0x00DA, 
  0x03E8, 0x0320, 0x0000, 0x00DB, 
  0x03E8, 0x0320, 0x00C8, 0x00DC, 
  0x03E8, 0x0320, 0x0190, 0x00DD, 
  0x03E8, 0x0320, 0x0258, 0x00DE, 
  0x03E8, 0x0320, 0x0320, 0x00DF, 
  0x03E8, 0x0320, 0x03E8, 0x00E0, 
  0x03E8, 0x03E8, 0x0000, 0x00E1, 
  0x03E8, 0x03E8, 0x00C8, 0x00E2, 
  0x03E8, 0x03E8, 0x0190, 0x00E3, 
  0x03E8, 0x03E8, 0x0258, 0x00E4, 
  0x03E8, 0x03E8, 0x0320, 0x00E5, 
  0x03B5, 0x0000, 0x0000, 0x00E6, 
  0x0386, 0x0000, 0x0000, 0x00E7, 
  0x02F1, 0x0000, 0x0000, 0x00E8, 
  0x02BE, 0x0000, 0x0000, 0x00E9, 
  0x01F6, 0x0000, 0x0000, 0x00EA, 
  0x012E, 0x0000, 0x0000, 0x00EB, 
  0x0066, 0x0000, 0x0000, 0x00EC, 
  0x0000, 0x03B5, 0x0000, 0x00ED, 
  0x0000, 0x0386, 0x0000, 0x00EE, 
  0x0000, 0x02F1, 0x0000, 0x00EF, 
  0x0000, 0x02BE, 0x0000, 0x00F0, 
  0x0000, 0x01F6, 0x0000, 0x00F1, 
  0x0000, 0x012E, 0x0000, 0x00F2, 
  0x0000, 0x0066, 0x0000, 0x00F3, 
  0x0000, 0x0000, 0x0066, 0x00F4, 
  0x0000, 0x0000, 0x012E, 0x00F5, 
  0x0000, 0x0000, 0x01F6, 0x00F6, 
  0x0000, 0x0000, 0x02BE, 0x00F7, 
  0x00C8, 0x00C8, 0x0258, 0x00F8, 
  0x0000, 0x0000, 0x0386, 0x00F9, 
  0x03B5, 0x03B5, 0x03B5, 0x00FA, 
  0x0386, 0x0386, 0x0386, 0x00FB, 
  0x02F1, 0x02F1, 0x02F1, 0x00FC, 
  0x02BE, 0x02BE, 0x02BE, 0x00FD, 
  0x012E, 0x012E, 0x012E, 0x00FE, 
  0x0000, 0x0000, 0x0000, 0x0001
};

OBJECT rs_object_przycisk[] =
{ 
  /******** Tree 0 FORM1 ****************************************************/
        -1, RADIO_UNSEL     , CHECK_SEL       , G_BOX             ,   /* Object 0  */
  FLAGS10, NORMAL, (LONG)0x00001100L,
  0x0000, 0x0000, 0x0008, 0x0003,
  RADIO_SEL       ,       -1,       -1, G_CICON           ,   /* Object 1 RADIO_UNSEL */
  NONE, NORMAL, (LONG)&rs_ciconblk_przycisk[0],
  0x0001, 0x0000, 0x0302, 0x0301,
  CHECK_UNSEL     ,       -1,       -1, G_CICON           ,   /* Object 2 RADIO_SEL */
  NONE, NORMAL, (LONG)&rs_ciconblk_przycisk[1],
  0x0004, 0x0000, 0x0302, 0x0301,
  CHECK_SEL       ,       -1,       -1, G_CICON           ,   /* Object 3 CHECK_UNSEL */
  NONE, NORMAL, (LONG)&rs_ciconblk_przycisk[2],
  0x0001, 0x0001, 0x0302, 0x0301,
         0,       -1,       -1, G_CICON           ,   /* Object 4 CHECK_SEL */
  LASTOB, NORMAL, (LONG)&rs_ciconblk_przycisk[3],
  0x0004, 0x0001, 0x0302, 0x0301
};
