/* Resource Datei Indizes f�r PRZYCISK */

#define FORM1            0   /* Formular/Dialog */
#define RADIO_UNSEL      1   /* USERDEF in Baum FORM1 */
#define RADIO_SEL        2   /* USERDEF in Baum FORM1 */
#define CHECK_UNSEL      3   /* USERDEF in Baum FORM1 */
#define CHECK_SEL        4   /* USERDEF in Baum FORM1 */
