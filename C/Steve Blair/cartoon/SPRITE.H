#define MENU 0  	/* TREE */
#define SETPRI 1  	/* TREE */
#define NEWSP 2  	/* TREE */
#define DIS 3  	/* TREE */
#define NEWFRAME 4  	/* TREE */
#define HELLO 5  	/* TREE */
#define ABOUT 9  	/* OBJECT in TREE #0 */
#define LOADPIC 18  	/* OBJECT in TREE #0 */
#define SAVEPIC 19  	/* OBJECT in TREE #0 */
#define LOADSPRI 21  	/* OBJECT in TREE #0 */
#define SAVESPRI 22  	/* OBJECT in TREE #0 */
#define DELETE 24  	/* OBJECT in TREE #0 */
#define QUIT 26  	/* OBJECT in TREE #0 */
#define DEFINESP 28  	/* OBJECT in TREE #0 */
#define SETSP 29  	/* OBJECT in TREE #0 */
#define DEFFRAME 31  	/* OBJECT in TREE #0 */
#define SHOWNUMS 33  	/* OBJECT in TREE #0 */
#define DELSPRI 34  	/* OBJECT in TREE #0 */
#define SETPRIOR 37  	/* OBJECT in TREE #0 */
#define DISPLAY 39  	/* OBJECT in TREE #0 */
#define ALL 40  	/* OBJECT in TREE #0 */
#define RESTORE 42  	/* OBJECT in TREE #0 */
#define SELECT 43  	/* OBJECT in TREE #0 */
#define FREE 44  	/* OBJECT in TREE #0 */
#define SETSPRIT 5  	/* OBJECT in TREE #1 */
#define PRIORITY 6  	/* OBJECT in TREE #1 */
#define OKSETPR 7  	/* OBJECT in TREE #1 */
#define CANSETPR 8  	/* OBJECT in TREE #1 */
#define NEWSPRIT 2  	/* OBJECT in TREE #2 */
#define OKSETSP 3  	/* OBJECT in TREE #2 */
#define CANSETSP 4  	/* OBJECT in TREE #2 */
#define ONE 2  	/* OBJECT in TREE #3 */
#define TWO 3  	/* OBJECT in TREE #3 */
#define THREE 4  	/* OBJECT in TREE #3 */
#define FOUR 5  	/* OBJECT in TREE #3 */
#define FIVE 6  	/* OBJECT in TREE #3 */
#define SIX 7  	/* OBJECT in TREE #3 */
#define SEVEN 8  	/* OBJECT in TREE #3 */
#define EIGHT 9  	/* OBJECT in TREE #3 */
#define NINE 10  	/* OBJECT in TREE #3 */
#define TEN 11  	/* OBJECT in TREE #3 */
#define ELEVEN 12  	/* OBJECT in TREE #3 */
#define TWELVE 13  	/* OBJECT in TREE #3 */
#define THIRTEEN 14  	/* OBJECT in TREE #3 */
#define FOURTEEN 15  	/* OBJECT in TREE #3 */
#define FIFTEEN 16  	/* OBJECT in TREE #3 */
#define SIXTEEN 17  	/* OBJECT in TREE #3 */
#define OKDIS 19  	/* OBJECT in TREE #3 */
#define CANDIS 20  	/* OBJECT in TREE #3 */
#define FRAME 3  	/* OBJECT in TREE #4 */
#define FROK 4  	/* OBJECT in TREE #4 */
#define FRCAN 5  	/* OBJECT in TREE #4 */
#define HELLOK 4  	/* OBJECT in TREE #5 */
