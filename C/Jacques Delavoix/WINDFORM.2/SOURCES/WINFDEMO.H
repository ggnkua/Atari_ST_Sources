/* Indice du ressource pour WINFDEMO */

#define LE_MENU  0   /* Arbre menu */
#define INFOS    7   /* STRING dans l'arbre LE_MENU */
#define OPENW    16  /* STRING dans l'arbre LE_MENU */
#define FICHE_CLI 17  /* STRING dans l'arbre LE_MENU */
#define COLOR_WIND 18  /* STRING dans l'arbre LE_MENU */
#define QUITTER  20  /* STRING dans l'arbre LE_MENU */

#define INFORME  1   /* Formulaire/Dialogue */
#define RETOUR   8   /* BUTTON dans l'arbre INFORME */
#define B_BISTABLE	9	/* BUTTON dans l'arbre INFORME */

#define FICHE_CLIENT 2   /* Formulaire/Dialogue */
#define NOM      3   /* FTEXT dans l'arbre FICHE_CLIENT */
#define VILLE    8   /* FTEXT dans l'arbre FICHE_CLIENT */
#define CLIENT_ANNULE 9   /* BUTTON dans l'arbre FICHE_CLIENT */
#define CLIENT_OK 10  /* BUTTON dans l'arbre FICHE_CLIENT */

#define BACK_COLOR 3   /* Formulaire/Dialogue */
#define COL_EDIT 1   /* FBOXTEXT dans l'arbre BACK_COLOR */
#define COL_0    3   /* BOX dans l'arbre BACK_COLOR */
#define COL_15   18  /* BOX dans l'arbre BACK_COLOR */
#define COL_ANNULE 19  /* BUTTON dans l'arbre BACK_COLOR */
#define COL_OK   20  /* BUTTON dans l'arbre BACK_COLOR */
#define COL_APPLI 21  /* BUTTON dans l'arbre BACK_COLOR */

#define NO_WINDOW 0   /* Chaine d'alerte */
