/* Fichier des Index de Ressource pour WINDFORM.RSC	*/

#define LE_MENU		0	/* Arbre de Menu */
#define INFOS		7	/* STRING dans Arbre LE_MENU */
#define OPENW		16	/* STRING dans Arbre LE_MENU */
#define FICHE_CLI	17	/* STRING dans Arbre LE_MENU */
#define COLOR_WIND	18	/* STRING dans Arbre LE_MENU */
#define QUITTER		20	/* STRING dans Arbre LE_MENU */

#define INFORME		1	/* Formulaire/Dialogue */
#define RETOUR		8	/* BUTTON dans Arbre INFORME */

#define FICHE_CLIENT 2	/* Formulaire/Dialogue */
#define NOM			3	/* FTEXT dans Arbre FICHE_CLIENT */
#define VILLE		8	/* FTEXT dans Arbre FICHE_CLIENT */
#define CLIENT_ANNULE 9	/* BUTTON dans Arbre FICHE_CLIENT */
#define CLIENT_OK	10	/* BUTTON dans Arbre FICHE_CLIENT */

#define BACK_COLOR	3	/* Formulaire/Dialogue */
#define COL_EDIT	1	/* FBOXTEXT dans Arbre BACK_COLOR */
#define COL_0		3	/* BOX dans Arbre BACK_COLOR */
#define COL_15		18	/* BOX dans Arbre BACK_COLOR */
#define COL_ANNULE	19	/* BUTTON dans Arbre BACK_COLOR */
#define COL_OK		20	/* BUTTON dans Arbre BACK_COLOR */
#define COL_APPLI	21	/* BUTTON dans Arbre BACK_COLOR */

#define NO_WINDOW	0	/* Chaine Libre */
