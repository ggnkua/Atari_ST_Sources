/*
 * Xdialog Library. Copyright (c) 1993, 1994, 2002 W. Klaren.
 *
 * This file is part of Teradesk.
 *
 * Teradesk is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 2 of the License, or
 * (at your option) any later version.
 *
 * Teradesk is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with Teradesk; if not, write to the Free Software
 * Foundation, Inc., 59 Temple Place, Suite 330, Boston, MA  02111-1307  USA
 */

#define CTL_A		0x0201
#define CTL_B		0x0202
#define CTL_C		0x0203
#define CTL_D		0x0204
#define CTL_E		0x0205
#define CTL_F		0x0206
#define CTL_G		0x0207
#define CTL_H		0x0208
#define CTL_I		0x0209
#define CTL_J		0x020A
#define CTL_K		0x020B
#define CTL_L		0x020C
#define CTL_M		0x020D
#define CTL_N		0x020E
#define CTL_O		0x020F
#define CTL_P		0x0210
#define CTL_Q		0x0211
#define CTL_R		0x0212
#define CTL_S		0x0213
#define CTL_T		0x0214
#define CTL_U		0x0215
#define CTL_V		0x0216
#define CTL_W		0x0217
#define CTL_X		0x0218
#define CTL_Y		0x0219
#define CTL_Z		0x021A
#define CTL_DEL		0x021F

#define ALT_A		0x0441
#define ALT_B		0x0442
#define ALT_C		0x0443
#define ALT_D		0x0444
#define ALT_E		0x0445
#define ALT_F		0x0446
#define ALT_G		0x0447
#define ALT_H		0x0448
#define ALT_I		0x0449
#define ALT_J		0x044A
#define ALT_K		0x044B
#define ALT_L		0x044C
#define ALT_M		0x044D
#define ALT_N		0x044E
#define ALT_O		0x044F
#define ALT_P		0x0450
#define ALT_Q		0x0451
#define ALT_R		0x0452
#define ALT_S		0x0453
#define ALT_T		0x0454
#define ALT_U		0x0455
#define ALT_V		0x0456
#define ALT_W		0x0457
#define ALT_X		0x0458
#define ALT_Y		0x0459
#define ALT_Z		0x045A

#define ESCAPE		0x001B
#define BACKSPC		0x0008
#define DELETE		0x007F
#define TAB			0x0009
#define RETURN		0x000D
#define SPACE		0x0020

#define INSERT			0x8052
#define SHFT_INSERT		0x8152
#define HOME			0x8047
#define SHFT_HOME		0x8147
#define UNDO			0x8061
#define HELP			0x8062
#define CURUP			0x8048
#define CURDOWN			0x8050
#define CURLEFT			0x804B
#define CURRIGHT		0x804D
#define SHFT_CURUP		0x8148
#define SHFT_CURDOWN	0x8150
#define SHFT_CURLEFT	0x814B
#define SHFT_CURRIGHT	0x814D
#define CTL_CURUP		0x8248
#define CTL_CURDOWN		0x8250
#define CTL_CURLEFT		0x8273
#define CTL_CURRIGHT	0x8274
#define PAGE_DOWN		0x8051			/* HR 240103: PgUp/PgDn keys on PC keyboards (Emulators and MILAN) */
#define PAGE_UP			0x8049
