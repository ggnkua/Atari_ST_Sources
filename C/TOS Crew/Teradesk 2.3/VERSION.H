/*
 * Teradesk. Copyright (c) 1993, 1994, 1995, 1997, 2002 W. Klaren.
 *                         2002-2003 H.Robbers
 *
 * This file is part of Teradesk.
 *
 * Teradesk is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 2 of the License, or
 * (at your option) any later version.
 *
 * Teradesk is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with Teradesk; if not, write to the Free Software
 * Foundation, Inc., 59 Temple Place, Suite 330, Boston, MA  02111-1307  USA
 */


/* DjV 009 251202 120103 */

#define CFG_VERSION		0x0202
#define MIN_VERSION		0x0200	 
#define INFO_VERSION	"Tera Desktop V2.3  26.02.2003"
#define INFO_COPYRIGHT	"\xBD W.Klaren, H.Robbers, Dj.Vukovic"
#define INFO_OTHER "1991-2003"

#if _MINT_
  #define INFO_SYSTEMS	"for TOS, MiNT, MagiC & Geneva"
#else
  #define INFO_SYSTEMS	"for single TOS only"
#endif

