/* Resource Datei Indizes f�r CARD */

#define MENUE    0   /* Menuebaum */
#define MT_DESK  3   /* TITLE in Baum MENUE */
#define MT_DATEI 4   /* TITLE in Baum MENUE */
#define MT_EDIT  5   /* TITLE in Baum MENUE */
#define MT_OPTS  6   /* TITLE in Baum MENUE */
#define M_PRGINFO 9   /* STRING in Baum MENUE */
#define M_NEU    18  /* STRING in Baum MENUE */
#define M_QUIT   20  /* STRING in Baum MENUE */
#define M_UNDO   22  /* STRING in Baum MENUE */
#define M_DRAW   24  /* STRING in Baum MENUE */
#define M_MISCHEN 26  /* STRING in Baum MENUE */
#define M_MISCHEN2 27  /* STRING in Baum MENUE */
#define M_CLASSIC 29  /* STRING in Baum MENUE */
#define M_HELP   30  /* STRING in Baum MENUE */

#define INFOBOX  1   /* Formular/Dialog */
