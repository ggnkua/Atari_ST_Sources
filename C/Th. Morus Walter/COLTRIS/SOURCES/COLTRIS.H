/* Resource Datei Indizes f�r COLTRIS */

#define MENUE    0   /* Menuebaum */
#define MT_FILE  4   /* TITLE in Baum MENUE */
#define M_INFO   8   /* STRING in Baum MENUE */
#define M_START  17  /* STRING in Baum MENUE */
#define M_HISCORE 19  /* STRING in Baum MENUE */
#define M_ABORT  21  /* STRING in Baum MENUE */
#define M_QUIT   22  /* STRING in Baum MENUE */
#define M_TETRIS 24  /* STRING in Baum MENUE */
#define M_COLUMNS 25  /* STRING in Baum MENUE */
#define M_SCORE  27  /* STRING in Baum MENUE */
#define M_PREVIEW 28  /* STRING in Baum MENUE */
#define M_STATISTIC 29  /* STRING in Baum MENUE */
#define M_OPTS   31  /* STRING in Baum MENUE */
#define M_STONES 32  /* STRING in Baum MENUE */

#define INFOBOX  1   /* Formular/Dialog */
#define I_COMPDATE 3   /* STRING in Baum INFOBOX */

#define OPTSBOX  2   /* Formular/Dialog */
#define O_TETRIS 2   /* BUTTON in Baum OPTSBOX */
#define O_COLUMNS 3   /* BUTTON in Baum OPTSBOX */
#define LEVEL0   5   /* BOXCHAR in Baum OPTSBOX */
#define LEVEL9   14  /* BOXCHAR in Baum OPTSBOX */
#define RANDOM0  16  /* BOXCHAR in Baum OPTSBOX */
#define RANDOM14 30  /* BUTTON in Baum OPTSBOX */
#define SOUND_ON 32  /* BUTTON in Baum OPTSBOX */
#define SOUND_OFF 33  /* BUTTON in Baum OPTSBOX */
#define GRAPH_ST 35  /* BUTTON in Baum OPTSBOX */
#define GRAPH_VDI 36  /* BUTTON in Baum OPTSBOX */
#define O_GTET   37  /* STRING in Baum OPTSBOX */
#define O_GCOL   38  /* STRING in Baum OPTSBOX */
#define SINGLE   40  /* BUTTON in Baum OPTSBOX */
#define MULTI    41  /* BUTTON in Baum OPTSBOX */
#define CYCLENONE 43  /* BUTTON in Baum OPTSBOX */
#define CYCLEPLAY 44  /* BUTTON in Baum OPTSBOX */
#define CYCLEALL 45  /* BUTTON in Baum OPTSBOX */
#define TOP_ALL  47  /* BUTTON in Baum OPTSBOX */
#define USER_KEY 48  /* BUTTON in Baum OPTSBOX */
#define ALERT    50  /* BUTTON in Baum OPTSBOX */
#define ABBR     51  /* BUTTON in Baum OPTSBOX */
#define OK       52  /* BUTTON in Baum OPTSBOX */

#define KEYS     3   /* Formular/Dialog */
#define KEYS_TXT 1   /* STRING in Baum KEYS */

#define HISCORE  4   /* Formular/Dialog */
#define HI_TITEL 1   /* BUTTON in Baum HISCORE */
#define HI_MARKE 2   /* BOXCHAR in Baum HISCORE */
#define HISCORE1 3   /* STRING in Baum HISCORE */
#define HISCOREN 30  /* STRING in Baum HISCORE */
#define CLR_HI   33  /* BUTTON in Baum HISCORE */
#define HI_OK    34  /* BUTTON in Baum HISCORE */

#define NEWHI    5   /* Formular/Dialog */
#define HI_NAME  1   /* FTEXT in Baum NEWHI */

#define XSCORE   6   /* Formular/Dialog */
#define LEVEL    2   /* TEXT in Baum XSCORE */
#define STONES   4   /* TEXT in Baum XSCORE */
#define LINES    6   /* TEXT in Baum XSCORE */
#define SCORE    8   /* TEXT in Baum XSCORE */

#define STATISTIC 7   /* Formular/Dialog */
#define TSTAT    1   /* BOX in Baum STATISTIC */
#define TSTAT0   2   /* TEXT in Baum STATISTIC */
#define C_STAT   9   /* BOX in Baum STATISTIC */
#define CSTAT0   10  /* TEXT in Baum STATISTIC */

#define ICON     8   /* Formular/Dialog */
#define ICON_TETRIS 1   /* ICON in Baum ICON */
#define ICON_COLUMNS 2   /* ICON in Baum ICON */
