/* Resource Datei Indizes f�r SCRDUMP */

#define SCREENDUMP 0   /* Formular/Dialog */
#define SELECT   5   /* BOX in Baum SCREENDUMP */
#define PATH     6   /* FTEXT in Baum SCREENDUMP */
#define RESET    7   /* BOX in Baum SCREENDUMP */
#define XIMG     9   /* BOX in Baum SCREENDUMP */
#define WINDOW   11  /* BUTTON in Baum SCREENDUMP */
#define DRAG     12  /* BUTTON in Baum SCREENDUMP */
#define SCREEN   13  /* BUTTON in Baum SCREENDUMP */
#define SAVE     14  /* BUTTON in Baum SCREENDUMP */
#define SET      15  /* BUTTON in Baum SCREENDUMP */
#define CANCEL   16  /* BUTTON in Baum SCREENDUMP */
