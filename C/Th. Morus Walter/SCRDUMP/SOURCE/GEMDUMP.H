/* Resource Datei Indizes f�r GEMDUMP */

#define SCREENDUMP 0   /* Formular/Dialog */
#define SELECT   5   /* BOX in Baum SCREENDUMP */
#define PATH     6   /* FTEXT in Baum SCREENDUMP */
#define RESET    7   /* BOX in Baum SCREENDUMP */
#define XIMG     9   /* BOX in Baum SCREENDUMP */
#define ALTHELP  11  /* BOX in Baum SCREENDUMP */
#define WINDOW   13  /* BUTTON in Baum SCREENDUMP */
#define DRAG     14  /* BUTTON in Baum SCREENDUMP */
#define SCREEN   15  /* BUTTON in Baum SCREENDUMP */
#define SAVE     16  /* BUTTON in Baum SCREENDUMP */
#define SET      17  /* BUTTON in Baum SCREENDUMP */
#define CANCEL   18  /* BUTTON in Baum SCREENDUMP */
