struct {int n; char *name;} tok_tab[] = {
    {257, "CHEX"},
    {258, "CDEC"},
    {259, "FRAC"},
    {260, "AREG"},
    {261, "BREG"},
    {262, "MREG"},
    {263, "NREG"},
    {264, "RREG"},
    {265, "XREG"},
    {266, "YREG"},
    {267, "OP"},
    {268, "OPA"},
    {269, "OPP"},
    {270, "OP_JCC"},
    {271, "OP_JSCC"},
    {272, "OP_TCC"},
    {273, "SYM"},
    {274, "STRING"},
    {275, "CHAR"},
    {276, "COMMENT"},
    {277, "XMEM"},
    {278, "YMEM"},
    {279, "LMEM"},
    {280, "PMEM"},
    {281, "AAAA"},
    {282, "A10"},
    {283, "BBBB"},
    {284, "B10"},
    {285, "AABB"},
    {286, "BBAA"},
    {287, "XXXX"},
    {288, "YYYY"},
    {289, "SR"},
    {290, "MR"},
    {291, "CCR"},
    {292, "OMR"},
    {293, "SP"},
    {294, "SSH"},
    {295, "SSL"},
    {296, "LA"},
    {297, "LC"},
    {298, "EOL"},
    {299, "EOS"},
    {300, "OP_ABS"},
    {301, "OP_ADC"},
    {302, "OP_ADD"},
    {303, "OP_ADDL"},
    {304, "OP_ADDR"},
    {305, "OP_ASL"},
    {306, "OP_ASR"},
    {307, "OP_CLR"},
    {308, "OP_CMP"},
    {309, "OP_CMPM"},
    {310, "OP_DIV"},
    {311, "OP_MAC"},
    {312, "OP_MACR"},
    {313, "OP_MPY"},
    {314, "OP_MPYR"},
    {315, "OP_NEG"},
    {316, "OP_NORM"},
    {317, "OP_RND"},
    {318, "OP_SBC"},
    {319, "OP_SUB"},
    {320, "OP_SUBL"},
    {321, "OP_SUBR"},
    {322, "OP_TFR"},
    {323, "OP_TST"},
    {324, "OP_AND"},
    {325, "OP_ANDI"},
    {326, "OP_EOR"},
    {327, "OP_LSL"},
    {328, "OP_LSR"},
    {329, "OP_NOT"},
    {330, "OP_OR"},
    {331, "OP_ORI"},
    {332, "OP_ROL"},
    {333, "OP_ROR"},
    {334, "OP_BCLR"},
    {335, "OP_BSET"},
    {336, "OP_BCHG"},
    {337, "OP_BTST"},
    {338, "OP_DO"},
    {339, "OP_ENDDO"},
    {340, "OP_LUA"},
    {341, "OP_MOVE"},
    {342, "OP_MOVEC"},
    {343, "OP_MOVEM"},
    {344, "OP_MOVEP"},
    {345, "OP_ILLEGAL"},
    {346, "OP_INCLUDE"},
    {347, "OP_JMP"},
    {348, "OP_JCLR"},
    {349, "OP_JSET"},
    {350, "OP_JSR"},
    {351, "OP_JSCLR"},
    {352, "OP_JSSET"},
    {353, "OP_NOP"},
    {354, "OP_REP"},
    {355, "OP_RESET"},
    {356, "OP_RTI"},
    {357, "OP_RTS"},
    {358, "OP_STOP"},
    {359, "OP_SWI"},
    {360, "OP_WAIT"},
    {361, "OP_EQU"},
    {362, "OP_ORG"},
    {363, "OP_DC"},
    {364, "OP_END"},
    {365, "OP_PAGE"},
    {366, "OP_PSECT"},
    {367, "OP_ALIGN"},
    {368, "SHL"},
    {369, "SHR"},
};
#define N_TOK (sizeof tok_tab / sizeof tok_tab[0])
int n_tok = N_TOK;
