;  Calibrate tone          
;  Mon Apr 15 17:45:10 1991
;  
;      Sample rate                      32.5520830 kHz      
;      0 VU level from peak            -15.0000000 dB       
;      Full scale peak voltage           3.0000000 V        
;      Freq                           1000.0000000 Hz       
;      Table size                 256
;  
;      delta phase                       7.8643201
;      cal tone amplitude        5827    0.1778279
;                                        0.5334838 V pk     
;  

ampl equ                                 0.1778279
dphase_l equ                 14500885 ;  0.8643201
dphase_h equ                        7 ;  7.0000000
