/*

 The Pro MIDI Player
 Copyright 1986-1994 By J.D. Koftinoff Software, Ltd.
 Released under the GPL in 2007
 Please see the file 'COPYING' including in this package.
 
*/
 
/*
 * C version of 'D:\DEV\PERF8\SRC\SET_EDIT.RSC'
 */

unsigned char SET_EDITRSC[] = {
	0,0,11,118,5,170,5,170,5,170,5,170,0,36,5,170,5,170,
	23,166,0,130,0,8,0,53,0,0,0,0,0,0,0,0,23,198,
	79,75,0,86,69,82,83,73,79,78,58,0,56,46,48,48,32,65,
	0,74,46,68,46,32,75,111,102,116,105,110,111,102,102,32,83,111,
	102,116,119,97,114,101,44,32,76,116,100,46,0,0,40,54,48,52,
	41,32,52,51,48,45,54,56,50,55,32,32,70,97,120,58,32,40,
	54,48,52,41,32,52,52,50,45,51,50,51,51,0,74,46,68,46,
	32,75,111,102,116,105,110,111,102,102,32,83,111,102,116,119,97,114,
	101,44,32,76,116,100,46,0,0,66,111,120,32,52,49,48,51,0,
	86,97,110,99,111,117,118,101,114,44,32,66,67,32,67,97,110,97,
	100,97,0,86,54,66,45,51,90,54,0,67,111,112,121,114,105,103,
	104,116,32,49,57,56,54,45,49,57,57,51,32,98,121,0,0,84,
	72,69,32,80,82,79,32,77,73,68,73,32,80,76,65,89,69,82,
	32,83,69,84,32,69,68,73,84,79,82,0,0,80,69,82,70,79,
	82,77,57,46,83,69,84,0,80,69,82,70,79,82,77,56,46,83,
	69,84,0,80,69,82,70,79,82,77,55,46,83,69,84,0,80,69,
	82,70,79,82,77,54,46,83,69,84,0,80,69,82,70,79,82,77,
	53,46,83,69,84,0,80,69,82,70,79,82,77,52,46,83,69,84,
	0,80,69,82,70,79,82,77,51,46,83,69,84,0,80,69,82,70,
	79,82,77,50,46,83,69,84,0,80,69,82,70,79,82,77,49,46,
	83,69,84,0,80,69,82,70,79,82,77,48,46,83,69,84,0,32,
	70,73,76,69,32,0,0,32,32,83,69,84,32,32,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,49,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,50,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,51,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,52,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,53,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,54,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,55,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,56,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,90,83,57,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,48,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,49,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,50,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,51,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,52,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,53,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,54,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,55,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,56,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,49,57,0,0,84,69,
	88,84,88,88,88,88,89,89,89,89,90,83,50,48,0,0,32,68,
	73,83,75,32,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,49,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,50,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,51,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,52,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,53,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,54,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,55,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,56,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,48,57,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,48,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,49,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,50,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,51,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,52,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,53,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,54,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,55,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,56,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,49,57,0,0,84,69,88,84,88,88,88,88,89,89,89,89,
	90,68,50,48,0,0,68,69,76,69,84,69,0,69,82,65,83,69,
	32,65,76,76,0,68,114,105,118,101,58,0,76,79,65,68,0,83,
	65,86,69,0,80,82,73,78,84,0,69,88,73,84,0,79,75,0,
	86,69,82,83,73,79,78,58,0,56,46,48,65,0,80,114,111,32,
	77,73,68,73,32,83,121,115,116,101,109,115,32,97,110,100,0,0,
	74,46,68,46,32,75,111,102,116,105,110,111,102,102,32,83,111,102,
	116,119,97,114,101,44,32,76,116,100,46,0,0,67,111,112,121,114,
	105,103,104,116,32,49,57,57,51,32,98,121,0,0,80,114,111,32,
	77,73,68,73,32,83,121,115,116,101,109,115,32,32,32,32,32,32,
	32,32,0,0,49,55,54,32,67,104,114,105,115,116,105,101,32,80,
	97,114,107,32,77,97,110,111,114,0,67,97,108,103,97,114,121,44,
	32,65,108,98,101,114,116,97,44,32,67,97,110,97,100,97,0,84,
	51,72,45,50,80,54,0,80,72,79,78,69,58,0,40,52,48,51,
	41,32,50,52,51,45,48,51,53,56,0,80,114,111,32,77,73,68,
	73,32,83,121,115,116,101,109,115,32,32,32,32,32,32,32,32,0,
	0,66,111,120,32,49,51,0,76,97,117,114,105,101,114,44,32,87,
	65,44,32,85,83,65,0,57,57,49,52,54,0,84,72,69,32,80,
	82,79,32,77,73,68,73,32,80,76,65,89,69,82,32,83,69,84,
	32,69,68,73,84,79,82,0,0,0,0,0,0,55,0,0,0,0,
	0,0,0,85,0,3,0,6,0,0,17,128,0,0,0,255,0,30,
	0,1,0,0,0,122,0,0,0,0,0,0,0,152,0,3,0,6,
	0,0,17,128,0,0,0,255,0,30,0,1,0,0,0,191,0,0,
	0,0,0,0,0,214,0,3,0,6,0,0,17,128,0,0,0,255,
	0,23,0,1,0,0,0,215,0,0,0,0,0,0,0,246,0,3,
	0,6,0,0,17,128,0,0,0,255,0,31,0,1,0,0,1,121,
	0,0,0,0,0,0,1,128,0,3,0,6,0,0,17,128,0,0,
	0,255,0,7,0,1,0,0,1,129,0,0,0,0,0,0,1,137,
	0,3,0,6,0,0,17,128,0,0,0,255,0,8,0,1,0,0,
	1,138,0,0,0,0,0,0,1,155,0,3,0,6,0,0,17,128,
	0,0,0,255,0,17,0,1,0,0,1,156,0,0,0,0,0,0,
	1,173,0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,
	0,0,1,174,0,0,0,0,0,0,1,191,0,3,0,6,0,0,
	17,128,0,0,0,255,0,17,0,1,0,0,1,192,0,0,0,0,
	0,0,1,209,0,3,0,6,0,0,17,128,0,0,0,255,0,17,
	0,1,0,0,1,210,0,0,0,0,0,0,1,227,0,3,0,6,
	0,0,17,128,0,0,0,255,0,17,0,1,0,0,1,228,0,0,
	0,0,0,0,1,245,0,3,0,6,0,0,17,128,0,0,0,255,
	0,17,0,1,0,0,1,246,0,0,0,0,0,0,2,7,0,3,
	0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,2,8,
	0,0,0,0,0,0,2,25,0,3,0,6,0,0,17,128,0,0,
	0,255,0,17,0,1,0,0,2,26,0,0,0,0,0,0,2,43,
	0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,
	2,44,0,0,0,0,0,0,2,61,0,3,0,6,0,0,17,128,
	0,0,0,255,0,17,0,1,0,0,2,62,0,0,0,0,0,0,
	2,79,0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,
	0,0,2,80,0,0,0,0,0,0,2,97,0,3,0,6,0,0,
	17,128,0,0,0,255,0,17,0,1,0,0,2,98,0,0,0,0,
	0,0,2,115,0,3,0,6,0,0,17,128,0,0,0,255,0,17,
	0,1,0,0,2,116,0,0,0,0,0,0,2,133,0,3,0,6,
	0,0,17,128,0,0,0,255,0,17,0,1,0,0,2,134,0,0,
	0,0,0,0,2,151,0,3,0,6,0,0,17,128,0,0,0,255,
	0,17,0,1,0,0,2,152,0,0,0,0,0,0,2,169,0,3,
	0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,2,170,
	0,0,0,0,0,0,2,187,0,3,0,6,0,0,17,128,0,0,
	0,255,0,17,0,1,0,0,2,188,0,0,0,0,0,0,2,205,
	0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,
	2,206,0,0,0,0,0,0,2,223,0,3,0,6,0,0,17,128,
	0,0,0,255,0,17,0,1,0,0,2,224,0,0,0,0,0,0,
	2,241,0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,
	0,0,2,242,0,0,0,0,0,0,2,249,0,3,0,6,0,0,
	17,128,0,0,0,255,0,7,0,1,0,0,2,250,0,0,0,0,
	0,0,3,11,0,3,0,6,0,0,17,128,0,0,0,255,0,17,
	0,1,0,0,3,12,0,0,0,0,0,0,3,29,0,3,0,6,
	0,0,17,128,0,0,0,255,0,17,0,1,0,0,3,30,0,0,
	0,0,0,0,3,47,0,3,0,6,0,0,17,128,0,0,0,255,
	0,17,0,1,0,0,3,48,0,0,0,0,0,0,3,65,0,3,
	0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,3,66,
	0,0,0,0,0,0,3,83,0,3,0,6,0,0,17,128,0,0,
	0,255,0,17,0,1,0,0,3,84,0,0,0,0,0,0,3,101,
	0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,
	3,102,0,0,0,0,0,0,3,119,0,3,0,6,0,0,17,128,
	0,0,0,255,0,17,0,1,0,0,3,120,0,0,0,0,0,0,
	3,137,0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,
	0,0,3,138,0,0,0,0,0,0,3,155,0,3,0,6,0,0,
	17,128,0,0,0,255,0,17,0,1,0,0,3,156,0,0,0,0,
	0,0,3,173,0,3,0,6,0,0,17,128,0,0,0,255,0,17,
	0,1,0,0,3,174,0,0,0,0,0,0,3,191,0,3,0,6,
	0,0,17,128,0,0,0,255,0,17,0,1,0,0,3,192,0,0,
	0,0,0,0,3,209,0,3,0,6,0,0,17,128,0,0,0,255,
	0,17,0,1,0,0,3,210,0,0,0,0,0,0,3,227,0,3,
	0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,3,228,
	0,0,0,0,0,0,3,245,0,3,0,6,0,0,17,128,0,0,
	0,255,0,17,0,1,0,0,3,246,0,0,0,0,0,0,4,7,
	0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,0,0,
	4,8,0,0,0,0,0,0,4,25,0,3,0,6,0,0,17,128,
	0,0,0,255,0,17,0,1,0,0,4,26,0,0,0,0,0,0,
	4,43,0,3,0,6,0,0,17,128,0,0,0,255,0,17,0,1,
	0,0,4,44,0,0,0,0,0,0,4,61,0,3,0,6,0,0,
	17,128,0,0,0,255,0,17,0,1,0,0,4,62,0,0,0,0,
	0,0,4,79,0,3,0,6,0,0,17,128,0,0,0,255,0,17,
	0,1,0,0,4,80,0,0,0,0,0,0,4,97,0,3,0,6,
	0,0,17,128,0,0,0,255,0,17,0,1,0,0,4,160,0,0,
	0,0,0,0,4,181,0,3,0,6,0,0,17,128,0,0,0,255,
	0,21,0,1,0,0,4,182,0,0,0,0,0,0,4,212,0,3,
	0,6,0,0,17,128,0,0,0,255,0,30,0,1,0,0,4,213,
	0,0,0,0,0,0,4,231,0,3,0,6,0,0,17,128,0,0,
	0,255,0,18,0,1,0,0,4,232,0,0,0,0,0,0,5,1,
	0,3,0,6,0,0,17,128,0,0,0,255,0,25,0,1,0,0,
	5,81,0,0,0,0,0,0,5,106,0,3,0,6,0,0,17,128,
	0,0,0,255,0,25,0,1,0,0,5,137,0,0,0,0,0,0,
	5,168,0,3,0,6,0,0,17,128,0,0,0,255,0,31,0,1,
	255,255,0,1,0,2,0,20,0,0,0,0,0,2,17,66,0,0,
	0,0,0,56,0,20,0,2,255,255,255,255,0,26,0,7,0,0,
	0,0,0,36,0,2,0,18,0,52,0,1,0,0,0,3,0,13,
	0,20,0,0,0,0,0,2,17,0,0,1,0,1,0,54,0,16,
	0,4,255,255,255,255,0,28,0,0,0,0,0,0,0,39,0,20,
	0,2,0,8,0,1,0,5,255,255,255,255,0,28,0,0,0,0,
	0,0,0,48,0,29,0,2,0,8,0,1,0,6,255,255,255,255,
	0,21,0,0,0,0,0,0,5,170,0,13,0,5,0,29,0,1,
	0,12,0,7,0,11,0,20,0,0,0,0,0,255,33,0,0,1,
	0,7,0,52,0,7,0,8,255,255,255,255,0,28,0,0,0,0,
	0,0,0,86,0,8,0,6,0,35,0,1,0,9,255,255,255,255,
	0,21,0,0,0,0,0,0,5,198,0,12,0,1,0,29,0,1,
	0,10,255,255,255,255,0,28,0,0,0,0,0,0,0,153,0,12,
	0,2,0,22,0,1,0,11,255,255,255,255,0,28,0,0,0,0,
	0,0,0,162,0,12,0,3,0,21,0,1,0,6,255,255,255,255,
	0,28,0,0,0,0,0,0,0,183,0,12,0,4,0,7,0,1,
	0,13,255,255,255,255,0,21,0,0,0,0,0,0,5,226,0,17,
	0,4,0,22,0,1,0,2,255,255,255,255,0,21,0,32,0,0,
	0,0,5,254,0,13,0,1,0,30,0,1,255,255,0,1,0,81,
	0,20,0,0,0,0,0,2,17,99,0,0,0,0,0,77,0,24,
	0,84,0,60,0,80,0,20,0,0,0,0,0,255,17,82,0,1,
	0,2,0,12,0,21,0,80,255,255,255,255,0,26,0,81,0,0,
	0,0,1,108,0,0,0,2,0,12,0,1,0,77,255,255,255,255,
	0,26,0,81,0,0,0,0,1,82,0,0,0,6,0,12,0,1,
	0,3,255,255,255,255,0,26,0,81,0,0,0,0,1,69,0,0,
	0,8,0,12,0,1,0,83,255,255,255,255,0,27,0,64,0,0,
	1,255,17,0,0,0,0,0,0,3,0,1,0,5,255,255,255,255,
	0,27,0,64,0,0,2,255,17,0,0,0,0,19,0,3,0,1,
	0,83,255,255,255,255,0,20,0,64,0,0,0,255,17,0,0,0,
	0,3,0,3,0,1,0,84,0,9,0,28,0,20,0,0,0,0,
	0,255,17,0,0,0,0,1,0,17,0,20,0,10,255,255,255,255,
	0,21,0,81,0,0,0,0,6,82,0,0,0,0,0,16,0,1,
	0,11,255,255,255,255,0,21,0,81,0,0,0,0,6,110,0,0,
	0,1,0,16,0,1,0,12,255,255,255,255,0,21,0,81,0,0,
	0,0,6,138,0,0,0,2,0,16,0,1,0,13,255,255,255,255,
	0,21,0,81,0,0,0,0,6,166,0,0,0,3,0,16,0,1,
	0,14,255,255,255,255,0,21,0,81,0,0,0,0,6,194,0,0,
	0,4,0,16,0,1,0,15,255,255,255,255,0,21,0,81,0,0,
	0,0,6,222,0,0,0,5,0,16,0,1,0,16,255,255,255,255,
	0,21,0,81,0,0,0,0,6,250,0,0,0,6,0,16,0,1,
	0,17,255,255,255,255,0,21,0,81,0,0,0,0,7,22,0,0,
	0,7,0,16,0,1,0,18,255,255,255,255,0,21,0,81,0,0,
	0,0,7,50,0,0,0,8,0,16,0,1,0,19,255,255,255,255,
	0,21,0,81,0,0,0,0,7,78,0,0,0,9,0,16,0,1,
	0,20,255,255,255,255,0,21,0,81,0,0,0,0,7,106,0,0,
	0,10,0,16,0,1,0,21,255,255,255,255,0,21,0,81,0,0,
	0,0,7,134,0,0,0,11,0,16,0,1,0,22,255,255,255,255,
	0,21,0,81,0,0,0,0,7,162,0,0,0,12,0,16,0,1,
	0,23,255,255,255,255,0,21,0,81,0,0,0,0,7,190,0,0,
	0,13,0,16,0,1,0,24,255,255,255,255,0,21,0,81,0,0,
	0,0,7,218,0,0,0,14,0,16,0,1,0,25,255,255,255,255,
	0,21,0,81,0,0,0,0,7,246,0,0,0,15,0,16,0,1,
	0,26,255,255,255,255,0,21,0,81,0,0,0,0,8,18,0,0,
	0,16,0,16,0,1,0,27,255,255,255,255,0,21,0,81,0,0,
	0,0,8,46,0,0,0,17,0,16,0,1,0,28,255,255,255,255,
	0,21,0,81,0,0,0,0,8,74,0,0,0,18,0,16,0,1,
	0,8,255,255,255,255,0,21,0,81,0,0,0,0,8,102,0,0,
	0,19,0,16,0,1,0,4,255,255,255,255,0,26,0,81,0,0,
	0,0,1,56,0,0,0,10,0,12,0,1,0,31,255,255,255,255,
	0,26,0,5,0,0,0,0,4,98,0,41,0,5,0,10,0,1,
	0,91,255,255,255,255,0,26,0,5,0,0,0,0,4,105,0,41,
	0,7,0,10,0,1,0,29,255,255,255,255,0,26,0,81,0,0,
	0,0,1,43,0,0,0,12,0,12,0,1,0,32,255,255,255,255,
	0,26,0,81,0,0,0,0,1,30,0,0,0,14,0,12,0,1,
	0,33,255,255,255,255,0,26,0,81,0,0,0,0,1,17,0,0,
	0,16,0,12,0,1,0,34,255,255,255,255,0,26,0,81,0,0,
	0,0,1,4,0,0,0,18,0,12,0,1,0,37,255,255,255,255,
	0,27,0,64,0,0,1,255,17,0,0,0,0,0,0,3,0,1,
	0,93,255,255,255,255,0,27,0,64,0,0,2,255,17,0,0,0,
	0,19,0,3,0,1,0,89,255,255,255,255,0,20,0,64,0,0,
	0,255,17,0,0,0,0,3,0,3,0,1,0,93,0,40,0,59,
	0,20,0,0,0,0,0,255,17,0,0,0,0,1,0,17,0,20,
	0,41,255,255,255,255,0,21,0,65,0,0,0,0,8,158,0,0,
	0,0,0,16,0,1,0,42,255,255,255,255,0,21,0,65,0,0,
	0,0,8,186,0,0,0,1,0,16,0,1,0,43,255,255,255,255,
	0,21,0,65,0,0,0,0,8,214,0,0,0,2,0,16,0,1,
	0,44,255,255,255,255,0,21,0,65,0,0,0,0,8,242,0,0,
	0,3,0,16,0,1,0,45,255,255,255,255,0,21,0,65,0,0,
	0,0,9,14,0,0,0,4,0,16,0,1,0,46,255,255,255,255,
	0,21,0,65,0,0,0,0,9,42,0,0,0,5,0,16,0,1,
	0,47,255,255,255,255,0,21,0,65,0,0,0,0,9,70,0,0,
	0,6,0,16,0,1,0,48,255,255,255,255,0,21,0,65,0,0,
	0,0,9,98,0,0,0,7,0,16,0,1,0,49,255,255,255,255,
	0,21,0,65,0,0,0,0,9,126,0,0,0,8,0,16,0,1,
	0,50,255,255,255,255,0,21,0,65,0,0,0,0,9,154,0,0,
	0,9,0,16,0,1,0,51,255,255,255,255,0,21,0,65,0,0,
	0,0,9,182,0,0,0,10,0,16,0,1,0,52,255,255,255,255,
	0,21,0,65,0,0,0,0,9,210,0,0,0,11,0,16,0,1,
	0,53,255,255,255,255,0,21,0,65,0,0,0,0,9,238,0,0,
	0,12,0,16,0,1,0,54,255,255,255,255,0,21,0,65,0,0,
	0,0,10,10,0,0,0,13,0,16,0,1,0,55,255,255,255,255,
	0,21,0,65,0,0,0,0,10,38,0,0,0,14,0,16,0,1,
	0,56,255,255,255,255,0,21,0,65,0,0,0,0,10,66,0,0,
	0,15,0,16,0,1,0,57,255,255,255,255,0,21,0,65,0,0,
	0,0,10,94,0,0,0,16,0,16,0,1,0,58,255,255,255,255,
	0,21,0,65,0,0,0,0,10,122,0,0,0,17,0,16,0,1,
	0,59,255,255,255,255,0,21,0,65,0,0,0,0,10,150,0,0,
	0,18,0,16,0,1,0,39,255,255,255,255,0,21,0,65,0,0,
	0,0,10,178,0,0,0,19,0,16,0,1,0,35,255,255,255,255,
	0,26,0,81,0,0,0,0,0,247,0,0,0,20,0,12,0,1,
	0,62,255,255,255,255,0,27,0,21,0,0,65,255,17,0,0,1,
	0,1,0,3,0,1,0,63,255,255,255,255,0,27,0,21,0,0,
	66,255,17,0,0,5,0,1,0,3,0,1,0,64,255,255,255,255,
	0,27,0,21,0,0,67,255,17,0,0,9,0,1,0,3,0,1,
	0,65,255,255,255,255,0,27,0,21,0,0,68,255,17,0,0,13,
	0,1,0,3,0,1,0,66,255,255,255,255,0,27,0,21,0,0,
	69,255,17,0,0,1,0,3,0,3,0,1,0,67,255,255,255,255,
	0,27,0,21,0,0,70,255,17,0,0,5,0,3,0,3,0,1,
	0,68,255,255,255,255,0,27,0,21,0,0,71,255,17,0,0,9,
	0,3,0,3,0,1,0,69,255,255,255,255,0,27,0,21,0,0,
	72,255,17,0,0,13,0,3,0,3,0,1,0,70,255,255,255,255,
	0,27,0,21,0,0,73,255,17,0,0,1,0,5,0,3,0,1,
	0,71,255,255,255,255,0,27,0,21,0,0,74,255,17,0,0,5,
	0,5,0,3,0,1,0,72,255,255,255,255,0,27,0,21,0,0,
	75,255,17,0,0,9,0,5,0,3,0,1,0,73,255,255,255,255,
	0,27,0,21,0,0,76,255,17,0,0,13,0,5,0,3,0,1,
	0,74,255,255,255,255,0,27,0,21,0,0,77,255,17,0,0,1,
	0,7,0,3,0,1,0,75,255,255,255,255,0,27,0,21,0,0,
	78,255,17,0,0,5,0,7,0,3,0,1,0,76,255,255,255,255,
	0,27,0,21,0,0,79,255,17,0,0,9,0,7,0,3,0,1,
	0,92,255,255,255,255,0,27,0,21,0,0,80,255,17,0,0,13,
	0,7,0,3,0,1,0,2,255,255,255,255,0,26,0,81,0,0,
	0,0,1,95,0,0,0,4,0,12,0,1,0,79,255,255,255,255,
	0,26,0,5,0,0,0,0,4,122,0,37,0,19,0,6,0,1,
	0,95,255,255,255,255,0,26,0,5,0,0,0,0,4,127,0,48,
	0,19,0,6,0,1,0,1,0,82,0,82,0,20,0,0,0,0,
	0,255,17,65,0,0,0,0,0,12,0,1,0,0,255,255,255,255,
	0,26,0,39,0,0,0,0,4,138,0,48,0,21,0,6,0,1,
	0,80,255,255,255,255,0,21,0,0,0,0,0,0,6,26,0,3,
	0,0,0,6,0,1,0,94,0,7,0,7,0,20,0,64,0,0,
	0,255,17,65,0,0,0,1,0,3,0,18,0,87,0,85,0,8,
	0,25,0,0,0,0,0,255,17,0,0,15,0,2,0,20,0,21,
	0,8,0,86,0,86,0,20,0,0,0,0,0,255,17,66,0,0,
	0,0,0,20,0,1,0,85,255,255,255,255,0,21,0,0,0,0,
	0,0,6,54,0,7,0,0,0,7,0,1,0,94,0,88,0,93,
	0,25,0,0,0,0,0,255,17,0,0,56,0,2,0,20,0,21,
	0,39,0,90,0,90,0,20,0,0,0,0,0,255,17,66,0,0,
	0,0,0,20,0,1,0,36,0,38,0,38,0,20,0,64,0,0,
	0,255,17,65,0,0,0,1,0,3,0,18,0,88,255,255,255,255,
	0,21,0,0,0,0,0,0,8,130,0,7,0,0,0,6,0,1,
	0,78,0,61,0,92,0,20,0,0,0,0,0,254,17,0,0,37,
	0,9,0,17,0,9,0,91,255,255,255,255,0,28,0,0,0,0,
	0,0,4,115,0,0,0,0,0,6,0,1,0,87,0,89,0,37,
	0,20,0,0,0,0,0,255,17,0,0,17,0,1,0,3,0,20,
	0,30,0,6,0,83,0,20,0,0,0,0,0,255,17,0,0,32,
	0,3,0,3,0,20,0,81,255,255,255,255,0,26,0,5,0,0,
	0,0,4,132,0,37,0,21,0,6,0,1,255,255,0,1,0,2,
	0,20,0,0,0,0,0,2,17,66,0,0,0,0,0,56,0,20,
	0,2,255,255,255,255,0,26,0,7,0,0,0,0,4,143,0,2,
	0,18,0,52,0,1,0,0,0,3,0,19,0,20,0,0,0,0,
	0,2,17,0,0,1,0,1,0,54,0,16,0,4,255,255,255,255,
	0,28,0,0,0,0,0,0,4,146,0,20,0,2,0,8,0,1,
	0,5,255,255,255,255,0,28,0,0,0,0,0,0,4,155,0,29,
	0,2,0,8,0,1,0,6,255,255,255,255,0,21,0,0,0,0,
	0,0,10,206,0,2,0,5,0,20,0,1,0,7,255,255,255,255,
	0,21,0,0,0,0,0,0,10,234,0,23,0,5,0,29,0,1,
	0,8,255,255,255,255,0,21,0,0,0,0,0,0,11,6,0,19,
	0,4,0,17,0,1,0,19,0,9,0,18,0,20,0,0,0,0,
	0,255,33,0,0,1,0,7,0,52,0,7,0,10,255,255,255,255,
	0,21,0,0,0,0,0,0,11,34,0,3,0,1,0,18,0,1,
	0,11,255,255,255,255,0,28,0,0,0,0,0,0,5,2,0,3,
	0,2,0,24,0,1,0,12,255,255,255,255,0,28,0,0,0,0,
	0,0,5,26,0,3,0,3,0,24,0,1,0,13,255,255,255,255,
	0,28,0,0,0,0,0,0,5,51,0,3,0,4,0,11,0,1,
	0,14,255,255,255,255,0,28,0,0,0,0,0,0,5,59,0,3,
	0,6,0,6,0,1,0,15,255,255,255,255,0,28,0,0,0,0,
	0,0,5,66,0,9,0,6,0,15,0,1,0,16,255,255,255,255,
	0,21,0,0,0,0,0,0,11,62,0,31,0,1,0,18,0,1,
	0,17,255,255,255,255,0,28,0,0,0,0,0,0,5,107,0,31,
	0,2,0,20,0,1,0,18,255,255,255,255,0,28,0,0,0,0,
	0,0,5,114,0,31,0,3,0,20,0,1,0,8,255,255,255,255,
	0,28,0,0,0,0,0,0,5,131,0,31,0,4,0,18,0,1,
	0,2,255,255,255,255,0,21,0,32,0,0,0,0,11,90,0,11,
	0,1,0,30,0,1,0,0,11,118,0,0,21,198,0,0,11,118,
	0,0,11,118,0,0,11,118,0,0,11,118,0,0,11,118,0,0,
	12,198
};
