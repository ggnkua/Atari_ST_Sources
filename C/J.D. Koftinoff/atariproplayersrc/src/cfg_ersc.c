/*

 The Pro MIDI Player
 Copyright 1986-1994 By J.D. Koftinoff Software, Ltd.
 Released under the GPL in 2007
 Please see the file 'COPYING' including in this package.
 
*/
 
/*
 * C version of 'D:\DEV\PERF8\SRC\CFG_EDIT.RSC'
 */

unsigned char CFG_EDITRSC[] = {
	0,0,7,6,4,214,4,214,4,214,4,214,0,36,4,214,4,214,
	23,254,0,181,0,10,0,20,0,0,0,0,0,0,0,0,24,38,
	32,78,79,32,0,32,89,69,83,32,0,82,79,76,65,78,68,58,
	0,32,68,45,49,48,32,32,0,32,68,45,53,48,32,32,0,32,
	77,84,45,51,50,32,0,32,85,45,50,48,0,32,74,88,45,56,
	80,0,32,74,68,45,56,48,48,0,89,65,77,65,72,65,58,0,
	32,68,88,45,55,32,32,0,32,79,70,70,0,32,68,80,45,50,
	0,32,79,78,32,0,32,49,0,32,50,0,32,51,0,32,52,0,
	32,53,0,32,54,0,32,55,0,32,56,0,32,57,0,49,48,0,
	49,49,0,49,50,0,49,51,0,49,52,0,49,53,0,49,54,0,
	32,32,32,32,78,111,110,101,0,32,49,0,32,50,0,32,51,0,
	32,52,0,32,53,0,32,54,0,32,55,0,32,56,0,32,57,0,
	49,48,0,49,49,0,49,50,0,49,51,0,49,52,0,49,53,0,
	49,54,0,78,111,110,101,0,65,108,108,0,32,80,71,32,49,0,
	32,80,71,32,49,50,53,0,32,72,111,108,100,32,80,101,100,97,
	108,0,32,80,71,32,65,76,76,0,32,80,111,114,116,97,109,101,
	110,116,111,0,79,75,0,84,72,69,32,80,82,79,32,77,73,68,
	73,32,80,76,65,89,69,82,32,67,79,78,70,73,71,85,82,65,
	84,73,79,78,32,69,68,73,84,79,82,0,0,86,69,82,83,73,
	79,78,58,0,56,46,48,65,0,80,114,111,32,77,73,68,73,32,
	83,121,115,116,101,109,115,32,97,110,100,0,0,74,46,68,46,32,
	75,111,102,116,105,110,111,102,102,32,83,111,102,116,119,97,114,101,
	44,32,76,116,100,46,0,0,67,111,112,121,114,105,103,104,116,32,
	49,57,57,51,32,98,121,0,0,80,114,111,32,77,73,68,73,32,
	83,121,115,116,101,109,115,32,32,32,32,32,32,32,32,0,0,49,
	55,54,32,67,104,114,105,115,116,105,101,32,80,97,114,107,32,77,
	97,110,111,114,0,67,97,108,103,97,114,121,44,32,65,108,98,101,
	114,116,97,44,32,67,97,110,97,100,97,0,84,51,72,45,50,80,
	54,0,80,72,79,78,69,58,0,40,52,48,51,41,32,50,52,51,
	45,48,51,53,56,0,80,114,111,32,77,73,68,73,32,83,121,115,
	116,101,109,115,32,32,32,32,32,32,32,32,0,0,66,111,120,32,
	49,51,0,76,97,117,114,105,101,114,44,32,87,65,44,32,85,83,
	65,0,57,57,49,52,54,0,79,75,0,84,72,69,32,80,82,79,
	32,77,73,68,73,32,80,76,65,89,69,82,32,67,79,78,70,73,
	71,85,82,65,84,73,79,78,32,69,68,73,84,79,82,0,0,86,
	69,82,83,73,79,78,58,0,56,46,48,48,32,65,0,74,46,68,
	46,32,75,111,102,116,105,110,111,102,102,32,83,111,102,116,119,97,
	114,101,44,32,76,116,100,46,0,0,40,54,48,52,41,32,52,51,
	48,45,54,56,50,55,32,32,70,97,120,58,32,40,54,48,52,41,
	32,52,52,50,45,51,50,51,51,0,74,46,68,46,32,75,111,102,
	116,105,110,111,102,102,32,83,111,102,116,119,97,114,101,44,32,76,
	116,100,46,0,0,66,111,120,32,52,49,48,51,0,86,97,110,99,
	111,117,118,101,114,44,32,66,67,32,67,97,110,97,100,97,0,86,
	54,66,45,51,90,54,0,67,111,112,121,114,105,103,104,116,32,49,
	57,56,54,45,49,57,57,51,32,98,121,0,0,32,68,82,73,86,
	69,0,73,78,80,85,84,0,69,120,116,101,114,110,97,108,32,67,
	111,110,116,114,111,108,32,67,104,97,110,110,101,108,58,0,74,111,
	121,115,116,105,99,107,32,77,111,100,101,58,0,67,67,72,78,0,
	0,85,74,79,89,0,0,67,84,82,76,84,89,80,69,0,0,67,
	111,110,116,114,111,108,32,84,121,112,101,58,0,79,85,84,80,85,
	84,0,68,105,115,112,108,97,121,32,67,104,97,110,110,101,108,32,
	47,32,85,110,105,116,32,35,0,68,67,72,78,0,0,68,73,83,
	80,84,89,80,69,0,0,68,105,115,112,108,97,121,32,84,121,112,
	101,58,0,79,84,72,69,82,0,77,73,68,73,32,84,104,114,117,
	47,82,101,99,104,97,110,110,101,108,105,122,101,58,0,84,72,82,
	85,0,0,73,110,116,101,114,110,97,108,32,67,111,110,116,114,111,
	108,32,67,104,97,110,110,101,108,58,0,73,67,72,78,0,0,80,
	69,88,67,0,0,80,97,117,115,101,32,65,102,116,101,114,32,69,
	120,99,108,117,115,105,118,101,58,0,76,111,97,100,32,83,105,110,
	103,108,101,32,83,111,110,103,115,32,79,110,108,121,58,0,80,65,
	76,32,0,0,80,97,117,115,101,32,97,102,116,101,114,32,115,111,
	110,103,32,108,111,97,100,58,0,76,68,83,83,0,0,76,79,65,
	68,0,83,65,86,69,0,69,88,73,84,0,32,49,0,32,50,0,
	32,51,0,32,52,0,32,53,0,32,54,0,32,55,0,32,56,0,
	32,57,0,49,48,0,49,49,0,49,50,0,49,51,0,49,52,0,
	49,53,0,49,54,0,49,55,0,49,56,0,49,57,0,50,48,0,
	50,49,0,50,50,0,50,51,0,50,52,0,50,53,0,50,54,0,
	50,55,0,50,56,0,50,57,0,51,48,0,51,49,0,51,50,0,
	32,32,32,32,78,111,110,101,32,32,32,32,0,0,0,0,1,39,
	0,0,0,0,0,0,1,80,0,3,0,6,0,0,17,128,0,0,
	0,255,0,41,0,1,0,0,1,95,0,0,0,0,0,0,1,116,
	0,3,0,6,0,0,17,128,0,0,0,255,0,21,0,1,0,0,
	1,117,0,0,0,0,0,0,1,147,0,3,0,6,0,0,17,128,
	0,0,0,255,0,30,0,1,0,0,1,148,0,0,0,0,0,0,
	1,166,0,3,0,6,0,0,17,128,0,0,0,255,0,18,0,1,
	0,0,1,167,0,0,0,0,0,0,1,192,0,3,0,6,0,0,
	17,128,0,0,0,255,0,25,0,1,0,0,2,16,0,0,0,0,
	0,0,2,41,0,3,0,6,0,0,17,128,0,0,0,255,0,25,
	0,1,0,0,2,75,0,0,0,0,0,0,2,116,0,3,0,6,
	0,0,17,128,0,0,0,255,0,41,0,1,0,0,2,133,0,0,
	0,0,0,0,2,163,0,3,0,6,0,0,17,128,0,0,0,255,
	0,30,0,1,0,0,2,200,0,0,0,0,0,0,2,230,0,3,
	0,6,0,0,17,128,0,0,0,255,0,30,0,1,0,0,3,13,
	0,0,0,0,0,0,3,36,0,3,0,6,0,0,17,128,0,0,
	0,255,0,23,0,1,0,0,3,91,0,0,0,0,0,0,3,96,
	0,3,0,6,0,0,17,128,0,0,0,255,0,5,0,1,0,0,
	3,97,0,0,0,0,0,0,3,102,0,3,0,6,0,0,17,128,
	0,0,0,255,0,5,0,1,0,0,3,103,0,0,0,0,0,0,
	3,112,0,3,0,6,0,0,17,128,0,0,0,255,0,9,0,1,
	0,0,3,159,0,0,0,0,0,0,3,164,0,3,0,6,0,0,
	17,128,0,0,0,255,0,5,0,1,0,0,3,165,0,0,0,0,
	0,0,3,174,0,3,0,6,0,0,17,128,0,0,0,255,0,9,
	0,1,0,0,3,219,0,0,0,0,0,0,3,224,0,3,0,6,
	0,0,17,128,0,0,0,255,0,5,0,1,0,0,3,251,0,0,
	0,0,0,0,4,0,0,3,0,6,0,0,17,128,0,0,0,255,
	0,5,0,1,0,0,4,1,0,0,0,0,0,0,4,6,0,3,
	0,6,0,0,17,128,0,0,0,255,0,5,0,1,0,0,4,54,
	0,0,0,0,0,0,4,59,0,3,0,6,0,0,17,128,0,0,
	0,255,0,5,0,1,0,0,4,83,0,0,0,0,0,0,4,88,
	0,3,0,6,0,0,17,128,0,0,0,255,0,5,0,1,255,255,
	0,1,0,2,0,20,0,0,0,0,0,254,17,0,0,0,0,0,
	0,6,0,2,0,2,255,255,255,255,0,28,0,5,0,0,0,0,
	0,36,0,0,0,1,0,6,0,1,0,0,255,255,255,255,0,28,
	0,37,0,0,0,0,0,41,0,0,0,0,0,6,0,1,255,255,
	0,1,0,10,0,20,0,0,0,0,0,254,17,0,0,0,0,0,
	0,16,0,7,0,2,255,255,255,255,0,28,0,0,0,8,0,0,
	0,47,0,0,0,0,0,8,0,1,0,3,255,255,255,255,0,28,
	0,5,0,0,0,0,0,55,0,0,0,1,0,8,0,1,0,4,
	255,255,255,255,0,28,0,5,0,0,0,0,0,63,0,0,0,2,
	0,8,0,1,0,5,255,255,255,255,0,28,0,5,0,0,0,0,
	0,71,0,0,0,3,0,8,0,1,0,6,255,255,255,255,0,28,
	0,5,0,0,0,0,0,79,0,0,0,4,0,8,0,1,0,9,
	255,255,255,255,0,28,0,5,0,0,0,0,0,85,0,0,0,5,
	0,8,0,1,0,8,255,255,255,255,0,28,0,0,0,8,0,0,
	0,100,0,8,0,0,0,8,0,1,0,10,255,255,255,255,0,28,
	0,5,0,0,0,0,0,108,0,8,0,1,0,8,0,1,0,7,
	255,255,255,255,0,28,0,5,0,0,0,0,0,92,0,0,0,6,
	0,8,0,1,0,0,255,255,255,255,0,20,0,32,0,8,0,0,
	17,0,0,8,0,2,0,8,0,5,255,255,0,1,0,3,0,20,
	0,0,0,0,0,254,17,0,0,0,0,0,0,6,0,3,0,2,
	255,255,255,255,0,28,0,5,0,0,0,0,0,116,0,0,0,1,
	0,6,0,1,0,3,255,255,255,255,0,28,0,5,0,0,0,0,
	0,121,0,0,0,2,0,6,0,1,0,0,255,255,255,255,0,28,
	0,37,0,0,0,0,0,127,0,0,0,0,0,6,0,1,255,255,
	0,1,0,17,0,20,0,0,0,0,0,254,17,0,0,0,0,0,
	0,12,0,5,0,2,255,255,255,255,0,28,0,5,0,0,0,0,
	0,132,0,0,0,0,0,3,0,1,0,3,255,255,255,255,0,28,
	0,5,0,0,0,0,0,135,0,3,0,0,0,3,0,1,0,4,
	255,255,255,255,0,28,0,5,0,0,0,0,0,138,0,6,0,0,
	0,3,0,1,0,5,255,255,255,255,0,28,0,5,0,0,0,0,
	0,141,0,9,0,0,0,3,0,1,0,6,255,255,255,255,0,28,
	0,5,0,0,0,0,0,144,0,0,0,1,0,3,0,1,0,7,
	255,255,255,255,0,28,0,5,0,0,0,0,0,147,0,3,0,1,
	0,3,0,1,0,8,255,255,255,255,0,28,0,5,0,0,0,0,
	0,150,0,6,0,1,0,3,0,1,0,9,255,255,255,255,0,28,
	0,5,0,0,0,0,0,153,0,9,0,1,0,3,0,1,0,10,
	255,255,255,255,0,28,0,5,0,0,0,0,0,156,0,0,0,2,
	0,3,0,1,0,11,255,255,255,255,0,28,0,5,0,0,0,0,
	0,159,0,3,0,2,0,3,0,1,0,12,255,255,255,255,0,28,
	0,5,0,0,0,0,0,162,0,6,0,2,0,3,0,1,0,13,
	255,255,255,255,0,28,0,5,0,0,0,0,0,165,0,9,0,2,
	0,3,0,1,0,14,255,255,255,255,0,28,0,5,0,0,0,0,
	0,168,0,0,0,3,0,3,0,1,0,15,255,255,255,255,0,28,
	0,5,0,0,0,0,0,171,0,3,0,3,0,3,0,1,0,16,
	255,255,255,255,0,28,0,5,0,0,0,0,0,174,0,6,0,3,
	0,3,0,1,0,17,255,255,255,255,0,28,0,5,0,0,0,0,
	0,177,0,9,0,3,0,3,0,1,0,0,255,255,255,255,0,28,
	0,37,0,0,0,0,0,180,0,0,0,4,0,12,0,1,255,255,
	0,1,0,18,0,20,0,0,0,0,0,254,17,0,0,0,0,0,
	0,12,0,5,0,2,255,255,255,255,0,28,0,5,0,0,0,0,
	0,189,0,0,0,0,0,3,0,1,0,3,255,255,255,255,0,28,
	0,5,0,0,0,0,0,192,0,3,0,0,0,3,0,1,0,4,
	255,255,255,255,0,28,0,5,0,0,0,0,0,195,0,6,0,0,
	0,3,0,1,0,5,255,255,255,255,0,28,0,5,0,0,0,0,
	0,198,0,9,0,0,0,3,0,1,0,6,255,255,255,255,0,28,
	0,5,0,0,0,0,0,201,0,0,0,1,0,3,0,1,0,7,
	255,255,255,255,0,28,0,5,0,0,0,0,0,204,0,3,0,1,
	0,3,0,1,0,8,255,255,255,255,0,28,0,5,0,0,0,0,
	0,207,0,6,0,1,0,3,0,1,0,9,255,255,255,255,0,28,
	0,5,0,0,0,0,0,210,0,9,0,1,0,3,0,1,0,10,
	255,255,255,255,0,28,0,5,0,0,0,0,0,213,0,0,0,2,
	0,3,0,1,0,11,255,255,255,255,0,28,0,5,0,0,0,0,
	0,216,0,3,0,2,0,3,0,1,0,12,255,255,255,255,0,28,
	0,5,0,0,0,0,0,219,0,6,0,2,0,3,0,1,0,13,
	255,255,255,255,0,28,0,5,0,0,0,0,0,222,0,9,0,2,
	0,3,0,1,0,14,255,255,255,255,0,28,0,5,0,0,0,0,
	0,225,0,0,0,3,0,3,0,1,0,15,255,255,255,255,0,28,
	0,5,0,0,0,0,0,228,0,3,0,3,0,3,0,1,0,16,
	255,255,255,255,0,28,0,5,0,0,0,0,0,231,0,6,0,3,
	0,3,0,1,0,17,255,255,255,255,0,28,0,5,0,0,0,0,
	0,234,0,9,0,3,0,3,0,1,0,18,255,255,255,255,0,28,
	0,5,0,0,0,0,0,237,0,0,0,4,0,6,0,1,0,0,
	255,255,255,255,0,28,0,37,0,0,0,0,0,242,0,6,0,4,
	0,6,0,1,255,255,0,1,0,5,0,20,0,0,0,0,0,254,
	17,0,0,0,0,0,0,12,0,5,0,2,255,255,255,255,0,28,
	0,5,0,0,0,0,0,246,0,0,0,1,0,12,0,1,0,3,
	255,255,255,255,0,28,0,5,0,0,0,0,0,252,0,0,0,2,
	0,12,0,1,0,4,255,255,255,255,0,28,0,5,0,0,0,0,
	1,4,0,0,0,3,0,12,0,1,0,5,255,255,255,255,0,28,
	0,5,0,0,0,0,1,16,0,0,0,0,0,12,0,1,0,0,
	255,255,255,255,0,28,0,37,0,0,0,0,1,24,0,0,0,4,
	0,12,0,1,255,255,0,1,0,2,0,20,0,0,0,0,0,2,
	17,66,0,0,0,0,0,56,0,20,0,2,255,255,255,255,0,26,
	0,7,0,0,0,0,1,36,0,2,0,18,0,52,0,1,0,0,
	0,3,0,9,0,20,0,0,0,0,0,2,17,0,0,1,0,1,
	0,54,0,16,0,4,255,255,255,255,0,21,0,0,0,0,0,0,
	4,214,0,7,0,1,0,40,0,1,0,5,255,255,255,255,0,28,
	0,0,0,0,0,0,1,81,0,20,0,2,0,8,0,1,0,6,
	255,255,255,255,0,28,0,0,0,0,0,0,1,90,0,29,0,2,
	0,8,0,1,0,7,255,255,255,255,0,21,0,0,0,0,0,0,
	4,242,0,2,0,5,0,20,0,1,0,8,255,255,255,255,0,21,
	0,0,0,0,0,0,5,14,0,23,0,5,0,29,0,1,0,9,
	255,255,255,255,0,21,0,0,0,0,0,0,5,42,0,19,0,4,
	0,17,0,1,0,2,0,10,0,19,0,20,0,0,0,0,0,255,
	33,0,0,1,0,7,0,52,0,7,0,11,255,255,255,255,0,21,
	0,0,0,0,0,0,5,70,0,3,0,1,0,18,0,1,0,12,
	255,255,255,255,0,28,0,0,0,0,0,0,1,193,0,3,0,2,
	0,24,0,1,0,13,255,255,255,255,0,28,0,0,0,0,0,0,
	1,217,0,3,0,3,0,24,0,1,0,14,255,255,255,255,0,28,
	0,0,0,0,0,0,1,242,0,3,0,4,0,11,0,1,0,15,
	255,255,255,255,0,28,0,0,0,0,0,0,1,250,0,3,0,6,
	0,6,0,1,0,16,255,255,255,255,0,28,0,0,0,0,0,0,
	2,1,0,9,0,6,0,15,0,1,0,17,255,255,255,255,0,21,
	0,0,0,0,0,0,5,98,0,31,0,1,0,18,0,1,0,18,
	255,255,255,255,0,28,0,0,0,0,0,0,2,42,0,31,0,2,
	0,20,0,1,0,19,255,255,255,255,0,28,0,0,0,0,0,0,
	2,49,0,31,0,3,0,20,0,1,0,9,255,255,255,255,0,28,
	0,32,0,0,0,0,2,66,0,31,0,4,0,18,0,1,255,255,
	0,1,0,2,0,20,0,0,0,0,0,2,17,66,0,0,0,0,
	0,56,0,20,0,2,255,255,255,255,0,26,0,7,0,0,0,0,
	2,72,0,2,0,18,0,52,0,1,0,0,0,3,0,13,0,20,
	0,0,0,0,0,2,17,0,0,1,0,1,0,54,0,16,0,4,
	255,255,255,255,0,21,0,0,0,0,0,0,5,126,0,7,0,1,
	0,40,0,1,0,5,255,255,255,255,0,28,0,0,0,0,0,0,
	2,117,0,20,0,2,0,8,0,1,0,6,255,255,255,255,0,28,
	0,0,0,0,0,0,2,126,0,29,0,2,0,8,0,1,0,7,
	255,255,255,255,0,21,0,0,0,0,0,0,5,154,0,13,0,5,
	0,29,0,1,0,13,0,8,0,12,0,20,0,0,0,0,0,255,
	33,0,0,1,0,7,0,52,0,7,0,9,255,255,255,255,0,28,
	0,0,0,0,0,0,2,164,0,8,0,6,0,35,0,1,0,10,
	255,255,255,255,0,21,0,0,0,0,0,0,5,182,0,12,0,1,
	0,29,0,1,0,11,255,255,255,255,0,28,0,0,0,0,0,0,
	2,231,0,12,0,2,0,22,0,1,0,12,255,255,255,255,0,28,
	0,0,0,0,0,0,2,240,0,12,0,3,0,21,0,1,0,7,
	255,255,255,255,0,28,0,0,0,0,0,0,3,5,0,12,0,4,
	0,7,0,1,0,2,255,255,255,255,0,21,0,32,0,0,0,0,
	5,210,0,17,0,4,0,22,0,1,255,255,0,1,0,45,0,20,
	0,0,0,0,0,2,17,67,0,0,0,0,0,80,0,24,0,20,
	0,2,0,3,0,20,0,0,0,0,0,254,17,0,0,2,0,1,
	0,9,0,20,0,18,0,19,0,19,0,20,0,0,0,0,0,255,
	17,34,0,0,0,0,0,9,0,1,0,1,255,255,255,255,0,27,
	0,21,0,0,80,255,17,0,0,5,0,17,0,3,0,1,0,17,
	255,255,255,255,0,27,0,21,0,0,79,255,17,0,0,1,0,17,
	0,3,0,1,0,3,255,255,255,255,0,27,0,21,0,0,78,255,
	17,0,0,5,0,15,0,3,0,1,0,4,255,255,255,255,0,27,
	0,21,0,0,77,255,17,0,0,1,0,15,0,3,0,1,0,5,
	255,255,255,255,0,27,0,21,0,0,76,255,17,0,0,5,0,13,
	0,3,0,1,0,6,255,255,255,255,0,27,0,21,0,0,75,255,
	17,0,0,1,0,13,0,3,0,1,0,7,255,255,255,255,0,27,
	0,21,0,0,74,255,17,0,0,5,0,11,0,3,0,1,0,8,
	255,255,255,255,0,27,0,21,0,0,73,255,17,0,0,1,0,11,
	0,3,0,1,0,9,255,255,255,255,0,27,0,21,0,0,72,255,
	17,0,0,5,0,9,0,3,0,1,0,10,255,255,255,255,0,27,
	0,21,0,0,71,255,17,0,0,1,0,9,0,3,0,1,0,11,
	255,255,255,255,0,27,0,21,0,0,70,255,17,0,0,5,0,7,
	0,3,0,1,0,12,255,255,255,255,0,27,0,21,0,0,69,255,
	17,0,0,1,0,7,0,3,0,1,0,14,255,255,255,255,0,27,
	0,21,0,0,67,255,17,0,0,1,0,5,0,3,0,1,0,13,
	255,255,255,255,0,27,0,21,0,0,68,255,17,0,0,5,0,5,
	0,3,0,1,0,16,255,255,255,255,0,27,0,21,0,0,66,255,
	17,0,0,5,0,3,0,3,0,1,0,15,255,255,255,255,0,27,
	0,21,0,0,65,255,17,0,0,1,0,3,0,3,0,1,0,2,
	255,255,255,255,0,28,0,0,0,0,0,0,3,37,0,1,0,0,
	0,6,0,1,0,29,0,21,0,27,0,20,0,0,0,0,0,254,
	17,0,0,14,0,1,0,64,0,6,0,23,0,22,0,22,0,20,
	0,0,0,0,0,255,17,34,0,0,0,0,0,64,0,1,0,21,
	255,255,255,255,0,28,0,0,0,0,0,0,3,44,0,26,0,0,
	0,6,0,1,0,25,255,255,255,255,0,28,0,0,0,0,0,0,
	3,50,0,2,0,2,0,25,0,1,0,28,255,255,255,255,0,21,
	0,64,0,0,0,0,5,238,0,28,0,2,0,4,0,1,0,24,
	255,255,255,255,0,28,0,0,0,0,0,0,3,76,0,2,0,3,
	0,14,0,1,0,27,255,255,255,255,0,21,0,64,0,0,0,0,
	6,38,0,55,0,2,0,8,0,1,0,20,255,255,255,255,0,28,
	0,0,0,0,0,0,3,113,0,35,0,2,0,13,0,1,0,26,
	255,255,255,255,0,21,0,64,0,0,0,0,6,10,0,28,0,3,
	0,4,0,1,0,36,0,30,0,34,0,20,0,0,0,0,0,254,
	17,0,0,14,0,8,0,64,0,6,0,32,0,31,0,31,0,20,
	0,0,0,0,0,255,17,34,0,0,0,0,0,64,0,1,0,30,
	255,255,255,255,0,28,0,0,0,0,0,0,3,127,0,26,0,0,
	0,7,0,1,0,33,255,255,255,255,0,28,0,0,0,0,0,0,
	3,134,0,2,0,2,0,24,0,1,0,35,255,255,255,255,0,21,
	0,64,0,0,0,0,6,66,0,28,0,2,0,4,0,1,0,29,
	255,255,255,255,0,28,0,0,0,0,0,0,3,175,0,35,0,2,
	0,13,0,1,0,34,255,255,255,255,0,21,0,64,0,0,0,0,
	6,94,0,55,0,2,0,8,0,1,0,43,0,37,0,49,0,20,
	0,0,0,0,0,254,17,0,0,14,0,15,0,64,0,6,0,39,
	0,38,0,38,0,20,0,0,0,0,0,255,17,34,0,0,0,0,
	0,64,0,1,0,37,255,255,255,255,0,28,0,0,0,0,0,0,
	3,189,0,27,0,0,0,7,0,1,0,40,255,255,255,255,0,28,
	0,0,0,0,0,0,3,195,0,3,0,2,0,23,0,1,0,41,
	255,255,255,255,0,21,0,64,0,0,0,0,6,122,0,28,0,2,
	0,4,0,1,0,46,255,255,255,255,0,28,0,0,0,0,0,0,
	3,225,0,3,0,3,0,25,0,1,0,47,255,255,255,255,0,21,
	0,64,0,0,0,0,6,178,0,59,0,2,0,4,0,1,0,44,
	255,255,255,255,0,26,0,5,0,0,0,0,4,89,0,48,0,22,
	0,9,0,1,0,45,255,255,255,255,0,26,0,5,0,0,0,0,
	4,94,0,59,0,22,0,9,0,1,0,0,255,255,255,255,0,26,
	0,39,0,0,0,0,4,99,0,70,0,22,0,8,0,1,0,42,
	255,255,255,255,0,21,0,64,0,0,0,0,6,150,0,28,0,3,
	0,4,0,1,0,48,255,255,255,255,0,28,0,0,0,0,0,0,
	4,7,0,35,0,2,0,22,0,1,0,50,255,255,255,255,0,28,
	0,0,0,0,0,0,4,30,0,35,0,3,0,23,0,1,0,36,
	255,255,255,255,0,21,0,64,0,0,0,0,6,234,0,59,0,3,
	0,4,0,1,0,51,255,255,255,255,0,21,0,64,0,0,0,0,
	6,206,0,59,0,4,0,4,0,1,0,49,255,255,255,255,0,28,
	0,0,0,0,0,0,4,60,0,35,0,4,0,24,0,1,255,255,
	0,1,0,33,0,20,0,0,0,0,0,254,17,0,0,0,0,0,
	0,12,0,9,0,2,255,255,255,255,0,28,0,5,0,0,0,0,
	4,104,0,0,0,0,0,3,0,1,0,3,255,255,255,255,0,28,
	0,5,0,0,0,0,4,107,0,3,0,0,0,3,0,1,0,4,
	255,255,255,255,0,28,0,5,0,0,0,0,4,110,0,6,0,0,
	0,3,0,1,0,5,255,255,255,255,0,28,0,5,0,0,0,0,
	4,113,0,9,0,0,0,3,0,1,0,6,255,255,255,255,0,28,
	0,5,0,0,0,0,4,116,0,0,0,1,0,3,0,1,0,7,
	255,255,255,255,0,28,0,5,0,0,0,0,4,119,0,3,0,1,
	0,3,0,1,0,8,255,255,255,255,0,28,0,5,0,0,0,0,
	4,122,0,6,0,1,0,3,0,1,0,9,255,255,255,255,0,28,
	0,5,0,0,0,0,4,125,0,9,0,1,0,3,0,1,0,10,
	255,255,255,255,0,28,0,5,0,0,0,0,4,128,0,0,0,2,
	0,3,0,1,0,11,255,255,255,255,0,28,0,5,0,0,0,0,
	4,131,0,3,0,2,0,3,0,1,0,12,255,255,255,255,0,28,
	0,5,0,0,0,0,4,134,0,6,0,2,0,3,0,1,0,13,
	255,255,255,255,0,28,0,5,0,0,0,0,4,137,0,9,0,2,
	0,3,0,1,0,14,255,255,255,255,0,28,0,5,0,0,0,0,
	4,140,0,0,0,3,0,3,0,1,0,15,255,255,255,255,0,28,
	0,5,0,0,0,0,4,143,0,3,0,3,0,3,0,1,0,16,
	255,255,255,255,0,28,0,5,0,0,0,0,4,146,0,6,0,3,
	0,3,0,1,0,17,255,255,255,255,0,28,0,5,0,0,0,0,
	4,149,0,9,0,3,0,3,0,1,0,18,255,255,255,255,0,28,
	0,5,0,0,0,0,4,152,0,0,0,4,0,3,0,1,0,19,
	255,255,255,255,0,28,0,5,0,0,0,0,4,155,0,3,0,4,
	0,3,0,1,0,20,255,255,255,255,0,28,0,5,0,0,0,0,
	4,158,0,6,0,4,0,3,0,1,0,21,255,255,255,255,0,28,
	0,5,0,0,0,0,4,161,0,9,0,4,0,3,0,1,0,22,
	255,255,255,255,0,28,0,5,0,0,0,0,4,164,0,0,0,5,
	0,3,0,1,0,23,255,255,255,255,0,28,0,5,0,0,0,0,
	4,167,0,3,0,5,0,3,0,1,0,24,255,255,255,255,0,28,
	0,5,0,0,0,0,4,170,0,6,0,5,0,3,0,1,0,25,
	255,255,255,255,0,28,0,5,0,0,0,0,4,173,0,9,0,5,
	0,3,0,1,0,26,255,255,255,255,0,28,0,5,0,0,0,0,
	4,176,0,0,0,6,0,3,0,1,0,27,255,255,255,255,0,28,
	0,5,0,0,0,0,4,179,0,3,0,6,0,3,0,1,0,28,
	255,255,255,255,0,28,0,5,0,0,0,0,4,182,0,6,0,6,
	0,3,0,1,0,29,255,255,255,255,0,28,0,5,0,0,0,0,
	4,185,0,9,0,6,0,3,0,1,0,30,255,255,255,255,0,28,
	0,5,0,0,0,0,4,188,0,0,0,7,0,3,0,1,0,31,
	255,255,255,255,0,28,0,5,0,0,0,0,4,191,0,3,0,7,
	0,3,0,1,0,32,255,255,255,255,0,28,0,5,0,0,0,0,
	4,194,0,6,0,7,0,3,0,1,0,33,255,255,255,255,0,28,
	0,5,0,0,0,0,4,197,0,9,0,7,0,3,0,1,0,0,
	255,255,255,255,0,28,0,37,0,0,0,0,4,200,0,0,0,8,
	0,12,0,1,0,0,15,238,0,0,14,158,0,0,7,78,0,0,
	12,46,0,0,10,102,0,0,20,206,0,0,12,190,0,0,7,6,
	0,0,8,86,0,0,8,182
};
