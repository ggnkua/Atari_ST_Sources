/*

 The Pro MIDI Player
 Copyright 1986-1994 By J.D. Koftinoff Software, Ltd.
 Released under the GPL in 2007
 Please see the file 'COPYING' including in this package.
 
*/
 
/*
 * C version of 'D:\DEV\PERF8\SRC\REC_EXCL.RSC'
 */

unsigned char REC_EXCLRSC[] = {
	0,0,3,186,2,106,2,106,2,106,2,106,0,36,2,106,2,106,
	7,122,0,40,0,3,0,12,0,0,0,0,0,0,0,0,7,134,
	79,75,0,86,69,82,83,73,79,78,58,0,56,46,48,48,32,65,
	0,74,46,68,46,32,75,111,102,116,105,110,111,102,102,32,83,111,
	102,116,119,97,114,101,44,32,76,116,100,46,0,0,40,54,48,52,
	41,32,52,51,48,45,54,56,50,55,32,32,70,97,120,58,32,40,
	54,48,52,41,32,52,52,50,45,51,50,51,51,0,74,46,68,46,
	32,75,111,102,116,105,110,111,102,102,32,83,111,102,116,119,97,114,
	101,44,32,76,116,100,46,0,0,66,111,120,32,52,49,48,51,0,
	86,97,110,99,111,117,118,101,114,44,32,66,67,32,67,97,110,97,
	100,97,0,86,54,66,45,51,90,54,0,67,111,112,121,114,105,103,
	104,116,32,49,57,56,54,45,49,57,57,51,32,98,121,0,0,84,
	72,69,32,80,82,79,32,77,73,68,73,32,80,76,65,89,69,82,
	32,83,89,83,45,69,88,32,82,69,67,79,82,68,69,82,0,0,
	79,75,0,86,69,82,83,73,79,78,58,0,56,46,48,65,0,80,
	114,111,32,77,73,68,73,32,83,121,115,116,101,109,115,32,97,110,
	100,0,0,74,46,68,46,32,75,111,102,116,105,110,111,102,102,32,
	83,111,102,116,119,97,114,101,44,32,76,116,100,46,0,0,67,111,
	112,121,114,105,103,104,116,32,49,57,57,51,32,98,121,0,0,80,
	114,111,32,77,73,68,73,32,83,121,115,116,101,109,115,32,32,32,
	32,32,32,32,32,0,0,49,55,54,32,67,104,114,105,115,116,105,
	101,32,80,97,114,107,32,77,97,110,111,114,0,67,97,108,103,97,
	114,121,44,32,65,108,98,101,114,116,97,44,32,67,97,110,97,100,
	97,0,84,51,72,45,50,80,54,0,80,72,79,78,69,58,0,40,
	52,48,51,41,32,50,52,51,45,48,51,53,56,0,80,114,111,32,
	77,73,68,73,32,83,121,115,116,101,109,115,32,32,32,32,32,32,
	32,32,0,0,66,111,120,32,49,51,0,76,97,117,114,105,101,114,
	44,32,87,65,44,32,85,83,65,0,57,57,49,52,54,0,84,72,
	69,32,80,82,79,32,77,73,68,73,32,80,76,65,89,69,82,32,
	83,89,83,45,69,88,32,82,69,67,79,82,68,69,82,0,0,82,
	69,67,79,82,68,32,83,89,83,84,69,77,32,69,88,67,76,85,
	83,73,86,69,0,0,83,84,65,82,84,0,69,88,73,84,0,84,
	72,73,83,73,83,84,72,69,83,84,65,84,85,83,76,73,78,69,
	84,69,88,84,84,72,73,83,73,83,83,84,65,84,85,83,76,73,
	78,69,84,0,0,0,0,0,0,55,0,0,0,0,0,0,0,85,
	0,3,0,6,0,0,17,128,0,0,0,255,0,30,0,1,0,0,
	0,122,0,0,0,0,0,0,0,152,0,3,0,6,0,0,17,128,
	0,0,0,255,0,30,0,1,0,0,0,191,0,0,0,0,0,0,
	0,214,0,3,0,6,0,0,17,128,0,0,0,255,0,23,0,1,
	0,0,0,215,0,0,0,0,0,0,0,251,0,3,0,6,0,0,
	17,128,0,0,0,255,0,36,0,1,0,0,1,13,0,0,0,0,
	0,0,1,34,0,3,0,6,0,0,17,128,0,0,0,255,0,21,
	0,1,0,0,1,35,0,0,0,0,0,0,1,65,0,3,0,6,
	0,0,17,128,0,0,0,255,0,30,0,1,0,0,1,66,0,0,
	0,0,0,0,1,84,0,3,0,6,0,0,17,128,0,0,0,255,
	0,18,0,1,0,0,1,85,0,0,0,0,0,0,1,110,0,3,
	0,6,0,0,17,128,0,0,0,255,0,25,0,1,0,0,1,190,
	0,0,0,0,0,0,1,215,0,3,0,6,0,0,17,128,0,0,
	0,255,0,25,0,1,0,0,1,246,0,0,0,0,0,0,2,26,
	0,3,0,6,0,0,17,128,0,0,0,255,0,36,0,1,0,0,
	2,27,0,0,0,0,0,0,2,51,0,3,0,6,0,0,17,128,
	0,0,0,255,0,24,0,1,0,0,2,63,0,0,0,0,0,0,
	2,104,0,3,0,6,0,2,49,131,0,0,0,255,0,41,0,1,
	255,255,0,1,0,2,0,20,0,0,0,0,0,2,17,66,0,0,
	0,0,0,56,0,20,0,2,255,255,255,255,0,26,0,7,0,0,
	0,0,0,36,0,2,0,18,0,52,0,1,0,0,0,3,0,13,
	0,20,0,0,0,0,0,2,17,0,0,1,0,1,0,54,0,16,
	0,4,255,255,255,255,0,28,0,0,0,0,0,0,0,39,0,20,
	0,2,0,8,0,1,0,5,255,255,255,255,0,28,0,0,0,0,
	0,0,0,48,0,29,0,2,0,8,0,1,0,6,255,255,255,255,
	0,21,0,0,0,0,0,0,2,106,0,13,0,5,0,29,0,1,
	0,12,0,7,0,11,0,20,0,0,0,0,0,255,33,0,0,1,
	0,7,0,52,0,7,0,8,255,255,255,255,0,28,0,0,0,0,
	0,0,0,86,0,8,0,6,0,35,0,1,0,9,255,255,255,255,
	0,21,0,0,0,0,0,0,2,134,0,12,0,1,0,29,0,1,
	0,10,255,255,255,255,0,28,0,0,0,0,0,0,0,153,0,12,
	0,2,0,22,0,1,0,11,255,255,255,255,0,28,0,0,0,0,
	0,0,0,162,0,12,0,3,0,21,0,1,0,6,255,255,255,255,
	0,28,0,0,0,0,0,0,0,183,0,12,0,4,0,7,0,1,
	0,13,255,255,255,255,0,21,0,0,0,0,0,0,2,162,0,17,
	0,4,0,22,0,1,0,2,255,255,255,255,0,21,0,32,0,0,
	0,0,2,190,0,11,0,1,0,35,0,1,255,255,0,1,0,2,
	0,20,0,0,0,0,0,2,17,66,0,0,0,0,0,56,0,20,
	0,2,255,255,255,255,0,26,0,7,0,0,0,0,0,252,0,2,
	0,18,0,52,0,1,0,0,0,3,0,19,0,20,0,0,0,0,
	0,2,17,0,0,1,0,1,0,54,0,16,0,4,255,255,255,255,
	0,28,0,0,0,0,0,0,0,255,0,20,0,2,0,8,0,1,
	0,5,255,255,255,255,0,28,0,0,0,0,0,0,1,8,0,29,
	0,2,0,8,0,1,0,6,255,255,255,255,0,21,0,0,0,0,
	0,0,2,218,0,2,0,5,0,20,0,1,0,7,255,255,255,255,
	0,21,0,0,0,0,0,0,2,246,0,23,0,5,0,29,0,1,
	0,8,255,255,255,255,0,21,0,0,0,0,0,0,3,18,0,19,
	0,4,0,17,0,1,0,19,0,9,0,18,0,20,0,0,0,0,
	0,255,33,0,0,1,0,7,0,52,0,7,0,10,255,255,255,255,
	0,21,0,0,0,0,0,0,3,46,0,3,0,1,0,18,0,1,
	0,11,255,255,255,255,0,28,0,0,0,0,0,0,1,111,0,3,
	0,2,0,24,0,1,0,12,255,255,255,255,0,28,0,0,0,0,
	0,0,1,135,0,3,0,3,0,24,0,1,0,13,255,255,255,255,
	0,28,0,0,0,0,0,0,1,160,0,3,0,4,0,11,0,1,
	0,14,255,255,255,255,0,28,0,0,0,0,0,0,1,168,0,3,
	0,6,0,6,0,1,0,15,255,255,255,255,0,28,0,0,0,0,
	0,0,1,175,0,9,0,6,0,15,0,1,0,16,255,255,255,255,
	0,21,0,0,0,0,0,0,3,74,0,31,0,1,0,18,0,1,
	0,17,255,255,255,255,0,28,0,0,0,0,0,0,1,216,0,31,
	0,2,0,20,0,1,0,18,255,255,255,255,0,28,0,0,0,0,
	0,0,1,223,0,31,0,3,0,20,0,1,0,8,255,255,255,255,
	0,28,0,0,0,0,0,0,1,240,0,31,0,4,0,18,0,1,
	0,2,255,255,255,255,0,21,0,32,0,0,0,0,3,102,0,9,
	0,1,0,35,0,1,255,255,0,1,0,5,0,20,0,0,0,0,
	0,3,17,0,0,0,0,0,0,44,0,10,0,3,0,2,0,2,
	0,20,0,0,0,0,0,255,17,18,0,2,0,1,0,40,0,3,
	0,1,255,255,255,255,0,21,0,0,0,0,0,0,3,130,0,8,
	0,1,0,23,0,1,0,4,255,255,255,255,0,26,0,5,0,0,
	0,0,2,52,0,2,0,5,0,12,0,2,0,5,255,255,255,255,
	0,26,0,5,0,0,0,0,2,58,0,30,0,5,0,12,0,2,
	0,0,255,255,255,255,0,22,0,32,0,0,0,0,3,158,0,2,
	0,8,0,40,0,1,0,0,3,186,0,0,6,234,0,0,5,10
};
