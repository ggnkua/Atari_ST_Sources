/*

 The Pro MIDI Player
 Copyright 1986-1994 By J.D. Koftinoff Software, Ltd.
 Released under the GPL in 2007
 Please see the file 'COPYING' including in this package.
 
*/
 
#define TX_CTYPE 26
#define TU_U15 15
#define TU_U17 17
#define TU_U16 16
#define TU_U18 18
#define TU_U19 19
#define TU_U21 21
#define TU_U20 20
#define TX_DTYPE 35
#define TX_DCHAN 33
#define TU_U22 22
#define TU_U23 23
#define TU_U25 25
#define TU_U24 24
#define TU_U26 26
#define TU_U27 27
#define TX_THRU 40
#define TU_U29 29
#define TU_U28 28
#define TX_ICHN 46
#define TU_U30 30
#define TX_PEXC 42
#define TU_U31 31
#define TU_NONE 33
#define TU_U32 32
#define TX_PAL 50
#define TR_YN 7
#define TX_LDSS 49
#define TYN_NO 1
#define TX_SAVE 44
#define TX_LOAD 43
#define TYN_YES 2
#define TX_EXIT 45
#define TR_DISP 2
#define TD_D50 3
#define TD_D10 2
#define TD_MT32 4
#define TD_U20 5
#define TD_JD800 9
#define TD_JX8P 6
#define TD_DX7 8
#define TR_JOY 8
#define TJ_OFF 1
#define TJ_ON 3
#define TJ_DP2 2
#define TR_CHAN1 9
#define TR_CHAN 4
#define TC_C1 1
#define TC_C2 2
#define TC_C4 4
#define TC_C3 3
#define TC_C5 5
#define TC_C6 6
#define TC_C8 8
#define TC_C7 7
#define TC_C9 9
#define TC_C10 10
#define TC_C12 12
#define TC_C11 11
#define TC_C13 13
#define TR_CTRL 3
#define TC_C14 14
#define TC_PG1 1
#define TC_C16 16
#define TC_C15 15
#define TC_PG125 2
#define TC_NONE 17
#define TC_PG 4
#define TC_HOLD 3
#define TC_ALL 18
#define TC_PORT 5
#define TR_ABOU1 6
#define TR_ABOUT 1
#define TR_CFG 0
#define TC_DRVA 18
#define TC_DRVE 14
#define TC_DRVC 15
#define TC_DRVG 12
#define TC_DRVI 10
#define TC_DRVM 6
#define TC_DRVK 8
#define TC_DRVO 4
#define TC_DRVB 17
#define TU_U1 1
#define TR_UNIT 5
#define TC_DRVF 13
#define TC_DRVD 16
#define TU_U2 2
#define TC_DRVH 11
#define TU_U3 3
#define TC_DRVJ 9
#define TU_U5 5
#define TU_U4 4
#define TC_DRVN 5
#define TC_DRVL 7
#define TU_U6 6
#define TC_DRVP 3
#define TU_U7 7
#define TU_U9 9
#define TU_U8 8
#define TU_U10 10
#define TU_U11 11
#define TU_U13 13
#define TU_U12 12
#define TX_UJOY 28
#define TX_CCHAN 24
#define TU_U14 14
extern unsigned char CFG_EDITRSC[];
