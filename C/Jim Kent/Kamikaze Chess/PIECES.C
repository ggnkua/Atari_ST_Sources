/* This file has the bit images for all the pieces.  Many thanks to
   Chris Kent who did most of these.  */

unsigned short iwhite_rook[] = {
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x673, 0x9800, 
0x673, 0x9800, 0x673, 0x9800, 0x673, 0x9800, 0x673, 0x9800, 
0x7ff, 0xf800, 0x3ff, 0xf000, 0xff, 0xc000, 0xbf, 0xc000, 
0xbf, 0xc000, 0xf7, 0xc000, 0xf6, 0xc000, 0xbe, 0xc000, 
0xbf, 0xc000, 0xff, 0xc000, 0xff, 0xc000, 0x1ff, 0xe000, 
0x1fff, 0xfe00, 0x3fff, 0xff80, 0x0, 0x0, 
};

unsigned short iwhite_knight[] = {
0x0, 0x0, 0x0, 0x300, 0xf, 0xff00, 0x7f, 0xfe00, 
0x1ff, 0xfc00, 0x7e7, 0xfc00, 0xfff, 0xfc00, 0x1fff, 0xfc00, 
0x3fff, 0xfc00, 0x3fff, 0xf800, 0x3fff, 0xf800, 0x3f0f, 0xf800, 
0x1e0f, 0xf000, 0xf, 0xe000, 0xf, 0xc000, 0x1f, 0xc000, 
0x3f, 0xc000, 0x3f, 0xe000, 0x3f, 0xe000, 0x1ff, 0xf800, 
0x7ff, 0xfe00, 0xfff, 0xff80, 0x0, 0x0, 
};

unsigned short iwhite_bishop[] = {
0x0, 0x0, 0x0, 0x0, 0x1c, 0x0, 0x3e, 0x0, 
0x7e, 0x0, 0xfc, 0x8000, 0xf9, 0x8000, 0xfb, 0x8000, 
0xff, 0x8000, 0x7f, 0x0, 0x7f, 0x0, 0x1c, 0x0, 
0x3e, 0x0, 0x3e, 0x0, 0x3e, 0x0, 0x1c, 0x0, 
0x3e, 0x0, 0x7f, 0x0, 0x7f, 0x0, 0xff, 0x8000, 
0x7ff, 0xf000, 0xfff, 0xf800, 0x0, 0x0, 
};

unsigned short iwhite_queen[] = {
0x0, 0x0, 0x4, 0x0, 0x4, 0x0, 0x4e, 0x4000, 
0x4e, 0x4000, 0x6e, 0xc000, 0x7f, 0xc000, 0x7f, 0xc000, 
0x3f, 0x8000, 0x3f, 0x8000, 0x1f, 0x0, 0x1f, 0x0, 
0xe, 0x0, 0xe, 0x0, 0xe, 0x0, 0xe, 0x0, 
0x1f, 0x0, 0x1f, 0x0, 0x3f, 0x8000, 0xff, 0xe000, 
0x1ff, 0xf000, 0x7ff, 0xfc00, 0x0, 0x0, 
};

unsigned short iwhite_king[] = {
0x0, 0x0, 0xc, 0x0, 0xc, 0x0, 0x3f, 0x0, 
0x3f, 0x0, 0xc, 0x0, 0x1e, 0x0, 0xbf, 0x4000, 
0x7f, 0x8000, 0x3f, 0x0, 0x3f, 0x0, 0x1e, 0x0, 
0xc, 0x0, 0xc, 0x0, 0x1e, 0x0, 0x1e, 0x0, 
0x1e, 0x0, 0x3f, 0x0, 0x3f, 0x0, 0x1ff, 0xe000, 
0x3ff, 0xf000, 0xfff, 0xfc00, 0x0, 0x0, 
};

unsigned short iwhite_pawn[] = {
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 0x1f, 0x0, 0x3f, 0x8000, 
0x3f, 0x8000, 0x3f, 0x8000, 0x3f, 0x8000, 0x1f, 0x0, 
0xe, 0x0, 0x1f, 0x0, 0x1f, 0x0, 0xe, 0x0, 
0x1f, 0x0, 0x3f, 0x8000, 0x7f, 0xc000, 0xff, 0xe000, 
0x3ff, 0xf800, 0x7ff, 0xfc00, 0x0, 0x0, 
};


unsigned short iblack_pawn[] = {
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0xc, 0x0, 
0x1e, 0x0, 0x3f, 0x0, 0x7f, 0x8000, 0x7f, 0x8000, 
0x3f, 0x0, 0x1e, 0x0, 0xc, 0x0, 0x1e, 0x0, 
0x1e, 0x0, 0xc, 0x0, 0xc, 0x0, 0x3ff, 0xf000, 
0xfff, 0xfc00, 0x1fff, 0xfe00, 0x0, 0x0, 
};

unsigned short iblack_rook[] = {
0x0, 0x0, 0x0, 0x0, 0x420, 0x8400, 0x420, 0x8400, 
0x671, 0xcc00, 0x671, 0xcc00, 0x671, 0xcc00, 0x77b, 0xdc00, 
0x7ff, 0xfc00, 0x7ff, 0xfc00, 0x1df, 0xf000, 0x1df, 0xf000, 
0x1ff, 0xf000, 0xfd, 0xe000, 0xfd, 0xe000, 0xff, 0xe000, 
0xdf, 0x6000, 0xdf, 0x6000, 0xff, 0xe000, 0xff, 0xe000, 
0x7ff, 0xfc00, 0x3fff, 0xff80, 0x0, 0x0, 
};

unsigned short iblack_knight[] = {
0x0, 0x0, 0x0, 0x0, 0x0, 0xfc00, 0xf, 0xfe00, 
0x1c, 0xfe00, 0x7b, 0xfe00, 0x1ff, 0xf200, 0x7ff, 0xf100, 
0xfff, 0xb100, 0x1fff, 0xb000, 0x3e7f, 0xa000, 0x7c7f, 0x8000, 
0x707f, 0x8000, 0x3f, 0x8000, 0x3f, 0x0, 0x3f, 0x0, 
0x7f, 0x8000, 0x7f, 0x8000, 0xff, 0xc000, 0xff, 0xe000, 
0x1fff, 0xfe00, 0x3fff, 0xff00, 0x0, 0x0, 
};

unsigned short iblack_bishop[] = {
0x0, 0x0, 0x4, 0x0, 0xc, 0x0, 0x1e, 0x0, 
0x3f, 0x0, 0x7c, 0x0, 0xf1, 0x4000, 0x1f3, 0xe000, 
0x1e3, 0xe000, 0x1e7, 0xe000, 0xf7, 0xc000, 0xbf, 0x4000, 
0x9e, 0x4000, 0x1cc, 0xe000, 0x8c, 0x4000, 0x1e, 0x0, 
0x3f, 0x0, 0x1e, 0x0, 0xc, 0x0, 0x3f, 0x0, 
0xfff, 0xfc00, 0x3fff, 0xff00, 0x0, 0x0, 
};

unsigned short iblack_queen[] = {
0x0, 0x0, 0x4, 0x0, 0x84, 0x2000, 0x8e, 0x2000, 
0x8a, 0x2000, 0xea, 0xe000, 0xfb, 0xe000, 0xdf, 0x6000, 
0xae, 0xa000, 0x35, 0x8000, 0x1f, 0x0, 0x1f, 0x0, 
0xe, 0x0, 0xe, 0x0, 0xe, 0x0, 0xe, 0x0, 
0x1f, 0x0, 0x1f, 0x0, 0x3f, 0x8000, 0xff, 0xe000, 
0x1ff, 0xf000, 0x7ff, 0xfc00, 0x0, 0x0, 
};

unsigned short iblack_king[] = {
0x4, 0x0, 0x4, 0x0, 0x1f, 0x0, 0x304, 0x1800, 
0x184, 0x3000, 0xff, 0xe000, 0xce, 0x6000, 0xce, 0x6000, 
0xce, 0x6000, 0x7b, 0xc000, 0x1f, 0x0, 0x15, 0x0, 
0xe, 0x0, 0xe, 0x0, 0xe, 0x0, 0xe, 0x0, 
0xe, 0x0, 0x1f, 0x0, 0x35, 0x8000, 0x6e, 0xc000, 
0x3ff, 0xf800, 0x1fff, 0xff00, 0x0, 0x0, 
};


