
#define FREE_HAND	0
#define REG_POLY	1
#define CIRCLE		2
#define STAR		3
#define BLOCK		4
