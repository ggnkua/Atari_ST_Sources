
struct cube
    {
    WORD x,X;
    WORD y,Y;
    WORD z,Z;
    };
typedef struct cube Cube;
extern Cube clipping_cube;
extern Cube *size_down_to_safety();


struct square
{
WORD x,X;
WORD y,Y;
};
typedef struct square Square;


