
/* TYPES OF FILES */
#define	PICTURE		0
#define	WINDOW		1
#define	BRUSH		2
#define	COLOR		3
#define	PATTERN		4
#define	SLIDE		5
#define	FONT		6
#define MASK		7

/* TYPES OF COMPRESSION */

#define	UNCOMPRESSED	0	/* no compression, straight binary image */

#define	READ	0
#define	WRITE	1
#define	RW	2

