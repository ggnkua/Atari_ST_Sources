
#define BIG_SHORT	0x7fff
#define BIG_INT		0x7fff
#define BIG_LONG	0x7fffffff
#define SCALE_ONE 	(1<<14)
#define GROUND_Z	512
#define TWO_PI		1024
#define upper_z_limit	(GROUND_Z/10)

extern WORD ground_z;


