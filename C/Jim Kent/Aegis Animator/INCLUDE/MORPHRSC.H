#define MORPHIT 0
#define EDITIT 1

#define GM_MENU 0
#define GM_MAKE 1
#define GM_MOVE 2
#define GM_PICK 3
#define GM_TIME 4
#define GM_COLOR 5

#define GA_MENU 0
#define GA_EDIT 1

