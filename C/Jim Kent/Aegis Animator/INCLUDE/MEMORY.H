

#define MEMORY_POOL 250000

extern long mem_free;


