
extern WORD ccolor;


#define MAXCOL 16 /* the number of colors in color map */
#define MAXCOMP 256 /* the highest value of an r,g,or b component */

#define cycle_color 15

