
#define NEW_GROUND_Z 512
    /* so as initted like original SUN ani ones */
