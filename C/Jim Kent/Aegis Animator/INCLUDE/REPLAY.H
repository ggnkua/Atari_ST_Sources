
#define REPLAY_TWEEN 	0
#define REPLAY_LOOP	1
#define REPLAY_START_END	2

