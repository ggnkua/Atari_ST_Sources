/* flicmenu.c generated by mm version 2 */

#include "flicker.h"
#include "flicmenu.h"


extern inverse_cursor(), black_block(), see_islidepot(), show_sel_mode(), 
	wbtext(), wbnumber(), white_slice(), wbtexty1();

extern  mblur_frame(), medge_frame(), miedge_frame(), mcrystalize(),
	mshatter(), manti_frame(), munrez(), mtile(), toggle_group(),
	mwave(), mwhipe(), mbuzz(), mdissolve(), mswap_undo();

#define PXY		161
#define PXDX	80
#define PXDY	13


struct flicmenu pxsel23 =
	{
	NONEXT,
	NOCHILD,
	1+29*CH_WIDTH, PXY+2*PXDY, 11*CH_WIDTH-2-1, PXDY-2,
	"Buzz",
	wbtext,
	mbuzz,
	NOGROUP, 0,
	'b',
	};
struct flicmenu pxsel22 =
	{
	&pxsel23,
	NOCHILD,
	1+20*CH_WIDTH, PXY+2*PXDY, 9*CH_WIDTH-2, PXDY-2,
	"Ripple",
	wbtext,
	mwave,
	NOGROUP, 0,
	'r',
	};
struct flicmenu pxsel21 =
	{
	&pxsel22,
	NOCHILD,
	1+8*CH_WIDTH, PXY+2*PXDY, 12*CH_WIDTH-2, PXDY-2,
	"Venetian",
	wbtext,
	mdissolve,
	NOGROUP, 0,
	'v',
	};
struct flicmenu pxsel20 =
	{
	&pxsel21,
	NOCHILD,
	1+0*PXDX, PXY+2*PXDY, 8*CH_WIDTH-2, PXDY-2,
	"Wipe",
	wbtext,
	mwhipe,
	NOGROUP, 0,
	'w',
	};
struct flicmenu pxsel13 =
	{
	&pxsel20,
	NOCHILD,
	1+29*CH_WIDTH, PXY+1*PXDY, 11*CH_WIDTH-2-1, PXDY-2,
	"Unrez",
	wbtext,
	munrez,
	NOGROUP, 0,
	'u',
	};
struct flicmenu pxsel12 =
	{
	&pxsel13,
	NOCHILD,
	1+20*CH_WIDTH, PXY+1*PXDY, 9*CH_WIDTH-2, PXDY-2,
	"Tile",
	wbtext,
	mtile,
	NOGROUP, 0,
	't',
	};
struct flicmenu pxsel11 =
	{
	&pxsel12,
	NOCHILD,
	1+8*CH_WIDTH, PXY+1*PXDY, 12*CH_WIDTH-2, PXDY-2,
	"Crystalize",
	wbtext,
	mcrystalize,
	NOGROUP, 0,
	'c',
	};
struct flicmenu pxsel10 =
	{
	&pxsel11,
	NOCHILD,
	1+0*PXDX, PXY+1*PXDY, 8*CH_WIDTH-2, PXDY-2,
	"Shatter",
	wbtext,
	mshatter,
	NOGROUP, 0,
	's',
	};
struct flicmenu pxsel03 =
	{
	&pxsel10,
	NOCHILD,
	1+29*CH_WIDTH, PXY+0*PXDY, 11*CH_WIDTH-2-1, PXDY-2,
	"Edge In",
	wbtext,
	miedge_frame,
	NOGROUP, 0,
	'e',
	};
struct flicmenu pxsel02 =
	{
	&pxsel03,
	NOCHILD,
	1+20*CH_WIDTH, PXY+0*PXDY, 9*CH_WIDTH-2, PXDY-2,
	"Outline",
	wbtext,
	medge_frame,
	NOGROUP, 0,
	'o',
	};
struct flicmenu pxsel01 =
	{
	&pxsel02,
	NOCHILD,
	1+8*CH_WIDTH, PXY+0*CH_WIDTH, 12*CH_WIDTH-2, PXDY-2,
	"Antialias",
	wbtext,
	manti_frame,
	NOGROUP, 0,
	'a',
	};
struct flicmenu pxsel00 =
	{
	&pxsel01,
	NOCHILD,
	1+0*PXDX, PXY+0*PXDY, 8*CH_WIDTH-2, PXDY-2,
	"Defocus",
	wbtext,
	mblur_frame,
	NOGROUP, 0,
	'd',
	};

/*  -------------------------- CUT HERE -------------------------- */

/* START TIME RANGE SELECTOR */
extern struct range trange;
extern pxstuff_tv(), pxdecl_in_trange(), pxincl_in_trange(), pxdecr_in_trange(),
	pxincr_in_trange(), change_trange(), see_trange(), wbnumber1();
extern struct cursor cleft, cright;

#define TSYOFF	149
#define TSDY	10

extern WORD tween_mode;
struct flicmenu pxtween_sel =
	{
	&pxsel00,
	NOCHILD,
	318-11, TSYOFF,	11, TSDY,
	"t",
	wbtext,
	toggle_group,
	&tween_mode, 1,
	't',
	};
struct flicmenu px_undo = 
	{
	&pxtween_sel,
	NOCHILD,
	217+51+1-4+49-9+2-1-64+12+2, TSYOFF,	49, TSDY,
	"Undo",
	wbtexty1,
	mswap_undo,
	NOGROUP, 0,
	0x6100,	/* undo */
	};
struct flicmenu pxinc_tright_sel =
	{
	&px_undo,
	NOCHILD,
	217+51+1-4+49-9+2-1-64, TSYOFF,	12, TSDY,
	(char *)&cright,
	inverse_cursor,
	pxincr_in_trange,
	NOGROUP, 0,
	NOKEY,
	};
struct flicmenu pxtright_time_sel =
	{
	&pxinc_tright_sel,
	NOCHILD,
	217+51+1-4+10+1+2+1-64, TSYOFF,	25, TSDY,
	(char *)&trange.v2,
	wbnumber1,
	pxstuff_tv,
	NOGROUP, 0,
	NOKEY,
	};
struct flicmenu pxdec_tright_sel =
	{
	&pxtright_time_sel,
	NOCHILD,
	217+51+1-4-64, TSYOFF,	12, TSDY,
	(char *)&cleft,
	inverse_cursor,
	pxdecr_in_trange,
	NOGROUP, 0,
	NOKEY,
	};
struct flicmenu pxtsegment_sel = 
	{
	&pxdec_tright_sel,
	NOCHILD,
	56, TSYOFF,	207-64, TSDY,
	(char *)&trange,
	see_trange,
	change_trange,
	NOGROUP, 0,
	NOKEY,
	};
struct flicmenu pxinc_tleft_sel =
	{
	&pxtsegment_sel,
	NOCHILD,
	1+49-9+2-1, TSYOFF,	12, TSDY,
	(char *)&cright,
	inverse_cursor,
	pxincl_in_trange,
	NOGROUP, 0,
	NOKEY,
	};
struct flicmenu pxtleft_time_sel =
	{
	&pxinc_tleft_sel,
	NOCHILD,
	1+10+1+2+1, TSYOFF,	25, TSDY,
	(char *)&trange.v1,
	wbnumber1,
	pxstuff_tv,
	NOGROUP, 0,
	NOKEY,
	};
struct flicmenu pxdec_tleft_sel =
	{
	&pxtleft_time_sel,
	NOCHILD,
	1, TSYOFF,	12, TSDY,
	(char *)&cleft,
	inverse_cursor,
	pxdecl_in_trange,
	NOGROUP, 0,
	NOKEY,
	};
/* END TIME RANGE SELECTOR */


/*  -------------------------- CUT HERE -------------------------- */

#define DOFF	136
#define MMDY	11

extern inverse_cursor(), black_block(), see_islidepot(), show_sel_mode(), 
	wbtext(), wbnumber(), white_slice();

extern struct cursor cdown, cleft, cright, cup, cright2, 
	cleft2, cappend, cinsert, csleft, csright;

extern toggle_sel_mode(), 
	mmsee_slider(), 	mmfeel_slider(),

	pxadd_ten(),
	pxappend(), 			pxinsert(), 
	pxplay_forwards(), 		pxplay_backwards(), 
	pxgo_first(), 			pxgo_last(),
	pxrewind(), 			pxfast_forward(),
	pxnext_frame(), 		pxlast_frame();

extern struct slidepot frame_sl;

/* BIG SPLICE */
struct flicmenu pxselmode_sel =
	{
	&pxdec_tleft_sel,
	NOCHILD,
	281+37-8-3, DOFF,	8+3, MMDY,
	NOTEXT,
	show_sel_mode,
	toggle_sel_mode,
	&select_mode, 1,
	'.',
	};
struct flicmenu pxframes_sel = 
	{
	&pxselmode_sel,
	NOCHILD,
	281-3, DOFF,	37-10, MMDY,
	(char *)&screen_ct,
	wbnumber,
	pxadd_ten,
	NOGROUP, 0,
	'\r',
	};
struct flicmenu pxfa = 
	{
	&pxframes_sel,
	NOCHILD,
	266-2, DOFF,	13-1, MMDY,
	(char *)&cdown,
	inverse_cursor,
	pxgo_last,
	NOGROUP, 0,
	0x4400,	/* F10 */
	};
struct flicmenu pxf9 = 
	{
	&pxfa,
	NOCHILD,
	248-2, DOFF,	16, MMDY,
	(char *)&cright2,
	inverse_cursor,
	pxfast_forward,
	NOGROUP, 0,
	0x4300,	/* F9 */
	};
struct flicmenu pxf8 = 
	{
	&pxf9,
	NOCHILD,
	232-2, DOFF,	14, MMDY,
	(char *)&cright,
	inverse_cursor,
	pxplay_forwards,
	NOGROUP, 0,
	0x4200,	/* F8 */
	};
struct flicmenu px6f8a = 
	{
	&pxf8,
	NOCHILD,
	232-2, DOFF,	14, MMDY,
	NOTEXT,
	NOSEE,
	pxplay_forwards,
	NOGROUP, 0,
	0x5000,	/* down arrow */
	};
struct flicmenu pxf7 = 
	{
	&px6f8a,
	NOCHILD,
	214-2, DOFF,	16, MMDY,
	(char *)&cappend,
	inverse_cursor,
	pxappend,
	NOGROUP, 0,
	0x4100,	/* F7 */
	};
struct flicmenu pxf4 = 
	{
	&pxf7,
	NOCHILD,
	196-2, DOFF,	16, MMDY,
	(char *)&csright,
	inverse_cursor,
	pxnext_frame,
	NOGROUP, 0,
	0x4000,	/* F6 */
	};
struct flicmenu pxsel_f4a = 
	{
	&pxf4,
	NOCHILD,
	196-2, DOFF,	16, MMDY,
	NOTEXT,
	NOSEE,
	pxnext_frame,
	NOGROUP, 0,
	0x4d00,	/* right arrow */
	};
struct flicmenu pxframe_sel = 
	{
	&pxsel_f4a,
	NOCHILD,
	86-1, DOFF,	108-1, MMDY,
	(char *)&frame_sl,
	mmsee_slider,
	mmfeel_slider,
	NOGROUP, 0,
	};
struct flicmenu pxf2 = 
	{
	&pxframe_sel,
	NOCHILD,
	68-1, DOFF,	16, MMDY,
	(char *)&csleft,
	inverse_cursor,
	pxlast_frame,
	NOGROUP, 0,
	0x3f00,	/* F5 */
	};
struct flicmenu pxsel_f2a = 
	{
	&pxf2,
	NOCHILD,
	68-1, DOFF,	16, MMDY,
	NOTEXT,
	NOSEE,
	pxlast_frame,
	NOGROUP, 0,
	0x4b00,	/* left arrow */
	};
struct flicmenu pxf1 = 
	{
	&pxsel_f2a,
	NOCHILD,
	50-1, DOFF,	16, MMDY,
	(char *)&cinsert,
	inverse_cursor,
	pxinsert,
	NOGROUP, 0,
	0x3e00,	/* F4 */
	};
struct flicmenu pxf0 = 
	{
	&pxf1,
	NOCHILD,
	34-1, DOFF,	14, MMDY,
	(char *)&cleft,
	inverse_cursor,
	pxplay_backwards,
	NOGROUP, 0,
	0x3d00,	/* F3 */
	};
struct flicmenu px6f0a = 
	{
	&pxf0,
	NOCHILD,
	34-1, DOFF,	14, MMDY,
	NOTEXT,
	NOSEE,
	pxplay_backwards,
	NOGROUP, 0,
	0x4800,	/* up arrow */
	};
struct flicmenu pxef = 
	{
	&px6f0a,
	NOCHILD,
	16-1, DOFF,	16, MMDY,
	(char *)&cleft2,
	inverse_cursor,
	pxrewind,
	NOGROUP, 0,
	0x3c00,	/* F2 */
	};
struct flicmenu pxee = 
	{
	&pxef,
	NOCHILD,
	1, DOFF,	12, MMDY,
	(char *)&cup,
	inverse_cursor,
	pxgo_first,
	NOGROUP, 0,
	0x3b00,	/* F1 */
	};
/* END SPLICE */
struct flicmenu px_menu = 
	{
	NONEXT,
	&pxee,
	0, DOFF-1,	319, 199-(DOFF-1),
	NOTEXT,
	white_slice,
	NOFEEL,
	NOGROUP, 0,
	};

