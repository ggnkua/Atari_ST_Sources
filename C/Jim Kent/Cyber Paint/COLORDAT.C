/* flicmenu.c generated by mm version 2 */

#include "flicker.h"
#include "flicmenu.h"

#define DOFF	126
#define MMDY	11

extern change_b(), change_color(), change_csegment(), change_g(),
	change_r(), cm_grab_color(), copy_ccolor(), cycle_seg(),
	do_tint(), make_range(), inverse_seg(), see_colors2(),
	see_itext(), see_menu_back(), see_range(), see_slidepot(),
	mmsee_slider(), cmfeel_slider(), inverse_cursor(),
	cplay_forwards(), cplay_backwards(), cgo_first(), 
	cmnext_frame(), cmlast_frame(), restore_colors(), see_number_slider(),
	see_n1_slider(), cm_insert(), cm_append(), ccinsert(), ccappend(),
	show_sel_mode(), toggle_sel_mode(), wbnumber(),
	crewind(), cfast_forward(), cadd_ten(),
	cgo_last(), wbtext(), white_slice(), xhls_mode(),
	jump_cefx(), color_clip(), color_paste(), use_clip_col(),
	inc_rgb(), dec_rgb(), right_arrow(), left_arrow();

#define not_cursor_yet black_block
#define see_block black_block

extern struct cursor cdown, cdrizzle, cflood, cleft,
	cline, cpen, cpolygon, cright, cup, cright2, cleft2,
	cappend, cinsert,
	cseparate, csleft, cspray, csright;

extern color_bars(), not_cursor_yet(), see_block(), see_islidepot();
extern see_itext();

extern struct slidepot frame_sl;

struct flicmenu a8523 = 
	{
	NONEXT,
	NOCHILD,
	306, 187,	12, 11,
	"%",
	wbtext,
	jump_cefx,
	NOGROUP, 0,
	'%',
	};
struct flicmenu a8522 = 
	{
	&a8523,
	NOCHILD,
	245, 187,	59, 11,
	"Range",
	wbtext,
	make_range,
	NOGROUP, 0,
	};
struct flicmenu a8521 = 
	{
	&a8522,
	NOCHILD,
	245, 174,	73, 11,
	"Use Clip",
	wbtext,
	use_clip_col,
	NOGROUP, 0,
	};
struct flicmenu a8520 = 
	{
	&a8521,
	NOCHILD,
	245, 161,	73, 11,
	"Restore",
	wbtext,
	restore_colors,
	NOGROUP, 0,
	};
struct flicmenu a851f = 
	{
	&a8520,
	NOCHILD,
	188, 187,	55, 11,
	"Copy",
	wbtext,
	copy_ccolor,
	NOGROUP, 0,
	};
struct flicmenu a851e = 
	{
	&a851f,
	NOCHILD,
	188, 174,	55, 11,
	"Paste",
	wbtext,
	color_paste,
	NOGROUP, 0,
	};
struct flicmenu a851d = 
	{
	&a851e,
	NOCHILD,
	188, 161,	55, 11,
	"Cut",
	wbtext,
	color_clip,
	NOGROUP, 0,
	};
struct slidepot b_sl =
	{
	0,
	7,
	4,
	};
extern struct flicmenu b_sel;
struct flicmenu b_sel_right =
	{
	&a851d,
	NOCHILD,
	37+14+123, 187,	12, 11,
	(char *)&b_sel,
	right_arrow,
	inc_rgb,
	NOGROUP, 2,
	};
struct flicmenu b_sel = 
	{
	&b_sel_right,
	NOCHILD,
	37+14, 187,	121, 11,
	(char *)&b_sl,
	see_n1_slider,
	change_b,
	NOGROUP, 0,
	};
struct flicmenu b_sel_left =
	{
	&b_sel,
	NOCHILD,
	37, 187,	12, 11,
	(char *)&b_sel,
	left_arrow,
	dec_rgb,
	NOGROUP, 2,
	};
struct slidepot g_sl =
	{
	0,
	7,
	5,
	};
extern struct flicmenu g_sel;
struct flicmenu g_sel_right =
	{
	&b_sel_left,
	NOCHILD,
	37+14+123, 174,	12, 11,
	(char *)&g_sel,
	right_arrow,
	inc_rgb,
	NOGROUP, 1,
	};
struct flicmenu g_sel = 
	{
	&g_sel_right,
	NOCHILD,
	37+14, 174,	121, 11,
	(char *)&g_sl,
	see_n1_slider,
	change_g,
	NOGROUP, 0,
	};
struct flicmenu g_sel_left =
	{
	&g_sel,
	NOCHILD,
	37, 174,	12, 11,
	(char *)&g_sel,
	left_arrow,
	dec_rgb,
	NOGROUP, 1,
	};
struct slidepot r_sl =
	{
	0,
	7,
	2,
	};
extern struct flicmenu r_sel;
struct flicmenu r_sel_right =
	{
	&g_sel_left,
	NOCHILD,
	37+14+123, 161,	12, 11,
	(char *)&r_sel,
	right_arrow,
	inc_rgb,
	NOGROUP, 0,
	};
struct flicmenu r_sel = 
	{
	&r_sel_right,
	NOCHILD,
	37+14, 161,	121, 11,
	(char *)&r_sl,
	see_n1_slider,
	change_r,
	NOGROUP, 0,
	};
struct flicmenu r_sel_left =
	{
	&r_sel,
	NOCHILD,
	37, 161,	12, 11,
	(char *)&r_sel,
	left_arrow,
	dec_rgb,
	NOGROUP, 0,
	};
int hls_mode = 0;
struct flicmenu hls_sel = 
	{
	&r_sel_left,
	NOCHILD,
	1, 181,	34, 17,
	"HLS",
	wbtext,
	xhls_mode,
	&hls_mode, 1,
	};
struct flicmenu rgb_sel = 
	{
	&hls_sel,
	NOCHILD,
	1, 161,	34, 18,
	"RGB",
	wbtext,
	xhls_mode,
	&hls_mode, 0,
	};
struct range csegment =
	{
	0,
	15,
	8,
	14,
	};
struct flicmenu csegment_sel = 
	{
	&rgb_sel,
	NOCHILD,
	1, 151,	317, 8,
	(char *)&csegment,
	see_range,
	change_csegment,
	NOGROUP, 0,
	};
struct grid cb_grid =
	{
	16,
	1,
	};
struct flicmenu cmcbars_sel = 
	{
	&csegment_sel,
	NOCHILD,
	0, 139,	319, 10,
	(char *)&cb_grid,
	see_colors2,
	change_color,
	NOGROUP, 0,
	};
/* BIG SPLICE */
struct flicmenu cselmode_sel = 
	{
	&cmcbars_sel,
	NOCHILD,
	281+37-8-3, DOFF,	8+3, MMDY,
	NOTEXT,
	show_sel_mode,
	toggle_sel_mode,
	&select_mode, 1,
	'.',
	};
struct flicmenu cframes_sel = 
	{
	&cselmode_sel,
	NOCHILD,
	281-3, DOFF,	37-10, MMDY,
	(char *)&screen_ct,
	wbnumber,
	cadd_ten,
	NOGROUP, 0,
	'\r',
	};
struct flicmenu cms_fa = 
	{
	&cframes_sel,
	NOCHILD,
	266-2, DOFF,	13-1, MMDY,
	(char *)&cdown,
	inverse_cursor,
	cgo_last,
	NOGROUP, 0,
	0x4400,	/* F10 */
	};
struct flicmenu cms_f9 = 
	{
	&cms_fa,
	NOCHILD,
	248-2, DOFF,	16, MMDY,
	(char *)&cright2,
	inverse_cursor,
	cfast_forward,
	NOGROUP, 0,
	0x4300,	/* F9 */
	};
struct flicmenu cms_f8 = 
	{
	&cms_f9,
	NOCHILD,
	232-2, DOFF,	14, MMDY,
	(char *)&cright,
	inverse_cursor,
	cplay_forwards,
	NOGROUP, 0,
	0x4200,	/* F8 */
	};
struct flicmenu cc6f8a = 
	{
	&cms_f8,
	NOCHILD,
	232-2, DOFF,	14, MMDY,
	NOTEXT,
	NOSEE,
	cplay_forwards,
	NOGROUP, 0,
	0x5000,	/* down arrow */
	};
struct flicmenu cms_f7 = 
	{
	&cc6f8a,
	NOCHILD,
	214-2, DOFF,	16, MMDY,
	(char *)&cappend,
	inverse_cursor,
	ccappend,
	NOGROUP, 0,
	0x4100,	/* F7 */
	};
struct flicmenu cms_f4 = 
	{
	&cms_f7,
	NOCHILD,
	196-2, DOFF,	16, MMDY,
	(char *)&csright,
	inverse_cursor,
	cmnext_frame,
	NOGROUP, 0,
	0x4000,	/* F6 */
	};
struct flicmenu cc6f4a = 
	{
	&cms_f4,
	NOCHILD,
	196-2, DOFF,	16, MMDY,
	NOTEXT,
	NOSEE,
	cmnext_frame,
	NOGROUP, 0,
	0x4d00,	/* right arrow */
	};
struct flicmenu cframe_sel = 
	{
	&cc6f4a,
	NOCHILD,
	86-1, DOFF,	108-1, MMDY,
	(char *)&frame_sl,
	mmsee_slider,
	cmfeel_slider,
	NOGROUP, 0,
	};
struct flicmenu cms_f2 = 
	{
	&cframe_sel,
	NOCHILD,
	68-1, DOFF,	16, MMDY,
	(char *)&csleft,
	inverse_cursor,
	cmlast_frame,
	NOGROUP, 0,
	0x3f00,	/* F5 */
	};
struct flicmenu cc6f2a = 
	{
	&cms_f2,
	NOCHILD,
	68-1, DOFF,	16, MMDY,
	NOTEXT,
	NOSEE,
	cmlast_frame,
	NOGROUP, 0,
	0x4b00,	/* left arrow */
	};
struct flicmenu cms_f1 = 
	{
	&cc6f2a,
	NOCHILD,
	50-1, DOFF,	16, MMDY,
	(char *)&cinsert,
	inverse_cursor,
	ccinsert,
	NOGROUP, 0,
	0x3e00,	/* F4 */
	};
struct flicmenu cms_f0 = 
	{
	&cms_f1,
	NOCHILD,
	34-1, DOFF,	14, MMDY,
	(char *)&cleft,
	inverse_cursor,
	cplay_backwards,
	NOGROUP, 0,
	0x3d00,	/* F3 */
	};
struct flicmenu cc6f0a = 
	{
	&cms_f0,
	NOCHILD,
	34-1, DOFF,	14, MMDY,
	NOTEXT,
	NOSEE,
	cplay_backwards,
	NOGROUP, 0,
	0x4800,	/* up arrow */
	};
struct flicmenu cms_ef = 
	{
	&cc6f0a,
	NOCHILD,
	16-1, DOFF,	16, MMDY,
	(char *)&cleft2,
	inverse_cursor,
	crewind,
	NOGROUP, 0,
	0x3c00,	/* F2 */
	};
struct flicmenu cms_ee = 
	{
	&cms_ef,
	NOCHILD,
	1, DOFF,	12, MMDY,
	(char *)&cup,
	inverse_cursor,
	cgo_first,
	NOGROUP, 0,
	0x3b00,	/* F1 */
	};
/* END SPLICE */
struct flicmenu rcolor_menu = 
	{
	NONEXT,
	&cms_ee,
	0, 199-74,	319, 74,
	NOTEXT,
	white_slice,
	NOFEEL,
	NOGROUP, 0,
	};

struct flicmenu color_menu =
	{
	NONEXT,
	&rcolor_menu,
	0, 0, 319, 199,
	NOTEXT,
	NOSEE,
	cm_grab_color,
	NOGROUP, 0,
	};

