	;	lookup table to speed conversion from byte-a-pixel to
	;	ST word-interleaved bitmap screen
	dseg
	public _iconvtab
_iconvtab
	dc.w	$0,$0,$0,$0
	dc.w	$8000,$0,$0,$0
	dc.w	$0,$8000,$0,$0
	dc.w	$8000,$8000,$0,$0
	dc.w	$0,$0,$8000,$0
	dc.w	$8000,$0,$8000,$0
	dc.w	$0,$8000,$8000,$0
	dc.w	$8000,$8000,$8000,$0
	dc.w	$0,$0,$0,$8000
	dc.w	$8000,$0,$0,$8000
	dc.w	$0,$8000,$0,$8000
	dc.w	$8000,$8000,$0,$8000
	dc.w	$0,$0,$8000,$8000
	dc.w	$8000,$0,$8000,$8000
	dc.w	$0,$8000,$8000,$8000
	dc.w	$8000,$8000,$8000,$8000

	dc.w	$0,$0,$0,$0
	dc.w	$4000,$0,$0,$0
	dc.w	$0,$4000,$0,$0
	dc.w	$4000,$4000,$0,$0
	dc.w	$0,$0,$4000,$0
	dc.w	$4000,$0,$4000,$0
	dc.w	$0,$4000,$4000,$0
	dc.w	$4000,$4000,$4000,$0
	dc.w	$0,$0,$0,$4000
	dc.w	$4000,$0,$0,$4000
	dc.w	$0,$4000,$0,$4000
	dc.w	$4000,$4000,$0,$4000
	dc.w	$0,$0,$4000,$4000
	dc.w	$4000,$0,$4000,$4000
	dc.w	$0,$4000,$4000,$4000
	dc.w	$4000,$4000,$4000,$4000

	dc.w	$0,$0,$0,$0
	dc.w	$2000,$0,$0,$0
	dc.w	$0,$2000,$0,$0
	dc.w	$2000,$2000,$0,$0
	dc.w	$0,$0,$2000,$0
	dc.w	$2000,$0,$2000,$0
	dc.w	$0,$2000,$2000,$0
	dc.w	$2000,$2000,$2000,$0
	dc.w	$0,$0,$0,$2000
	dc.w	$2000,$0,$0,$2000
	dc.w	$0,$2000,$0,$2000
	dc.w	$2000,$2000,$0,$2000
	dc.w	$0,$0,$2000,$2000
	dc.w	$2000,$0,$2000,$2000
	dc.w	$0,$2000,$2000,$2000
	dc.w	$2000,$2000,$2000,$2000

	dc.w	$0,$0,$0,$0
	dc.w	$1000,$0,$0,$0
	dc.w	$0,$1000,$0,$0
	dc.w	$1000,$1000,$0,$0
	dc.w	$0,$0,$1000,$0
	dc.w	$1000,$0,$1000,$0
	dc.w	$0,$1000,$1000,$0
	dc.w	$1000,$1000,$1000,$0
	dc.w	$0,$0,$0,$1000
	dc.w	$1000,$0,$0,$1000
	dc.w	$0,$1000,$0,$1000
	dc.w	$1000,$1000,$0,$1000
	dc.w	$0,$0,$1000,$1000
	dc.w	$1000,$0,$1000,$1000
	dc.w	$0,$1000,$1000,$1000
	dc.w	$1000,$1000,$1000,$1000

	dc.w	$0,$0,$0,$0
	dc.w	$800,$0,$0,$0
	dc.w	$0,$800,$0,$0
	dc.w	$800,$800,$0,$0
	dc.w	$0,$0,$800,$0
	dc.w	$800,$0,$800,$0
	dc.w	$0,$800,$800,$0
	dc.w	$800,$800,$800,$0
	dc.w	$0,$0,$0,$800
	dc.w	$800,$0,$0,$800
	dc.w	$0,$800,$0,$800
	dc.w	$800,$800,$0,$800
	dc.w	$0,$0,$800,$800
	dc.w	$800,$0,$800,$800
	dc.w	$0,$800,$800,$800
	dc.w	$800,$800,$800,$800

	dc.w	$0,$0,$0,$0
	dc.w	$400,$0,$0,$0
	dc.w	$0,$400,$0,$0
	dc.w	$400,$400,$0,$0
	dc.w	$0,$0,$400,$0
	dc.w	$400,$0,$400,$0
	dc.w	$0,$400,$400,$0
	dc.w	$400,$400,$400,$0
	dc.w	$0,$0,$0,$400
	dc.w	$400,$0,$0,$400
	dc.w	$0,$400,$0,$400
	dc.w	$400,$400,$0,$400
	dc.w	$0,$0,$400,$400
	dc.w	$400,$0,$400,$400
	dc.w	$0,$400,$400,$400
	dc.w	$400,$400,$400,$400

	dc.w	$0,$0,$0,$0
	dc.w	$200,$0,$0,$0
	dc.w	$0,$200,$0,$0
	dc.w	$200,$200,$0,$0
	dc.w	$0,$0,$200,$0
	dc.w	$200,$0,$200,$0
	dc.w	$0,$200,$200,$0
	dc.w	$200,$200,$200,$0
	dc.w	$0,$0,$0,$200
	dc.w	$200,$0,$0,$200
	dc.w	$0,$200,$0,$200
	dc.w	$200,$200,$0,$200
	dc.w	$0,$0,$200,$200
	dc.w	$200,$0,$200,$200
	dc.w	$0,$200,$200,$200
	dc.w	$200,$200,$200,$200

	dc.w	$0,$0,$0,$0
	dc.w	$100,$0,$0,$0
	dc.w	$0,$100,$0,$0
	dc.w	$100,$100,$0,$0
	dc.w	$0,$0,$100,$0
	dc.w	$100,$0,$100,$0
	dc.w	$0,$100,$100,$0
	dc.w	$100,$100,$100,$0
	dc.w	$0,$0,$0,$100
	dc.w	$100,$0,$0,$100
	dc.w	$0,$100,$0,$100
	dc.w	$100,$100,$0,$100
	dc.w	$0,$0,$100,$100
	dc.w	$100,$0,$100,$100
	dc.w	$0,$100,$100,$100
	dc.w	$100,$100,$100,$100

	dc.w	$0,$0,$0,$0
	dc.w	$80,$0,$0,$0
	dc.w	$0,$80,$0,$0
	dc.w	$80,$80,$0,$0
	dc.w	$0,$0,$80,$0
	dc.w	$80,$0,$80,$0
	dc.w	$0,$80,$80,$0
	dc.w	$80,$80,$80,$0
	dc.w	$0,$0,$0,$80
	dc.w	$80,$0,$0,$80
	dc.w	$0,$80,$0,$80
	dc.w	$80,$80,$0,$80
	dc.w	$0,$0,$80,$80
	dc.w	$80,$0,$80,$80
	dc.w	$0,$80,$80,$80
	dc.w	$80,$80,$80,$80

	dc.w	$0,$0,$0,$0
	dc.w	$40,$0,$0,$0
	dc.w	$0,$40,$0,$0
	dc.w	$40,$40,$0,$0
	dc.w	$0,$0,$40,$0
	dc.w	$40,$0,$40,$0
	dc.w	$0,$40,$40,$0
	dc.w	$40,$40,$40,$0
	dc.w	$0,$0,$0,$40
	dc.w	$40,$0,$0,$40
	dc.w	$0,$40,$0,$40
	dc.w	$40,$40,$0,$40
	dc.w	$0,$0,$40,$40
	dc.w	$40,$0,$40,$40
	dc.w	$0,$40,$40,$40
	dc.w	$40,$40,$40,$40

	dc.w	$0,$0,$0,$0
	dc.w	$20,$0,$0,$0
	dc.w	$0,$20,$0,$0
	dc.w	$20,$20,$0,$0
	dc.w	$0,$0,$20,$0
	dc.w	$20,$0,$20,$0
	dc.w	$0,$20,$20,$0
	dc.w	$20,$20,$20,$0
	dc.w	$0,$0,$0,$20
	dc.w	$20,$0,$0,$20
	dc.w	$0,$20,$0,$20
	dc.w	$20,$20,$0,$20
	dc.w	$0,$0,$20,$20
	dc.w	$20,$0,$20,$20
	dc.w	$0,$20,$20,$20
	dc.w	$20,$20,$20,$20

	dc.w	$0,$0,$0,$0
	dc.w	$10,$0,$0,$0
	dc.w	$0,$10,$0,$0
	dc.w	$10,$10,$0,$0
	dc.w	$0,$0,$10,$0
	dc.w	$10,$0,$10,$0
	dc.w	$0,$10,$10,$0
	dc.w	$10,$10,$10,$0
	dc.w	$0,$0,$0,$10
	dc.w	$10,$0,$0,$10
	dc.w	$0,$10,$0,$10
	dc.w	$10,$10,$0,$10
	dc.w	$0,$0,$10,$10
	dc.w	$10,$0,$10,$10
	dc.w	$0,$10,$10,$10
	dc.w	$10,$10,$10,$10

	dc.w	$0,$0,$0,$0
	dc.w	$8,$0,$0,$0
	dc.w	$0,$8,$0,$0
	dc.w	$8,$8,$0,$0
	dc.w	$0,$0,$8,$0
	dc.w	$8,$0,$8,$0
	dc.w	$0,$8,$8,$0
	dc.w	$8,$8,$8,$0
	dc.w	$0,$0,$0,$8
	dc.w	$8,$0,$0,$8
	dc.w	$0,$8,$0,$8
	dc.w	$8,$8,$0,$8
	dc.w	$0,$0,$8,$8
	dc.w	$8,$0,$8,$8
	dc.w	$0,$8,$8,$8
	dc.w	$8,$8,$8,$8

	dc.w	$0,$0,$0,$0
	dc.w	$4,$0,$0,$0
	dc.w	$0,$4,$0,$0
	dc.w	$4,$4,$0,$0
	dc.w	$0,$0,$4,$0
	dc.w	$4,$0,$4,$0
	dc.w	$0,$4,$4,$0
	dc.w	$4,$4,$4,$0
	dc.w	$0,$0,$0,$4
	dc.w	$4,$0,$0,$4
	dc.w	$0,$4,$0,$4
	dc.w	$4,$4,$0,$4
	dc.w	$0,$0,$4,$4
	dc.w	$4,$0,$4,$4
	dc.w	$0,$4,$4,$4
	dc.w	$4,$4,$4,$4

	dc.w	$0,$0,$0,$0
	dc.w	$2,$0,$0,$0
	dc.w	$0,$2,$0,$0
	dc.w	$2,$2,$0,$0
	dc.w	$0,$0,$2,$0
	dc.w	$2,$0,$2,$0
	dc.w	$0,$2,$2,$0
	dc.w	$2,$2,$2,$0
	dc.w	$0,$0,$0,$2
	dc.w	$2,$0,$0,$2
	dc.w	$0,$2,$0,$2
	dc.w	$2,$2,$0,$2
	dc.w	$0,$0,$2,$2
	dc.w	$2,$0,$2,$2
	dc.w	$0,$2,$2,$2
	dc.w	$2,$2,$2,$2

	dc.w	$0,$0,$0,$0
	dc.w	$1,$0,$0,$0
	dc.w	$0,$1,$0,$0
	dc.w	$1,$1,$0,$0
	dc.w	$0,$0,$1,$0
	dc.w	$1,$0,$1,$0
	dc.w	$0,$1,$1,$0
	dc.w	$1,$1,$1,$0
	dc.w	$0,$0,$0,$1
	dc.w	$1,$0,$0,$1
	dc.w	$0,$1,$0,$1
	dc.w	$1,$1,$0,$1
	dc.w	$0,$0,$1,$1
	dc.w	$1,$0,$1,$1
	dc.w	$0,$1,$1,$1
	dc.w	$1,$1,$1,$1

