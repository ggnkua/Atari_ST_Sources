/* flicmenu.c generated by mm version 2 */

#include "flicker.h"
#include "flicmenu.h"


extern not_cursor_yet(), see_islidepot();
extern inverse_cursor(), black_block(), see_islidepot(),
	tmnext_frame(), tmlast_frame(),
	mmsee_slider(), mmfeel_slider(),
	tplay_forwards(), tplay_backwards(), tgo_first(), tgo_last(),
	time_mode(), trewind(), tfast_forward(),
	do_save(), do_load(), do_kill(),
	new_file_type(), patch(), flash_red(),
	splay_forwards(), splay_backwards(), srewind(), sfast_forward(),
	sgo_first(), sgo_last(), change_mode(),
	smnext_frame(), smlast_frame(), sappend(), sinsert(),
	show_sel_mode(), toggle_sel_mode(),
	wbtextx2(), change_dev(), sadd_10(),
	wbtext(), wbnumber(), white_slice();

extern struct cursor cdown, cleft, cright, csleft,
	cinsert, cappend, cright2, cleft2, csright, cup;

extern struct slidepot frame_sl;

extern WORD current_drive, got_patch;

WORD save_file_type = SEQ;
WORD normal_over_under;

#define SYO (-4)
#define DEVY 191
#define DEVDY 11
#define DEVDX 16
#define DEVX1 (56) 

struct flicmenu apatch_sel =
	{
	NONEXT,
	NOCHILD,
	11*(DEVDX+2)+DEVX1, SYO+DEVY,	64, DEVDY,
	"Patch",
	wbtext,
	patch,
	&got_patch, 1,
	};
struct flicmenu ad010 =
	{
	&apatch_sel,
	NOCHILD,
	10*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"K:",
	wbtextx2,
	change_dev,
	&current_drive, 10,
	};
struct flicmenu ad009 =
	{
	&ad010,
	NOCHILD,
	9*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"J:",
	wbtextx2,
	change_dev,
	&current_drive, 9,
	'j',
	};
struct flicmenu ad008 =
	{
	&ad009,
	NOCHILD,
	8*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"I:",
	wbtextx2,
	change_dev,
	&current_drive, 8,
	'i',
	};
struct flicmenu ad007 =
	{
	&ad008,
	NOCHILD,
	7*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"H:",
	wbtextx2,
	change_dev,
	&current_drive, 7,
	'h',
	};
struct flicmenu ad006 =
	{
	&ad007,
	NOCHILD,
	6*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"G:",
	wbtextx2,
	change_dev,
	&current_drive, 6,
	'g',
	};
struct flicmenu ad005 =
	{
	&ad006,
	NOCHILD,
	5*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"F:",
	wbtextx2,
	change_dev,
	&current_drive, 5,
	'f',
	};
struct flicmenu ad004 =
	{
	&ad005,
	NOCHILD,
	4*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"E:",
	wbtextx2,
	change_dev,
	&current_drive, 4,
	'e',
	};
struct flicmenu ad003 =
	{
	&ad004,
	NOCHILD,
	3*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"D:",
	wbtextx2,
	change_dev,
	&current_drive, 3,
	'd',
	};
struct flicmenu ad002 =
	{
	&ad003,
	NOCHILD,
	2*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"C:",
	wbtextx2,
	change_dev,
	&current_drive, 2,
	'c',
	};
struct flicmenu ad001 =
	{
	&ad002,
	NOCHILD,
	1*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"B:",
	wbtextx2,
	change_dev,
	&current_drive, 1,
	'b',
	};
struct flicmenu ad000 =
	{
	&ad001,
	NOCHILD,
	0*(DEVDX+2)+DEVX1, SYO+DEVY,	DEVDX, DEVDY,
	"A:",
	wbtextx2,
	change_dev,
	&current_drive, 0,
	'a',
	};

#define NOUY 179
struct flicmenu ac747 = 
	{
	&ad000,
	NOCHILD,
	56+87*2+1-50+69, SYO+NOUY,	68, 10,
	"Splice",
	wbtext,
	change_mode,
	&normal_over_under, 3,
	};
struct flicmenu ac746 = 
	{
	&ac747,
	NOCHILD,
	56+87*2+1-50, SYO+NOUY,	67, 10,
	"Under",
	wbtext,
	change_mode,
	&normal_over_under, 2,
	};
struct flicmenu ac745 = 
	{
	&ac746,
	NOCHILD,
	56+87*1-20, SYO+NOUY,	56, 10,
	"Over",
	wbtext,
	change_mode,
	&normal_over_under, 1,
	};
struct flicmenu ac744 = 
	{
	&ac745,
	NOCHILD,
	56, SYO+NOUY,	65, 10,
	"Normal",
	wbtext,
	change_mode,
	&normal_over_under, 0,
	};
#define TYDY 10
#define TYY2 167
struct flicmenu ac743 = 
	{
	&ac744,
	NOCHILD,
	268, SYO+TYY2,	50, TYDY,
	".ADO",
	wbtext,
	new_file_type,
	&save_file_type, 9,
	'0',
	};
struct flicmenu ac742 = 
	{
	&ac743,
	NOCHILD,
	215, SYO+TYY2,	51, TYDY,
	".BL?",
	wbtext,
	new_file_type,
	&save_file_type, 8,
	'9',
	};
struct flicmenu ac741 = 
	{
	&ac742,
	NOCHILD,
	162, SYO+TYY2,	51, TYDY,
	".PC1",
	wbtext,
	new_file_type,
	&save_file_type, 7,
	'8',
	};
struct flicmenu ac740 = 
	{
	&ac741,
	NOCHILD,
	109, SYO+TYY2,	51, TYDY,
	".PI1",
	wbtext,
	new_file_type,
	&save_file_type, 6,
	'7',
	};
struct flicmenu ac73b = 
	{
	&ac740,
	NOCHILD,
	56, SYO+TYY2,	51, TYDY,
	".DLT",
	wbtext,
	new_file_type,
	&save_file_type, 5,
	'6',
	};
#define TYY1 155
struct flicmenu ac73f = 
	{
	&ac73b,
	NOCHILD,
	268, SYO+TYY1,	50, TYDY,
	".STR",
	wbtext,
	new_file_type,
	&save_file_type, 4,
	'5',
	};
struct flicmenu ac73e = 
	{
	&ac73f,
	NOCHILD,
	215, SYO+TYY1,	51, TYDY,
	".CEL",
	wbtext,
	new_file_type,
	&save_file_type, 2,
	'4',
	};
struct flicmenu ac73d = 
	{
	&ac73e,
	NOCHILD,
	162, SYO+TYY1,	51, TYDY,
	".COL",
	wbtext,
	new_file_type,
	&save_file_type, 3,
	'3',
	};
struct flicmenu ac73c = 
	{
	&ac73d,
	NOCHILD,
	109, SYO+TYY1,	51, TYDY,
	".NEO",
	wbtext,
	new_file_type,
	&save_file_type, 1,
	'2',
	};
struct flicmenu ac73a = 
	{
	&ac73c,
	NOCHILD,
	56, SYO+TYY1,	51, TYDY,
	".SEQ",
	wbtext,
	new_file_type,
	&save_file_type, 0,
	'1',
	};
struct flicmenu ac739 = 
	{
	&ac73a,
	NOCHILD,
	1, SYO+184+3,	53, 15,
	"Kill",
	wbtext,
	do_kill,
	NOGROUP, 0,
	'k',
	};
struct flicmenu ac738 = 
	{
	&ac739,
	NOCHILD,
	1, SYO+169+2,	53, 14,
	"Save",
	wbtext,
	do_save,
	NOGROUP, 0,
	's',
	};
struct flicmenu ac737 = 
	{
	&ac738,
	NOCHILD,
	1, SYO+154+1,	53, 14,
	"Load",
	wbtext,
	do_load,
	NOGROUP, 0,
	'l',
	};
struct flicmenu sselmode_sel = 
	{
	&ac737,
	NOCHILD,
	281+37-8-3, SYO+139+1,	8+3, 13,
	NOTEXT,
	show_sel_mode,
	toggle_sel_mode,
	&select_mode, 1,
	'.',
	};
struct flicmenu sframes_sel = 
	{
	&sselmode_sel,
	NOCHILD,
	278, SYO+140,	27, 13,
	(char *)&screen_ct,
	wbnumber,
	sadd_10,
	NOGROUP, 0,
	'\r',
	};
struct flicmenu ac6fa = 
	{
	&sframes_sel,
	NOCHILD,
	265-1, SYO+139+1,	12, 13,
	(char *)&cdown,
	inverse_cursor,
	sgo_last,
	NOGROUP, 0,
	0x4400,	/* F10 */
	};
struct flicmenu ac6f9 = 
	{
	&ac6fa,
	NOCHILD,
	247-1, SYO+139+1,	16, 13,
	(char *)&cright2,
	inverse_cursor,
	sfast_forward,
	NOGROUP, 0,
	0x4300,	/* F9 */
	};
struct flicmenu ac6f8 = 
	{
	&ac6f9,
	NOCHILD,
	231-1, SYO+139+1,	14, 13,
	(char *)&cright,
	inverse_cursor,
	splay_forwards,
	NOGROUP, 0,
	0x4200,	/* F8 */
	};
struct flicmenu ac6f8a = 
	{
	&ac6f8,
	NOCHILD,
	231-1, SYO+139+1,	14, 13,
	NOTEXT,
	NOSEE,
	splay_forwards,
	NOGROUP, 0,
	0x5000,	/* down arrow */
	};
struct flicmenu ac6f7 = 
	{
	&ac6f8a,
	NOCHILD,
	213-1, SYO+139+1,	16, 13,
	(char *)&cappend,
	inverse_cursor,
	sappend,
	NOGROUP, 0,
	0x4100,	/* F7 */
	};
struct flicmenu ac6f4 = 
	{
	&ac6f7,
	NOCHILD,
	195-1, SYO+139+1,	16, 13,
	(char *)&csright,
	inverse_cursor,
	smnext_frame,
	NOGROUP, 0,
	0x4000,	/* F6 */
	};
struct flicmenu ac6f4a = 
	{
	&ac6f4,
	NOCHILD,
	195-1, SYO+139+1,	16, 13,
	NOTEXT,
	NOSEE,
	smnext_frame,
	NOGROUP, 0,
	0x4d00,	/* right arrow */
	};
struct flicmenu sframe_sel = 
	{
	&ac6f4a,
	NOCHILD,
	85-1, SYO+139+1,	108, 13,
	(char *)&frame_sl,
	mmsee_slider,
	mmfeel_slider,
	NOGROUP, 0,
	};
struct flicmenu ac6f2 = 
	{
	&sframe_sel,
	NOCHILD,
	67-1, SYO+139+1,	16, 13,
	(char *)&csleft,
	inverse_cursor,
	smlast_frame,
	NOGROUP, 0,
	0x3f00,	/* F5 */
	};
struct flicmenu ac6f2a = 
	{
	&ac6f2,
	NOCHILD,
	67-1, SYO+139+1,	16, 13,
	NOTEXT,
	NOSEE,
	smlast_frame,
	NOGROUP, 0,
	0x4b00,	/* left arrow */
	};
struct flicmenu ac6f1 = 
	{
	&ac6f2a,
	NOCHILD,
	49-1, SYO+139+1,	16, 13,
	(char *)&cinsert,
	inverse_cursor,
	sinsert,
	NOGROUP, 0,
	0x3e00,	/* F4 */
	};
struct flicmenu ac6f0 = 
	{
	&ac6f1,
	NOCHILD,
	33-1, SYO+139+1,	14, 13,
	(char *)&cleft,
	inverse_cursor,
	splay_backwards,
	NOGROUP, 0,
	0x3d00,	/* F3 */
	};
struct flicmenu ac6f0a = 
	{
	&ac6f0,
	NOCHILD,
	33-1, SYO+139+1,	14, 13,
	NOTEXT,
	NOSEE,
	splay_backwards,
	NOGROUP, 0,
	0x4800,	/* up arrow */
	};
struct flicmenu ac6ef = 
	{
	&ac6f0a,
	NOCHILD,
	15, SYO+139+1,	15, 13,
	(char *)&cleft2,
	inverse_cursor,
	srewind,
	NOGROUP, 0,
	0x3c00,	/* F2 */
	};
struct flicmenu ac6ee = 
	{
	&ac6ef,
	NOCHILD,
	1, SYO+139+1,	12, 13,
	(char *)&cup,
	inverse_cursor,
	sgo_first,
	NOGROUP, 0,
	0x3b00,	/* F1 */
	};
struct flicmenu menu_save = 
	{
	NONEXT,
	&ac6ee,
	0, SYO+139,	319, 64,
	NOTEXT,
	white_slice,
	NOFEEL,
	NOGROUP, 0,
	};
