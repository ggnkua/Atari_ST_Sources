/* resource set indicies for PAGEFLIP */

#define FORM1    0	/* form/dialog */
#define FSEQ     4	/* BOXTEXT in tree FORM1 */
#define B1       5	/* BOXTEXT in tree FORM1 */
#define B2       6	/* BOXTEXT in tree FORM1 */
#define B3       7	/* BOXTEXT in tree FORM1 */
#define B4       8	/* BOXTEXT in tree FORM1 */
#define B5       9	/* BOXTEXT in tree FORM1 */
#define B6       10	/* BOXTEXT in tree FORM1 */
#define B7       11	/* BOXTEXT in tree FORM1 */
#define B8       12	/* BOXTEXT in tree FORM1 */
#define BCLEAR   13	/* BUTTON in tree FORM1 */
#define BBKSPACE 14	/* BUTTON in tree FORM1 */
#define SPEEDDN  15	/* BOXTEXT in tree FORM1 */
#define TRACK0   16	/* BOXTEXT in tree FORM1 */
#define BSPEED   17	/* BOXTEXT in tree FORM1 */
#define SPEEDUP  18	/* BOXTEXT in tree FORM1 */
#define BPERFORM 19	/* BUTTON in tree FORM1 */
#define BEXIT    20	/* BUTTON in tree FORM1 */

