/* resource set indicies for OPERATOR */

#define FORM1    0	/* form/dialog */
#define SRCDN    7	/* BUTTON in tree FORM1 */
#define SRCNUM   8	/* BOXTEXT in tree FORM1 */
#define SRCUP    9	/* BUTTON in tree FORM1 */
#define MASKDN   10	/* BUTTON in tree FORM1 */
#define MASKNUM  11	/* BOXTEXT in tree FORM1 */
#define MASKUP   12	/* BUTTON in tree FORM1 */
#define DESTDN   13	/* BUTTON in tree FORM1 */
#define DESTNUM  14	/* BOXTEXT in tree FORM1 */
#define DESTUP   15	/* BUTTON in tree FORM1 */
#define BNOTSRC  17	/* BOXTEXT in tree FORM1 */
#define BAND     19	/* BOXTEXT in tree FORM1 */
#define BOR      20	/* BOXTEXT in tree FORM1 */
#define BEOR     21	/* BOXTEXT in tree FORM1 */
#define BWMASK   22	/* BOXTEXT in tree FORM1 */
#define BNOTDEST 23	/* BOXTEXT in tree FORM1 */
#define BEXIT    25	/* BUTTON in tree FORM1 */
#define BVIEW    26	/* BOXTEXT in tree FORM1 */
#define BPERFORM 27	/* BUTTON in tree FORM1 */

