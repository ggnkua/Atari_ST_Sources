/* Indice du ressource pour ICONS */

#define ICONS    0   /* Formulaire/Dialogue */
