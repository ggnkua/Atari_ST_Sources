/* Indice du ressource pour TEST */

#define ME       0   /* Arbre menu */
#define ABTXAES  10  /* STRING dans l'arbre ME */
#define QUITXAES 19  /* STRING dans l'arbre ME */
#define WIN1XAES 21  /* STRING dans l'arbre ME */
#define WIN2XAES 22  /* STRING dans l'arbre ME */
#define WIN3XAES 24  /* STRING dans l'arbre ME */
#define WIN4XAES 25  /* STRING dans l'arbre ME */
#define WIN5XAES 26  /* STRING dans l'arbre ME */
#define WIN6XAES 27  /* STRING dans l'arbre ME */
#define WIN7XAES 28  /* STRING dans l'arbre ME */
#define WIN8XAES 29  /* STRING dans l'arbre ME */
#define SIZEXAES 31  /* STRING dans l'arbre ME */
#define BKGNXAES 32  /* STRING dans l'arbre ME */
#define LWINXAES 34  /* STRING dans l'arbre ME */
#define SWINXAES 35  /* STRING dans l'arbre ME */
#define CUSTXAES 37  /* STRING dans l'arbre ME */
#define VDESKTOP 39  /* STRING dans l'arbre ME */
#define NAMESET  41  /* STRING dans l'arbre ME */
#define CLOSSET  42  /* STRING dans l'arbre ME */
#define FULLSET  43  /* STRING dans l'arbre ME */
#define MOVESET  44  /* STRING dans l'arbre ME */
#define INFOSET  45  /* STRING dans l'arbre ME */
#define SIZESET  46  /* STRING dans l'arbre ME */
#define UPARSET  47  /* STRING dans l'arbre ME */
#define DNARSET  48  /* STRING dans l'arbre ME */
#define VSLIDSET 49  /* STRING dans l'arbre ME */
#define LFARSET  50  /* STRING dans l'arbre ME */
#define RTARSET  51  /* STRING dans l'arbre ME */
#define HSLIDSET 52  /* STRING dans l'arbre ME */
#define CASCSET  54  /* STRING dans l'arbre ME */
#define MENUSET  55  /* STRING dans l'arbre ME */
#define OPTISET  56  /* STRING dans l'arbre ME */
#define EALLXAES 58  /* STRING dans l'arbre ME */
#define DALLXAES 59  /* STRING dans l'arbre ME */
#define STANXAES 61  /* STRING dans l'arbre ME */
#define CHGSET   63  /* STRING dans l'arbre ME */
#define LOADSET  65  /* STRING dans l'arbre ME */
#define SAVESET  66  /* STRING dans l'arbre ME */
#define CLEARSET 68  /* STRING dans l'arbre ME */

#define TITLE    1   /* Formulaire/Dialogue */

#define DEMO1    2   /* Formulaire/Dialogue */
#define RADIO1   4   /* BOXTEXT dans l'arbre DEMO1 */
#define RADIO2   5   /* BOXTEXT dans l'arbre DEMO1 */
#define RADIO3   6   /* BOXTEXT dans l'arbre DEMO1 */
#define RADIO4   7   /* BOXTEXT dans l'arbre DEMO1 */
#define CHAR1    8   /* BOXTEXT dans l'arbre DEMO1 */
#define BUT1     9   /* BUTTON dans l'arbre DEMO1 */
#define OKAY1    10  /* BOXTEXT dans l'arbre DEMO1 */
#define BUT2     11  /* BOXTEXT dans l'arbre DEMO1 */
#define EDIT80_1 12  /* FTEXT dans l'arbre DEMO1 */
#define SLLT1    14  /* BOXTEXT dans l'arbre DEMO1 */
#define TRACK1   15  /* BOX dans l'arbre DEMO1 */
#define SLIDE1   16  /* BOXTEXT dans l'arbre DEMO1 */
#define SLRT1    17  /* BOXTEXT dans l'arbre DEMO1 */
#define SLUP1    18  /* BOXTEXT dans l'arbre DEMO1 */
#define TRACK5   19  /* BOX dans l'arbre DEMO1 */
#define SLIDE5   20  /* BOXTEXT dans l'arbre DEMO1 */
#define HMAXDEC  24  /* BOXTEXT dans l'arbre DEMO1 */
#define HMAXTRAK 25  /* BOX dans l'arbre DEMO1 */
#define HMAXSLID 26  /* BOXTEXT dans l'arbre DEMO1 */
#define HMAXINC  27  /* BOXTEXT dans l'arbre DEMO1 */
#define VMAXDEC  29  /* BOXTEXT dans l'arbre DEMO1 */
#define VMAXTRAK 30  /* BOX dans l'arbre DEMO1 */
#define VMAXSLID 31  /* BOXTEXT dans l'arbre DEMO1 */
#define VMAXINC  32  /* BOXTEXT dans l'arbre DEMO1 */
#define HSTEPDEC 34  /* BOXTEXT dans l'arbre DEMO1 */
#define HSTEPTRK 35  /* BOX dans l'arbre DEMO1 */
#define HSTEPSLD 36  /* BOXTEXT dans l'arbre DEMO1 */
#define HSTEPINC 37  /* BOXTEXT dans l'arbre DEMO1 */
#define SLDN1    38  /* BOXTEXT dans l'arbre DEMO1 */
#define VSTEPDEC 40  /* BOXTEXT dans l'arbre DEMO1 */
#define VSTEPTRK 41  /* BOX dans l'arbre DEMO1 */
#define VSTEPSLD 42  /* BOXTEXT dans l'arbre DEMO1 */
#define VSTEPINC 43  /* BOXTEXT dans l'arbre DEMO1 */

#define SETTINGS 3   /* Formulaire/Dialogue */
#define LBMTEXT  3   /* STRING dans l'arbre SETTINGS */
#define WXCTEXT  4   /* STRING dans l'arbre SETTINGS */
#define CMETEXT  5   /* STRING dans l'arbre SETTINGS */
#define WCTEXT   6   /* STRING dans l'arbre SETTINGS */
#define FIETEXT  7   /* STRING dans l'arbre SETTINGS */
#define TDSTEXT  8   /* STRING dans l'arbre SETTINGS */
#define UCTEXT   9   /* STRING dans l'arbre SETTINGS */
#define LBMFLAG  10  /* BOXTEXT dans l'arbre SETTINGS */
#define WXCFLAG  11  /* BOXTEXT dans l'arbre SETTINGS */
#define CMEFLAG  12  /* BOXTEXT dans l'arbre SETTINGS */
#define WCFLAG   13  /* BOXTEXT dans l'arbre SETTINGS */
#define FIEFLAG  14  /* BOXTEXT dans l'arbre SETTINGS */
#define TDSFLAG  15  /* BOXTEXT dans l'arbre SETTINGS */
#define UCFLAG   16  /* BOXTEXT dans l'arbre SETTINGS */
#define LBMDROP  17  /* BOXCHAR dans l'arbre SETTINGS */
#define WXCDROP  18  /* BOXCHAR dans l'arbre SETTINGS */
#define CMEDROP  19  /* BOXCHAR dans l'arbre SETTINGS */
#define WCDROP   20  /* BOXCHAR dans l'arbre SETTINGS */
#define FIEDROP  21  /* BOXCHAR dans l'arbre SETTINGS */
#define TDSDROP  22  /* BOXCHAR dans l'arbre SETTINGS */
#define UCDROP   23  /* BOXCHAR dans l'arbre SETTINGS */

#define PRGICON  4   /* Formulaire/Dialogue */
#define WINICON  1   /* ICON dans l'arbre PRGICON */

#define STRTREE  5   /* Formulaire/Dialogue */

#define BXTTREE  6   /* Formulaire/Dialogue */

#define BUTTREE  7   /* Formulaire/Dialogue */

#define TXTTREE  8   /* Formulaire/Dialogue */

#define FTXTREE  9   /* Formulaire/Dialogue */
#define FIRSTTXT 1   /* FTEXT dans l'arbre FTXTREE */

#define BFTTREE  10  /* Formulaire/Dialogue */
#define FIRSTFTX 1   /* FBOXTEXT dans l'arbre BFTTREE */
