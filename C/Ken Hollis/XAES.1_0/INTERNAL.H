/* Indice du ressource pour INTERNAL */

#define WINPOP   0   /* Formulaire/Dialogue */
#define WPCLOSE  2   /* TEXT dans l'arbre WINPOP */
#define WPICON   3   /* TEXT dans l'arbre WINPOP */

#define CASCPOP  1   /* Formulaire/Dialogue */
#define WPCASC   2   /* TEXT dans l'arbre CASCPOP */
#define WPPTB    3   /* TEXT dans l'arbre CASCPOP */
#define WPPRIO   5   /* TEXT dans l'arbre CASCPOP */
#define WPBEVENT 6   /* TEXT dans l'arbre CASCPOP */
#define WPAOT    7   /* TEXT dans l'arbre CASCPOP */

#define FULLPOP  2   /* Formulaire/Dialogue */
#define WPMAX    2   /* TEXT dans l'arbre FULLPOP */
#define WPMIN    3   /* TEXT dans l'arbre FULLPOP */

#define RTPOP    3   /* Formulaire/Dialogue */
#define WHATIS   2   /* TEXT dans l'arbre RTPOP */
#define CLOSEWIN 4   /* TEXT dans l'arbre RTPOP */
#define CYCLEWIN 5   /* TEXT dans l'arbre RTPOP */
#define CLOSEALL 7   /* TEXT dans l'arbre RTPOP */
#define REDRWIN  8   /* TEXT dans l'arbre RTPOP */
#define REDRALL  9   /* TEXT dans l'arbre RTPOP */
#define FORCEXIT 10  /* TEXT dans l'arbre RTPOP */

#define ICONPOP  4   /* Formulaire/Dialogue */
#define UNICON   2   /* TEXT dans l'arbre ICONPOP */
#define PODICON  3   /* TEXT dans l'arbre ICONPOP */
#define CLOICON  5   /* TEXT dans l'arbre ICONPOP */

#define HELPWIN  5   /* Formulaire/Dialogue */
#define HELPTITL 2   /* TEXT dans l'arbre HELPWIN */
#define HELPWORK 3   /* BOX dans l'arbre HELPWIN */
#define HELPOK   5   /* BOXTEXT dans l'arbre HELPWIN */

#define LISTBOX  6   /* Formulaire/Dialogue */
#define LBUP     1   /* BOXCHAR dans l'arbre LISTBOX */
#define LBVERTRK 2   /* BOX dans l'arbre LISTBOX */
#define LBVERSL  3   /* BOX dans l'arbre LISTBOX */
#define LBHORTRK 4   /* BOX dans l'arbre LISTBOX */
#define LBHORSL  5   /* BOX dans l'arbre LISTBOX */
#define LBDOWN   6   /* BOXCHAR dans l'arbre LISTBOX */
#define LBLEFT   7   /* BOXCHAR dans l'arbre LISTBOX */
#define LBRIGHT  8   /* BOXCHAR dans l'arbre LISTBOX */
#define LBTEXT1  9   /* STRING dans l'arbre LISTBOX */
#define LBTEXT2  10  /* STRING dans l'arbre LISTBOX */
#define LBTEXT3  11  /* STRING dans l'arbre LISTBOX */
#define LBTEXT4  12  /* STRING dans l'arbre LISTBOX */
#define LBTEXT5  13  /* STRING dans l'arbre LISTBOX */
#define LBTEXT6  14  /* STRING dans l'arbre LISTBOX */
#define LBTEXT7  15  /* STRING dans l'arbre LISTBOX */

#define POPUP    7   /* Formulaire/Dialogue */
#define PUUP     1   /* BOXCHAR dans l'arbre POPUP */
#define PUVERTRK 2   /* BOX dans l'arbre POPUP */
#define PUVERSL  3   /* BOX dans l'arbre POPUP */
#define PUDOWN   4   /* BOXCHAR dans l'arbre POPUP */
#define PUTEXT1  5   /* STRING dans l'arbre POPUP */
#define PUTEXT2  6   /* STRING dans l'arbre POPUP */
#define PUTEXT3  7   /* STRING dans l'arbre POPUP */
#define PUTEXT4  8   /* STRING dans l'arbre POPUP */
#define PUTEXT5  9   /* STRING dans l'arbre POPUP */
#define PUTEXT6  10  /* STRING dans l'arbre POPUP */
#define PUTEXT7  11  /* STRING dans l'arbre POPUP */
#define PUTEXT8  12  /* STRING dans l'arbre POPUP */
#define PUTEXT9  13  /* STRING dans l'arbre POPUP */
#define PUTEXT10 14  /* STRING dans l'arbre POPUP */

#define ALERTBOX 8   /* Formulaire/Dialogue */
#define ALICON   2   /* IMAGE dans l'arbre ALERTBOX */
#define ALLINE1  3   /* STRING dans l'arbre ALERTBOX */
#define ALLINE2  4   /* STRING dans l'arbre ALERTBOX */
#define ALLINE3  5   /* STRING dans l'arbre ALERTBOX */
#define ALLINE4  6   /* STRING dans l'arbre ALERTBOX */
#define ALLINE5  7   /* STRING dans l'arbre ALERTBOX */
#define ALBUT1   8   /* BOXTEXT dans l'arbre ALERTBOX */
#define ALBUT2   9   /* BOXTEXT dans l'arbre ALERTBOX */
#define ALBUT3   10  /* BOXTEXT dans l'arbre ALERTBOX */

#define VIRT     9   /* Formulaire/Dialogue */
#define VDESK1   1   /* BOX dans l'arbre VIRT */
#define VDESK2   2   /* BOX dans l'arbre VIRT */
#define VDESK3   3   /* BOX dans l'arbre VIRT */
#define VDESK4   4   /* BOX dans l'arbre VIRT */
#define VDESK5   5   /* BOX dans l'arbre VIRT */
#define VDESK6   6   /* BOX dans l'arbre VIRT */
#define VDESK8   7   /* BOX dans l'arbre VIRT */
#define VDESK9   8   /* BOX dans l'arbre VIRT */
#define VDESK7   9   /* BOX dans l'arbre VIRT */
