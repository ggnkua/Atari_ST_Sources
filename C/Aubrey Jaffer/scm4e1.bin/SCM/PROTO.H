#ifdef __STDC__
# define	P(s) s
#else
# define P(s) ()
#endif


/* scm.c */
SCM lalarm P((SCM i ));
void tick_signal P((void ));
SCM lticks P((SCM i ));
void init_signals P((void ));
void ignore_signals P((void ));
void unignore_signals P((void ));
void restore_signals P((void ));
int run_scm P((int argc , char **argv , int iverbose , char *initpath ));
int main P((int argc , char **argv ));

/* time.c */
SCM your_time P((void ));
SCM your_time P((void ));
SCM your_time P((void ));
SCM my_time P((void ));
SCM dcdtime P((void ));
SCM long2num P((long sl ));
SCM get_univ_time P((void ));
SCM dcdunivtime P((SCM ut ));
long time_in_msec P((long x ));
SCM l_stat P((SCM str ));
void init_time P((void ));

/* repl.c */
int set_erase P((void ));
void init_tables P((void ));
void intprint P((long n , int radix , SCM port ));
void ipruk P((char *hdr , SCM ptr , SCM port ));
void iprlist P((char *hdr , SCM exp , int tlr , SCM port , int writing ));
void iprin1 P((SCM exp , SCM port , int writing ));
SCM char_readyp P((SCM port ));
SCM eof_objectp P((SCM x ));
void lfflush P((SCM port ));
SCM lflush P((SCM port ));
SCM lwrite P((SCM obj , SCM port ));
SCM display P((SCM obj , SCM port ));
SCM newline P((SCM port ));
SCM write_char P((SCM chr , SCM port ));
SCM trans_on P((SCM fil ));
SCM trans_off P((void ));
void lputc P((int c , SCM port ));
void lputs P((char *s , SCM port ));
int lfwrite P((char *ptr , sizet size , sizet nitems , SCM port ));
int lgetc P((SCM port ));
void lungetc P((int c , SCM port ));
SCM read_char P((SCM port ));
SCM peek_char P((SCM port ));
SCM lread P((SCM port ));
SCM file_position P((SCM port ));
SCM file_set_position P((SCM port , SCM pos ));
SCM readline P((SCM port ));
SCM read_line1 P((SCM str , SCM port ));
SCM tryarb P((SCM arb ));
SCM relarb P((SCM arb ));
SCM makarb P((SCM name ));
int handle_it P((int i ));
void init_init P((char *initpath ));
SCM repl_driver P((char *initpath ));
SCM line_num P((void ));
SCM prog_args P((void ));
void growth_mon P((char *obj , long size , char *units ));
void gc_start P((char *what ));
void gc_end P((void ));
void repl_report P((void ));
SCM lroom P((SCM args ));
void heap_report P((void ));
void exit_report P((void ));
SCM prolixity P((SCM arg ));
void repl P((void ));
SCM quit P((SCM n ));
SCM abrt P((void ));
SCM restart P((void ));
SCM lexec P((SCM args ));
void han_sig P((void ));
void han_alrm P((void ));
SCM tryload P((SCM filename ));
void warn P((char *str1 , char *str2 ));
SCM lerrno P((SCM arg ));
SCM lperror P((SCM arg ));
void everr P((SCM exp , SCM env , SCM arg , char *pos , char *s_subr ));
void wta P((SCM arg , char *pos , char *s_subr ));
SCM cur_input_port P((void ));
SCM cur_output_port P((void ));
SCM cur_error_port P((void ));
SCM set_inp P((SCM port ));
SCM set_outp P((SCM port ));
SCM set_errp P((SCM port ));
void init_features P((void ));
void add_feature P((char *str ));
void init_repl P((int iverbose ));
void final_repl P((void ));

/* scl.c */
sizet iint2str P((long num , int rad , char *p ));
SCM number2string P((SCM x , SCM radix ));
int floprint P((SCM sexp , SCM port , int writing ));
int bigprint P((SCM exp , SCM port , int writing ));
SCM istr2int P((char *str , long len , long radix ));
SCM istr2int P((char *str , long len , long radix ));
SCM istr2flo P((char *str , long len , long radix ));
SCM istring2number P((char *str , long len , long radix ));
SCM string2number P((SCM str , SCM radix ));
SCM makdbl P((double x , double y ));
SCM eqv P((SCM x , SCM y ));
SCM memv P((SCM x , SCM lst ));
SCM assv P((SCM x , SCM alist ));
SCM list_tail P((SCM lst , SCM k ));
SCM string2list P((SCM str ));
SCM string_copy P((SCM str ));
SCM string_fill P((SCM str , SCM chr ));
SCM vector2list P((SCM v ));
SCM vector_fill P((SCM v , SCM fill ));
SCM bigequal P((SCM x , SCM y ));
SCM floequal P((SCM x , SCM y ));
SCM equal P((SCM x , SCM y ));
SCM numberp P((SCM x ));
SCM realp P((SCM x ));
SCM intp P((SCM x ));
SCM inexactp P((SCM x ));
SCM eqp P((SCM x , SCM y ));
SCM lessp P((SCM x , SCM y ));
SCM greaterp P((SCM x , SCM y ));
SCM leqp P((SCM x , SCM y ));
SCM greqp P((SCM x , SCM y ));
SCM zerop P((SCM z ));
SCM positivep P((SCM x ));
SCM negativep P((SCM x ));
SCM lmax P((SCM x , SCM y ));
SCM lmin P((SCM x , SCM y ));
SCM sum P((SCM x , SCM y ));
SCM difference P((SCM x , SCM y ));
SCM product P((SCM x , SCM y ));
SCM divide P((SCM x , SCM y ));
double lasinh P((double x ));
double lacosh P((double x ));
double latanh P((double x ));
double ltrunc P((double x ));
double round P((double x ));
void two_doubles P((SCM z1 , SCM z2 , char *sstring , struct dpair *xy ));
SCM expt P((SCM z1 , SCM z2 ));
SCM latan2 P((SCM z1 , SCM z2 ));
SCM makrect P((SCM z1 , SCM z2 ));
SCM makpolar P((SCM z1 , SCM z2 ));
SCM real_part P((SCM z ));
SCM imag_part P((SCM z ));
SCM magnitude P((SCM z ));
SCM angle P((SCM z ));
double floident P((double z ));
SCM in2ex P((SCM z ));
SCM numident P((SCM x ));
SCM dbl2big P((double d ));
double big2dbl P((SCM b ));
unsigned long hasher P((SCM obj , unsigned long n , sizet d ));
SCM hash P((SCM obj , SCM n ));
SCM hashv P((SCM obj , SCM n ));
SCM hashq P((SCM obj , SCM n ));
SCM lsystem P((SCM cmd ));
SCM lgetenv P((SCM nam ));
SCM softtype P((void ));
SCM ed P((SCM fname ));
SCM vms_debug P((void ));
void init_scl P((void ));

/* sys.c */
long mode_bits P((char *modes ));
SCM open_file P((SCM filename , SCM modes ));
SCM open_pipe P((SCM pipestr , SCM modes ));
SCM close_port P((SCM port ));
SCM input_portp P((SCM x ));
SCM output_portp P((SCM x ));
SCM ltmpnam P((void ));
SCM ltmpnam P((void ));
SCM lchdir P((SCM str ));
SCM del_fil P((SCM str ));
SCM ren_fil P((SCM oldname , SCM newname ));
SCM lisatty P((SCM port ));
void prinport P((SCM exp , SCM port , char *type ));
sizet stwrite P((char *str , sizet siz , sizet num , SCM p ));
int noop0 P((FILE *stream ));
SCM mkstrport P((SCM cs , long modes ));
SCM cwos P((SCM proc ));
SCM cwis P((SCM str , SCM proc ));
sizet pwrite P((char *ptr , sizet size , sizet nitems , FILE *port ));
sizet sfwrite P((char *str , sizet siz , sizet num , SCM p ));
int sfflush P((SCM stream ));
SCM mksfpt P((SCM pv , SCM modes ));
int void P((**finals ));
void add_final P((void (*final )()));
void init_io P((void ));
void grew_lim P((long nm ));
char *must_malloc P((long len , char *what ));
char *must_realloc P((char *where , long olen , long len , char *what ));
void must_free P((char *obj ));
SCM sym2vcell P((SCM sym ));
SCM intern P((char *name , sizet len ));
SCM sysintern P((char *name , SCM val ));
SCM cons P((SCM x , SCM y ));
SCM cons2 P((SCM w , SCM x , SCM y ));
SCM acons P((SCM w , SCM x , SCM y ));
SCM makstr P((long len ));
SCM makfromstr P((char *src , sizet len ));
SCM make_subr P((char *name , int type , SCM (*fcn )()));
void stack_check P((void ));
void stack_report P((void ));
SCM dynwind P((SCM thunk1 , SCM thunk2 , SCM thunk3 ));
void dowinds P((SCM to , long delta ));
SCM make_cont P((void ));
void dynthrow P((SCM cont , SCM val ));
void lthrow P((SCM cont , SCM val ));
SCM obhash P((SCM obj ));
SCM obunhash P((SCM obj ));
unsigned long strhash P((unsigned char *str , sizet len , unsigned long n ));
sizet init_heap_seg P((CELLPTR seg_org , sizet size ));
long newsmob P((smobfuns *smob ));
long newptob P((ptobfuns *ptob ));
SCM markcdr P((SCM ptr ));
SCM mark0 P((SCM ptr ));
sizet free0 P((CELLPTR ptr ));
SCM equal0 P((SCM ptr1 , SCM ptr2 ));
void init_storage P((STACKITEM *stack_start_ptr ));
SCM gc_for_newcell P((void ));
SCM gc P((void ));
void igc P((char *what ));
void free_storage P((void ));
void gc_mark P((SCM p ));
void mark_locations P((STACKITEM x [], sizet n ));

/* eval.c */
SCM *ilookup P((SCM iloc , SCM env ));
SCM *lookupcar P((SCM vloc , SCM genv ));
SCM eval_args P((SCM l , SCM env ));
SCM m_quote P((SCM xorig , SCM env ));
SCM m_begin P((SCM xorig , SCM env ));
SCM m_if P((SCM xorig , SCM env ));
SCM m_set P((SCM xorig , SCM env ));
SCM m_and P((SCM xorig , SCM env ));
SCM m_or P((SCM xorig , SCM env ));
SCM m_case P((SCM xorig , SCM env ));
SCM m_cond P((SCM xorig , SCM env ));
SCM m_lambda P((SCM xorig , SCM env ));
SCM m_letstar P((SCM xorig , SCM env ));
SCM m_do P((SCM xorig , SCM env ));
SCM m_quasiquote P((SCM xorig , SCM env ));
SCM m_delay P((SCM xorig , SCM env ));
SCM m_define P((SCM x , SCM env ));
SCM m_letrec P((SCM xorig , SCM env ));
SCM m_let P((SCM xorig , SCM env ));
SCM m_apply P((SCM xorig , SCM env ));
SCM m_cont P((SCM xorig , SCM env ));
SCM ceval P((SCM x , SCM env ));
SCM procedurep P((SCM obj ));
SCM nconc2last P((SCM lst ));
SCM apply P((SCM proc , SCM arg1 , SCM args ));
SCM map P((SCM proc , SCM arg1 , SCM args ));
SCM for_each P((SCM proc , SCM arg1 , SCM args ));
SCM closure P((SCM code , SCM env ));
SCM makprom P((SCM code ));
SCM makacro P((SCM code ));
SCM makmacro P((SCM code ));
SCM makmmacro P((SCM code ));
SCM force P((SCM x ));
SCM copytree P((SCM obj ));
SCM eval P((SCM obj ));
SCM definedp P((SCM x , SCM env ));
SCM make_synt P((char *name , SCM (*macroizer )(), SCM (*fcn )()));
void init_eval P((void ));

/* subr.c */
SCM lnot P((SCM x ));
SCM booleanp P((SCM obj ));
SCM eq P((SCM x , SCM y ));
SCM consp P((SCM x ));
SCM setcar P((SCM pair , SCM value ));
SCM setcdr P((SCM pair , SCM value ));
SCM nullp P((SCM x ));
long ilength P((SCM sx ));
SCM listp P((SCM x ));
SCM list P((SCM objs ));
SCM length P((SCM x ));
SCM append P((SCM args ));
SCM reverse P((SCM lst ));
SCM list_ref P((SCM lst , SCM k ));
SCM memq P((SCM x , SCM lst ));
SCM member P((SCM x , SCM lst ));
SCM assq P((SCM x , SCM alist ));
SCM assoc P((SCM x , SCM alist ));
SCM symbolp P((SCM x ));
SCM symbol2string P((SCM s ));
SCM string2symbol P((SCM s ));
SCM exactp P((SCM x ));
SCM oddp P((SCM n ));
SCM evenp P((SCM n ));
SCM absval P((SCM x ));
SCM lquotient P((SCM x , SCM y ));
SCM lremainder P((SCM x , SCM y ));
SCM modulo P((SCM x , SCM y ));
SCM lgcd P((SCM x , SCM y ));
SCM llcm P((SCM n1 , SCM n2 ));
SCM logand P((SCM n1 , SCM n2 ));
SCM logior P((SCM n1 , SCM n2 ));
SCM logxor P((SCM n1 , SCM n2 ));
SCM lognot P((SCM n ));
SCM intexpt P((SCM z1 , SCM z2 ));
SCM ash P((SCM n , SCM cnt ));
SCM bitextract P((SCM n , SCM start , SCM end ));
SCM logcount P((SCM n ));
SCM intlength P((SCM n ));
SCM charp P((SCM x ));
SCM char_lessp P((SCM x , SCM y ));
SCM char_leqp P((SCM x , SCM y ));
SCM char_grp P((SCM x , SCM y ));
SCM char_geqp P((SCM x , SCM y ));
SCM chci_eq P((SCM x , SCM y ));
SCM chci_lessp P((SCM x , SCM y ));
SCM chci_leqp P((SCM x , SCM y ));
SCM chci_grp P((SCM x , SCM y ));
SCM chci_geqp P((SCM x , SCM y ));
SCM char_alphap P((SCM chr ));
SCM char_nump P((SCM chr ));
SCM char_whitep P((SCM chr ));
SCM char_upperp P((SCM chr ));
SCM char_lowerp P((SCM chr ));
SCM char2int P((SCM chr ));
SCM int2char P((SCM n ));
SCM char_upcase P((SCM chr ));
SCM char_downcase P((SCM chr ));
SCM stringp P((SCM x ));
SCM string P((SCM chrs ));
SCM make_string P((SCM k , SCM chr ));
SCM st_length P((SCM str ));
SCM st_ref P((SCM str , SCM k ));
SCM st_set P((SCM str , SCM k , SCM chr ));
SCM st_equal P((SCM s1 , SCM s2 ));
SCM stci_equal P((SCM s1 , SCM s2 ));
SCM st_lessp P((SCM s1 , SCM s2 ));
SCM st_leqp P((SCM s1 , SCM s2 ));
SCM st_grp P((SCM s1 , SCM s2 ));
SCM st_geqp P((SCM s1 , SCM s2 ));
SCM stci_lessp P((SCM s1 , SCM s2 ));
SCM stci_leqp P((SCM s1 , SCM s2 ));
SCM stci_grp P((SCM s1 , SCM s2 ));
SCM stci_geqp P((SCM s1 , SCM s2 ));
SCM substring P((SCM str , SCM start , SCM end ));
SCM st_append P((SCM args ));
SCM vectorp P((SCM x ));
SCM vector_length P((SCM v ));
SCM vector P((SCM l ));
SCM vector_ref P((SCM v , SCM k ));
SCM vector_set P((SCM v , SCM k , SCM obj ));
SCM make_vector P((SCM k , SCM fill ));
SCM mkbig P((sizet nlen , int sign ));
SCM big2long P((SCM b , sizet l ));
SCM adjbig P((SCM b , sizet nlen ));
SCM normbig P((SCM b ));
SCM copybig P((SCM b , int sign ));
SCM long2big P((long n ));
int bigcomp P((SCM x , SCM y ));
long pseudolong P((long x ));
BIGDIG *longdigs P((long x , BIGDIG digs [DIGSPERLONG ]));
SCM addbig P((BIGDIG *x , sizet nx , int xsgn , SCM bigy , int sgny ));
SCM mulbig P((BIGDIG *x , sizet nx , BIGDIG *y , sizet ny , int sgn ));
unsigned int divbigdig P((BIGDIG *ds , sizet h , BIGDIG div ));
SCM divbigint P((SCM x , long z , int sgn , int mode ));
SCM divbigbig P((BIGDIG *x , sizet nx , BIGDIG *y , sizet ny , int sgn , int modes ));
void init_iprocs P((iproc *subra , int type ));
void init_subrs P((void ));

/* sc2.c */
SCM last_pair P((SCM sx ));
SCM subml P((SCM str1 , SCM start1 , SCM args ));
SCM submr P((SCM str1 , SCM start1 , SCM args ));
SCM subfl P((SCM str , SCM start , SCM args ));
SCM strnullp P((SCM str ));
SCM appendb P((SCM args ));
void init_sc2 P((void ));

/* unif.c */
void uvprin1 P((SCM exp , SCM port , int writing ));
SCM make_uve P((SCM k , SCM prot ));
SCM uve_equal P((SCM u , SCM v ));
SCM uve_len P((SCM v ));
SCM arrayp P((SCM v , SCM prot ));
SCM array_rank P((SCM ra ));
SCM array_dims P((SCM ra ));
SCM aind P((SCM ra , SCM args ));
SCM shap2ra P((SCM args , char *what ));
SCM dims2ura P((SCM dims , SCM prot , SCM fill ));
SCM make_sh_array P((SCM oldra , SCM mapfunc , SCM dims ));
SCM array_inbp P((SCM args ));
SCM aref P((SCM v , SCM args ));
SCM array_ref P((SCM args ));
SCM aset P((SCM v , SCM obj , SCM args ));
SCM uve_fill P((SCM v , SCM obj ));
SCM array_simplep P((SCM ra ));
SCM array_contents P((SCM ra ));
SCM array_contp P((SCM ra ));
SCM uve_read P((SCM v , SCM port ));
SCM uve_write P((SCM v , SCM port ));
SCM lcount P((SCM item , SCM seq ));
SCM position P((SCM item , SCM v , SCM k ));
SCM bit_set P((SCM v , SCM kv , SCM obj ));
SCM bit_count P((SCM v , SCM kv , SCM obj ));
SCM bit_inv P((SCM v ));
SCM strup P((SCM v ));
SCM strdown P((SCM v ));
SCM resizuve P((SCM vect , SCM len ));
SCM list2uve P((SCM prot , SCM lst ));
SCM istr2bve P((char *str , long len ));
SCM array2list P((SCM v ));
SCM list2ura P((SCM ndim , SCM prot , SCM lst ));
int raprin1 P((SCM exp , SCM port , int writing ));
SCM array_prot P((SCM ra ));
int ramapc P((int (*cproc )(), SCM data , SCM ra0 , SCM lra , char *what ));
SCM array_copy P((SCM src , SCM dst ));
SCM array_map P((SCM ra0 , SCM proc , SCM lra ));
SCM array_for_each P((SCM proc , SCM ra0 , SCM lra ));
SCM array_imap P((SCM ra , SCM proc ));
void init_unif P((void ));

/* rgx.c */
sizet fregex P((CELLPTR ptr ));
int prinregex P((SCM exp , SCM port , int writing ));
SCM lregerror P((SCM scode ));
SCM lregcomp P((SCM pattern ));
SCM lregexec P((SCM prog , SCM str ));
SCM lregmatp P((SCM prog , SCM str ));
void init_rgx P((void ));

/* crs.c */
int freewindow P((WINDOW *win ));
int prinwindow P((SCM exp , SCM port , int writing ));
int bwaddch P((int c , WINDOW *win ));
int bwaddstr P((char *str , WINDOW *win ));
sizet bwwrite P((char *str , sizet siz , sizet num , WINDOW *win ));
SCM mkwindow P((WINDOW *win ));
SCM linitscr P((void ));
SCM lendwin P((void ));
SCM lnewwin P((SCM lines , SCM cols , SCM args ));
SCM lmvwin P((SCM win , SCM y , SCM x ));
SCM lsubwin P((SCM win , SCM lines , SCM args ));
SCM loverlay P((SCM srcwin , SCM dstwin ));
SCM loverwrite P((SCM srcwin , SCM dstwin ));
SCM lwmove P((SCM win , SCM y , SCM x ));
SCM lwadd P((SCM win , SCM obj ));
SCM lwinsert P((SCM win , SCM obj ));
SCM lbox P((SCM win , SCM vertch , SCM horch ));
SCM lgetyx P((SCM win ));
SCM lwinch P((SCM win ));
SCM lunctrl P((SCM c ));
SCM owidth P((SCM arg ));
SCM oheight P((SCM arg ));
SCM lrefresh P((void ));
int SUBR0 P((int lnl , int nl ));
int SUBRW P((int lwerase , int werase , int s_werase , int 0 ));
SCM lclearok P((SCM w , SCM b ));
void init_crs P((void ));

/* dynl.c */
void listundefs P((void ));
SCM llink P((SCM fname ));
SCM fcall P((SCM symb ));
SCM lunlink P((SCM fname ));
void init_dynl P((void ));
sizet frshl P((CELLPTR ptr ));
int prinshl P((SCM exp , SCM port , int writing ));
SCM lload P((SCM fname ));
SCM fcall P((SCM symb , SCM shl ));
SCM lunload P((SCM shl ));
void init_dynl P((void ));
struct dsc $descriptor *descriptorize P((struct dsc $descriptor *x , SCM buff ));
SCM dynl P((SCM dir , SCM symbol , SCM fname ));
void init_dynl P((void ));
sizet frshl P((CELLPTR ptr ));
int prinshl P((SCM exp , SCM port , int writing ));
SCM lload P((SCM fname ));
SCM fcall P((SCM symb , SCM shl ));
SCM lunload P((SCM shl ));
void init_dynl P((void ));

#undef P
