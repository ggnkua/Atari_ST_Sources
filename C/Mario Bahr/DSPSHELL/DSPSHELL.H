/* Resource Datei Indizes f�r DSPSHELL */

#define MENUE    0   /* Menuebaum */
#define MTINFO   3   /* TITLE in Baum MENUE */
#define MTDATEI  4   /* TITLE in Baum MENUE */
#define MTDO_IT  5   /* TITLE in Baum MENUE */
#define MTOPTION 6   /* TITLE in Baum MENUE */
#define M_INFO   9   /* STRING in Baum MENUE */
#define M_NEU    18  /* STRING in Baum MENUE */
#define M_OEFFNEN 19  /* STRING in Baum MENUE */
#define MEXE     20  /* STRING in Baum MENUE */
#define M_ENDE   21  /* STRING in Baum MENUE */
#define MEDITOR  23  /* STRING in Baum MENUE */
#define MASSEMBLE 24  /* STRING in Baum MENUE */
#define MOUTLOD  25  /* STRING in Baum MENUE */
#define MMAKEALL 26  /* STRING in Baum MENUE */
#define MPFAD    28  /* STRING in Baum MENUE */
#define MSAVE    29  /* STRING in Baum MENUE */

#define MAIN     1   /* Formular/Dialog */
#define DEDITOR  1   /* BUTTON in Baum MAIN */
#define DASSEMBLE 2   /* BUTTON in Baum MAIN */
#define DOUTTOLOD 3   /* BUTTON in Baum MAIN */
#define DMAKEALL 4   /* BUTTON in Baum MAIN */
#define IN_DATEI 6   /* TEXT in Baum MAIN */

#define PARAMETER 2   /* Formular/Dialog */
#define PARACAN  1   /* BUTTON in Baum PARAMETER */
#define PARAOK   2   /* BUTTON in Baum PARAMETER */
#define PSASM    7   /* TEXT in Baum PARAMETER */
#define PSOUTTOLOD 8   /* TEXT in Baum PARAMETER */
#define PSEDITOR 9   /* TEXT in Baum PARAMETER */
#define C        10  /* TEXT in Baum PARAMETER */

#define DESKTOP  3   /* Formular/Dialog */

#define DINFO    4   /* Formular/Dialog */
#define DINFOOK  4   /* BUTTON in Baum DINFO */

#define DANZEIGE 5   /* Formular/Dialog */
#define ANZEIGE  1   /* TEXT in Baum DANZEIGE */
#define DNAME    3   /* TEXT in Baum DANZEIGE */
