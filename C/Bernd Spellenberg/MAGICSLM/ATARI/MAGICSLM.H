/* Resource Datei Indizes f�r MAGICSLM */

#define SETUP    0   /* Formular/Dialog */
#define START    3   /* BUTTON in Baum SETUP */
#define STOP     4   /* BUTTON in Baum SETUP */
#define MODEMIN  8   /* BOX in Baum SETUP */
#define FILEIN   9   /* BOX in Baum SETUP */
#define SLMOUT   14  /* BOX in Baum SETUP */
#define PCXOUT   15  /* BOX in Baum SETUP */

#define PRINT    1   /* Formular/Dialog */
#define PAGENR   5   /* TEXT in Baum PRINT */
#define BYTES    6   /* TEXT in Baum PRINT */
#define ZUSTAND  7   /* TEXT in Baum PRINT */
#define RESET    8   /* BUTTON in Baum PRINT */
#define FF       9   /* BUTTON in Baum PRINT */
#define ABBR     10  /* BUTTON in Baum PRINT */
