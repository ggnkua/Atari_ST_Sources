void	UnSetPosWindow( WORD WinId );