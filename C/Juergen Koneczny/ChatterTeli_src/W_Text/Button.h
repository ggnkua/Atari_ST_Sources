WORD	HandleMuButtonTextWindow( WORD WinId, EVNT *Events, TEXT_WINDOW *TextWindow, WORD Global[15] );