void	OpenAboutDialog( WORD Global[15] );