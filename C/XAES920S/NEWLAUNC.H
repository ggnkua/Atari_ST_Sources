
char *appex[] = {".prg",".app",".gtp", nil},
     *accex[] = {".acc", nil}
     ;

global
short launch(LOCK lock, short mode, short wisgr, short wiscr, char *parm, char *p_tail, XA_CLIENT *caller)
{
}
