/*
 * XaAES - XaAES Ain't the AES
 *
 * A multitasking AES replacement for MiNT
 *
 */

#ifndef _SYS_MENU_H_
#define _SYS_MENU_H_

void do_system_menu(LOCK lock, short clicked_title, short menu_item);

#endif