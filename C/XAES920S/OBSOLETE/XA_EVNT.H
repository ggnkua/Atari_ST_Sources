/*
 * XaAES - XaAES Ain't the AES
 *
 * A multitasking AES replacement for MiNT
 *
 */

#ifndef _XA_EVNT_H_
#define _XA_EVNT_H_

void cancel_evnt_multi(XA_CLIENT *client);		/* HR */


#endif
