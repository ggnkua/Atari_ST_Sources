/* Resource Datei Indizes f�r DEBUGGER */

#define SETDEBUG         0   /* Formular/Dialog */
#define DB_APPL          1   /* BUTTON in Baum SETDEBUG */
#define DB_ALL           2   /* BUTTON in Baum SETDEBUG */
#define DB_SHEL          3   /* BUTTON in Baum SETDEBUG */
#define DB_NONE          4   /* BUTTON in Baum SETDEBUG */
#define DB_OK            5   /* BUTTON in Baum SETDEBUG */
