/* Resource Datei Indizes f�r XAAES */

#define SYSTEM_MENU      0   /* Menuebaum */
#define SYS_DESK         3   /* TITLE in Baum SYSTEM_MENU */
#define XA_SYSTEM_ABOUT  7   /* STRING in Baum SYSTEM_MENU */
#define XA_SYSTEM_LAUNCH 16  /* STRING in Baum SYSTEM_MENU */
#define MN_TASK_MANAGER  17  /* STRING in Baum SYSTEM_MENU */
#define MN_SALERT        19  /* STRING in Baum SYSTEM_MENU */
#define MN_ENV           20  /* STRING in Baum SYSTEM_MENU */
#define SHUTDOWN         22  /* STRING in Baum SYSTEM_MENU */

#define ALERT_ICONS      1   /* Formular/Dialog */
#define ALR_IC_DRIVE     1   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_STOP      2   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_SYSTEM    3   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_BOMB      4   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_WARNING   5   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_INFO      6   /* USERDEF in Baum ALERT_ICONS */
#define ALR_IC_QUESTION  7   /* USERDEF in Baum ALERT_ICONS */

#define ALERT_BOX        2   /* Formular/Dialog */
#define ALERT_BACK       0   /* BOX in Baum ALERT_BOX */
#define ALERT_D_ICON     1   /* USERDEF in Baum ALERT_BOX */
#define ALERT_T1         2   /* STRING in Baum ALERT_BOX */
#define ALERT_T2         3   /* STRING in Baum ALERT_BOX */
#define ALERT_T3         4   /* STRING in Baum ALERT_BOX */
#define ALERT_T4         5   /* STRING in Baum ALERT_BOX */
#define ALERT_T5         6   /* STRING in Baum ALERT_BOX */
#define ALERT_T6         7   /* STRING in Baum ALERT_BOX */
#define ALERT_BUT1       8   /* BUTTON in Baum ALERT_BOX */
#define ALERT_BUT2       9   /* BUTTON in Baum ALERT_BOX */
#define ALERT_BUT3       10  /* BUTTON in Baum ALERT_BOX */

#define ABOUT_XAAES      3   /* Formular/Dialog */
#define ABOUT_DATE       20  /* STRING in Baum ABOUT_XAAES */

#define DEF_DESKTOP      4   /* Formular/Dialog */
#define DESKTOP          0   /* BOX in Baum DEF_DESKTOP */
#define DESKTOP_LOGO     1   /* ICON in Baum DEF_DESKTOP */

#define TASK_MANAGER     5   /* Formular/Dialog */
#define TM_KILL          1   /* USERDEF in Baum TASK_MANAGER */
#define TM_SLEEP         2   /* USERDEF in Baum TASK_MANAGER */
#define TM_WAKE          3   /* USERDEF in Baum TASK_MANAGER */
#define TM_ICONS         4   /* IBOX in Baum TASK_MANAGER */
#define TM_ICN_HALTED    5   /* USERDEF in Baum TASK_MANAGER */
#define TM_ICN_LOCK      6   /* USERDEF in Baum TASK_MANAGER */
#define TM_ICN_MENU      7   /* ICON in Baum TASK_MANAGER */
#define TM_ICN_MESSAGE   8   /* USERDEF in Baum TASK_MANAGER */
#define TM_ICN_XAAES     9   /* USERDEF in Baum TASK_MANAGER */
#define TM_LIST          10  /* BOX in Baum TASK_MANAGER */

#define SYS_ERROR        6   /* Formular/Dialog */
#define SYSALERT_LIST    1   /* BOX in Baum SYS_ERROR */
#define SALERT_ICONS     3   /* IBOX in Baum SYS_ERROR */
#define SALERT_IC1       4   /* USERDEF in Baum SYS_ERROR */
#define SALERT_IC2       5   /* USERDEF in Baum SYS_ERROR */
#define SALERT_IC3       6   /* USERDEF in Baum SYS_ERROR */
#define SALERT_IC4       7   /* USERDEF in Baum SYS_ERROR */
#define SALERT_CLEAR     8   /* BUTTON in Baum SYS_ERROR */

#define FILE_SELECT      7   /* Formular/Dialog */
#define FS_FILE          1   /* FBOXTEXT in Baum FILE_SELECT */
#define FS_LIST          2   /* BOX in Baum FILE_SELECT */
#define FS_UNDER         3   /* IBOX in Baum FILE_SELECT */
#define FS_ICONS         5   /* IBOX in Baum FILE_SELECT */
#define FS_ICN_DIR       6   /* USERDEF in Baum FILE_SELECT */
#define FS_ICN_EXE       7   /* USERDEF in Baum FILE_SELECT */
#define FS_CANCEL        8   /* BUTTON in Baum FILE_SELECT */
#define FS_OK            9   /* BUTTON in Baum FILE_SELECT */

#define FSEL_MENU        8   /* Menuebaum */
#define FSEL_DRV         3   /* TITLE in Baum FSEL_MENU */
#define FSEL_FILTER      4   /* TITLE in Baum FSEL_MENU */
#define FSEL_DRVBOX      6   /* BOX in Baum FSEL_MENU */
#define FSEL_DRVA        7   /* STRING in Baum FSEL_MENU */
#define FSEL_PATBOX      43  /* BOX in Baum FSEL_MENU */
#define FSEL_PATA        44  /* STRING in Baum FSEL_MENU */
