/*
	XaAES LOGO Program
	- Just displays the XaAES logo
*/

#include <vdi.h>
#include <aes.h>
#ifndef WM_BOTTOMED
#define WM_BOTTOMED	33
#define WF_BOTTOM 25
#endif

#define LOGO_W 0x00C0
#define LOGO_H 0x003D
#define LOGO_DATASIZE 0x0B70
unsigned short x_logo[LOGO_DATASIZE] =
{ 0xFFFF, 0xFFFF, 0xF81F, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0x87E1, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFF0, 0x7FF1, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFF8F, 0xFFD8, 0xFFFC, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFC7F, 0xFFF0, 0xFFF8, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xF3FF, 0xFFA0, 0xFFF0, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xCFFF, 0xFDE8, 0xFFE0, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0x3FFF, 0xFF20, 0xFFC0, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFE, 0xFFFF, 0xFFE0, 0xFF80, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFD, 0xFFFF, 0xE749, 0xFF00, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFB, 0xFFFF, 0x9BC1, 0xFE00, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFC7, 0xFFF8, 0x7AD1, 0xFC01, 
  0xC000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFFDF, 0xFFF7, 0xFB01, 0xF803, 
  0xC000, 0x0000, 0x03FF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFBF, 0xFF0F, 0xFA81, 0xF007, 
  0xC000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFFBF, 0xF8FF, 0xFBA1, 0xE00F, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFF7F, 0xF7FF, 0xFA81, 0xC0FF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFF7F, 0x8FFF, 0xFB01, 0x81FF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFEFF, 0x7FFF, 0xFA41, 0x03FE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFEFF, 0xF7FF, 0xF900, 0x07FE, 
  0x0000, 0x0000, 0x3FFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFEFF, 0xF7FF, 0xFB00, 0x0FFE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFDFF, 0xC7FF, 0xF800, 0x1FFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFDFE, 0x3FFF, 0xFA00, 0x3FFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFDC1, 0xFFFF, 0xFAC0, 0x7FFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFE3F, 0xFFFF, 0xF800, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xE3FF, 
  0xFFF0, 0x00FF, 0xFFF0, 0x03FF, 
  0xFFFF, 0xFFFF, 0xF801, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xDDFF, 
  0xFC0F, 0xFF7F, 0xFE0F, 0xFC3F, 
  0xFFFF, 0xFFFF, 0xF883, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xBDFF, 
  0xFBFF, 0xFF7F, 0xF1FF, 0xFFBF, 
  0xFFFF, 0xFFFF, 0xF807, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFC, 0x7DFF, 
  0x87FF, 0xFE7F, 0xCFFF, 0xFF7F, 
  0xFFFF, 0xFFFF, 0xF247, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFD, 0xFDFF, 
  0x7FFF, 0xFFBF, 0x3FFF, 0xFF7F, 
  0xFFFF, 0xFFFF, 0xED87, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFA, 0xFBFE, 
  0xFFFF, 0xFFBE, 0xFFFF, 0xFF7F, 
  0xFFFF, 0xFFFF, 0xC807, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFF4, 0x7BFD, 
  0xFFF8, 0x3C3D, 0xFFE0, 0x3E7F, 
  0xFFFF, 0xFFFF, 0xBA07, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFEA, 0xF7FB, 
  0xFF07, 0xE3FB, 0xFF1F, 0xB1FF, 
  0xFFFF, 0xFFFF, 0x1087, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFF96, 0xEFF7, 
  0xFCFF, 0xDFFB, 0xFCFF, 0x6FFF, 
  0xFFFF, 0xFFFE, 0xE407, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFF6D, 0xEFF7, 
  0xE3FF, 0xBFF7, 0xF3FC, 0xCFFF, 
  0xFFFF, 0xFFFD, 0x5007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFEDD, 0xDFEF, 
  0xDFFE, 0x7FF7, 0xEFFC, 0x3FFF, 
  0xFFFF, 0xFFFB, 0xF287, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFDBB, 0xDFEF, 
  0xBFFF, 0xFFF7, 0xDFFF, 0xFFFF, 
  0xFFFF, 0xFFF5, 0x0007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFB7B, 0xBFEF, 
  0x7FFF, 0xFFF7, 0xBFFF, 0xFFFF, 
  0xFFFF, 0xFFEF, 0xA807, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xE6F7, 0x7FEF, 
  0x9FFF, 0xFFF7, 0xDFFF, 0xFFFF, 
  0xFFFF, 0xFFDF, 0x6007, 0xFFFF, 
  0xFE3F, 0xFFFF, 0xDDF7, 0x7FE3, 
  0xE000, 0x3FF7, 0xE7FF, 0xFFFF, 
  0xFFFF, 0xFFBE, 0xE807, 0xFFFF, 
  0xF80F, 0xFFE1, 0xB3EE, 0xFFF9, 
  0xFFFF, 0xDFFB, 0xF81F, 0xFFFF, 
  0xFFFF, 0xFF7D, 0xE007, 0xFFFF, 
  0xC007, 0xFF9F, 0x701E, 0x0FFE, 
  0x7FFF, 0xDFFB, 0xFFE3, 0xFFFF, 
  0xFFFF, 0xFEFB, 0xE007, 0xFFFF, 
  0x0007, 0xFE3E, 0xFFFF, 0xEFFF, 
  0x87FF, 0xDFFC, 0x03FC, 0x7FFF, 
  0xFFFF, 0xFDF7, 0xE007, 0xFFFE, 
  0x000F, 0xFC7F, 0xFFFF, 0xEFFF, 
  0xFBFF, 0x3FFF, 0xFC3F, 0x9FFF, 
  0xFFFF, 0xF3EF, 0xE007, 0xFFF8, 
  0x0007, 0xF95F, 0xFFFF, 0xDFFF, 
  0x87C0, 0xFFFF, 0xFFC3, 0xEFFF, 
  0xFFFF, 0x8FDF, 0xE007, 0xFFE0, 
  0x0607, 0xFB7F, 0xFFFF, 0xBFFE, 
  0x7E3F, 0xFFFF, 0xFFFD, 0xF7FF, 
  0xFFFF, 0x7FBF, 0xE007, 0xFFC0, 
  0x3C0F, 0xF33F, 0xFFF0, 0x7FFD, 
  0xF1FF, 0xFFFF, 0xFFFE, 0xF7FF, 
  0xFFFE, 0xFF7F, 0xE007, 0xF800, 
  0xF80F, 0xF5F0, 0x00EF, 0xFFF3, 
  0xCFFF, 0xFFFF, 0xFFFF, 0x77FF, 
  0xFFF9, 0xFEFF, 0xE007, 0xF000, 
  0xF01F, 0xFF6F, 0xFEEF, 0xFFEF, 
  0x3FFF, 0xFFFF, 0xFFFE, 0xF7FF, 
  0xFFF7, 0xFDFF, 0xE007, 0xC001, 
  0xE03F, 0xFEEF, 0xFDDF, 0xFFDE, 
  0xFFFF, 0x87FF, 0xFFFD, 0xF7FF, 
  0xFFEF, 0xFBFF, 0xE007, 0x0003, 
  0x803C, 0x7DDF, 0xFBDF, 0xFFB9, 
  0xFFFF, 0x7787, 0xFF03, 0xEFFF, 
  0xFFDF, 0xF7FF, 0xE000, 0x000F, 
  0x807A, 0x7BBF, 0xFBB8, 0xFE77, 
  0xFFFE, 0xF777, 0xF8FF, 0xEFFF, 
  0xFFBF, 0xEFFF, 0xE000, 0x020E, 
  0x0070, 0xE77F, 0xF3A5, 0xFEF7, 
  0xFFF9, 0xF6F8, 0x07FF, 0xDFFF, 
  0xFFBF, 0xDFFF, 0xC000, 0x0608, 
  0x1005, 0x9EFF, 0xF79B, 0xFDEF, 
  0xFFC7, 0xCDFF, 0xFFFF, 0xBFFF, 
  0xFF7F, 0xBFFF, 0xC000, 0x0F00, 
  0x2003, 0x3DFF, 0xEFF7, 0xFDF7, 
  0xFC3F, 0xDBFF, 0xFFFF, 0x7FFF, 
  0xFF7F, 0x7FFF, 0xE000, 0x1F80, 
  0xE026, 0xFBFF, 0xEFF7, 0xFDF8, 
  0x03FF, 0xDBFF, 0xFFF8, 0xFFFF, 
  0xFF7E, 0xFFFF, 0xE000, 0x7FC0, 
  0xE00E, 0xB7FF, 0xEFEF, 0xFDFF, 
  0xFFFF, 0xBBFF, 0xFFE7, 0xFFFF, 
  0xFEFD, 0xFFFF, 0xE000, 0xFFF3, 
  0xE09D, 0xEFFF, 0xF31F, 0xFDFF, 
  0xFFFE, 0x79FF, 0xFF1F, 0xFFFF, 
  0xFEFB, 0xFFFF, 0xE003, 0xFFFF, 
  0xE132, 0xDFFF, 0xF8FF, 0xFEFF, 
  0xFFF9, 0xFEFF, 0xF0FF, 0xFFFF, 
  0xFEE7, 0xFFFF, 0xF007, 0xFFFF, 
  0xF0F7, 0xBFFF, 0xFFFF, 0xFEFF, 
  0xFFE7, 0xFF80, 0x0FFF, 0xFFFF, 
  0xFF1F, 0xFFFF, 0xF00F, 0xFFFF, 
  0xFFF7, 0x7FFF, 0xFFFF, 0xFF7F, 
  0xFF9F, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xF87F, 0xFFFF, 
  0xFFF0, 0xFFFF, 0xFFFF, 0xFF9F, 
  0xF87F, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xF81F, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0x87E1, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFF0, 0x7FFD, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFF8F, 0xFFFE, 0xFFFC, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFC3F, 0xFFFE, 0xFFFB, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xF17F, 0xFFFE, 0xFFF7, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xC25F, 0xFFFE, 0xFFEE, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0x007F, 0xFFFE, 0xFFDF, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFE, 0x05BF, 0xFFFE, 0xFFBE, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFC, 0x08FF, 0xE7FD, 0xFF7C, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFF8, 0x057F, 0x9BFD, 0xFEFC, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFC0, 0x0B78, 0x7BFD, 0xFDF5, 
  0xC000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFFC0, 0x1177, 0xFBFD, 0xFBFB, 
  0xFF80, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x7FFF, 0xFFFF, 
  0xFF80, 0x0A0F, 0xFBFD, 0xF7F7, 
  0xC000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFF80, 0x00FF, 0xFBFD, 0xEF0F, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFF00, 0x07FF, 0xFBFD, 0xDEFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFF00, 0x0FFF, 0xFBFD, 0xBDFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFE00, 0x7FFF, 0xFBFD, 0x7BFE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFE00, 0x07FF, 0xFBFE, 0xF7FF, 
  0xF800, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0007, 0xFFFF, 0xFFFF, 
  0xFE00, 0x07FF, 0xFBFF, 0xEFFE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFC00, 0x07FF, 0xFBFF, 0xDFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFC00, 0x3FFF, 0xFBFF, 0xBFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFC01, 0xFFFF, 0xFBFF, 0x7FFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFE3F, 0xFFFF, 0xFBFE, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xE3FF, 
  0xFFF0, 0x00FF, 0xFFF0, 0x03FF, 
  0xFFFF, 0xFFFF, 0xFBFD, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xC1FF, 
  0xFC00, 0x867F, 0xFE0F, 0xFC3F, 
  0xFFFF, 0xFFFF, 0xFBFB, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0x81FF, 
  0xF800, 0x887F, 0xF1FF, 0xFFBF, 
  0xFFFF, 0xFFFF, 0xFBF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFC, 0x01FF, 
  0x8000, 0x147F, 0xC1FF, 0xFF7F, 
  0xFFFF, 0xFFFF, 0xF7F7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFC, 0x01FF, 
  0x0000, 0x013F, 0x1FFF, 0xFF7F, 
  0xFFFF, 0xFFFF, 0xEFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFF8, 0x03FE, 
  0x0000, 0xC5BE, 0x17FF, 0xFF7F, 
  0xFFFF, 0xFFFF, 0xDFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFF0, 0x03FC, 
  0x0000, 0x103D, 0x5FE0, 0x3E7F, 
  0xFFFF, 0xFFFF, 0xBFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFE2, 0x07F8, 
  0x0007, 0x83F8, 0xFF1F, 0xB1FF, 
  0xFFFF, 0xFFFF, 0x7FF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFF86, 0x0FF0, 
  0x00FE, 0x1FF8, 0x5CFF, 0x6FFF, 
  0xFFFF, 0xFFFE, 0xFFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFF0C, 0x0FF0, 
  0x03FE, 0x3FF3, 0x73FC, 0xCFFF, 
  0xFFFF, 0xFFFD, 0xFFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFE1C, 0x1FE0, 
  0x1FFC, 0x7FF3, 0xEFFC, 0x3FFF, 
  0xFFFF, 0xFFFB, 0xFFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFC38, 0x1FE0, 
  0x3FFF, 0xFFF2, 0x9FFF, 0xFFFF, 
  0xFFFF, 0xFFF7, 0xDFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xF878, 0x3FE0, 
  0x7FFF, 0xFFF1, 0xBFFF, 0xFFFF, 
  0xFFFF, 0xFFEF, 0xAFF7, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xE0F0, 0x7FE0, 
  0x1FFF, 0xFFF3, 0x5FFF, 0xFFFF, 
  0xFFFF, 0xFFDF, 0x6FF7, 0xFFFF, 
  0xFE3F, 0xFFFF, 0xC1F0, 0x7FE0, 
  0x0000, 0x3FF2, 0xE7FF, 0xFFFF, 
  0xFFFF, 0xFFBE, 0xEFF7, 0xFFFF, 
  0xF80F, 0xFFE1, 0x83E0, 0xFFF8, 
  0x0000, 0x1FFB, 0xF81F, 0xFFFF, 
  0xFFFF, 0xFF7D, 0xEFF7, 0xFFFF, 
  0xC007, 0xFF83, 0x0000, 0x0FFE, 
  0x0000, 0x1FFA, 0xFFE3, 0xFFFF, 
  0xFFFF, 0xFEFB, 0xEFF7, 0xFFFF, 
  0x0007, 0xFE00, 0x0000, 0x0FFF, 
  0x8000, 0x1FFC, 0x03FC, 0x7FFF, 
  0xFFFF, 0xFDF7, 0xEFF7, 0xFFFE, 
  0x000F, 0xFC00, 0x0000, 0x0FFF, 
  0xF800, 0x3FFF, 0xFC3F, 0x9FFF, 
  0xFFFF, 0xF3EF, 0xEFF7, 0xFFF8, 
  0x0007, 0xF800, 0x0000, 0x1FFF, 
  0x8000, 0xFFFF, 0xFFC3, 0xEFFF, 
  0xFFFF, 0x8FDF, 0xEFF7, 0xFFE0, 
  0x0607, 0xF800, 0x0000, 0x3FFE, 
  0x003F, 0xFFFF, 0xFFFD, 0xF7FF, 
  0xFFFF, 0x5FBF, 0xEFF7, 0xFFC0, 
  0x3C0F, 0xF000, 0x0000, 0x7FFC, 
  0x01FF, 0xFFFF, 0xFFFE, 0xF7FF, 
  0xFFFE, 0x1F7F, 0xEFF7, 0xF828, 
  0xF80F, 0xF000, 0x000F, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0x77FF, 
  0xFFF8, 0x9EFF, 0xEFF7, 0xF1A0, 
  0xF01F, 0xFF0F, 0xFE0F, 0xFFE0, 
  0x3FFF, 0xFFFF, 0xFFFE, 0xF7FF, 
  0xFFF0, 0x75FF, 0xEFF7, 0xC961, 
  0xE03F, 0xFE0F, 0xFC1F, 0xFFC0, 
  0xFFFF, 0x87FF, 0xFFFD, 0xF7FF, 
  0xFFE5, 0x13FF, 0xEFF7, 0x2C83, 
  0x803C, 0x7C1F, 0xF81F, 0xFF81, 
  0xFFFF, 0x0787, 0xFF03, 0xEFFF, 
  0xFFC0, 0x17FF, 0xEFF0, 0x600F, 
  0x8078, 0x783F, 0xF838, 0xFE07, 
  0xFFFE, 0x2767, 0xF8FF, 0xEFFF, 
  0xFF81, 0x6FFF, 0xEFFF, 0xF2AE, 
  0x0074, 0xE07F, 0xF021, 0xFE07, 
  0xFFF8, 0x16B8, 0x07FF, 0xDFFF, 
  0xFF80, 0xDFFF, 0xDFFF, 0xD608, 
  0x1001, 0x80FF, 0xF003, 0xFC0F, 
  0xFFC4, 0x4C7F, 0xFFFF, 0xBFFF, 
  0xFF01, 0x3FFF, 0xDFFF, 0xEF00, 
  0x2003, 0x01FF, 0xE007, 0xFC07, 
  0xFC01, 0x195F, 0xFFFF, 0x7FFF, 
  0xFF00, 0x7FFF, 0xEFFF, 0x9F80, 
  0xE006, 0x03FF, 0xE007, 0xFC00, 
  0x0008, 0x5AB5, 0xFFF8, 0xFFFF, 
  0xFF00, 0xFFFF, 0xEFFF, 0x7FC0, 
  0xE00E, 0x07FF, 0xE00F, 0xFC00, 
  0x0003, 0x39B7, 0xFFE7, 0xFFFF, 
  0xFE01, 0xFFFF, 0xEFF8, 0xFFF3, 
  0xE01C, 0x0FFF, 0xF01F, 0xFC00, 
  0x0000, 0x78FF, 0xFF1F, 0xFFFF, 
  0xFE03, 0xFFFF, 0xEFFB, 0xFFFF, 
  0xE030, 0x1FFF, 0xF8FF, 0xFE00, 
  0x0001, 0xFEBB, 0xF0FF, 0xFFFF, 
  0xFE07, 0xFFFF, 0xF7F7, 0xFFFF, 
  0xF0F0, 0x3FFF, 0xFFFF, 0xFE00, 
  0x0007, 0xFF80, 0x0FFF, 0xFFFF, 
  0xFF1F, 0xFFFF, 0xF78F, 0xFFFF, 
  0xFFF0, 0x7FFF, 0xFFFF, 0xFF00, 
  0x001F, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xF87F, 0xFFFF, 
  0xFFF0, 0xFFFF, 0xFFFF, 0xFF80, 
  0x007F, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xF81F, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0x8001, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFF0, 0x0001, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFF80, 0x0000, 0xFFFC, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFC00, 0x0000, 0xFFF8, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xF000, 0x0000, 0xFFF0, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xC000, 0x0000, 0xFFE1, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0x0000, 0x0000, 0xFFC0, 
  0x7FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFE, 0x0000, 0x0000, 0xFF80, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFC, 0x0000, 0x0001, 0xFF02, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFF8, 0x0000, 0x1801, 0xFE02, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFC0, 0x0000, 0x7801, 0xFC09, 
  0xC000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFFC0, 0x0007, 0xF801, 0xF803, 
  0xC07F, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xE000, 0x0000, 0x0000, 0x007F, 
  0xFF80, 0x000F, 0xF801, 0xF007, 
  0xC000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFF80, 0x00FF, 0xF801, 0xE00F, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFF00, 0x07FF, 0xF801, 0xC0FF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFF00, 0x0FFF, 0xF801, 0x81FF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFE00, 0x7FFF, 0xF801, 0x03FE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFE00, 0x07FF, 0xF800, 0x07FE, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFFE, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFE00, 0x07FF, 0xF800, 0x0FFE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x007F, 
  0xFC00, 0x07FF, 0xF800, 0x1FFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFC00, 0x3FFF, 0xF800, 0x3FFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFC01, 0xFFFF, 0xF800, 0x7FFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFE3F, 0xFFFF, 0xF800, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xE3FF, 
  0xFFF0, 0x00FF, 0xFFF0, 0x03FF, 
  0xFFFF, 0xFFFF, 0xF801, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xDDFF, 
  0xFC00, 0x007F, 0xFE00, 0x003F, 
  0xFFFF, 0xFFFF, 0xF803, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xBDFF, 
  0xFA00, 0x007F, 0xF000, 0x003F, 
  0xFFFF, 0xFFFF, 0xF807, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFC, 0x7DFF, 
  0x8000, 0x007F, 0xC000, 0x007F, 
  0xFFFF, 0xFFFF, 0xF007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFD, 0xFDFF, 
  0x0000, 0x003F, 0x0000, 0x007F, 
  0xFFFF, 0xFFFF, 0xE007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFA, 0xFBFE, 
  0x8000, 0x003E, 0x0000, 0x007F, 
  0xFFFF, 0xFFFF, 0xC007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFF4, 0x7BFC, 
  0x4000, 0x003C, 0x0000, 0x007F, 
  0xFFFF, 0xFFFF, 0x8007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFEA, 0xF7FB, 
  0x0007, 0x83F8, 0x001F, 0x81FF, 
  0xFFFF, 0xFFFF, 0x0007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFF96, 0xEFF1, 
  0x00FE, 0x1FF8, 0x00FF, 0x0FFF, 
  0xFFFF, 0xFFFE, 0x0007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFF6D, 0xEFF0, 
  0x03FE, 0x3FF0, 0x03FC, 0x0FFF, 
  0xFFFF, 0xFFFC, 0x0007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFEDD, 0xDFE8, 
  0x1FFC, 0x7FF0, 0x0FFC, 0x3FFF, 
  0xFFFF, 0xFFF8, 0x0007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFDBB, 0xDFE4, 
  0x3FFF, 0xFFF0, 0x1FFF, 0xFFFF, 
  0xFFFF, 0xFFF0, 0x0007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFB7B, 0xBFEC, 
  0x7FFF, 0xFFF0, 0x3FFF, 0xFFFF, 
  0xFFFF, 0xFFE0, 0x2007, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xE6F7, 0x7FE0, 
  0x1FFF, 0xFFF0, 0x1FFF, 0xFFFF, 
  0xFFFF, 0xFFC0, 0x6007, 0xFFFF, 
  0xFE3F, 0xFFFF, 0xDDF7, 0x7FE0, 
  0x0000, 0x3FF0, 0x07FF, 0xFFFF, 
  0xFFFF, 0xFF80, 0xE007, 0xFFFF, 
  0xF9CF, 0xFFE1, 0xB3EE, 0xFFF8, 
  0x8000, 0x1FF8, 0x001F, 0xFFFF, 
  0xFFFF, 0xFF01, 0xE007, 0xFFFF, 
  0xC3F7, 0xFF9F, 0x701E, 0x0FFE, 
  0x0000, 0x1FF8, 0x0003, 0xFFFF, 
  0xFFFF, 0xFE03, 0xE007, 0xFFFF, 
  0x3FF7, 0xFE7E, 0xFFFF, 0x8FFF, 
  0x8000, 0x1FFC, 0x0000, 0x7FFF, 
  0xFFFF, 0xFC07, 0xE007, 0xFFFE, 
  0xFFEF, 0xFDFF, 0xFFFA, 0xAFFF, 
  0xF800, 0x3FFF, 0xFC00, 0x1FFF, 
  0xFFFF, 0xF00F, 0xE007, 0xFFF9, 
  0xF8F7, 0xFBFF, 0xFFFB, 0x5FFF, 
  0x8000, 0xFFFF, 0xFFC0, 0x0FFF, 
  0xFFFF, 0x801F, 0xE007, 0xFFE7, 
  0xC7FF, 0xFBFF, 0xFFFF, 0x3FFE, 
  0x003F, 0xFFFF, 0xFFFC, 0x07FF, 
  0xFFFF, 0x003F, 0xE007, 0xFFDF, 
  0x3DEF, 0xF3FF, 0xFFF0, 0x7FFC, 
  0x01FF, 0xFFFF, 0xFFFE, 0x07FF, 
  0xFFFE, 0x007F, 0xE007, 0xF816, 
  0xFBEF, 0xF7F0, 0x00EF, 0xFFF0, 
  0x0FFF, 0xFFFF, 0xFFFF, 0x07FF, 
  0xFFF8, 0x00FF, 0xE007, 0xF65E, 
  0xF7DF, 0xFF6F, 0xFEEF, 0xFFE0, 
  0x3FFF, 0xFFFF, 0xFFFE, 0x07FF, 
  0xFFF0, 0x01FF, 0xE007, 0xC69D, 
  0xEFBF, 0xFEEF, 0xFDDF, 0xFFD0, 
  0xFFFF, 0x87FF, 0xFFFC, 0x07FF, 
  0xFFE0, 0x03FF, 0xE007, 0x137B, 
  0x9FBD, 0xFDDF, 0xFBDF, 0xFF81, 
  0xFFFF, 0x0787, 0xFF00, 0x0FFF, 
  0xFFC0, 0x07FF, 0xE000, 0x9DEF, 
  0xBF7B, 0x7BBF, 0xFBB8, 0xFE47, 
  0xFFFE, 0x0707, 0xF800, 0x0FFF, 
  0xFF80, 0x0FFF, 0xE000, 0x0A4E, 
  0x6F76, 0xE77F, 0xF3A1, 0xFE07, 
  0xFFF8, 0x0600, 0x0000, 0x1FFF, 
  0xFF80, 0x1FFF, 0xC000, 0x26E9, 
  0xD78D, 0x9EFF, 0xF783, 0xFC0F, 
  0xFFC0, 0x0C00, 0x0000, 0x3FFF, 
  0xFF00, 0x3FFF, 0xC000, 0x0F77, 
  0x2FFB, 0x7DFF, 0xEFB7, 0xFD07, 
  0xFC00, 0x1800, 0x0000, 0x7FFF, 
  0xFF00, 0x7FFF, 0xE000, 0x1FBE, 
  0xEFF6, 0xFBFF, 0xEED7, 0xFD00, 
  0x0000, 0x1800, 0x0000, 0xFFFF, 
  0xFF00, 0xFFFF, 0xE000, 0x7FD8, 
  0xEFEE, 0xF7FF, 0xEFCF, 0xFC00, 
  0x0000, 0x3800, 0x0007, 0xFFFF, 
  0xFE01, 0xFFFF, 0xE000, 0xFFF3, 
  0xEFDD, 0xEFFF, 0xF31F, 0xFC40, 
  0x0000, 0x7800, 0x001F, 0xFFFF, 
  0xFE03, 0xFFFF, 0xE003, 0xFFFF, 
  0xEF33, 0xDFFF, 0xF8FF, 0xFE40, 
  0x0001, 0xFE00, 0x00FF, 0xFFFF, 
  0xFE07, 0xFFFF, 0xF007, 0xFFFF, 
  0xF0F7, 0xBFFF, 0xFFFF, 0xFE00, 
  0x0007, 0xFF00, 0x0FFF, 0xFFFF, 
  0xFF1F, 0xFFFF, 0xF00F, 0xFFFF, 
  0xFFF7, 0x7FFF, 0xFFFF, 0xFF20, 
  0x001F, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xF87F, 0xFFFF, 
  0xFFF0, 0xFFFF, 0xFFFF, 0xFF80, 
  0x007F, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFE0, 
  0x07FF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0x0000, 0x0000, 0x07E0, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x781E, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x000F, 0x8002, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0070, 0x0001, 0x0003, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0380, 0x0000, 0x0004, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0C00, 0x0000, 0x0008, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x3000, 0x0000, 0x0010, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0xC000, 0x0000, 0x0020, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0001, 0x0000, 0x0000, 0x0040, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0002, 0x0000, 0x0000, 0x0080, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0004, 0x0000, 0x0400, 0x0100, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0038, 0x0000, 0x0400, 0x0200, 
  0x3FFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFF80, 
  0x0020, 0x0000, 0x0400, 0x0400, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0040, 0x0000, 0x0400, 0x0800, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0040, 0x0000, 0x0400, 0x1000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0080, 0x0000, 0x0400, 0x2000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0080, 0x0000, 0x0400, 0x4000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0100, 0x0000, 0x0400, 0x8001, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFF80, 
  0x0100, 0x0000, 0x0401, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0100, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0200, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0200, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0200, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x1C00, 
  0x000F, 0xFF00, 0x000F, 0xFC00, 
  0x0000, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x2000, 
  0x03F0, 0x0000, 0x01F0, 0x03C0, 
  0x0000, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x4000, 
  0x0400, 0x0000, 0x0E00, 0x0000, 
  0x0000, 0x0000, 0x0400, 0x0000, 
  0x0000, 0x0000, 0x0003, 0x8000, 
  0x7800, 0x0000, 0x3000, 0x0000, 
  0x0000, 0x0000, 0x0800, 0x0000, 
  0x0000, 0x0000, 0x0002, 0x0000, 
  0x8000, 0x0000, 0xC000, 0x0000, 
  0x0000, 0x0000, 0x1000, 0x0000, 
  0x0000, 0x0000, 0x0004, 0x0001, 
  0x0000, 0x0001, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x2000, 0x0000, 
  0x0000, 0x0000, 0x0008, 0x8002, 
  0x0000, 0x0002, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x4000, 0x0000, 
  0x0000, 0x0000, 0x0011, 0x0004, 
  0x0000, 0x0004, 0x0000, 0x4000, 
  0x0000, 0x0000, 0x8000, 0x0000, 
  0x0000, 0x0000, 0x0061, 0x0008, 
  0x0000, 0x0004, 0x0000, 0x8000, 
  0x0000, 0x0001, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0082, 0x0008, 
  0x0000, 0x0008, 0x0003, 0x0000, 
  0x0000, 0x0002, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0102, 0x0010, 
  0x0000, 0x0008, 0x0000, 0x0000, 
  0x0000, 0x0004, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0204, 0x0010, 
  0x0000, 0x0008, 0x0000, 0x0000, 
  0x0000, 0x0008, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0404, 0x0010, 
  0x0000, 0x0008, 0x4000, 0x0000, 
  0x0000, 0x0010, 0x1000, 0x0000, 
  0x0000, 0x0000, 0x1808, 0x0010, 
  0x6000, 0x0008, 0x2000, 0x0000, 
  0x0000, 0x0020, 0x1000, 0x0000, 
  0x01C0, 0x0000, 0x2008, 0x001C, 
  0x1FFF, 0xC008, 0x1800, 0x0000, 
  0x0000, 0x0040, 0x1000, 0x0000, 
  0x0630, 0x001E, 0x4010, 0x0006, 
  0x0000, 0x0004, 0x07E0, 0x0000, 
  0x0000, 0x0080, 0x1000, 0x0000, 
  0x3C00, 0x0060, 0x8FE1, 0xF000, 
  0x0000, 0x0004, 0x001C, 0x0000, 
  0x0000, 0x0100, 0x1000, 0x0000, 
  0xC000, 0x0181, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0003, 0x8000, 
  0x0000, 0x0200, 0x1000, 0x0001, 
  0x0000, 0x0200, 0x0000, 0x0000, 
  0x0400, 0x0000, 0x0000, 0x6000, 
  0x0000, 0x0C00, 0x1000, 0x0006, 
  0x0000, 0x0400, 0x0000, 0x0000, 
  0x7800, 0x0000, 0x0000, 0x1000, 
  0x0000, 0x7000, 0x1000, 0x0018, 
  0x0000, 0x0400, 0x0000, 0x0001, 
  0x8000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x8000, 0x1000, 0x0020, 
  0x0200, 0x0C00, 0x0000, 0x0002, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0001, 0x0000, 0x1000, 0x07C0, 
  0x0400, 0x0800, 0x0000, 0x000C, 
  0x0000, 0x0000, 0x0000, 0x8000, 
  0x0006, 0x0000, 0x1000, 0x0800, 
  0x0800, 0x0080, 0x0100, 0x0010, 
  0x0000, 0x0000, 0x0001, 0x0000, 
  0x0008, 0x0000, 0x1000, 0x3000, 
  0x1000, 0x0100, 0x0200, 0x0020, 
  0x0000, 0x7800, 0x0002, 0x0000, 
  0x0010, 0x0000, 0x1000, 0xC000, 
  0x6002, 0x0200, 0x0400, 0x0040, 
  0x0000, 0x8078, 0x00FC, 0x0000, 
  0x0020, 0x0000, 0x1007, 0x0000, 
  0x4004, 0x0400, 0x0406, 0x0180, 
  0x0001, 0x0088, 0x0700, 0x0000, 
  0x0040, 0x0000, 0x1000, 0x0101, 
  0x800E, 0x1800, 0x0C18, 0x0100, 
  0x0006, 0x0107, 0xF800, 0x0000, 
  0x0040, 0x0000, 0x2000, 0x0106, 
  0x0870, 0x6000, 0x0820, 0x0200, 
  0x0038, 0x0200, 0x0000, 0x0000, 
  0x0080, 0x0000, 0x2000, 0x0088, 
  0x1008, 0x8000, 0x1000, 0x0208, 
  0x03C0, 0x0400, 0x0000, 0x0000, 
  0x0080, 0x0000, 0x1000, 0x0040, 
  0x1001, 0x0000, 0x1000, 0x0207, 
  0xFC00, 0x0400, 0x0000, 0x0000, 
  0x0080, 0x0000, 0x1000, 0x0020, 
  0x1041, 0x0000, 0x1000, 0x0200, 
  0x0000, 0x0400, 0x0000, 0x0000, 
  0x0100, 0x0000, 0x1000, 0x0000, 
  0x1002, 0x0000, 0x0000, 0x0200, 
  0x0000, 0x0400, 0x0000, 0x0000, 
  0x0100, 0x0000, 0x1000, 0x0000, 
  0x100C, 0x0000, 0x0000, 0x0100, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0100, 0x0000, 0x0800, 0x0000, 
  0x0008, 0x0000, 0x0000, 0x0100, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0800, 0x0000, 
  0x0008, 0x0000, 0x0000, 0x0080, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0008, 0x0000, 0x0000, 0x0040, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x0000, 0x0000, 0x0000, 0x0000
};

#ifndef NULL
#define NULL (void *)0
#endif

MFDB logo_bm;
short my_handle;

void display_bitmap(short x, short y)
{
	MFDB screen;
	short p[8];

	screen.fd_addr = NULL;

	p[0] = p[1] = 0;
	p[2] = LOGO_W-1;
	p[3] = LOGO_H - 1;
	p[4] = x;
	p[5] = y;
	p[6] = x + LOGO_W - 1;
	p[7] = y + LOGO_H - 1;

	vro_cpyfm(my_handle, S_ONLY, p, &logo_bm, &screen);
}

short main(int argc, char *argv[])
{
	MFDB dest;
	short my_AppId, x, y, w, h;
	short work_in[11] = {1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 2};
	short work_out[57], msg[16], w_id1;
	short open_windows = 1, dummy;
	short wx, wy, ww, wh, clip[4], pnt[4];
	char win1_name[20];
	unsigned short logo_trnfrm[LOGO_DATASIZE];
	GRECT dirty, walk;
	short e = 0, evx, evy, a, kc_shstate, kc_key, click_count;

	my_AppId = appl_init();
	my_handle = graf_handle(&x, &y, &w, &h);		/* Open a virtual workstation */
	v_opnvwk(work_in, &my_handle, work_out);

	logo_bm.fd_w = LOGO_W;
	logo_bm.fd_h = LOGO_H;
	logo_bm.fd_wdwidth = 12;
	logo_bm.fd_nplanes = 4;
	logo_bm.fd_stand = 1;
	dest = logo_bm;
	dest.fd_stand = 0;

	logo_bm.fd_addr = (void *)x_logo;
	dest.fd_addr = (void *)logo_trnfrm;
	vr_trnfm(my_handle, &logo_bm, &dest);
	logo_bm.fd_addr = (void *)logo_trnfrm;

	w_id1 = wind_create(NAME|CLOSE|MOVER, 0, 0, LOGO_W + 40, LOGO_H + 40);

	if (argc > 1)
		sprintf(win1_name,"%s", argv[1]);
	else
		sprintf(win1_name,"Welcome to...", argv[1]);
		
	wind_set(w_id1, WF_NAME, ADDR(win1_name));

	x = (work_out[0] - (LOGO_W + 40)) / 2;
	y = (work_out[1] - (LOGO_H + 40)) / 2;
	wind_open(w_id1, x, y, LOGO_W + 40, LOGO_H + 40);

	while((open_windows) && (!(e & MU_TIMER))) {
		e = evnt_multi(MU_MESAG|MU_TIMER, 258, 3, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
			msg, 15000, 0, &evx, &evy, &a, &kc_shstate, &kc_key, &click_count);

		if (e & MU_MESAG) {
			dummy = msg[0];
			switch(dummy) {
			case WM_CLOSED:	/* Did someone close one of our windows? */
				wind_close(msg[3]);
				open_windows--;
				break;
			case WM_MOVED:
				wind_set(msg[3], WF_CURRXYWH, msg[4], msg[5], msg[6], msg[7]);
				break;
			case WM_REDRAW:
				dirty.g_x = msg[4];
				dirty.g_y = msg[5];
				dirty.g_w = msg[6];
				dirty.g_h = msg[7];
				wind_update(BEG_UPDATE);
				wind_get(msg[3], WF_WORKXYWH, &wx, &wy, &ww, &wh);
				walk.g_x = wx;
				walk.g_y = wy;
				walk.g_w = ww;
				walk.g_h = wh;
				pnt[0] = wx;
				pnt[1] = wy;
				pnt[2] = wx + ww;
				pnt[3] = wy + wh;
				wind_get(msg[3], WF_FIRSTXYWH, &x, &y, &w, &h);
				rc_intersect(&walk, &dirty);
				graf_mouse(M_OFF, NULL);
				while(h) {
					walk.g_x = x;
					walk.g_y = y;
					walk.g_w = w;
					walk.g_h = h;
					if (rc_intersect(&dirty, &walk)) {
						clip[0] = walk.g_x;
						clip[1] = walk.g_y;
						clip[2] = walk.g_x + walk.g_w;
						clip[3] = walk.g_y + walk.g_h;
						vs_clip(my_handle, 1, clip);
						vsf_color(my_handle, LWHITE);
						v_bar(my_handle, pnt);
						display_bitmap(wx, wy);
					}
					wind_get(msg[3], WF_NEXTXYWH, &x, &y, &w, &h);
				}
				vs_clip(my_handle, 0, clip);
				graf_mouse(M_ON, NULL);
				wind_update(END_UPDATE);
				break;
			case WM_TOPPED:
				wind_set(msg[3], WF_TOP, 0, 0, 0, 0);
				break;
			case WM_BOTTOMED:
				wind_set(msg[3], WF_BOTTOM, 0, 0, 0, 0);
				break;
			}
		}
	}
	
	v_clsvwk(my_handle);
	
	appl_exit();
	
	return 0;
}
