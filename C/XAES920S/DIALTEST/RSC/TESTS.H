/* Resource Datei Indizes f�r TESTS */

#define T                0   /* Formular/Dialog */
#define FT1              4   /* FTEXT in Baum T */
#define FT2              5   /* FTEXT in Baum T */
#define FT3              6   /* FTEXT in Baum T */
#define FT4              7   /* FTEXT in Baum T */
#define RB1              9   /* BUTTON in Baum T */
#define RB2              10  /* BUTTON in Baum T */
#define RB3              11  /* BUTTON in Baum T */
#define TEX1             12  /* BUTTON in Baum T */
#define FORM_DO          14  /* BUTTON in Baum T */
#define MYFORM_DO        15  /* BUTTON in Baum T */
#define FORM_MODE        16  /* BUTTON in Baum T */
#define TEX2             17  /* STRING in Baum T */
#define DTX              19  /* FTEXT in Baum T */
#define DTY              20  /* FTEXT in Baum T */
#define DTW              21  /* FTEXT in Baum T */
#define DTH              22  /* FTEXT in Baum T */
#define OBX              25  /* FTEXT in Baum T */
#define OBY              26  /* FTEXT in Baum T */
#define OBW              27  /* FTEXT in Baum T */
#define OBH              28  /* FTEXT in Baum T */
#define DO               43  /* BUTTON in Baum T */
#define CANCEL           44  /* BUTTON in Baum T */
#define OK               45  /* BUTTON in Baum T */
#define XA_VERSION       46  /* FTEXT in Baum T */
