/*
 * XaAES - XaAES Ain't the AES
 *
 * A multitasking AES replacement for MiNT
 *
 */

#ifndef _MATCHPAT_H_
#define _MATCHPAT_H_

int match_pattern(char *t, char *pat);

#endif