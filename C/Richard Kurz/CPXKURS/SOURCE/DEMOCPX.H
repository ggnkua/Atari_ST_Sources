#define DIALOG 0  	/* TREE */
#define POPUP 5  	/* OBJECT in TREE #0 */
#define VVATER 13  	/* OBJECT in TREE #0 */
#define VTEXT 14  	/* OBJECT in TREE #0 */
#define VMINUS 15  	/* OBJECT in TREE #0 */
#define VPLUS 16  	/* OBJECT in TREE #0 */
#define MENU 17  	/* OBJECT in TREE #0 */
#define HVATER 19  	/* OBJECT in TREE #0 */
#define HTEXT 20  	/* OBJECT in TREE #0 */
#define HMINUS 21  	/* OBJECT in TREE #0 */
#define HPLUS 22  	/* OBJECT in TREE #0 */
#define OKAY 24  	/* OBJECT in TREE #0 */
#define ABBRUCH 25  	/* OBJECT in TREE #0 */
#define SICHERN 27  	/* OBJECT in TREE #0 */
