#define DIALOG 0  	/* TREE */
#define WAIT 1  	/* TREE */
#define TEXT 2  	/* TREE */
#define HELP 3  	/* TREE */
#define REINFO 4  	/* TREE */
#define RMOVE 1  	/* OBJECT in TREE #0 */
#define OPTIONEN 3  	/* OBJECT in TREE #0 */
#define RMENU 4  	/* OBJECT in TREE #0 */
#define USEVDI 5  	/* OBJECT in TREE #0 */
#define USELA 6  	/* OBJECT in TREE #0 */
#define LOESCHEN 7  	/* OBJECT in TREE #0 */
#define KONTAKT 8  	/* OBJECT in TREE #0 */
#define TEXTMISC 10  	/* OBJECT in TREE #0 */
#define BUENDIG 11  	/* OBJECT in TREE #0 */
#define TEXTSEHE 13  	/* OBJECT in TREE #0 */
#define BLADEN 14  	/* OBJECT in TREE #0 */
#define TASCII 16  	/* OBJECT in TREE #0 */
#define TFONT 17  	/* OBJECT in TREE #0 */
#define VONR 18  	/* OBJECT in TREE #0 */
#define VON 19  	/* OBJECT in TREE #0 */
#define VONV 20  	/* OBJECT in TREE #0 */
#define MINI 22  	/* OBJECT in TREE #0 */
#define KLEIN 23  	/* OBJECT in TREE #0 */
#define GROSS 24  	/* OBJECT in TREE #0 */
#define BISR 27  	/* OBJECT in TREE #0 */
#define BIS 28  	/* OBJECT in TREE #0 */
#define BISV 29  	/* OBJECT in TREE #0 */
#define FETT 34  	/* OBJECT in TREE #0 */
#define HELL 36  	/* OBJECT in TREE #0 */
#define KURSIV 38  	/* OBJECT in TREE #0 */
#define OUTLINE 40  	/* OBJECT in TREE #0 */
#define TSTYLE 42  	/* OBJECT in TREE #0 */
#define FLERNENB 43  	/* OBJECT in TREE #0 */
#define FLERNEN 44  	/* OBJECT in TREE #0 */
#define STARTB 45  	/* OBJECT in TREE #0 */
#define START 46  	/* OBJECT in TREE #0 */
#define RINFO 47  	/* OBJECT in TREE #0 */
#define HILFE 48  	/* OBJECT in TREE #0 */
#define ENDE 49  	/* OBJECT in TREE #0 */
#define LERNCHAR 2  	/* OBJECT in TREE #1 */
#define TSICHERN 3  	/* OBJECT in TREE #2 */
#define TLOESCH 4  	/* OBJECT in TREE #2 */
#define TAUFHEB 5  	/* OBJECT in TREE #2 */
