/* Resource Datei Indizes f�r CI_RSC */

#define MENU1    0   /* Menuebaum */
#define MT1      3   /* TITLE in Baum MENU1 */
#define MT2      4   /* TITLE in Baum MENU1 */
#define MINFO    7   /* STRING in Baum MENU1 */
#define MENDE    16  /* STRING in Baum MENU1 */

#define DIALOG   1   /* Formular/Dialog */
#define COLICN2  2   /* USERDEF in Baum DIALOG */
#define COLICN1  3   /* USERDEF in Baum DIALOG */
#define S_VATER  4   /* BOX in Baum DIALOG */
#define S_SOHN   5   /* BUTTON in Baum DIALOG */
#define D_INFO   6   /* BOXTEXT in Baum DIALOG */
#define D_OKAY   7   /* BOXTEXT in Baum DIALOG */

#define EINFO    2   /* Formular/Dialog */
