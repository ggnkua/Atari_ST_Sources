#define DIALOG 0  	/* TREE */
#define OKAY 2  	/* OBJECT in TREE #0 */
#define ABBRUCH 3  	/* OBJECT in TREE #0 */
#define SICHERN 5  	/* OBJECT in TREE #0 */
#define HINTERGR 6  	/* OBJECT in TREE #0 */
#define S_LK3DIN 7  	/* OBJECT in TREE #0 */
#define S_LK3DAC 8  	/* OBJECT in TREE #0 */
#define S_INDBUT 9  	/* OBJECT in TREE #0 */
#define S_ACTBUT 10  	/* OBJECT in TREE #0 */
#define S_BACKGR 11  	/* OBJECT in TREE #0 */
#define S_AD3DVA 12  	/* OBJECT in TREE #0 */
#define WERTE 13  	/* OBJECT in TREE #0 */
#define WERT1 14  	/* OBJECT in TREE #0 */
#define S1WERT 15  	/* OBJECT in TREE #0 */
#define S1PLUS 16  	/* OBJECT in TREE #0 */
#define S1MINUS 17  	/* OBJECT in TREE #0 */
#define WERT2 19  	/* OBJECT in TREE #0 */
#define S2WERT 20  	/* OBJECT in TREE #0 */
#define S2PLUS 21  	/* OBJECT in TREE #0 */
#define S2MINUS 22  	/* OBJECT in TREE #0 */
