#define MENU 0  	/* TREE */
#define DIALOG 1  	/* TREE */
#define EINFO 2  	/* TREE */
#define HILFE 3  	/* TREE */
#define MINFO 8  	/* OBJECT in TREE #0 */
#define MENDE 17  	/* OBJECT in TREE #0 */
#define MFLADEN 18  	/* OBJECT in TREE #0 */
#define MFSICH 19  	/* OBJECT in TREE #0 */
#define MFEINGA 22  	/* OBJECT in TREE #0 */
#define MSTART 23  	/* OBJECT in TREE #0 */
#define MHILFE 25  	/* OBJECT in TREE #0 */
#define EZ1 2  	/* OBJECT in TREE #1 */
#define EFERTIG 4  	/* OBJECT in TREE #1 */
#define ESTART 5  	/* OBJECT in TREE #1 */
#define HFEXIT 6  	/* OBJECT in TREE #3 */
