/* calc.h */

#define TRUE 1
#define FALSE 0

int make_pcode(char *eingabe);
double evalute(double vari);
