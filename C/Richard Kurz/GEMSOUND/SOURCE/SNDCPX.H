#define DIALOG 0  	/* TREE */
#define PINFO 1  	/* TREE */
#define M_INFO 2  	/* OBJECT in TREE #0 */
#define M_OPTION 3  	/* OBJECT in TREE #0 */
#define VPLUS 7  	/* OBJECT in TREE #0 */
#define DISPLAY 8  	/* OBJECT in TREE #0 */
#define AES_NR 9  	/* OBJECT in TREE #0 */
#define SOUND 13  	/* OBJECT in TREE #0 */
#define FLAG 17  	/* OBJECT in TREE #0 */
#define VVATER 21  	/* OBJECT in TREE #0 */
#define VTEXT 22  	/* OBJECT in TREE #0 */
#define VMINUS 23  	/* OBJECT in TREE #0 */
#define OKAY 25  	/* OBJECT in TREE #0 */
#define ABBRUCH 26  	/* OBJECT in TREE #0 */
#define SICHERN 28  	/* OBJECT in TREE #0 */
