/* Resource Datei Indizes f�r AESD_RSC */

#define MENU1    0   /* Menuebaum */
#define MT1      3   /* TITLE in Baum MENU1 */
#define MT2      4   /* TITLE in Baum MENU1 */
#define MT3      5   /* TITLE in Baum MENU1 */
#define MINFO    8   /* STRING in Baum MENU1 */
#define MENDE    17  /* STRING in Baum MENU1 */
#define MTEST1   19  /* STRING in Baum MENU1 */
#define MTEST2   20  /* STRING in Baum MENU1 */
#define MDIDELAY 22  /* STRING in Baum MENU1 */
#define MDRDELAY 23  /* STRING in Baum MENU1 */
#define MCLDELAY 24  /* STRING in Baum MENU1 */
#define MSCDELAY 25  /* STRING in Baum MENU1 */
#define MSCHEIGHT 26  /* STRING in Baum MENU1 */

#define DIALOG   1   /* Formular/Dialog */
#define POPUP1   2   /* BOXTEXT in Baum DIALOG */
#define POPUP2   3   /* BOXTEXT in Baum DIALOG */
#define TOS_LOGO 4   /* IMAGE in Baum DIALOG */

#define EINFO    2   /* Formular/Dialog */

#define MENU2    3   /* Formular/Dialog */
#define SUBM1    1   /* BOX in Baum MENU2 */
#define SUBM2    8   /* BOX in Baum MENU2 */
#define DIDELAY  19  /* BOX in Baum MENU2 */
#define DID0     20  /* STRING in Baum MENU2 */
#define DID100   21  /* STRING in Baum MENU2 */
#define DID200   22  /* STRING in Baum MENU2 */
#define DID400   23  /* STRING in Baum MENU2 */
#define DID500   24  /* STRING in Baum MENU2 */
#define DRDELAY  25  /* BOX in Baum MENU2 */
#define DRD0     26  /* STRING in Baum MENU2 */
#define DRD1     27  /* STRING in Baum MENU2 */
#define DRD2     28  /* STRING in Baum MENU2 */
#define DRD5     29  /* STRING in Baum MENU2 */
#define DRD10    30  /* STRING in Baum MENU2 */
#define CLDELAY  31  /* BOX in Baum MENU2 */
#define CLD0     32  /* STRING in Baum MENU2 */
#define CLD125   33  /* STRING in Baum MENU2 */
#define CLD250   34  /* STRING in Baum MENU2 */
#define CLD500   35  /* STRING in Baum MENU2 */
#define CLD750   36  /* STRING in Baum MENU2 */
#define SCDELAY  37  /* BOX in Baum MENU2 */
#define SCD0     38  /* STRING in Baum MENU2 */
#define SCD100   39  /* STRING in Baum MENU2 */
#define SCD200   40  /* STRING in Baum MENU2 */
#define SCD400   41  /* STRING in Baum MENU2 */
#define SCD500   42  /* STRING in Baum MENU2 */
#define SCHEIGHT 43  /* BOX in Baum MENU2 */
#define SCH5     44  /* STRING in Baum MENU2 */
#define SCH8     45  /* STRING in Baum MENU2 */
#define SCH16    46  /* STRING in Baum MENU2 */
#define DPOPUP1  47  /* BOX in Baum MENU2 */
#define DPOPUP2  51  /* BOX in Baum MENU2 */
#define MPSUB    55  /* STRING in Baum MENU2 */
#define DSUBM1   56  /* BOX in Baum MENU2 */
