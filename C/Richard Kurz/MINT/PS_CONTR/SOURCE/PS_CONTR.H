/* Resource Datei Indizes f�r PS_CONTR */

#define DIALOG   0   /* Formular/Dialog */
#define DISPLAY  7   /* BOX in Baum DIALOG */
#define ZEILE1   8   /* TEXT in Baum DIALOG */
#define ZEILE17  24  /* TEXT in Baum DIALOG */
#define BYRK     26  /* BOXTEXT in Baum DIALOG */
#define HILFE    27  /* BOXTEXT in Baum DIALOG */
#define ALLE     29  /* BOXTEXT in Baum DIALOG */
#define NIX      30  /* BOXTEXT in Baum DIALOG */
#define D_PRIO   31  /* BOX in Baum DIALOG */
#define PLUS     32  /* BOXCHAR in Baum DIALOG */
#define MINUS    33  /* BOXCHAR in Baum DIALOG */
#define MIN      34  /* BOXTEXT in Baum DIALOG */
#define MAX      35  /* BOXTEXT in Baum DIALOG */
#define NORM     36  /* BOXTEXT in Baum DIALOG */
#define LOADSAVE 37  /* BOXTEXT in Baum DIALOG */
#define SIGNAL   38  /* BOXTEXT in Baum DIALOG */
#define D_SIGN   39  /* BOX in Baum DIALOG */
#define S_STOP   40  /* BOXTEXT in Baum DIALOG */
#define S_TSTP   41  /* BOXTEXT in Baum DIALOG */
#define S_CONT   42  /* BOXTEXT in Baum DIALOG */
#define S_KILL   43  /* BOXTEXT in Baum DIALOG */
#define S_TERM   44  /* BOXTEXT in Baum DIALOG */
#define ZURUECK  45  /* BOXTEXT in Baum DIALOG */
#define D_FILE   46  /* BOX in Baum DIALOG */
#define LOESCHEN 47  /* BOXTEXT in Baum DIALOG */
#define LOADI    48  /* BOXTEXT in Baum DIALOG */
#define ZURUECK2 49  /* BOXTEXT in Baum DIALOG */
#define SAVEI    50  /* BOXTEXT in Baum DIALOG */
#define ADDI     51  /* BOXTEXT in Baum DIALOG */

#define HELP     1   /* Formular/Dialog */
#define HFEXIT   13  /* BUTTON in Baum HELP */

#define PSINFO1  2   /* Formular/Dialog */
#define IPID     2   /* STRING in Baum PSINFO1 */
#define IPPID    4   /* STRING in Baum PSINFO1 */
#define ISTATUS  6   /* STRING in Baum PSINFO1 */
#define ITSTATUS 7   /* STRING in Baum PSINFO1 */
#define IPRI     9   /* STRING in Baum PSINFO1 */
#define ICURPRI  11  /* STRING in Baum PSINFO1 */
#define ISIZE    13  /* STRING in Baum PSINFO1 */
#define IPSYS    17  /* STRING in Baum PSINFO1 */
#define IPUSR    18  /* STRING in Baum PSINFO1 */
#define ICSYS    20  /* STRING in Baum PSINFO1 */
#define ICUSR    21  /* STRING in Baum PSINFO1 */

#define PSINFO2  3   /* Formular/Dialog */

#define PSINFO3  4   /* Formular/Dialog */

#define PSINFO4  5   /* Formular/Dialog */

#define EINFO    6   /* Formular/Dialog */
