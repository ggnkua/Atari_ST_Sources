/* Resource Datei Indizes f�r LINK_RSC */

#define DIALOG   0   /* Formular/Dialog */
#define SYMBLINK 1   /* BOXTEXT in Baum DIALOG */
#define READLINK 2   /* BOXTEXT in Baum DIALOG */
#define ENDE     4   /* BUTTON in Baum DIALOG */
#define HILFE    5   /* BUTTON in Baum DIALOG */
#define BYRK     6   /* BUTTON in Baum DIALOG */
#define LOESCHEN 7   /* BOXTEXT in Baum DIALOG */

#define MELDUNG  1   /* Formular/Dialog */
#define FZ1      1   /* TEXT in Baum MELDUNG */
#define FZ2      2   /* TEXT in Baum MELDUNG */
#define FZ3      3   /* TEXT in Baum MELDUNG */
#define FZ4      4   /* TEXT in Baum MELDUNG */

#define EINFO    2   /* Formular/Dialog */

#define HELP     3   /* Formular/Dialog */
