#define DIALOG 0  	/* TREE */
#define SPEEDER 1  	/* TREE */
#define SETRS232 2  	/* TREE */
#define PINFO 3  	/* TREE */
#define M_INFO 2  	/* OBJECT in TREE #0 */
#define M_SPEED 3  	/* OBJECT in TREE #0 */
#define RSSET 4  	/* OBJECT in TREE #0 */
#define SHIFTL 8  	/* OBJECT in TREE #0 */
#define SHIFTR 9  	/* OBJECT in TREE #0 */
#define CONTROL 10  	/* OBJECT in TREE #0 */
#define ALTERNAT 11  	/* OBJECT in TREE #0 */
#define DOPPELK 12  	/* OBJECT in TREE #0 */
#define TAUSCHEN 14  	/* OBJECT in TREE #0 */
#define JOYSTICK 17  	/* OBJECT in TREE #0 */
#define IBMMOUSE 21  	/* OBJECT in TREE #0 */
#define SFILE 22  	/* OBJECT in TREE #0 */
#define OKAY 24  	/* OBJECT in TREE #0 */
#define ABBRUCH 25  	/* OBJECT in TREE #0 */
#define SICHERN 27  	/* OBJECT in TREE #0 */
#define TEST 0  	/* OBJECT in TREE #1 */
#define KENNUNG 2  	/* OBJECT in TREE #1 */
#define VP1 6  	/* OBJECT in TREE #1 */
#define VP2 7  	/* OBJECT in TREE #1 */
#define VV1 12  	/* OBJECT in TREE #1 */
#define VT1 13  	/* OBJECT in TREE #1 */
#define VV2 14  	/* OBJECT in TREE #1 */
#define VT2 15  	/* OBJECT in TREE #1 */
#define VM1 24  	/* OBJECT in TREE #1 */
#define VM2 25  	/* OBJECT in TREE #1 */
#define FP1 31  	/* OBJECT in TREE #1 */
#define FV1 37  	/* OBJECT in TREE #1 */
#define FT1 38  	/* OBJECT in TREE #1 */
#define FM1 49  	/* OBJECT in TREE #1 */
#define OM 55  	/* OBJECT in TREE #1 */
#define OV 56  	/* OBJECT in TREE #1 */
#define OT 57  	/* OBJECT in TREE #1 */
#define OP 58  	/* OBJECT in TREE #1 */
#define LP 59  	/* OBJECT in TREE #1 */
#define RP 61  	/* OBJECT in TREE #1 */
#define SFLAG 62  	/* OBJECT in TREE #1 */
#define LV 63  	/* OBJECT in TREE #1 */
#define LT 64  	/* OBJECT in TREE #1 */
#define RV 65  	/* OBJECT in TREE #1 */
#define RT 66  	/* OBJECT in TREE #1 */
#define WFLAG 68  	/* OBJECT in TREE #1 */
#define LM 69  	/* OBJECT in TREE #1 */
#define RM 70  	/* OBJECT in TREE #1 */
#define UM 71  	/* OBJECT in TREE #1 */
#define UV 72  	/* OBJECT in TREE #1 */
#define UT 73  	/* OBJECT in TREE #1 */
#define UP 74  	/* OBJECT in TREE #1 */
#define ZURUECK 76  	/* OBJECT in TREE #1 */
#define ABBRUCH2 77  	/* OBJECT in TREE #1 */
#define MSYSTEM 5  	/* OBJECT in TREE #2 */
#define MICROSOF 6  	/* OBJECT in TREE #2 */
#define MODEM1 8  	/* OBJECT in TREE #2 */
#define MODEM2 9  	/* OBJECT in TREE #2 */
#define SERIELL1 10  	/* OBJECT in TREE #2 */
#define SERIELL2 11  	/* OBJECT in TREE #2 */
#define GLAETTEN 14  	/* OBJECT in TREE #2 */
#define ZURUECK3 16  	/* OBJECT in TREE #2 */
#define ABBRUCH3 17  	/* OBJECT in TREE #2 */
