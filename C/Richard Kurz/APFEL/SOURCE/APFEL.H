/* Resource Datei Indizes f�r APFEL */

#define MENU     0   /* Menuebaum */
#define MINFO    8   /* STRING in Baum MENU */
#define MENDE    17  /* STRING in Baum MENU */
#define MSTART   19  /* STRING in Baum MENU */
#define MZEIT    20  /* STRING in Baum MENU */
#define MPARA    22  /* STRING in Baum MENU */
#define MEPARA   23  /* STRING in Baum MENU */

#define DIALOG   1   /* Formular/Dialog */
#define EOK      8   /* BUTTON in Baum DIALOG */
#define REALMIN  9   /* FTEXT in Baum DIALOG */
#define IMAGMIN  10  /* FTEXT in Baum DIALOG */
#define REALMAX  11  /* FTEXT in Baum DIALOG */
#define IMAGMAX  12  /* FTEXT in Baum DIALOG */
#define RGRENZE  13  /* FTEXT in Baum DIALOG */
#define RTIEFE   14  /* FTEXT in Baum DIALOG */
#define EABBR    15  /* BUTTON in Baum DIALOG */

#define EINFO    2   /* Formular/Dialog */
