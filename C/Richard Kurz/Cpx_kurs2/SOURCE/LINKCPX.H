#define DIALOG 0  	/* TREE */
#define EDICON 1  	/* TREE */
#define LHEAD 1  	/* OBJECT in TREE #0 */
#define CINFO 2  	/* OBJECT in TREE #0 */
#define CTEXT 4  	/* OBJECT in TREE #0 */
#define E_ICON 5  	/* OBJECT in TREE #0 */
#define CICON 6  	/* OBJECT in TREE #0 */
#define CITEXT 7  	/* OBJECT in TREE #0 */
#define IVATER 11  	/* OBJECT in TREE #0 */
#define ITEXT 12  	/* OBJECT in TREE #0 */
#define IMINUS 13  	/* OBJECT in TREE #0 */
#define IPLUS 14  	/* OBJECT in TREE #0 */
#define TVATER 16  	/* OBJECT in TREE #0 */
#define TTEXT 17  	/* OBJECT in TREE #0 */
#define TMINUS 18  	/* OBJECT in TREE #0 */
#define TPLUS 19  	/* OBJECT in TREE #0 */
#define BOOTI 23  	/* OBJECT in TREE #0 */
#define SETO 24  	/* OBJECT in TREE #0 */
#define RAMRES 25  	/* OBJECT in TREE #0 */
#define CPXID 27  	/* OBJECT in TREE #0 */
#define CPXVER 28  	/* OBJECT in TREE #0 */
#define OKAY 32  	/* OBJECT in TREE #0 */
#define SICHERN 34  	/* OBJECT in TREE #0 */
#define IGROSS 1  	/* OBJECT in TREE #1 */
#define IRAHMEN 3  	/* OBJECT in TREE #1 */
#define IKLEIN 4  	/* OBJECT in TREE #1 */
#define IUP 5  	/* OBJECT in TREE #1 */
#define ILEFT 6  	/* OBJECT in TREE #1 */
#define IRIGHT 7  	/* OBJECT in TREE #1 */
#define IDOWN 8  	/* OBJECT in TREE #1 */
#define ISTRING 10  	/* OBJECT in TREE #1 */
#define DATEI 13  	/* OBJECT in TREE #1 */
#define IOK 14  	/* OBJECT in TREE #1 */
#define IABBRUCH 15  	/* OBJECT in TREE #1 */
#define IDEL 16  	/* OBJECT in TREE #1 */
#define IDEL2 17  	/* OBJECT in TREE #1 */
