
#define	FORM1	    0

#define name_field	    1
#define button_field	    2
#define title_field	    3
