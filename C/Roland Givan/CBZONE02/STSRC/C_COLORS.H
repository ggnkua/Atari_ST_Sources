/*
 * just keep track of the various color indices
 */

#define COLOR_BG	0       /* this has to be first */
#define COLOR_FG	1
#define COLOR_CURSOR	2
#define COLOR_CRACKS    3
#define COLOR_PSALVO	4
#define COLOR_XHAIR	5
#define COLOR_HORIZON	6
#define COLOR_MOON	7
#define COLOR_ESALVO	8
#define COLOR_TEXT	9
#define COLOR_JOYSTICK	10
#define COLOR_SCANNER	11
#define COLOR_TANK	12      /* the fading colors must follow ALL the */
#define COLOR_SUPER	13      /* nonfading colors */
#define COLOR_MISSILE	14
#define COLOR_COPTER	15
#define COLOR_LANDER	16
#define COLOR_CUBE	17
#define COLOR_PYRAMID	18

#define MAX_COLORS 19

#define FN_COLOR 0                      /* this section is derived */
#define LN_COLOR 11
#define FF_COLOR 12
#define LF_COLOR 18
#define L_COLOR 18

#define F1_COLOR 5
#define L1_COLOR 7
#define F2_COLOR 1
#define L2_COLOR 4
#define F3_COLOR 17
#define L3_COLOR 18
#define F4_COLOR 8
#define L4_COLOR 10
#define F5_COLOR 11
#define L5_COLOR 16
#define F6_COLOR 11
#define L6_COLOR 18
#define F7_COLOR 1
#define L7_COLOR 7
#define F8_COLOR 1
#define L8_COLOR 10
#define F9_COLOR 1
#define L9_COLOR 18


#define OUT_OF_DRAWING_RANGE 2000.0


