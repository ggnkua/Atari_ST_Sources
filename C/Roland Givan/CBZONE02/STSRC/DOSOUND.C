#include <osbind.h>
#include "c_include.h"

extern Optionp opt;

char explode[]={0x82,20,0,0,1,0,2,0,3,0,4,0,5,0,6,31,7,7,8,16,9,16,10,16,11,0,12,100,13,0,0x82,0};
char explode2[]={0,0,1,0,2,0,3,0,4,0,5,0,6,10,7,199,8,16,9,16,10,16,11,0,12,80,13,0,0x82,0};
char ping[]={0,65,1,0,2,0,3,0,4,0,5,0,6,0,7,62,8,16,9,0,10,0,11,0,12,16,13,9,0x82,0};
char shot[]={0,0,1,0,2,0,3,0,4,0,5,0,6,15,7,199,8,16,9,16,10,16,11,0,12,16,13,0,0x82,0};

char triple_ping[]={0,65,1,0,2,0,3,0,4,0,5,0,6,0,7,62,8,16,9,0,10,0,11,0,12,16,13,9,0x82,25,
			0,65,1,0,2,0,3,0,4,0,5,0,6,0,7,62,8,16,9,0,10,0,11,0,12,16,13,9,0x82,25,
			0,65,1,0,2,0,3,0,4,0,5,0,6,0,7,62,8,16,9,0,10,0,11,0,12,16,13,9,0x82,0};

char siren[]={0,0xfe,1,0,2,0,3,0,4,0,5,0,6,0,7,0xfe,8,11,9,0,10,0,11,0,12,0,13,0,0x82,10,
			0,0x56,1,1,0x82,10,0,0xfe,1,0,0x82,10,0,0x56,1,1,0x82,10,8,0,9,0,0x82,0};

void sound(char *data)
{
	if (opt->loud){
		Dosound(data);
	}
}