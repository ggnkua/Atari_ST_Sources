
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"
          
;*************************************************************************
;*
;* Graphics Library routines 4 of 5.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; graf_slidebox
;-------------------------------------------------------------------------

_graf_slidebox::
          .cargs    #4,.ptree.l,.intin
          AControl  76,3,1,1
          lea       .intin(sp),a1       ; -> intin
          lea       .ptree(sp),a0       ; -> addrin
          ACall     RET2USER
 
;         end of code

