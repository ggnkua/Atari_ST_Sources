
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"
          
;*************************************************************************
;*
;* FSel manager routine (old-style fsel'er)..
;*
;*************************************************************************

;-------------------------------------------------------------------------
; fsel_input
;-------------------------------------------------------------------------

_fsel_input::

          .cargs    #8,.ptr1.l,.ptr2.l,.button.l
          link      a6,#-4

          AControl  90,0,2,2

          moveq.l   #-4,d2       
          lea       .ptr1(a6),a0       ; -> addrin
          ACall     RET2HERE
          
          moveq.l   #-4,d1
          lea       .button(a6),a1
          jmp       (a0)
          
;         end of code

