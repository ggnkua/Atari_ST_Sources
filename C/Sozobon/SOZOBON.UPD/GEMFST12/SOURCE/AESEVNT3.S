
;*========================================================================
;*
;* AESFAST Public Domain GEM bindings.
;*
;*========================================================================

          .include  "aesfast.sh"

;*************************************************************************
;*
;* Event manager routines 4 of n.
;*
;*************************************************************************

;-------------------------------------------------------------------------
; evnt_timer
;-------------------------------------------------------------------------

_evnt_timer::
          .cargs    #4,.countlo,.counthi
          AControl  24,2,1,0
          lea       .countlo(sp),a1     ; -> intin
          ACall     RET2USER

;         end of code

