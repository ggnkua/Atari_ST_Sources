/* Copyright (c) 1988,1991 by Sozobon, Limited.  Author: Tony Andrews
 *
 * Permission is granted to anyone to use this software for any purpose
 * on any computer system, and to redistribute it freely, with the
 * following restrictions:
 * 1) No charge may be made other than reasonable charges for reproduction.
 * 2) Modified versions must be clearly marked as such.
 * 3) The authors are not responsible for any harmful consequences
 *    of using this software, even if they result from defects in it.
 */

/*
 * Mnemonics for the instructions.
 */

char	*opnames[] = {
	"or",
	"btst",
	"movep",
	"bchg",
	"bclr",
	"bset",
	"and",
	"sub",
	"add",
	"eor",
	"cmp",
	"move",
	"negx",
	"chk",
	"lea",
	"clr",
	"neg",
	"not",
	"nbcd",
	"swap",
	"pea",
	"ext",
	"movem",
	"tst",
	"tas",
	"trap",
	"link",
	"unlk",
	"reset",
	"nop",
	"stop",
	"rte",
	"rts",
	"trapv",
	"rtr",
	"jsr",
	"jmp",
	"addq",
	"st",
	"dbt",
	"subq",
	"sf",
	"dbra",		/* also dbf */
	"shi",
	"dbhi",
	"sls",
	"dbls",
	"scc",
	"dbcc",
	"scs",
	"dbcs",
	"sne",
	"dbne",
	"seq",
	"dbeq",
	"svc",
	"dvc",
	"svs",
	"dvs",
	"spl",
	"smi",
	"dbmi",
	"sge",
	"dbge",
	"slt",
	"dblt",
	"sgt",
	"dbgt",
	"sle",
	"dble",
	"bra",
	"bsr",
	"bhi",
	"bls",
	"bcc",
	"bcs",
	"bne",
	"beq",
	"bvc",
	"bvs",
	"bpl",
	"bmi",
	"bge",
	"blt",
	"bgt",
	"ble",
	"moveq",
	"divu",
	"sbcd",
	"divs",
	"subx",
	"cmpm",
	"mulu",
	"abcd",
	"exg",
	"muls",
	"addx",
	"asr",
	"lsr",
	"roxr",
	"ror",
	"asl",
	"lsl",
	"roxl",
	"rol",
/*
 * Pseudo-ops that show up in text sections
 */
	".dc",
	(char *) 0
};
