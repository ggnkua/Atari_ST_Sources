#ifndef _FCNTL_H
#include <fcntl.h>
#endif
