
/* 
 * cpp config file
 * Sample CPP config file; emulates the preprocessor constants provided
 * by Sozobon 2.0 eXtended version, hcc patchlevel 27
 */

#pragma CPP_cmdline_arg -fc++-comments

#define MC68000		1
#define mc68000		1
#define ATARI_ST	1
#define TOS		1
#define __TOS__		1
#define SOZOBON		0x200
#define __SOZOBONX__	0x234
#define __MSHORT__	1
#define	__STDC__	0
