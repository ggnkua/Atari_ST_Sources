
/* 
 * cpp config file
 * 
 * 
 */

#pragma CPP_cmdline_arg -fc++-comments


