/* Resource Datei Indizes f�r MAGICDEM */

#define Menutree         0   /* Menuebaum */
#define Infomenu         3   /* TITLE in Baum MENUTREE */
#define Dateimenu        4   /* TITLE in Baum MENUTREE */
#define Optionmenu       5   /* TITLE in Baum MENUTREE */
#define Demomenu         6   /* TITLE in Baum MENUTREE */
#define Infodial         9   /* STRING in Baum MENUTREE */
#define Fensterauf       18  /* STRING in Baum MENUTREE */
#define Fensterzu        19  /* STRING in Baum MENUTREE */
#define Linesdemo        20  /* STRING in Baum MENUTREE */
#define Runprogram       22  /* STRING in Baum MENUTREE */
#define Quit             24  /* STRING in Baum MENUTREE */
#define Selectfont       26  /* STRING in Baum MENUTREE */
#define Buttons          28  /* STRING in Baum MENUTREE */
#define Strings          29  /* STRING in Baum MENUTREE */
#define Frameboxen       30  /* STRING in Baum MENUTREE */
#define Listboxen        31  /* STRING in Baum MENUTREE */
#define Editfeld         32  /* STRING in Baum MENUTREE */
#define Slider           33  /* STRING in Baum MENUTREE */
#define Boxes            34  /* STRING in Baum MENUTREE */
#define Popups           35  /* STRING in Baum MENUTREE */
#define Alertbox         36  /* STRING in Baum MENUTREE */
#define Coloricons       37  /* STRING in Baum MENUTREE */
#define Ibutton          38  /* STRING in Baum MENUTREE */
#define Rcards           39  /* STRING in Baum MENUTREE */

#define Infodialog       1   /* Formular/Dialog */
#define Release          2   /* STRING in Baum INFODIALOG */
#define Moremagic        8   /* BUTTON in Baum INFODIALOG */
#define Magicok          9   /* BUTTON in Baum INFODIALOG */
#define Magiclogo        10  /* IMAGE in Baum INFODIALOG */

#define Editdialog       2   /* Formular/Dialog */
#define Editok           10  /* BUTTON in Baum EDITDIALOG */

#define Sliderdialog     3   /* Formular/Dialog */
#define Sliderok         15  /* BUTTON in Baum SLIDERDIALOG */

#define Listboxdialog    4   /* Formular/Dialog */
#define Listbox1         2   /* BOX in Baum LISTBOXDIALOG */
#define Sliderup         14  /* BOXCHAR in Baum LISTBOXDIALOG */
#define Sliderdown       17  /* BOXCHAR in Baum LISTBOXDIALOG */
#define Dropbox1         19  /* BUTTON in Baum LISTBOXDIALOG */
#define Dropcircle1      20  /* BOXCHAR in Baum LISTBOXDIALOG */
#define Listbox2         23  /* BOX in Baum LISTBOXDIALOG */
#define Slup             35  /* BOXCHAR in Baum LISTBOXDIALOG */
#define Sldown           38  /* BOXCHAR in Baum LISTBOXDIALOG */
#define Searchinput      39  /* FBOXTEXT in Baum LISTBOXDIALOG */
#define Deselect         40  /* BUTTON in Baum LISTBOXDIALOG */
#define Listboxok        41  /* BUTTON in Baum LISTBOXDIALOG */
#define Checkmode        45  /* BUTTON in Baum LISTBOXDIALOG */

#define Popupdial        5   /* Formular/Dialog */

#define Subpop1          6   /* Formular/Dialog */

#define Subpop2          7   /* Formular/Dialog */

#define Magicbuttons     8   /* Formular/Dialog */
#define Mb_default       3   /* BUTTON in Baum MAGICBUTTONS */
#define Mb_gback         4   /* BUTTON in Baum MAGICBUTTONS */
#define Mb_gem           5   /* BUTTON in Baum MAGICBUTTONS */
#define Mb_exit          6   /* BUTTON in Baum MAGICBUTTONS */
#define Mb_radio         7   /* BUTTON in Baum MAGICBUTTONS */
#define Mb_indicator     8   /* BUTTON in Baum MAGICBUTTONS */
#define Mb_activator     9   /* BUTTON in Baum MAGICBUTTONS */
#define Mb_selected      10  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_crossed       11  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_mback         12  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_magic         13  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_checked       14  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_disabled      15  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_outlined      16  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_shadowed      17  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_whitebak      18  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_draw3d        19  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state8        20  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_ok            21  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state9        22  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state10       23  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state11       24  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state12       25  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state13       26  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state14       27  /* BUTTON in Baum MAGICBUTTONS */
#define Mb_state15       28  /* BUTTON in Baum MAGICBUTTONS */

#define Magicstrings     9   /* Formular/Dialog */
#define Ms_indicator     2   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_selected      3   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_crossed       4   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_checked       5   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_disabled      6   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_outlined      7   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_shadowed      8   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_whitebak      9   /* BUTTON in Baum MAGICSTRINGS */
#define Ms_draw3d        10  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_activator     11  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state8        12  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state9        13  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state10       14  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state11       15  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state12       16  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state13       17  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state14       18  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_state15       19  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_gback         20  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_gem           21  /* STRING in Baum MAGICSTRINGS */
#define Ms_mback         22  /* BUTTON in Baum MAGICSTRINGS */
#define Ms_magic         23  /* STRING in Baum MAGICSTRINGS */
#define Ms_ok            24  /* BUTTON in Baum MAGICSTRINGS */

#define Magicframes      10  /* Formular/Dialog */
#define Mf_activator     2   /* BUTTON in Baum MAGICFRAMES */
#define Mf_selected      3   /* BUTTON in Baum MAGICFRAMES */
#define Mf_crossed       4   /* BUTTON in Baum MAGICFRAMES */
#define Mf_checked       5   /* BUTTON in Baum MAGICFRAMES */
#define Mf_disabled      6   /* BUTTON in Baum MAGICFRAMES */
#define Mf_outlined      7   /* BUTTON in Baum MAGICFRAMES */
#define Mf_shadowed      8   /* BUTTON in Baum MAGICFRAMES */
#define Mf_whitebak      9   /* BUTTON in Baum MAGICFRAMES */
#define Mf_draw3d        10  /* BUTTON in Baum MAGICFRAMES */
#define Mf_indicator     11  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state8        12  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state9        13  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state10       14  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state11       15  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state12       16  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state13       17  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state14       18  /* BUTTON in Baum MAGICFRAMES */
#define Mf_state15       19  /* BUTTON in Baum MAGICFRAMES */
#define Mf_back          20  /* BUTTON in Baum MAGICFRAMES */
#define Mf_frame         21  /* BUTTON in Baum MAGICFRAMES */
#define Mf_ok            22  /* BUTTON in Baum MAGICFRAMES */

#define Magicboxes       11  /* Formular/Dialog */
#define Mx_indicator     2   /* BUTTON in Baum MAGICBOXES */
#define Mx_selected      3   /* BUTTON in Baum MAGICBOXES */
#define Mx_crossed       4   /* BUTTON in Baum MAGICBOXES */
#define Mx_checked       5   /* BUTTON in Baum MAGICBOXES */
#define Mx_disabled      6   /* BUTTON in Baum MAGICBOXES */
#define Mx_outlined      7   /* BUTTON in Baum MAGICBOXES */
#define Mx_shadowed      8   /* BUTTON in Baum MAGICBOXES */
#define Mx_whitebak      9   /* BUTTON in Baum MAGICBOXES */
#define Mx_draw3d        10  /* BUTTON in Baum MAGICBOXES */
#define Mx_activator     11  /* BUTTON in Baum MAGICBOXES */
#define Mx_state8        12  /* BUTTON in Baum MAGICBOXES */
#define Mx_state9        13  /* BUTTON in Baum MAGICBOXES */
#define Mx_state10       14  /* BUTTON in Baum MAGICBOXES */
#define Mx_state11       15  /* BUTTON in Baum MAGICBOXES */
#define Mx_state12       16  /* BUTTON in Baum MAGICBOXES */
#define Mx_state13       17  /* BUTTON in Baum MAGICBOXES */
#define Mx_state14       18  /* BUTTON in Baum MAGICBOXES */
#define Mx_state15       19  /* BUTTON in Baum MAGICBOXES */
#define Mx_back          20  /* BUTTON in Baum MAGICBOXES */
#define Mx_box           21  /* BOX in Baum MAGICBOXES */
#define Mx_ok            22  /* BUTTON in Baum MAGICBOXES */

#define Farbicons        12  /* Formular/Dialog */
#define Colorok          2   /* BUTTON in Baum FARBICONS */
#define Coloricon        3   /* USERDEF in Baum FARBICONS */

#define Iconbutton       13  /* Formular/Dialog */
#define Ibuttok          2   /* BUTTON in Baum ICONBUTTON */

#define Toolbox          14  /* Formular/Dialog */
#define Tbtcol           1   /* STRING in Baum TOOLBOX */
#define Tbhcol           2   /* STRING in Baum TOOLBOX */
#define Tb1              3   /* ICON in Baum TOOLBOX */
#define Tb2              4   /* ICON in Baum TOOLBOX */
#define Tb3              5   /* ICON in Baum TOOLBOX */
#define Tbtf             6   /* BUTTON in Baum TOOLBOX */
#define Tbhf             8   /* BUTTON in Baum TOOLBOX */

#define Register         15  /* Formular/Dialog */
#define Rcbutton         3   /* BUTTON in Baum REGISTER */
