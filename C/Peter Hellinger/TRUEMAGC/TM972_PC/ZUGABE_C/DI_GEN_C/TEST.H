/* Resource Datei Indizes f�r TEST */

#define MAIN_DIAL 0   /* Formular/Dialog */
#define MODE_NORMAL 2   /* BUTTON in Baum MAIN_DIAL */
#define MODE_SPEZIAL 3   /* BUTTON in Baum MAIN_DIAL */
#define MODE_FLYDIAL 4   /* BUTTON in Baum MAIN_DIAL */
#define MODE_MODAL 5   /* BUTTON in Baum MAIN_DIAL */
#define MODE_NONMODAL 6   /* BUTTON in Baum MAIN_DIAL */
#define USE_INFO 8   /* BUTTON in Baum MAIN_DIAL */
#define USE_RSC  11  /* BUTTON in Baum MAIN_DIAL */
#define USE_OBJ  12  /* BUTTON in Baum MAIN_DIAL */
#define DIAL_TITEL 15  /* FTEXT in Baum MAIN_DIAL */
#define DIAL_ABBRUCH 16  /* BUTTON in Baum MAIN_DIAL */
#define DIAL_OK  17  /* BUTTON in Baum MAIN_DIAL */
