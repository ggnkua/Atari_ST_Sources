/*
   diese Datei includet alle zur C-Version von Magic geh”renden Headerfiles
   
   geschrieben von Thomas K�nneth
   Friedrich-Neuper-Str. 2b
   90552 R”thenbach
   
   Diese Datei ist Bestandteil der C-Version von Magic 4.0 von
   Peter Hellinger und Thomas K�nneth und darf nur gem„ž den
   Nutzungsbedingungen von Magic f�r C verwendet werden
   
   Alle Rechte beim Autor
*/

#ifdef COLICN_HEADER
#include <magic\m_colicn.h>
#endif

#include <magic\m_types.h>
#include <magic\m_sys.h>
#include <magic\m_appl.h>
#include <magic\m_dials.h>
#include <magic\m_alerts.h>
#include <magic\m_area.h>
#include <magic\m_asctab.h>
#include <magic\m_event.h>
#include <magic\m_fonts.h>
#include <magic\m_fontse.h>
#include <magic\m_makros.h>
#include <magic\m_menus.h>
#include <magic\m_messag.h>
#include <magic\m_msgfil.h>
#include <magic\m_popups.h>
#include <magic\m_random.h>
#include <magic\m_rsc.h>
#include <magic\m_string.h>
#include <magic\m_termin.h>
#include <magic\m_time.h>
#include <magic\m_utils.h>
#include <magic\m_window.h>
#include <magic\m_xobjec.h>
#include <magic\m_profil.h>
#include <magic\m_advanc.h>

#ifndef NO_EXT
#include <magic\m_xtrnl.h>
#endif
