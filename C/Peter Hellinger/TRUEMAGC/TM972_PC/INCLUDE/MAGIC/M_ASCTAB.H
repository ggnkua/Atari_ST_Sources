/*
   Modul: M_ASCTAB (Headerdatei)

   geschrieben von Thomas K�nneth
   Friedrich-Neuper-Str. 2b
   90552 R”thenbach

   Diese Datei ist Bestandteil der C-Version von Magic 4.0 von
   Peter Hellinger und Thomas K�nneth und darf nur gem„ž den
   Nutzungsbedingungen von Magic f�r C verwendet werden

   Alle Rechte beim Autor
*/

#ifndef _MPASCTAB_
#define _MPASCTAB_

#ifndef _MAGICTYP_
#include <magic\m_types.h>
#endif

char AsciiTable(GRECT *rect);

#endif