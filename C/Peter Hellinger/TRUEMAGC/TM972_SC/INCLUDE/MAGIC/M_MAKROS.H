/*
   M_MAKROS.H
   
   geschrieben 1993 von:
   Thomas K�nneth
   Friedrich-Neuper-Str. 2b
   90552 R”thenbach
   
   diese Datei ist Bestandteil der C-Version von Magic 4.0
   von Peter Hellinger und Thomas K�nneth
*/

#ifndef MIN
#define  MIN(x,y) ((x<y)?x:y)
#endif

#ifndef MAX
#define  MAX(x,y) ((x>y)?x:y)
#endif
