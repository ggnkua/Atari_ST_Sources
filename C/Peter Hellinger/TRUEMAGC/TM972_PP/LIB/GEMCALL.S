; +---------------------------------------------------------------------
; |  Exported symbols
; +---------------------------------------------------------------------

        .EXPORT callgem
        .EXPORT GetD0

        MC68000        


callgem:        MOVE.L  A0, D1
                TRAP    #2
                RTS

GetD0:          RTS