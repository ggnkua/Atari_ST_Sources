{ Compileroptionen  PurePascal 1.1 }
{                                  }
{$R-  Rangecheck                   }    
{$S-  Stackcheck                   }
{$I-  I/O-Check                    }
{$V-  VAR-String-Check             }
{$B-  Boolean Evaluation           }
{$X+  Extended Syntax              }
{                                  }