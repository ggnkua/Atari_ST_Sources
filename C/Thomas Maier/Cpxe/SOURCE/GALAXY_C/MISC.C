
/* Koordinaten der Sterne und Sinustabelle und Objektbaum */

#include <aes.h>

WORD stars[] = {
-12,-30,
-8,-29,
7,-29,
12,-29,
18,-29,
-19,-28,
3,-28,
21,-27,
-22,-26,
-18,-26,
-1,-25,
9,-25,
12,-25,
2,-24,
6,-24,
11,-24,
14,-24,
18,-24,
-19,-23,
-24,-21,
-10,-21,
1,-21,
14,-21,
-26,-20,
-15,-20,
-20,-19,
-4,-19,
-1,-19,
-13,-18,
8,-18,
-1,-17,
-26,-16,
-21,-15,
16,-14,
22,-14,
-31,-13,
-26,-13,
-4,-13,
-17,-12,
0,-12,
20,-12,
-10,-11,
-1,-11,
-26,-10,
1,-9,
10,-9,
-25,-8,
1,-8,
-22,-7,
-2,-7,
0,-7,
13,-7,
-23,-5,
-12,-5,
-2,-5,
22,-5,
-19,-3,
1,-3,
2,-3,
-26,-2,
2,-2,
-18,-1,
-3,-1,
-1,-1,
1,-1,
7,-1,
12,-1,
15,-1,
-21,0,
-6,0,
0,0,
1,0,
2,0,
4,0,
7,0,
18,0,
-10,1,
-2,1,
-1,1,
12,1,
-7,2,
0,2,
2,2,
3,2,
28,2,
-17,3,
-1,3,
1,3,
15,3,
16,3,
21,3,
-12,4,
0,4,
1,4,
5,4,
23,5,
22,6,
-22,7,
0,7,
21,7,
26,7,
-28,8,
5,8,
26,8,
-15,9,
-2,9,
28,9,
-11,10,
0,10,
8,10,
23,10,
-13,11,
25,11,
28,11,
-2,12,
-24,13,
26,13,
30,13,
-22,14,
-4,14,
-20,15,
-6,15,
11,16,
18,16,
28,16,
-15,17,
27,17,
-13,18,
-10,18,
9,18,
11,18,
3,19,
9,19,
22,19,
-25,21,
27,21,
26,22,
-10,23,
12,23,
-17,24,
-15,24,
-14,24,
-13,24,
-9,24,
-12,25,
-9,25,
8,25,
10,25,
-12,26,
-10,26,
-14,27,
-13,27,
-12,27,
-11,27,
-5,27,
-1,27,
5,27,
19,27,
-18,28,
-16,28,
-14,28,
-13,28,
-12,28,
-11,28,
-10,28,
-13,29,
-12,29,
-8,29,
-3,29,
23,29,
-6,30,
1,30,
-19,31,
-13,31,
-12,32
};

WORD num_stars = 175;
WORD bild_w = 80, bild_h = 40;


WORD sintab[] = {
0,256,
22,255,
44,252,
66,247,
87,240,
108,232,
128,221,
146,209,
164,196,
181,181,
196,164,
209,146,
221,128,
232,108,
240,87,
247,66,
252,44,
255,22,
256,0,
255,-22,
252,-44,
247,-66,
240,-87,
232,-108,
221,-127,
209,-146,
196,-164,
181,-181,
164,-196,
146,-209,
127,-221,
108,-232,
87,-240,
66,-247,
44,-252,
22,-255,
0,-256,
-22,-255,
-44,-252,
-66,-247,
-87,-240,
-108,-232,
-128,-221,
-146,-209,
-164,-196,
-181,-181,
-196,-164,
-209,-146,
-221,-128,
-232,-108,
-240,-87,
-247,-66,
-252,-44,
-255,-22,
-256,0,
-255,22,
-252,44,
-247,66,
-240,87,
-232,108,
-221,128,
-209,146,
-196,164,
-181,181,
-164,196,
-146,209,
-128,221,
-108,232,
-87,240,
-66,247,
-44,252,
-22,255
};

UWORD image[200];
BITBLK bitblk = { image, 10, 40, 0, 0, WHITE };
OBJECT tree[] = { 
{ -1, 1, 1, G_BOX, 0, 0, {(void*)0x71L}, 0, 0, 80, 40 },
{ 0, -1, -1, G_IMAGE, LASTOB, 0, {(void*)&bitblk}, 0, 0, 80, 40 } };

