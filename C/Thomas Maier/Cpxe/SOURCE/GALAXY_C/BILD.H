/* resource set indices for BILD */

#define BILD       0 /* Free image */

