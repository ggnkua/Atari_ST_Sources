
#define SINSTEP 5
#define MATHOFFSET 256

extern WORD num_stars;
extern WORD bild_w,bild_h;

extern WORD sintab[];

extern WORD stars[];

extern UWORD image[];
extern BITBLK bitblk;
extern OBJECT tree[];