/***** GEM C Resource File ****
 * built from input resource file   'dog-rsc.rsc'   with
 * krsc2c  V 1.05  Copyright (c) 1995,1996 ToMST, Thomas Maier, 07.09.96
 *   (GEM Resource File to C Converter)
 */

#define __RSC_RELATIV 0
#define __RSC_ABSOLUT 1
#define __RSC_ABSOLUT_MIN 2

/* mode that was used to built this file */
#define __RSC_mode __RSC_ABSOLUT_MIN

#include <aes.h>


TEDINFO rs_tedinfo[] = {};

static UWORD rs_bitmap_0[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0003, 0xc000,
 0x0001, 0x41e0, 0x0001, 0x2120, 0x0001, 0x5140, 0x0000, 0x9380,
 0x0001, 0xccc0, 0x0001, 0x1b40, 0x0001, 0x5f40, 0x0001, 0x1b20,
 0x0003, 0x45e0, 0x0003, 0x13e0, 0x0002, 0x47e0, 0x0003, 0x13e0,
 0x0007, 0xc5e0, 0x000f, 0x9120, 0x001c, 0xc6e0, 0x003f, 0xb1c0,
 0x042c, 0xefc0, 0x0c7d, 0x1a00, 0x0ec4, 0x4600, 0x0b91, 0x1200,
 0x0f45, 0xc600, 0x0d13, 0x9300, 0x014c, 0xd500, 0x033f, 0x9300,
 0x027d, 0xd500, 0x031f, 0x19c0, 0x0245, 0xcc60, 0x0375, 0x1520,
 0x075d, 0xc660, 0x03ff, 0xf940, 0x0000, 0x3800, 0x0000, 0x0000};

static UWORD rs_bitmap_1[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x01c0, 0x0000, 0x0680, 0x0000, 0x0b00, 0x0000, 0x1900,
 0x0080, 0x1738, 0x0100, 0x1950, 0x0600, 0x27e0, 0x0500, 0x28a0,
 0x0700, 0x6340, 0x0500, 0xcbc0, 0x0700, 0xe33c, 0x0581, 0x88be,
 0x06ff, 0x623e, 0x01dd, 0x88be, 0x027e, 0x621e, 0x0288, 0xd89c,
 0x0622, 0x7e24, 0x0588, 0x9f8c, 0x0622, 0x27f8, 0x0588, 0x8c00,
 0x0622, 0x2800, 0x0398, 0x9800, 0x0266, 0x6800, 0x01ff, 0xd800,
 0x06ea, 0x6800, 0x08ff, 0xbb00, 0x0e36, 0x2680, 0x189b, 0x8c80,
 0x2e36, 0x2680, 0x1ffd, 0xfb80, 0x0000, 0x0000, 0x0000, 0x0000};

static UWORD rs_bitmap_2[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x01c0, 0x0000, 0x0680, 0x0000, 0x0b00, 0x0000, 0x1900,
 0x0000, 0x1738, 0x0000, 0x1950, 0x0000, 0x27e0, 0x0000, 0x28a0,
 0x3000, 0x6340, 0x3c00, 0xcbc0, 0x1b00, 0xe33c, 0x0c81, 0x88be,
 0x06ff, 0x623e, 0x03dd, 0x88be, 0x027e, 0x621e, 0x0288, 0xd89c,
 0x0622, 0x7e24, 0x0588, 0x9f8c, 0x0622, 0x27f8, 0x0588, 0x8c00,
 0x0622, 0x2800, 0x0398, 0x9800, 0x0266, 0x6800, 0x01ff, 0xd800,
 0x06ea, 0x6800, 0x08ff, 0xbb00, 0x0e36, 0x2680, 0x189b, 0x8c80,
 0x2e36, 0x2680, 0x1ffd, 0xfb80, 0x0000, 0x0000, 0x0000, 0x0000};

static UWORD rs_bitmap_3[] = {
 0x0000, 0x0000, 0x0000, 0x0200, 0x0000, 0x0500, 0x0000, 0x0500,
 0x0000, 0x0d10, 0x0000, 0x0bb0, 0x0000, 0x0ca8, 0x0000, 0x19b0,
 0x0000, 0x1ce0, 0x0000, 0x31b0, 0x0000, 0x25e0, 0x0000, 0x31a0,
 0x0000, 0x445e, 0x0000, 0x911f, 0x0001, 0xc45f, 0x0007, 0xb11f,
 0x007e, 0xec4e, 0x01ff, 0x3bfa, 0x017c, 0x4fce, 0x0311, 0x191a,
 0x0c44, 0x444c, 0x1311, 0x1310, 0xe6c4, 0x4e50, 0x1b13, 0x3360,
 0x02cc, 0xedc0, 0x0318, 0x3300, 0x01d8, 0x2e00, 0x0330, 0x1800,
 0x0640, 0x0000, 0x0770, 0x0000, 0x0448, 0x0000, 0x2719, 0x0000,
 0x4448, 0x8000, 0x27f1, 0x1000, 0x0000, 0x0000, 0x0ad8, 0x0000};

static UWORD rs_bitmap_4[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x1800,
 0x0000, 0x0e00, 0x0000, 0x0720, 0x0000, 0x08b0, 0x0000, 0x0ab0,
 0x0000, 0x1df0, 0x0000, 0x3230, 0x0000, 0x38e0, 0x0600, 0x62e0,
 0x1980, 0x48de, 0x2e40, 0xe23f, 0x03a1, 0x889f, 0x033f, 0xe23f,
 0x079d, 0xd88f, 0x0f2e, 0x7e2e, 0x1988, 0x9d9c, 0x2222, 0x2ef4,
 0x5888, 0x8f9c, 0x6222, 0x2e6e, 0x4898, 0x8cc9, 0x7e36, 0x6649,
 0x39b9, 0xf899, 0x12ef, 0xca22, 0x0e88, 0x0db2, 0x0070, 0x0776,
 0x0000, 0x0198, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x1111, 0x1000, 0x2222, 0x2000, 0x0000, 0x0000, 0x0000, 0x0000};

static UWORD rs_bitmap_5[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x3800, 0x0000, 0x1600, 0x0000, 0x1160, 0x0000, 0x0aa0,
 0x0000, 0x19b0, 0x0000, 0x1660, 0x0000, 0x18d0, 0x0700, 0x22e0,
 0x1880, 0x28e0, 0x3e40, 0x623e, 0x03a0, 0x889f, 0x0221, 0x623f,
 0x01bf, 0xd89f, 0x0737, 0x662e, 0x099c, 0x999a, 0x1222, 0x3636,
 0x3988, 0x9ffc, 0x6222, 0x2700, 0x8898, 0x9cf0, 0x6222, 0x273c,
 0x3b98, 0x8bac, 0x277e, 0x626a, 0x19ff, 0x989a, 0x0e68, 0x0e96,
 0x0078, 0x0da4, 0x0000, 0x0668, 0x0000, 0x0190, 0x0000, 0x0060,
 0x1111, 0x1100, 0x2222, 0x2200, 0x0000, 0x0000, 0x0000, 0x0000};

static UWORD rs_bitmap_6[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x7000, 0x0000, 0x2c00,
 0x0000, 0x1280, 0x0000, 0x1540, 0x0000, 0x3160, 0x0000, 0x26c0,
 0x0600, 0x39a0, 0x1d80, 0x45c0, 0x0580, 0x51c0, 0x02c0, 0xc47c,
 0x0361, 0x113e, 0x027e, 0xc47e, 0x033b, 0xb13e, 0x1e4c, 0xcc5c,
 0x3711, 0x3334, 0x4444, 0x6c6c, 0x9111, 0x3ff8, 0xc444, 0x4e00,
 0x9311, 0x3800, 0xcfdc, 0x69c0, 0x7bfb, 0x1f30, 0x2ccf, 0xccd0,
 0x3133, 0x9190, 0x0e01, 0xc520, 0x0001, 0x3260, 0x0001, 0x5cc0,
 0x2223, 0x3900, 0x4445, 0xfe00, 0x0000, 0x0000, 0x0000, 0x0000};

ICONBLK rs_iconblk[] = {};

BITBLK rs_bitblk[] = {
{ rs_bitmap_0, 4, 36, 0, 0, 1 },
{ rs_bitmap_1, 4, 36, 0, 0, 1 },
{ rs_bitmap_2, 4, 36, 0, 0, 1 },
{ rs_bitmap_3, 4, 36, 0, 0, 1 },
{ rs_bitmap_4, 4, 36, 0, 0, 1 },
{ rs_bitmap_5, 4, 36, 0, 0, 1 },
{ rs_bitmap_6, 4, 36, 0, 0, 1 }};

char *rs_frstr[] = {};

BITBLK *rs_frimg[] = {};

OBJECT rs_object[] = {
{ -1, 1, 7, 0x14, 0x0000, 0x0000, (void *)0x11100, 0x0001, 0x0001, 0x0025, 0x0003 },
{ 2, -1, -1, 0x17, 0x0000, 0x0000, (void *)&rs_bitblk[0], 0x0000, 0x0000, 0x2000, 0x2400 },
{ 3, -1, -1, 0x17, 0x0000, 0x0000, (void *)&rs_bitblk[1], 0x0005, 0x0000, 0x2000, 0x2400 },
{ 4, -1, -1, 0x17, 0x0000, 0x0000, (void *)&rs_bitblk[2], 0x000b, 0x0000, 0x2000, 0x2400 },
{ 5, -1, -1, 0x17, 0x0000, 0x0000, (void *)&rs_bitblk[3], 0x0011, 0x0000, 0x2000, 0x2400 },
{ 6, -1, -1, 0x17, 0x0000, 0x0000, (void *)&rs_bitblk[4], 0x0017, 0x0000, 0x2000, 0x2400 },
{ 7, -1, -1, 0x17, 0x0000, 0x0000, (void *)&rs_bitblk[5], 0x001c, 0x0000, 0x2000, 0x2400 },
{ 0, -1, -1, 0x17, 0x0020, 0x0000, (void *)&rs_bitblk[6], 0x0021, 0x0000, 0x2000, 0x2400 }};

OBJECT *rs_trindex[] = {
 &rs_object[0]};

