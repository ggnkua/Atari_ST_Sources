/* resource set indices for EYES */

#define OTEYES     0 /* form/dialog */
#define OBACK      0 /* BOX in tree OTEYES */
#define OEYES      1 /* IMAGE in tree OTEYES */
#define OPUPS      2 /* IBOX in tree OTEYES */
#define OPUP2      3 /* IMAGE in tree OTEYES */
#define OPUP1      4 /* IMAGE in tree OTEYES */

