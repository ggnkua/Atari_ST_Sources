
/* EYES.H    allgemeine Einstellungen */


#define SINTABMAX 90
#define TANTABMAX 89

#define MATHOFFSET  256L

extern WORD sintab[];
extern WORD tantab[];

