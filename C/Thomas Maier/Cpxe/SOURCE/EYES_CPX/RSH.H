/*++++ GEM C Resource HEADER File ++++
 * built from input resource file   'eyes.rsc'   with
 * krsc2c  V 1.05  Copyright (c) 1995,1996 ToMST, Thomas Maier, 07.09.96
 *   (GEM Resource File to C Converter)
 */

#define __RSC_RELATIV 0
#define __RSC_ABSOLUT 1
#define __RSC_ABSOLUT_MIN 2

/* mode that was used to built this file */
#define __RSC_mode __RSC_ABSOLUT_MIN

/* numbers of each element */
#define NUM_TEDINFO 0
#define NUM_ICONBLK 0
#define NUM_BITBLK  3
#define NUM_FRSTR   0
#define NUM_FRIMG   0
#define NUM_OBJS    5
#define NUM_TREE    1

extern TEDINFO rs_tedinfo[]; /* array of all TEDINFO's */
extern ICONBLK rs_iconblk[]; /* array of all ICONBLK's */
extern BITBLK  rs_bitblk[];  /* array of ALL BITBLK's  */
extern char   *rs_frstr[];   /* array of pointers to free strings */
extern BITBLK *rs_frimg[];   /* array of pointers to free BITBLK's */
extern OBJECT  rs_object[];  /* array of all OBJECT's */
extern OBJECT *rs_trindex[]; /* array of pointers to the 1. object of a tree */
