/*----------------------------------------------------------------------------------------*
 * MControl                                                                               *
 *----------------------------------------------------------------------------------------*
 * Copyright (c) 2000 - 2002 Joachim Fornallaz                                            *
 *----------------------------------------------------------------------------------------*
 * This source file is subject to the BSD license.                                        *
 *----------------------------------------------------------------------------------------*
 * Authors: Joachim Fornallaz <jf@omnis.ch>                                               *
 *----------------------------------------------------------------------------------------*/

#ifndef	_rect_h_
#define	_rect_h_

#include	<types2b.h>

/*----------------------------------------------------------------------------------------*/
/* struct definitions																							*/
/*----------------------------------------------------------------------------------------*/

/*----------------------------------------------------------------------------------------*/
/* global variables																								*/
/*----------------------------------------------------------------------------------------*/

/*----------------------------------------------------------------------------------------*/
/* function prototypes																							*/
/*----------------------------------------------------------------------------------------*/

void	objc_rect( OBJECT *tree, int16 obj, GRECT *rect );
int16	rc_equal(GRECT *p1, GRECT *p2);
int16 rc_inside( GRECT *r, int16 x, int16 y );
int16	rc_intersect( GRECT *r1, GRECT *r2 );
int16	*grect_to_array( GRECT *area, int16 *array );
void	array_to_grect( int16 *array, GRECT *area );

#endif