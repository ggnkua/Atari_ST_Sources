
#define	ABOUT	    0

#define EXITABO	    1

#define	NEWFOLD	    1

#define TEMPLATE	    1
#define UPFOLD	    3
#define CREATE	    4
#define CANCEL	    5
#define NUMFOLD	    6
#define DNFOLD	    7
#define INFOFORM	    8

#define	PROGRESS	    2

#define PROGRESS_MAIN	    0
#define PROGRES1	    1
#define PROGRES2	    2
#define STOP	    3
#define CONTINUE	    4
#define EXITBACK	    5
#define PROGRES3	    6
