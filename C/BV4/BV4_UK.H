/* Indices du fichier ressource pour BV4_UK */

#define MENU             0   /* Menu */
#define MINFO            8   /* STRING dans l'arbre MENU */
#define MOPEN            17  /* STRING dans l'arbre MENU */
#define MGEN             18  /* STRING dans l'arbre MENU */
#define MSAVE            19  /* STRING dans l'arbre MENU */
#define MUSAVE           20  /* STRING dans l'arbre MENU */
#define MSLIDE           22  /* STRING dans l'arbre MENU */
#define MCNV             23  /* STRING dans l'arbre MENU */
#define MFULL            24  /* STRING dans l'arbre MENU */
#define MMOSA            25  /* STRING dans l'arbre MENU */
#define MPRTGDOS         27  /* STRING dans l'arbre MENU */
#define MPRTWIM          28  /* STRING dans l'arbre MENU */
#define MZOOM            30  /* STRING dans l'arbre MENU */
#define MCLS             32  /* STRING dans l'arbre MENU */
#define MACLS            33  /* STRING dans l'arbre MENU */
#define MBRK             35  /* STRING dans l'arbre MENU */
#define MQUIT            36  /* STRING dans l'arbre MENU */
#define MMEM             38  /* STRING dans l'arbre MENU */
#define MMOD             39  /* STRING dans l'arbre MENU */
#define MOPT             40  /* STRING dans l'arbre MENU */
#define MINT             41  /* STRING dans l'arbre MENU */
#define MSEL             42  /* STRING dans l'arbre MENU */
#define MCNF             43  /* STRING dans l'arbre MENU */
#define MLOG             45  /* STRING dans l'arbre MENU */
#define MSYS             46  /* STRING dans l'arbre MENU */
#define MFRE             48  /* STRING dans l'arbre MENU */

#define FPRG             1   /* Formulaire/Dialogue */
#define FPRGF            1   /* BOX dans l'arbre FPRG */
#define FPRG1            2   /* BOXTEXT dans l'arbre FPRG */
#define FPRG2            3   /* BOXTEXT dans l'arbre FPRG */

#define FPOP             2   /* Formulaire/Dialogue */
#define FPOPBOX          1   /* BOX dans l'arbre FPOP */
#define FPOPF            2   /* BOXTEXT dans l'arbre FPOP */
#define FPOPP            3   /* BOXTEXT dans l'arbre FPOP */
#define FPOPI            4   /* USERDEF dans l'arbre FPOP */
#define FPOPUP           5   /* USERDEF dans l'arbre FPOP */
#define FPOPDN           6   /* USERDEF dans l'arbre FPOP */

#define FUSER            3   /* Formulaire/Dialogue */
#define FUSDPOP          1   /* USERDEF dans l'arbre FUSER */
#define FUSDCIR          3   /* USERDEF dans l'arbre FUSER */
#define FUSDCAR          5   /* USERDEF dans l'arbre FUSER */
#define FUSDDAR          7   /* USERDEF dans l'arbre FUSER */
#define FUSDUAR          9   /* USERDEF dans l'arbre FUSER */
#define FUSDLAR          11  /* USERDEF dans l'arbre FUSER */
#define FUSDRAR          13  /* USERDEF dans l'arbre FUSER */
#define FUSDLQAR         15  /* USERDEF dans l'arbre FUSER */
#define FUSDRQAR         17  /* USERDEF dans l'arbre FUSER */

#define FMOUSE           4   /* Formulaire/Dialogue */
#define FMOUWHEEL        1   /* ICON dans l'arbre FMOUSE */
#define FMOULST          8   /* ICON dans l'arbre FMOUSE */
#define FMOUSIZ          9   /* ICON dans l'arbre FMOUSE */
#define FMOUUPDN         10  /* ICON dans l'arbre FMOUSE */
#define FMOUUP           11  /* ICON dans l'arbre FMOUSE */
#define FMOUDN           12  /* ICON dans l'arbre FMOUSE */

#define ICONE            5   /* Formulaire/Dialogue */
#define ICNBV4           1   /* USERDEF dans l'arbre ICONE */
#define ICNLOG           2   /* USERDEF dans l'arbre ICONE */
#define ICNREG           3   /* USERDEF dans l'arbre ICONE */
#define ICNSLD           4   /* USERDEF dans l'arbre ICONE */
#define ICNCNV           5   /* USERDEF dans l'arbre ICONE */
#define ICNDEF           6   /* USERDEF dans l'arbre ICONE */
#define ICNINF           7   /* USERDEF dans l'arbre ICONE */
#define ICNMOD           8   /* USERDEF dans l'arbre ICONE */
#define ICNMEM           9   /* USERDEF dans l'arbre ICONE */
#define ICNOPT           10  /* USERDEF dans l'arbre ICONE */
#define ICNSYS           11  /* USERDEF dans l'arbre ICONE */

#define DUMMY            6   /* Formulaire/Dialogue */

#define FINFO            7   /* Formulaire/Dialogue */
#define FINFICN          2   /* USERDEF dans l'arbre FINFO */
#define FINFDAT          4   /* TEXT dans l'arbre FINFO */
#define FINFO1           5   /* BUTTON dans l'arbre FINFO */
#define FINFO2           6   /* BUTTON dans l'arbre FINFO */
#define FINFO3           7   /* BUTTON dans l'arbre FINFO */
#define FINFPLS          8   /* BUTTON dans l'arbre FINFO */

#define FINF1            8   /* Formulaire/Dialogue */

#define FINF2            9   /* Formulaire/Dialogue */

#define FINF3            10  /* Formulaire/Dialogue */

#define FMEM             11  /* Formulaire/Dialogue */
#define FMEMINI          4   /* BUTTON dans l'arbre FMEM */
#define FMEMLEN          7   /* TEXT dans l'arbre FMEM */
#define FMEMFRE          9   /* TEXT dans l'arbre FMEM */
#define FMEMSYS          11  /* TEXT dans l'arbre FMEM */
#define FMEMMOD          12  /* BUTTON dans l'arbre FMEM */

#define FSMEM            12  /* Formulaire/Dialogue */
#define FSMEMLEN         3   /* FTEXT dans l'arbre FSMEM */
#define FSMEMFRE         5   /* TEXT dans l'arbre FSMEM */
#define FSMEMSYS         7   /* TEXT dans l'arbre FSMEM */
#define FSMEMMIN         8   /* BUTTON dans l'arbre FSMEM */
#define FSMEMMAX         9   /* BUTTON dans l'arbre FSMEM */
#define FSMEMAN          10  /* BUTTON dans l'arbre FSMEM */
#define FSMEMOK          11  /* BUTTON dans l'arbre FSMEM */

#define FME              13  /* Formulaire/Dialogue */
#define FMEF             1   /* BOX dans l'arbre FME */
#define FMET             2   /* TEXT dans l'arbre FME */
#define FMEUP            12  /* BOXCHAR dans l'arbre FME */
#define FMEF1            13  /* BOX dans l'arbre FME */
#define FMEF2            14  /* BOX dans l'arbre FME */
#define FMEDN            15  /* BOXCHAR dans l'arbre FME */
#define FMEMOD           17  /* BUTTON dans l'arbre FME */
#define FMETYP           19  /* BUTTON dans l'arbre FME */
#define FMEP             20  /* IBOX dans l'arbre FME */
#define FMEADD           21  /* BUTTON dans l'arbre FME */
#define FMEDEL           22  /* BUTTON dans l'arbre FME */
#define FMEINF           23  /* BUTTON dans l'arbre FME */
#define FMESET           24  /* BUTTON dans l'arbre FME */
#define FMEAN            25  /* BUTTON dans l'arbre FME */
#define FMEOK            26  /* BUTTON dans l'arbre FME */

#define FOPT             14  /* Formulaire/Dialogue */
#define FOPTEXT          2   /* BUTTON dans l'arbre FOPT */
#define FOPTPAT          3   /* BUTTON dans l'arbre FOPT */
#define FOPTMAJ          4   /* BUTTON dans l'arbre FOPT */
#define FOPTICN          5   /* BUTTON dans l'arbre FOPT */
#define FOPTGFX          7   /* BUTTON dans l'arbre FOPT */
#define FOPTPAL          8   /* BUTTON dans l'arbre FOPT */
#define FOPTTRM          10  /* BUTTON dans l'arbre FOPT */
#define FOPTSAV          12  /* BUTTON dans l'arbre FOPT */
#define FOPTDSK          13  /* BUTTON dans l'arbre FOPT */
#define FOPTNUM          15  /* BUTTON dans l'arbre FOPT */

#define FINT             15  /* Formulaire/Dialogue */
#define FINTPOP          1   /* BUTTON dans l'arbre FINT */
#define FINTOTO          2   /* BUTTON dans l'arbre FINT */
#define FINTCOL          4   /* BUTTON dans l'arbre FINT */
#define FINTTRM          5   /* BUTTON dans l'arbre FINT */
#define FINTCTR          7   /* BUTTON dans l'arbre FINT */
#define FINTICNW         9   /* BUTTON dans l'arbre FINT */
#define FINTICNH         10  /* BUTTON dans l'arbre FINT */
#define FINTCLS          12  /* BUTTON dans l'arbre FINT */
#define FINTLNG          14  /* BUTTON dans l'arbre FINT */
#define FINTSWP          17  /* TEXT dans l'arbre FINT */

#define FSEL             16  /* Formulaire/Dialogue */
#define FSELEXTD         4   /* FTEXT dans l'arbre FSEL */
#define FSELEXT          5   /* FTEXT dans l'arbre FSEL */
#define FSELPATD         18  /* FTEXT dans l'arbre FSEL */
#define FSELPAT          19  /* FTEXT dans l'arbre FSEL */

#define FLOG             17  /* Formulaire/Dialogue */
#define FLOGINOM         2   /* STRING dans l'arbre FLOG */
#define FLOGNMB          3   /* BUTTON dans l'arbre FLOG */
#define FLOGIMIMG        5   /* STRING dans l'arbre FLOG */
#define FLOGIMPAL        7   /* STRING dans l'arbre FLOG */
#define FLOGIPAL         9   /* STRING dans l'arbre FLOG */
#define FLOGISIZ         11  /* STRING dans l'arbre FLOG */
#define FLOGFNOM         13  /* STRING dans l'arbre FLOG */
#define FLOGFLEN         15  /* STRING dans l'arbre FLOG */
#define FLOGFPAL         17  /* STRING dans l'arbre FLOG */
#define FLOGFSIZ         19  /* STRING dans l'arbre FLOG */
#define FLOGRIM          21  /* STRING dans l'arbre FLOG */

#define FSYS             18  /* Formulaire/Dialogue */
#define FSYSMCH          3   /* STRING dans l'arbre FSYS */
#define FSYSPROC         5   /* STRING dans l'arbre FSYS */
#define FSYSREZ          7   /* STRING dans l'arbre FSYS */
#define FSYSTOS          10  /* STRING dans l'arbre FSYS */
#define FSYSGDOS         12  /* STRING dans l'arbre FSYS */
#define FSYSAES          14  /* STRING dans l'arbre FSYS */
#define FSYSMINT         16  /* STRING dans l'arbre FSYS */

#define FSLIDE           19  /* Formulaire/Dialogue */
#define FSLDPAUSE        2   /* BUTTON dans l'arbre FSLIDE */
#define FSLDBT           3   /* BUTTON dans l'arbre FSLIDE */
#define FSLDLOOP         4   /* BUTTON dans l'arbre FSLIDE */
#define FSLDREC          5   /* BUTTON dans l'arbre FSLIDE */
#define FSLDNAME         6   /* BUTTON dans l'arbre FSLIDE */
#define FSLDLED          7   /* BUTTON dans l'arbre FSLIDE */
#define FSLDTV           8   /* BUTTON dans l'arbre FSLIDE */
#define FSLDDEC          9   /* BUTTON dans l'arbre FSLIDE */
#define FSLDINC          10  /* BUTTON dans l'arbre FSLIDE */
#define FSLDPATH         11  /* FBOXTEXT dans l'arbre FSLIDE */
#define FSLDGO           12  /* BUTTON dans l'arbre FSLIDE */

#define WAIT             20  /* Formulaire/Dialogue */
#define WAITNUM          5   /* TEXT dans l'arbre WAIT */

#define BUREAU           21  /* Formulaire/Dialogue */
#define DSKBIN           1   /* USERDEF dans l'arbre BUREAU */
#define DSKPRT           2   /* USERDEF dans l'arbre BUREAU */
#define DSKCLP1          3   /* USERDEF dans l'arbre BUREAU */
#define DSKCLP2          4   /* USERDEF dans l'arbre BUREAU */
#define DSKICN           5   /* BOX dans l'arbre BUREAU */

#define FCNV             22  /* Formulaire/Dialogue */
#define FCNVDEL          3   /* BUTTON dans l'arbre FCNV */
#define FCNVCOL          5   /* BUTTON dans l'arbre FCNV */
#define FCNVSRC          7   /* BOXTEXT dans l'arbre FCNV */
#define FCNVDST          9   /* BOXTEXT dans l'arbre FCNV */
#define FCNVGO           10  /* BUTTON dans l'arbre FCNV */

#define PCNV             23  /* Formulaire/Dialogue */
#define PCNVWIM          1   /* BOXTEXT dans l'arbre PCNV */
#define PCNVIMG          2   /* BOXTEXT dans l'arbre PCNV */
#define PCNV1            4   /* BOXTEXT dans l'arbre PCNV */
#define PCNV2            5   /* BOXTEXT dans l'arbre PCNV */
#define PCNV4            6   /* BOXTEXT dans l'arbre PCNV */
#define PCNV8            7   /* BOXTEXT dans l'arbre PCNV */
#define PCNV16           8   /* BOXTEXT dans l'arbre PCNV */
#define PCNV24           9   /* BOXTEXT dans l'arbre PCNV */
#define PCNV32           10  /* BOXTEXT dans l'arbre PCNV */

#define FTRM             24  /* Formulaire/Dialogue */
#define FTRMSRC          2   /* TEXT dans l'arbre FTRM */
#define FTRMDST          4   /* TEXT dans l'arbre FTRM */
#define FTRMTXT          6   /* TEXT dans l'arbre FTRM */
#define FTRMPOP          7   /* BUTTON dans l'arbre FTRM */
#define FTRMOK           8   /* BUTTON dans l'arbre FTRM */
#define FTRMAN           9   /* BUTTON dans l'arbre FTRM */

#define FZOOM            25  /* Formulaire/Dialogue */
#define FZMSRC           2   /* TEXT dans l'arbre FZOOM */
#define FZMDST           4   /* TEXT dans l'arbre FZOOM */
#define FZMPOP           5   /* BUTTON dans l'arbre FZOOM */
#define FZMW             7   /* FBOXTEXT dans l'arbre FZOOM */
#define FZMH             9   /* FBOXTEXT dans l'arbre FZOOM */
#define FZMQUAL          10  /* BUTTON dans l'arbre FZOOM */
#define FZMREP           11  /* BUTTON dans l'arbre FZOOM */
#define FZMAN            12  /* BUTTON dans l'arbre FZOOM */
#define FZMOK            13  /* BUTTON dans l'arbre FZOOM */

#define PZOOM            26  /* Formulaire/Dialogue */
#define PZMSS1           1   /* BOXTEXT dans l'arbre PZOOM */
#define PZMDS1           2   /* BOXTEXT dans l'arbre PZOOM */
#define PZMSS2           3   /* BOXTEXT dans l'arbre PZOOM */
#define PZMDS2           4   /* BOXTEXT dans l'arbre PZOOM */
#define PZMSD1           6   /* BOXTEXT dans l'arbre PZOOM */
#define PZMDD1           7   /* BOXTEXT dans l'arbre PZOOM */
#define PZMSD2           8   /* BOXTEXT dans l'arbre PZOOM */
#define PZMDD2           9   /* BOXTEXT dans l'arbre PZOOM */
#define PZMO2            11  /* BOXTEXT dans l'arbre PZOOM */
#define PZMO3            12  /* BOXTEXT dans l'arbre PZOOM */
#define PZMO4            13  /* BOXTEXT dans l'arbre PZOOM */
#define PZMO5            14  /* BOXTEXT dans l'arbre PZOOM */
#define PZMO6            15  /* BOXTEXT dans l'arbre PZOOM */
#define PZMO7            16  /* BOXTEXT dans l'arbre PZOOM */
#define PZMO8            17  /* BOXTEXT dans l'arbre PZOOM */
#define PZMO9            18  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI2            20  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI3            21  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI4            22  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI5            23  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI6            24  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI7            25  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI8            26  /* BOXTEXT dans l'arbre PZOOM */
#define PZMI9            27  /* BOXTEXT dans l'arbre PZOOM */
#define PZMW             29  /* BOXTEXT dans l'arbre PZOOM */
#define PZMH             30  /* BOXTEXT dans l'arbre PZOOM */
#define PZMWH            31  /* BOXTEXT dans l'arbre PZOOM */

#define FMOD             27  /* Formulaire/Dialogue */
#define FMODP            1   /* FBOXTEXT dans l'arbre FMOD */
#define FMODX1           2   /* BUTTON dans l'arbre FMOD */
#define FMODT1           3   /* TEXT dans l'arbre FMOD */
#define FMODP1           4   /* BUTTON dans l'arbre FMOD */
#define FMODD1           5   /* TEXT dans l'arbre FMOD */
#define FMODX2           6   /* BUTTON dans l'arbre FMOD */
#define FMODT2           7   /* TEXT dans l'arbre FMOD */
#define FMODP2           8   /* BUTTON dans l'arbre FMOD */
#define FMODD2           9   /* TEXT dans l'arbre FMOD */
#define FMODX4           10  /* BUTTON dans l'arbre FMOD */
#define FMODT4           11  /* TEXT dans l'arbre FMOD */
#define FMODP4           12  /* BUTTON dans l'arbre FMOD */
#define FMODD4           13  /* TEXT dans l'arbre FMOD */
#define FMODX8           14  /* BUTTON dans l'arbre FMOD */
#define FMODT8           15  /* TEXT dans l'arbre FMOD */
#define FMODP8           16  /* BUTTON dans l'arbre FMOD */
#define FMODD8           17  /* TEXT dans l'arbre FMOD */
#define FMODX10          18  /* BUTTON dans l'arbre FMOD */
#define FMODT10          19  /* TEXT dans l'arbre FMOD */
#define FMODX20          20  /* BUTTON dans l'arbre FMOD */
#define FMODT20          21  /* TEXT dans l'arbre FMOD */
#define FMODX40          22  /* BUTTON dans l'arbre FMOD */
#define FMODT40          23  /* TEXT dans l'arbre FMOD */
#define FMODX80          24  /* BUTTON dans l'arbre FMOD */
#define FMODT80          25  /* TEXT dans l'arbre FMOD */
#define FMODCNF          26  /* BUTTON dans l'arbre FMOD */

#define PCOL2            28  /* Formulaire/Dialogue */

#define PCOL4            29  /* Formulaire/Dialogue */

#define PTRM             30  /* Formulaire/Dialogue */

#define FPRT             31  /* Formulaire/Dialogue */
#define FPRTDRV          2   /* BUTTON dans l'arbre FPRT */
#define FPRTBOX          3   /* IBOX dans l'arbre FPRT */
#define FPRTIP           5   /* TEXT dans l'arbre FPRT */
#define FPRTIC           6   /* TEXT dans l'arbre FPRT */
#define FPRTFP           8   /* TEXT dans l'arbre FPRT */
#define FPRTFC           9   /* TEXT dans l'arbre FPRT */
#define FPRTOUT          10  /* BUTTON dans l'arbre FPRT */
#define FPRTMAX          11  /* BUTTON dans l'arbre FPRT */
#define FPRTH1           15  /* BUTTON dans l'arbre FPRT */
#define FPRTH2           16  /* BUTTON dans l'arbre FPRT */
#define FPRTH3           17  /* BUTTON dans l'arbre FPRT */
#define FPRTV1           19  /* BUTTON dans l'arbre FPRT */
#define FPRTV2           20  /* BUTTON dans l'arbre FPRT */
#define FPRTV3           21  /* BUTTON dans l'arbre FPRT */
#define FPRTAN           22  /* BUTTON dans l'arbre FPRT */
#define FPRTOK           23  /* BUTTON dans l'arbre FPRT */

#define PPRT             32  /* Formulaire/Dialogue */

#define PME1             33  /* Formulaire/Dialogue */

#define PME2             34  /* Formulaire/Dialogue */
#define PME2TOT          1   /* BOXTEXT dans l'arbre PME2 */
#define PME2PAR          2   /* BOXTEXT dans l'arbre PME2 */
#define PME2GEN          3   /* BOXTEXT dans l'arbre PME2 */
#define PME2ANI          4   /* BOXTEXT dans l'arbre PME2 */
#define PME2ALL          6   /* BOXTEXT dans l'arbre PME2 */

#define PME3             35  /* Formulaire/Dialogue */
#define PME3NOR          1   /* BOXTEXT dans l'arbre PME3 */
#define PME3GEN          2   /* BOXTEXT dans l'arbre PME3 */
#define PME3ANI          3   /* BOXTEXT dans l'arbre PME3 */
#define PME3ALL          5   /* BOXTEXT dans l'arbre PME3 */

#define PME4             36  /* Formulaire/Dialogue */
#define PME4ONE          1   /* BOXTEXT dans l'arbre PME4 */
#define PME4TWO          2   /* BOXTEXT dans l'arbre PME4 */
#define PME4ALL          4   /* BOXTEXT dans l'arbre PME4 */

#define FMI              37  /* Formulaire/Dialogue */
#define FMINAME          1   /* STRING dans l'arbre FMI */
#define FMIVER           3   /* STRING dans l'arbre FMI */
#define FMIFMT           5   /* STRING dans l'arbre FMI */
#define FMIID            7   /* STRING dans l'arbre FMI */
#define FMITYPE          9   /* STRING dans l'arbre FMI */

#define FRIM             38  /* Formulaire/Dialogue */
#define FRIMNAME         2   /* FBOXTEXT dans l'arbre FRIM */
#define FRIMPOP          3   /* BUTTON dans l'arbre FRIM */
#define FRIMW            5   /* FBOXTEXT dans l'arbre FRIM */
#define FRIMH            7   /* FBOXTEXT dans l'arbre FRIM */
#define FRIMAN           8   /* BUTTON dans l'arbre FRIM */
#define FRIMOK           9   /* BUTTON dans l'arbre FRIM */

#define PRIM             39  /* Formulaire/Dialogue */
#define PRIMSS1          1   /* BOXTEXT dans l'arbre PRIM */
#define PRIMDS1          2   /* BOXTEXT dans l'arbre PRIM */
#define PRIMSS2          3   /* BOXTEXT dans l'arbre PRIM */
#define PRIMDS2          4   /* BOXTEXT dans l'arbre PRIM */
#define PRIMSS3          5   /* BOXTEXT dans l'arbre PRIM */
#define PRIMDS3          6   /* BOXTEXT dans l'arbre PRIM */
#define PRIMSS4          7   /* BOXTEXT dans l'arbre PRIM */
#define PRIMDS4          8   /* BOXTEXT dans l'arbre PRIM */
#define PRIMSD1          10  /* BOXTEXT dans l'arbre PRIM */
#define PRIMDD1          11  /* BOXTEXT dans l'arbre PRIM */
#define PRIMSD2          12  /* BOXTEXT dans l'arbre PRIM */
#define PRIMDD2          13  /* BOXTEXT dans l'arbre PRIM */
#define PRIMSD3          14  /* BOXTEXT dans l'arbre PRIM */
#define PRIMDD3          15  /* BOXTEXT dans l'arbre PRIM */
#define PRIMSD4          16  /* BOXTEXT dans l'arbre PRIM */
#define PRIMDD4          17  /* BOXTEXT dans l'arbre PRIM */
#define PRIMMAN          19  /* BOXTEXT dans l'arbre PRIM */

#define PINT1            40  /* Formulaire/Dialogue */
#define PINT1NEV         1   /* BOXTEXT dans l'arbre PINT1 */
#define PINT1OPN         2   /* BOXTEXT dans l'arbre PINT1 */
#define PINT1ALW         3   /* BOXTEXT dans l'arbre PINT1 */

#define PINT2            41  /* Formulaire/Dialogue */
#define PINT2DEL         1   /* BOXTEXT dans l'arbre PINT2 */
#define PINT2ICN         2   /* BOXTEXT dans l'arbre PINT2 */
#define PINT2ASK         3   /* BOXTEXT dans l'arbre PINT2 */

#define PINT3            42  /* Formulaire/Dialogue */
#define PINT3FR          1   /* BOXTEXT dans l'arbre PINT3 */
#define PINT3UK          2   /* BOXTEXT dans l'arbre PINT3 */
#define PINT3DE          3   /* BOXTEXT dans l'arbre PINT3 */

#define POPT1            43  /* Formulaire/Dialogue */
#define POPT1OTO         1   /* BOXTEXT dans l'arbre POPT1 */
#define POPT1NON         2   /* BOXTEXT dans l'arbre POPT1 */
#define POPT1ASK         3   /* BOXTEXT dans l'arbre POPT1 */

#define PINT4            44  /* Formulaire/Dialogue */
#define PINT4LF          1   /* BOXTEXT dans l'arbre PINT4 */
#define PINT4RT          2   /* BOXTEXT dans l'arbre PINT4 */

#define PINT5            45  /* Formulaire/Dialogue */
#define PINT5UP          1   /* BOXTEXT dans l'arbre PINT5 */
#define PINT5DN          2   /* BOXTEXT dans l'arbre PINT5 */

#define FDEBUG           46  /* Formulaire/Dialogue */
#define FDBGOK           2   /* BUTTON dans l'arbre FDEBUG */
#define FDBGINI          6   /* BUTTON dans l'arbre FDEBUG */
#define FDBGMEM          7   /* BUTTON dans l'arbre FDEBUG */
#define FDBGTRM          8   /* BUTTON dans l'arbre FDEBUG */
#define FDBGRIM          9   /* BUTTON dans l'arbre FDEBUG */
#define FDBGWIM          10  /* BUTTON dans l'arbre FDEBUG */
#define FDBGIFX          11  /* BUTTON dans l'arbre FDEBUG */
#define FDBGFILE         13  /* TEXT dans l'arbre FDEBUG */

#define NOMEM            0   /* Chaine d'alerte */

#define ACNVSRC          1   /* Chaine d'alerte */

#define ACNVDST          2   /* Chaine d'alerte */

#define ACNVSAME         3   /* Chaine d'alerte */

#define WINCLOSE         4   /* Chaine d'alerte */

#define QUIT             5   /* Chaine d'alerte */

#define NOWIN            6   /* Chaine d'alerte */

#define RIMFILE          7   /* Chaine d'alerte */

#define RIMMEM           8   /* Chaine d'alerte */

#define RIMNORIM         9   /* Chaine d'alerte */

#define RIMNONE          10  /* Chaine d'alerte */

#define RIMNODIM         11  /* Chaine d'alerte */

#define RIMERROR         12  /* Chaine d'alerte */

#define TRMNOTRM         13  /* Chaine d'alerte */

#define TRMNOZM          14  /* Chaine d'alerte */

#define TRMSRCPAL        15  /* Chaine d'alerte */

#define TRMDSTPAL        16  /* Chaine d'alerte */

#define TRM1STFMT        17  /* Chaine d'alerte */

#define TRMTMPMEM        18  /* Chaine d'alerte */

#define TRMSRCMEM        19  /* Chaine d'alerte */

#define TRM2NDMEM        20  /* Chaine d'alerte */

#define TRM2NDFMT        21  /* Chaine d'alerte */

#define WIMNOWIM         22  /* Chaine d'alerte */

#define WIMNOCOL         23  /* Chaine d'alerte */

#define WIMNOMEM         24  /* Chaine d'alerte */

#define WIMNOFILE        25  /* Chaine d'alerte */

#define WIMERROR         26  /* Chaine d'alerte */

#define WIMZM            27  /* Chaine d'alerte */

#define GDOSNO           28  /* Chaine d'alerte */

#define GDOSNOWIM        29  /* Chaine d'alerte */

#define GDOSOPEN         30  /* Chaine d'alerte */

#define GDOSNODRV        31  /* Chaine d'alerte */

#define TRM19            32  /* Chaine d'alerte */

#define TRM18            33  /* Chaine d'alerte */

#define TRM17            34  /* Chaine d'alerte */

#define TRM16            35  /* Chaine d'alerte */

#define TRM15            36  /* Chaine d'alerte */

#define TRM12            37  /* Chaine d'alerte */

#define TRM11            38  /* Chaine d'alerte */

#define TRM10            39  /* Chaine d'alerte */

#define TRM09            40  /* Chaine d'alerte */

#define TRM08            41  /* Chaine d'alerte */

#define TRM07            42  /* Chaine d'alerte */

#define TRM06            43  /* Chaine d'alerte */

#define TRM05            44  /* Chaine d'alerte */

#define TRM04            45  /* Chaine d'alerte */

#define TRM03            46  /* Chaine d'alerte */

#define TRM01            47  /* Chaine d'alerte */

#define TFSELLOAD        48  /* Chaine libre */

#define TFSELSAVE        49  /* Chaine libre */

#define TWOPT            50  /* Chaine libre */

#define TSOPT            51  /* Chaine libre */

#define TWLOG            52  /* Chaine libre */

#define TSLOG            53  /* Chaine libre */

#define TWREG            54  /* Chaine libre */

#define TSREG            55  /* Chaine libre */

#define TWSEL            56  /* Chaine libre */

#define TSSEL            57  /* Chaine libre */

#define TWMOD            58  /* Chaine libre */

#define TWMEM            59  /* Chaine libre */

#define TWSYS            60  /* Chaine libre */

#define TSLDPATH         61  /* Chaine libre */

#define TWSLIDE          62  /* Chaine libre */

#define TSSLIDE          63  /* Chaine libre */

#define TWCNV            64  /* Chaine libre */

#define TSCNV            65  /* Chaine libre */

#define TCNVLOAD         66  /* Chaine libre */

#define TCNVSAVE         67  /* Chaine libre */

#define TCNVTRM          68  /* Chaine libre */

#define TCNVDEL          69  /* Chaine libre */

#define TCNVSRC          70  /* Chaine libre */

#define TCNVDST          71  /* Chaine libre */

#define TWINF1           72  /* Chaine libre */

#define TWINF2           73  /* Chaine libre */

#define TWINF3           74  /* Chaine libre */

#define WTRM             75  /* Chaine libre */

#define WZOOM            76  /* Chaine libre */

#define INIT12           77  /* Chaine libre */

#define INIT13           78  /* Chaine libre */

#define INIT14           79  /* Chaine libre */

#define INIT15           80  /* Chaine libre */

#define INIT16           81  /* Chaine libre */

#define INIT17           82  /* Chaine libre */

#define INIT18           83  /* Chaine libre */

#define INIT19           84  /* Chaine libre */

#define WME              85  /* Chaine libre */

#define WRIM             86  /* Chaine libre */

#define OUI              87  /* Chaine libre */

#define NON              88  /* Chaine libre */

#define FSELSWP          89  /* Chaine libre */

#define RIMTST           90  /* Chaine libre */

#define RIMPAL           91  /* Chaine libre */

#define RIMIMG           92  /* Chaine libre */

#define TRMINF           93  /* Chaine libre */

#define TRMZOOM          94  /* Chaine libre */

#define WPRT             95  /* Chaine libre */

#define GDOSPRINT        96  /* Chaine libre */

#define WIMWORK1         97  /* Chaine libre */

#define WIMWORK2         98  /* Chaine libre */

#define WIMSAVE          99  /* Chaine libre */

#define PARX             100 /* Chaine libre */

#define WMIRIM           101 /* Chaine libre */

#define WMIWIM           102 /* Chaine libre */

#define WMIIFX           103 /* Chaine libre */

#define FMERIM           104 /* Chaine libre */

#define FMEWIM           105 /* Chaine libre */

#define FMEIFX           106 /* Chaine libre */

#define TSMOD            107 /* Chaine libre */

#define TSMEM            108 /* Chaine libre */

#define TSSYS            109 /* Chaine libre */

#define TWINT            110 /* Chaine libre */

#define TSINT            111 /* Chaine libre */

#define FSELLOG          112 /* Chaine libre */
