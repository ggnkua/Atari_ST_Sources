/* Indices du fichier ressource pour INTERN */

#define FPROG            0   /* Formulaire/Dialogue */
#define FPROGT           1   /* BOXTEXT dans l'arbre FPROG */
#define FPROGF           2   /* BOX dans l'arbre FPROG */
#define FPROG1           3   /* BOXTEXT dans l'arbre FPROG */
#define FPROG2           4   /* BOXTEXT dans l'arbre FPROG */

#define NOPARX           0   /* Chaine d'alerte */

#define ERR01            1   /* Chaine d'alerte */

#define ERR02            2   /* Chaine d'alerte */

#define ERR03            3   /* Chaine d'alerte */

#define ERR04            4   /* Chaine d'alerte */

#define ERR05            5   /* Chaine d'alerte */

#define ERR06            6   /* Chaine d'alerte */

#define ERR07            7   /* Chaine d'alerte */

#define ERR08            8   /* Chaine d'alerte */

#define ERR09            9   /* Chaine d'alerte */

#define ERR10            10  /* Chaine d'alerte */

#define PARXSYS          11  /* Chaine libre */

#define INIT01           12  /* Chaine libre */

#define INIT02           13  /* Chaine libre */

#define INIT03           14  /* Chaine libre */

#define INIT04           15  /* Chaine libre */

#define INIT05           16  /* Chaine libre */

#define INIT08           17  /* Chaine libre */

#define INIT09           18  /* Chaine libre */

#define INIT10           19  /* Chaine libre */

#define INIT11           20  /* Chaine libre */
