/* resource file indicies for SETBOOT */

#define MENU     0	/* menu tree */
#define MDESK    3	/* TITLE in tree MENU */
#define MFILE    4	/* TITLE in tree MENU */
#define MBOOT    5	/* TITLE in tree MENU */
#define MHELP    6	/* TITLE in tree MENU */
#define MABOUT   9	/* STRING in tree MENU */
#define MQUIT    18	/* STRING in tree MENU */
#define MSET     20	/* STRING in tree MENU */
#define MDISPLAY 21	/* STRING in tree MENU */
#define MINIT    23	/* STRING in tree MENU */
#define MHGEN    25	/* STRING in tree MENU */
#define MHSET    26	/* STRING in tree MENU */
#define MHDISPL  27	/* STRING in tree MENU */
#define MHNVRAM  28	/* STRING in tree MENU */

#define ABOUT    1	/* form/dialog */
#define ABOUTOK  4	/* BUTTON in tree ABOUT */

#define SET      2	/* form/dialog */
#define TOSBOX   3	/* BUTTON in tree SET */
#define ASVBOX   5	/* BUTTON in tree SET */
#define NOBOX    7	/* BUTTON in tree SET */
#define SETOK    9	/* BUTTON in tree SET */
#define SETCANCL 10	/* BUTTON in tree SET */

#define HELP     3	/* form/dialog */
#define HELPOK   6	/* BUTTON in tree HELP */

#define DISPLAY  4	/* form/dialog */
#define DISPLOK  1	/* BUTTON in tree DISPLAY */
#define BOOTINFO 3	/* STRING in tree DISPLAY */

#define HSET     5	/* form/dialog */

#define HDISP    6	/* form/dialog */

#define HINIT    7	/* form/dialog */

#define QUITMSG  0	/* Free string index */

#define REBTMSG  1	/* Free string index */

#define NOTTMSG  2	/* Free string index */

#define NOMEMMSG 3	/* Free string index */

#define NOMENMSG 4	/* Free string index */

#define INITMSG  5	/* Free string index */

#define BTTOSMSG 6	/* Free string index */

#define BTASVMSG 7	/* Free string index */

#define BTNOMSG  8	/* Free string index */

#define CSUMMSG1 9	/* Free string index */

#define CSUMMSG2 10	/* Free string index */

#define READMSG  11	/* Free string index */

#define WRITMSG1 12	/* Free string index */

#define WRITMSG2 13	/* Free string index */

