/*
 *	setbtmsg.h
 *
 *	messages for dialog boxes
 */
 
#define nogem		"[1][Initializing GEM failed.][Abort]"
#define	norsc		"[1]Loading the resource file|SETBOOT.RSC failed.][Abort]"

/*
 *	These strings are loaded with the RSC file
 */
char	*nomemmsg;
char	*quitmsg;
char	*rebootmsg;
char	*nottmsg;
char	*nomenu;
char	*initmsg;
char	*boottosmsg;
char	*bootasvmsg;
char	*bootnomsg;
char	*checksummsg;
char	*readfailedmsg;
char	*writefailedmsg;
