/* ShIcEd Form Definition Data */
#define SHAP_W 0x0008
#define SHAP_H 0x000F
#define DATASIZE 0x0078
unsigned int image[DATASIZE] = 
{ 0x07F0, 0x07F0, 0x07F0, 0x07F0, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x180C, 0x180C, 0x1FFC, 0x180C, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x2002, 0x2002, 0x3FFE, 0x2002, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x4001, 0x4001, 0x7D5F, 0x4001, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x4001, 0x4001, 0x7D5F, 0x4001, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x8000, 0x8000, 0xFD5F, 0x8000, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0x8000, 0x8000, 0xFD5F, 0x8000, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0x8000, 0x8000, 0xFD5F, 0x8000, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0x8000, 0x8000, 0xFD5F, 0x8000, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0x8000, 0x8000, 0xFB6F, 0x8000, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0x4001, 0x4001, 0x6773, 0x4001, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x4001, 0x4001, 0x7FFF, 0x4001, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x2002, 0x2002, 0x3FFE, 0x2002, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x180C, 0x180C, 0x1FFC, 0x180C, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x07F0, 0x07F0, 0x07F0, 0x07F0, 
  0x0000, 0x0000, 0x0000, 0x0000
};


/* ShIcEd Form Definition Data */
#define SHAP_W 0x0008
#define SHAP_H 0x000F
#define DATASIZE 0x0078
unsigned int image[DATASIZE] = 
{ 0x07F0, 0x07F0, 0x07F0, 0x07F0, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x1FFC, 0x1FFC, 0x1FFC, 0x1FFC, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x3FFE, 0x3FFE, 0x3FFE, 0x3FFE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x7FFF, 0x7FFF, 0x7FFF, 0x7FFF, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x7FFF, 0x7FFF, 0x7FFF, 0x7FFF, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
  0x8000, 0x8000, 0x8000, 0x8000, 
  0x7FFF, 0x7FFF, 0x7FFF, 0x7FFF, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x7FFF, 0x7FFF, 0x7FFF, 0x7FFF, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x3FFE, 0x3FFE, 0x3FFE, 0x3FFE, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x1FFC, 0x1FFC, 0x1FFC, 0x1FFC, 
  0x0000, 0x0000, 0x0000, 0x0000, 
  0x07F0, 0x07F0, 0x07F0, 0x07F0, 
  0x0000, 0x0000, 0x0000, 0x0000
};
