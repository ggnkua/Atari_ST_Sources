#define TREE1 0  	/* TREE */
#define UNCLE 1  	/* OBJECT in TREE #0 */
#define UR 5  	/* OBJECT in TREE #0 */
#define UL 4  	/* OBJECT in TREE #0 */
#define LL 3  	/* OBJECT in TREE #0 */
#define TREE2 1  	/* TREE */
#define LR 6  	/* OBJECT in TREE #0 */
#define OVER 2  	/* OBJECT in TREE #1 */
