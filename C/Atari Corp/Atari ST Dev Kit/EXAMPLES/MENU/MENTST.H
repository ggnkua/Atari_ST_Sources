#define TREE1 0  	/* TREE */
#define COL1 4  	/* OBJECT in TREE #0 */
#define PAT1 16  	/* OBJECT in TREE #0 */
#define PAT2 17  	/* OBJECT in TREE #0 */
#define QUIT 18  	/* OBJECT in TREE #0 */
