/*

	dialog.h

	GEM Dialog Handling Prototypes
	Copyright 1991 Atari Corporation

	Created: March 17, 1991 Kenneth Soohoo AETAS
*/

extern void open_dialog(/* OBJECT * */);
extern void close_dialog();
extern int do_dialog(/* OBJECT * */);
