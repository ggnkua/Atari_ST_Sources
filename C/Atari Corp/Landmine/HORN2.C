/* Mission sucess sound */
#define SUCCESS_SAMPLE_LENGTH	(0x3666+0x80)
int success_smp_length = SUCCESS_SAMPLE_LENGTH;
int success_smp_rate = 0x82;
int success_sample[SUCCESS_SAMPLE_LENGTH / 2] = {
0x3242,0x4954,0x484F,0x524E,0x0000,0x002D,0x0000,0x0008,
0xFFFF,0x0000,0xFFFF,0xFF00,0x1872,0x0000,0x3666,0x0000,
0x0000,0x0000,0x3666,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFB00,0x0500,
0x0000,0x0500,0x0000,0x0000,0xF6FB,0x0500,0x0000,0x0500,
0xFB00,0x0500,0x00F6,0xF600,0x0500,0x0005,0x00FB,0x0505,
0x00F6,0xF600,0x0A00,0x000A,0x05FB,0x0005,0x00FB,0xF100,
0x1905,0xF10A,0x14FB,0xF605,0x05F1,0xE205,0x2805,0xEC0A,
0x0FFB,0xF605,0x00EC,0xE20A,0x2305,0xFB0A,0x05FB,0x0005,
0x00F1,0xDD05,0x2305,0x000F,0x00F1,0x000A,0x00EC,0xDD00,
0x2805,0xFB14,0x00EC,0x000F,0xFBE2,0xE20A,0x2800,0x0014,
0x00F1,0x050A,0xF6DD,0xE21E,0x28F6,0x0014,0xF6F1,0x0A0A,
0xF1D8,0xE72D,0x19EC,0x1414,0xF1F6,0x0F0A,0xECD8,0xFB37,
0x05EC,0x1E0A,0xE2F6,0x1905,0xE2D3,0x0537,0x00EC,0x2305,
0xDDFB,0x1E05,0xDDD8,0x0F37,0xFBF1,0x2300,0xD800,0x2305,
0xDDD8,0x143C,0xFBF6,0x2300,0xD800,0x1E00,0xE2DD,0x1937,
0xF6FB,0x1EFB,0xE200,0x19FB,0xE2E2,0x2828,0xEC0A,0x19F1,
0xE705,0x0FF1,0xE2F6,0x2D14,0xE714,0x0FE7,0xF10F,0x0AEC,
0xE700,0x2805,0xEC1E,0x0ADD,0xF114,0x05E7,0xEC0A,0x28FB,
0xF11E,0x05E2,0xF614,0x00E2,0xF114,0x1EF6,0xFB1E,0x00E2,
0x0014,0xFBE7,0xF61E,0x14F1,0x0514,0xF6E7,0x000A,0xF6EC,
0x001E,0x0AEC,0x0A0F,0xF1F6,0x0500,0xF1F6,0x0A19,0x00F1,
0x0F0A,0xF1F6,0x0A00,0xF1FB,0x0A14,0x00F6,0x0F05,0xF100,
0x0AFB,0xF100,0x0F0F,0xFBFB,0x0A00,0xF100,0x0AFB,0xF605,
0x0F05,0xF600,0x0A00,0xF605,0x05FB,0xFB0A,0x0F00,0xFB00,
0x05FB,0xFB05,0x00F6,0x000F,0x0F00,0xFB05,0x00F6,0xFB05,
0x00F6,0x000F,0x05FB,0xFB00,0x00FB,0x0005,0x00F6,0x000A,
0x00FB,0x0000,0x00FB,0x0005,0xFBFB,0x0505,0x00FB,0x0000,
0x00FB,0x0000,0xFB00,0x0505,0x0000,0x00FB,0xFB00,0x0000,
0xFB00,0x0A05,0x0000,0x0000,0x0000,0x0000,0xFB00,0x0500,
0xFB00,0x0000,0xFB00,0x0000,0x0005,0x0500,0xFB00,0x0000,
0x0000,0x0000,0x0005,0x0500,0xFBFB,0xFBFB,0x0000,0x0000,
0x0005,0x0000,0xFB00,0x0000,0xFBFB,0x0005,0x0500,0x0000,
0xFB00,0x00FB,0xF600,0x0F05,0x0005,0x00FB,0xFBFB,0xFBF6,
0x000A,0x0A05,0x0500,0xFB00,0x00FB,0xF6FB,0x050A,0x0A05,
0x0500,0x0000,0x00F6,0xF100,0x0F05,0x0005,0x0500,0x00FB,
0xF6E7,0xF614,0x0F00,0x0A0F,0x05FB,0x00FB,0xF1F1,0x0514,
0x0505,0x0F0A,0x00FB,0x00F6,0xE7F1,0x0F19,0x0505,0x0A00,
0xF6FB,0x00F6,0xE7F1,0x1419,0x000A,0x0FFB,0xF100,0x00F6,
0xE2E7,0x1923,0x000A,0x0AF6,0xF100,0x00F1,0xD8E7,0x2828,
0xFB05,0x0FFB,0xF605,0x05EC,0xD3F1,0x3C1E,0xEC0F,0x0FF1,
0xF60A,0x05E2,0xCE0A,0x4605,0xF119,0x0FEC,0xF60A,0x00E2,
0xC91E,0x4BF6,0xF61E,0x05E2,0xFB14,0xFBD3,0xCE32,0x46E7,
0x0028,0xFBD8,0x0014,0xF1C9,0xD341,0x32D8,0x1423,0xECDD,
0x0A0F,0xE7CE,0xE746,0x19D8,0x2323,0xE2E2,0x0F0A,0xDDC9,
0x0050,0x00D8,0x2D19,0xD8EC,0x1905,0xD8CE,0x1955,0xF6EC,
0x370A,0xCEF6,0x1E00,0xD8CE,0x2850,0xECFB,0x3C00,0xCE00,
0x2300,0xD3CE,0x3C4B,0xDD05,0x37F6,0xC905,0x23F6,0xCED3,
0x4637,0xD314,0x32EC,0xCE0F,0x28E2,0xBFE7,0x4619,0xCE23,
0x28D8,0xDD1E,0x14D8,0xC400,0x4B05,0xD328,0x1ED3,0xE71E,
0x0ADD,0xDD05,0x3C00,0xDD23,0x0FDD,0xF114,0x00EC,0xF1FB,
0x320A,0xD814,0x0AE7,0xF105,0xFBF1,0xFB05,0x230A,0xEC05,
0x05F6,0xF6FB,0xF1FB,0x050F,0x1400,0xF6FB,0x00FB,0xFBF6,
0xF105,0x0F0F,0x0FFB,0xFB05,0x00FB,0xFBFB,0xF605,0x0A0F,
0x0AFB,0x0005,0xFBFB,0x00FB,0xFB05,0x0A0A,0x05FB,0x0000,
0xFBFB,0xFBFB,0x000A,0x0A05,0x00FB,0x0000,0xFB00,0x0000,
0x050F,0x0F00,0xFB00,0x0500,0xFB00,0x00FB,0x050F,0x0500,
0xFB00,0x05FB,0xFB00,0x0005,0x0A0A,0x0500,0xFB00,0x0500,
0x0000,0x0005,0x0505,0x0000,0xFB00,0x0000,0x0000,0x0005,
0x0500,0x0000,0xFB00,0x00FB,0x0000,0x0005,0x0500,0x0000,
0xFBFB,0x00FB,0xFBFB,0xFB05,0x0505,0xFBFB,0xFBFB,0x00FB,
0x0500,0x0005,0x0500,0xFBFB,0x0000,0xFBFB,0x0500,0x0005,
0x0500,0xFB00,0x0000,0xFB00,0x0500,0x0005,0x0000,0xFB00,
0xFB00,0xFB00,0x0500,0x0505,0x05FB,0xFB00,0xFB00,0xFB00,
0x0500,0x0500,0x00FB,0xFB00,0xFB00,0x0005,0x0000,0x0500,
0x00FB,0xFB00,0xFB00,0x0005,0x0000,0x00FB,0xFBFB,0xFB05,
0x0000,0x0505,0x0005,0x00F6,0xFBFB,0x0005,0x0005,0xFB0F,
0xFB05,0xF6FB,0xFB00,0x0000,0x0005,0x0500,0x0000,0x0000,
0x0005,0x000A,0x0005,0x0500,0x0000,0xFB05,0x0005,0x0005,
0x0000,0x05F6,0xF600,0x05FB,0x0500,0x00FB,0x0000,0xFBFB,
0xF105,0x0AFB,0x050F,0x0000,0x00FB,0xFBF1,0xF1EC,0x32FB,
0x0014,0x0AF6,0x0005,0xFBE7,0xDDFB,0x41EC,0x0519,0x0AEC,
0xFB0F,0xF6E2,0xD8FB,0x41F6,0xFB1E,0x0FEC,0xFB19,0x00E2,
0xD80F,0x41EC,0xFB1E,0x00EC,0xFB19,0xF6D8,0xD34B,0x23DD,
0x191E,0xECE2,0x0F0F,0xECCE,0xC47D,0x0AE7,0x2819,0xDDDD,
0x280A,0xD8C4,0xC47F,0xD8EC,0x3C0F,0xC9E2,0x280A,0xD3C4,
0xD37F,0xC4FB,0x460A,0xBFF1,0x2800,0xC9C4,0xF67F,0xBA0A,
0x41F6,0xC40A,0x23F6,0xBFC4,0x5A46,0xB528,0x3CDD,0xBF2D,
0x19E2,0xB5CE,0x7FD8,0xDD46,0x1EC4,0xD337,0x0FCE,0xB0E2,
0x7F97,0x0550,0x05BA,0xF62D,0x0ABF,0xC4F6,0x7F8D,0x0F55,
0xF1B5,0x0537,0xF6BA,0xC91E,0x7D92,0x1950,0xE7B5,0x1932,
0xE7B5,0xD37F,0x28B0,0x323C,0xCEBF,0x3714,0xD3B0,0xEC7F,
0xBAE7,0x460F,0xC4E2,0x2D05,0xC4BF,0x2878,0x9714,0x4BEC,
0xBA14,0x28F1,0xB5D3,0x7837,0xA623,0x41D3,0xBA2D,0x28D3,
0xB5EC,0x7F05,0xB532,0x37C4,0xC437,0x23C9,0xB500,0x7FCE,
0xCE46,0x19BF,0xD83C,0x0ABA,0xBF2D,0x73AB,0xFB46,0xF6BF,
0x0A2D,0xECB0,0xE77F,0x14B5,0x2837,0xDDBF,0x321E,0xC9B5,
0x0F7F,0xD3D3,0x3C1E,0xC9DD,0x3C0F,0xB5C9,0x2D78,0xBAE7,
0x4B05,0xBAF6,0x3CF6,0xB5DD,0x5046,0xB505,0x41F1,0xBF14,
0x37DD,0xB005,0x780A,0xBF2D,0x23D8,0xCE2D,0x1EC4,0xBF32,
0x6EC9,0xE23C,0x05CE,0xE732,0x00B0,0xE75A,0x32BF,0x0F2D,
0xF1C9,0x0F28,0xE2B5,0x145A,0x05D3,0x1919,0xE7D3,0x1923,
0xC9CE,0x3746,0xECEC,0x1400,0xECEC,0x190A,0xD3EC,0x322D,
0xE700,0x05FB,0xF6F6,0x0FF6,0xDD1E,0x190A,0xF600,0xF600,
0xF6F6,0xFBEC,0x0019,0x0A0A,0x05F6,0xFB0A,0xECFB,0xFBF6,
0x0A0F,0x0A0A,0xFBF1,0x0005,0xECFB,0x00FB,0x0F0A,0x0F05,
0xF6F6,0x0A00,0xF100,0xFB00,0x0A0A,0x0AFB,0xF100,0x0AF6,
0xF605,0x0000,0x0F0A,0x00F6,0xF60A,0xFBEC,0xFB05,0xFB0A,
0x0A05,0xFBF6,0xFB0A,0xF6F6,0x0500,0x000F,0x0A00,0xF6F6,
0x0000,0xF6F6,0x0A00,0x000A,0x0500,0xF6FB,0x05FB,0xF6FB,
0x05FB,0x050A,0x05FB,0xF600,0x05FB,0xFB05,0x0000,0x0F05,
0x05FB,0xFB00,0x05FB,0xFB05,0x0005,0x0A00,0x05FB,0xFB00,
0x00FB,0xFB0A,0x0000,0x0500,0x00FB,0xFB05,0xFBFB,0xFB05,
0xFB05,0x0500,0xFBFB,0x0000,0xFBFB,0x0505,0x0005,0x0005,
0xFBFB,0x0500,0xFBFB,0x0500,0x0005,0x0000,0xFBFB,0x00FB,
0xFB00,0x0500,0x0005,0x0000,0xFB00,0x00FB,0xFB05,0x0500,
0x0000,0x00FB,0xFBFB,0x00FB,0x0005,0x0500,0x0000,0x05FB,
0xFB00,0x00FB,0x0005,0x0500,0x0000,0x00FB,0xFB00,0xFBFB,
0x0500,0x0500,0x0000,0x00FB,0xFB00,0xFB00,0x0500,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFBFB,
0x0000,0xFB00,0x0000,0x0000,0x0000,0xFBFB,0x00FB,0xFB05,
0x0000,0x0000,0x00FB,0xFB00,0x00FB,0xFB00,0x0000,0x0000,
0x00FB,0x0000,0x00FB,0x0000,0x0000,0x0000,0x00FB,0x0000,
0x0000,0x0500,0x0000,0x0000,0xFBFB,0x0000,0x0000,0x0500,
0x0000,0x0000,0xFBFB,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFB00,0x0000,0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,0x0005,0x00FB,
0x0000,0x00FB,0xFB00,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFBFB,0xFBFB,0x0005,0x0000,0x0000,0x0000,0x0000,0x00FB,
0x000A,0x05FB,0x0505,0x0000,0x0500,0xFBF6,0xFB00,0x050A,
0x0A05,0x0000,0x0000,0x00FB,0xF6EC,0xF105,0x0500,0x0F0A,
0xFB05,0x0A00,0x0000,0xFBE7,0xE700,0x1400,0x000F,0x0500,
0x0A05,0xFB00,0x00F6,0xE7EC,0x0A14,0x050A,0x0F00,0xFB05,
0x00FB,0x0000,0xECD8,0x0528,0x0505,0x1400,0xEC00,0x0AFB,
0x0000,0xE7CE,0x0A37,0x0A0A,0x1900,0xF105,0x00F6,0x0005,
0xECC9,0xF13C,0x19F6,0x1914,0xF1FB,0x05FB,0xFB00,0xF6D8,
0xD332,0x2DE7,0x1423,0xFBF6,0x0500,0xF600,0xFBD3,0xD332,
0x19DD,0x1E1E,0xECFB,0x14F6,0xEC0A,0x00C4,0xF64B,0x05E2,
0x2319,0xE70F,0x14E2,0xEC0F,0x00C9,0xEC4B,0x0FDD,0x1E14,
0xF60A,0x05EC,0xEC05,0x00D3,0xD841,0x2DD8,0x141E,0xF100,
0x0FF6,0xE700,0x00D8,0xD33C,0x37D8,0x0F23,0xF100,0x14F6,
0xEC00,0xFBD3,0xF646,0x14E2,0x1E14,0xDD0A,0x23EC,0xEC0F,
0x00BF,0x055A,0x0AE7,0x230F,0xE20F,0x19EC,0xEC05,0xF6C4,
0xF650,0x14E2,0x190A,0xE705,0x0FEC,0xEC05,0xFBC9,0xE74B,
0x1ED8,0x1919,0xE700,0x14F6,0xE700,0xFBD3,0x0050,0x0FDD,
0x1E14,0xDD00,0x19EC,0xE205,0xF6C9,0x1455,0x00E2,0x230A,
0xE20A,0x14E7,0xEC0F,0xF1C9,0x1450,0x05E7,0x1905,0xEC05,
0x0AEC,0xEC05,0xF1D8,0x0F46,0x0FE7,0x0F0A,0xF100,0x0AF6,
0xEC00,0xF1E7,0x193C,0x0FEC,0x0A0A,0xF100,0x0AFB,0xF6F6,
0xECF6,0x2832,0x05FB,0x0000,0x00FB,0xFBF6,0xF6F1,0xF1FB,
0x232D,0x05FB,0xFB00,0x00FB,0xFBFB,0xFBF6,0xF100,0x1E19,
0x05FB,0xFB00,0x00FB,0xFBFB,0xF6F6,0x000A,0x1414,0x00FB,
0xFB00,0x00FB,0xFBF6,0xF6FB,0x0005,0x1914,0xFBFB,0x0500,
0xFBFB,0xFBF6,0xFB00,0xFB05,0x1E0A,0xF600,0x00F6,0xFB00,
0xF6F6,0xFB05,0x0005,0x190A,0xFB00,0x00FB,0x00FB,0xF6FB,
0x0005,0x050A,0x0F05,0x0000,0x00FB,0xFBF6,0xF6FB,0x0000,
0x050F,0x0A00,0xFB00,0x00FB,0xFBFB,0xFBFB,0x0005,0x050A,
0x0A00,0xFB00,0x00FB,0xFBFB,0xFB00,0x0500,0x000A,0x0A00,
0xFB00,0x00FB,0xFBFB,0xFB00,0x0505,0x0005,0x0500,0xFB00,
0xFBFB,0xFBFB,0xFB00,0x0005,0x0505,0x00FB,0xFB00,0x00FB,
0x00FB,0xFB00,0x0500,0x050A,0x00FB,0xFB00,0x00FB,0x0000,
0x0000,0x0505,0x0005,0x0000,0x0000,0x00FB,0x00FB,0xFB00,
0x0505,0x0005,0x0000,0xFB00,0x00FB,0x0000,0x0005,0x0500,
0x0000,0x0000,0x0000,0x00FB,0x0000,0x0005,0x0500,0x0005,
0x0000,0x0000,0xFBFB,0x0000,0x0005,0x0500,0x0005,0x00FB,
0xFB00,0x00FB,0xFBFB,0x0000,0x0500,0x0000,0x0000,0x0000,
0x00FB,0x0000,0x0005,0x0500,0x0000,0x0000,0x00FB,0xFBFB,
0xFB00,0x0005,0x0500,0x0000,0x0000,0x00FB,0xFB00,0x0000,
0x0005,0x0500,0x0000,0x0000,0x00FB,0xFB00,0x0000,0x0005,
0x0500,0x0000,0x0000,0x00FB,0xFBFB,0x0000,0x0005,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,
0x0000,0x0000,0xFB00,0x0000,0x0005,0x0000,0x0000,0x0000,
0x00FB,0x0000,0x0000,0x0005,0x0500,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0505,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,
0xFB00,0x0000,0x0000,0x0500,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FB,0x0000,0x0500,0xFB00,0x0500,0x0500,0x00FB,0x00FB,
0x00FB,0x0500,0xFB00,0x0005,0xFB00,0x0000,0x0000,0x00FB,
0xFB00,0xFBFB,0x0AFB,0x0000,0x0500,0x0005,0x0000,0x0500,
0x05FB,0xFBFB,0xF60A,0x05FB,0x050A,0x00FB,0x0A00,0xFB00,
0x0000,0x00F1,0xE7EC,0x0A2D,0xEC0F,0x1400,0xF60F,0x05EC,
0x000A,0x00F1,0xECEC,0xEC19,0xFB05,0x1E0F,0xFB0F,0x0FF6,
0x05FB,0xFB00,0xFBFB,0xFBEC,0xE2FB,0x1EFB,0x140A,0x0FF6,
0x0A0A,0xF6F6,0xFBF6,0xFB05,0x00F6,0xDDCE,0x321E,0xFB05,
0x23F6,0xF60F,0xF1EC,0xFB00,0x00FB,0x00E2,0xDDF6,0x3CF1,
0x0F28,0x0FF1,0x000F,0xF6EC,0x0000,0x05F6,0x00E2,0xD80A,
0x3705,0x1923,0x00EC,0x0F05,0xFBFB,0x05FB,0xF6FB,0xF6DD,
0xDD19,0x3700,0x2314,0xF6F6,0x1900,0xE7FB,0x0AF6,0xF1FB,
0xE7DD,0xE737,0x1E00,0x2805,0xF100,0x0FF1,0xF100,0x00F6,
0xF6FB,0xDDDD,0x0F46,0xFB19,0x2800,0xF60A,0x00E7,0xF60A,
0x00F1,0xFBEC,0xD3F6,0x2828,0xF137,0x14EC,0xFB19,0xECE2,
0x000A,0xF6EC,0xFBE2,0xD819,0x3C05,0x0A2D,0xFBF1,0x0A0A,
0xE7F1,0x0A00,0xECF6,0xE2D8,0x0528,0x23FB,0x3205,0xF100,
0x0FF1,0xE705,0x05F6,0xF1F6,0xDDDD,0x231E,0x1414,0x23F6,
0x000A,0x00E7,0xF605,0x05F1,0xFBEC,0xCEF6,0x2D23,0xFB23,
0x14F1,0x050A,0xF6E2,0x000A,0xF6F1,0xFBD8,0xDD23,0x320A,
0x0F23,0xFBFB,0x0505,0xECF1,0x0A05,0xF1F6,0xE2D8,0x0A28,
0x1E05,0x2D00,0xF605,0x05F6,0xEC00,0x0AF1,0xF1F6,0xD8F1,
0x1E19,0x1414,0x1EFB,0x0005,0x00F1,0xF105,0x00F1,0xFBE2,
0xDD0A,0x2319,0x051E,0x05F6,0x0005,0xF6EC,0xFB0A,0xF6EC,
0xF1DD,0xFB0F,0x280F,0x0F0F,0xF605,0x00F6,0xF6FB,0x0500,
0xF6F6,0xF6E2,0x0A19,0x190A,0x0A05,0xFB05,0xFBF6,0xFBFB,
0x05F6,0xF1F6,0xEC00,0x0F19,0x1405,0x0A00,0x0000,0xF6FB,
0xFB00,0xFBF1,0xF1F6,0x0000,0x0F23,0x0A00,0x0500,0xFBFB,
0xFBFB,0xFBFB,0xFBF1,0xF600,0x000A,0x190F,0x0005,0x0500,
0xFBFB,0x00FB,0xFBFB,0xF6F1,0xFB00,0x050F,0x0F05,0x0000,
0x00FB,0xFBFB,0x00FB,0xFBF6,0xF6F6,0xFB0A,0x0F0A,0x0A05,
0x0000,0xFB00,0xFBFB,0xFBFB,0xFBFB,0xFBFB,0x050F,0x0A0A,
0x0A00,0xFB00,0xFBFB,0xFBFB,0x00FB,0xFBFB,0xFB00,0x0A0A,
0x050A,0x00FB,0x0000,0x00FB,0xFB00,0xFBFB,0xFBFB,0xFB05,
0x0A05,0x0505,0x0000,0x00FB,0xFBFB,0xFBFB,0xFBFB,0x0000,
0x050A,0x0A05,0x0500,0xFBFB,0x0000,0xFB00,0x00FB,0xFBFB,
0x0000,0x050A,0x0500,0x0000,0x0000,0x0000,0x0000,0xFBFB,
0x0000,0x0000,0x0505,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFBFB,0x0000,0x0005,0x0500,0x0000,0x0000,0x0000,0x00FB,
0xFBFB,0xFB00,0x0000,0x0005,0x0500,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0505,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0505,0x0500,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0505,0x0000,
0x0000,0x0000,0x0000,0xFB00,0x0000,0x0005,0x0000,0x0000,
0x00FB,0xFB00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FB,0xFB05,0x0500,0x0005,0x0000,0x0000,0x0000,0xF6F1,
0x000F,0x0000,0x0A05,0x0005,0x00FB,0x00F6,0xE7E7,0x0519,
0x0505,0x0F00,0x000A,0x05FB,0xF6F1,0xE2E2,0x0A1E,0x050A,
0x0F05,0x050A,0x05FB,0x00FB,0xE7DD,0x001E,0x0A05,0x140A,
0x0000,0x05FB,0xFBFB,0xECD3,0xEC28,0x14FB,0x1414,0xFBFB,
0x05FB,0xFB00,0xFBCE,0xD82D,0x23F6,0x1E19,0xF1FB,0x0AFB,
0xF605,0x00CE,0xCE2D,0x28F1,0x191E,0xFBFB,0x05FB,0xF600,
0xFBD3,0xC42D,0x32EC,0x0F1E,0xFBFB,0x0500,0xF600,0xFBD8,
0xD332,0x28E2,0x141E,0xFB00,0x0AFB,0xF100,0x00D3,0xE746,
0x1EE7,0x1919,0xF60A,0x0FF6,0xF100,0x00CE,0xE746,0x23E7,
0x1419,0xFB00,0x05F6,0xECFB,0xFBCE,0xE746,0x23E7,0x141E,
0xFB00,0x0AFB,0xF1FB,0xFBD3,0xE241,0x23E2,0x1419,0xF600,
0x0AFB,0xECFB,0xF6C4,0x0F55,0x0AF6,0x190F,0xEC00,0x0AF6,
0xF600,0xE7B5,0x285A,0x00FB,0x1405,0xF105,0x00F1,0xF100,
0xE2BA,0x2D5A,0xFBFB,0x1405,0xF605,0x05F1,0xF1FB,0xE2BF,
0x3255,0xF6FB,0x1405,0xF100,0x00F1,0xF1FB,0xDDC4,0x3741,
0xEC05,0x1400,0xFB05,0x00F1,0xF6FB,0xCEE2,0x462D,0xF60A,
0x0AFB,0x0005,0xF6EC,0xF6FB,0xC900,0x5514,0xFB0A,0x05FB,
0x0000,0xF6F1,0xF6F1,0xC414,0x5A0F,0xFB0A,0x00FB,0x0000,
0xF6F1,0xF1E7,0xC92D,0x5A00,0x000F,0x00FB,0x05FB,0xF1F1,
0xF1E2,0xCE41,0x4BF6,0x0F0A,0xFB00,0x00F6,0xF1F6,0xF1DD,
0xE241,0x2DF6,0x1900,0xF10A,0x00EC,0xF1F6,0xF1D8,0xF64B,
0x23F6,0x1900,0xF10A,0x00EC,0xF1F6,0xE2D8,0x144B,0x14FB,
0x14FB,0xF10A,0x00E7,0xF1F1,0xDDE2,0x324B,0x0000,0x14F6,
0xF10A,0xFBE7,0xF1EC,0xE2EC,0x4146,0xFB00,0x0FF6,0xF105,
0xF6E7,0xF1E7,0xE7FB,0x3737,0xFB00,0x0AFB,0xF600,0xF6EC,
0xECE7,0xF105,0x3228,0xFBFB,0x0000,0xFBFB,0xF1EC,0xF1F1,
0xF60F,0x231E,0x00FB,0x0500,0xFBF6,0xF6EC,0xE700,0x0A0F,
0x1919,0x00F6,0x0A05,0xF1FB,0xF6E7,0xF605,0x000F,0x230F,
0x00EC,0x0F0A,0xECF6,0xFBE7,0xEC0A,0x0AFB,0x320F,0x00F6,
0x0A00,0xF6F6,0xF6EC,0xF10F,0x0A05,0x2805,0x05F6,0x00FB,
0xFBF6,0xF1EC,0xFB0F,0x000F,0x1E05,0x00F6,0x00FB,0xF6F6,
0xF1F6,0xFB0A,0x050F,0x1900,0x05FB,0xFB00,0xF6F6,0xF6FB,
0x000F,0x050F,0x1400,0x00F6,0x00FB,0xF6FB,0xF6FB,0x000F,
0x050F,0x0F00,0x00FB,0x00FB,0xF6FB,0xF6FB,0x050F,0x050A,
0x0A00,0xFBFB,0x00FB,0xF6FB,0xF600,0x050F,0x050A,0x0A00,
0xFB00,0xFBF6,0xF6F6,0xF600,0x050F,0x0505,0x0500,0xFB00,
0xFBF6,0xF6FB,0xF605,0x050A,0x0505,0x0000,0xFBFB,0xFBFB,
0xFBFB,0xFB05,0x0A05,0x0505,0x0000,0xFBFB,0xFBFB,0xFBFB,
0xFB05,0x0A05,0x0500,0x00FB,0xFBFB,0xFBFB,0xFB00,0x0005,
0x0A00,0x0500,0x0000,0x0000,0xFBFB,0x00FB,0x0005,0x0A00,
0x0000,0x0000,0x00FB,0xFBFB,0x00FB,0x0505,0x0A00,0x0000,
0x0000,0xFBFB,0x00FB,0x0500,0x050A,0x0500,0x0000,0xFBFB,
0xFBFB,0xFB00,0x0500,0x0005,0x0500,0x0000,0x00FB,0xFBFB,
0x00FB,0x0000,0x0005,0x0500,0x0000,0x00FB,0xFBFB,0x00FB,
0x0000,0x0005,0x0500,0x00FB,0xFBFB,0xFBFB,0x0000,0x0000,
0x0005,0x0500,0x0000,0x00FB,0xFB00,0x0000,0x0000,0x0005,
0x0000,0x0000,0x00FB,0x0000,0x0000,0x0000,0x0005,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0500,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0500,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0505,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFB0A,
0x0A00,0xFB0F,0x00FB,0x0000,0xE7F1,0x190A,0xF60A,0x0A00,
0xFB05,0xFBEC,0xEC19,0x0FF1,0x0514,0xFB00,0x0AFB,0xF6E7,
0xF628,0x0AF1,0x140F,0xFBF6,0x0F00,0xF1E2,0xE219,0x14F1,
0x0F1E,0xF6F1,0x0A05,0xE2CE,0xE25F,0xF1F6,0x320F,0xE2F6,
0x19FB,0xD8CE,0xC96E,0x05F6,0x3714,0xE2F6,0x2D05,0xD8C4,
0xBA7F,0xE2EC,0x3C14,0xD800,0x2305,0xC9C4,0xC47F,0xBF00,
0x3C0A,0xD3F6,0x1905,0xD3CE,0xA67F,0xD8EC,0x320F,0xCEEC,
0x3705,0xCEBA,0xB07F,0xA6FB,0x4605,0xC405,0x2D00,0xBFC4,
0xBA7F,0x8828,0x41FB,0xBF14,0x2300,0xB0D3,0xE27F,0x882D,
0x4BF1,0xB528,0x23F6,0xABB5,0x784B,0xA146,0x4BE2,0xA64B,
0x23D8,0xABD3,0x7F1E,0xBF55,0x3CCE,0xB546,0x2DBF,0xABB0,
0x7F9C,0xEC5F,0x1EBA,0xDD37,0x1EB5,0xA6BA,0x7F80,0x1964,
0x0AAB,0xFB32,0x19A1,0xC4C4,0x7F80,0x1E69,0xF6A1,0x143C,
0x0097,0xBF1E,0x7F80,0x2D64,0xE297,0x3C32,0xF697,0xC464,
0x5F80,0x4B50,0xD3A6,0x412D,0xDD9C,0xC47F,0xF6B5,0x553C,
0xC9B0,0x4B1E,0xBAA1,0xBF7F,0x8005,0x5F0F,0xBAF6,0x2314,
0xB0B5,0xD87F,0x801E,0x64F6,0xA614,0x32F6,0xA1C4,0x237F,
0x8032,0x69D8,0xA141,0x28E2,0xA1C9,0x7F32,0x8355,0x55BF,
0xAB5F,0x23C9,0xA6D8,0x7FEC,0xB564,0x3CAB,0xBF5A,0x19B5,
0xA6C9,0x7F80,0xEC78,0x0FA1,0x003C,0x05A6,0xBAF6,0x7F80,
0x1446,0x32C4,0xE232,0x0AC4,0xBA0A,0x5AF1,0xCE50,0x1EB5,
0xF641,0x00B0,0xBF46,0x69DD,0xF15A,0x0AAB,0x054B,0xF6AB,
0xCE69,0x5FC4,0x0055,0xF6AB,0x0F41,0xE2A1,0xD364,0x28B0,
0x2346,0xD8C4,0x1E28,0xC9AB,0xFB5A,0x00BF,0x3C23,0xBFE2,
0x2D0A,0xBABF,0x2850,0xE7DD,0x410F,0xB5F6,0x3CFB,0xA6CE,
0x644B,0xC400,0x4BFB,0xB505,0x3CDD,0xA6F6,0x6928,0xC414,
0x3CE7,0xC40A,0x2DD8,0xB505,0x500A,0xCE19,0x2DDD,0xD81E,
0x19C4,0xCE28,0x3CF6,0xE21E,0x0FD8,0xF11E,0x00D3,0xEC28,
0x2DFB,0xEC14,0x05E7,0xFB0F,0xFBDD,0x0032,0x1EF1,0xF60A,
0x05EC,0xFB05,0xF1F1,0x0F23,0x0FF6,0xFB05,0x00F6,0x00FB,
0xEC00,0x140F,0x0AFB,0xFB05,0x00F6,0x00F6,0xF10A,0x190F,
0x00F6,0xFB00,0xF6F1,0x00FB,0xFB0A,0x0F0A,0x00FB,0x0005,
0xF6FB,0x0000,0x000A,0x0F05,0xFBFB,0x0500,0xF6FB,0x0000,
0x050F,0x0A00,0xFBFB,0x0000,0xF600,0x00FB,0x0A0F,0x0500,
0xFB00,0x00FB,0xF600,0x0000,0x0A0F,0x05FB,0xFB00,0x00F6,
0xF600,0x0000,0x0A0A,0x00FB,0xFB00,0x00F6,0x0000,0x0005,
0x0A05,0x00FB,0xFB00,0x00FB,0x0000,0x0005,0x0500,0x00FB,
0x0000,0xFBFB,0x0000,0x0005,0x0500,0xFBFB,0x0000,0xFB00,
0x0500,0x000A,0x0500,0xFB00,0x00FB,0xFB00,0x0500,0x0005,
0x0500,0xFB00,0x00FB,0xFB00,0x0500,0x0005,0x0500,0xFB00,
0x00FB,0x0005,0x0500,0x0000,0x0000,0xFB00,0x00FB,0x0005,
0x0500,0x0000,0x0000,0x0000,0x00FB,0x0005,0x0000,0x0000,
0x00FB,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFB00,0x0000,0x0000,0x0000,0x0000,0x0000,0xFB00,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFB00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x00FB,0x0000,0x0000,
0x0000,0x00FB,0xFB00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x00FB,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x00FB,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0005,0x0500,0x0000,0x0000,0x0000,0xFBF6,0xFB05,0x0500,
0x0505,0x0000,0x0000,0x0000,0xFBFB,0x0005,0x0500,0x0000,
0x0000,0x0000,0x00FB,0xFBFB,0xFB00,0x0500,0x0000,0x0000,
0x0000,0x00FB,0xF6EC,0xF619,0x0FFB,0x0F0A,0xFB00,0x0500,
0xFBFB,0xF6E2,0xE219,0x23FB,0x0F14,0x0000,0x0A00,0xFBFB,
0xF1DD,0xDD19,0x2DFB,0x0519,0x0000,0x0A05,0xFB00,0xFBE7,
0xD3FB,0x2D0F,0x001E,0x0AF6,0x0005,0x00FB,0xFBE7,0xC4FB,
0x370A,0xFB1E,0x0AF1,0x0005,0xF600,0x00E7,0xBF00,0x4605,
0x0028,0x0AEC,0x0500,0xF100,0x05EC,0xBFFB,0x460A,0xF623,
0x0FF6,0x0500,0xF1FB,0x00F1,0xC9EC,0x4114,0xEC23,0x14FB,
0x0500,0xF6FB,0x00F6,0xCEF6,0x460F,0xF123,0x14F6,0x0A05,
0xF1F6,0x00EC,0xBF19,0x5500,0xFB1E,0x0AF6,0x0F00,0xECFB,
0xFBFB,0xD8A6,0x7F19,0xEC19,0x19F6,0x0014,0xE2F6,0xFBF6,
0xD3B0,0x7F23,0xE214,0x1EF6,0xF614,0xE7F6,0xF6F6,0xCEB5,
0x7F0A,0xE719,0x19F6,0xF60F,0xE7FB,0xFBEC,0xC9AB,0x7FC9,
0x0F1E,0x05F1,0x0F00,0xE2FB,0x05E2,0xBFC4,0x7FB0,0x1919,
0xFBF1,0x23F1,0xE7FB,0x00DD,0xB5EC,0x7FBA,0x1919,0xF6F6,
0x19F1,0xE7F6,0x00E2,0xBADD,0x7FBF,0x0A23,0xF6F6,0x14F1,
0xECF6,0xFBD8,0xBF0A,0x7FB5,0x231E,0xE7FB,0x2DE2,0xECFB,
0xFBD3,0xC464,0x4BBF,0x2D14,0xE200,0x2DD8,0xF1FB,0x00CE,
0xB57F,0x32D3,0x320A,0xE20F,0x1ED8,0xF600,0x00BF,0xBF7F,
0x23D3,0x320F,0xD814,0x19D8,0xF1FB,0xF6C4,0xC97F,0x14D8,
0x2D0F,0xCE0F,0x14D3,0xF600,0xECBF,0xD37F,0xE7EC,0x3700,
0xC923,0x0FCE,0xF60A,0xE2B5,0xFB7F,0xD8F6,0x32EC,0xD828,
0x00D3,0xF600,0xDDC4,0x147F,0xDDF6,0x32E7,0xE219,0x00D8,
0xF100,0xCED3,0x2873,0xE2F1,0x32F1,0xE70F,0x00DD,0xECFB,
0xCEF1,0x2D50,0xF6F1,0x23F6,0xF10A,0xF6E2,0xF600,0xD800,
0x323C,0xFBE7,0x0A0A,0xF100,0xF6EC,0xE705,0xEC00,0x3214,
0x14E2,0x0A0F,0xF1FB,0xF6F1,0xE2FB,0x0500,0x281E,0x05E7,
0x0A0A,0xECF6,0xF6EC,0xE70F,0x00FB,0x3714,0xF6EC,0x1400,
0xEC00,0xF1EC,0xF10F,0xFB05,0x3200,0xFBF6,0x0AFB,0xF6FB,
0xECEC,0xFB19,0xF10F,0x2800,0x00FB,0x00F6,0xF6FB,0xECF6,
0x000F,0xFB19,0x1400,0x00FB,0x00FB,0xFBF6,0xF1FB,0x050A,
0x0519,0x0F00,0xFB00,0x00F6,0xF6FB,0xF1FB,0x050A,0x0514,
0x0A05,0xFB00,0x05F6,0xFBF6,0xF605,0x0505,0x0514,0x0500,
0xFB00,0x00F1,0xFBFB,0xF600,0x0A05,0x050F,0x0505,0xFBFB,
0x00F1,0xFBF6,0xFB05,0x0A00,0x0A05,0xFB05,0xFBFB,0xFBF6,
0xFBF6,0xFB05,0x0F05,0x0505,0x00FB,0xFBFB,0x00F6,0xFBFB,
0xFB05,0x0A05,0x0005,0x0000,0xFBFB,0xFBFB,0xFBF6,0x000A,
0x0A00,0x0505,0x0000,0x00FB,0xFBFB,0x00FB,0x0505,0x0A05,
0x0500,0x0000,0xFBFB,0xFBFB,0xFBFB,0x050A,0x0505,0x0500,
0x00FB,0xFBFB,0xFBFB,0xFBFB,0x050A,0x0505,0x0000,0x00FB,
0xFBFB,0xFBFB,0xFB00,0x0505,0x0005,0x0000,0xFB00,0xFBFB,
0xFBFB,0xFB00,0x0505,0x0000,0x0000,0x0000,0xFBFB,0xFB00,
0x0000,0x0505,0x0000,0x0000,0xFBFB,0xFBFB,0xFB00,0x0000,
0x0505,0x0000,0x0000,0x00FB,0xFB00,0xFB00,0x0000,0x0505,
0x0000,0x0000,0x00FB,0xFB00,0xFB00,0x0000,0x0505,0x0000,
0x0000,0xFBFB,0x0000,0x0005,0x0000,0x0505,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0500,0x0000,0x0000,0x0000,
0xFB00,0x0000,0x0000,0x0500,0x0000,0x0000,0xFBFB,0x0000,
0x0000,0x0000,0x0500,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0005,0x0500,0x0000,0x0000,0xFBFB,0xFB00,0x0500,0x0000,
0x0500,0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,0x0500,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFB05,
0x0000,0x0A05,0x0000,0x00F1,0xEC0F,0x0A00,0xFB0A,0x0000,
0x0000,0xF6EC,0xFB0F,0x05FB,0x050A,0xFBFB,0x0505,0xFBF1,
0xF60A,0x0FFB,0x0014,0xFBF6,0x0A05,0xFBF1,0xEC0A,0x1400,
0x0014,0x00F1,0x0A0A,0xFBE7,0xE205,0x46E7,0x0514,0xFBE7,
0x0F0F,0xE7C9,0xD84B,0x1EDD,0x1E19,0xECFB,0x1405,0xE7C9,
0xD823,0x37FB,0x0A23,0x00EC,0x0A14,0xF6D8,0xD323,0x3CF1,
0x0A28,0xFBDD,0x0519,0xF1D8,0xD814,0x3CFB,0x0028,0xF6DD,
0x0A1E,0xF1D8,0xC919,0x46F1,0x0023,0xF6DD,0x0F1E,0xECCE,
0xBF37,0x32DD,0x1E1E,0xECF1,0x140A,0xE2CE,0xD33C,0x1EE2,
0x2D19,0xE2F1,0x190A,0xDDC9,0xEC46,0x0AE2,0x3714,0xD3F6,
0x2805,0xCEC9,0x004B,0x00F1,0x410A,0xCEFB,0x2D00,0xC9CE,
0x2D55,0xF100,0x41FB,0xC400,0x2DF6,0xC4BF,0x4B46,0xCE1E,
0x37EC,0xD30A,0x23E2,0xC4C9,0x4628,0xCE32,0x28DD,0xE214,
0x14D8,0xBFE2,0x4605,0xD33C,0x14CE,0xEC23,0x0ACE,0xBFFB,
0x5000,0xE241,0x0AC4,0xF62D,0x00C4,0xC923,0x5AF1,0xF146,
0x05C4,0xFB2D,0xF6BF,0xC955,0x55CE,0x0F3C,0xF1C9,0x051E,
0xDDBF,0xD350,0x1EC9,0x2D23,0xD8E7,0x140F,0xD3BF,0xF64B,
0xFBD3,0x4114,0xC9F6,0x2800,0xC4BF,0x375F,0xE2F1,0x4600,
0xBF00,0x2DF6,0xBFD3,0x505A,0xDD00,0x46F6,0xBF05,0x2DEC,
0xBAD8,0x5A3C,0xC919,0x3CE7,0xCE14,0x1ED8,0xBAF1,0x5005,
0xCE37,0x23D3,0xEC23,0x05C9,0xC92D,0x5AEC,0xF146,0x05C4,
0x0032,0xF1B5,0xD35F,0x4BCE,0x0F41,0xF1C9,0x0A28,0xE2B5,
0xEC5F,0x23C9,0x2332,0xDDD3,0x191E,0xD3BF,0x0555,0x00D3,
0x2D1E,0xCEE7,0x2305,0xBFCE,0x4150,0xE2F1,0x3700,0xC4FB,
0x28EC,0xB5E2,0x5F37,0xCE0A,0x32EC,0xCE0A,0x1ED3,0xBA0F,
0x5F05,0xD323,0x23DD,0xE219,0x05BF,0xCE32,0x4BF1,0xEC28,
0x0FD8,0xEC1E,0xF6BA,0xEC46,0x2DE7,0xFB23,0x00DD,0xFB1E,
0xE7BA,0x0A50,0x1EE7,0x0A14,0xF1E7,0x0014,0xD8D3,0x1E37,
0x05EC,0x0A00,0xF1F6,0x0505,0xE2F6,0x231E,0x00F6,0x0500,
0xFBFB,0x00F6,0xE70F,0x230A,0x0000,0xFB00,0xFBF6,0xF6EC,
0xF60F,0x0F0A,0x05FB,0xFB00,0xFBF1,0xF6F6,0x000F,0x0F0F,
0x00FB,0x0005,0xF6F1,0xFBFB,0x050A,0x0F0A,0xFBFB,0x0000,
0xF6FB,0x0000,0x050F,0x0F00,0xF600,0x05FB,0xF100,0x0000,
0x0A0F,0x05FB,0xFB05,0x05F6,0xF600,0x0000,0x0F0F,0x05FB,
0xFB05,0x00F1,0xF600,0x0005,0x0F0A,0x00FB,0x0005,0x00F6,
0x0000,0x0005,0x0A05,0x00FB,0x0000,0xFBFB,0x0005,0x0005,
0x0A00,0x00FB,0x0000,0xFBFB,0x0000,0x0005,0x0500,0xFBFB,
0x00FB,0xFB00,0x0000,0x0505,0x0500,0x0000,0x0000,0xFB00,
0x0000,0x0505,0x0000,0xFB00,0x00FB,0x0000,0x0000,0x0000,
0x0000,0xFB00,0x00FB,0x0000,0x0000,0x0000,0x0000,0xFB00,
0x00FB,0x0005,0x0000,0x0500,0x0000,0xFB00,0xFBFB,0x0000,
0x0000,0x0000,0x00FB,0x0000,0x0000,0x0000,0x0000,0x0000,
0x00FB,0x0000,0xFB00,0x0000,0x0000,0x0000,0x00FB,0x0000,
0x0000,0x0000,0x0000,0x0000,0x00FB,0x0000,0x0000,0x0000,
0x0000,0x0000,0x00FB,0x0000,0x0000,0x0000,0x0000,0x0000,
0xFB00,0x00FB,0x0000,0x0000,0x0000,0x0000,0xFB00,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x00FB,0xFB00,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x00FB,0x0000,0x0000,
0x0000,0x0000,0x0000,0xFB00,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFB00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFB0A,0x14F6,0x0F0F,0xFBCE,0xFB37,0xF100,0x190F,
0xF1DD,0xD823,0x14F1,0x1928,0xF1DD,0xD800,0x2DE7,0x0A37,
0x05E2,0x05DD,0xF12D,0xF119,0x23FB,0xE7E7,0xDD32,0xF60A,
0x2819,0xE7F6,0xD8BF,0x6EE7,0x0537,0x0ADD,0xECD3,0xCE55,
0x000A,0x3CF6,0xDDEC,0xC9B5,0x7FCE,0x1E41,0xF6D3,0xFBB5,
0xE264,0xD82D,0x41DD,0xDD05,0x9755,0x19DD,0x5028,0xCED3,
0xF1A1,0x7FBF,0x145F,0xFBBF,0xF1AB,0x2846,0xA164,0x55B0,
0xC41E,0x807F,0x0AD3,0x7828,0xA1F1,0xFB80,0x7FC4,0x1E6E,
0xF6B5,0x05C9,0x927F,0x9C41,0x64CE,0xCE0F,0x9CC9,0x7FB0,
0x554B,0xB5D8,0x0083,0x7FEC,0xF178,0x1E92,0xFBDD,0xA17F,
0x8D46,0x6ECE,0xB00A,0x8837,0x509C,0x7F3C,0x83E7,0x1E80,
0x7F14,0xD378,0x0F97,0xF1F1,0x807F,0xA132,0x64EC,0xB005,
0xBFA1,0x7F9C,0x465F,0xC4CE,0x0088,0xFB73,0xAB69,0x3C92,
0xE70F,0x807F,0xE2F6,0x7314,0x83F1,0xDDAB,0x7F80,0x6464,
0xB5B0,0x2D80,0xEC7F,0x8D78,0x4B88,0xD81E,0x807F,0xFBE2,
0x780F,0x88F1,0xF683,0x7FC9,0x1E6E,0xE7B0,0xFBBA,0xCE7F,
0x8D5F,0x5AAB,0xC419,0x8305,0x73AB,0x6437,0x88E2,0x1480,
0x7FBA,0x0F73,0x0088,0x00CE,0xA67F,0x8D46,0x64B0,0xBF14,
0x8DFB,0x7D9C,0x7341,0x80E2,0x2380,0x7F14,0xE264,0x148D,
0xF1F1,0x9C7F,0xAB2D,0x6ED8,0xB0F6,0xB0D3,0x7FA6,0x505A,
0x97D3,0x0F8D,0x5A2D,0xC95F,0x2D83,0xEC0A,0x927F,0xBF19,
0x6EE7,0xA6F1,0xCEB5,0x7FA1,0x465F,0xA1CE,0x0A92,0x0F69,
0xBA55,0x3780,0xF10A,0x927F,0x05EC,0x5A0A,0x92F1,0xECB5,
0x7FBA,0x2D5F,0xCEBF,0xF1BA,0xCE7F,0xBA32,0x5097,0xD800,
0xA173,0x1EDD,0x3C32,0x80E7,0xFBB5,0x7FC4,0x1450,0xF1B0,
0xE2D3,0xD37F,0xBA3C,0x46A6,0xE2EC,0xB52D,0x3CE2,0x3223,
0x92FB,0xE2D8,0x7FE7,0x232D,0xECBA,0x00D8,0xEC73,0x0532,
0x05BF,0xDD1E,0xCEB5,0x7FF6,0x14EC,0xD3F1,0x23D3,0xF669,
0xFBF1,0xFBD3,0xEC14,0xE25F,0x2DF6,0x05FB,0xD3EC,0x0AD3,
0x5F0F,0xFBF1,0xECDD,0x00F6,0x0A46,0xFBF6,0xF6E2,0xE70A,
0xEC41,0x2DF1,0xF1F6,0xECE7,0x05FB,0x410A,0xF6FB,0xF1E7,
0xFB05,0x0F1E,0xFB00,0xF6DD,0xEC0F,0x1414,0x0F00,0x00EC,
0xE7F1,0x0F19,0x0F14,0x05F1,0xE7F1,0xFB05,0x140A,0x0FFB,
0xE7F1,0xF605,0x0A19,0x0505,0xF6E7,0xF600,0x0A14,0x140A,
0x00F1,0xECFB,0x0005,0x0F0A,0x0FFB,0xECF1,0x0005,0x0514,
0x050A,0xF1F1,0xFB00,0x0A14,0x140A,0x00EC,0xF6FB,0xFB0A,
0x190A,0x05FB,0xF1FB,0xFBFB,0x0A0F,0x0000,0xF6F6,0xFBFB,
0x050F,0x0AFB,0xFBF6,0xF6FB,0xFB0A,0x0F05,0x00FB,0xF6FB,
0x00FB,0x0A0A,0x0005,0xF6F6,0x0000,0xFB0A,0x0AFB,0x00F1,
0xF605,0xFB0A,0x0F00,0x00FB,0xF1FB,0x05FB,0x0F0F,0xFB05,
0xFBF1,0x0505,0xFB0A,0x0AF6,0x05F6,0xF60A,0x05FB,0x0A00,
0xFB05,0xF6FB,0x0AFB,0x050A,0xFB00,0x00F6,0x0005,0xFB0A,
0x05FB,0x05FB,0xF605,0x0500,0x0A00,0xFB05,0xF6FB,0x0A00,
0x0005,0xFBFB,0x05F6,0x000A,0xFB00,0x05F6,0x0000,0xFB05,
0x05FB,0x0500,0xFB05,0xFBFB,0x0500,0xFB05,0xFBFB,0x05FB,
0xFB05,0x00FB,0x05FB,0x0005,0xFB05,0x05FB,0x0005,0xFB00,
0x00FB,0x0505,0xFB05,0x00FB,0x05FB,0xFB05,0x00FB,0x05FB,
0xFB05,0xFB05,0x05FB,0xFB05,0xFB00,0x00FB,0x0505,0x0000,
0x00FB,0x0000,0xFB05,0x0000,0x00FB,0xFB05,0x0000,0x0000,
0xFB00,0x0000,0x05FB,0x0000,0xFBFB,0x0000,0x0000,0xFB00,
0x00FB,0x0000,0x0005,0x00FB,0x00FB,0xFB05,0xFB00,0x0500,
0x0000,0x0000,0x0500,0x0000,0xFB00,0x0000,0x0000,0x0005,
0x0000,0x0000,0x0000,0x0000,0x0500,0x0000,0x0000,0x0500,
0x0005,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,
0x0000,0x0500,0x0000,0x0000,0x0000,0x0005,0x0000,0x0000,
0x0005,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,0x0000,
0x0000,0x0000,0x0005,0x0000,0x0000,0x0000,0x0000,0x00FB,
0xFB00,0x0000,0x0000,0x0000,0xFBFB,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0xFBFB,0x0000,0x0000,0x0000,0x0000,0x0000,0x0005,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0005,0x00FB,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x00F6,0x050A,0xFB0A,0x0000,0x0000,0xF6DD,0xFB23,
0x0FF6,0x0F0F,0xF600,0x05F6,0xE7E7,0x1419,0xEC0A,0x14FB,
0x0000,0x00F6,0xDDF1,0x2805,0xF614,0x14FB,0xFB0A,0x05FB,
0xE2DD,0x0A28,0xF10A,0x28FB,0xF10F,0x05F6,0xD8D3,0x0F46,
0xE219,0x28F1,0xDD14,0x0AF6,0xD8C4,0xD87F,0xC419,0x37FB,
0xDD1E,0x1EF1,0xD8BF,0x057D,0xAB19,0x3CF6,0xCE32,0x14E7,
0xC9C4,0x4150,0xC41E,0x37DD,0xCE14,0x0FEC,0xD8C4,0xF17D,
0xB519,0x2DE7,0xC423,0x28DD,0xD8C4,0x1E78,0x9232,0x3CD8,
0xB555,0x19D8,0xD3C4,0x7346,0xB555,0x37C9,0xBA5A,0x05D8,
0xD3C4,0x7F37,0xBA55,0x2DC4,0xBF50,0x19C4,0xC9AB,0x7FE7,
0xC969,0x28BA,0xCE50,0x0ABA,0xCEB0,0x7FBA,0xE773,0x1EAB,
0xD855,0x05AB,0xD3B5,0x7F80,0x0569,0x00AB,0x0546,0xF1B0,
0xC9DD,0x7F80,0x415F,0xE2A1,0x4637,0xE2B5,0xCEFB,0x7F80,
0x5A5A,0xC9A1,0x4141,0xD3B5,0xCE55,0x5A80,0x5A4B,0xC4A1,
0x5F37,0xCEB0,0xC47F,0x378D,0x693C,0xBFA1,0x5F2D,0xBABA,
0xC47F,0x0AB0,0x7332,0xB5B0,0x5F19,0xB5BA,0xB57F,0x83EC,
0x730F,0xB0DD,0x4105,0xBAB5,0xCE7F,0x8023,0x6EF6,0xA605,
0x3CF1,0xA6C4,0xF17F,0x8041,0x6ED3,0x9C32,0x46D8,0xB5C4,
0x4B69,0x8064,0x5AC4,0xA150,0x3CC4,0xBAC4,0x7F46,0x8073,
0x50B5,0xB055,0x32B5,0xB5BF,0x7FD3,0xBA7F,0x2DB0,0xBF5A,
0x14AB,0xB5C9,0x7F80,0xFB7F,0x00AB,0xF13C,0x00AB,0xBAE2,
0x7F80,0x1978,0xE2AB,0x193C,0xE7A6,0xBF3C,0x7380,0x3C69,
0xBFAB,0x413C,0xD3B0,0xBF7F,0x3780,0x5A55,0xB0B5,0x4B3C,
0xB5B5,0xC97F,0xD8B0,0x7837,0xA6C9,0x4B1E,0xA6B0,0xDD7F,
0x80F1,0x7D0A,0xA100,0x3705,0xA1B5,0x0A7F,0x8028,0x73E2,
0xA12D,0x32EC,0xA1BA,0x695A,0x8041,0x69C9,0xA641,0x37D3,
0xABBA,0x7F0A,0x9C5A,0x50B0,0xB54B,0x2DB0,0xB5CE,0x7FA6,
0xCE64,0x2DA1,0xD83C,0x1997,0xBAEC,0x7F80,0x0569,0x0597,
0x1432,0xFB9C,0xBA3C,0x7F80,0x3C5F,0xE29C,0x3732,0xE29C,
0xBA7F,0x2888,0x5A55,0x0ABA,0xFB37,0xFBBA,0xBA64,0x5FC4,
0x1450,0xF1BF,0x052D,0xE7B5,0xCE5F,0x2DBA,0x2D41,0xDDCE,
0x191E,0xD3AB,0xFB64,0xFBC9,0x4128,0xC9E7,0x2D0A,0xC4AB,
0x3773,0xDDEC,0x4B0A,0xBAF6,0x37FB,0xBABA,0x5F69,0xC40A,
0x50F6,0xBF05,0x32EC,0xB5CE,0x5F28,0xB528,0x3CD8,0xC914,
0x1ED8,0xB0E7,0x5A00,0xBF41,0x2DC9,0xDD28,0x0FC9,0xB023,
0x6EEC,0xE24B,0x19BA,0xF137,0x00BA,0xB055,0x73D3,0x004B,
0x00BA,0x0037,0xF1B5,0xBF64,0x4BBA,0x1E46,0xECC4,0x0F28,
0xDDB5,0xD85A,0x14BF,0x372D,0xCED8,0x2314,0xCEB5,0x0564,
0xF6D3,0x461E,0xC4EC,0x3705,0xBFB0,0x4678,0xDDF6,0x4B05,
0xBAFB,0x37F6,0xB5BA,0x5F5A,0xC919,0x46F1,0xC405,0x2DE2,
0xB0C9,0x5F2D,0xB52D,0x3CDD,0xC919,0x23CE,0xB0F1,0x5F05,
0xC437,0x28C9,0xDD28,0x0FC4,0xB01E,0x69E7,0xDD46,0x14BF,
0xEC37,0x00BA,0xB05A,0x6ECE,0x054B,0x00BF,0xFB32,0xF1B0,
0xC95F,0x2DBA,0x233C,0xE2C9,0x0F23,0xDDB0,0xE75A,0x05BF,
0x3732,0xCED8,0x2814,0xC4AB,0x236E,0xECD8,0x461E,0xBFEC,
0x370A,0xBFB0,0x5573,0xD3FB,0x4605,0xBFF6,0x37F6,0xB5BA,
0x5F4B,0xBF19,0x41EC,0xC405,0x28E2,0xB0DD,0x5A0F,0xBA32,
0x32D3,0xD81E,0x19CE,0xAB0A,0x64F1,0xD341,0x1EBF,0xE737,
0x0ABF,0xAB50,0x78D3,0xF64B,0x0ABA,0xF637,0xF6B5,0xBA5F,
0x50BA,0x0F4B,0xF6BF,0x052D,0xE2B0,0xCE5A,0x1EB5,0x3241,
0xD8CE,0x1923,0xD3B0,0x0564,0xF6C9,0x4128,0xC4E2,0x370F,
0xBFB0,0x4B78,0xDDF1,0x4B0F,0xBAF6,0x3CFB,0xB5BA,0x5F55,
0xBA14,0x4BF6,0xBF05,0x2DE2,0xB0D8,0x5F1E,0xB52D,0x3CD8,
0xC919,0x1ED3,0xABFB,0x5FFB,0xC43C,0x28C4,0xDD32,0x0FBF,
0xAB37,0x78E2,0xE246,0x0FB5,0xEC3C,0x00BA,0xB55F,0x64C4,
0x0A50,0xFBBA,0x0032,0xE7B0,0xCE5A,0x23B5,0x2841,0xDDCE,
0x1923,0xD3B0,0x0064,0xFBC4,0x3C28,0xC4DD,0x3214,0xC4AB,
0x3C78,0xDDE2,0x4B14,0xBAF1,0x3C00,0xBABA,0x6464,0xC90F,
0x50FB,0xBA00,0x32EC,0xB0CE,0x5A28,0xB528,0x41DD,0xC914,
0x23D8,0xB0F1,0x5A00,0xBA37,0x2DC9,0xDD2D,0x14C9,0xAB23,
0x6EE2,0xD346,0x19BA,0xEC3C,0x05BF,0xB55A,0x73D3,0x004B,
0x00BA,0xFB37,0xF1B5,0xC95F,0x37BA,0x1E41,0xE2C4,0x0F28,
0xD8AB,0xE75A,0x05BA,0x372D,0xC9D8,0x2814,0xC9B0,0x1E6E,
0xECD8,0x461E,0xBFEC,0x370A,0xBFB5,0x5573,0xD300,0x4B05,
0xBAFB,0x37F6,0xB5C9,0x5F3C,0xBA1E,0x41E7,0xBF05,0x28E2,
0xB0E2,0x5A0A,0xBA32,0x32CE,0xD823,0x19CE,0xAB14,0x6EF1,
0xD341,0x1EBF,0xE732,0x0ABF,0xB04B,0x73D8,0xF646,0x05BA,
0xF637,0xFBBA,0xBF5A,0x55C4,0x0F46,0xF1BF,0x0532,0xE7B0,
0xD355,0x19B5,0x2D3C,0xD8D3,0x1E1E,0xD3AB,0x0569,0xF6CE,
0x4123,0xBFE2,0x320F,0xC4B0,0x4678,0xDDF1,0x4B0A,0xBFF6,
0x37FB,0xBABA,0x5A50,0xBF14,0x46F1,0xC405,0x28E2,0xB0DD,
0x5A14,0xB52D,0x37D8,0xD31E,0x19D3,0xAB05,0x69F6,0xC93C,
0x23C4,0xE232,0x0AC4,0xB03C,0x73D8,0xE746,0x0FBF,0xF132,
0xFBBA,0xBA5A,0x5AC4,0x0A46,0xF6BF,0x0028,0xE7B0,0xD35A,
0x1EBA,0x2D3C,0xD8CE,0x191E,0xD3B0,0x005F,0xFBC4,0x3C28,
0xC4E2,0x2D0F,0xC9B0,0x3C73,0xE2EC,0x4B14,0xBFF1,0x3200,
0xBABA,0x5A5A,0xC90F,0x46FB,0xC400,0x2DEC,0xB5CE,0x5A28,
0xBA28,0x3CDD,0xCE14,0x1ED8,0xB0FB,0x5F00,0xC437,0x28C4,
0xDD2D,0x0FC9,0xAB32,0x78E2,0xE246,0x14BF,0xEC37,0x00BF,
0xB555,0x69CE,0x054B,0x00BA,0xFB2D,0xECB0,0xC45A,0x2DB5,
0x2341,0xE2C9,0x0F23,0xDDB0,0xE25A,0x05BA,0x3732,0xCED8,
0x2819,0xCEB0,0x0F64,0xF1D8,0x461E,0xBFEC,0x370A,0xC4B5,
0x5073,0xD800,0x4B05,0xBFFB,0x32F6,0xB5BF,0x5F4B,0xBF19,
0x46EC,0xC40A,0x28E2,0xB0DD,0x550F,0xBF32,0x32CE,0xD828,
0x1ECE,0xAB0F,0x64EC,0xD341,0x1EBF,0xE737,0x0AC4,0xB546,
0x6ED8,0xF646,0x05BF,0xFB37,0xF6B5,0xC455,0x3CBA,0x1941,
0xE7C4,0x0A23,0xDDB0,0xE75A,0x0ABF,0x3232,0xCED8,0x2319,
0xCEB0,0x1464,0xECD3,0x411E,0xBFE7,0x370A,0xC4B5,0x4B73,
0xD8FB,0x4B05,0xBAFB,0x37FB,0xBAC4,0x5A4B,0xBF19,0x46EC,
0xC40A,0x28E2,0xB0E2,0x5F14,0xBA32,0x37D3,0xD823,0x19D3,
0xB00F,0x69F1,0xD346,0x1EBF,0xE737,0x0AC4,0xB54B,0x6ED8,
0xFB4B,0x00BF,0xFB32,0xF6B5,0xC45A,0x46BF,0x1946,0xE7BF,
0x0A28,0xE2B5,0xD855,0x14BA,0x3232,0xCED3,0x231E,0xD3AB,
0x0A69,0xECC9,0x285F,0xE797,0x3737,0xE2A1,0xBF7F,0x1E92,
0x504B,0xC4AB,0x4132,0xBFB0,0xCE7F,0xBABF,0x6432,0xB0D3,
0x4119,0xB0BA,0xF17F,0x80F6,0x6914,0x9C00,0x4100,0xA6BF,
0x327F,0x8023,0x64EC,0x9C28,0x3CE2,0xABC4,0x7F2D,0x8846,
0x50CE,0xAB41,0x2DC9,0xB0C9,0x7FCE,0xBA5F,0x37B0,0xC941,
0x19AB,0xBAEC,0x7F80,0xEC64,0x149C,0xFB37,0x0A9C,0xBF2D,
0x7F80,0x1964,0xF197,0x2837,0xE7A6,0xC47F,0x4680,0x4155,
0xD3A6,0x3C3C,0xC4B0,0xC47F,0xF1AB,0x5A41,0xBABF,0x4123,
0xBAB0,0xDD7F,0x97DD,0x641E,0xA6EC,0x3C0F,0xA6BA,0x0A7F,
0x8005,0x64FB,0x9C19,0x37F1,0xA6C4,0x7D55,0x8032,0x5AD8,
0xA63C,0x32D3,0xB0D3,0x7F00,0xA655,0x41BF,0xBA41,0x2DBA,
0xB5D8,0x7FA6,0xD364,0x1EA6,0xDD3C,0x0FA6,0xBF0A,0x7F80,
0x0A5F,0xFB9C,0x1932,0xFB9C,0xBF6E,0x6480,0x325A,0xDDA1,
0x3732,0xD3AB,0xC97F,0x00A6,0x5541,0xBFBA,0x3C28,0xBAB0,
0xDD7F,0xB0D3,0x5F23,0xA6E7,0x3C14,0xA6BF,0x0A7F,0x8005,
0x6400,0x9C14,0x37F6,0xA1C4,0x7355,0x8032,0x55DD,0xA137,
0x32D8,0xA6CE,0x7F00,0xA655,0x41BA,0xBF41,0x23B5,0xB0E7,
0x7F97,0xE269,0x19A1,0xF632,0x0FA1,0xBF41,0x7F80,0x195F,
0xF19C,0x2337,0xE79C,0xC97F,0x2892,0x464B,0xC9B0,0x372D,
0xC9A6,0xD87F,0xBFC4,0x5F2D,0xB0D8,0x371E,0xA6BA,0x057F,
0x80FB,0x6405,0x9C05,0x3700,0x9CBF,0x6E64,0x8028,0x5AE2,
0xA132,0x32E2,0x9CCE,0x7F05,0xA150,0x41C4,0xBA37,0x32BA,
0xB0EC,0x7FAB,0xD364,0x1EAB,0xDD37,0x14A6,0xBF23,0x7F80,
0x055F,0xFBA1,0x1932,0xF69C,0xC47F,0x4688,0x3C50,0xD3A6,
0x3732,0xD3A6,0xD87F,0xDDB5,0x5537,0xBAC9,0x3723,0xB0BA,
0xF67F,0x8DE7,0x6414,0xA1FB,0x320F,0xA1BF,0x4B7D,0x8014,
0x5FEC,0x9C23,0x32E7,0xA1C9,0x7F23,0x9241,0x46C9,0xB037,
0x2DC9,0xA6E2,0x7FB5,0xC45F,0x28B0,0xDD32,0x1EB0,0xB505,
0x7F83,0xF664,0x0AA1,0x0037,0x05A1,0xBF5F,0x6E80,0x1E5A,
0xE7A1,0x2D37,0xE7A1,0xD37F,0x1E97,0x4646,0xC9B0,0x3C2D,
0xC4B0,0xE27F,0xBFC4,0x5A28,0xB0D8,0x3714,0xB0B5,0x057F,
0x80FB,0x5F0A,0xA10A,0x3200,0xA1C4,0x5F69,0x8028,0x55E2,
0xA12D,0x32DD,0xA1D3,0x7F05,0xA146,0x41C4,0xB537,0x28C4,
0xB0DD,0x7FB0,0xC95A,0x28B0,0xDD37,0x14AB,0xBF0A,0x7F80,
0xFB64,0x05A1,0x0F32,0xFBA6,0xC46E,0x5A83,0x2355,0xE2A1,
0x3232,0xDDA6,0xD37F,0xFBAB,0x463C,0xC9BF,0x3728,0xC4B5,
0xE27F,0xB0D8,0x5A23,0xB0E2,0x370F,0xABBF,0x197F,0x8000,
0x5F00,0xA10F,0x32FB,0xA6C4,0x6E55,0x8323,0x55DD,0xA12D,
0x32DD,0xA6CE,0x7FFB,0xAB46,0x41C4,0xBF37,0x1EC4,0xB5E7,
0x7FAB,0xD85A,0x23AB,0xE737,0x0FAB,0xBF0F,0x7F80,0x005F,
0x00A1,0x1432,0xF6A1,0xC47F,0x5088,0x2855,0xDDAB,0x322D,
0xD8AB,0xD37F,0xE7B5,0x4B3C,0xBFC9,0x371E,0xBABA,0xF67F,
0x97E2,0x5F19,0xA6F6,0x3205,0xABC4,0x417D,0x8014,0x5AF6,
0xA11E,0x2DEC,0xA6C9,0x7F2D,0x9732,0x4BD3,0xAB32,0x28D3,
0xABD8,0x7FD3,0xBF50,0x32B5,0xD332,0x19B5,0xBA0F,0x7F8D,
0xEC5A,0x0AA6,0x0028,0x05A6,0xBF69,0x6483,0x1955,0xECA6,
0x282D,0xE2A6,0xD37F,0xFBB0,0x3C41,0xC9BF,0x2D23,0xC9B0,
0xE77F,0xB5D3,0x5028,0xB0DD,0x370F,0xB0BA,0x2D7F,0x8D00,
0x5505,0xA605,0x32FB,0xA6C9,0x7F50,0x9228,0x50E2,0xAB28,
0x28D8,0xABD8,0x7FF1,0xB546,0x37C4,0xC932,0x19C4,0xB0F6,
0x7F9C,0xE750,0x19B0,0xEC2D,0x05B0,0xBF41,0x7F88,0x0F55,
0xF6A6,0x142D,0xECB0,0xC97F,0x2897,0x3246,0xD8B0,0x2D28,
0xCEAB,0xDD7F,0xC4C9,0x4628,0xBAD8,0x2D19,0xBAB5,0x1E7F,
0x8DFB,0x5005,0xAB00,0x2800,0xABC4,0x6E5F,0x921E,0x4BEC,
0xAB1E,0x32DD,0xABD3,0x7F0A,0xAB3C,0x3CCE,0xBA32,0x23C4,
0xB5F6,0x7FBA,0xD84B,0x23BA,0xDD32,0x14B5,0xC423,0x7F92,
0xFB50,0x0AAB,0x0032,0xF6AB,0xCE78,0x4B97,0x2841,0xE7B0,
0x2328,0xD8B0,0xD37F,0xFBB0,0x3C37,0xC9BF,0x3223,0xBFB5,
0xF67F,0xB0DD,0x4B1E,0xB5E2,0x320A,0xB0BF,0x417D,0x9205,
0x4BFB,0xAB0F,0x28F1,0xABCE,0x7F3C,0x9C28,0x41DD,0xB528,
0x28CE,0xB0E7,0x7FEC,0xBF41,0x32C9,0xC932,0x1EC4,0xBAFB,
0x7FB0,0xE24B,0x19B5,0xE732,0x0AB0,0xC932,0x7F92,0x0A4B,
0x00B0,0x0F2D,0xF1AB,0xD37D,0x419C,0x2841,0xE2B0,0x2828,
0xD3B0,0xEC7F,0xF6BA,0x3C2D,0xCEC9,0x2D1E,0xBFBA,0xF67F,
0xB5DD,0x4B19,0xB5CE,0x0A1E,0xDDBA,0xF65A,0x0FC9,0x2323,
0xD8D8,0x1914,0xD3BF,0x1E5A,0xF6DD,0x3214,0xCEEC,0x2300,
0xC9CE,0x4155,0xDDF6,0x3700,0xC9FB,0x23F1,0xBFDD,0x5032,
0xCE14,0x32EC,0xCE0A,0x1EDD,0xBF00,0x5A0A,0xCE28,0x23D8,
0xDD19,0x0FCE,0xC923,0x5AF1,0xE237,0x14C9,0xEC28,0x00C9,
0xCE41,0x55E2,0xF637,0x05C9,0xF628,0xF6C4,0xD850,0x41D3,
0x0A32,0xF1C9,0x0523,0xE7BF,0xF155,0x19C9,0x1E28,0xE2D8,
0x1414,0xD8C4,0x0F50,0xFBD8,0x2D19,0xCEE7,0x2305,0xC9CE,
0x3255,0xE7EC,0x370A,0xC9F6,0x28F6,0xC4D8,0x4B41,0xD805,
0x32F6,0xC900,0x23E7,0xC4EC,0x5023,0xCE19,0x2DE2,0xD814,
0x14D8,0xC905,0x4B00,0xD828,0x1ED8,0xE21E,0x0AD3,0xCE23,
0x50F1,0xE72D,0x0FCE,0xF123,0x00C9,0xD83C,0x4BE2,0xFB32,
0x00CE,0xFB23,0xF1C9,0xE246,0x37D8,0x0A2D,0xF1D3,0x0A1E,
0xE7C9,0xEC46,0x1ED3,0x1928,0xE7DD,0x1414,0xD8CE,0x0546,
0x05D8,0x2319,0xD3E7,0x1E0A,0xD3D3,0x234B,0xF6E7,0x2D0F,
0xD3F1,0x1E00,0xCEDD,0x3741,0xE2F6,0x2D00,0xD300,0x1EF6,
0xCEE7,0x3C2D,0xDD05,0x28F6,0xD805,0x19EC,0xD3F6,0x3C1E,
0xDD14,0x23E7,0xDD0F,0x0FE2,0xD805,0x3C05,0xE21E,0x19E2,
0xE714,0x0ADD,0xD814,0x37F6,0xE723,0x0AD8,0xF119,0x00D8,
0xE22D,0x37EC,0xF628,0x00D8,0x0019,0xF1D3,0xF137,0x28E2,
0x0A23,0xF1DD,0x0514,0xECD8,0xFB37,0x19E2,0x0F1E,0xE7E2,
0x0A0A,0xE2DD,0x0A37,0x05E7,0x190F,0xE2F1,0x0F00,0xE2E7,
0x192D,0xFBF1,0x1E05,0xE2FB,0x14FB,0xDDEC,0x2328,0xF1FB,
0x1E00,0xE200,0x0FF1,0xDDFB,0x2D19,0xE705,0x19F1,0xE70A,
0x0AE7,0xE20A,0x320A,0xEC0F,0x14EC,0xEC0A,0x05E7,0xE70F,
0x2800,0xF114,0x0FEC,0xF10A,0x00E2,0xEC19,0x23FB,0xF614,
0x05E7,0xFB0A,0xFBE7,0xFB1E,0x19F6,0x0014,0xFBEC,0x000A,
0xF6E7,0x001E,0x0AF1,0x050F,0xF6F1,0x0505,0xECEC,0x0F1E,
0x05F6,0x0A0A,0xF1F1,0x0500,0xECF1,0x1419,0x00FB,0x0A05,
0xF1FB,0x0A00,0xECFB,0x1914,0xFB00,0x0F00,0xF100,0x05F6,
0xEC00,0x190F,0xFB00,0x0AFB,0xF600,0x05F6,0xF105,0x1905,
0xFB0A,0x0AFB,0xFB05,0x00F1,0xF60F,0x1400,0xFB05,0x00F6,
0xFB00,0x00F6,0xFB0F,0x0F00,0x0005,0x00F6,0x0000,0xFBF6,
0x000F,0x05FB,0x0005,0xFBF6,0x0000,0xF6F6,0x050F,0x0500,
0x0500,0xFBFB,0x0000,0xF6FB,0x0A0F,0x00FB,0x0000,0xFBFB,
0x00FB,0xF600,0x0F0A,0x0000,0x0000,0xFB00,0x00FB,0xFB00,
0x0A05,0x0000,0x0000,0xFB00,0x00FB,0xFB05,0x0F05,0x0000,
0x0000,0xFB00,0x00FB,0x000A,0x0A00,0x0000,0x00FB,0x0000,
0x00FB,0x0005,0x0500,0x0000,0x00FB,0x0000,0x0000,0x0005,
0x0500,0x0000,0x00FB,0x0000,0xFB00,0x0505,0x0500,0x0000,
0x00FB,0x0000,0xFB00,0x0505,0x0500,0x0000,0x00FB,0x0000,
0x0000,0x0505,0x0000,0x0000,0xFB00,0x0000,0x0000,0x0505,
0x00FB,0x0000,0x0000,0x0000,0x0005,0x0500,0x00FB,0x0000,
0x0000,0x0000,0x0005,0x0500,0x00FB,0x0000,0x0000,0x0000,
0x0005,0x0500,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0xFB00,0x0000,
0x0000,0x0000,0x0000,0x0000,0xFB00,0x0000,0x0000,0x0000,
0x0000,0x0000,0xFB00,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
0x0000,0x0500,0x0000,0x0000,0x0000,0x0000,0x0000,0x0500,
0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x00FB,
0x0000,0x0000,0x0000
};
