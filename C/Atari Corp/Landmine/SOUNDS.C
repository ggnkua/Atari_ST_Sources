char pow[] = {
	0x08, 0x00, 0x0a, 0x00,
	0x06, 0x08,
	0x02, 0x00, 0x03, 0x04,		/* Channel B frq highish */
	0x07, ~0x2A, 0x09, 0x0E,	/* Tone enable, volume */
	0x80, 0x00,			/* Load temp register */
	0x81, 0x02, 0x20, 0xE0,		/* Loop */
	0x09, 0x00,			/* Volume off */
	0x08, 0x00, 0x0A, 0x00,
	0xFF, 0x00
};

char pow1[] = {
	0x08, 0x00, 0x0a, 0x00,
	0x06, 0x08,
	0x02, 0x00, 0x03, 0x05,		/* Channel B frq highish */
	0x07, ~0x2A, 0x09, 0x0E,	/* Tone enable, volume */
	0x80, 0x00,			/* Load temp register */
	0x81, 0x02, 0x20, 0xE0,		/* Loop */
	0x09, 0x00,			/* Volume off */
	0x08, 0x00, 0x0A, 0x00,
	0xFF, 0x00
};

char boom[] = {
	0x04, 0x00, 0x05, 0x04,		/* Starting frequency for explosion */
	0x07, ~0x2A, 0x0A, 0x00,	/* Channel C enable, starting volume */
	0x06, 0x0F,
	0x80, 0x00,			/* Load temp register */
	0x81, 0x0A, 0x04, 0x10,		/* Move volume up from zero */
	0x80, 0x10,			/* Load temp register vol top */
	0x81, 0x0A, 0xFF, 0x00,		/* Move volume down from 16 */
	0x0A, 0x00,
	0x08, 0x00, 0x09, 0x00,
	0xFF, 0x00
	};

char boom1[] = {
	0x04, 0xFF, 0x05, 0xFF,		/* Starting frequency for explosion */
	0x07, ~0x2A, 0x0A, 0x10,	/* Channel C enable, starting volume */
	0x06, 0x1F,			/* We want a low expl */
	0x0D, 0x0D,			/* Shape as /-- */
	0x0B, 0x04,			/* Sustain of 0x04 */
	0x0C, 0x00,
	0x82, 0x04, 			/* Wait for 4/50 */
	0x0D, 0x09,			/* Change shape */
	0x0B, 0x10, 0x0C, 0x27,		/* Sustain for 10000 */
	0x82, 0x1E,			/* Hold for 30/50 */
	0x0A, 0x00,			/* Volume off */
	0x08, 0x00, 0x09, 0x00,
	0xFF, 0x00
	};

char bonus[] = {
	0x08, 0x00, 0x09, 0x00,
	0x04, 0xF0, 0x05, 0x0C,		/* Starting frequency for bonus */
	0x07, ~0x04, 0x0A, 0x10,	/* Channel C enable, waveform */
	0x0B, 0x00, 0x0C, 0x02,		/* Medium period */
	0x0D, 0x0D,			/* Shape as /| */
	0x80, 0x2F,
	0x81, 0x05, 0xFF, 0x00,
	0x0D, 0x00,			/* Change shape to \_ */
	0x0B, 0x10, 0x0C, 0x00,		/* Long Period */
	0x82, 0x90,			/* Hold for 100/50 */
	0x0A, 0x00,			/* Volume off */
	0x08, 0x00, 0x09, 0x00,
	0xFF, 0x00
};



