#define SUNCLOCK 0  	/* TREE */
#define FORWARD 2  	/* OBJECT in TREE #0 */
#define BACKWARD 4  	/* OBJECT in TREE #0 */
#define HOUR 7  	/* OBJECT in TREE #0 */
#define DAY 9  	/* OBJECT in TREE #0 */
#define WEEK 11  	/* OBJECT in TREE #0 */
#define MONTH 13  	/* OBJECT in TREE #0 */
#define YEAR 15  	/* OBJECT in TREE #0 */
#define ANIMATE 18  	/* OBJECT in TREE #0 */
#define REALTIME 20  	/* OBJECT in TREE #0 */
#define BUFFER 25  	/* OBJECT in TREE #0 */
