#ifndef scr2_first
#define scr2_first

/*----- prototyping -----*/
void Scr2Init( void );
void Scr2Exit( void );
void Scr2Swap( void );
void Scr2Copy( void );

#endif
