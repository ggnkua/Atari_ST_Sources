/* resource set indicies for XACCTEST */

#define MENU     0	/* menu tree */
#define MINFO    7	/* STRING in tree MENU */
#define MS_KEY   16	/* STRING in tree MENU */
#define MS_TEXT  17	/* STRING in tree MENU */
#define MS_META  18	/* STRING in tree MENU */
#define MS_IMG   19	/* STRING in tree MENU */
#define MQUIT    21	/* STRING in tree MENU */

#define DIALOG   1	/* form/dialog */
#define DO_INFO  1	/* BUTTON in tree DIALOG */
#define DO_KEY   2	/* BUTTON in tree DIALOG */
#define DO_TEXT  3	/* BUTTON in tree DIALOG */
#define DO_META  4	/* BUTTON in tree DIALOG */
#define DO_IMG   5	/* BUTTON in tree DIALOG */
#define DO_OK    6	/* BUTTON in tree DIALOG */

#define SENDKEY  2	/* form/dialog */

#define SENDTEXT 3	/* form/dialog */
#define STXT_TXT 1	/* FTEXT in tree SENDTEXT */
#define STXT_OK  2	/* BUTTON in tree SENDTEXT */

#define XACCLIST 4	/* form/dialog */
#define XL_TITLE 1	/* STRING in tree XACCLIST */
#define XL_TITUN 2	/* BOX in tree XACCLIST */
#define XL_IBOX  4	/* IBOX in tree XACCLIST */
#define XL_ENTRY 5	/* TEXT in tree XACCLIST */
#define XL_OK    13	/* BUTTON in tree XACCLIST */
