#define EXIT 1
#define TREE00 0
#define DATAF 27
#define INCF 29
#define DECF 28
#define TREE01 1
#define PIC 5
#define YLO 22
#define XLO 20
#define XHI 21
#define YHI 24
#define NUMBER 18
#define READY 4
#define RECALC 9
#define DATA 12
#define ADD 26
#define INC 13
#define DEC 11
#define PRINT 34
#define BUFFER 35
#define LARGE 2
