#ifndef _UTILITY

# define _UTILITY

void Swap( int *a, int *b );

char *DeleteSpace( char *str );

#endif
