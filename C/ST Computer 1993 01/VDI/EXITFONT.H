#ifndef _EXITFONT

# define _EXITFONT

# include "initfont.h"

void ExitFonts( int v_handle, FONTSTRCT *f );

#endif
