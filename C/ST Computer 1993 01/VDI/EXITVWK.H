#ifndef _EXITVWK

# define _EXITVWK

void ExitVWork( int v_handle );

#endif
