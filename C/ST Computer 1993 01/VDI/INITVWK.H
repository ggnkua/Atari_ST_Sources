#ifndef _INITVWK

# define _INITVWK

int InitVWork( int *v_handle,
               int *pixel_width,
               int *pixel_height,
               int *scr_width,
               int *scr_height,
               int *ch_width,
               int *ch_height,
               int *planes );

#endif
