* KARATEKA.S - bit image for NEWMOUSE from C.O.L.R. Object Editor
* Copyright 1986 ANTIC Publishing

.globl _bitimage
_bitimage:      * 2 by 42 words
        DC.L    $01FC0000,$00000000,$00000000,$00000000
        DC.L    $03FE0000,$00000000,$00000000,$00000000
        DC.L    $03C0003E,$00000000,$00000000,$00000000
        DC.L    $038A0074,$0000000A,$00000000,$00000000
        DC.L    $0380007E,$00000000,$00000000,$00000000
        DC.L    $030000FE,$00000000,$00000000,$00000000
        DC.L    $010000FE,$00000000,$00000000,$00000000
        DC.L    $000000FC,$00000000,$00000000,$00000000
        DC.L    $000000F8,$00000000,$00000000,$00000000
        DC.L    $60000038,$00005FC7,$20000000,$0000E000
        DC.L    $80000008,$0000FFF7,$00000000,$0000F000
        DC.L    $8000000E,$00007FF1,$00000000,$0000F800
        DC.L    $0040001E,$0000FFA1,$0000000C,$0000FC00
        DC.L    $0980001E,$0000F661,$0000001E,$0000FFE0
        DC.L    $06000018,$0000F9E7,$8000001E,$00007FE0
        DC.L    $00100000,$0000FFEF,$40000000,$0000BFE0
        DC.L    $00200000,$0000FFDF,$00000000,$00009FE0
        DC.L    $00C00000,$00007F3F,$10000000,$0000F000
        DC.L    $0F000000,$000008FF,$38100000,$0000FFF0
        DC.L    $02000000,$000003FF,$70000000,$0000FFF8
        DC.L    $00810000,$000000FF,$FC000000,$0000FFF8
        DC.L    $007F0000,$0000007F,$EC000000,$0000FFF8
        DC.L    $007E0000,$0000007F,$40800000,$0000FF78
        DC.L    $00000000,$0000007F,$C0000000,$0000E0F8
        DC.L    $00000000,$0000007F,$C0080000,$0000E0F0
        DC.L    $00400000,$0000003F,$00000180,$0000E070
        DC.L    $00400000,$0000007F,$200000F0,$0000C000
        DC.L    $00000000,$0000003F,$20000078,$0000C000
        DC.L    $00200000,$0000001F,$20000000,$0000E000
        DC.L    $00200000,$0000003F,$20000000,$0000E000
        DC.L    $00000000,$0000001F,$20000000,$0000E000
        DC.L    $00000000,$0000001F,$20000000,$0000E000
        DC.L    $00100000,$0000000F,$20000000,$0000C000
        DC.L    $00100000,$0000001F,$20000000,$0000C000
        DC.L    $00000000,$0000000F,$00000000,$0000E000
        DC.L    $00000000,$0000000F,$00000000,$0000E000
        DC.L    $00080000,$00000007,$00000000,$0000E000
        DC.L    $00080000,$0000000F,$00000000,$0000E000
        DC.L    $00000000,$00000007,$00000000,$0000E000
        DC.L    $00000007,$00000000,$00008000,$00000000
        DC.L    $00000007,$00000000,$0000C000,$00000000
        DC.L    $00000001,$00000000,$0000F000,$00000000

