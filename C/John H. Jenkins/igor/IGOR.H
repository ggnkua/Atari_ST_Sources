/* resource set indicies for HELPER */

#define SEARCHD  0	/* form/dialog */
#define SEARCHS  2	/* FBOXTEXT in tree SEARCHD */
#define FIRSTB   3	/* BUTTON in tree SEARCHD */
#define NEXTB    4	/* BUTTON in tree SEARCHD */
#define CANCELB  5	/* BUTTON in tree SEARCHD */
#define YESB     7	/* BUTTON in tree SEARCHD */
#define NOB      8	/* BUTTON in tree SEARCHD */
#define FINALB   9	/* BUTTON in tree SEARCHD */
#define PREVB    10	/* BUTTON in tree SEARCHD */

