/* resource set indicies for GEMTRRSC */

#define MENMENU  0	/* menu tree */
#define MENDESK  3	/* TITLE in tree MENMENU */
#define MENFILE  4	/* TITLE in tree MENMENU */
#define MENINFO  7	/* STRING in tree MENMENU */
#define MENGO    16	/* STRING in tree MENMENU */
#define MENLOOK  17	/* STRING in tree MENMENU */
#define MENSCORE 18	/* STRING in tree MENMENU */
#define MENQUICK 20	/* STRING in tree MENMENU */
#define MENQUIT  22	/* STRING in tree MENMENU */

#define INFOF    1	/* form/dialog */
#define INFOVERS 5	/* STRING in tree INFOF */
#define FQUICK   10	/* BOX in tree INFOF */

#define BESTF    2	/* form/dialog */
#define BSLOW    2	/* TEXT in tree BESTF */
#define BQUICK   3	/* TEXT in tree BESTF */
#define B1       5	/* FTEXT in tree BESTF */
#define B2       6	/* FTEXT in tree BESTF */
#define B3       7	/* FTEXT in tree BESTF */
#define B4       8	/* FTEXT in tree BESTF */
#define B5       9	/* FTEXT in tree BESTF */
#define B6       10	/* FTEXT in tree BESTF */
#define B7       11	/* FTEXT in tree BESTF */
#define B8       12	/* FTEXT in tree BESTF */
#define B9       13	/* FTEXT in tree BESTF */
#define B10      14	/* FTEXT in tree BESTF */
#define S1       16	/* FTEXT in tree BESTF */
#define S2       17	/* FTEXT in tree BESTF */
#define S4       19	/* FTEXT in tree BESTF */
#define S5       20	/* FTEXT in tree BESTF */
#define S6       21	/* FTEXT in tree BESTF */
#define S7       22	/* FTEXT in tree BESTF */
#define S8       23	/* FTEXT in tree BESTF */
#define S9       24	/* FTEXT in tree BESTF */
#define S10      25	/* FTEXT in tree BESTF */
#define BNAME    26	/* FTEXT in tree BESTF */

#define WINDERR  0	/* Alert string index */

#define PAUSE    1	/* Alert string index */

#define QUIT     2	/* Alert string index */
