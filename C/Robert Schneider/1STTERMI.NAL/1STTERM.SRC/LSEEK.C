lseek()
{
}

