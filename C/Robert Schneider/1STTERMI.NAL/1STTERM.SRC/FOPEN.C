fopen()
{
}

freopen()
{
}

