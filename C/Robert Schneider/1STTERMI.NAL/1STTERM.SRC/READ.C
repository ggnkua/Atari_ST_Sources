getkey()
{
}

read()
{
}

