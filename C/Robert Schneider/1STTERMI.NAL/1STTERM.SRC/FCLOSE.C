fclose()
{
}

fflush()
{
}

