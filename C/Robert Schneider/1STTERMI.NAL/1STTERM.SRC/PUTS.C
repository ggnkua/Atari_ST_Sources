puts()
{
}

fputs()
{
}

