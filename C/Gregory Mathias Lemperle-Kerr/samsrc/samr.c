#ifndef OBJECT
#include <aes.h>
#endif

static char p_to_nul[1] = "";

TEDINFO rs_tedinfo[] = {
  {"Spieu's Analyzer of Media", p_to_nul, p_to_nul,
     3,   0,   2, 4481,   0,   0,  26,   1},
  {"Version 1.1", p_to_nul, p_to_nul,
     3,   0,   2, 4481,   0,   0,  12,   1},
  {"Gregory Mathias Lemperle-Kerr", p_to_nul, p_to_nul,
     3,   0,   2, 4353,   0,   0,  30,   1},
  {"1990 Spieu!Soft", p_to_nul, p_to_nul,
     3,   0,   2, 4481,   0,   0,  16,   1},
  {"Compiled", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,   9,   1},
  {"with", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,   5,   1},
  {" Fat sectors:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  14,   1},
  {"0000001", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {" Bytes/Entry:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  14,   1},
  {"0000002", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {" Bad clusters:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  15,   1},
  {"0000003", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {" Tot clusters:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  15,   1},
  {"0000004", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {" Main dir len:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  15,   1},
  {"0000005", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {" Bytes/Clust.:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  15,   1},
  {"0000006", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {" Sectrs/Track:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  15,   1},
  {"0000007", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {" Heads/Tracks:", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  15,   1},
  {"008/009", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   8,   1},
  {"0000010", p_to_nul, p_to_nul,
     3,   0,   2, 4481,   0,   1,   8,   1},
  {"0000011 > S F B U S F B U S F B U S F B U S F B U S F B U S F B U", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  66,   1},
  {"0000012 > S F B U S F B U S F B U S F B U S F B U S F B U S F B U", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  66,   1},
  {"0000013 > S F B U S F B U S F B U S F B U S F B U S F B U S F B U", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  66,   1},
  {"0000014 > S F B U S F B U S F B U S F B U S F B U S F B U S F B U", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  66,   1},
  {"0000015 > S F B U S F B U S F B U S F B U S F B U S F B U S F B U", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  66,   1},
  {"0000016 > S F B U S F B U S F B U S F B U S F B U S F B U S F B U", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   1,  66,   1},
  {" Cluster:", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   1,  10,   1},
  {" Status :", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   1,  10,   1},
  {" Bad Cls:", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   1,  10,   1},
  {" Total:", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   1,   8,   1},
  {" Test :       ", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   1,  15,   1},
  {" Sens.:", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   1,   8,   1},
  {"U.S.A.", p_to_nul, p_to_nul,
     3,   0,   0, 4353,   0,   0,   7,   1},
  {"(309) 764-1250", p_to_nul, p_to_nul,
     5,   0,   0, 4353,   0,   0,  15,   1},
  {"(217) 359-7483", p_to_nul, p_to_nul,
     5,   0,   0, 4353,   0,   0,  15,   1},
  {"2516 31st Ave. Ct.", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  19,   1},
  {"Moline, IL 61265", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  17,   1},
  {"Europe", p_to_nul, p_to_nul,
     3,   0,   0, 4353,   0,   0,   7,   1},
  {"041-61-475146", p_to_nul, p_to_nul,
     5,   0,   0, 4353,   0,   0,  14,   1},
  {"Pfaffenrainstr. 46", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  19,   1},
  {"CH-4103 Bottmingen", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  19,   1},
  {"Switzerland", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  12,   1},
  {"Please send the equivalent", p_to_nul, p_to_nul,
     3,   0,   2, 4481,   0,   1,  27,   1},
  {"of ca. $10 to one of these:", p_to_nul, p_to_nul,
     3,   0,   2, 4481,   0,   1,  28,   1},
  {" #   .START.   .SIZE.   TYP", p_to_nul, p_to_nul,
     3,   0,   2, 7105,   0,   0,  28,   1}
};

int imsk000[] = {
  0xffff,0xfffe,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
  0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
  0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
  0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
  0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
  0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
  0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff
};

int idat000[] = {
   0x0000,0x0004,0x0000,0x0004,0xffff,0xc01f,0x13ff,0xf804,
   0x10ff,0xff04,0x101f,0xffe0,0x1003,0xfffc,0x1004,0x7fff,
   0x1004,0x0fff,0x1577,0xb9ff,0x1544,0xa83f,0x1544,0xa807,
   0x1747,0xb800,0x0000,0x0000,0x0000,0x0000,0x07f0,0x0000,
   0x0c00,0x0000,0x0800,0x0000,0x0878,0xf000,0x0808,0x9000,
   0x0878,0x9000,0x0840,0x9000,0x087a,0xf000,0x0800,0x0000,
   0x0c00,0x0000,0x07f0,0x0000,0x0000,0x0000,0x0000,0x0000
};

ICONBLK rs_iconblk[] = {
  {imsk000, idat000, p_to_nul, 
   0x1000, 0x0006, 0x000d, 0x0010, 0x0000, 0x0020,
   0x001c, 0x0014, 0x001c, 0x0000, 0x0006}
};

int bblock000[] = {
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0003,
  0xe000,0x0000,0x0000,0x0000,0x0000,0x0000,0x007e,0x3e00,
  0x0000,0x000c,0x0007,0xc000,0x0000,0x00c0,0x0380,0x0000,
  0x0038,0x0018,0x20e0,0x0000,0x0080,0x00fc,0x0000,0x03e0,
  0x0010,0x2723,0xe000,0x0180,0x0007,0xff00,0x7c00,0x0018,
  0x3c26,0x2000,0x0100,0x0000,0x01ff,0xc000,0x000c,0x3038,
  0x2000,0x0100,0x0000,0x0000,0x0000,0x0000,0x6030,0x6000,
  0x0100,0x0000,0x0000,0x0000,0x0000,0xc060,0x4000,0x0180,
  0x0000,0x0000,0x0000,0x0000,0xc0c0,0xc000,0x0080,0x0000,
  0x0000,0x0000,0x0001,0x8081,0x8000,0x00e0,0x3ce0,0xe000,
  0xec41,0x0003,0x0181,0x0000,0x003e,0x64a1,0xf079,0xb841,
  0x0007,0x0183,0x0000,0x0004,0x44e3,0x90cf,0x30c3,0x000e,
  0x0306,0x0000,0x0004,0xccc7,0x1184,0x21e3,0x000c,0x0604,
  0x0000,0x000f,0x88c7,0x37cc,0x3f3e,0x0018,0x041b,0x0000,
  0x0008,0x077f,0xf478,0x0002,0x0000,0x0016,0x2000,0x0008,
  0x0000,0x1800,0x0002,0x0000,0x001c,0x0000,0x0018,0x0000,
  0x3800,0x0002,0x0000,0x0000,0x0000,0x0010,0x0000,0x6800,
  0x0001,0x0000,0x0000,0x0000,0x0030,0x01ff,0xffe0,0x0000,
  0x8000,0x0000,0x0000,0x0060,0x0f00,0x481f,0xffe0,0x4000,
  0x0000,0x0000,0x0043,0xf800,0x4800,0x003e,0x6000,0x0000,
  0x0000,0x009e,0x0000,0x7800,0x0003,0xb000,0x0000,0x0000,
  0x00b0,0x0000,0x0000,0x0000,0xf000,0x0000,0x0000,0x01e0,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x01c0,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0180,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
  0x0001,0xfc00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0003,
  0x0600,0x0f00,0x000c,0x0000,0x0000,0x0000,0x0002,0x0200,
  0x39c0,0x001c,0x0000,0x0000,0x0002,0x0002,0x0200,0x6060,
  0x0014,0x0000,0x0000,0x0002,0x0001,0x0200,0xc020,0x0014,
  0x0000,0x0000,0x0006,0x0001,0xfa01,0x8030,0x039c,0x0000,
  0x0000,0x0006,0x0000,0x0403,0x0010,0x00f8,0x0000,0x0000,
  0x0006,0x0000,0x0406,0x0010,0x0008,0x0000,0x0000,0x0006,
  0x0000,0x040c,0x0018,0x0008,0x0000,0x0000,0x0006,0x0000,
  0x0c18,0x0008,0x0008,0x0000,0x0000,0x000e,0x0000,0x0830,
  0x0008,0x0008,0x0000,0x0000,0x000a,0x0000,0x0860,0x0008,
  0x0008,0x0000,0x0000,0x000a,0x003c,0x18c0,0x0008,0x0008,
  0x0000,0x0000,0x001a,0x0000,0x3180,0x0008,0x0008,0x0000,
  0x0000,0x0012,0x0000,0x2300,0x0008,0x0010,0x0000,0x0000,
  0x0012,0x0000,0x3e00,0x0008,0x0010,0x0000,0x0001,0xc01a,
  0x0e00,0x61e0,0x0008,0x0010,0xe0b9,0xc3f2,0x478e,0x0a00,
  0x6123,0xcf08,0x0390,0xb0ea,0x430a,0x4486,0x1600,0xb122,
  0x4908,0x0ef1,0x114e,0x430b,0xc487,0x1c01,0x11e2,0x4908,
  0x0861,0x3344,0x4709,0x8499,0x9803,0x10c6,0x4908,0x0830,
  0xa24c,0x5ddb,0x8cf0,0xf102,0x1b6c,0x5988,0x0cde,0xfe00,
  0x71fe,0x78c0,0x1f02,0x0e38,0x7078,0x0783,0xf000,0x0100,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0100,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0100,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0100,0x0000,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0100,0x0000,0x0000,0x0000,0x0000
};

BITBLK rs_bitblk[] = {
  {bblock000,  0x000e, 0x0038, 0x0000, 0x0000, 0x0001}
};

OBJECT rs_object[] = {
  /* Tree #0*/
  {  -1,   1,   5,0x0019,0x0000,0x0000, 0x00000000L,   0,   0,  90,  25},
  {   5,   2,   2,0x0014,0x0000,0x0000, 0x00001100L,   0,   0,  90, 513},
  {   1,   3,   4,0x0019,0x0000,0x0000, 0x00000000L,   2,   0,  13, 769},
  {   4,  -1,  -1,0x0020,0x0000,0x0000, (long)" Desk ",   0,   0,   6, 769},
  {   2,  -1,  -1,0x0020,0x0000,0x0000, (long)" Media ",   6,   0,   7, 769},
  {   0,   6,  15,0x0019,0x0000,0x0000, 0x00000000L,   0, 769,  40,  19},
  {  15,   7,  14,0x0014,0x0000,0x0000, 0x00ff1100L,   2,   0,  20,   8},
  {   8,  -1,  -1,0x001c,0x0000,0x0000, (long)"  SAM V1.1  ",   0,   0,  20,   1},
  {   9,  -1,  -1,0x001c,0x0000,0x0008, (long)"--------------------",   0,   1,  20,   1},
  {  10,  -1,  -1,0x001c,0x0000,0x0000, (long)"1",   0,   2,  20,   1},
  {  11,  -1,  -1,0x001c,0x0000,0x0000, (long)"2",   0,   3,  20,   1},
  {  12,  -1,  -1,0x001c,0x0000,0x0000, (long)"3",   0,   4,  20,   1},
  {  13,  -1,  -1,0x001c,0x0000,0x0000, (long)"4",   0,   5,  20,   1},
  {  14,  -1,  -1,0x001c,0x0000,0x0000, (long)"5",   0,   6,  20,   1},
  {   6,  -1,  -1,0x001c,0x0000,0x0000, (long)"6",   0,   7,  20,   1},
  {   5,  16,  23,0x0014,0x0000,0x0000, 0x00ff1100L,   8,   0,  24,   8},
  {  17,  -1,  -1,0x001c,0x0000,0x0000, (long)"  Q  Quit               ",   0,   6,  24,   1},
  {  18,  -1,  -1,0x001c,0x0000,0x0008, (long)"------------------------",   0,   0,  24,   1},
  {  19,  -1,  -1,0x001c,0x0000,0x0008, (long)"------------------------",   0,   3,  24,   1},
  {  20,  -1,  -1,0x001c,0x0000,0x0000, (long)"  M  Disk Map      ",   0,   1,  24,   1},
  {  21,  -1,  -1,0x001c,0x0000,0x0000, (long)"  A  Analyze Media   ",   0,   2,  24,   1},
  {  22,  -1,  -1,0x001c,0x0000,0x0008, (long)"------------------------",   0,   7,  24,   1},
  {  23,  -1,  -1,0x001c,0x0000,0x0008, (long)"------------------------",   0,   5,  24,   1},
  {  15,  -1,  -1,0x001c,0x0020,0x0000, (long)"  R  Repartition ",   0,   4,  24,   1},
  /* Tree #1*/
  {  -1,   1,   6,0x0014,0x0000,0x0000, 0x000711ebL, 772, 513,  37,2063},
  {   4,   2,   3,0x0014,0x0000,0x0000, 0x00031181L,   2,   1,1056,2051},
  {   3,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[0],   0,   0,1056,   2},
  {   1,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[1],  11,   2,  11,   1},
  {   6,   5,  11,0x0014,0x0007,0x0020, 0x00021181L,   2,2057,1056,2052},
  {   9,  -1,  -1,0x0017,0x0005,0x0020, (long)&rs_bitblk[0],  17,2048,1038,2051},
  {   0,   7,   8,0x0014,0x0000,0x0000, 0x0001118bL,   2,   5,1056,   4},
  {   8,  -1,  -1,0x0015,0x0000,0x0001, (long)&rs_tedinfo[2],   0,   0,1056,   2},
  {   6,  -1,  -1,0x0015,0x0000,0x0001, (long)&rs_tedinfo[3],   0,   2,1056,   2},
  {  10,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[4],   4,2048,1030,2048},
  {  11,  -1,  -1,0x001f,0x0005,0x0000, (long)&rs_iconblk[0],   3,   2,8195,8192},
  {   4,  -1,  -1,0x0015,0x0020,0x0000, (long)&rs_tedinfo[5],1029,   1,   4,2048},
  /* Tree #2*/
  {  -1,   1,   1,0x0014,0x0000,0x0000, 0x000211f1L, 770, 513,  68,  16},
  {   0,   2,   2,0x0014,0x0000,0x0000, 0x000111e1L,   1,2048,  66,  15},
  {   1,   3,   3,0x0014,0x0000,0x0000, 0x000111d1L,   1,2048,1087,  14},
  {   2,   4,   4,0x0014,0x0000,0x0000, 0x000111c1L,   1,2048,1085,  13},
  {   3,   5,  33,0x0014,0x0000,0x0000, 0x000111b1L,   1,2048,1083,  12},
  {   7,   6,   6,0x0016,0x0000,0x0000, (long)&rs_tedinfo[6],   1,2050,1042,   1},
  {   5,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[7],  11,   0,   7,   1},
  {  11,   8,  34,0x0014,0x0000,0x0000, 0x00011191L,  42,2048,1040,   4},
  {   9,  -1,  -1,0x001a,0x0005,0x0000, (long)"DONE",1025,2048,1037,   1},
  {  10,  -1,  -1,0x001b,0x0040,0x0000, 0x04011181L,1025,   2,   3,2049},
  {  34,  -1,  -1,0x001b,0x0040,0x0000, 0x03011181L,  12,   2,   3,2049},
  {  13,  12,  12,0x0016,0x0000,0x0000, (long)&rs_tedinfo[8],   1,2051,1042,   1},
  {  11,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[9],  11,   0,   7,   1},
  {  15,  14,  14,0x0016,0x0000,0x0000, (long)&rs_tedinfo[10],   1,2049,1042,   1},
  {  13,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[11],  11,   0,   7,   1},
  {  17,  16,  16,0x0016,0x0000,0x0000, (long)&rs_tedinfo[12],   1,2048,1042,   1},
  {  15,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[13],1035,   0,   6,   1},
  {  19,  18,  18,0x0016,0x0000,0x0000, (long)&rs_tedinfo[14],1045,2048,1042,   1},
  {  17,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[15],1035,   0,   6,   1},
  {  21,  20,  20,0x0016,0x0000,0x0000, (long)&rs_tedinfo[16],1045,2049,1042,   1},
  {  19,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[17],1035,   0,   6,   1},
  {  23,  22,  22,0x0016,0x0000,0x0000, (long)&rs_tedinfo[18],1045,2050,1042,   1},
  {  21,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[19],1035,   0,   6,   1},
  {  25,  24,  24,0x0016,0x0000,0x0000, (long)&rs_tedinfo[20],1045,2051,1042,   1},
  {  23,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[21],1035,   0,   6,   1},
  {  26,  -1,  -1,0x001a,0x0040,0x0000, (long)"",1075,2053,   7,   1},
  {  27,  -1,  -1,0x001a,0x0040,0x0000, (long)"",1075,2058,   7,   1},
  {  28,  -1,  -1,0x0016,0x0000,0x0000, (long)&rs_tedinfo[22],  51,   7,   8,   3},
  {  29,  -1,  -1,0x0016,0x0000,0x0000, (long)&rs_tedinfo[23],   1,2053,1073,   1},
  {  30,  -1,  -1,0x0016,0x0000,0x0000, (long)&rs_tedinfo[24],   1,2054,1073,   1},
  {  31,  -1,  -1,0x0016,0x0000,0x0000, (long)&rs_tedinfo[25],   1,2055,1073,   1},
  {  32,  -1,  -1,0x0016,0x0000,0x0000, (long)&rs_tedinfo[26],   1,2056,1073,   1},
  {  33,  -1,  -1,0x0016,0x0000,0x0000, (long)&rs_tedinfo[27],   1,2057,1073,   1},
  {   4,  -1,  -1,0x0016,0x0000,0x0000, (long)&rs_tedinfo[28],   1,2058,1073,   1},
  {   7,  -1,  -1,0x001b,0x0063,0x0020, 0x43011181L,   6,   2,1028,2049},
  /* Tree #3*/
  {  -1,   1,  20,0x0014,0x0000,0x0000, 0x000a1181L,1797,2561,  48,  13},
  {   9,   2,   7,0x0014,0x0000,0x0000, 0x000111c1L,   2,   1,  24,   8},
  {   5,   3,   4,0x0016,0x0000,0x0000, (long)&rs_tedinfo[29],   1,2048,  22,   2},
  {   4,  -1,  -1,0x001c,0x0000,0x0000, (long)"0000017",  10,2048,   7,   1},
  {   2,  -1,  -1,0x001c,0x0000,0x0000, (long)"R",  19,2048,   1,   1},
  {   7,   6,   6,0x0016,0x0000,0x0000, (long)&rs_tedinfo[30],   1,   3,  22,   2},
  {   5,  -1,  -1,0x001c,0x0000,0x0000, (long)"No error...",  10,2048,  11,   1},
  {   1,   8,   8,0x0016,0x0000,0x0000, (long)&rs_tedinfo[31],   1,2053,  22,   2},
  {   7,  -1,  -1,0x001c,0x0000,0x0000, (long)"0000019",  10,2048,   7,   1},
  {  20,  10,  16,0x0014,0x0000,0x0000, 0x000111e1L,  28,   1,  18,   8},
  {  12,  11,  11,0x0016,0x0000,0x0000, (long)&rs_tedinfo[32],   1,2048,  16,   2},
  {  10,  -1,  -1,0x001c,0x0000,0x0000, (long)"0000018",   8,2048,   7,   1},
  {  16,  13,  15,0x0016,0x0000,0x0000, (long)&rs_tedinfo[33],   1,   3,  16,   2},
  {  14,  -1,  -1,0x001b,0x0040,0x0000, 0x02011181L,   8,   0,   2,   2},
  {  15,  -1,  -1,0x001b,0x0040,0x0000, 0x01011181L,  14,   0,   2,   2},
  {  12,  -1,  -1,0x001c,0x0000,0x0000, (long)"PAS",1034,2048,   3,   1},
  {   9,  17,  19,0x0016,0x0000,0x0000, (long)&rs_tedinfo[34],   1,2053,  16,   2},
  {  18,  -1,  -1,0x001c,0x0000,0x0000, (long)"16",  11,2048,   2,   1},
  {  19,  -1,  -1,0x001b,0x0040,0x0000, 0x02011181L,   8,   0,   2,   2},
  {  16,  -1,  -1,0x001b,0x0040,0x0000, 0x01011181L,  14,   0,   2,   2},
  {   0,  21,  26,0x0014,0x0000,0x0000, 0x000111a1L,   2,2057,  44,2050},
  {  22,  -1,  -1,0x001a,0x0007,0x0020, (long)"ANALYZE",1025,2048,   9,   1},
  {  23,  -1,  -1,0x001a,0x0005,0x0000, (long)"CANCEL",1038,2048,1032,2049},
  {  24,  -1,  -1,0x001b,0x0040,0x0000, 0x04011181L,  34,2048,   3,2049},
  {  25,  -1,  -1,0x001b,0x0000,0x0000, 0x43011181L,  37,2048,   3,2049},
  {  26,  -1,  -1,0x001b,0x0040,0x0000, 0x03011181L,  40,2048,   3,2049},
  {  20,  -1,  -1,0x001a,0x0025,0x0000, (long)"CLEAR",1049,2048,   7,2049},
  /* Tree #4*/
  {  -1,   1,  22,0x0014,0x0000,0x0000, 0x000211f1L,1796,2561,1064,2061},
  {  14,   2,   8,0x0014,0x0047,0x0000, 0x000111e5L,   1,   9,1062,   4},
  {   8,   3,   7,0x0014,0x0005,0x0000, 0x00011181L,   1,2048,1041,   3},
  {   4,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[35],1024,   0,   6,   1},
  {   5,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[36],   7,   0,1034,2048},
  {   6,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[37],   7,2048,1034,2048},
  {   7,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[38],1024,2049,  14,2048},
  {   2,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[39],1024,   2,  12,2048},
  {   1,   9,  13,0x0014,0x0005,0x0000, 0x00011181L,  20,2048,1041,   3},
  {  10,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[40],1024,   0,   6,   1},
  {  11,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[41],1031,2048,  10,2048},
  {  12,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[42],1024,2049,1038,2048},
  {  13,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[43],1024,   2,  14,2048},
  {   8,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[44],1024,2050,  11,2048},
  {  21,  15,  15,0x0014,0x0000,0x0000, 0x000111e1L,   1,2048,1062,   8},
  {  14,  16,  16,0x0014,0x0000,0x0000, 0x000111d1L,   1,2048,1060,   7},
  {  15,  17,  17,0x0014,0x0000,0x0000, 0x000111b1L,   1,2048,1058,   6},
  {  16,  18,  18,0x0014,0x0000,0x0000, 0x000111a1L,   1,2048,1056,   5},
  {  17,  19,  20,0x0014,0x0000,0x0000, 0x00011191L,   1,2048,1054,   4},
  {  20,  -1,  -1,0x0016,0x0005,0x0000, (long)&rs_tedinfo[45],1024,2048,1053,2049},
  {  18,  -1,  -1,0x0016,0x0005,0x0000, (long)&rs_tedinfo[46],1024,   2,1053,2049},
  {  22,  -1,  -1,0x0014,0x0000,0x0000, 0x000011e1L,1538,   0, 547,2560},
  {   0,  -1,  -1,0x0014,0x0020,0x0000, 0x000011e1L,1538,3596, 547,2560},
  /* Tree #5*/
  {  -1,   1,  16,0x0014,0x0000,0x0000, 0x000211f1L, 769,2560,1059,  17},
  {  16,   2,   2,0x0014,0x0000,0x0000, 0x000111e1L,1025,2048,1056,2060},
  {   1,   3,  15,0x0014,0x0000,0x0000, 0x00011181L,1025,2048,  29,2059},
  {   6,   4,   5,0x001b,0x0040,0x0000, 0x02011181L,   0,2057,  29,   2},
  {   5,  -1,  -1,0x001a,0x0005,0x0000, (long)"DELETE",   1,2048,   8,   1},
  {   3,  -1,  -1,0x001a,0x0005,0x0000, (long)"INSERT",  20,2048,   8,   1},
  {   9,   7,   8,0x001b,0x0040,0x0000, 0x01011181L,   0,   0,  29,   2},
  {   8,  -1,  -1,0x001c,0x0000,0x0000, (long)"1234567",   1,2048,   7,   1},
  {   6,  -1,  -1,0x001c,0x0000,0x0000, (long)"1234567",1044,2048,   7,   1},
  {  10,  -1,  -1,0x0015,0x0000,0x0008, (long)&rs_tedinfo[47],   1,   2,  27,2049},
  {  11,  -1,  -1,0x001c,0x0041,0x0000, (long)"00   1234567   123456   GEM",   1,2051,  27,   1},
  {  12,  -1,  -1,0x001c,0x0041,0x0000, (long)"01   1234567   123456   GEM",   1,2052,  27,   1},
  {  13,  -1,  -1,0x001c,0x0041,0x0000, (long)"02   1234567   123456   GEM",   1,2053,  27,   1},
  {  14,  -1,  -1,0x001c,0x0041,0x0000, (long)"03   1234567   123456   GEM",   1,2054,  27,   1},
  {  15,  -1,  -1,0x001c,0x0041,0x0000, (long)"04   1234567   123456   GEM",   1,2055,  27,   1},
  {   2,  -1,  -1,0x001c,0x0041,0x0000, (long)"05   1234567   123456   GEM",   1,2056,  27,   1},
  {   0,  17,  21,0x0014,0x0000,0x0000, 0x000111c1L,1025,2061,1056,2050},
  {  18,  -1,  -1,0x001a,0x0005,0x0000, (long)"WRITE",1025,2048,1031,2049},
  {  19,  -1,  -1,0x001b,0x0040,0x0000, 0x04011181L,1035,2048,   3,2049},
  {  20,  -1,  -1,0x001b,0x0040,0x0000, 0x03011181L,  18,2048,   3,2049},
  {  21,  -1,  -1,0x001b,0x0047,0x0000, 0x30011181L,1038,2048,1027,2049},
  {  16,  -1,  -1,0x001a,0x0025,0x0000, (long)"ABORT",1047,2048,1031,2049}
};

OBJECT *rs_trindex[] = {
  &rs_object[0],
  &rs_object[24],
  &rs_object[36],
  &rs_object[71],
  &rs_object[98],
  &rs_object[121]
};

int rs_trloc[] = {0,24,36,71,98,121};

#define NUM_TI 48
#define NUM_IB 1
#define NUM_BB 1
#define NUM_OBS 143
#define NUM_TREE 6


void fix_objects(void)
{
  register int i;

  for(i=0; i<NUM_OBS; i++)
    rsrc_obfix(rs_object, i);
}

