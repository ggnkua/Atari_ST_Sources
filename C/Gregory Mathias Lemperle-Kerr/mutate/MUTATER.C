#ifndef __AES__
#include <aes.h>
#endif
static char p_to_nul[1] = "";

TEDINFO rs_tedinfo[] = {
  {"000000:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000010:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000020:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000030:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000040:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000050:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000060:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000070:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000080:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"000090:0000 0000 0000 0000 0000 0000 0000 0000 ABCDEFGHIJKLMNOP", p_to_nul, p_to_nul,
     3,   0,   0, 4481,   0,   0,  64,   1},
  {"0", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"2", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"4", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"6", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"8", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"A", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"C", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"E", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"Alpha", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,   6,   1},
  {"I", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"N", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"F", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"O", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,   2,   1},
  {"MUTATE V1.0 by Gregory Mathias Lemperle-Kerr", p_to_nul, p_to_nul,
     3,   0,   2, 4481,   0,   0,  45,   1},
  {"Memory/Sector/File Editor.  (Handles any size sector)", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  54,   1},
  {"Options on Bar: (Q)uit (F)ile (D)isk (M)emory", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  46,   1},
  {"Use TAB to switch between Hex and Ascii input", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  46,   1},
  {"Use UPDATE or QUIT or D/F/M to write changes", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  45,   1},
  {"Use ARROWS for page, +/- for block,  buttons to change", p_to_nul, p_to_nul,
     5,   0,   0, 4481,   0,   0,  56,   1},
  {"(C) 1990 Spieu!soft.  Call (011)(41)(61) 475146 for Update", p_to_nul, p_to_nul,
     5,   0,   2, 4481,   0,   0,  59,   1}
};

ICONBLK rs_iconblk[] = {
  0L
};

int bblock000[] = {
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
  0x0000,0x0000,0x4000,0x0000,0x1f00,0x0000,0x4000,0x0000,
  0x1107,0x8000,0x4004,0x0000,0x214c,0xc040,0x4004,0x0000,
  0x21d0,0x41e0,0x4004,0x0000,0x21f0,0x4320,0xc004,0x0000,
  0x0060,0x4420,0x8000,0x0000,0x00a0,0x4400,0x8008,0x0000,
  0x00c0,0x5840,0x800c,0x0000,0x00c0,0x1040,0x8008,0x0000,
  0x00c0,0xa040,0x8008,0x0000,0x00c0,0xa041,0x0008,0x0000,
  0x0081,0x4041,0x8018,0x0000,0x0081,0x4081,0x0018,0x0000,
  0x0082,0x811f,0xf010,0x0000,0x0082,0x8102,0x0018,0x0000,
  0x0086,0x8202,0x0010,0x0000,0x0085,0x0002,0x0010,0x0000,
  0x0185,0x0403,0x0010,0x0000,0x010f,0x0802,0x0030,0x0000,
  0x010a,0x0003,0x0e20,0x0000,0x010a,0x1902,0x1a20,0x0000,
  0x010c,0x1322,0x1220,0x0000,0x0118,0x1223,0x1227,0x0000,
  0x0118,0x2262,0x1225,0x0000,0x0230,0x2663,0x3225,0x0000,
  0x0220,0x2443,0xf225,0x0000,0x0220,0x4e46,0x1465,0x0000,
  0x0c60,0x4bec,0x1e75,0x0800,0x0000,0x7030,0x025f,0xf000,
  0x0000,0x0000,0x0386,0x0000,0x0000,0x0000,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0200,0x0000,0x0000,
  0x0000,0x0203,0x0000,0x0000,0x0000,0x0206,0x8000,0x0000,
  0x0000,0x0204,0xc000,0x0000,0x0000,0x0204,0x4000,0x0000,
  0x0000,0x0208,0x4000,0x0000,0x0000,0x0208,0x4000,0x0000,
  0x0000,0x0208,0x4000,0x0000,0x0000,0x0244,0xc000,0x0000,
  0x0000,0x0207,0x8000,0x0000,0x0000,0x0000,0x0000,0x0000
};

int bblock001[] = {
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0003,
  0xe000,0x0000,0x0000,0x0000,0x0000,0x0000,0x007e,0x3e00,
  0x0000,0x000c,0x0007,0xc000,0x0000,0x00c0,0x0380,0x0000,
  0x0038,0x0018,0x20e0,0x0000,0x0080,0x00fc,0x0000,0x03e0,
  0x0010,0x2723,0xe000,0x0180,0x0007,0xff00,0x7c00,0x0018,
  0x3c26,0x2000,0x0100,0x0000,0x01ff,0xc000,0x000c,0x3038,
  0x2000,0x0100,0x0000,0x0000,0x0000,0x0000,0x6030,0x6000,
  0x0100,0x0000,0x0000,0x0000,0x0000,0xc060,0x4000,0x0180,
  0x0000,0x0000,0x0000,0x0000,0xc0c0,0xc000,0x0080,0x0000,
  0x0000,0x0000,0x0001,0x8081,0x8000,0x00e0,0x3ce0,0xe000,
  0xec41,0x0003,0x0181,0x0000,0x003e,0x64a1,0xf079,0xb841,
  0x0007,0x0183,0x0000,0x0004,0x44e3,0x90cf,0x30c3,0x000e,
  0x0306,0x0000,0x0004,0xccc7,0x1184,0x21e3,0x000c,0x0604,
  0x0000,0x000f,0x88c7,0x37cc,0x3f3e,0x0018,0x041b,0x0000,
  0x0008,0x077f,0xf478,0x0002,0x0000,0x0016,0x2000,0x0008,
  0x0000,0x1800,0x0002,0x0000,0x001c,0x0000,0x0018,0x0000,
  0x3800,0x0002,0x0000,0x0000,0x0000,0x0010,0x0000,0x6800,
  0x0001,0x0000,0x0000,0x0000,0x0030,0x01ff,0xffe0,0x0000,
  0x8000,0x0000,0x0000,0x0060,0x0f00,0x481f,0xffe0,0x4000,
  0x0000,0x0000,0x0043,0xf800,0x4800,0x003e,0x6000,0x0000,
  0x0000,0x009e,0x0000,0x7800,0x0003,0xb000,0x0000,0x0000,
  0x00b0,0x0000,0x0000,0x0000,0xf000,0x0000,0x0000,0x01e0,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x01c0,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0180,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,
  0x0001,0xfc00,0x0000,0x0000,0x0000,0x0000,0x0000,0x0003,
  0x0600,0x0f00,0x000c,0x0000,0x0000,0x0000,0x0002,0x0200,
  0x39c0,0x001c,0x0000,0x0000,0x0002,0x0002,0x0200,0x6060,
  0x0014,0x0000,0x0000,0x0002,0x0001,0x0200,0xc020,0x0014,
  0x0000,0x0000,0x0006,0x0001,0xfa01,0x8030,0x039c,0x0000,
  0x0000,0x0006,0x0000,0x0403,0x0010,0x00f8,0x0000,0x0000,
  0x0006,0x0000,0x0406,0x0010,0x0008,0x0000,0x0000,0x0006,
  0x0000,0x040c,0x0018,0x0008,0x0000,0x0000,0x0006,0x0000,
  0x0c18,0x0008,0x0008,0x0000,0x0000,0x000e,0x0000,0x0830,
  0x0008,0x0008,0x0000,0x0000,0x000a,0x0000,0x0860,0x0008,
  0x0008,0x0000,0x0000,0x000a,0x003c,0x18c0,0x0008,0x0008,
  0x0000,0x0000,0x001a,0x0000,0x3180,0x0008,0x0008,0x0000,
  0x0000,0x0012,0x0000,0x2300,0x0008,0x0010,0x0000,0x0000,
  0x0012,0x0000,0x3e00,0x0008,0x0010,0x0000,0x0001,0xc01a,
  0x0e00,0x61e0,0x0008,0x0010,0xe0b9,0xc3f2,0x478e,0x0a00,
  0x6123,0xcf08,0x0390,0xb0ea,0x430a,0x4486,0x1600,0xb122,
  0x4908,0x0ef1,0x114e,0x430b,0xc487,0x1c01,0x11e2,0x4908,
  0x0861,0x3344,0x4709,0x8499,0x9803,0x10c6,0x4908,0x0830,
  0xa24c,0x5ddb,0x8cf0,0xf102,0x1b6c,0x5988,0x0cde,0xfe00,
  0x71fe,0x78c0,0x1f02,0x0e38,0x7078,0x0783,0xf000,0x0100,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0000,0x0100,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0000,0x0100,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0000,0x0100,0x0000,0x0000,0x0000,
  0x0000,0x0000,0x0000,0x0100,0x0000,0x0000,0x0000,0x0000
};

BITBLK rs_bitblk[] = {
  {bblock000,  0x0008, 0x0032, 0x0000, 0x0000, 0x0001},
  {bblock001,  0x000e, 0x0038, 0x0000, 0x0000, 0x0001}
};

OBJECT rs_object[] = {
  /* Tree #0*/
  {  -1,   1,  45,0x0014,0x0000,0x0000, 0x000411c1L,1794,2561,  73,3854},
  {  21,   2,  20,0x0014,0x0000,0x0020, 0x00011181L,   1,2048, 578,3850},
  {   3,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[0],1025,3072, 575,   1},
  {   4,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[1],1025,2561,  63,   1},
  {   5,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[2],1025,2562,  63,   1},
  {   6,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[3],1025,2563,  63,   1},
  {   7,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[4],1025,2564,  63,   1},
  {   8,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[5],1025,2565,  63,   1},
  {   9,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[6],1025,2566,  63,   1},
  {  10,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[7],1025,2567,  63,   1},
  {  11,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[8],1025,2568,  63,   1},
  {  12,  -1,  -1,0x0015,0x0005,0x0000, (long)&rs_tedinfo[9],1025,2569,  63,   1},
  {  13,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[10],1032, 512,   1,2048},
  {  14,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[11],1037, 512,   1,2048},
  {  15,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[12],1042, 512,   1,2048},
  {  16,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[13],1047, 512,   1,2048},
  {  17,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[14],1052, 512,   1,2048},
  {  18,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[15],1057, 512,   1,2048},
  {  19,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[16],1062, 512,   1,2048},
  {  20,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[17],1067, 512,   1,2048},
  {   1,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[18],1072, 512,1539,2048},
  {  25,  22,  24,0x0014,0x0041,0x0000, 0x000111c1L,  68,2048,1794,3850},
  {  23,  -1,  -1,0x001b,0x0040,0x0000, 0x01011181L, 256, 256,1282, 513},
  {  24,  -1,  -1,0x001b,0x0040,0x0000, 0x02011181L, 256,3081,1282, 513},
  {  21,  -1,  -1,0x0014,0x0041,0x0000, 0x00011181L, 256, 769,1282,2312},
  {  45,  26,  44,0x0014,0x0000,0x0000, 0x000111e1L,1792,3083, 583,3074},
  {  30,  27,  29,0x0014,0x0000,0x0000, 0x000111c1L,   4,2048,1032,2049},
  {  28,  -1,  -1,0x001b,0x0005,0x0000, 0x46011181L, 512, 512, 770, 769},
  {  29,  -1,  -1,0x001b,0x0005,0x0000, 0x44011181L,   3, 512, 770, 769},
  {  26,  -1,  -1,0x001b,0x0005,0x0000, 0x4d011181L,1541, 512, 770, 769},
  {  35,  31,  34,0x0014,0x0000,0x0000, 0x00011181L,1548,2048,  16,2049},
  {  32,  -1,  -1,0x001c,0x0000,0x0000, (long)"0000000",   3,1024, 263,   1},
  {  33,  -1,  -1,0x001a,0x0005,0x0000, (long)"", 781,1024,   2,   1},
  {  34,  -1,  -1,0x001a,0x0040,0x0000, (long)"+",1024,1024,   2,   1},
  {  30,  -1,  -1,0x001a,0x0040,0x0000, (long)"-",1034,1024,   2,   1},
  {  38,  36,  37,0x0014,0x0000,0x0000, 0x00011181L,  29,2048,  16,2049},
  {  37,  -1,  -1,0x001c,0x0000,0x0000, (long)"FILENAME.EXT",1024,1024, 268,   1},
  {  35,  -1,  -1,0x001a,0x0005,0x0000, (long)"", 781,1024,   2,   1},
  {  42,  39,  41,0x0014,0x0000,0x0000, 0x00011181L, 301,2304, 775,1793},
  {  40,  -1,  -1,0x001a,0x0040,0x0000, (long)"",1024,1024,   2,   1},
  {  41,  -1,  -1,0x001b,0x0005,0x0000, 0x43011181L,1538, 512,1537,1025},
  {  38,  -1,  -1,0x001a,0x0040,0x0000, (long)"",1796,1024,   2,   1},
  {  43,  -1,  -1,0x001a,0x0005,0x0000, (long)"Find",1333,2048,   7,1793},
  {  44,  -1,  -1,0x001a,0x0005,0x0000, (long)"Q",1792,2048,1026,2049},
  {  25,  -1,  -1,0x001a,0x0007,0x0030, (long)"UPDATE", 830,1792, 775,2049},
  {   0,  46,  50,0x0014,0x0000,0x0000, 0x00011181L, 327,1792, 513,3850},
  {  47,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[19], 256,1025,   1,2560},
  {  48,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[20], 256,3075,   1,2560},
  {  49,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[21], 256,1030,   1,2560},
  {  50,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[22], 256,3080,   1,2560},
  {  45,  -1,  -1,0x0019,0x0025,0x0000, 0x00011181L,   0,   0, 257,3594},
  /* Tree #1*/
  {  -1,   1,   1,0x0014,0x0000,0x0000, 0x000a11e1L, 523,2049, 310,2832},
  {   0,   2,  10,0x0014,0x0000,0x0000, 0x00011181L,1026,1281,  49, 526},
  {   3,  -1,  -1,0x0017,0x0000,0x0000, (long)&rs_bitblk[0], 788, 512, 263,1795},
  {   4,  -1,  -1,0x0017,0x0003,0x0030, (long)&rs_bitblk[1], 274, 778,1038,2051},
  {   5,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[23], 258,1027,1068, 513},
  {   6,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[24], 258,2052, 553,2304},
  {   7,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[25], 258, 517, 553,2304},
  {   8,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[26], 258,3077, 553,2304},
  {   9,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[27], 258,1542, 553,2304},
  {  10,  -1,  -1,0x0015,0x0000,0x0000, (long)&rs_tedinfo[28], 258,   7, 553,2304},
  {   1,  -1,  -1,0x0015,0x0020,0x0000, (long)&rs_tedinfo[29],1026,1289, 812,2560}
};

int rs_trloc[] = {
 0,
 51
};

OBJECT *rs_trindex[] = {
  &rs_object[0],
  &rs_object[51]
};

#define NUM_TI 30
#define NUM_IB 0
#define NUM_BB 2
#define NUM_OBS 62
#define NUM_TREE 2


void fix_objects(void)
{
  register int i;

  for(i=0; i<NUM_OBS; i++)
    rsrc_obfix(rs_object, i);
}

