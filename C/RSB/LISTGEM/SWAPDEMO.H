/* resource set indicies for SWAPDEMO */

#define HAUPTMEN 0	/* menu tree */
#define DESK     3	/* TITLE in tree HAUPTMEN */
#define DATEI    4	/* TITLE in tree HAUPTMEN */
#define ABOUT    7	/* STRING in tree HAUPTMEN */
#define TOSEXEC  16	/* STRING in tree HAUPTMEN */
#define GEMEXEC  17	/* STRING in tree HAUPTMEN */
#define ENDE     19	/* STRING in tree HAUPTMEN */

#define ABOUTBOX 1	/* form/dialog */
#define OKBUTTON 1	/* BUTTON in tree ABOUTBOX */

#define DESKTOP  2	/* form/dialog */
#define MAXL     1	/* IBOX in tree DESKTOP */

