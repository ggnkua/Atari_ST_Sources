#define HAUPTMEN 0  	/* TREE */
#define ABOUTBOX 1  	/* TREE */
#define DESKTOP 2  	/* TREE */
#define MAXL 1  	/* OBJECT in TREE #2 */
#define DATEI 4  	/* OBJECT in TREE #0 */
#define TOSEXEC 16  	/* OBJECT in TREE #0 */
#define GEMEXEC 17  	/* OBJECT in TREE #0 */
#define DESK 3  	/* OBJECT in TREE #0 */
#define ENDE 19  	/* OBJECT in TREE #0 */
#define ABOUT 7  	/* OBJECT in TREE #0 */
#define OKBUTTON 1  	/* OBJECT in TREE #1 */
