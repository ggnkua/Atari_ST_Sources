#define DIALOG 0  	/* TREE */
#define RPM 5  	/* OBJECT in TREE #0 */
#define MSG 3  	/* OBJECT in TREE #0 */
#define DRIVEA 6  	/* OBJECT in TREE #0 */
#define QUIT 7  	/* OBJECT in TREE #0 */
#define DRIVEB 8  	/* OBJECT in TREE #0 */
