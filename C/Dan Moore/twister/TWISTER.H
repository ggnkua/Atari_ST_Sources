#define DEBUSH 0  	/* TREE */
#define LONELY 4  	/* OBJECT in TREE #0 */
#define MARRIED 5  	/* OBJECT in TREE #0 */
#define DRIVE0 7  	/* OBJECT in TREE #0 */
#define  DRIVE1 8  	/* OBJECT in TREE #0 */
#define RUNAWAY 2  	/* OBJECT in TREE #0 */
#define TWISTIT 1  	/* OBJECT in TREE #0 */
