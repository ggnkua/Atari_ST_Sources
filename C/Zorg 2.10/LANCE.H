/* lance.c */
void	lance_prg( void );
boolean	lance_prg_proc( t_dialog *dialog, int exit );
