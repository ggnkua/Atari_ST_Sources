/* constantes de d‚finitions de ZORG.INF */
#define WIN_DEF		1	/* position et taille des fenˆtres */
#define CARACTERE_ZERO_DEF	2	/* affichage du caractŠre NULL */
#define FLOPPY_RAW	3	/* choix pr‚d‚finis pour disquette */
#define HARD_RAW	4	/* choix pr‚d‚finis pour disque dur */
#define DEVICE		5	/* d‚finition des partitions */
#define SOUND_FLAG	6	/* Musique */
#define ZORG_INF	7	/* … partir de ZORG.INF ? */
#define ZORG_VERSION	8	/* version du fichier .INF */
#define CLEAR_SCREEN	9	/* efface l'‚cran avant de lancer un prg */
#define FLUSH_CACHE	10	/* vide les cache ''   '' */
#define	MAKE_PAUSE	11	/* fait une pause aprŠs   '' */
#define BLOC_SIZE	12	/* taille d'un bloc */
#define TOS_40x_BUG	13	/* ‚vite le bug du TOS 4.0x ? */
#define SAVE_POS	14	/* sauvegarde la position avant une recherche */
#define SCROLL_TIMER	15	/* temps en miliseconde avant de charger le secteur */
#define SHORTCUTS	16	/* d‚finitions des raccourcis clavier */
#define DIALOG_WINDOW	17	/* mettre les boŒtes de dialogue dans des fenˆtres */
#define RESET_FLAG_INF	18	/* Reset aprŠs un changement de structure */
/* 19 utilis‚ dans la version 5 */
#define MULTI_WARNING_FLAG	20	/* message en environement multitache */
#define KEEP_STRUCTURE	21	/* garde la structure aprŠs un 'Test...' */
#define MANAGE_VFAT_OPT	22	/* gestion des noms longs */
