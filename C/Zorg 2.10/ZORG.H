
#define PARAM_DIALOGUE     0 	/* TREE - DIALOG */
#define PARAM_TEXT_1       4 	/* G_TEXT in (#0) PARAM_DIALOGUE */
#define PARAM_TEXT_2       5 	/* G_TEXT in (#0) PARAM_DIALOGUE */

#define PRESENTATION       1 	/* TREE - DIALOG */
#define DATE_TXT           3 	/* G_TEXT in (#1) PRESENTATION */
#define VERSION_TEXT       6 	/* G_TEXT in (#1) PRESENTATION */
#define PRESENTATION_INF  14 	/* G_BUTTON in (#1) PRESENTATION */
#define PRESENTATION_OK   16 	/* G_BUTTON in (#1) PRESENTATION */

#define CHOIX_UNIT         2 	/* TREE - DIALOG */
#define HD_UNIT_TEXTE2     4 	/* G_STRING in (#2) CHOIX_UNIT */
#define HD_UNIT2           6 	/* G_BOXTEXT in (#2) CHOIX_UNIT */
#define HD_UNIT_BUTTON2    7 	/* G_BOX in (#2) CHOIX_UNIT */
#define HD_MODE_TEXTE2     8 	/* G_STRING in (#2) CHOIX_UNIT */
#define HD_MODE2          10 	/* G_BOXTEXT in (#2) CHOIX_UNIT */
#define HD_MODE_BUTTON2   11 	/* G_BOX in (#2) CHOIX_UNIT */
#define CHOIX_UNIT_OK     12 	/* G_BUTTON in (#2) CHOIX_UNIT */
#define CHOIX_UNIT_ANNUL  14 	/* G_BUTTON in (#2) CHOIX_UNIT */

#define SECTEUR_ARR        3 	/* TREE - DIALOG */
#define SECTEUR_ARRIVEE    3 	/* G_FBOXTEXT in (#3) SECTEUR_ARR */
#define CLUSTER_ARRIVEE    5 	/* G_FBOXTEXT in (#3) SECTEUR_ARR */
#define SECT_ARRIVE_FOND   7 	/* G_BOX in (#3) SECTEUR_ARR */
#define SECT_ARRIVE_BAR    8 	/* G_BOX in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_BOOT   9 	/* G_BUTTON in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_FAT1  11 	/* G_BUTTON in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_FAT2  13 	/* G_BUTTON in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_ROOT  15 	/* G_BUTTON in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_FRST  17 	/* G_BUTTON in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_OK    19 	/* G_BUTTON in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_LIST  21 	/* G_BUTTON in (#3) SECTEUR_ARR */
#define SECTEUR_ARR_ANNU  23 	/* G_BUTTON in (#3) SECTEUR_ARR */

#define OFFSET_ARR         4 	/* TREE - DIALOG */
#define OFFSET_ARRIVEE     3 	/* G_FBOXTEXT in (#4) OFFSET_ARR */
#define SECTEUR_OFFSET     5 	/* G_FBOXTEXT in (#4) OFFSET_ARR */
#define OFFSET_ARR_FOND    7 	/* G_BOX in (#4) OFFSET_ARR */
#define OFFSET_ARR_BARRE   8 	/* G_BOX in (#4) OFFSET_ARR */
#define OFFSET_ARR_OK      9 	/* G_BUTTON in (#4) OFFSET_ARR */
#define OFFSET_ARR_LIST   11 	/* G_BUTTON in (#4) OFFSET_ARR */
#define OFFSET_ARR_ANNUL  13 	/* G_BUTTON in (#4) OFFSET_ARR */

#define RAW_SECTEUR_ARR    5 	/* TREE - DIALOG */
#define RAW_SECT_ARRIVEE   3 	/* G_FBOXTEXT in (#5) RAW_SECTEUR_ARR */
#define RAW_SECT_FOND      4 	/* G_BOX in (#5) RAW_SECTEUR_ARR */
#define RAW_SECT_BAR       5 	/* G_BOX in (#5) RAW_SECTEUR_ARR */
#define RAW_SECT_OK        6 	/* G_BUTTON in (#5) RAW_SECTEUR_ARR */
#define RAW_SECT_LISTE     8 	/* G_BUTTON in (#5) RAW_SECTEUR_ARR */
#define RAW_SECT_ANNULER  10 	/* G_BUTTON in (#5) RAW_SECTEUR_ARR */

#define SEARCH             6 	/* TREE - DIALOG */
#define SEARCH_ASCII       6 	/* G_FBOXTEXT in (#6) SEARCH */
#define ASCII_ACTIF        7 	/* G_IBOX in (#6) SEARCH */
#define SEARCH_HEXA        9 	/* G_FBOXTEXT in (#6) SEARCH */
#define HEXA_ACTIF        10 	/* G_IBOX in (#6) SEARCH */
#define DIFF_MAJ_MIN      11 	/* G_IBOX in (#6) SEARCH */
#define TO_START          16 	/* G_BUTTON in (#6) SEARCH */
#define TO_END            18 	/* G_BUTTON in (#6) SEARCH */
#define SEARCH_GO         20 	/* G_BUTTON in (#6) SEARCH */
#define SEARCH_CALC       22 	/* G_BUTTON in (#6) SEARCH */
#define SEARCH_ANNULER    24 	/* G_BUTTON in (#6) SEARCH */

#define WAIT               7 	/* TREE - DIALOG */
#define WAIT_MESSAGE       2 	/* G_STRING in (#7) WAIT */
#define WAIT_INFO          4 	/* G_TEXT in (#7) WAIT */
#define SLIDE_PERE         5 	/* G_BOX in (#7) WAIT */
#define SLIDE_FILS         6 	/* G_BOX in (#7) WAIT */
#define INDICATEUR_WAIT   13 	/* G_TEXT in (#7) WAIT */
#define MAX_WAIT          14 	/* G_STRING in (#7) WAIT */

#define DIRECTORY_INFO     8 	/* TREE - DIALOG */
#define DIR_NAME           5 	/* G_STRING in (#8) DIRECTORY_INFO */
#define DIR1               7 	/* G_FBOXTEXT in (#8) DIRECTORY_INFO */
#define DIR8              14 	/* G_FBOXTEXT in (#8) DIRECTORY_INFO */
#define DIR9              16 	/* G_FBOXTEXT in (#8) DIRECTORY_INFO */
#define DIR_PREVIOUS      24 	/* G_BUTTON in (#8) DIRECTORY_INFO */
#define DIR_OK            26 	/* G_BUTTON in (#8) DIRECTORY_INFO */
#define DIR_NEXT          28 	/* G_BUTTON in (#8) DIRECTORY_INFO */

#define FILE_INFO          9 	/* TREE - DIALOG */
#define FILE_NAME          5 	/* G_FBOXTEXT in (#9) FILE_INFO */
#define READ_ONLY          7 	/* G_BUTTON in (#9) FILE_INFO */
#define HIDDEN             9 	/* G_BUTTON in (#9) FILE_INFO */
#define SYSTEM            11 	/* G_BUTTON in (#9) FILE_INFO */
#define VOLUME            13 	/* G_BUTTON in (#9) FILE_INFO */
#define DIRECTORY         15 	/* G_BUTTON in (#9) FILE_INFO */
#define ARCHIVE           17 	/* G_BUTTON in (#9) FILE_INFO */
#define FILE_DATE_TOUCH   19 	/* G_STRING in (#9) FILE_INFO */
#define FILE_DATE         21 	/* G_FBOXTEXT in (#9) FILE_INFO */
#define FILE_TIME_TOUCH   22 	/* G_STRING in (#9) FILE_INFO */
#define FILE_TIME         24 	/* G_FBOXTEXT in (#9) FILE_INFO */
#define FILE_CLUSTER_DEC  26 	/* G_FBOXTEXT in (#9) FILE_INFO */
#define FILE_CLUSTER_HEX  27 	/* G_FBOXTEXT in (#9) FILE_INFO */
#define FILE_SIZE_DEC     29 	/* G_FBOXTEXT in (#9) FILE_INFO */
#define FILE_SIZE_HEXA    30 	/* G_FBOXTEXT in (#9) FILE_INFO */
#define FILE_SAUVER       31 	/* G_BUTTON in (#9) FILE_INFO */
#define FILE_ANNULER      33 	/* G_BUTTON in (#9) FILE_INFO */

#define LISTE_GOTO        10 	/* TREE - DIALOG */
#define LISTE_UP           4 	/* G_BOXCHAR in (#10) LISTE_GOTO */
#define LISTE_PERE         5 	/* G_BOX in (#10) LISTE_GOTO */
#define LISTE_FILS         6 	/* G_BOX in (#10) LISTE_GOTO */
#define LISTE_BOX         10 	/* G_BOX in (#10) LISTE_GOTO */
#define LISTE_LIGNE_1     11 	/* G_TEXT in (#10) LISTE_GOTO */
#define LISTE_LIGNE_2     12 	/* G_TEXT in (#10) LISTE_GOTO */
#define LISTE_LIGNE_3     13 	/* G_TEXT in (#10) LISTE_GOTO */
#define LISTE_LIGNE_4     14 	/* G_TEXT in (#10) LISTE_GOTO */
#define LISTE_LIGNE_5     15 	/* G_TEXT in (#10) LISTE_GOTO */
#define LISTE_DOWN        16 	/* G_BOXCHAR in (#10) LISTE_GOTO */
#define LISTE_OK          17 	/* G_BUTTON in (#10) LISTE_GOTO */
#define EFFACE            19 	/* G_BUTTON in (#10) LISTE_GOTO */
#define LISTE_ANNULER     21 	/* G_BUTTON in (#10) LISTE_GOTO */

#define LANCE_PRG         11 	/* TREE - DIALOG */
#define PROGRAM_NAME       5 	/* G_FBOXTEXT in (#11) LANCE_PRG */
#define COMMAND_LINE       7 	/* G_FBOXTEXT in (#11) LANCE_PRG */
#define VIDE_CACHE        10 	/* G_IBOX in (#11) LANCE_PRG */
#define PAUSE             13 	/* G_IBOX in (#11) LANCE_PRG */
#define EFFACER_ECRAN     16 	/* G_IBOX in (#11) LANCE_PRG */
#define LANCE_OK          19 	/* G_BUTTON in (#11) LANCE_PRG */
#define LANCE_ANNULER     21 	/* G_BUTTON in (#11) LANCE_PRG */

#define ASCII             12 	/* TREE - DIALOG */
#define ASCII_LIGNE_1      4 	/* G_STRING in (#12) ASCII */
#define ASCII_CARACTERE   13 	/* G_TEXT in (#12) ASCII */
#define ASCII_OK          14 	/* G_BUTTON in (#12) ASCII */

#define TAILLE_FICHIER    13 	/* TREE - DIALOG */
#define CREATE_FILE_SIZE   4 	/* G_FBOXTEXT in (#13) TAILLE_FICHIER */
#define CREATE_FILE_OK     5 	/* G_BUTTON in (#13) TAILLE_FICHIER */
#define CREATE_FILE_ANNU   7 	/* G_BUTTON in (#13) TAILLE_FICHIER */

#define RAW_DISQUETTE     14 	/* TREE - DIALOG */
#define SIMPLE_FACE        6 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define DOUBLE_FACE        7 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define SECTEURS_10       10 	/* G_BOXTEXT in (#14) RAW_DISQUETTE */
#define SECTEURS_20       11 	/* G_BOXTEXT in (#14) RAW_DISQUETTE */
#define SECTEURS_COUNT    12 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define SECTEURS_MOINS    13 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define SECTEURS_PLUS     14 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define PISTES_80         17 	/* G_BOXTEXT in (#14) RAW_DISQUETTE */
#define PISTES_82         18 	/* G_BOXTEXT in (#14) RAW_DISQUETTE */
#define PISTES_COUNT      19 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define PISTES_MOINS      20 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define PISTES_PLUS       21 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define LECTEUR_A         24 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define LECTEUR_B         25 	/* G_BOXCHAR in (#14) RAW_DISQUETTE */
#define DISQUETTE_PERSO1  26 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define DISQUETTE_PERSO2  27 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define DISQUETTE_PERSO3  28 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define DISQUETTE_PERSO4  29 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define DISQUETTE_PERSO5  30 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define DISQUETTE_PERSO6  31 	/* G_FBOXTEXT in (#14) RAW_DISQUETTE */
#define DISQUETTE_OK      32 	/* G_BUTTON in (#14) RAW_DISQUETTE */
#define DISQUETTE_ANNULE  34 	/* G_BUTTON in (#14) RAW_DISQUETTE */

#define RAW_DISQUE_DUR    15 	/* TREE - DIALOG */
#define HD_SECTEUR_MOINS   5 	/* G_BOXCHAR in (#15) RAW_DISQUE_DUR */
#define HD_SECTEUR_COUNT   6 	/* G_FBOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_SECTEUR_PLUS    7 	/* G_BOXCHAR in (#15) RAW_DISQUE_DUR */
#define HD_UNIT_TEXTE      8 	/* G_STRING in (#15) RAW_DISQUE_DUR */
#define HD_UNIT           10 	/* G_BOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_UNIT_BUTTON    11 	/* G_BOX in (#15) RAW_DISQUE_DUR */
#define HD_MODE_TEXTE     12 	/* G_STRING in (#15) RAW_DISQUE_DUR */
#define HD_MODE           14 	/* G_BOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_MODE_BUTTON    15 	/* G_BOX in (#15) RAW_DISQUE_DUR */
#define HD_PERSO1         16 	/* G_FBOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_PERSO2         17 	/* G_FBOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_PERSO3         18 	/* G_FBOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_PERSO4         19 	/* G_FBOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_PERSO5         20 	/* G_FBOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_PERSO6         21 	/* G_FBOXTEXT in (#15) RAW_DISQUE_DUR */
#define HD_OK             22 	/* G_BUTTON in (#15) RAW_DISQUE_DUR */
#define HD_ANNULER        24 	/* G_BUTTON in (#15) RAW_DISQUE_DUR */

#define CONFIG_GENE_DIAL  16 	/* TREE - DIALOG */
#define CARACTERE_NUL      5 	/* G_BOXCHAR in (#16) CONFIG_GENE_DIAL */
#define TEMPS_LATENCE      6 	/* G_FBOXTEXT in (#16) CONFIG_GENE_DIAL */
#define TAILLE_BLOC        8 	/* G_FBOXTEXT in (#16) CONFIG_GENE_DIAL */
#define SAVE_CUR_POS      10 	/* G_IBOX in (#16) CONFIG_GENE_DIAL */
#define SOUND             13 	/* G_IBOX in (#16) CONFIG_GENE_DIAL */
#define DIALOG_IN_WINDOW  16 	/* G_IBOX in (#16) CONFIG_GENE_DIAL */
#define MULTI_WARNING     19 	/* G_IBOX in (#16) CONFIG_GENE_DIAL */
#define CONFIG_GENE_OK    22 	/* G_BUTTON in (#16) CONFIG_GENE_DIAL */
#define CONFIG_GENE_APPL  24 	/* G_BUTTON in (#16) CONFIG_GENE_DIAL */
#define CONFIG_GENE_ANNU  26 	/* G_BUTTON in (#16) CONFIG_GENE_DIAL */
#define CONFIG_GENE_SAUV  28 	/* G_BUTTON in (#16) CONFIG_GENE_DIAL */

#define CONFIG_DSK_DIAL   17 	/* TREE - DIALOG */
#define CONF_RAW_FLOPPY    5 	/* G_BUTTON in (#17) CONFIG_DSK_DIAL */
#define CONF_RAW_HARD      7 	/* G_BUTTON in (#17) CONFIG_DSK_DIAL */
#define CONFIG_DISQUES     9 	/* G_BUTTON in (#17) CONFIG_DSK_DIAL */
#define TOS_40X_BUG       11 	/* G_IBOX in (#17) CONFIG_DSK_DIAL */
#define RESET_FLAG        14 	/* G_IBOX in (#17) CONFIG_DSK_DIAL */
#define KEEP_CACHE        17 	/* G_IBOX in (#17) CONFIG_DSK_DIAL */
#define MANAGE_VFAT       20 	/* G_IBOX in (#17) CONFIG_DSK_DIAL */
#define CONFIG_DSK_OK     23 	/* G_BUTTON in (#17) CONFIG_DSK_DIAL */
#define CONFIG_DSK_ANNUL  25 	/* G_BUTTON in (#17) CONFIG_DSK_DIAL */
#define CONFIG_DSK_SAUVE  27 	/* G_BUTTON in (#17) CONFIG_DSK_DIAL */

#define CONFIG_MENU       18 	/* TREE - DIALOG */
#define TITLE              4 	/* G_STRING in (#18) CONFIG_MENU */
#define MENU_TITLE         5 	/* G_BOXTEXT in (#18) CONFIG_MENU */
#define TITLE_BUTTON       6 	/* G_BOX in (#18) CONFIG_MENU */
#define ENTREE             7 	/* G_STRING in (#18) CONFIG_MENU */
#define MENU_ENTREE        8 	/* G_BOXTEXT in (#18) CONFIG_MENU */
#define ENTREE_BUTTON      9 	/* G_BOX in (#18) CONFIG_MENU */
#define SHORT_CUT         11 	/* G_TEXT in (#18) CONFIG_MENU */
#define MENU_OK           13 	/* G_BUTTON in (#18) CONFIG_MENU */
#define MENU_APPLIQUER    14 	/* G_BUTTON in (#18) CONFIG_MENU */
#define MENU_ANNULER      15 	/* G_BUTTON in (#18) CONFIG_MENU */

#define COULEURS          19 	/* TREE - DIALOG */
#define GADGET             4 	/* G_STRING in (#19) COULEURS */
#define GADGET_TITLE       6 	/* G_BOXTEXT in (#19) COULEURS */
#define GADGET_BUTTON      7 	/* G_BOX in (#19) COULEURS */
#define COULEUR            8 	/* G_STRING in (#19) COULEURS */
#define COULEUR_TITLE     10 	/* G_BOX in (#19) COULEURS */
#define COULEUR_BUTTON    11 	/* G_BOX in (#19) COULEURS */
#define TRAME             12 	/* G_STRING in (#19) COULEURS */
#define TRAME_TITLE       14 	/* G_BOX in (#19) COULEURS */
#define TRAME_BUTTON      15 	/* G_BOX in (#19) COULEURS */
#define COULEURS_OK       16 	/* G_BUTTON in (#19) COULEURS */
#define COULEURS_APPLIQU  18 	/* G_BUTTON in (#19) COULEURS */
#define COULEURS_ANNULER  20 	/* G_BUTTON in (#19) COULEURS */

#define MENU              20 	/* TREE - MENU   */
#define MENU_ZORG          3 	/* G_TITLE in (#20) MENU */
#define MENU_ETAT          4 	/* G_TITLE in (#20) MENU */
#define MENU_OUVRE         5 	/* G_TITLE in (#20) MENU */
#define MENU_EDITION       6 	/* G_TITLE in (#20) MENU */
#define MENU_STRUCTURE     7 	/* G_TITLE in (#20) MENU */
#define MENU_DEPLACEMENT   8 	/* G_TITLE in (#20) MENU */
#define MENU_FENETRES      9 	/* G_TITLE in (#20) MENU */
#define MENU_OPTIONS      10 	/* G_TITLE in (#20) MENU */
#define MENU_AIDE         11 	/* G_TITLE in (#20) MENU */
#define INFORMATIONS      14 	/* G_STRING in (#20) MENU */
#define INFORMATION       23 	/* G_STRING in (#20) MENU */
#define REPERTOIRE_LOUPE  24 	/* G_STRING in (#20) MENU */
#define TEST_STRUCTURE    25 	/* G_STRING in (#20) MENU */
#define STATISTIQUES      26 	/* G_STRING in (#20) MENU */
#define OCCUPATION        27 	/* G_STRING in (#20) MENU */
#define TRACE_UN_FICHIER  28 	/* G_STRING in (#20) MENU */
#define QUITTER           30 	/* G_STRING in (#20) MENU */
#define UNITE_LOGIQUE     33 	/* G_STRING in (#20) MENU */
#define OUVRE_DISQUETTE   34 	/* G_STRING in (#20) MENU */
#define OUVRE_DISQUE_DUR  35 	/* G_STRING in (#20) MENU */
#define OUVRE_FICHIER     36 	/* G_STRING in (#20) MENU */
#define OUVRE_FICHIER_FS  37 	/* G_STRING in (#20) MENU */
#define OUVRE_FICH_TEXTE  38 	/* G_STRING in (#20) MENU */
#define CREER_FICHIER     39 	/* G_STRING in (#20) MENU */
#define FERMER            40 	/* G_STRING in (#20) MENU */
#define LIRE_BOOT         42 	/* G_STRING in (#20) MENU */
#define ECRIRE_BOOT       43 	/* G_STRING in (#20) MENU */
#define CHARGER_BOOT      44 	/* G_STRING in (#20) MENU */
#define SAUVER_BOOT       45 	/* G_STRING in (#20) MENU */
#define SAUVER_SECTEUR    48 	/* G_STRING in (#20) MENU */
#define COPIER_SECTEUR    49 	/* G_STRING in (#20) MENU */
#define COLLER_SECTEUR    50 	/* G_STRING in (#20) MENU */
#define ECHANGER_TAMPON   51 	/* G_STRING in (#20) MENU */
#define RETOUR_INITIAL    52 	/* G_STRING in (#20) MENU */
#define OUVRIR_TAMPON     54 	/* G_STRING in (#20) MENU */
#define SAUVER_TAMPON     55 	/* G_STRING in (#20) MENU */
#define CHARGER_TB_ASCII  56 	/* G_STRING in (#20) MENU */
#define EFFACER_TAMPON    57 	/* G_STRING in (#20) MENU */
#define DEFRAGMENTATION   59 	/* G_STRING in (#20) MENU */
#define UNIQUE_LIBRE      60 	/* G_STRING in (#20) MENU */
#define RESTO_COMPLETE    61 	/* G_STRING in (#20) MENU */
#define VIDE_CLST_LIBRES  63 	/* G_STRING in (#20) MENU */
#define NETTOIE_REPERTOI  64 	/* G_STRING in (#20) MENU */
#define SECTEUR_SUIVANT   66 	/* G_STRING in (#20) MENU */
#define SECTEUR_PRECEDEN  67 	/* G_STRING in (#20) MENU */
#define BLOC_SUIVANT      68 	/* G_STRING in (#20) MENU */
#define BLOC_PRECEDENT    69 	/* G_STRING in (#20) MENU */
#define MARQUER_POSITION  71 	/* G_STRING in (#20) MENU */
#define ALLER_MARQUE      72 	/* G_STRING in (#20) MENU */
#define ALLER_SECTEUR     73 	/* G_STRING in (#20) MENU */
#define CHERCHER_CHAINE   75 	/* G_STRING in (#20) MENU */
#define CHERCHER_NOUVEAU  76 	/* G_STRING in (#20) MENU */
#define CHOIX_FONTE       78 	/* G_STRING in (#20) MENU */
#define CHOIX_COULEURS    79 	/* G_STRING in (#20) MENU */
#define TAILLE_IDEALE     80 	/* G_STRING in (#20) MENU */
#define ASCENSEURS        81 	/* G_STRING in (#20) MENU */
#define CYCLER_FENETRES   82 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_1     84 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_2     85 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_3     86 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_4     87 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_5     88 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_6     89 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_7     90 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_8     91 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_9     92 	/* G_STRING in (#20) MENU */
#define WINDOW_LIST_10    93 	/* G_STRING in (#20) MENU */
#define CONFIG_GENERALE   96 	/* G_STRING in (#20) MENU */
#define CONFIG_DSK        97 	/* G_STRING in (#20) MENU */
#define RACCOURCIS_CLAVI  98 	/* G_STRING in (#20) MENU */
#define DONNEES_ZORG     100 	/* G_STRING in (#20) MENU */
#define DONNEES_SYSTEME  101 	/* G_STRING in (#20) MENU */
#define INVALIDE_CACHE   102 	/* G_STRING in (#20) MENU */
#define UPDATE_SYSTEME   103 	/* G_STRING in (#20) MENU */
#define VISU_TEXTE       105 	/* G_STRING in (#20) MENU */
#define VISU_ASCII       106 	/* G_STRING in (#20) MENU */
#define VISU_HEXA        107 	/* G_STRING in (#20) MENU */
#define AFFICHE_DECIMAL  108 	/* G_STRING in (#20) MENU */
#define FICHIER_ASSOCIE  109 	/* G_STRING in (#20) MENU */
#define CURSEUR_VISIBLE  110 	/* G_STRING in (#20) MENU */
#define CLIPBOARD_GEM    111 	/* G_STRING in (#20) MENU */
#define TABLE_ASCII      113 	/* G_STRING in (#20) MENU */
#define AIDE             114 	/* G_STRING in (#20) MENU */
#define EXECUTER_PROG    116 	/* G_STRING in (#20) MENU */
#define RESET            118 	/* G_STRING in (#20) MENU */

#define DESK              21 	/* TREE - DIALOG */
#define DESK_FOND          0 	/* G_BOX in (#21) DESK */

#define COLOR_DESK        22 	/* TREE - DIALOG */

#define SLIDER            23 	/* TREE - DIALOG */
#define SLIDER_FOND        0 	/* G_BOX in (#23) SLIDER */
#define SLIDER_HAUT        1 	/* G_BOXTEXT in (#23) SLIDER */
#define SLIDER_PERE        2 	/* G_BOX in (#23) SLIDER */
#define SLIDER_FILS        3 	/* G_BOX in (#23) SLIDER */
#define SLIDER_BAS         4 	/* G_BOXTEXT in (#23) SLIDER */

#define POPUP_UNIT        24 	/* TREE - DIALOG */

#define POPUP_ACCESS      25 	/* TREE - DIALOG */

#define POPUP_GADGETS     26 	/* TREE - DIALOG */

#define POPUP_COULEURS    27 	/* TREE - DIALOG */

#define POPUP_TRAMES      28 	/* TREE - DIALOG */

#define TEXTES            29 	/* TREE - DIALOG */
#define BOOT_1             1 	/* G_STRING in (#29) TEXTES */
#define BOOT_2             2 	/* G_STRING in (#29) TEXTES */
#define BOOT_3             3 	/* G_STRING in (#29) TEXTES */
#define BOOT_4             4 	/* G_STRING in (#29) TEXTES */
#define BOOT_5             5 	/* G_STRING in (#29) TEXTES */
#define BOOT_6             6 	/* G_STRING in (#29) TEXTES */
#define BOOT_7             7 	/* G_STRING in (#29) TEXTES */
#define BOOT_8             8 	/* G_STRING in (#29) TEXTES */
#define BOOT_9             9 	/* G_STRING in (#29) TEXTES */
#define BOOT_10           10 	/* G_STRING in (#29) TEXTES */
#define BOOT_11           11 	/* G_STRING in (#29) TEXTES */
#define BOOT_12           12 	/* G_STRING in (#29) TEXTES */
#define BOOT_13           13 	/* G_STRING in (#29) TEXTES */
#define BOOT_14           14 	/* G_STRING in (#29) TEXTES */
#define BOOT_15           15 	/* G_STRING in (#29) TEXTES */
#define BOOT_16           16 	/* G_STRING in (#29) TEXTES */
#define BOOT_17           17 	/* G_STRING in (#29) TEXTES */
#define BOOT_18           18 	/* G_STRING in (#29) TEXTES */
#define BOOT_19           19 	/* G_STRING in (#29) TEXTES */
#define BOOT_20           20 	/* G_STRING in (#29) TEXTES */
#define BOOT_21           21 	/* G_STRING in (#29) TEXTES */
#define BOOT_22           22 	/* G_STRING in (#29) TEXTES */
#define BOOT_23           23 	/* G_STRING in (#29) TEXTES */
#define BOOT_24           24 	/* G_STRING in (#29) TEXTES */
#define BOOT_25           25 	/* G_STRING in (#29) TEXTES */
#define BOOT_26           26 	/* G_STRING in (#29) TEXTES */
#define BOOT_27           27 	/* G_STRING in (#29) TEXTES */
#define BOOT_28           28 	/* G_STRING in (#29) TEXTES */
#define BOOT_29           29 	/* G_STRING in (#29) TEXTES */
#define BOOT_30           30 	/* G_STRING in (#29) TEXTES */
#define BOOT_31           31 	/* G_STRING in (#29) TEXTES */
#define BOOT_32           32 	/* G_STRING in (#29) TEXTES */
#define BRUT_1            33 	/* G_STRING in (#29) TEXTES */
#define BRUT_3            34 	/* G_STRING in (#29) TEXTES */
#define BRUT_4            35 	/* G_STRING in (#29) TEXTES */
#define BRUT_5            36 	/* G_STRING in (#29) TEXTES */
#define BRUT_6            37 	/* G_STRING in (#29) TEXTES */
#define BRUT_7            38 	/* G_STRING in (#29) TEXTES */
#define BRUT_9            39 	/* G_STRING in (#29) TEXTES */
#define BRUT_10           40 	/* G_STRING in (#29) TEXTES */
#define BRUT_11           41 	/* G_STRING in (#29) TEXTES */
#define BRUT_12           42 	/* G_STRING in (#29) TEXTES */
#define CONFIG_1          43 	/* G_STRING in (#29) TEXTES */
#define CONFIG_2          44 	/* G_STRING in (#29) TEXTES */
#define CONFIG_3          45 	/* G_STRING in (#29) TEXTES */
#define CONFIG_4          46 	/* G_STRING in (#29) TEXTES */
#define CONFIG_5          47 	/* G_STRING in (#29) TEXTES */
#define CONFIG_7          48 	/* G_STRING in (#29) TEXTES */
#define CONFIG_8          49 	/* G_STRING in (#29) TEXTES */
#define CURSEUR_1         50 	/* G_STRING in (#29) TEXTES */
#define CURSEUR_2         51 	/* G_STRING in (#29) TEXTES */
#define CURSEUR_3         52 	/* G_STRING in (#29) TEXTES */
#define CURSEUR_4         53 	/* G_STRING in (#29) TEXTES */
#define DEPLACE_1         54 	/* G_STRING in (#29) TEXTES */
#define DIALOG_1          55 	/* G_STRING in (#29) TEXTES */
#define DIALOG_2          56 	/* G_STRING in (#29) TEXTES */
#define DIALOG_3          57 	/* G_STRING in (#29) TEXTES */
#define DIALOG_4          58 	/* G_STRING in (#29) TEXTES */
#define DIALOG_5          59 	/* G_STRING in (#29) TEXTES */
#define DIALOG_6          60 	/* G_STRING in (#29) TEXTES */
#define DIALOG_7          61 	/* G_STRING in (#29) TEXTES */
#define DIALOG_8          62 	/* G_STRING in (#29) TEXTES */
#define DIALOG_9          63 	/* G_STRING in (#29) TEXTES */
#define DIALOG_10         64 	/* G_STRING in (#29) TEXTES */
#define DIALOG_11         65 	/* G_STRING in (#29) TEXTES */
#define DIALOG_12         66 	/* G_STRING in (#29) TEXTES */
#define DIALOG_13         67 	/* G_STRING in (#29) TEXTES */
#define DIALOG_14         68 	/* G_STRING in (#29) TEXTES */
#define DIALOG_15         69 	/* G_STRING in (#29) TEXTES */
#define DIALOG_16         70 	/* G_STRING in (#29) TEXTES */
#define DIALOG_17         71 	/* G_STRING in (#29) TEXTES */
#define DIALOG_18         72 	/* G_STRING in (#29) TEXTES */
#define DIALOG_19         73 	/* G_STRING in (#29) TEXTES */
#define DIALOG_20         74 	/* G_STRING in (#29) TEXTES */
#define DIALOG_21         75 	/* G_STRING in (#29) TEXTES */
#define DIALOG_22         76 	/* G_STRING in (#29) TEXTES */
#define DIALOG_23         77 	/* G_STRING in (#29) TEXTES */
#define DIALOG_24         78 	/* G_STRING in (#29) TEXTES */
#define DIALOG_25         79 	/* G_STRING in (#29) TEXTES */
#define DIALOG_26         80 	/* G_STRING in (#29) TEXTES */
#define DIALOG_27         81 	/* G_STRING in (#29) TEXTES */
#define DIALOG_28         82 	/* G_STRING in (#29) TEXTES */
#define DIALOG_29         83 	/* G_STRING in (#29) TEXTES */
#define DIALOG_30         84 	/* G_STRING in (#29) TEXTES */
#define DIALOG_31         85 	/* G_STRING in (#29) TEXTES */
#define DIALOG_32         86 	/* G_STRING in (#29) TEXTES */
#define DIALOG_33         87 	/* G_STRING in (#29) TEXTES */
#define DIALOG_34         88 	/* G_STRING in (#29) TEXTES */
#define DIALOG_35         89 	/* G_STRING in (#29) TEXTES */
#define DIALOG_36         90 	/* G_STRING in (#29) TEXTES */
#define DIALOG_37         91 	/* G_STRING in (#29) TEXTES */
#define DIALOG_39         92 	/* G_STRING in (#29) TEXTES */
#define DIALOG_40         93 	/* G_STRING in (#29) TEXTES */
#define DIALOG_41         94 	/* G_STRING in (#29) TEXTES */
#define DIALOG_42         95 	/* G_STRING in (#29) TEXTES */
#define DIALOG_43         96 	/* G_STRING in (#29) TEXTES */
#define DIALOG_44         97 	/* G_STRING in (#29) TEXTES */
#define DIALOG_45         98 	/* G_STRING in (#29) TEXTES */
#define DIALOG_46         99 	/* G_STRING in (#29) TEXTES */
#define DIALOG_47        100 	/* G_STRING in (#29) TEXTES */
#define DIALOG_48        101 	/* G_STRING in (#29) TEXTES */
#define DIALOG_96        102 	/* G_STRING in (#29) TEXTES */
#define DIALOG_97        103 	/* G_STRING in (#29) TEXTES */
#define DIALOG_98        104 	/* G_STRING in (#29) TEXTES */
#define DIALOG_99        105 	/* G_STRING in (#29) TEXTES */
#define FAT_1            106 	/* G_STRING in (#29) TEXTES */
#define FAT_2            107 	/* G_STRING in (#29) TEXTES */
#define FAT_3            108 	/* G_STRING in (#29) TEXTES */
#define FAT_4            109 	/* G_STRING in (#29) TEXTES */
#define FAT_5            110 	/* G_STRING in (#29) TEXTES */
#define FAT_6            111 	/* G_STRING in (#29) TEXTES */
#define FAT_7            112 	/* G_STRING in (#29) TEXTES */
#define FAT_8            113 	/* G_STRING in (#29) TEXTES */
#define FAT_9            114 	/* G_STRING in (#29) TEXTES */
#define FAT_10           115 	/* G_STRING in (#29) TEXTES */
#define FAT_11           116 	/* G_STRING in (#29) TEXTES */
#define FENETRE_1        117 	/* G_STRING in (#29) TEXTES */
#define FENETRE_2        118 	/* G_STRING in (#29) TEXTES */
#define FENETRE_3        119 	/* G_STRING in (#29) TEXTES */
#define FENETRE_4        120 	/* G_STRING in (#29) TEXTES */
#define FENETRE_5        121 	/* G_STRING in (#29) TEXTES */
#define FENETRE_6        122 	/* G_STRING in (#29) TEXTES */
#define FENETRE_7        123 	/* G_STRING in (#29) TEXTES */
#define FENETRE_8        124 	/* G_STRING in (#29) TEXTES */
#define FENETRE_11       125 	/* G_STRING in (#29) TEXTES */
#define FENETRE_12       126 	/* G_STRING in (#29) TEXTES */
#define FENETRE_13       127 	/* G_STRING in (#29) TEXTES */
#define FENETRE_14       128 	/* G_STRING in (#29) TEXTES */
#define INFO_1           129 	/* G_STRING in (#29) TEXTES */
#define INFO_2           130 	/* G_STRING in (#29) TEXTES */
#define INFO_3           131 	/* G_STRING in (#29) TEXTES */
#define INFO_4           132 	/* G_STRING in (#29) TEXTES */
#define INFO_5           133 	/* G_STRING in (#29) TEXTES */
#define INFO_6           134 	/* G_STRING in (#29) TEXTES */
#define INFO_7           135 	/* G_STRING in (#29) TEXTES */
#define INFO_8           136 	/* G_STRING in (#29) TEXTES */
#define INFO_9           137 	/* G_STRING in (#29) TEXTES */
#define INFO_10          138 	/* G_STRING in (#29) TEXTES */
#define INFO_11          139 	/* G_STRING in (#29) TEXTES */
#define INFO_12          140 	/* G_STRING in (#29) TEXTES */
#define INFO_13          141 	/* G_STRING in (#29) TEXTES */
#define INFO_14          142 	/* G_STRING in (#29) TEXTES */
#define INFO_15          143 	/* G_STRING in (#29) TEXTES */
#define INFO_16          144 	/* G_STRING in (#29) TEXTES */
#define INFO_17          145 	/* G_STRING in (#29) TEXTES */
#define INFO_18          146 	/* G_STRING in (#29) TEXTES */
#define INFO_19          147 	/* G_STRING in (#29) TEXTES */
#define INFO_20          148 	/* G_STRING in (#29) TEXTES */
#define INFO_21          149 	/* G_STRING in (#29) TEXTES */
#define INFO_22          150 	/* G_STRING in (#29) TEXTES */
#define INFO_23          151 	/* G_STRING in (#29) TEXTES */
#define INFO_24          152 	/* G_STRING in (#29) TEXTES */
#define INFO_25          153 	/* G_STRING in (#29) TEXTES */
#define INFO_26          154 	/* G_STRING in (#29) TEXTES */
#define INFO_27          155 	/* G_STRING in (#29) TEXTES */
#define INFO_28          156 	/* G_STRING in (#29) TEXTES */
#define INFO_29          157 	/* G_STRING in (#29) TEXTES */
#define INFO_30          158 	/* G_STRING in (#29) TEXTES */
#define INFO_31          159 	/* G_STRING in (#29) TEXTES */
#define INFO_32          160 	/* G_STRING in (#29) TEXTES */
#define INFO_33          161 	/* G_STRING in (#29) TEXTES */
#define INFO_34          162 	/* G_STRING in (#29) TEXTES */
#define INFO_35          163 	/* G_STRING in (#29) TEXTES */
#define INFO_36          164 	/* G_STRING in (#29) TEXTES */
#define INFO_37          165 	/* G_STRING in (#29) TEXTES */
#define INFO_38          166 	/* G_STRING in (#29) TEXTES */
#define INFO_39          167 	/* G_STRING in (#29) TEXTES */
#define INFO_40          168 	/* G_STRING in (#29) TEXTES */
#define INFO_41          169 	/* G_STRING in (#29) TEXTES */
#define INFO_42          170 	/* G_STRING in (#29) TEXTES */
#define INFO_43          171 	/* G_STRING in (#29) TEXTES */
#define INFO_44          172 	/* G_STRING in (#29) TEXTES */
#define INFO_45          173 	/* G_STRING in (#29) TEXTES */
#define INFO_46          174 	/* G_STRING in (#29) TEXTES */
#define INFO_47          175 	/* G_STRING in (#29) TEXTES */
#define INFO_48          176 	/* G_STRING in (#29) TEXTES */
#define INFO_49          177 	/* G_STRING in (#29) TEXTES */
#define INFO_50          178 	/* G_STRING in (#29) TEXTES */
#define INFO_51          179 	/* G_STRING in (#29) TEXTES */
#define INFO_52          180 	/* G_STRING in (#29) TEXTES */
#define INFO_53          181 	/* G_STRING in (#29) TEXTES */
#define INFO_54          182 	/* G_STRING in (#29) TEXTES */
#define INFO_55          183 	/* G_STRING in (#29) TEXTES */
#define INFO_56          184 	/* G_STRING in (#29) TEXTES */
#define INFO_57          185 	/* G_STRING in (#29) TEXTES */
#define INFO_58          186 	/* G_STRING in (#29) TEXTES */
#define INFO_59          187 	/* G_STRING in (#29) TEXTES */
#define INFO_60          188 	/* G_STRING in (#29) TEXTES */
#define INFO_61          189 	/* G_STRING in (#29) TEXTES */
#define INFO_62          190 	/* G_STRING in (#29) TEXTES */
#define INFO_63          191 	/* G_STRING in (#29) TEXTES */
#define INFO_64          192 	/* G_STRING in (#29) TEXTES */
#define INFO_65          193 	/* G_STRING in (#29) TEXTES */
#define INFO_66          194 	/* G_STRING in (#29) TEXTES */
#define INFO_67          195 	/* G_STRING in (#29) TEXTES */
#define INFO_68          196 	/* G_STRING in (#29) TEXTES */
#define INFO_69          197 	/* G_STRING in (#29) TEXTES */
#define INFO_70          198 	/* G_STRING in (#29) TEXTES */
#define INFO_71          199 	/* G_STRING in (#29) TEXTES */
#define INFO_72          200 	/* G_STRING in (#29) TEXTES */
#define INIT_1           201 	/* G_STRING in (#29) TEXTES */
#define INIT_2           202 	/* G_STRING in (#29) TEXTES */
#define INIT_3           203 	/* G_STRING in (#29) TEXTES */
#define LANCE_1          204 	/* G_STRING in (#29) TEXTES */
#define LANCE_2          205 	/* G_STRING in (#29) TEXTES */
#define LANCE_3          206 	/* G_STRING in (#29) TEXTES */
#define LANCE_4          207 	/* G_STRING in (#29) TEXTES */
#define MAIN_1           208 	/* G_STRING in (#29) TEXTES */
#define MAIN_2           209 	/* G_STRING in (#29) TEXTES */
#define MAIN_3           210 	/* G_STRING in (#29) TEXTES */
#define MAIN_4           211 	/* G_STRING in (#29) TEXTES */
#define MAIN_5           212 	/* G_STRING in (#29) TEXTES */
#define MAIN_6           213 	/* G_STRING in (#29) TEXTES */
#define MAIN_7           214 	/* G_STRING in (#29) TEXTES */
#define MAIN_9           215 	/* G_STRING in (#29) TEXTES */
#define MAIN_10          216 	/* G_STRING in (#29) TEXTES */
#define MENU_1           217 	/* G_STRING in (#29) TEXTES */
#define MENU_2           218 	/* G_STRING in (#29) TEXTES */
#define MENU_3           219 	/* G_STRING in (#29) TEXTES */
#define MENU_4           220 	/* G_STRING in (#29) TEXTES */
#define MENU_5           221 	/* G_STRING in (#29) TEXTES */
#define OUVRE_1          222 	/* G_STRING in (#29) TEXTES */
#define OUVRE_2          223 	/* G_STRING in (#29) TEXTES */
#define OUVRE_3          224 	/* G_STRING in (#29) TEXTES */
#define OUVRE_4          225 	/* G_STRING in (#29) TEXTES */
#define OUVRE_5          226 	/* G_STRING in (#29) TEXTES */
#define OUVRE_6          227 	/* G_STRING in (#29) TEXTES */
#define OUVRE_7          228 	/* G_STRING in (#29) TEXTES */
#define OUVRE_8          229 	/* G_STRING in (#29) TEXTES */
#define OUVRE_9          230 	/* G_STRING in (#29) TEXTES */
#define OUVRE_10         231 	/* G_STRING in (#29) TEXTES */
#define OUVRE_11         232 	/* G_STRING in (#29) TEXTES */
#define OUVRE_12         233 	/* G_STRING in (#29) TEXTES */
#define OUVRE_13         234 	/* G_STRING in (#29) TEXTES */
#define OUVRE_14         235 	/* G_STRING in (#29) TEXTES */
#define OUVRE_15         236 	/* G_STRING in (#29) TEXTES */
#define OUVRE_16         237 	/* G_STRING in (#29) TEXTES */
#define OUVRE_17         238 	/* G_STRING in (#29) TEXTES */
#define OUVRE_18         239 	/* G_STRING in (#29) TEXTES */
#define OUVRE_19         240 	/* G_STRING in (#29) TEXTES */
#define OUVRE_20         241 	/* G_STRING in (#29) TEXTES */
#define OUVRE_21         242 	/* G_STRING in (#29) TEXTES */
#define OUVRE_22         243 	/* G_STRING in (#29) TEXTES */
#define OUVRE_23         244 	/* G_STRING in (#29) TEXTES */
#define OUVRE_24         245 	/* G_STRING in (#29) TEXTES */
#define PRESENTATION_1   246 	/* G_STRING in (#29) TEXTES */
#define REORG_1          247 	/* G_STRING in (#29) TEXTES */
#define REORG_2          248 	/* G_STRING in (#29) TEXTES */
#define REORG_3          249 	/* G_STRING in (#29) TEXTES */
#define REORG_4          250 	/* G_STRING in (#29) TEXTES */
#define REORG_5          251 	/* G_STRING in (#29) TEXTES */
#define REORG_6          252 	/* G_STRING in (#29) TEXTES */
#define REORG_7          253 	/* G_STRING in (#29) TEXTES */
#define REORG_8          254 	/* G_STRING in (#29) TEXTES */
#define REORG_9          255 	/* G_STRING in (#29) TEXTES */
#define REORG_10         256 	/* G_STRING in (#29) TEXTES */
#define REORG_11         257 	/* G_STRING in (#29) TEXTES */
#define REORG_12         258 	/* G_STRING in (#29) TEXTES */
#define REORG_13         259 	/* G_STRING in (#29) TEXTES */
#define REORG_14         260 	/* G_STRING in (#29) TEXTES */
#define REORG_15         261 	/* G_STRING in (#29) TEXTES */
#define REORG_16         262 	/* G_STRING in (#29) TEXTES */
#define REORG_18         263 	/* G_STRING in (#29) TEXTES */
#define SEARCH_2         264 	/* G_STRING in (#29) TEXTES */
#define SEARCH_3         265 	/* G_STRING in (#29) TEXTES */
#define SEARCH_4         266 	/* G_STRING in (#29) TEXTES */
#define SEARCH_5         267 	/* G_STRING in (#29) TEXTES */
#define SECTEUR_1        268 	/* G_STRING in (#29) TEXTES */
#define SECTEUR_2        269 	/* G_STRING in (#29) TEXTES */
#define SECTEUR_3        270 	/* G_STRING in (#29) TEXTES */
#define SECTEUR_4        271 	/* G_STRING in (#29) TEXTES */
#define TAMPON_1         272 	/* G_STRING in (#29) TEXTES */
#define TAMPON_2         273 	/* G_STRING in (#29) TEXTES */
#define TAMPON_3         274 	/* G_STRING in (#29) TEXTES */
#define TAMPON_4         275 	/* G_STRING in (#29) TEXTES */
#define TAMPON_5         276 	/* G_STRING in (#29) TEXTES */
#define TAMPON_6         277 	/* G_STRING in (#29) TEXTES */
#define TAMPON_7         278 	/* G_STRING in (#29) TEXTES */
#define TAMPON_8         279 	/* G_STRING in (#29) TEXTES */
#define TAMPON_9         280 	/* G_STRING in (#29) TEXTES */
#define TAMPON_10        281 	/* G_STRING in (#29) TEXTES */
#define TAMPON_11        282 	/* G_STRING in (#29) TEXTES */
#define TAMPON_12        283 	/* G_STRING in (#29) TEXTES */
#define TAMPON_13        284 	/* G_STRING in (#29) TEXTES */
#define TAMPON_14        285 	/* G_STRING in (#29) TEXTES */
#define TAMPON_15        286 	/* G_STRING in (#29) TEXTES */
#define TAMPON_16        287 	/* G_STRING in (#29) TEXTES */
#define TAMPON_17        288 	/* G_STRING in (#29) TEXTES */
