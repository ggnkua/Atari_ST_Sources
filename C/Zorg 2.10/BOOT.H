/* boot.c */
void	lire_boot( void );
void	info_boot( void );
void	ecrire_boot( void );
void	charger_boot( void );
void	sauver_boot( void );
