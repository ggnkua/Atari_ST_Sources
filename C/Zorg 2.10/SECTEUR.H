/* secteur.c */
void	affichage_decimal( windowptr thewin );
void	secteur_ascii( windowptr thewin );
void	secteur_hexa( windowptr thewin );
void	load_secteur( windowptr thewin, int menu );
void	save_secteur( windowptr thewin, int menu );
int		read_secteur( windowptr thewin, int menu );
int		write_secteur( windowptr thewin, int menu );
