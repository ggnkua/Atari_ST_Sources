/* update.c */
void	occupationproc( int first, WIN *thewin, GRECT *clip );
void	secteurproc( int first, WIN *thewin, GRECT *clip );
void	textproc( int first, WIN *thewin, GRECT *clip );
void	redraw_slide( windowptr thewin, GRECT *clip );
void	aff_text( windowptr thewin, GRECT *clip );
