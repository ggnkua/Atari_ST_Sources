/* desk.c */
void	read_desktop( void );
void	do_desk( int mousex, int mousey , int double_clic, int key );
void	init_desk( boolean mode );
void	redraw_desk( void );
