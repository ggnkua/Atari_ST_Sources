/* Resource Datei Indizes f�r DEMOICON */

#define TEST     0   /* Formular/Dialog */
#define ICONBACK 0   /* BOX in Baum TEST */
#define ICON     1   /* ICON in Baum TEST */
