/* Resource Datei Indizes f�r CDREC */

#define MAIN     0   /* Formular/Dialog */
#define TITEL    1   /* STRING in Baum MAIN */
#define TYPEMCD  2   /* TEXT in Baum MAIN */
#define TYPEDCD  3   /* TEXT in Baum MAIN */
#define TYPEACD  4   /* TEXT in Baum MAIN */
#define UNDERLINE 5   /* IBOX in Baum MAIN */
#define TRACK01  7   /* BUTTON in Baum MAIN */
#define TRACK02  8   /* BUTTON in Baum MAIN */
#define TRACK03  9   /* BUTTON in Baum MAIN */
#define TRACK04  10  /* BUTTON in Baum MAIN */
#define TRACK05  11  /* BUTTON in Baum MAIN */
#define TRACK06  12  /* BUTTON in Baum MAIN */
#define TRACK07  13  /* BUTTON in Baum MAIN */
#define TRACK08  14  /* BUTTON in Baum MAIN */
#define TRACK09  15  /* BUTTON in Baum MAIN */
#define TRACK10  16  /* BUTTON in Baum MAIN */
#define TRACK11  17  /* BUTTON in Baum MAIN */
#define TRACK12  18  /* BUTTON in Baum MAIN */
#define TRACK13  19  /* BUTTON in Baum MAIN */
#define TRACK14  20  /* BUTTON in Baum MAIN */
#define TRACK15  21  /* BUTTON in Baum MAIN */
#define TRACK16  22  /* BUTTON in Baum MAIN */
#define TRACK17  23  /* BUTTON in Baum MAIN */
#define TRACK18  24  /* BUTTON in Baum MAIN */
#define TRACK19  25  /* BUTTON in Baum MAIN */
#define TRACK20  26  /* BUTTON in Baum MAIN */
#define TRACK21  27  /* BUTTON in Baum MAIN */
#define TRACK22  28  /* BUTTON in Baum MAIN */
#define TRACK23  29  /* BUTTON in Baum MAIN */
#define TRACK24  30  /* BUTTON in Baum MAIN */
#define TRACK25  31  /* BUTTON in Baum MAIN */
#define TRACK26  32  /* BUTTON in Baum MAIN */
#define TRACK27  33  /* BUTTON in Baum MAIN */
#define TRACK28  34  /* BUTTON in Baum MAIN */
#define TRACK29  35  /* BUTTON in Baum MAIN */
#define TRACK30  36  /* BUTTON in Baum MAIN */
#define TRACK31  37  /* BUTTON in Baum MAIN */
#define TRACK32  38  /* BUTTON in Baum MAIN */
#define TRACK33  39  /* BUTTON in Baum MAIN */
#define TRACK34  40  /* BUTTON in Baum MAIN */
#define TRACK35  41  /* BUTTON in Baum MAIN */
#define TRACK36  42  /* BUTTON in Baum MAIN */
#define TRACK37  43  /* BUTTON in Baum MAIN */
#define TRACK38  44  /* BUTTON in Baum MAIN */
#define TRACK39  45  /* BUTTON in Baum MAIN */
#define TRACK40  46  /* BUTTON in Baum MAIN */
#define TRACK41  47  /* BUTTON in Baum MAIN */
#define TRACK42  48  /* BUTTON in Baum MAIN */
#define TRACK43  49  /* BUTTON in Baum MAIN */
#define TRACK44  50  /* BUTTON in Baum MAIN */
#define TRACK45  51  /* BUTTON in Baum MAIN */
#define TRACK46  52  /* BUTTON in Baum MAIN */
#define TRACK47  53  /* BUTTON in Baum MAIN */
#define TRACK48  54  /* BUTTON in Baum MAIN */
#define SAVEAVR  56  /* BUTTON in Baum MAIN */
#define SAVEWAV  57  /* BUTTON in Baum MAIN */
#define STEREO   59  /* BUTTON in Baum MAIN */
#define MONO     60  /* BUTTON in Baum MAIN */
#define EIGHT    62  /* BUTTON in Baum MAIN */
#define SIXTEEN  63  /* BUTTON in Baum MAIN */
#define HALFFREQ 65  /* BOXCHAR in Baum MAIN */
#define PLYSTART 66  /* BOXCHAR in Baum MAIN */
#define EDSTART  67  /* FTEXT in Baum MAIN */
#define TAKEST   68  /* BOXCHAR in Baum MAIN */
#define CURPOS   69  /* FTEXT in Baum MAIN */
#define PLYEND   70  /* BOXCHAR in Baum MAIN */
#define EDEND    71  /* FTEXT in Baum MAIN */
#define TAKEEN   72  /* BOXCHAR in Baum MAIN */
#define STOPIT   73  /* BUTTON in Baum MAIN */
#define RECSIZE  74  /* FTEXT in Baum MAIN */
#define DHCOPY   75  /* TEXT in Baum MAIN */
#define COUNTER  76  /* BOXTEXT in Baum MAIN */
#define CDSAVE   77  /* BUTTON in Baum MAIN */
#define CDCANCEL 78  /* BUTTON in Baum MAIN */
