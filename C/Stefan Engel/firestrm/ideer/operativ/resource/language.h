#define Andorra                     "AD\0"
#define United_Arab_Emirates        "AE\0"
#define Afghanistan                 "AF\0"
#define Antigua_and_Barbuda         "AG\0"
#define Anguilla                    "AI\0"
#define Albania                     "AL\0"
#define Armenia                     "AM\0"
#define Netherlands_Antilles        "AN\0"
#define Angola                      "AO\0"
#define Antarctica                  "AQ\0"
#define Argentina                   "AR\0"
#define American_Samoa              "AS\0"
#define Austria                     "AT\0"
#define Australia                   "AU\0"
#define Aruba                       "AW\0"
#define Azerbaijan                  "AZ\0"
#define Bosnia_and_Herzegovina      "BA\0"
#define Barbados                    "BB\0"
#define Bangladesh                  "BD\0"
#define Belgium                     "BE\0"
#define Burkina_Faso                "BF\0"
#define Bulgaria                    "BG\0"
#define Bahrain                     "BH\0"
#define Burundi                     "BI\0"
#define Benin                       "BJ\0"
#define Bermuda                     "BM\0"
#define Brunei_Darussalam           "BN\0"
#define Bolivia                     "BO\0"
#define Brazil                      "BR\0"
#define Bahamas                     "BS\0"
#define Bhutan                      "BT\0"
#define Bouvet_Island               "BV\0"
#define Botswana                    "BW\0"
#define Belarus                     "BY\0"
#define Belize                      "BZ\0"
#define Canada                      "CA\0"
#define Cocos_Islands               "CC\0"
#define Central_African_Republic    "CF\0"
#define Congo                       "CG\0"
#define Switzerland                 "CH\0"
#define Cote_DIvoire                "CI\0"
#define Cook_Islands                "CK\0"
#define Chile                       "CL\0"
#define Cameroon                    "CM\0"
#define China                       "CN\0"
#define Colombia                    "CO\0"
#define Costa Rica                  "CR\0"
#define Czechoslovakia              "CS\0"
#define Cuba                        "CU\0"
#define Cape_Verde                  "CV\0"
#define Christmas_Island            "CX\0"
#define Cyprus                      "CY\0"
#define Czech_Republic              "CZ\0"
#define Germany                     "DE\0"
#define Djibouti                    "DJ\0"
#define Denmark                     "DK\0"
#define Dominica                    "DM\0"
#define Dominican_Republic          "DO\0"
#define Algeria                     "DZ\0"
#define Ecuador                     "EC\0"
#define Estonia                     "EE\0"
#define Egypt                       "EG\0"
#define Western_Sahara              "EH\0"
#define Eritrea                     "ER\0"
#define Spain                       "ES\0"
#define Ethiopia                    "ET\0"
#define Finland                     "FI\0"
#define Fiji                        "FJ\0"
#define Falkland_Islands            "FK\0"
#define Micronesia                  "FM\0"
#define Faroe_Islands               "FO\0"
#define France                      "FR\0"
#define France_Metropolitan         "FX\0"
#define Gabon                       "GA\0"
#define Great_Britain               "GB\0"
#define Grenada                     "GD\0"
#define Georgia                     "GE\0"
#define French_Guiana               "GF\0"
#define Ghana                       "GH\0"
#define Gibraltar                   "GI\0"
#define Greenland                   "GL\0"
#define Gambia                      "GM\0"
#define Guinea                      "GN\0"
#define Guadeloupe                  "GP\0"
#define Equatorial_Guinea           "GQ\0"
#define Greece                      "GR\0"
#define S_Georgia_and_S_Sandwich_Islands "GS\0"
#define Guatemala                   "GT\0"
#define Guam                        "GU\0"
#define Guinea_Bissau               "GW\0"
#define Guyana                      "GY\0"
#define Hong_Kong                   "HK\0"
#define Heard_and_McDonald_Islands  "HM\0"
#define Honduras                    "HN\0"
#define Croatia                     "HR\0"
#define Haiti                       "HT\0"
#define Hungary                     "HU\0"
#define Indonesia                   "ID\0"
#define Ireland                     "IE\0"
#define Israel                      "IL\0"
#define India                       "IN\0"
#define Br_Indian_Ocean_Terr        "IO\0"
#define Iraq                        "IQ\0"
#define Iran                        "IR\0"
#define Iceland                     "IS\0"
#define Italy                       "IT\0"
#define Jamaica                     "JM\0"
#define Jordan                      "JO\0"
#define Japan                       "JP\0"
#define Kenya                       "KE\0"
#define Kyrgyzstan                  "KG\0"
#define Cambodia                    "KH\0"
#define Kiribati                    "KI\0"
#define Comoros                     "KM\0"
#define Saint_Kitts_and Nevis       "KN\0"
#define Korea_North                 "KP\0"
#define Korea_South                 "KR\0"
#define Kuwait                      "KW\0"
#define Cayman_Islands              "KY\0"
#define Kazakhstan                  "KZ\0"
#define Laos                        "LA\0"
#define Lebanon                     "LB\0"
#define Saint_Lucia                 "LC\0"
#define Liechtenstein               "LI\0"
#define Sri_Lanka                   "LK\0"
#define Liberia                     "LR\0"
#define Lesotho                     "LS\0"
#define Lithuania                   "LT\0"
#define Luxembourg                  "LU\0"
#define Latvia                      "LV\0"
#define Libya                       "LY\0"
#define Morocco                     "MA\0"
#define Monaco                      "MC\0"
#define Moldova                     "MD\0"
#define Madagascar                  "MG\0"
#define Marshall_Islands            "MH\0"
#define Macedonia                   "MK\0"
#define Mali                        "ML\0"
#define Myanmar                     "MM\0"
#define Mongolia                    "MN\0"
#define Macau                       "MO\0"
#define Northern_Mariana_Islands    "MP\0"
#define Martinique                  "MQ\0"
#define Mauritania                  "MR\0"
#define Montserrat                  "MS\0"
#define Malta                       "MT\0"
#define Mauritius                   "MU\0"
#define Maldives                    "MV\0"
#define Malawi                      "MW\0"
#define Mexico                      "MX\0"
#define Malaysia                    "MY\0"
#define Mozambique                  "MZ\0"
#define Namibia                     "NA\0"
#define New_Caledonia               "NC\0"
#define Niger                       "NE\0"
#define Norfolk_Island              "NF\0"
#define Nigeria                     "NG\0"
#define Nicaragua                   "NI\0"
#define Netherlands                 "NL\0"
#define Norway                      "NO\0"
#define Nepal                       "NP\0"
#define Nauru                       "NR\0"
#define Neutral_Zone                "NT\0"
#define Niue                        "NU\0"
#define New_Zealand_Aotearoa        "NZ\0"
#define Oman                        "OM\0"
#define Panama                      "PA\0"
#define Peru                        "PE\0"
#define French_Polynesia            "PF\0"
#define Papua_New_Guinea            "PG\0"
#define Philippines                 "PH\0"
#define Pakistan                    "PK\0"
#define Poland                      "PL\0"
#define St_Pierre_and_Miquelon      "PM\0"
#define Pitcairn                    "PN\0"
#define Puerto Rico                 "PR\0"
#define Portugal                    "PT\0"
#define Palau                       "PW\0"
#define Paraguay                    "PY\0"
#define Qatar                       "QA\0"
#define Reunion                     "RE\0"
#define Romania                     "RO\0"
#define Russian_Federation          "RU\0"
#define Rwanda                      "RW\0"
#define Saudi_Arabia                "SA\0"
#define Solomon_Islands             "SB\0"
#define Seychelles                  "SC\0"
#define Sudan                       "SD\0"
#define Sweden                      "SE\0"
#define Singapore                   "SG\0"
#define St_Helena                   "SH\0"
#define Slovenia                    "SI\0"
#define Svalbard_and_Jan_Mayen_Islan"SJ\0"   ds
#define Slovak_Republic             "SK\0"
#define Sierra_Leone                "SL\0"
#define San_Marino                  "SM\0"
#define Senegal                     "SN\0"
#define Somalia                     "SO\0"
#define Suriname                    "SR\0"
#define Sao_Tome_and_Principe       "ST\0"
#define USSR_former                 "SU\0"
#define El Salvador                 "SV\0"
#define Syria                       "SY\0"
#define Swaziland                   "SZ\0"
#define Turks_and_Caicos_Islands    "TC\0"
#define Chad                        "TD\0"
#define French_Southern_Territories "TF\0"
#define Togo                        "TG\0"
#define Thailand                    "TH\0"
#define Tajikistan                  "TJ\0"
#define Tokelau                     "TK\0"
#define Turkmenistan                "TM\0"
#define Tunisia                     "TN\0"
#define Tonga                       "TO\0"
#define East_Timor                  "TP\0"
#define Turkey                      "TR\0"
#define Trinidad_and_Tobago         "TT\0"
#define Tuvalu                      "TV\0"
#define Taiwan                      "TW\0"
#define Tanzania                    "TZ\0"
#define Ukraine                     "UA\0"
#define Uganda                      "UG\0"
#define United_Kingdom              "UK\0"
#define US_Minor_Outlying_Islands   "UM\0"
#define United States               "US\0"
#define Uruguay                     "UY\0"
#define Uzbekistan                  "UZ\0"
#define Vatican_City_State_Holy_See "VA\0"
#define Saint_Vincent_and_the_Grenadines "VC\0"
#define Venezuela                   "VE\0"
#define Virgin_Islands_British      "VG\0"
#define Virgin_Islands_US           "VI\0"
#define Viet_Nam                    "VN\0"
#define Vanuatu                     "VU\0"
#define Wallis_and_Futuna_Islands   "WF\0"
#define Samoa                       "WS\0"
#define Yemen                       "YE\0"
#define Mayotte                     "YT\0"
#define Yugoslavia                  "YU\0"
#define South_Africa                "ZA\0"
#define Zambia                      "ZM\0"
#define Zaire                       "ZR\0"
#define Zimbabwe                    "ZW\0"
