 /*  Resource C-Header-File v1.97 f�r ResourceMaster ab v2.06 by ARDISOFT  */

#define MAINMENU 0  /* menu */
#define MACC 3  /* TITLE in tree MAINMENU */
#define MFILE 4  /* TITLE in tree MAINMENU */
#define MABOUT 7  /* STRING in tree MAINMENU */
#define MNEXTWIN 16  /* STRING in tree MAINMENU */
#define MQUIT 18  /* STRING in tree MAINMENU */

#define ABOUT 1  /* form/dial */
#define ABLOGOHI 2  /* IMAGE in tree ABOUT */
#define ABLOGOLO 3  /* IMAGE in tree ABOUT */
#define ABVER 4  /* TEXT in tree ABOUT */
#define ABHELP 5  /* BUTTON in tree ABOUT */
#define ABOK 6  /* BUTTON in tree ABOUT */

#define FIND 2  /* form/dial */
#define FGENERAL 2  /* BUTTON in tree FIND */
#define FATTR 3  /* BUTTON in tree FIND */
#define FSUB 5  /* IBOX in tree FIND */
#define FSATTR 6  /* BOX in tree FIND */
#define FTIME 7  /* BUTTON in tree FIND */
#define FFROMDATE 9  /* FBOXTEXT in tree FIND */
#define FTODATE 11  /* FBOXTEXT in tree FIND */
#define FSIZE 12  /* BUTTON in tree FIND */
#define FFROMSIZE 14  /* FBOXTEXT in tree FIND */
#define FTOSIZE 16  /* FBOXTEXT in tree FIND */
#define FCONTENTS 18  /* BUTTON in tree FIND */
#define FCMASK 19  /* FBOXTEXT in tree FIND */
#define FCCASE 20  /* BUTTON in tree FIND */
#define FCBINARY 21  /* BUTTON in tree FIND */
#define FSGENERAL 22  /* BOX in tree FIND */
#define FON 24  /* BUTTON in tree FIND */
#define FDRIVES 26  /* FBOXTEXT in tree FIND */
#define FIN 27  /* BUTTON in tree FIND */
#define FPATHS 28  /* BUTTON in tree FIND */
#define FPATH 29  /* TEXT in tree FIND */
#define FFMASK 31  /* FBOXTEXT in tree FIND */
#define FFCASE 32  /* BUTTON in tree FIND */
#define FDIRS 33  /* BUTTON in tree FIND */
#define FFOLLOW 34  /* BUTTON in tree FIND */
#define FVERBOSE 35  /* BUTTON in tree FIND */
#define FGOBOX 36  /* BOXTEXT in tree FIND */
#define FGO 37  /* BUTTON in tree FIND */
#define FHELP 38  /* BUTTON in tree FIND */
#define FCANCEL 39  /* BUTTON in tree FIND */

#define STATUS 3  /* form/dial */
#define SHITS 3  /* TEXT in tree STATUS */
#define SCBOX 4  /* IBOX in tree STATUS */
#define SCURRENT 6  /* TEXT in tree STATUS */
#define SHELP 7  /* BUTTON in tree STATUS */
#define SCANCEL 8  /* BUTTON in tree STATUS */

#define ICONWIN 4  /* form/dial */

#define ICONDIAL 5  /* form/dial */

#define ICONGRP 6  /* form/dial */

#define ALNOGUIDE 0  /* Alert string */

#define ALNOMEM 1  /* Alert string */

#define ALNOSHUT 2  /* Alert string */

#define ALWDIAL 3  /* Alert string */

#define ALNOWDIAL 4  /* Alert string */

#define ALNOTEMPLATE 5  /* Alert string */

#define ALDRVFORMAT 6  /* Alert string */

#define ALFROMDATE 7  /* Alert string */

#define ALTODATE 8  /* Alert string */

#define ALFROMSIZE 9  /* Alert string */

#define ALTOSIZE 10  /* Alert string */

#define ALDATEORDER 11  /* Alert string */

#define ALSIZEORDER 12  /* Alert string */

#define ALEMPTYCMASK 13  /* Alert string */

#define ALFAILURE 14  /* Alert string */

#define ALNOTHING 15  /* Alert string */

#define TXCHOOSEPATH 16  /* Free string */
