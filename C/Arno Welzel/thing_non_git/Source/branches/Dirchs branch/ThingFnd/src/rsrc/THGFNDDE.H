/* Resource Datei Indizes f�r THGFNDDE */

#define MAINMENU         0   /* Menuebaum */
#define MACC             3   /* TITLE in Baum MAINMENU */
#define MFILE            4   /* TITLE in Baum MAINMENU */
#define MABOUT           7   /* STRING in Baum MAINMENU */
#define MNEXTWIN         16  /* STRING in Baum MAINMENU */
#define MQUIT            18  /* STRING in Baum MAINMENU */

#define ABOUT            1   /* Formular/Dialog */
#define ABLOGOHI         2   /* IMAGE in Baum ABOUT */
#define ABLOGOLO         3   /* IMAGE in Baum ABOUT */
#define ABVER            4   /* TEXT in Baum ABOUT */
#define ABHELP           5   /* BUTTON in Baum ABOUT */
#define ABOK             6   /* BUTTON in Baum ABOUT */

#define FIND             2   /* Formular/Dialog */
#define FGENERAL         2   /* BUTTON in Baum FIND */
#define FATTR            3   /* BUTTON in Baum FIND */
#define FSUB             5   /* IBOX in Baum FIND */
#define FSATTR           6   /* BOX in Baum FIND */
#define FTIME            7   /* BUTTON in Baum FIND */
#define FFROMDATE        9   /* FBOXTEXT in Baum FIND */
#define FTODATE          11  /* FBOXTEXT in Baum FIND */
#define FSIZE            12  /* BUTTON in Baum FIND */
#define FFROMSIZE        14  /* FBOXTEXT in Baum FIND */
#define FTOSIZE          16  /* FBOXTEXT in Baum FIND */
#define FCONTENTS        18  /* BUTTON in Baum FIND */
#define FCMASK           19  /* FBOXTEXT in Baum FIND */
#define FCCASE           20  /* BUTTON in Baum FIND */
#define FCBINARY         21  /* BUTTON in Baum FIND */
#define FSGENERAL        22  /* BOX in Baum FIND */
#define FON              24  /* BUTTON in Baum FIND */
#define FDRIVES          26  /* FBOXTEXT in Baum FIND */
#define FIN              27  /* BUTTON in Baum FIND */
#define FPATHS           28  /* BUTTON in Baum FIND */
#define FPATH            29  /* TEXT in Baum FIND */
#define FFMASK           31  /* FBOXTEXT in Baum FIND */
#define FFCASE           32  /* BUTTON in Baum FIND */
#define FDIRS            33  /* BUTTON in Baum FIND */
#define FFOLLOW          34  /* BUTTON in Baum FIND */
#define FVERBOSE         35  /* BUTTON in Baum FIND */
#define FGOBOX           36  /* BOXTEXT in Baum FIND */
#define FGO              37  /* BUTTON in Baum FIND */
#define FHELP            38  /* BUTTON in Baum FIND */
#define FCANCEL          39  /* BUTTON in Baum FIND */

#define STATUS           3   /* Formular/Dialog */
#define SHITS            3   /* TEXT in Baum STATUS */
#define SCBOX            4   /* IBOX in Baum STATUS */
#define SCURRENT         6   /* TEXT in Baum STATUS */
#define SHELP            7   /* BUTTON in Baum STATUS */
#define SCANCEL          8   /* BUTTON in Baum STATUS */

#define ICONWIN          4   /* Formular/Dialog */

#define ICONDIAL         5   /* Formular/Dialog */

#define ICONGRP          6   /* Formular/Dialog */

#define ALNOGUIDE        0   /* Alert String */

#define ALNOMEM          1   /* Alert String */

#define ALNOSHUT         2   /* Alert String */

#define ALWDIAL          3   /* Alert String */

#define ALNOWDIAL        4   /* Alert String */

#define ALNOTEMPLATE     5   /* Alert String */

#define ALDRVFORMAT      6   /* Alert String */

#define ALFROMDATE       7   /* Alert String */

#define ALTODATE         8   /* Alert String */

#define ALFROMSIZE       9   /* Alert String */

#define ALTOSIZE         10  /* Alert String */

#define ALDATEORDER      11  /* Alert String */

#define ALSIZEORDER      12  /* Alert String */

#define ALEMPTYCMASK     13  /* Alert String */

#define ALFAILURE        14  /* Alert String */

#define ALNOTHING        15  /* Alert String */

#define TXCHOOSEPATH     16  /* Freier String */
