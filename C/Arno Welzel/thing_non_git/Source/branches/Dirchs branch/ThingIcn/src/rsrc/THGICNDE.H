/* Resource Datei Indizes f�r THGICNDE */

#define MAINMENU         0   /* Menuebaum */
#define MACC             3   /* TITLE in Baum MAINMENU */
#define MFILE            4   /* TITLE in Baum MAINMENU */
#define MEDIT            5   /* TITLE in Baum MAINMENU */
#define MABOUT           8   /* STRING in Baum MAINMENU */
#define MSAVE            17  /* STRING in Baum MAINMENU */
#define MREVERT          18  /* STRING in Baum MAINMENU */
#define MNEXTWIN         20  /* STRING in Baum MAINMENU */
#define MQUIT            22  /* STRING in Baum MAINMENU */
#define MEDITICON        24  /* STRING in Baum MAINMENU */
#define MFINDFILE        26  /* STRING in Baum MAINMENU */
#define MFINDICON        27  /* STRING in Baum MAINMENU */

#define ABOUT            1   /* Formular/Dialog */
#define ABLOGOHI         2   /* IMAGE in Baum ABOUT */
#define ABLOGOLO         3   /* IMAGE in Baum ABOUT */
#define ABVER            8   /* TEXT in Baum ABOUT */
#define ABHELP           9   /* BUTTON in Baum ABOUT */
#define ABOK             10  /* BUTTON in Baum ABOUT */

#define ASEDIT           2   /* Formular/Dialog */
#define AENAME           3   /* STRING in Baum ASEDIT */
#define AEREM            5   /* STRING in Baum ASEDIT */
#define AELIST           6   /* BOX in Baum ASEDIT */
#define AEUP             14  /* BUTTON in Baum ASEDIT */
#define AEICONBACK       15  /* BOX in Baum ASEDIT */
#define AEICON           16  /* ICON in Baum ASEDIT */
#define AEBOX            17  /* BOX in Baum ASEDIT */
#define AESLIDE          18  /* BUTTON in Baum ASEDIT */
#define AEDOWN           19  /* BUTTON in Baum ASEDIT */
#define AEINFOBOX        20  /* IBOX in Baum ASEDIT */
#define AEFILE           22  /* BUTTON in Baum ASEDIT */
#define AEFOLDER         23  /* BUTTON in Baum ASEDIT */
#define AEDRIVE          24  /* BUTTON in Baum ASEDIT */
#define AEWILD           26  /* FBOXTEXT in Baum ASEDIT */
#define FOFCOLS          27  /* STRING in Baum ASEDIT */
#define FOFCOL           29  /* IBOX in Baum ASEDIT */
#define AECHAR           31  /* FBOXTEXT in Baum ASEDIT */
#define AECHANGE         32  /* BUTTON in Baum ASEDIT */
#define AEDELETE         33  /* BUTTON in Baum ASEDIT */
#define AEHELP           34  /* BUTTON in Baum ASEDIT */
#define AEOK             35  /* BUTTON in Baum ASEDIT */
#define AECANCEL         36  /* BUTTON in Baum ASEDIT */

#define FIND             3   /* Formular/Dialog */
#define FITITLE          1   /* STRING in Baum FIND */
#define FITEXT           2   /* FBOXTEXT in Baum FIND */
#define FILIST           3   /* BOX in Baum FIND */
#define FIUP             14  /* BUTTON in Baum FIND */
#define FIBOX            15  /* BOX in Baum FIND */
#define FISLIDE          16  /* BUTTON in Baum FIND */
#define FIDOWN           17  /* BUTTON in Baum FIND */
#define FIHELP           18  /* BUTTON in Baum FIND */
#define FIOK             19  /* BUTTON in Baum FIND */
#define FICANCEL         20  /* BUTTON in Baum FIND */

#define POPCOLOR         4   /* Formular/Dialog */

#define ICONWIN          5   /* Formular/Dialog */

#define ICONDIAL         6   /* Formular/Dialog */

#define ICONGRP          7   /* Formular/Dialog */

#define COMMENTS         8   /* Formular/Dialog */

#define ALREVERT         0   /* Alert String */

#define ALQUIT           1   /* Alert String */

#define ALMULTI          2   /* Alert String */

#define ALREPLACE        3   /* Alert String */

#define ALCHANGE         4   /* Alert String */

#define ALILLEGAL        5   /* Alert String */

#define ALNOGUIDE        6   /* Alert String */

#define ALNOMEM          7   /* Alert String */

#define ALNORSC          8   /* Alert String */

#define ALLONGTEXT       9   /* Alert String */

#define ALILLTYPE        10  /* Alert String */

#define ALNOSHUT         11  /* Alert String */

#define ALWDIAL          12  /* Alert String */

#define ALNOWDIAL        13  /* Alert String */

#define ALTWICE          14  /* Alert String */

#define ALICONMISS       15  /* Alert String */

#define ALILLLINES       16  /* Alert String */

#define ALWERR           17  /* Alert String */

#define ALICONNOTFOUND   18  /* Alert String */

#define ALMASKNOTFOUND   19  /* Alert String */

#define WTITLE           20  /* Freier String */

#define WINFO            21  /* Freier String */

#define TXCLASS          22  /* Freier String */

#define TRNONE           23  /* Freier String */

#define TRDRIVE          24  /* Freier String */

#define TRTRASH          25  /* Freier String */

#define TRCLIP           26  /* Freier String */

#define TRPRINTER        27  /* Freier String */

#define TRFILE           28  /* Freier String */

#define TRAPP            29  /* Freier String */

#define TRFOLDER         30  /* Freier String */

#define TRGROUP          31  /* Freier String */

#define TRPARENT         32  /* Freier String */

#define TRDEVICE         33  /* Freier String */

#define WTITLEC          34  /* Freier String */

#define TXSICON          35  /* Freier String */

#define TXSMASK          36  /* Freier String */
