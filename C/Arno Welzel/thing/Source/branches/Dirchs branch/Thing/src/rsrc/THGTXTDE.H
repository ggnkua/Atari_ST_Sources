/* Resource Datei Indizes f�r THGTXTDE */

#define ALNOMEM          0   /* Alert String */

#define ALNOWIN          1   /* Alert String */

#define ALNOPWIN         2   /* Alert String */

#define ALNEWREZ         3   /* Alert String */

#define ALDESKFULL       4   /* Alert String */

#define ALTRASH          5   /* Alert String */

#define ALPROPEN         6   /* Alert String */

#define ALNORSC          7   /* Alert String */

#define ALDOSAVECONF     8   /* Alert String */

#define ALASKFALLBACK    9   /* Alert String */

#define ALUSENEWCPATH    10  /* Alert String */

#define ALCOSAVE         11  /* Alert String */

#define ALQUIT           12  /* Alert String */

#define ALFORMERR        13  /* Alert String */

#define ALFORMAT         14  /* Alert String */

#define ALSERIAL         15  /* Alert String */

#define ALSTART          16  /* Alert String */

#define ALDNAME          17  /* Alert String */

#define ALILLPATH        18  /* Alert String */

#define ALILLNAME        19  /* Alert String */

#define ALILLFNAME       20  /* Alert String */

#define ALILLMASK        21  /* Alert String */

#define ALILLDNAME       22  /* Alert String */

#define ALILLDEST        23  /* Alert String */

#define ALTOOMANY        24  /* Alert String */

#define ALACCFAIL        25  /* Alert String */

#define ALACCLOAD        26  /* Alert String */

#define ALNOARGV         27  /* Alert String */

#define ALNOPFONT        28  /* Alert String */

#define ALNOCFONT        29  /* Alert String */

#define ALNOGUIDE        30  /* Alert String */

#define ALAPPDEL         31  /* Alert String */

#define ALAPPEXT         32  /* Alert String */

#define ALAPPLABEL       33  /* Alert String */

#define ALAPPNEW         34  /* Alert String */

#define ALAPPEXIST       35  /* Alert String */

#define ALAPPMISS        36  /* Alert String */

#define ALNOLABEL        37  /* Alert String */

#define ALNOPATH         38  /* Alert String */

#define ALNONAME         39  /* Alert String */

#define ALNOVA           40  /* Alert String */

#define ALNODRIVE        41  /* Alert String */

#define ALFLOPEN         42  /* Alert String */

#define ALFLCREATE       43  /* Alert String */

#define ALFLREAD         44  /* Alert String */

#define ALFLWRITE        45  /* Alert String */

#define ALDEVWRITE       46  /* Alert String */

#define ALFLRENAME       47  /* Alert String */

#define ALFLATTR         48  /* Alert String */

#define ALPCREATE        49  /* Alert String */

#define ALCCREATE        50  /* Alert String */

#define ALLCREATE        51  /* Alert String */

#define ALFLDELETE       52  /* Alert String */

#define ALPREAD          53  /* Alert String */

#define ALPDELETE        54  /* Alert String */

#define ALVAILL          55  /* Alert String */

#define ALNOPAR          56  /* Alert String */

#define ALNOAPP          57  /* Alert String */

#define ALNOOBJ          58  /* Alert String */

#define ALDISKFULL       59  /* Alert String */

#define ALLOADICON       60  /* Alert String */

#define ALNOKOBOLD       61  /* Alert String */

#define ALDOUBLE         62  /* Alert String */

#define ALCONERR         63  /* Alert String */

#define ALCONRUN         64  /* Alert String */

#define ALNOTOS2GEM      65  /* Alert String */

#define ALBREAK          66  /* Alert String */

#define ALAPPFIND        67  /* Alert String */

#define ALAVEDRAG        68  /* Alert String */

#define ALAVEDRAGS       69  /* Alert String */

#define ALAVEDRAGT       70  /* Alert String */

#define ALEACDRAG        71  /* Alert String */

#define ALWDIAL          72  /* Alert String */

#define ALDEVICE         73  /* Alert String */

#define ALNOOUTPUT       74  /* Alert String */

#define ALDOOUTPUT       75  /* Alert String */

#define ALAVLOST         76  /* Alert String */

#define ALDOLOADCONF     77  /* Alert String */

#define ALNOLOCK         78  /* Alert String */

#define ALDOPRINT        79  /* Alert String */

#define ALNOPRINT        80  /* Alert String */

#define ALNOVIEW         81  /* Alert String */

#define ALDELENTRY       82  /* Alert String */

#define ALNOWDIAL        83  /* Alert String */

#define ALOPENGROUP      84  /* Alert String */

#define ALSAVEGROUP      85  /* Alert String */

#define ALNEWGROUP       86  /* Alert String */

#define ALGROUPEXIST     87  /* Alert String */

#define ALGROUPCHANGED   88  /* Alert String */

#define ALNOSHUT         89  /* Alert String */

#define ALSHUT           90  /* Alert String */

#define ALMISS           91  /* Alert String */

#define ALFONTSEL        92  /* Alert String */

#define ALILLIMG         93  /* Alert String */

#define ALIMGERR         94  /* Alert String */

#define ALNOTIMG         95  /* Alert String */

#define ALILLACT         96  /* Alert String */

#define ALRECURS         97  /* Alert String */

#define ALFEXIST         98  /* Alert String */

#define ALTOOMUCH        99  /* Alert String */

#define ALDELALL         100 /* Alert String */

#define ALNOGFONT        101 /* Alert String */

#define ALICONMISS       102 /* Alert String */

#define ALEXIST          103 /* Alert String */

#define ALTOOLONG        104 /* Alert String */

#define ALQUOTEERR       105 /* Alert String */

#define ALNOQUOTE        106 /* Alert String */

#define ALNOEJECT        107 /* Alert String */

#define ALSAME           108 /* Alert String */

#define ALUID            109 /* Alert String */

#define ALGID            110 /* Alert String */

#define ALCMDLINE        111 /* Alert String */

#define ALPRIVATEMEM     112 /* Alert String */

#define ALHOTKEY         113 /* Alert String */

#define ALDIRIMGERR      114 /* Alert String */

#define ALSTARTERR       115 /* Alert String */

#define ALDUMMY          116 /* Alert String */

#define ALNEWIMG         117 /* Alert String */

#define ALPMDETAILS      118 /* Alert String */

#define MSFORMAT1        119 /* Freier String */

#define MSFORMAT2        120 /* Freier String */

#define MSDEL1           121 /* Freier String */

#define MSCOPY1          122 /* Freier String */

#define MSMOVE1          123 /* Freier String */

#define MSLINK1          124 /* Freier String */

#define MSDEL2           125 /* Freier String */

#define TXTRASH          126 /* Freier String */

#define TXCLIP           127 /* Freier String */

#define TXPRT            128 /* Freier String */

#define TXFILESYS        129 /* Freier String */

#define TXAPSEARCH       130 /* Freier String */

#define TXCLIPSEARCH     131 /* Freier String */

#define TXFILESEARCH     132 /* Freier String */

#define TXFOLDSEARCH     133 /* Freier String */

#define TXOBJSEARCH      134 /* Freier String */

#define TXKBSEARCH       135 /* Freier String */

#define TXIMGSEARCH      136 /* Freier String */

#define TXNOFILE         137 /* Freier String */

#define TXWPNONE         138 /* Freier String */

#define TXWPINFO1        139 /* Freier String */

#define TXWPINFO         140 /* Freier String */

#define TXWPINFOS1       141 /* Freier String */

#define TXWPINFOS        142 /* Freier String */

#define MSDFILE          143 /* Freier String */

#define MSDFOLDER        144 /* Freier String */

#define MSRFILE          145 /* Freier String */

#define MSRFOLDER        146 /* Freier String */

#define TXCONTITLE       147 /* Freier String */

#define TXFTCONSOLE      148 /* Freier String */

#define TXFTPATH         149 /* Freier String */

#define TXFTGRP          150 /* Freier String */

#define TXFTFONTSEL      151 /* Freier String */

#define TXTOSWAIT        152 /* Freier String */

#define TXTOSTERM        153 /* Freier String */

#define TXSVIEW          154 /* Freier String */

#define TXSOPEN          155 /* Freier String */

#define TXSPRINT         156 /* Freier String */

#define TXNEWGRP         157 /* Freier String */

#define TXMSHUT          158 /* Freier String */

#define TXOBJOPEN        159 /* Freier String */

#define TXNOARGVMEM      160 /* Freier String */

#define TXSCSTART        161 /* Freier String */

#define TXPARENTSEARCH   162 /* Freier String */

#define TXRUNACC         163 /* Freier String */

#define TXINSTALLACC     164 /* Freier String */

#define TXADATE          165 /* Freier String */

#define TXMDATE          166 /* Freier String */

#define TXCDATE          167 /* Freier String */

#define TXPOPDEL         168 /* Freier String */

#define TXPOPREMOVE      169 /* Freier String */

#define HMABOUT          170 /* Freier String */

#define HMNEW            171 /* Freier String */

#define HMOPEN           172 /* Freier String */

#define HMFIND           173 /* Freier String */

#define HMINFO           174 /* Freier String */

#define HMCLOSE          175 /* Freier String */

#define HMSHOW           176 /* Freier String */

#define HMPRINT          177 /* Freier String */

#define HMSAVEGROUP      178 /* Freier String */

#define HMEJECT          179 /* Freier String */

#define HMFORMAT         180 /* Freier String */

#define HMQUIT           181 /* Freier String */

#define HMCOPY           182 /* Freier String */

#define HMCUT            183 /* Freier String */

#define HMPASTE          184 /* Freier String */

#define HMDELETE         185 /* Freier String */

#define HMSELECTALL      186 /* Freier String */

#define HMSELECTNONE     187 /* Freier String */

#define HMTEXT           188 /* Freier String */

#define HMSYMTEXT        189 /* Freier String */

#define HMICONS          190 /* Freier String */

#define HMMASK           191 /* Freier String */

#define HMFONT           192 /* Freier String */

#define HMFONTSEL        193 /* Freier String */

#define HMSAVEINDEX      194 /* Freier String */

#define HMNEXTWIN        195 /* Freier String */

#define HMCLOSEWIN       196 /* Freier String */

#define HMCLOSEALLWIN    197 /* Freier String */

#define HMDUPWIN         198 /* Freier String */

#define HMAPPL           199 /* Freier String */

#define HMFUNC           200 /* Freier String */

#define HMCONFIG         201 /* Freier String */

#define HMDRIVE          202 /* Freier String */

#define HMCHANGEREZ      203 /* Freier String */

#define HMEDITICONS      204 /* Freier String */

#define HMLOADICONS      205 /* Freier String */

#define HMCONSOLE        206 /* Freier String */

#define HMAUTOSAVE       207 /* Freier String */

#define HMSAVECONFIG     208 /* Freier String */

#define HMLOADCONFIG     209 /* Freier String */

#define HMWAIT           210 /* Freier String */

#define HMSELAPP         211 /* Freier String */

#define HMDIINFO         212 /* Freier String */

#define HMTRASHINFO      213 /* Freier String */

#define HMCLIPINFO       214 /* Freier String */

#define HMDAPPINFO       215 /* Freier String */

#define HMDFILEINFO      216 /* Freier String */

#define HMDPRTINFO       217 /* Freier String */

#define HMGRPINFO        218 /* Freier String */

#define HMGOBINFO        219 /* Freier String */

#define HMCONFIG0        220 /* Freier String */

#define HMCONFIG1        221 /* Freier String */

#define HMCONFIG2        222 /* Freier String */

#define HMCONFIG3        223 /* Freier String */

#define HMCONFIG4        224 /* Freier String */

#define HMCONFIG5        225 /* Freier String */

#define HMAPP0           226 /* Freier String */

#define HMAPP1           227 /* Freier String */

#define HMAPP2           228 /* Freier String */

#define HMAPP3           229 /* Freier String */

#define HMSORT           230 /* Freier String */

#define HMRENAME         231 /* Freier String */

#define HMPAR            232 /* Freier String */

#define HMDEVICE         233 /* Freier String */

#define HMSELINFO        234 /* Freier String */

#define HMPARENT         235 /* Freier String */

#define DEFAULTAPPL      236 /* Freier String */

#define HMCOPYCONF       237 /* Freier String */

#define HMDELCONF        238 /* Freier String */

#define HMHOTKEYS        239 /* Freier String */

#define HMHKACTIVE       240 /* Freier String */

#define HMDEFAULT        241 /* Freier String */
