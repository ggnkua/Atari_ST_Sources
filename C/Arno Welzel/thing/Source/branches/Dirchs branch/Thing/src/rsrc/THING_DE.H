/* Resource Datei Indizes f�r THING_DE */

#define LANGUAGE         0   /* Formular/Dialog */
#define LANGFONT         1   /* STRING in Baum LANGUAGE */
#define LANGDATE         2   /* STRING in Baum LANGUAGE */
#define LANGTIME         3   /* STRING in Baum LANGUAGE */
#define LANGOSVER        4   /* STRING in Baum LANGUAGE */
#define LANGMGXVER       5   /* STRING in Baum LANGUAGE */
#define LANGSCR1         6   /* STRING in Baum LANGUAGE */
#define LANGSCR2         7   /* STRING in Baum LANGUAGE */
#define LANGT2GVER       8   /* STRING in Baum LANGUAGE */
#define LANGT2GMISS      9   /* STRING in Baum LANGUAGE */
#define LANGCHAR         10  /* STRING in Baum LANGUAGE */
#define LANGDATE1        11  /* STRING in Baum LANGUAGE */
#define LANGDATE2        12  /* STRING in Baum LANGUAGE */
#define LANGTIME1        13  /* STRING in Baum LANGUAGE */
#define LANGVER          14  /* STRING in Baum LANGUAGE */
#define LANGTVER         15  /* STRING in Baum LANGUAGE */

#define MAINMENU         1   /* Menuebaum */
#define MACC             3   /* TITLE in Baum MAINMENU */
#define MFILE            4   /* TITLE in Baum MAINMENU */
#define MEDIT            5   /* TITLE in Baum MAINMENU */
#define MINDEX           6   /* TITLE in Baum MAINMENU */
#define MWINDOW          7   /* TITLE in Baum MAINMENU */
#define MOPTIONS         8   /* TITLE in Baum MAINMENU */
#define MTOOL            9   /* TITLE in Baum MAINMENU */
#define MABOUT           12  /* STRING in Baum MAINMENU */
#define MTFILE           20  /* BOX in Baum MAINMENU */
#define MNEW             21  /* STRING in Baum MAINMENU */
#define MOPEN            22  /* STRING in Baum MAINMENU */
#define MFIND            23  /* STRING in Baum MAINMENU */
#define MINFO            24  /* STRING in Baum MAINMENU */
#define MCLOSE           26  /* STRING in Baum MAINMENU */
#define MSHOW            27  /* STRING in Baum MAINMENU */
#define MPRINT           28  /* STRING in Baum MAINMENU */
#define MSAVEGROUP       29  /* STRING in Baum MAINMENU */
#define MEJECT           31  /* STRING in Baum MAINMENU */
#define MFORMAT          33  /* STRING in Baum MAINMENU */
#define MQUIT            35  /* STRING in Baum MAINMENU */
#define MCUT             37  /* STRING in Baum MAINMENU */
#define MCOPY            38  /* STRING in Baum MAINMENU */
#define MPASTE           39  /* STRING in Baum MAINMENU */
#define MDELETE          40  /* STRING in Baum MAINMENU */
#define MSELECTALL       42  /* STRING in Baum MAINMENU */
#define MSELECTNONE      43  /* STRING in Baum MAINMENU */
#define MTEXT            45  /* STRING in Baum MAINMENU */
#define MSYMTEXT         46  /* STRING in Baum MAINMENU */
#define MICONS           47  /* STRING in Baum MAINMENU */
#define MSORTVICE        49  /* STRING in Baum MAINMENU */
#define MSORTFOLD        50  /* STRING in Baum MAINMENU */
#define MSORTNAME        51  /* STRING in Baum MAINMENU */
#define MSORTSIZE        52  /* STRING in Baum MAINMENU */
#define MSORTDATE        53  /* STRING in Baum MAINMENU */
#define MSORTEXT         54  /* STRING in Baum MAINMENU */
#define MSORTNONE        55  /* STRING in Baum MAINMENU */
#define MDEFAULT         57  /* STRING in Baum MAINMENU */
#define MMASK            59  /* STRING in Baum MAINMENU */
#define MFONT            60  /* STRING in Baum MAINMENU */
#define MSAVEINDEX       62  /* STRING in Baum MAINMENU */
#define MTWINDOW         63  /* BOX in Baum MAINMENU */
#define MNEXTWIN         64  /* STRING in Baum MAINMENU */
#define MCLOSEWIN        65  /* STRING in Baum MAINMENU */
#define MCLOSEALLWIN     66  /* STRING in Baum MAINMENU */
#define MDUPWIN          67  /* STRING in Baum MAINMENU */
#define MWIN1            69  /* STRING in Baum MAINMENU */
#define MWIN2            70  /* STRING in Baum MAINMENU */
#define MWIN3            71  /* STRING in Baum MAINMENU */
#define MWIN4            72  /* STRING in Baum MAINMENU */
#define MWIN5            73  /* STRING in Baum MAINMENU */
#define MWIN6            74  /* STRING in Baum MAINMENU */
#define MWIN7            75  /* STRING in Baum MAINMENU */
#define MWIN8            76  /* STRING in Baum MAINMENU */
#define MWIN9            77  /* STRING in Baum MAINMENU */
#define MWIN10           78  /* STRING in Baum MAINMENU */
#define MTEXTRA          79  /* BOX in Baum MAINMENU */
#define MAPPL            80  /* STRING in Baum MAINMENU */
#define MFUNC            81  /* STRING in Baum MAINMENU */
#define MCONFIG          82  /* STRING in Baum MAINMENU */
#define MHOTKEYS         84  /* STRING in Baum MAINMENU */
#define MHKACTIVE        85  /* STRING in Baum MAINMENU */
#define MDRIVE           87  /* STRING in Baum MAINMENU */
#define MCHANGEREZ       88  /* STRING in Baum MAINMENU */
#define MEDITICONS       89  /* STRING in Baum MAINMENU */
#define MLOADICONS       90  /* STRING in Baum MAINMENU */
#define MCONSOLE         92  /* STRING in Baum MAINMENU */
#define MFONTSEL         94  /* STRING in Baum MAINMENU */
#define MAUTOSAVE        96  /* STRING in Baum MAINMENU */
#define MSAVECONFIG      97  /* STRING in Baum MAINMENU */
#define MLOADCONFIG      98  /* STRING in Baum MAINMENU */
#define MTOOLS           100 /* STRING in Baum MAINMENU */
#define MTOOL1           102 /* STRING in Baum MAINMENU */

#define DESKTOP          2   /* Formular/Dialog */

#define DESKAPP          3   /* Formular/Dialog */

#define ABOUT            4   /* Formular/Dialog */
#define ABLOGOHI         2   /* USERDEF in Baum ABOUT */
#define ABLOGOLO         3   /* IMAGE in Baum ABOUT */
#define ABVER            4   /* TEXT in Baum ABOUT */
#define ABHELP           7   /* BUTTON in Baum ABOUT */
#define ABOK             8   /* BUTTON in Baum ABOUT */
#define ABINFO           9   /* BUTTON in Baum ABOUT */

#define AINFO1           5   /* Formular/Dialog */
#define AIOS             3   /* STRING in Baum AINFO1 */
#define AIDISPLAY        5   /* STRING in Baum AINFO1 */
#define AITOS2GEM        7   /* STRING in Baum AINFO1 */
#define AIHELP           21  /* BUTTON in Baum AINFO1 */
#define AIOK             22  /* BUTTON in Baum AINFO1 */

#define MASK             6   /* Formular/Dialog */
#define MAPATH           3   /* STRING in Baum MASK */
#define MAMASK           4   /* FBOXTEXT in Baum MASK */
#define MALIST           5   /* BOX in Baum MASK */
#define MAUP             16  /* BUTTON in Baum MASK */
#define MABOX            17  /* BOX in Baum MASK */
#define MASLIDE          18  /* BUTTON in Baum MASK */
#define MADOWN           19  /* BUTTON in Baum MASK */
#define MAHELP           20  /* BUTTON in Baum MASK */
#define MAOK             21  /* BUTTON in Baum MASK */
#define MACANCEL         22  /* BUTTON in Baum MASK */

#define FONT             7   /* Formular/Dialog */
#define FOTITLE          1   /* STRING in Baum FONT */
#define FOSAMPLE         2   /* IBOX in Baum FONT */
#define FOID             3   /* TEXT in Baum FONT */
#define FOFONTS          4   /* STRING in Baum FONT */
#define FOFONT           6   /* BOXTEXT in Baum FONT */
#define FOFONTA          7   /* BUTTON in Baum FONT */
#define FOSIZES          8   /* STRING in Baum FONT */
#define FOSIZE           10  /* FBOXTEXT in Baum FONT */
#define FOSIZEA          11  /* BUTTON in Baum FONT */
#define FOFCOLS          12  /* STRING in Baum FONT */
#define FOFCOL           14  /* IBOX in Baum FONT */
#define FOBCOLS          15  /* STRING in Baum FONT */
#define FOBCOL           17  /* IBOX in Baum FONT */
#define FOSUB            18  /* IBOX in Baum FONT */
#define FOSATTR          19  /* IBOX in Baum FONT */
#define FOATTR1          21  /* BUTTON in Baum FONT */
#define FOATTR2          22  /* BUTTON in Baum FONT */
#define FOATTR3          23  /* BUTTON in Baum FONT */
#define FOATTR4          24  /* BUTTON in Baum FONT */
#define FOATTR5          25  /* BUTTON in Baum FONT */
#define FOATTR6          26  /* BUTTON in Baum FONT */
#define FOATTR7          27  /* BUTTON in Baum FONT */
#define FOSVIEW          28  /* IBOX in Baum FONT */
#define FOVSIZE          30  /* BUTTON in Baum FONT */
#define FOVDATE          31  /* BUTTON in Baum FONT */
#define FOVTIME          32  /* BUTTON in Baum FONT */
#define FOVFLAG          33  /* BUTTON in Baum FONT */
#define FOBPATS          34  /* STRING in Baum FONT */
#define FOBPAT           36  /* IBOX in Baum FONT */
#define FOIMGF           37  /* BUTTON in Baum FONT */
#define FOIMG            38  /* TEXT in Baum FONT */
#define FOHELP           39  /* BUTTON in Baum FONT */
#define FOOK             40  /* BUTTON in Baum FONT */
#define FOCANCEL         41  /* BUTTON in Baum FONT */

#define FORMAT           8   /* Formular/Dialog */
#define FMDRIVEA         4   /* BUTTON in Baum FORMAT */
#define FMDRIVEB         5   /* BUTTON in Baum FORMAT */
#define FMNAME           7   /* FBOXTEXT in Baum FORMAT */
#define FMFORMDD         10  /* BUTTON in Baum FORMAT */
#define FMFORMHD         11  /* BUTTON in Baum FORMAT */
#define FMQUICK          12  /* BUTTON in Baum FORMAT */
#define FMHELP           13  /* BUTTON in Baum FORMAT */
#define FMOK             14  /* BUTTON in Baum FORMAT */
#define FMCANCEL         15  /* BUTTON in Baum FORMAT */

#define PARAM            9   /* Formular/Dialog */
#define PATITLE          1   /* STRING in Baum PARAM */
#define PATEXT           2   /* FBOXTEXT in Baum PARAM */
#define PAHELP           3   /* BUTTON in Baum PARAM */
#define PAOK             4   /* BUTTON in Baum PARAM */
#define PACANCEL         5   /* BUTTON in Baum PARAM */

#define FLINFO           10  /* Formular/Dialog */
#define FITITLE          1   /* STRING in Baum FLINFO */
#define FLGENERAL        2   /* BUTTON in Baum FLINFO */
#define FLPROG           3   /* BUTTON in Baum FLINFO */
#define FLATTR           4   /* BUTTON in Baum FLINFO */
#define FLSUB            6   /* IBOX in Baum FLINFO */
#define FLSATTR          7   /* BOX in Baum FLINFO */
#define FLMODE1          8   /* BUTTON in Baum FLINFO */
#define FASUID           17  /* BUTTON in Baum FLINFO */
#define FAUID            25  /* FBOXTEXT in Baum FLINFO */
#define FAGID            27  /* FBOXTEXT in Baum FLINFO */
#define FLSPROG          28  /* BOX in Baum FLINFO */
#define FPFAST           30  /* BUTTON in Baum FLINFO */
#define FPLALT           31  /* BUTTON in Baum FLINFO */
#define FPMALT           32  /* BUTTON in Baum FLINFO */
#define FPMINMEM         33  /* BUTTON in Baum FLINFO */
#define FLPMEMS          34  /* STRING in Baum FLINFO */
#define FLPMEM           36  /* TEXT in Baum FLINFO */
#define FPSHARED         37  /* BUTTON in Baum FLINFO */
#define FPMAGIC          39  /* FBOXTEXT in Baum FLINFO */
#define FLSGENERAL       41  /* BOX in Baum FLINFO */
#define FILABEL          43  /* FBOXTEXT in Baum FLINFO */
#define FIPATH           45  /* STRING in Baum FLINFO */
#define FINAME           47  /* FBOXTEXT in Baum FLINFO */
#define FILINK           48  /* STRING in Baum FLINFO */
#define FILINKDEST       49  /* STRING in Baum FLINFO */
#define FLOFILE          50  /* IBOX in Baum FLINFO */
#define FISIZE           52  /* STRING in Baum FLINFO */
#define FIDATE           54  /* TEXT in Baum FLINFO */
#define FITIME           56  /* TEXT in Baum FLINFO */
#define FIDATETYPE       57  /* TEXT in Baum FLINFO */
#define FLOFOLD          58  /* IBOX in Baum FLINFO */
#define FLFILES          60  /* STRING in Baum FLINFO */
#define FLFOLDERS        62  /* STRING in Baum FLINFO */
#define FLOFLAG          63  /* IBOX in Baum FLINFO */
#define FIFLAGRO         65  /* BUTTON in Baum FLINFO */
#define FIFLAGH          66  /* BUTTON in Baum FLINFO */
#define FIFLAGS          67  /* BUTTON in Baum FLINFO */
#define FIFLAGA          68  /* BUTTON in Baum FLINFO */
#define FLFKEYS          69  /* STRING in Baum FLINFO */
#define FLFKEY           71  /* TEXT in Baum FLINFO */
#define FIHOTKEYSEL      72  /* BUTTON in Baum FLINFO */
#define FIHOTKEY         73  /* TEXT in Baum FLINFO */
#define FIHELP           74  /* BUTTON in Baum FLINFO */
#define FIOK             75  /* BUTTON in Baum FLINFO */
#define FINEXT           76  /* BUTTON in Baum FLINFO */
#define FICANCEL         77  /* BUTTON in Baum FLINFO */

#define PAINFO           11  /* Formular/Dialog */
#define PNHELP           4   /* BUTTON in Baum PAINFO */
#define PNOK             5   /* BUTTON in Baum PAINFO */

#define DEVINFO          12  /* Formular/Dialog */
#define DVNAME           3   /* STRING in Baum DEVINFO */
#define DVLABEL          5   /* FBOXTEXT in Baum DEVINFO */
#define DVHELP           8   /* BUTTON in Baum DEVINFO */
#define DVOK             9   /* BUTTON in Baum DEVINFO */
#define DVNEXT           10  /* BUTTON in Baum DEVINFO */
#define DVCANCEL         11  /* BUTTON in Baum DEVINFO */

#define DIINFO           13  /* Formular/Dialog */
#define DITITLE          1   /* STRING in Baum DIINFO */
#define DILABEL          3   /* FBOXTEXT in Baum DIINFO */
#define DINAME           5   /* FBOXTEXT in Baum DIINFO */
#define DIUSELABEL       6   /* BUTTON in Baum DIINFO */
#define DIAUTOINSTALL    7   /* BUTTON in Baum DIINFO */
#define DIBTOTAL         9   /* BOX in Baum DIINFO */
#define DIBUSED          10  /* BOX in Baum DIINFO */
#define DIBVALUE         11  /* STRING in Baum DIINFO */
#define DIUSED           13  /* TEXT in Baum DIINFO */
#define DIUSEDKB         14  /* TEXT in Baum DIINFO */
#define DIFREE           16  /* TEXT in Baum DIINFO */
#define DIFREEKB         17  /* TEXT in Baum DIINFO */
#define DISIZE           19  /* TEXT in Baum DIINFO */
#define DISIZEKB         20  /* TEXT in Baum DIINFO */
#define DIHELP           21  /* BUTTON in Baum DIINFO */
#define DIOK             22  /* BUTTON in Baum DIINFO */
#define DINEXT           23  /* BUTTON in Baum DIINFO */
#define DICANCEL         24  /* BUTTON in Baum DIINFO */

#define TRASHINFO        14  /* Formular/Dialog */
#define TILABEL          3   /* FBOXTEXT in Baum TRASHINFO */
#define TIHELP           6   /* BUTTON in Baum TRASHINFO */
#define TIOK             7   /* BUTTON in Baum TRASHINFO */
#define TINEXT           8   /* BUTTON in Baum TRASHINFO */
#define TICANCEL         9   /* BUTTON in Baum TRASHINFO */

#define CLIPINFO         15  /* Formular/Dialog */
#define CILABEL          3   /* FBOXTEXT in Baum CLIPINFO */
#define CIPATH           5   /* FBOXTEXT in Baum CLIPINFO */
#define CIHELP           7   /* BUTTON in Baum CLIPINFO */
#define CIOK             8   /* BUTTON in Baum CLIPINFO */
#define CINEXT           9   /* BUTTON in Baum CLIPINFO */
#define CICANCEL         10  /* BUTTON in Baum CLIPINFO */

#define PRTINFO          16  /* Formular/Dialog */
#define PRLABEL          3   /* FBOXTEXT in Baum PRTINFO */
#define PRHELP           7   /* BUTTON in Baum PRTINFO */
#define PROK             8   /* BUTTON in Baum PRTINFO */
#define PRNEXT           9   /* BUTTON in Baum PRTINFO */
#define PRCANCEL         10  /* BUTTON in Baum PRTINFO */

#define DAPPINFO         17  /* Formular/Dialog */
#define DAGENERAL        2   /* BUTTON in Baum DAPPINFO */
#define DAFILES          3   /* BUTTON in Baum DAPPINFO */
#define DAOPTIONS        4   /* BUTTON in Baum DAPPINFO */
#define DAENV            5   /* BUTTON in Baum DAPPINFO */
#define DASUB            7   /* IBOX in Baum DAPPINFO */
#define DASGENERAL       8   /* BOX in Baum DAPPINFO */
#define DAILABEL         10  /* FBOXTEXT in Baum DAPPINFO */
#define DAISEARCH        11  /* BUTTON in Baum DAPPINFO */
#define DAINAME          12  /* TEXT in Baum DAPPINFO */
#define DAISHORTS        13  /* STRING in Baum DAPPINFO */
#define DAISHORT         15  /* TEXT in Baum DAPPINFO */
#define DAIUSESEL        16  /* BUTTON in Baum DAPPINFO */
#define DAIAPPL          19  /* BUTTON in Baum DAPPINFO */
#define DAIWINDOW        20  /* BUTTON in Baum DAPPINFO */
#define DAIFILE          21  /* BUTTON in Baum DAPPINFO */
#define DAINONLY         24  /* BUTTON in Baum DAPPINFO */
#define DAIFPATH         25  /* BUTTON in Baum DAPPINFO */
#define DAIPARAM         27  /* FBOXTEXT in Baum DAPPINFO */
#define DAIALWAYS        28  /* BUTTON in Baum DAPPINFO */
#define DASFILES         29  /* BOX in Baum DAPPINFO */
#define DAINAME3         31  /* STRING in Baum DAPPINFO */
#define DAIOPEN          33  /* FBOXTEXT in Baum DAPPINFO */
#define DAIINDRAG        34  /* BUTTON in Baum DAPPINFO */
#define DAIVIEW          36  /* FBOXTEXT in Baum DAPPINFO */
#define DAIPRINT         38  /* FBOXTEXT in Baum DAPPINFO */
#define DASOPTIONS       39  /* BOX in Baum DAPPINFO */
#define DAINAME2         41  /* STRING in Baum DAPPINFO */
#define DAOFULL          42  /* BUTTON in Baum DAPPINFO */
#define DAOAUTO          43  /* BUTTON in Baum DAPPINFO */
#define DAOASKPARM       44  /* BUTTON in Baum DAPPINFO */
#define DAOUNIXPATHS     45  /* BUTTON in Baum DAPPINFO */
#define DAOVAPROT        46  /* BUTTON in Baum DAPPINFO */
#define DAOOVERLAY       47  /* BUTTON in Baum DAPPINFO */
#define DAOSINGLE        48  /* BUTTON in Baum DAPPINFO */
#define DAOCONWIN        49  /* BUTTON in Baum DAPPINFO */
#define DAOWAITKEY       50  /* BUTTON in Baum DAPPINFO */
#define DAOMAXMEM        52  /* FBOXTEXT in Baum DAPPINFO */
#define DAOALERT         55  /* FBOXTEXT in Baum DAPPINFO */
#define DASENV           56  /* BOX in Baum DAPPINFO */
#define DAINAME4         58  /* STRING in Baum DAPPINFO */
#define DAELIST          59  /* BOX in Baum DAPPINFO */
#define DAEUP            66  /* BUTTON in Baum DAPPINFO */
#define DAEBOX           67  /* BOX in Baum DAPPINFO */
#define DAESLIDE         68  /* BUTTON in Baum DAPPINFO */
#define DAEDOWN          69  /* BUTTON in Baum DAPPINFO */
#define DAEVAL           70  /* FBOXTEXT in Baum DAPPINFO */
#define DAEUSE           71  /* BUTTON in Baum DAPPINFO */
#define DAEEDIT          72  /* BUTTON in Baum DAPPINFO */
#define DAEDELETE        73  /* BUTTON in Baum DAPPINFO */
#define DAIHELP          74  /* BUTTON in Baum DAPPINFO */
#define DAIOK            75  /* BUTTON in Baum DAPPINFO */
#define DAIDELETE        76  /* BUTTON in Baum DAPPINFO */
#define DAICANCEL        77  /* BUTTON in Baum DAPPINFO */

#define SELINFO          18  /* Formular/Dialog */
#define SIPATH           3   /* STRING in Baum SELINFO */
#define SIFILES          5   /* STRING in Baum SELINFO */
#define SIFOLDERS        7   /* STRING in Baum SELINFO */
#define SISIZE           9   /* STRING in Baum SELINFO */
#define SIHELP           10  /* BUTTON in Baum SELINFO */
#define SIDETAILS        11  /* BUTTON in Baum SELINFO */
#define SICANCEL         12  /* BUTTON in Baum SELINFO */

#define COPY             19  /* Formular/Dialog */
#define CPSOURCET        2   /* STRING in Baum COPY */
#define CPSOURCE         3   /* TEXT in Baum COPY */
#define CPFILES          5   /* STRING in Baum COPY */
#define CPDEST           7   /* TEXT in Baum COPY */
#define CPFOLDERS        9   /* STRING in Baum COPY */
#define CPSIZE           11  /* STRING in Baum COPY */
#define CPOPTBOX         12  /* IBOX in Baum COPY */
#define CPCOPY           13  /* BUTTON in Baum COPY */
#define CPLINK           14  /* BUTTON in Baum COPY */
#define CPMOVE           15  /* BUTTON in Baum COPY */
#define CPRENAME         16  /* BUTTON in Baum COPY */
#define CPFOLLOW         17  /* BUTTON in Baum COPY */
#define CPBACKUP         18  /* BUTTON in Baum COPY */
#define CPHELP           19  /* BUTTON in Baum COPY */
#define CPOK             20  /* BUTTON in Baum COPY */
#define CPCANCEL         21  /* BUTTON in Baum COPY */

#define DELETE           20  /* Formular/Dialog */
#define DLSOURCE         3   /* STRING in Baum DELETE */
#define DLFILES          5   /* STRING in Baum DELETE */
#define DLFOLDERS        7   /* STRING in Baum DELETE */
#define DLSIZE           9   /* STRING in Baum DELETE */
#define DLHELP           10  /* BUTTON in Baum DELETE */
#define DLOK             11  /* BUTTON in Baum DELETE */
#define DLCANCEL         12  /* BUTTON in Baum DELETE */

#define RENAMEFILE       21  /* Formular/Dialog */
#define RFTITLE          2   /* STRING in Baum RENAMEFILE */
#define RFSPATH          5   /* STRING in Baum RENAMEFILE */
#define RFSNAME          7   /* STRING in Baum RENAMEFILE */
#define RFSATTR          8   /* IBOX in Baum RENAMEFILE */
#define RFSSIZE          10  /* STRING in Baum RENAMEFILE */
#define RFSDATE          12  /* STRING in Baum RENAMEFILE */
#define RFSTIME          14  /* STRING in Baum RENAMEFILE */
#define RFDPATH          17  /* STRING in Baum RENAMEFILE */
#define RFDNAME          19  /* FBOXTEXT in Baum RENAMEFILE */
#define RFDATTR          20  /* IBOX in Baum RENAMEFILE */
#define RFDSIZE          22  /* STRING in Baum RENAMEFILE */
#define RFDDATE          24  /* STRING in Baum RENAMEFILE */
#define RFDTIME          26  /* STRING in Baum RENAMEFILE */
#define RFHELP           27  /* BUTTON in Baum RENAMEFILE */
#define RFOK             28  /* BUTTON in Baum RENAMEFILE */
#define RFALL            29  /* BUTTON in Baum RENAMEFILE */
#define RFNEXT           30  /* BUTTON in Baum RENAMEFILE */
#define RFCANCEL         31  /* BUTTON in Baum RENAMEFILE */

#define DEFAPPL          22  /* Formular/Dialog */
#define DALOCATE         3   /* FBOXTEXT in Baum DEFAPPL */
#define DALIST           4   /* BOX in Baum DEFAPPL */
#define DAUP             15  /* BUTTON in Baum DEFAPPL */
#define DABOX            16  /* BOX in Baum DEFAPPL */
#define DASLIDE          17  /* BUTTON in Baum DEFAPPL */
#define DADOWN           18  /* BUTTON in Baum DEFAPPL */
#define DAHELP           19  /* BUTTON in Baum DEFAPPL */
#define DAOK             20  /* BUTTON in Baum DEFAPPL */
#define DANEW            21  /* BUTTON in Baum DEFAPPL */
#define DAEDIT           22  /* BUTTON in Baum DEFAPPL */
#define DADELETE         23  /* BUTTON in Baum DEFAPPL */

#define CONFIG           23  /* Formular/Dialog */
#define CODESK           2   /* BUTTON in Baum CONFIG */
#define COWIN            3   /* BUTTON in Baum CONFIG */
#define COWIN2           4   /* BUTTON in Baum CONFIG */
#define COPROG           5   /* BUTTON in Baum CONFIG */
#define COCOPY           6   /* BUTTON in Baum CONFIG */
#define COT2G            7   /* BUTTON in Baum CONFIG */
#define COSUB            8   /* IBOX in Baum CONFIG */
#define COSPROG          9   /* BOX in Baum CONFIG */
#define COEXIT           10  /* BUTTON in Baum CONFIG */
#define COTOSWAIT        11  /* BUTTON in Baum CONFIG */
#define COALTEXT         12  /* BUTTON in Baum CONFIG */
#define COALTCPX         13  /* BUTTON in Baum CONFIG */
#define COASKACC         14  /* BUTTON in Baum CONFIG */
#define COVASTART        15  /* BUTTON in Baum CONFIG */
#define CODEL            16  /* BUTTON in Baum CONFIG */
#define COBACKWIN        17  /* BUTTON in Baum CONFIG */
#define COFFINDER        19  /* BUTTON in Baum CONFIG */
#define COFINDER         20  /* TEXT in Baum CONFIG */
#define COFFORMAT        21  /* BUTTON in Baum CONFIG */
#define COFORMAT         22  /* TEXT in Baum CONFIG */
#define COSCOPY          23  /* BOX in Baum CONFIG */
#define COCDELETE        25  /* BUTTON in Baum CONFIG */
#define COCCOPY          26  /* BUTTON in Baum CONFIG */
#define COCREPLACE       27  /* BUTTON in Baum CONFIG */
#define COBUFSIZE        29  /* FBOXTEXT in Baum CONFIG */
#define COKTOSONLY       32  /* BUTTON in Baum CONFIG */
#define COKFORMAT        33  /* BUTTON in Baum CONFIG */
#define COKCOPY          34  /* BUTTON in Baum CONFIG */
#define COKCOPYN         35  /* FBOXTEXT in Baum CONFIG */
#define COKCOPYS         37  /* FBOXTEXT in Baum CONFIG */
#define COKDELETE        39  /* BUTTON in Baum CONFIG */
#define COKDELETEN       40  /* FBOXTEXT in Baum CONFIG */
#define COFKPROG         42  /* BUTTON in Baum CONFIG */
#define COKPROG          43  /* TEXT in Baum CONFIG */
#define COSWIN           44  /* BOX in Baum CONFIG */
#define CONOWIN          45  /* BUTTON in Baum CONFIG */
#define COBSEL           46  /* BUTTON in Baum CONFIG */
#define COCLOSEBOX       47  /* BUTTON in Baum CONFIG */
#define CONOHSCROLL      48  /* BUTTON in Baum CONFIG */
#define CORELWIN         49  /* BUTTON in Baum CONFIG */
#define COAUTOSEL        50  /* BUTTON in Baum CONFIG */
#define COAUTOCOMP       51  /* BUTTON in Baum CONFIG */
#define COAUTOUPDATE     52  /* BUTTON in Baum CONFIG */
#define COHIDDEN         53  /* BUTTON in Baum CONFIG */
#define COVERT           54  /* BUTTON in Baum CONFIG */
#define COTOSMODE        55  /* BUTTON in Baum CONFIG */
#define COQREAD          56  /* BUTTON in Baum CONFIG */
#define CONOHOTCLOSER    57  /* BUTTON in Baum CONFIG */
#define COSCROLL         59  /* FBOXTEXT in Baum CONFIG */
#define COSDESK          60  /* BOX in Baum CONFIG */
#define COUSE3D          61  /* BUTTON in Baum CONFIG */
#define COISNAP          62  /* BUTTON in Baum CONFIG */
#define CORDOUBLE        63  /* BUTTON in Baum CONFIG */
#define CODCOLS          64  /* STRING in Baum CONFIG */
#define CODCOL           66  /* IBOX in Baum CONFIG */
#define CODPATS          67  /* STRING in Baum CONFIG */
#define CODPAT           69  /* IBOX in Baum CONFIG */
#define COIMGUSE         71  /* BUTTON in Baum CONFIG */
#define COIMGCENTER      72  /* BUTTON in Baum CONFIG */
#define COIMGTRANS       73  /* BUTTON in Baum CONFIG */
#define COIMGPAL         74  /* BUTTON in Baum CONFIG */
#define COFIMG           75  /* BUTTON in Baum CONFIG */
#define COIMG            76  /* TEXT in Baum CONFIG */
#define COIMGAPPLY       77  /* BUTTON in Baum CONFIG */
#define COST2G           78  /* BOX in Baum CONFIG */
#define COUSET2G         79  /* BUTTON in Baum CONFIG */
#define COAUTOCON        80  /* BUTTON in Baum CONFIG */
#define COT2GHIST        82  /* FBOXTEXT in Baum CONFIG */
#define COTBUFNONE       86  /* BUTTON in Baum CONFIG */
#define COTBUFSIZE       87  /* BUTTON in Baum CONFIG */
#define COTBUFTIME       88  /* BUTTON in Baum CONFIG */
#define COTCOLNONE       91  /* BUTTON in Baum CONFIG */
#define COTCOLVT52       92  /* BUTTON in Baum CONFIG */
#define COTCOLVDI        93  /* BUTTON in Baum CONFIG */
#define COBUFTIME        94  /* FBOXTEXT in Baum CONFIG */
#define COTWTITLE        98  /* BOXTEXT in Baum CONFIG */
#define COTWVSLIDE       99  /* BOX in Baum CONFIG */
#define COTWHSLIDE       100 /* BOX in Baum CONFIG */
#define COSWIN2          101 /* BOX in Baum CONFIG */
#define COCASESORT       102 /* BUTTON in Baum CONFIG */
#define COCASELOC        103 /* BUTTON in Baum CONFIG */
#define COAUTOPLACE      104 /* BUTTON in Baum CONFIG */
#define COINTERACTIVE    105 /* BUTTON in Baum CONFIG */
#define COAUTOSIZEXS     106 /* STRING in Baum CONFIG */
#define COAUTOSIZEX      108 /* TEXT in Baum CONFIG */
#define COAUTOSIZEYS     109 /* STRING in Baum CONFIG */
#define COAUTOSIZEY      111 /* TEXT in Baum CONFIG */
#define COFLEFT          114 /* FBOXTEXT in Baum CONFIG */
#define COFRIGHT         116 /* FBOXTEXT in Baum CONFIG */
#define COFHOR           118 /* FBOXTEXT in Baum CONFIG */
#define COFUPPER         120 /* FBOXTEXT in Baum CONFIG */
#define COFLOWER         122 /* FBOXTEXT in Baum CONFIG */
#define COFVERT          124 /* FBOXTEXT in Baum CONFIG */
#define COHELP           125 /* BUTTON in Baum CONFIG */
#define COOK             126 /* BUTTON in Baum CONFIG */
#define COCANCEL         127 /* BUTTON in Baum CONFIG */

#define CFUNC            24  /* Formular/Dialog */
#define CFSNORM          3   /* BUTTON in Baum CFUNC */
#define CFSSHIFT         4   /* BUTTON in Baum CFUNC */
#define CFSCTRL          5   /* BUTTON in Baum CFUNC */
#define CFSALT           6   /* BUTTON in Baum CFUNC */
#define CFSTOOL          7   /* BUTTON in Baum CFUNC */
#define CFSUB            8   /* BOX in Baum CFUNC */
#define CFLIST           9   /* IBOX in Baum CFUNC */
#define CFENTRY          10  /* FBOXTEXT in Baum CFUNC */
#define CFLABEL          20  /* IBOX in Baum CFUNC */
#define CFHELP           31  /* BUTTON in Baum CFUNC */
#define CFOK             32  /* BUTTON in Baum CFUNC */
#define CFCLEAR          33  /* BUTTON in Baum CFUNC */
#define CFCANCEL         34  /* BUTTON in Baum CFUNC */

#define CHANGEREZ        25  /* Formular/Dialog */
#define CRREZS           2   /* STRING in Baum CHANGEREZ */
#define CRREZ            4   /* TEXT in Baum CHANGEREZ */
#define CRHELP           7   /* BUTTON in Baum CHANGEREZ */
#define CROK             8   /* BUTTON in Baum CHANGEREZ */
#define CRCANCEL         9   /* BUTTON in Baum CHANGEREZ */

#define WAIT             26  /* Formular/Dialog */
#define WTEXT1           1   /* TEXT in Baum WAIT */
#define WTEXT2           2   /* TEXT in Baum WAIT */
#define WFBOX            3   /* BOX in Baum WAIT */
#define WFSLIDE          4   /* BOX in Baum WAIT */
#define WFHELP           5   /* BUTTON in Baum WAIT */
#define WFCANCEL         6   /* BUTTON in Baum WAIT */

#define WAITCOPY         27  /* Formular/Dialog */
#define WCTEXT           1   /* STRING in Baum WAITCOPY */
#define WCFILES          3   /* TEXT in Baum WAITCOPY */
#define WCSTXT           4   /* STRING in Baum WAITCOPY */
#define WCSIZE           5   /* TEXT in Baum WAITCOPY */
#define WCFOLDERS        7   /* TEXT in Baum WAITCOPY */
#define WCNAMES          9   /* IBOX in Baum WAITCOPY */
#define WCSRC            10  /* TEXT in Baum WAITCOPY */
#define WCDST            11  /* TEXT in Baum WAITCOPY */
#define WCDTXT           12  /* STRING in Baum WAITCOPY */
#define WCBOX            13  /* BOX in Baum WAITCOPY */
#define WCSLIDE          14  /* BOX in Baum WAITCOPY */
#define WCHELP           15  /* BUTTON in Baum WAITCOPY */
#define WCCANCEL         16  /* BUTTON in Baum WAITCOPY */

#define SELAPP           28  /* Formular/Dialog */
#define SATITLE          1   /* STRING in Baum SELAPP */
#define SAFILE           3   /* STRING in Baum SELAPP */
#define SALIST           6   /* BOX in Baum SELAPP */
#define SAUP             12  /* BUTTON in Baum SELAPP */
#define SABOX            13  /* BOX in Baum SELAPP */
#define SASLIDE          14  /* BUTTON in Baum SELAPP */
#define SADOWN           15  /* BUTTON in Baum SELAPP */
#define SAHELP           16  /* BUTTON in Baum SELAPP */
#define SAOK             17  /* BUTTON in Baum SELAPP */
#define SACANCEL         18  /* BUTTON in Baum SELAPP */

#define GROUPINFO        29  /* Formular/Dialog */
#define GITITLE          3   /* FBOXTEXT in Baum GROUPINFO */
#define GIFILE           5   /* STRING in Baum GROUPINFO */
#define GIAUTOSAVE       6   /* BUTTON in Baum GROUPINFO */
#define GIGETATTR        7   /* BUTTON in Baum GROUPINFO */
#define GIAUTOCLOSE      8   /* BUTTON in Baum GROUPINFO */
#define GIPARENT         10  /* FBOXTEXT in Baum GROUPINFO */
#define GIFUNCS          11  /* STRING in Baum GROUPINFO */
#define GIFUNC           13  /* TEXT in Baum GROUPINFO */
#define GIHELP           14  /* BUTTON in Baum GROUPINFO */
#define GIOK             15  /* BUTTON in Baum GROUPINFO */
#define GICANCEL         16  /* BUTTON in Baum GROUPINFO */

#define GOBINFO          30  /* Formular/Dialog */
#define GETITLE          3   /* FBOXTEXT in Baum GOBINFO */
#define GEPATH           5   /* STRING in Baum GOBINFO */
#define GEENTRY          7   /* FBOXTEXT in Baum GOBINFO */
#define GEPARALWAYS      9   /* BUTTON in Baum GOBINFO */
#define GEPARAM          10  /* FBOXTEXT in Baum GOBINFO */
#define GEHELP           11  /* BUTTON in Baum GOBINFO */
#define GEOK             12  /* BUTTON in Baum GOBINFO */
#define GESKIP           13  /* BUTTON in Baum GOBINFO */
#define GECANCEL         14  /* BUTTON in Baum GOBINFO */

#define POPREZ           31  /* Formular/Dialog */

#define POPCOLOR         32  /* Formular/Dialog */

#define POPPAT           33  /* Formular/Dialog */

#define POPSHORT         34  /* Formular/Dialog */

#define POPFSHORT        35  /* Formular/Dialog */

#define POPCONTEXT       36  /* Formular/Dialog */
#define POPCOPEN         1   /* STRING in Baum POPCONTEXT */
#define POPCDIROPEN      2   /* STRING in Baum POPCONTEXT */
#define POPCINFO         3   /* STRING in Baum POPCONTEXT */
#define POPCVIEW         5   /* STRING in Baum POPCONTEXT */
#define POPCPRINT        6   /* STRING in Baum POPCONTEXT */
#define POPCSENDTO       8   /* STRING in Baum POPCONTEXT */
#define POPCDEL          10  /* STRING in Baum POPCONTEXT */
#define POPCCOPY         12  /* STRING in Baum POPCONTEXT */
#define POPCCUT          13  /* STRING in Baum POPCONTEXT */
#define POPCAPPL         15  /* STRING in Baum POPCONTEXT */

#define POPICONTEXT      37  /* Formular/Dialog */
#define POPICOPEN        1   /* STRING in Baum POPICONTEXT */
#define POPICINFO        2   /* STRING in Baum POPICONTEXT */
#define POPICEJECT       4   /* STRING in Baum POPICONTEXT */
#define POPICFORMAT      6   /* STRING in Baum POPICONTEXT */
#define POPICDEL         8   /* STRING in Baum POPICONTEXT */

#define POPCWINDOW       38  /* Formular/Dialog */
#define POPCWNEW         1   /* STRING in Baum POPCWINDOW */
#define POPCWINFO        2   /* STRING in Baum POPCWINDOW */
#define POPCWEJECT       4   /* STRING in Baum POPCWINDOW */
#define POPCWUPDATE      6   /* STRING in Baum POPCWINDOW */
#define POPCWPASTE       8   /* STRING in Baum POPCWINDOW */
#define POPCWSHOW        10  /* STRING in Baum POPCWINDOW */
#define POPCWSORT        12  /* STRING in Baum POPCWINDOW */
#define POPCWMASK        14  /* STRING in Baum POPCWINDOW */
#define POPCWFONT        15  /* STRING in Baum POPCWINDOW */
#define POPCWSAVEINDEX   17  /* STRING in Baum POPCWINDOW */

#define POPCGRPWIN       39  /* Formular/Dialog */
#define POPCGNEW         1   /* STRING in Baum POPCGRPWIN */
#define POPCGINFO        2   /* STRING in Baum POPCGRPWIN */
#define POPCGSAVEGROUP   4   /* STRING in Baum POPCGRPWIN */
#define POPCGSHOW        6   /* STRING in Baum POPCGRPWIN */
#define POPCGFONT        8   /* STRING in Baum POPCGRPWIN */

#define POPPMEM          40  /* Formular/Dialog */

#define POPSORT          41  /* Formular/Dialog */
#define POPSORTREV       1   /* STRING in Baum POPSORT */
#define POPSORTFOLD      2   /* STRING in Baum POPSORT */
#define POPSORTNAME      4   /* STRING in Baum POPSORT */
#define POPSORTSIZE      5   /* STRING in Baum POPSORT */
#define POPSORTDATE      6   /* STRING in Baum POPSORT */
#define POPSORTEXT       7   /* STRING in Baum POPSORT */
#define POPSORTNONE      8   /* STRING in Baum POPSORT */

#define POPSHOW          42  /* Formular/Dialog */
#define POPSHOWTEXT      1   /* STRING in Baum POPSHOW */
#define POPSHOWSYMTEXT   2   /* STRING in Baum POPSHOW */
#define POPSHOWICONS     3   /* STRING in Baum POPSHOW */

#define POPAUTOSIZE      43  /* Formular/Dialog */

#define ICONS            44  /* Formular/Dialog */
#define DUMMYICON        1   /* ICON in Baum ICONS */
#define SDUMMYICON       2   /* ICON in Baum ICONS */

#define NEWOBJ           45  /* Formular/Dialog */
#define NOFOLD           4   /* BUTTON in Baum NEWOBJ */
#define NOFILE           5   /* BUTTON in Baum NEWOBJ */
#define NOGROUP          6   /* BUTTON in Baum NEWOBJ */
#define NOLINK           7   /* BUTTON in Baum NEWOBJ */
#define NOSUB            8   /* IBOX in Baum NEWOBJ */
#define NOSGROUP         9   /* BUTTON in Baum NEWOBJ */
#define NGPATH           11  /* STRING in Baum NEWOBJ */
#define NGFILE           14  /* FTEXT in Baum NEWOBJ */
#define NGTITLE          17  /* FBOXTEXT in Baum NEWOBJ */
#define NGAUTOSAVE       18  /* BUTTON in Baum NEWOBJ */
#define NGICON           19  /* BUTTON in Baum NEWOBJ */
#define NOSFILE          20  /* BUTTON in Baum NEWOBJ */
#define NFPATH           21  /* STRING in Baum NEWOBJ */
#define NFNAME           22  /* FBOXTEXT in Baum NEWOBJ */
#define NOSLINK          25  /* BUTTON in Baum NEWOBJ */
#define NSPATH           27  /* STRING in Baum NEWOBJ */
#define NSABS            28  /* BUTTON in Baum NEWOBJ */
#define NSREL            29  /* BUTTON in Baum NEWOBJ */
#define NSRDESC          30  /* STRING in Baum NEWOBJ */
#define NSASEL           31  /* BUTTON in Baum NEWOBJ */
#define NSRDEST          32  /* FBOXTEXT in Baum NEWOBJ */
#define NSADEST          33  /* TEXT in Baum NEWOBJ */
#define NSNAME           35  /* FBOXTEXT in Baum NEWOBJ */
#define NOHELP           36  /* BUTTON in Baum NEWOBJ */
#define NOOK             37  /* BUTTON in Baum NEWOBJ */
#define NOCANCEL         38  /* BUTTON in Baum NEWOBJ */

#define ICONWIN          46  /* Formular/Dialog */

#define ICONDIAL         47  /* Formular/Dialog */

#define ICONPATH         48  /* Formular/Dialog */

#define ICONCON          49  /* Formular/Dialog */

#define HOTKEYS          50  /* Formular/Dialog */
#define HKLOCATE         3   /* FBOXTEXT in Baum HOTKEYS */
#define HKLIST           4   /* BOX in Baum HOTKEYS */
#define HKUP             15  /* BUTTON in Baum HOTKEYS */
#define HKBOX            16  /* BOX in Baum HOTKEYS */
#define HKSLIDE          17  /* BUTTON in Baum HOTKEYS */
#define HKDOWN           18  /* BUTTON in Baum HOTKEYS */
#define HKHELP           19  /* BUTTON in Baum HOTKEYS */
#define HKCLOSE          20  /* BUTTON in Baum HOTKEYS */
#define HKNEW            21  /* BUTTON in Baum HOTKEYS */
#define HKCHANGE         22  /* BUTTON in Baum HOTKEYS */
#define HKDELETE         23  /* BUTTON in Baum HOTKEYS */

#define CHOOSEHOTKEY     51  /* Formular/Dialog */
