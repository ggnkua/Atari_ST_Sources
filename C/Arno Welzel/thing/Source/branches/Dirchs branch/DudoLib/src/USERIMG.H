/* Resource Datei Indizes f�r USERIMG */

#define USERIMG  0   /* Formular/Dialog */
#define CBHNORMDIS 1   /* IMAGE in Baum USERIMG */
#define CBHSELDIS 2   /* IMAGE in Baum USERIMG */
#define CBHSEL   3   /* IMAGE in Baum USERIMG */
#define AUHNORM  4   /* IMAGE in Baum USERIMG */
#define AUHSEL   5   /* IMAGE in Baum USERIMG */
#define ADHNORM  6   /* IMAGE in Baum USERIMG */
#define ADHSEL   7   /* IMAGE in Baum USERIMG */
#define ARHNORM  8   /* IMAGE in Baum USERIMG */
#define ARHSEL   9   /* IMAGE in Baum USERIMG */
#define ALHNORM  10  /* IMAGE in Baum USERIMG */
#define ALHSEL   11  /* IMAGE in Baum USERIMG */
#define CBLNORMDIS 12  /* IMAGE in Baum USERIMG */
#define CBLSELDIS 13  /* IMAGE in Baum USERIMG */
#define CBLSEL   14  /* IMAGE in Baum USERIMG */
#define RBHNORM  15  /* IMAGE in Baum USERIMG */
#define RBHNORMDIS 16  /* IMAGE in Baum USERIMG */
#define RBHSEL   17  /* IMAGE in Baum USERIMG */
#define RBHSELDIS 18  /* IMAGE in Baum USERIMG */
#define RBLNORM  19  /* IMAGE in Baum USERIMG */
#define RBLNORMDIS 20  /* IMAGE in Baum USERIMG */
#define RBLSEL   21  /* IMAGE in Baum USERIMG */
#define RBLSELDIS 22  /* IMAGE in Baum USERIMG */
#define RBLSEL_BGRD_3D 23  /* IMAGE in Baum USERIMG */
#define AUHNORMDIS 24  /* IMAGE in Baum USERIMG */
#define ADHNORMDIS 25  /* IMAGE in Baum USERIMG */
#define ARHNORMDIS 26  /* IMAGE in Baum USERIMG */
#define ALHNORMDIS 27  /* IMAGE in Baum USERIMG */
#define RBHNORM_BGRD_3D 28  /* IMAGE in Baum USERIMG */
#define RBHNORM_BGRD_LB 29  /* IMAGE in Baum USERIMG */
#define RBHSEL_BGRD_3D 30  /* IMAGE in Baum USERIMG */
#define RBHSEL_BGRD_LB 31  /* IMAGE in Baum USERIMG */
#define RBLNORM_BGRD_3D 32  /* IMAGE in Baum USERIMG */
#define RBLNORM_BGRD_LB 33  /* IMAGE in Baum USERIMG */
#define RBLSEL_BGRD_LB 34  /* IMAGE in Baum USERIMG */
