/**
 * DudoLib - Dirchs user defined object library
 * Copyright (C) 1994-2012 Dirk Klemmt
 *
 * This program is free software: you can redistribute it and/or
 * modify it under the terms of the GNU Lesser General Public
 * License as published by the Free Software Foundation, either
 * version 3 of the License, or (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE. See the
 * GNU Lesser General Public License for more details.
 *
 * You should have received a copy of the GNU Lesser General Public
 * License along with this program. If not, see
 * <http://www.gnu.org/licenses/>.
 *
 * @copyright  Dirk Klemmt 1994-2012
 * @author     Dirk Klemmt
 * @license    LGPL
 */

#include <string.h>
#include "..\include\dudolib.h"

/**
 * Liefert das Eltern-Objekt zu dem uebergebenen Objekt.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index im Objekt-Baum
 */
WORD getObjectParent(OBJECT *objectTree, WORD objectIdx) {
	WORD i;

	/* Root-Objekt hat kein Eltern-Object */
	if (objectIdx == 0)
		return (NIL);

	for (i = objectIdx;; i = objectTree[i].ob_next) {
		/* Falls ob_tail des naechsten Objekts das aktuelle ist, so ist dies das Eltern-Objekt */
		if (objectTree[objectTree[i].ob_next].ob_tail == i)
			return (objectTree[i].ob_next);
	}
}

/**
 * Diese Methode liefert den Text, der in der Objekt-Struktur hinterlegt ist. Handelt es
 * sich um ein benutzerdefiniertes Objekt wird der Wert nur dann zurueck gegeben, wenn
 * es eines meiner Bibliothek ist.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Text-Objekts im Objekt-Baum
 */
BYTE *getObjectText(OBJECT *objectTree, WORD objectIdx) {
	UBPARM *ubparm;

	if (objectTree == NULL)
		return ("ERROR: no object tree given!");

	switch (objectTree[objectIdx].ob_type & 0xFF) {
	case G_BOX:
	case G_IBOX:
	case G_BOXCHAR:
		return ((BYTE *) objectTree[objectIdx].ob_spec.obspec.character);

	case G_STRING:
	case G_BUTTON:
		return (objectTree[objectIdx].ob_spec.free_string);

	case G_TEXT:
	case G_BOXTEXT:
	case G_FTEXT:
	case G_FBOXTEXT:
		return (objectTree[objectIdx].ob_spec.tedinfo->te_ptext);

	case G_USERDEF:
		ubparm = (UBPARM *) objectTree[objectIdx].ob_spec.userblk->ub_parm;
		if (ubparm->magic == 'DIRK')
			return (ubparm->text);

	default:
		return ("WARNING: unsupported object type!");
	}
}

/**
 * Diese Methode setzt den Text, der in der Objekt-Struktur hinterlegt werden soll.
 * Dabei muss der Speicherbereich fuer den Text bereits alloziert worden sein!
 *
 * Handelt es sich um ein benutzerdefiniertes Objekt wird der Text nur dann gesetzt,
 * wenn es eines meiner Bibliothek ist. Dieser Speicherbereich wird alloziert.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Text-Objekts im Objekt-Baum
 * @param *text
 */
WORD setObjectText(OBJECT *objectTree, WORD objectIdx, BYTE *text) {
	UBPARM *ubparm;

	if (objectTree == NULL)
		return (USR_NOOBJECT);

	switch (objectTree[objectIdx].ob_type & 0xFF) {
	case G_BOX:
	case G_IBOX:
	case G_BOXCHAR:
		objectTree[objectIdx].ob_spec.obspec.character = text[0];
		break;

	case G_STRING:
	case G_BUTTON:
		objectTree[objectIdx].ob_spec.free_string = text;
		break;

	case G_TEXT:
	case G_BOXTEXT:
	case G_FTEXT:
	case G_FBOXTEXT:
		objectTree[objectIdx].ob_spec.tedinfo->te_ptext = text;
		break;

	case G_USERDEF:
		ubparm = (UBPARM *) objectTree[objectIdx].ob_spec.userblk->ub_parm;
		if (ubparm->magic == 'DIRK') {
			ubparm->text = (BYTE *) realloc(ubparm->text, strlen(text) + 1);
			if (ubparm->text == NULL)
				return (USR_OUTOFMEMORY);

			strcpy(ubparm->text, text);
		} else {
			return (USR_UNKNOWNUSERDEF);
		}
		break;
	}

	return (USR_NOERROR);
}

/**
 * Mit dieser Methode kann man die Werte der Variablen 'ob_flags' eines Elements in der Objekt-
 * Struktur auf eine uebergebene Statusmaske testen.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts
 * @param objectFlags zu testende Statusmaske (ob_flags) des Objekts
 * @returns TRUE - Stati gesetzt ((ob_flags & objectFlags) != 0), FALSE - Stati nicht gesetzt ((ob_flags & objectFlags) == 0)
 */
BOOLEAN getObjectFlags(OBJECT *objectTree, WORD objectIdx, BOOLEAN objectFlags) {
	return (!!(objectTree[objectIdx].ob_flags & objectFlags));
}

/**
 * Mit dieser Methode kann man die Werte der Variablen 'ob_flags' eines Elements in der Objekt-
 * Struktur setzen oder loeschen.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts, dessen Werte gesetzt oder geloescht werden sollen
 * @param ob_flags der zu setzende oder loeschende Wert
 * @param set TRUE - setzen, FALSE loeschen
 */
void setObjectFlags(OBJECT *objectTree, WORD objectIdx, WORD objectFlags, BOOLEAN set) {
	if (set == TRUE)
		objectTree[objectIdx].ob_flags |= objectFlags;
	else
		objectTree[objectIdx].ob_flags &= ~objectFlags;
}

/**
 * Mit dieser Methode kann man die Werte der Variablen 'ob_state' eines Elements in der Objekt-
 * Struktur auf eine uebergebene Statusmaske testen.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts
 * @param objectState zu testende Statusmaske (ob_state) des Objekts
 * @returns TRUE - Stati gesetzt ((ob_state & objectState) != 0), FALSE - Stati nicht gesetzt ((ob_state & objectState) == 0)
 */
BOOLEAN getObjectState(OBJECT *objectTree, WORD objectIdx, BOOLEAN objectState) {
	return (!!(objectTree[objectIdx].ob_state & objectState));
}

/**
 * Mit dieser Methode kann man die Werte der Variablen 'ob_state' eines Elements in der Objekt-
 * Struktur auf den Status SELECTED testen.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts
 * @returns TRUE - Objekt selektiert, FALSE - sonst
 */
BOOLEAN isObjectSelected(OBJECT *objectTree, WORD objectIdx) {
	return (!!(objectTree[objectIdx].ob_state & SELECTED));
}

/**
 * Mit dieser Methode kann man die Werte der Variablen 'ob_state' eines Elements in der Objekt-
 * Struktur auf den Status DISABLED testen.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts
 * @returns TRUE - Objekt disabled, FALSE - sonst
 */
BOOLEAN isObjectDisabled(OBJECT *objectTree, WORD objectIdx) {
	return (!!(objectTree[objectIdx].ob_state & DISABLED));
}

/**
 * Mit dieser Methode kann man die Werte der Variablen 'ob_state' eines Elements in der Objekt-
 * Struktur setzen oder loeschen.
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts, dessen Werte gesetzt  werden sollen
 * @param objectState die zu setzenden Werte
 * @param set TRUE - objectState wird gesetzt, FALSE - objectState wird geloescht
 */
void setObjectState(OBJECT *objectTree, WORD objectIdx, WORD objectState, BOOLEAN set) {
	if (set == TRUE)
		objectTree[objectIdx].ob_state |= objectState;
	else
		objectTree[objectIdx].ob_state &= ~objectState;
}

/*
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts, dessen Werte gesetzt  werden sollen
 */
void setObjectSelected(OBJECT *objectTree, WORD objectIdx) {
	objectTree[objectIdx].ob_state |= SELECTED;
}

/*
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts, dessen Werte gesetzt  werden sollen
 */
void unsetObjectSelected(OBJECT *objectTree, WORD objectIdx) {
	objectTree[objectIdx].ob_state &= ~SELECTED;
}

/*
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts, dessen Werte gesetzt  werden sollen
 */
void setObjectDisabled(OBJECT *objectTree, WORD objectIdx) {
	objectTree[objectIdx].ob_state |= DISABLED;
}

/*
 *
 * @param *objectTree Zeiger auf Objekt-Baum
 * @param objectIdx Objekt-Index des Objekts, dessen Werte gesetzt  werden sollen
 */
void unsetObjectDisabled(OBJECT *objectTree, WORD objectIdx) {
	objectTree[objectIdx].ob_state &= ~DISABLED;
}
