/* resource set indicies for TETRIS */

#define MENMENU  0	/* menu tree */
#define MENDESK  3	/* TITLE in tree MENMENU */
#define MENFILE  4	/* TITLE in tree MENMENU */
#define MENINFO  7	/* STRING in tree MENMENU */
#define MENGO    16	/* STRING in tree MENMENU */
#define MENLOOK  17	/* STRING in tree MENMENU */
#define MENSCORE 18	/* STRING in tree MENMENU */
#define MENQUICK 20	/* STRING in tree MENMENU */
#define MENSCR   21	/* STRING in tree MENMENU */
#define MENCOLOR 22	/* STRING in tree MENMENU */
#define MENTAST  23	/* STRING in tree MENMENU */
#define MENQUIT  25	/* STRING in tree MENMENU */

#define INFOF    1	/* form/dialog */
#define INFOVERS 3	/* STRING in tree INFOF */

#define BESTF    2	/* form/dialog */
#define B1       2	/* FTEXT in tree BESTF */
#define B2       3	/* FTEXT in tree BESTF */
#define B3       4	/* FTEXT in tree BESTF */
#define B4       5	/* FTEXT in tree BESTF */
#define B5       6	/* FTEXT in tree BESTF */
#define B6       7	/* FTEXT in tree BESTF */
#define B7       8	/* FTEXT in tree BESTF */
#define B8       9	/* FTEXT in tree BESTF */
#define B9       10	/* FTEXT in tree BESTF */
#define B10      11	/* FTEXT in tree BESTF */
#define S1       12	/* FTEXT in tree BESTF */
#define S2       13	/* FTEXT in tree BESTF */
#define S4       15	/* FTEXT in tree BESTF */
#define S5       16	/* FTEXT in tree BESTF */
#define S6       17	/* FTEXT in tree BESTF */
#define S7       18	/* FTEXT in tree BESTF */
#define S8       19	/* FTEXT in tree BESTF */
#define S9       20	/* FTEXT in tree BESTF */
#define S10      21	/* FTEXT in tree BESTF */
#define BNAME    22	/* FTEXT in tree BESTF */
#define BSPEED   24	/* STRING in tree BESTF */

