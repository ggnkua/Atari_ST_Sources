/* Resource Datei Indizes f�r EULER */

#define MENU     0   /* Menuebaum */
#define MINFO    8   /* STRING in Baum MENU */
#define MLOAD    17  /* STRING in Baum MENU */
#define MDUMP    18  /* STRING in Baum MENU */
#define MDUMPOFF 19  /* STRING in Baum MENU */
#define MFILE    20  /* STRING in Baum MENU */
#define MCD      21  /* STRING in Baum MENU */
#define MDIR     22  /* STRING in Baum MENU */
#define MSIZE    24  /* STRING in Baum MENU */
#define MSTEXT   25  /* STRING in Baum MENU */
#define MSGRAPH  26  /* STRING in Baum MENU */
#define MCONFIG  27  /* STRING in Baum MENU */
#define MQUIT    29  /* STRING in Baum MENU */
#define MLONG    31  /* STRING in Baum MENU */
#define MSHORT   32  /* STRING in Baum MENU */
#define MSHRINK  33  /* STRING in Baum MENU */
#define MFULL    34  /* STRING in Baum MENU */
#define MLIST    35  /* STRING in Baum MENU */
#define MRESET   36  /* STRING in Baum MENU */
#define MCLS     37  /* STRING in Baum MENU */
#define MCLG     38  /* STRING in Baum MENU */
#define MLDEMO   40  /* STRING in Baum MENU */
#define MLHELP   41  /* STRING in Baum MENU */
#define MEXEDIT  43  /* STRING in Baum MENU */
#define MLFILE   44  /* STRING in Baum MENU */

#define FINFO    1   /* Formular/Dialog */

#define FSIZE    2   /* Formular/Dialog */
#define SSIZE    1   /* FTEXT in Baum FSIZE */
#define SABORT   3   /* BUTTON in Baum FSIZE */
