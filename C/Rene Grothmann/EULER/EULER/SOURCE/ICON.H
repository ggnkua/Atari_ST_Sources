#define icon_width 50
#define icon_height 50
#define icon_x_hot -1
#define icon_y_hot -1
static char icon_bits[] = {
   0x00, 0x80, 0x4a, 0x19, 0x00, 0x00, 0x00, 0x00, 0x80, 0xda, 0x1d, 0x00,
   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
   0x00, 0x00, 0x00, 0x00, 0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x04,
   0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80,
   0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
   0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
   0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0xfe, 0x80, 0x00,
   0x04, 0x3c, 0x00, 0xc0, 0x01, 0x87, 0x00, 0x04, 0xc3, 0x00, 0x30, 0x00,
   0x98, 0x00, 0x84, 0x00, 0x01, 0x0c, 0x00, 0xe0, 0x00, 0x84, 0x00, 0x02,
   0x02, 0x00, 0x80, 0x00, 0x44, 0x00, 0x02, 0x01, 0x00, 0x80, 0x00, 0x44,
   0x00, 0x84, 0x00, 0x00, 0x80, 0x00, 0x24, 0x00, 0x48, 0x00, 0x00, 0x80,
   0x00, 0x24, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x14, 0x00, 0x10, 0x00,
   0x00, 0x80, 0x00, 0x14, 0x00, 0x28, 0x00, 0x00, 0x80, 0x00, 0x0c, 0x00,
   0x44, 0x00, 0x00, 0x80, 0x00, 0x0c, 0x00, 0x42, 0x00, 0x00, 0x80, 0x00,
   0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x04, 0x00, 0x81, 0x00, 0x00,
   0x80, 0x00, 0x04, 0x80, 0x00, 0x01, 0x00, 0xc0, 0x00, 0x04, 0x40, 0x00,
   0x02, 0x00, 0xc0, 0x00, 0x04, 0x20, 0x00, 0x02, 0x00, 0xa0, 0x00, 0x04,
   0x10, 0x00, 0x04, 0x00, 0x90, 0x00, 0x04, 0x08, 0x00, 0x08, 0x00, 0x90,
   0x00, 0x04, 0x04, 0x00, 0x08, 0x00, 0x88, 0x00, 0x04, 0x02, 0x00, 0x10,
   0x00, 0x88, 0x00, 0x04, 0x01, 0x00, 0x20, 0x00, 0x84, 0x00, 0x84, 0x00,
   0x00, 0x40, 0x00, 0x82, 0x00, 0x64, 0x00, 0x00, 0x80, 0x00, 0x81, 0x00,
   0x1c, 0x00, 0x00, 0x00, 0xc3, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3c,
   0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
   0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04,
   0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80,
   0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
   0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
   0x00, 0x00, 0x00, 0x80, 0x00, 0xfc, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00,
   0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
   0x00, 0x00};
