#define RSRC 0
#define STRINGS 3
