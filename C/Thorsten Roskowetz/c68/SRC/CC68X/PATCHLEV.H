#define MAJOR_VERSION	0
#define MINOR_VERSION	0
#define PATCH_LEVEL	2
