#define WORD short int                  /* 16-Bit word */

#define WORD_MIN SHRT_MIN    	          /* Minimum value of a 16-Bit word. */
#define WORD_MAX SHRT_MAX 	  	        /* Maximum              "          */

#define	SCAN_ZERO '0'										/* ASCII Code of <<0>>, Type: char needed. */

#define PATHLEN 256+1                   /* max. Pathlength, if you need more. */
