/* resource file indicies for DEGAS2PS */

#define MENU     0	/* menu tree */
#define COPY     8	/* STRING in tree MENU */
#define OUVRIR   17	/* STRING in tree MENU */
#define EDITER   18	/* STRING in tree MENU */
#define IMPRIMER 20	/* STRING in tree MENU */
#define AIDE     22	/* STRING in tree MENU */
#define QUITTER  24	/* STRING in tree MENU */

#define COPYRIG  1	/* form/dialog */
#define MERCI    4	/* BUTTON in tree COPYRIG */
#define NUMVER   6	/* FBOXTEXT in tree COPYRIG */

#define SORTIE   2	/* form/dialog */
#define FICHIER  1	/* BUTTON in tree SORTIE */
#define ANN1     2	/* BUTTON in tree SORTIE */
#define LASER    3	/* BUTTON in tree SORTIE */
#define PRINTER  6	/* BUTTON in tree SORTIE */

#define FORMAT   3	/* form/dialog */
#define REEL     3	/* BOXCHAR in tree FORMAT */
#define CUSTOM   4	/* BOXCHAR in tree FORMAT */
#define TREELTXT 5	/* TEXT in tree FORMAT */
#define TMAXTXT  7	/* TEXT in tree FORMAT */
#define PERSOTXT 8	/* TEXT in tree FORMAT */
#define AUTO     9	/* BOXCHAR in tree FORMAT */
#define COPIE    11	/* FTEXT in tree FORMAT */
#define MOINS    13	/* BOXCHAR in tree FORMAT */
#define PLUS     14	/* BOXCHAR in tree FORMAT */
#define REDUC    15	/* FTEXT in tree FORMAT */
#define LARGEUR  17	/* FTEXT in tree FORMAT */
#define HAUTEUR  19	/* FTEXT in tree FORMAT */
#define ANN2     22	/* BUTTON in tree FORMAT */
#define PRINT    23	/* BUTTON in tree FORMAT */
#define PORTXT   26	/* TEXT in tree FORMAT */
#define PORTRAIT 27	/* BOXCHAR in tree FORMAT */
#define PAYTXT   28	/* TEXT in tree FORMAT */
#define PAYSAGE  29	/* BOXCHAR in tree FORMAT */
#define LATEX    31	/* BOXCHAR in tree FORMAT */
#define NOLATEX  32	/* BOXCHAR in tree FORMAT */

#define ANNONCE  4	/* form/dialog */
#define PHRASE1  2	/* FTEXT in tree ANNONCE */
#define PHRASE2  3	/* FTEXT in tree ANNONCE */
#define PHRASE3  4	/* FTEXT in tree ANNONCE */
#define PHRASE4  5	/* FTEXT in tree ANNONCE */
#define CADRE    13	/* BOX in tree ANNONCE */
#define BOITE    14	/* BOX in tree ANNONCE */

#define HELP     5	/* form/dialog */
#define OUT      16	/* BUTTON in tree HELP */

