#define Lmemset
#include "bzero.S"
