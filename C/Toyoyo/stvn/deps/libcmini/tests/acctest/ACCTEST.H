/* Resource Datei Indizes f�r ACCTEST */

#define MAIN             0   /* Formular/Dialog */
