/*
	<tos.h>
	This header is "Public Domain".
	(P) 1992 by Markus M. Nick
	
	This header makes it easier to compile sources with both PureC/TurboC 
	and GNU-CC.  Now you needn't include different header files any more.
	
	Please send your comments and suggestions to:
		Markus_Nick@mz.maus.de
*/

#ifndef __TOS__

#include <osbind.h>

#define __TOS__
#endif
