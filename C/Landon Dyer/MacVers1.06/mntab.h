#ifdef DEF_MN
/*
 *  Keyword definitions
 */
#define	MN__6502	2
#define	MN__68000	3
#define	MN__ABS	7
#define	MN__ASSERT	28
#define	MN__BSS	4
#define	MN__CARGS	10
#define	MN__COMM	8
#define	MN__DATA	5
#define	MN__DC	12
#define	MN__DCB	17
#define	MN__DISABLE	22
#define	MN__DS	13
#define	MN__DUMP	20
#define	MN__EJECT	46
#define	MN__ELSE	501
#define	MN__ENABLE	23
#define	MN__END	34
#define	MN__ENDIF	502
#define	MN__ENDM	505
#define	MN__ENDR	507
#define	MN__ERROR	47
#define	MN__EVEN	1
#define	MN__EXITM	510
#define	MN__EXTERN	24
#define	MN__GLOBL	24
#define	MN__GOTO	11
#define	MN__IF	500
#define	MN__IIF	503
#define	MN__INCLUDE	33
#define	MN__INIT	9
#define	MN__LIST	38
#define	MN__LOAD	21
#define	MN__MACRO	504
#define	MN__NLIST	39
#define	MN__ORG	0
#define	MN__REPT	506
#define	MN__SUBTTL	45
#define	MN__TEXT	6
#define	MN__TITLE	44
#define	MN__UNDEFMAC	14
#define	MN__WARN	48
#define	MN_ABCD	1001
#define	MN_ABS	7
#define	MN_ADD	1003
#define	MN_ADDA	1005
#define	MN_ADDI	1006
#define	MN_ADDQ	1007
#define	MN_ADDX	1008
#define	MN_AND	1010
#define	MN_ANDI	1012
#define	MN_ASL	1015
#define	MN_ASR	1019
#define	MN_ASSERT	28
#define	MN_BCC	1023
#define	MN_BCHG	1037
#define	MN_BCLR	1041
#define	MN_BCS	1024
#define	MN_BEQ	1025
#define	MN_BGE	1026
#define	MN_BGT	1027
#define	MN_BHI	1028
#define	MN_BHS	1023
#define	MN_BLE	1029
#define	MN_BLO	1024
#define	MN_BLS	1030
#define	MN_BLT	1031
#define	MN_BMI	1032
#define	MN_BNE	1033
#define	MN_BNZ	1033
#define	MN_BPL	1034
#define	MN_BRA	1045
#define	MN_BSET	1046
#define	MN_BSR	1050
#define	MN_BSS	4
#define	MN_BT	1045
#define	MN_BTST	1051
#define	MN_BVC	1035
#define	MN_BVS	1036
#define	MN_BZ	1025
#define	MN_BZE	1025
#define	MN_CARGS	10
#define	MN_CHK	1055
#define	MN_CLR	1056
#define	MN_CMP	1058
#define	MN_CMPA	1060
#define	MN_CMPI	1061
#define	MN_CMPM	1062
#define	MN_COMM	8
#define	MN_DATA	5
#define	MN_DBCC	1063
#define	MN_DBCS	1064
#define	MN_DBEQ	1065
#define	MN_DBF	1066
#define	MN_DBGE	1067
#define	MN_DBGT	1068
#define	MN_DBHI	1069
#define	MN_DBHS	1069
#define	MN_DBLE	1070
#define	MN_DBLO	1064
#define	MN_DBLS	1071
#define	MN_DBLT	1072
#define	MN_DBMI	1073
#define	MN_DBNE	1074
#define	MN_DBNZ	1074
#define	MN_DBPL	1075
#define	MN_DBRA	1066
#define	MN_DBT	1076
#define	MN_DBVC	1077
#define	MN_DBVS	1078
#define	MN_DBZE	1065
#define	MN_DC	12
#define	MN_DCB	17
#define	MN_DISABLE	22
#define	MN_DIVS	1079
#define	MN_DIVU	1080
#define	MN_DS	13
#define	MN_DUMP	20
#define	MN_EJECT	46
#define	MN_ELSE	501
#define	MN_ENABLE	23
#define	MN_END	34
#define	MN_ENDIF	502
#define	MN_ENDM	505
#define	MN_ENDR	507
#define	MN_EOR	1081
#define	MN_EORI	1082
#define	MN_ERROR	47
#define	MN_EVEN	1
#define	MN_EXG	1085
#define	MN_EXITM	510
#define	MN_EXT	1086
#define	MN_EXTERN	24
#define	MN_GLOBL	24
#define	MN_GOTO	11
#define	MN_IF	500
#define	MN_IIF	503
#define	MN_ILLEGAL	1088
#define	MN_INCLUDE	33
#define	MN_INIT	9
#define	MN_JMP	1089
#define	MN_JSR	1090
#define	MN_LEA	1091
#define	MN_LINK	1092
#define	MN_LIST	38
#define	MN_LOAD	21
#define	MN_LSL	1093
#define	MN_LSR	1097
#define	MN_MACRO	504
#define	MN_MOVE	1101
#define	MN_MOVEA	1108
#define	MN_MOVEM	1109
#define	MN_MOVEP	1110
#define	MN_MOVEQ	1112
#define	MN_MULS	1113
#define	MN_MULU	1114
#define	MN_NBCD	1115
#define	MN_NEG	1116
#define	MN_NEGX	1117
#define	MN_NLIST	39
#define	MN_NOP	1118
#define	MN_NOT	1119
#define	MN_OR	1120
#define	MN_ORG	0
#define	MN_ORI	1122
#define	MN_PEA	1125
#define	MN_REPT	506
#define	MN_RESET	1126
#define	MN_ROL	1127
#define	MN_ROR	1131
#define	MN_ROXL	1135
#define	MN_ROXR	1139
#define	MN_RTE	1143
#define	MN_RTR	1144
#define	MN_RTS	1145
#define	MN_SBCD	1146
#define	MN_SCC	1148
#define	MN_SCS	1149
#define	MN_SEQ	1150
#define	MN_SF	1151
#define	MN_SGE	1152
#define	MN_SGT	1153
#define	MN_SHI	1154
#define	MN_SHS	1148
#define	MN_SLE	1155
#define	MN_SLO	1149
#define	MN_SLS	1156
#define	MN_SLT	1157
#define	MN_SMI	1158
#define	MN_SNE	1159
#define	MN_SNZ	1159
#define	MN_SPL	1160
#define	MN_ST	1161
#define	MN_STOP	1164
#define	MN_SUB	1165
#define	MN_SUBA	1167
#define	MN_SUBI	1168
#define	MN_SUBQ	1169
#define	MN_SUBTTL	45
#define	MN_SUBX	1170
#define	MN_SVC	1162
#define	MN_SVS	1163
#define	MN_SWAP	1172
#define	MN_SZE	1150
#define	MN_TAS	1173
#define	MN_TEXT	6
#define	MN_TITLE	44
#define	MN_TRAP	1174
#define	MN_TRAPV	1175
#define	MN_TST	1176
#define	MN_UNDEFMAC	14
#define	MN_UNLK	1177
#define	MN_WARN	48
#endif

#ifdef DECL_MN
/*
 *  keyword state-machine tables
 *
 */

int mnbase[300] = {
 0, 23, 43, 47, 63, 78, 74, 19,
 94, 20, 86, 89, 107, 4, 1, 106,
 122, 132, 3, 7, 0, 49, 10, 55,
 146, 142, 62, 109, 98, 10, 28, 30,
 44, 32, 111, 44, 71, 143, 78, 79,
 151, 165, 68, 97, 152, 167, 84, 127,
 82, 113, 170, 112, 155, 134, 122, 146,
 141, 160, 165, 159, 187, 178, 189, 168,
 178, 166, 211, 173, 178, 192, 197, 183,
 182, 204, 202, 213, 202, 201, 219, 207,
 222, 212, 222, 205, 216, 226, 224, 223,
 217, 227, 234, 222, 227, 235, 239, 240,
 227, 241, 238, 243, 240, 245, 240, 240,
 254, 257, 263, 260, 247, 243, 248, 268,
 250, 268, 255, 0, 1, 255, 256, 258,
 260, 266, 261, 280, 264, 271, 280, 267,
 286, 270, 284, 282, 277, 273, 288, 292,
 277, 296, 295, 290, 293, 287, 302, 281,
 286, 303, 290, 305, 309, 302, 307, 306,
 296, 295, 296, 310, 318, 307, 320, 319,
 306, 319, 316, 325, 319, 324, 320, 333,
 333, 332, 340, 327, 326, 340, 342, 347,
 342, 344, 339, 342, 337, 353, 357, 346,
 357, 351, 344, 354, 346, 363, 350, 364,
 351, 367, 349, 355, 355, 371, 365, 374,
 363, 379, 365, 362, 372, 369, 381, 376,
 375, 0, 3, 385, 384, 379, 392, 393,
 379, 394, 393, 398, 392, 387, 390, 386,
 402, 406, 394, 399, 392, 393, 410, 397,
 397, 397, 398, 399, 408, 416, 408, 405,
 405, 423, 406, 415, 422, 411, 417, 413,
 420, 426, 413, 420, 435, 417, 418, 419,
 435, 419, 436, 4, 425, 425, 443, 426,
 435, 443, 432, 440, 436, 443, 435, 442,
 438, 439, 455, 455, 442, 451, 459, 451,
 465, 463, 456, 456, 450, 459, 467, 459,
 470, 463, 463, 472, 466, 474, 479, 476,
 477, 482, 481, 482
};

int mntab[610] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 1, -1,
 209, 210, -2, 259, -2, 115, -1, -1,
 116, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, 20, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, 2, 3, 4, 5, 6, 90, 7,
 114, 8, 9, 138, 10, 11, 12, 13,
 14, 113, 15, 16, 17, 18, 89, 19,
 21, 22, 23, 24, 25, 119, 26, 71,
 27, 76, 72, 28, 29, 30, 31, 77,
 139, 32, 33, 34, 35, 37, 36, 38,
 140, 141, 41, 117, 42, 142, 43, 44,
 120, 39, 145, 45, 46, 47, 40, 48,
 54, 49, 50, 51, 118, 52, 121, 55,
 146, 53, 132, 56, 57, 133, 58, 59,
 60, 61, 148, 149, 64, -2, 65, 62,
 66, 67, 82, 78, 68, -2, -2, 79,
 69, -2, 70, 63, -2, 80, -2, 73,
 83, 81, 74, 136, 75, 85, 84, 91,
 86, 137, -2, -2, 143, -2, 134, 87,
 144, 92, 88, 135, 94, 95, 93, 96,
 -2, 97, 98, 154, -2, 108, 99, 100,
 101, 109, 102, -2, 155, 110, 103, 104,
 105, 106, 147, 122, 107, 123, 111, 112,
 126, -2, 127, 124, 128, -2, -2, -2,
 129, -2, -2, -2, 130, -2, 131, 125,
 -2, -2, 150, -2, -2, 151, -2, 153,
 156, 152, 157, 158, -2, 172, -2, 173,
 -2, 174, -2, -2, -2, -2, 159, 177,
 160, -2, 161, 162, 178, 179, 182, 163,
 164, 165, 183, 166, -2, 167, 180, -2,
 170, 168, -2, 171, 175, 169, 184, 176,
 185, 181, -2, -2, -2, 187, 186, 189,
 -2, 190, 188, 191, 192, 193, -2, 194,
 195, -2, -2, -2, -2, -2, 196, -2,
 -2, 197, 199, -2, -2, -2, -2, -2,
 -2, -2, -2, 198, -2, -2, -2, 200,
 201, -2, -2, -2, -2, -2, -2, -2,
 202, -2, -2, 203, 204, 205, -2, -2,
 206, 208, -2, 211, -2, -2, 212, 213,
 207, 214, -2, 215, 216, 217, 218, 219,
 221, 222, 220, 223, 225, 226, -2, 227,
 229, 230, 231, 232, -2, 228, 224, 233,
 234, 235, 236, 237, 238, -2, -2, -2,
 239, -2, -2, -2, -2, 240, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, 241, -2, 242,
 -2, -2, -2, -2, -2, 243, -2, 244,
 -2, -2, 245, -2, -2, 246, 247, 248,
 -2, -2, 249, 250, -2, -2, -2, -2,
 251, 252, -2, -2, -2, -2, 253, -2,
 254, -2, -2, -2, -2, -2, -2, -2,
 256, 257, 258, -2, -2, -2, 260, 261,
 -2, -2, 262, -2, -2, 263, -2, 255,
 264, 265, 266, -2, -2, -2, 267, 268,
 269, -2, -2, 270, -2, -2, -2, 271,
 272, -2, 273, -2, 274, 275, -2, 276,
 -2, 277, -2, 278, -2, -2, -2, 279,
 -2, 280, 281, -2, -2, -2, -2, 282,
 -2, -2, 283, 284, -2, 285, -2, 286,
 -2, -2, -2, -2, -2, -2, 287, -2,
 288, -2, -2, 289, -2, 290, -2, 291,
 -2, -2, 292, 293, -2, 294, -2, 295,
 -2, -2, 296, -2, 297, -2, -2, -2,
 298, -2, -2, 299, -2, -2, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1
};

int mncheck[610] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 0, -1,
 115, 116, 209, 210, 259, 20, -1, -1,
 20, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, 1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, 0, 0, 0, 0, 0, 14, 0,
 19, 0, 0, 29, 0, 0, 0, 0,
 0, 18, 0, 0, 0, 0, 13, 0,
 1, 1, 1, 1, 1, 22, 1, 7,
 1, 9, 7, 1, 1, 1, 1, 9,
 30, 1, 1, 1, 1, 2, 1, 2,
 31, 32, 3, 21, 3, 33, 3, 3,
 23, 2, 35, 3, 3, 3, 2, 3,
 4, 3, 3, 3, 21, 3, 23, 4,
 36, 3, 26, 4, 4, 26, 4, 5,
 5, 5, 38, 39, 6, 42, 6, 5,
 6, 6, 11, 10, 6, 46, 48, 10,
 6, 5, 6, 5, 8, 10, 43, 8,
 11, 10, 8, 28, 8, 12, 11, 15,
 12, 28, 49, 27, 34, 43, 27, 12,
 34, 15, 12, 27, 16, 16, 15, 16,
 16, 16, 16, 51, 47, 17, 16, 16,
 16, 17, 16, 53, 54, 17, 16, 16,
 16, 16, 37, 24, 16, 24, 17, 17,
 25, 47, 25, 24, 25, 55, 52, 56,
 25, 44, 37, 40, 25, 24, 25, 24,
 41, 40, 40, 44, 45, 41, 52, 50,
 57, 41, 58, 59, 61, 63, 45, 64,
 41, 65, 45, 45, 50, 50, 60, 67,
 60, 60, 60, 60, 68, 69, 71, 60,
 60, 60, 72, 60, 70, 60, 70, 60,
 62, 60, 73, 62, 66, 60, 74, 66,
 75, 70, 76, 77, 78, 79, 75, 80,
 81, 82, 79, 83, 84, 85, 81, 86,
 87, 88, 89, 90, 89, 88, 91, 92,
 93, 91, 94, 95, 96, 92, 97, 98,
 99, 100, 101, 92, 102, 93, 93, 103,
 104, 98, 99, 95, 105, 97, 99, 99,
 106, 107, 108, 109, 110, 111, 112, 101,
 113, 114, 117, 118, 105, 119, 120, 121,
 113, 122, 123, 124, 125, 126, 127, 128,
 129, 130, 128, 131, 132, 133, 134, 135,
 136, 137, 138, 139, 140, 135, 131, 141,
 142, 143, 144, 145, 146, 147, 148, 149,
 150, 151, 152, 153, 154, 155, 148, 156,
 157, 158, 159, 160, 161, 162, 148, 156,
 164, 165, 163, 156, 166, 148, 167, 162,
 168, 169, 159, 161, 163, 170, 172, 173,
 163, 163, 171, 174, 171, 175, 165, 176,
 168, 177, 178, 176, 179, 180, 181, 182,
 176, 183, 184, 185, 186, 187, 188, 189,
 190, 191, 192, 193, 192, 194, 195, 196,
 197, 198, 199, 200, 201, 202, 203, 198,
 204, 205, 206, 207, 201, 208, 211, 212,
 213, 214, 215, 216, 201, 217, 218, 201,
 219, 220, 221, 201, 222, 220, 223, 224,
 225, 226, 220, 227, 228, 229, 230, 231,
 232, 233, 234, 235, 236, 237, 238, 239,
 240, 241, 242, 243, 244, 245, 246, 247,
 248, 249, 250, 251, 252, 253, 254, 255,
 256, 257, 258, 260, 261, 262, 263, 264,
 252, 265, 266, 252, 252, 267, 268, 269,
 270, 271, 272, 273, 274, 275, 276, 277,
 278, 279, 280, 281, 282, 283, 284, 285,
 286, 287, 288, 289, 290, 291, 292, 293,
 294, 295, 296, 297, 298, 299, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1
};

int mnaccept[610] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, 2, -1, 3, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 1120, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, 1045, -1, -1, -1, -1,
 -1, 1025, -1, -1, -1, -1, -1, -1,
 -1, 12, 1003, 1010, -1, 1025, -1, -1,
 -1, -1, -1, -1, -1, 1032, 1034, -1,
 -1, 13, -1, -1, 500, -1, 1026, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, 1045, 500, -1, 1027, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 1151, -1, -1, -1, 1033, -1, -1, -1,
 -1, -1, -1, 1025, -1, -1, 1161, -1,
 -1, -1, -1, -1, -1, 12, -1, -1,
 -1, 1033, -1, -1, -1, 1055, 1035, 1056,
 -1, 1028, 7, 1015, -1, 13, -1, -1,
 1023, 1019, -1, 1023, 1029, -1, 1036, -1,
 1058, -1, -1, -1, 17, -1, 1024, -1,
 1024, -1, 1030, 1031, 1050, 4, -1, 1081,
 -1, 1066, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, 1085, -1, -1, 1076,
 -1, -1, 503, -1, -1, -1, -1, 34,
 -1, 1086, 1089, 1090, 1091, -1, -1, -1,
 1093, -1, -1, -1, -1, -1, 1097, 1116,
 -1, 1118, 0, 1125, 1122, 1119, -1, 1127,
 1143, -1, -1, 1148, 1150, 1131, 1152, 1154,
 1155, 1158, 1159, -1, 1160, 1144, 1145, -1,
 1165, 1148, 1149, 1149, 1162, 1153, 1156, 1157,
 -1, 1150, 1173, -1, -1, -1, 1176, 1159,
 -1, -1, 7, -1, 1163, 4, -1, -1,
 -1, -1, 17, -1, -1, -1, -1, -1,
 -1, -1, 34, -1, -1, -1, 503, -1,
 -1, -1, -1, -1, 0, -1, -1, -1,
 -1, -1, -1, -1, -1, 1001, 1005, 1012,
 -1, 1037, 1041, 1046, 1051, -1, 1006, 1060,
 8, 5, 1063, 1065, 1067, 1069, 1007, 1061,
 1073, 1074, 1070, 1062, 1075, 1008, 1066, 1069,
 1077, 1065, 1064, 1068, 1064, -1, 20, -1,
 1071, 1072, 1079, 501, 1080, -1, 1074, -1,
 1078, 1082, -1, 505, 1, -1, -1, -1,
 507, 11, -1, -1, 9, 1092, 38, 21,
 -1, 1101, 1113, 1115, 1114, 1117, -1, 506,
 -1, 1135, 1146, 1164, 1167, 1172, 6, 1139,
 -1, 1174, -1, 1177, 1168, 48, -1, -1,
 8, 5, -1, 20, 1169, -1, 501, -1,
 -1, -1, -1, 1170, 1, 505, -1, -1,
 -1, 11, 507, -1, 9, 38, 21, -1,
 -1, 506, -1, 6, -1, -1, 48, -1,
 10, -1, 46, -1, 502, 47, 510, -1,
 24, -1, -1, 504, 1108, 39, 1126, -1,
 44, 1175, -1, -1, 10, -1, 46, -1,
 1109, 502, 47, 1110, 1112, 510, -1, 24,
 -1, 504, 39, -1, 44, -1, 28, -1,
 23, 24, -1, -1, 45, -1, 28, -1,
 23, 24, -1, 45, -1, 22, 1088, 33,
 -1, 22, 33, -1, 14, 14, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1
};
#endif
