#ifdef DEF_MP
/*
 *  Keyword definitions
 */
#define	MP_ADC	2000
#define	MP_AND	2001
#define	MP_ASL	2002
#define	MP_BCC	2003
#define	MP_BCS	2004
#define	MP_BEQ	2005
#define	MP_BIT	2011
#define	MP_BMI	2007
#define	MP_BNE	2006
#define	MP_BPL	2008
#define	MP_BRK	2012
#define	MP_BVC	2009
#define	MP_BVS	2010
#define	MP_CLC	2013
#define	MP_CLD	2014
#define	MP_CLI	2015
#define	MP_CLV	2016
#define	MP_CMP	2017
#define	MP_CPX	2018
#define	MP_CPY	2019
#define	MP_DEC	2020
#define	MP_DEX	2021
#define	MP_DEY	2022
#define	MP_EOR	2023
#define	MP_INC	2024
#define	MP_INX	2025
#define	MP_INY	2026
#define	MP_JMP	2027
#define	MP_JSR	2028
#define	MP_LDA	2029
#define	MP_LDX	2030
#define	MP_LDY	2031
#define	MP_LSR	2032
#define	MP_NOP	2033
#define	MP_ORA	2034
#define	MP_PHA	2035
#define	MP_PHP	2036
#define	MP_PLA	2037
#define	MP_PLP	2038
#define	MP_ROL	2039
#define	MP_ROR	2040
#define	MP_RTI	2041
#define	MP_RTS	2042
#define	MP_SBC	2043
#define	MP_SEC	2044
#define	MP_SED	2045
#define	MP_SEI	2046
#define	MP_STA	2047
#define	MP_STX	2048
#define	MP_STY	2049
#define	MP_TAX	2050
#define	MP_TAY	2051
#define	MP_TSX	2052
#define	MP_TXA	2053
#define	MP_TXS	2054
#define	MP_TYA	2055
#endif

#ifdef DECL_MP
/*
 *  keyword state-machine tables
 *
 */

int mpbase[49] = {
 0, 3, 18, 12, 1, 11, 15, 20,
 26, 20, 19, 30, 26, 42, 42, 5,
 7, 1, 45, 32, 30, 42, 47, 41,
 43, 52, 54, 40, 35, 62, 50, 66,
 54, 54, 72, 56, 59, 76, 77, 78,
 70, 76, 77, 80, 80, 74, 68, 99,
 100
};

int mptab[228] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, 1, 2, 3, 4, 5, 29, 15,
 -2, 6, 7, -2, 8, -2, 9, 10,
 11, 16, 12, 13, 14, 18, 17, 19,
 26, 27, 30, 20, 28, 31, 34, 21,
 22, 32, 23, 36, 24, 37, 38, 33,
 25, 40, 39, 45, 42, 35, 41, 43,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, 46, 44, -2,
 -2, -2, 47, 48, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, -2, -1, -1,
 -2, -2, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -2, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1
};

int mpcheck[228] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, 0, 0, 0, 0, 0, 4, 1,
 15, 0, 0, 16, 0, 17, 0, 0,
 0, 1, 0, 0, 0, 2, 1, 2,
 3, 3, 5, 2, 3, 6, 8, 2,
 2, 7, 2, 9, 2, 10, 11, 7,
 2, 12, 11, 14, 13, 8, 12, 13,
 18, 19, 20, 21, 22, 23, 24, 25,
 27, 26, 26, 28, 28, 14, 13, 26,
 18, 29, 14, 14, 30, 31, 32, 25,
 33, 34, 35, 36, 26, 37, 38, 39,
 42, 44, 40, 43, 43, 41, 29, 29,
 40, 43, 31, 31, 46, 38, 39, 41,
 34, 34, 45, 45, 47, 48, -1, -1,
 44, 44, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 47, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1
};

int mpaccept[228] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 2000, -1, -1, 2001, -1, 2002, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 2003, 2005, 2011, 2007, 2006, 2008, 2012, 2009,
 2017, 2013, 2014, 2018, 2019, -1, -1, 2015,
 2004, 2020, -1, -1, 2023, 2024, 2027, 2010,
 2028, 2029, 2032, 2033, 2016, 2034, 2035, 2037,
 2043, 2047, 2039, 2044, 2045, 2041, 2021, 2022,
 2040, 2046, 2025, 2026, 2052, 2036, 2038, 2042,
 2030, 2031, 2050, 2051, 2053, 2055, -1, -1,
 2048, 2049, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 2054, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1
};
#endif
