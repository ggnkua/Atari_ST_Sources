#ifdef DEF_KW
/*
 *  Keyword definitions
 */
#define	KW__B	66
#define	KW__L	76
#define	KW__W	87
#define	KW_A0	136
#define	KW_A1	137
#define	KW_A2	138
#define	KW_A3	139
#define	KW_A4	140
#define	KW_A5	141
#define	KW_A6	142
#define	KW_A7	143
#define	KW_CCR	148
#define	KW_D0	128
#define	KW_D1	129
#define	KW_D2	130
#define	KW_D3	131
#define	KW_D4	132
#define	KW_D5	133
#define	KW_D6	134
#define	KW_D7	135
#define	KW_DATE	121
#define	KW_DEFINED	112
#define	KW_EQU	61
#define	KW_MACDEF	119
#define	KW_PC	144
#define	KW_R0	128
#define	KW_R1	129
#define	KW_R10	138
#define	KW_R11	139
#define	KW_R12	140
#define	KW_R13	141
#define	KW_R14	142
#define	KW_R15	143
#define	KW_R2	130
#define	KW_R3	131
#define	KW_R4	132
#define	KW_R5	133
#define	KW_R6	134
#define	KW_R7	135
#define	KW_R8	136
#define	KW_R9	137
#define	KW_REFERENCED	113
#define	KW_REG	82
#define	KW_SET	83
#define	KW_SP	143
#define	KW_SR	147
#define	KW_SSP	145
#define	KW_STREQ	118
#define	KW_TIME	120
#define	KW_USP	146
#endif

#ifdef DECL_KW
/*
 *  keyword state-machine tables
 *
 */

int kwbase[57] = {
 0, 0, 0, 3, 8, 0, 4, 72,
 6, 1, 82, 3, 94, 0, 6, 5,
 102, 59, 0, 3, 8, 6, 113, 1,
 8, 13, 14, 24, 23, 4, 23, 8,
 128, 8, 51, 56, 55, 61, 60, 81,
 78, 84, 84, 85, 86, 78, 88, 76,
 79, 92, 92, 95, 97, 88, 100, 99,
 101
};

int kwtab[256] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 1, -1,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -1, 2, -2, 3, 4, 5, 20, -2,
 -2, -1, -1, 24, -2, -1, -1, -1,
 6, 21, 7, 8, 26, 9, -2, -2,
 -2, 25, -2, -2, -2, -2, -2, -1,
 -1, 10, -2, 11, 12, 13, 27, 31,
 -2, 37, 40, 41, -2, 14, 42, -2,
 15, 30, 16, 17, 18, 19, 38, -2,
 -2, 22, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, -2,
 -2, -2, -2, 39, -2, 23, -2, -2,
 -2, -2, -2, -2, -2, -2, -2, 32,
 -2, -2, -2, -2, -2, -2, -2, -2,
 34, -2, -2, -2, -2, -2, -2, -2,
 -2, 43, 44, -2, -2, -2, 35, 36,
 -2, -2, -2, -2, -2, -2, -2, 45,
 46, 47, 48, -2, 49, 50, 51, 28,
 -2, 52, -2, 29, 53, -2, 54, 55,
 56, -2, -1, 33, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1
};

int kwcheck[256] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 0, -1,
 2, 2, 2, 2, 2, 2, 2, 2,
 4, 4, 4, 4, 4, 4, 4, 4,
 -1, 0, 1, 0, 0, 0, 3, 6,
 23, -1, -1, 8, 1, -1, -1, -1,
 0, 5, 0, 0, 9, 0, 8, 1,
 8, 8, 20, 21, 24, 25, 26, -1,
 -1, 0, 1, 0, 0, 0, 11, 14,
 15, 18, 29, 31, 1, 0, 33, 33,
 0, 13, 0, 0, 0, 0, 19, 1,
 7, 7, 7, 7, 7, 7, 7, 7,
 7, 7, 10, 10, 10, 10, 10, 10,
 10, 10, 27, 28, 30, 7, 12, 12,
 12, 12, 12, 12, 12, 12, 16, 16,
 16, 16, 16, 16, 16, 16, 16, 16,
 17, 22, 22, 22, 22, 22, 22, 34,
 35, 36, 37, 17, 38, 17, 17, 17,
 32, 32, 32, 32, 32, 32, 39, 40,
 41, 42, 43, 44, 45, 46, 47, 12,
 48, 49, 50, 12, 51, 52, 53, 54,
 55, 56, -1, 16, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1
};

int kwaccept[256] = {
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 136, 137, 138, 139, 140, 141, 142, 143,
 128, 129, 130, 131, 132, 133, 134, 135,
 -1, -1, 66, -1, -1, -1, -1, 144,
 82, -1, -1, -1, 76, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, 143, 87,
 147, -1, 148, 61, 83, 145, 146, -1,
 -1, -1, 66, -1, -1, -1, -1, -1,
 144, -1, -1, -1, 76, -1, -1, 82,
 -1, -1, -1, -1, -1, -1, -1, 87,
 128, 129, 130, 131, 132, 133, 134, 135,
 136, 137, 136, 137, 138, 139, 140, 141,
 142, 143, 148, -1, 61, -1, 128, 129,
 130, 131, 132, 133, 134, 135, 128, 129,
 130, 131, 132, 133, 134, 135, 136, 137,
 -1, 138, 139, 140, 141, 142, 143, 83,
 145, -1, -1, 143, 146, 147, -1, -1,
 138, 139, 140, 141, 142, 143, 121, -1,
 -1, -1, -1, 120, -1, -1, -1, -1,
 118, -1, 119, -1, -1, 112, -1, -1,
 -1, 113, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1,
 -1, -1, -1, -1, -1, -1, -1, -1
};
#endif
