
;*************************************************************************
;
;   XROMS.S
;
;   - Atari BASIC rev C, XL/XE OS, FastChip FP, and default h/w registers
;
;   12/25/88 created
;
;   09/09/93 11:00
;
;*************************************************************************

    .data

; Atari BASIC revision C

_ROMA000::

; $A000
    dc.w $A5CA, $D004, $A508, $D045, $A2FF, $9AD8, $AEE7, $02AC
    dc.w $E802, $8680, $8481, $A900, $8592, $85CA, $C88A, $A282
    dc.w $9500, $E894, $00E8, $E092, $90F6, $A286, $A001, $207A
    dc.w $A8A2, $8CA0, $0320, $7AA8, $A900, $A891, $8491, $8AC8
    dc.w $A980, $918A, $C8A9, $0391, $8AA9, $0A85, $C920, $F1B8
    dc.w $2045, $BD20, $5BBD, $A592, $F003, $209D, $BD20, $62BD
    dc.w $A5CA, $D09C, $A2FF, $9A20, $51DA, $A95D, $85C2, $20ED
    dc.w $BD20, $F2A9, $F0EA, $A900, $85F2, $859F, $8594, $85A6
    dc.w $85B3, $85B0, $85B1, $A584, $85AD, $A585, $85AE, $20A1
    dc.w $DB20, $9AA1, $20C4, $A2A5, $D510, $0285, $A620, $A1DB
    dc.w $A4F2, $84A8, $B1F3, $C99B, $D007, $24A6, $30B2, $4C86
    dc.w $A1A5, $9485, $A720, $C4A2, $20A1, $DBA9, $A4A0, $9FA2
    dc.w $0220, $54A4, $86F2, $A5AF, $20C4, $A220, $A1DB, $20BE
    dc.w $A190, $35A4, $9FB1, $F3C9, $9BD0, $06C8, $91F3, $88A9
    dc.w $2009, $8091, $F3A9, $4005, $A685, $A6A4, $A884, $F2A2
    dc.w $0386, $A7E8, $8694, $A937, $20C4, $A2A4, $F2B1, $F3E6
; $A100
    dc.w $F2C9, $9BD0, $F320, $C4A2, $A594, $A4A7, $9180, $A4F2
    dc.w $88B1, $F3C9, $9BD0, $9AA0, $02A5, $9491, $8020, $A2A9
    dc.w $A900, $B003, $20DC, $A938, $E594, $F01E, $B013, $49FF
    dc.w $A8C8, $A28A, $207A, $A8A5, $9785, $8AA5, $9885, $8BD0
    dc.w $09A8, $20D0, $A9A2, $8A20, $F8A8, $A494, $88B1, $8091
    dc.w $8A98, $D0F8, $24A6, $5029, $A5B1, $0A0A, $0AA2, $8820
    dc.w $F7A8, $38A5, $84E5, $ADA8, $A585, $E5AE, $A284, $20FA
    dc.w $A824, $A610, $0620, $AAB5, $4C60, $A020, $8EB5, $4C60
    dc.w $A010, $FB4C, $5EA9, $20A2, $A9B0, $F320, $DCA9, $A820
    dc.w $D0A9, $A28A, $20F8, $A84C, $60A0, $2000, $D890, $08A9
    dc.w $0085, $F2A0, $8030, $0920, $41AD, $A4D5, $30F1, $A5D4
    dc.w $84A1, $85A0, $20C4, $A2A5, $A185, $D54C, $C4A2, $A001
    dc.w $B195, $859E, $8D83, $0488, $B195, $859D, $8D82, $0484
    dc.w $A9A5, $948D, $8104, $A5F2, $8D80, $0420, $93A2, $3016
    dc.w $C901, $9024, $D006, $2008, $A24C, $59A2, $C905, $9055
    dc.w $209B, $A24C, $59A2, $38E9, $C1B0, $02A2, $FF18, $659D
; $A200
    dc.w $488A, $659E, $484C, $1BA2, $2093, $A248, $2093, $A248
    dc.w $9009, $68A8, $68AA, $9848, $8A48, $60A6, $A9E8, $E8E8
    dc.w $E8F0, $1F86, $A9A5, $F29D, $8004, $A594, $9D81, $04A5
    dc.w $9D9D, $8204, $A59E, $9D83, $0468, $859E, $6885, $9D4C
    dc.w $DBA1, $4C18, $B9A6, $A9F0, $D1BD, $8204, $859D, $BD83
    dc.w $0485, $9ECA, $CACA, $CA86, $A9B0, $034C, $DBA1, $2093
    dc.w $A230, $FBC9, $02B0, $0820, $8CA2, $208C, $A2D0, $EFC9
    dc.w $03F0, $D2B0, $E9A5, $F2C5, $9F90, $0285, $9FA6, $A9BD
    dc.w $8004, $85F2, $BD81, $0485, $944C, $DBA1, $E69D, $D002
    dc.w $E69E, $6020, $8CA2, $A200, $A19D, $60C9, $0FF0, $17B0
    dc.w $40C9, $0DD0, $0620, $8CA2, $4CE4, $A268, $68A9, $0448
    dc.w $A9A6, $484C, $1BA2, $208C, $A2A0, $00B1, $9DA4, $9488
    dc.w $9180, $1860, $A494, $9180, $E694, $D0F7, $4C18, $B9A2
    dc.w $FF9A, $A594, $A4A7, $9180, $4CB1, $A0A2, $FF9A, $4CFB
    dc.w $A020, $A1DB, $A5F2, $C5B3, $F015, $85B3, $A9A7, $A0DE
    dc.w $A200, $2054, $A4B0, $2386, $B2A5, $AF69, $1085, $B0A0
; $A300
    dc.w $00B1, $9DC5, $B0F0, $0AC9, $44D0, $13A5, $B0C9, $4490
    dc.w $0D20, $C4A2, $A6B2, $86F2, $1860, $A900, $85B0, $3860
    dc.w $A900, $F002, $A980, $85D2, $20A1, $DBA5, $F285, $AC20
    dc.w $E8A3, $B025, $20E1, $A2A5, $B0F0, $08A4, $B2B1, $F3C9
    dc.w $3090, $16E6, $F220, $E8A3, $90F9, $20AF, $DB90, $F4B1
    dc.w $F3C9, $24F0, $0624, $D210, $0938, $6024, $D210, $FAC8
    dc.w $D00D, $B1F3, $C928, $D007, $C8A9, $4005, $D285, $D2A5
    dc.w $AC85, $F284, $ACA5, $83A4, $82A2, $0020, $54A4, $B00A
    dc.w $E4AC, $F04D, $2082, $A44C, $7EA3, $38A5, $ACE5, $F285
    dc.w $F2A8, $A284, $207A, $A8A5, $AF85, $D3A4, $F288, $A6AC
    dc.w $CABD, $8005, $9197, $CA88, $10F7, $A4F2, $88B1, $9709
    dc.w $8091, $97A0, $08A2, $8820, $7AA8, $E6B1, $A002, $A900
    dc.w $99D2, $00C8, $C008, $90F8, $88B9, $D200, $9197, $8810
    dc.w $F824, $D250, $02C6, $ACA5, $AC85, $F2A5, $AF30, $0609
    dc.w $8018, $4CC4, $A24C, $2CB9, $A4F2, $B1F3, $C941, $9003
    dc.w $C95B, $6038, $6020, $A1DB, $A5F2, $85AC, $2000, $D890
; $A400
    dc.w $05A5, $AC85, $F260, $A90E, $20C4, $A2C8, $A200, $B5D4
    dc.w $9180, $C8E8, $E006, $90F6, $8494, $1860, $20A1, $DBA4
    dc.w $F2B1, $F3C9, $22D0, $CCA9, $0F20, $C4A2, $A594, $85AB
    dc.w $20C4, $A2E6, $F2A4, $F2B1, $F3C9, $9BF0, $0CC9, $22F0
    dc.w $0620, $C4A2, $4C33, $A4E6, $F218, $A594, $E5AB, $A4AB
    dc.w $9180, $1860, $86AA, $A2FF, $86AF, $8596, $8495, $E6AF
    dc.w $A6F2, $A4AA, $B195, $F025, $A900, $08BD, $8005, $297F
    dc.w $C92E, $F01B, $5195, $0AF0, $0268, $08C8, $E890, $EC28
    dc.w $F0D0, $1898, $6595, $A8A5, $9669, $00D0, $CD38, $60A9
    dc.w $02C5, $AAD0, $DFB1, $9530, $03C8, $D0F9, $38B0, $DCC2
    dc.w $A752, $45CD, $C5A7, $4441, $54C1, $EEA6, $494E, $5055
    dc.w $D4B7, $A643, $4F4C, $4FD2, $2CA7, $4C49, $53D4, $1DA7
    dc.w $454E, $5445, $D2BA, $A64C, $45D4, $8EA7, $49C6, $CCA6
    dc.w $464F, $D2E4, $A64E, $4558, $D4B7, $A647, $4F54, $CFB7
    dc.w $A647, $4F20, $54CF, $B7A6, $474F, $5355, $C2B7, $A654
    dc.w $5241, $D0B8, $A642, $59C5, $B8A6, $434F, $4ED4, $59A7
; $A500
    dc.w $434F, $CD1A, $A743, $4C4F, $53C5, $B8A6, $434C, $D2B8
    dc.w $A644, $45C7, $59A7, $4449, $CDB8, $A645, $4EC4, $B8A6
    dc.w $4E45, $D713, $A74F, $5045, $CE1D, $A74C, $4F41, $C41D
    dc.w $A753, $4156, $C53A, $A753, $5441, $5455, $D343, $A74E
    dc.w $4F54, $C543, $A750, $4F49, $4ED4, $11A7, $5849, $CF5C
    dc.w $A74F, $CE56, $A750, $4F4B, $C5F6, $A650, $5249, $4ED4
    dc.w $B8A6, $5241, $C4EF, $A652, $4541, $C4E9, $A652, $4553
    dc.w $544F, $52C5, $B8A6, $5245, $5455, $52CE, $20A7, $5255
    dc.w $CEB8, $A653, $544F, $D0B8, $A650, $4FD0, $F6A6, $BFE2
    dc.w $A647, $45D4, $B4A6, $5055, $D4B7, $A647, $5241, $5048
    dc.w $4943, $D356, $A750, $4C4F, $D456, $A750, $4F53, $4954
    dc.w $494F, $CEB8, $A644, $4FD3, $56A7, $4452, $4157, $54CF
    dc.w $54A7, $5345, $5443, $4F4C, $4FD2, $DCA6, $4C4F, $4341
    dc.w $54C5, $52A7, $534F, $554E, $C4FA, $A64C, $5052, $494E
    dc.w $D4B8, $A643, $5341, $56C5, $B8A6, $434C, $4F41, $C4BA
    dc.w $A600, $8000, $2A45, $5252, $4F52, $2D20, $A053, $544F
; $A600
    dc.w $5050, $4544, $A0CD, $C402, $C203, $2BBA, $2CDB, $02CD
    dc.w $D803, $250F, $3502, $260F, $3602, $2803, $FE02, $E802
    dc.w $01F4, $A302, $0078, $A603, $C49C, $0203, $2302, $2502
    dc.w $2602, $2402, $2702, $1D02, $1F02, $1E02, $2002, $2102
    dc.w $2202, $2A02, $2903, $011F, $A3C2, $030D, $2B0F, $380E
    dc.w $C42C, $0203, $120F, $3C0E, $0203, $44D2, $0200, $C8A7
    dc.w $D302, $C203, $3F2B, $0F3A, $00D4, $A72C, $032B, $0F3A
    dc.w $0E2C, $032B, $0F3A, $C72C, $03C4, $E3C2, $03C8, $02CB
    dc.w $0201, $1BA4, $0300, $D0A7, $A503, $0123, $A3C2, $032B
    dc.w $0F37, $0EC4, $2C02, $0312, $0F3C, $0E02, $031D, $0F2F
    dc.w $021E, $0F30, $021F, $0F31, $0220, $0F32, $0221, $0F33
    dc.w $0222, $0F34, $031C, $0E12, $0EFA, $0300, $45A6, $220F
    dc.w $2D0E, $F102, $8622, $0F2E, $007C, $A6E8, $0301, $1FA3
    dc.w $220F, $2D0E, $190E, $C3DC, $031A, $0E02, $030E, $120E
    dc.w $12C4, $03DD, $1201, $1FA3, $CB03, $0EC8, $02C6, $03F7
    dc.w $DBC2, $0314, $0216, $03C9, $BB02, $EC00, $9AA7, $B503
; $A700
    dc.w $1C0E, $0301, $1FA3, $0201, $23A3, $03B8, $C203, $12BC
    dc.w $0203, $0E12, $AC12, $F912, $F39A, $03A5, $9703, $ED94
    dc.w $03EA, $9102, $8F03, $9A12, $0297, $1502, $03DE, $8502
    dc.w $DB12, $C402, $C203, $00BA, $A7F4, $03C3, $F103, $8212
    dc.w $0045, $A603, $BA12, $0045, $A6E4, $0300, $7CA6, $030E
    dc.w $120E, $030E, $120E, $12B8, $D503, $EDD2, $030E, $C4C7
    dc.w $CD03, $1702, $1803, $0EC2, $0312, $BC02, $0314, $0216
    dc.w $0301, $1FA3, $0D2B, $0F39, $0E00, $53A6, $2C02, $0123
    dc.w $A32B, $0F3B, $0E2C, $03AA, $C302, $0312, $BB02, $030E
    dc.w $1BC3, $9B03, $01F4, $A302, $01CE, $A2C9, $02D4, $C302
    dc.w $03C3, $0203, $C3C8, $030E, $0200, $7CA6, $03C4, $B302
    dc.w $03C6, $C203, $BD02, $0312, $0215, $030E, $C302, $0312
    dc.w $0E02, $0301, $DAA2, $01DA, $A240, $0241, $0243, $0242
    dc.w $033D, $023E, $030E, $C203, $120F, $3CBA, $0203, $8280
    dc.w $ACA4, $BABB, $9B47, $4F54, $CF47, $4F53, $55C2, $54CF
    dc.w $5354, $45D0, $5448, $45CE, $A33C, $BD3C, $BE3E, $BDBC
; $A800
    dc.w $BEBD, $DEAA, $ABAD, $AF4E, $4FD4, $4FD2, $414E, $C4A8
    dc.w $A9BD, $BD3C, $BD3C, $BE3E, $BDBC, $BEBD, $ABAD, $A880
    dc.w $80A8, $A8AC, $5354, $52A4, $4348, $52A4, $5553, $D241
    dc.w $53C3, $5641, $CC4C, $45CE, $4144, $D241, $54CE, $434F
    dc.w $D350, $4545, $CB53, $49CE, $524E, $C446, $52C5, $4558
    dc.w $D04C, $4FC7, $434C, $4FC7, $5351, $D253, $47CE, $4142
    dc.w $D349, $4ED4, $5041, $4444, $4CC5, $5354, $4943, $CB50
    dc.w $5452, $49C7, $5354, $5249, $C700, $A900, $84A4, $85A5
    dc.w $9838, $6590, $A8A5, $9165, $A5CD, $E602, $900C, $D007
    dc.w $CCE5, $0290, $05F0, $034C, $30B9, $38A5, $90F5, $0085
    dc.w $A2A5, $91F5, $0185, $A318, $7501, $859A, $B500, $8599
    dc.w $8597, $65A4, $859B, $B501, $8598, $65A5, $65A3, $859C
    dc.w $B500, $65A4, $9500, $B501, $65A5, $9501, $E8E8, $E092
    dc.w $90EE, $850F, $A590, $850E, $A6A3, $E8A4, $A2D0, $0DEA
    dc.w $F011, $EA88, $C69A, $C69C, $B199, $919B, $88D0, $F9B1
    dc.w $9991, $9BCA, $D0ED, $60A8, $A900, $84A4, $85A5, $38A5
; $A900
    dc.w $90F5, $0049, $FFA8, $C884, $A2A5, $91F5, $0185, $A3B5
    dc.w $00E5, $A285, $99B5, $01E9, $0085, $9A86, $9B38, $B500
    dc.w $E5A4, $9500, $B501, $E5A5, $9501, $E8E8, $E092, $90ED
    dc.w $850F, $A590, $850E, $A69B, $B500, $E5A2, $859B, $B501
    dc.w $E900, $859C, $A6A3, $E8A4, $A2D0, $08CA, $D005, $60E6
    dc.w $9AE6, $9CB1, $9991, $9BC8, $D0F9, $CAD0, $F260, $2019
    dc.w $B820, $F2A9, $F036, $A4A7, $C49F, $B01D, $B18A, $85A7
    dc.w $98C8, $B18A, $C884, $A820, $7EA9, $EA4C, $61A9, $0AAA
    dc.w $BDFA, $A948, $BDFB, $A948, $60A0, $01B1, $8A30, $10A5
    dc.w $9F20, $D0A9, $20E1, $A910, $C54C, $8CB7, $4C92, $B74C
    dc.w $5DA0, $A58A, $85BE, $A58B, $85BF, $A589, $A488, $858B
    dc.w $848A, $A001, $B18A, $C5A1, $900D, $D00A, $88B1, $8AC5
    dc.w $A090, $04D0, $0118, $6020, $DCA9, $20D0, $A94C, $B2A9
    dc.w $1865, $8A85, $8AA5, $8B69, $0085, $8B60, $A002, $B18A
    dc.w $60A0, $01B1, $8A60, $2045, $BD4C, $71E4, $2045, $BD6C
    dc.w $0A00, $A411, $D003, $C611, $9860, $A9E4, $A9E4, $B33D
; $AA00
    dc.w $BA1E, $B4B4, $BAC4, $AAD9, $B777, $B67C, $B6FF, $B6D4
    dc.w $B6D4, $B6D1, $B7D7, $A9E5, $B7B4, $B205, $BC21, $B765
    dc.w $B28C, $B205, $B78B, $A00B, $BBF1, $BAFA, $BB6C, $BC2E
    dc.w $BC3C, $BC53, $BBEB, $B7E3, $B277, $B3D9, $B290, $B2AD
    dc.w $B295, $BDA7, $B74B, $B791, $B83D, $B3D9, $BC84, $BC77
    dc.w $BA45, $BA6B, $BA0B, $A9EB, $BA26, $B9AC, $BC9D, $B9D2
    dc.w $B495, $BBD0, $BB63, $AAD9, $B911, $ACA2, $ACAB, $ACC1
    dc.w $ACB1, $ACB8, $ACC8, $B15D, $AC82, $BDF9, $AC79, $AC8B
    dc.w $ACE3, $ACD8, $ACCE, $AB34, $AD65, $AD49, $AE8D, $ACA2
    dc.w $ACAB, $ACC1, $ACB1, $ACB8, $ACC8, $AB34, $AC94, $AE10
    dc.w $AD70, $AD6C, $AD65, $AD6C, $AD63, $B033, $B051, $B0A4
    dc.w $AFFC, $AFEA, $AFB4, $B006, $B117, $B10E, $AFCB, $B105
    dc.w $B075, $AFD5, $B149, $B120, $B13C, $B152, $AD03, $B098
    dc.w $B0C7, $B00C, $B010, $B014, $B018, $2026, $AB20, $36AB
    dc.w $B005, $20B2, $AB30, $F685, $ABAA, $BD25, $AC4A, $4A4A
    dc.w $4A85, $ACA4, $A9B1, $80AA, $BD25, $AC29, $0FC5, $AC90
; $AB00
    dc.w $0DAA, $F031, $B180, $E6A9, $2018, $AB4C, $F3AA, $A5AB
    dc.w $8891, $8084, $A94C, $DDAA, $38E9, $1D0A, $AABD, $6AAA
    dc.w $48BD, $6BAA, $4860, $A0FF, $A911, $9180, $84A9, $C884
    dc.w $B084, $AA84, $B160, $A4A8, $E6A8, $B18A, $3043, $C90F
    dc.w $9003, $F013, $60A2, $00C8, $B18A, $95D4, $E8E0, $0690
    dc.w $F6C8, $A900, $AAF0, $22C8, $B18A, $A28A, $85D6, $85D8
    dc.w $C898, $1875, $0085, $D4A9, $0085, $D785, $D975, $0185
    dc.w $D598, $65D6, $A8A2, $00A9, $8385, $D286, $D384, $A818
    dc.w $6020, $1EAC, $B19D, $99D2, $00C8, $C008, $90F6, $1860
    dc.w $20E9, $ABA9, $0224, $D2D0, $1505, $D285, $D26A, $900F
    dc.w $18A5, $D465, $8C85, $D4A8, $A5D5, $658D, $85D5, $6020
    dc.w $22B9, $E6AA, $A5AA, $0A0A, $0AC5, $A9B0, $0DA8, $88A2
    dc.w $07B5, $D291, $8088, $CA10, $F860, $4C20, $B920, $D7AB
    dc.w $A5D5, $10F5, $4C26, $B920, $DAAA, $20E9, $AB4C, $41AD
    dc.w $20CD, $ABD0, $0160, $202E, $B9A5, $AAC6, $AA0A, $0A0A
    dc.w $A888, $A207, $B180, $95D2, $88CA, $10F8, $6020, $E9AB
; $AC00
    dc.w $20B6, $DD4C, $E9AB, $20DA, $AA4C, $E9AB, $A5D3, $201E
    dc.w $ACA2, $00B5, $D291, $9DC8, $E8E0, $0890, $F660, $A000
    dc.w $849E, $0A0A, $269E, $0A26, $9E18, $6586, $859D, $A587
    dc.w $659E, $859E, $6000, $0000, $0000, $0000, $0000, $0000
    dc.w $0000, $8888, $8888, $8888, $CCAA, $9999, $AADD, $5566
    dc.w $F24E, $F1F1, $EEEE, $EEEE, $EEEE, $DDDD, $F2F2, $F2F2
    dc.w $F243, $F2F2, $F2F2, $F2F2, $F2F2, $F2F2, $F2F2, $F2F2
    dc.w $F2F2, $F2F2, $F2F2, $F2F2, $F2F2, $20FD, $AB20, $2CAD
    dc.w $4CB2, $AB20, $FDAB, $2032, $AD4C, $B2AB, $20FD, $AB20
    dc.w $38AD, $4CB2, $AB20, $E9AB, $A5D4, $F004, $4980, $85D4
    dc.w $4CB2, $AB20, $11AD, $3048, $F046, $103F, $2011, $AD4C
    dc.w $E0AC, $2011, $AD30, $3910, $3220, $11AD, $302D, $F02B
    dc.w $102E, $2011, $AD30, $2410, $2720, $11AD, $4CE9, $AC20
    dc.w $FDAB, $A5D4, $25E0, $4CE0, $AC20, $FDAB, $A5D4, $05E0
    dc.w $F009, $D00C, $20E9, $ABA5, $D4F0, $05A9, $00A8, $F004
    dc.w $A940, $A001, $85D4, $84D5, $A2D6, $A004, $2048, $DA85
; $AD00
    dc.w $D24C, $B2AB, $20E9, $ABA5, $D4F0, $F610, $E3A9, $C030
    dc.w $E1A4, $A988, $B180, $C92F, $9003, $4C6C, $AF20, $FDAB
    dc.w $202C, $ADA5, $D460, $2066, $DAB0, $1360, $2060, $DAB0
    dc.w $0D60, $20DB, $DAB0, $0760, $2028, $DBB0, $0160, $201E
    dc.w $B920, $D2D9, $B001, $6020, $2EB9, $A5A9, $C9FF, $D00F
    dc.w $20FD, $ABA2, $05B5, $E095, $D4CA, $10F9, $4C0C, $ACA9
    dc.w $8085, $B160, $E6B0, $A4A9, $6868, $4C04, $ABA9, $4085
    dc.w $B124, $B110, $06A5, $AA85, $AFC6, $AAA9, $00A8, $C5B0
    dc.w $F00B, $C6B0, $20DA, $ABA5, $D530, $23A4, $D485, $9884
    dc.w $9720, $DAAB, $A5D4, $85F5, $A5D5, $3012, $85F6, $20E9
    dc.w $AB24, $B150, $05A9, $0085, $B160, $66D2, $B003, $2022
    dc.w $B9A5, $F6C5, $D790, $08D0, $F5A5, $F5C5, $D6B0, $EFA5
    dc.w $98C5, $D990, $08D0, $E7A5, $97C5, $D8B0, $E120, $48AF
    dc.w $A597, $A498, $203D, $AF20, $31AF, $A5D4, $A4D5, $203D
    dc.w $AFA5, $8CA4, $8D20, $3DAF, $24B1, $1015, $A5AF, $85AA
    dc.w $20E9, $ABA0, $05B9, $D400, $91F5, $8810, $F8C8, $84B1
; $AE00
    dc.w $60A0, $05B1, $F599, $D400, $8810, $F8C8, $84D2, $4CB2
    dc.w $ABA5, $B0F0, $0720, $81AE, $8498, $8597, $2081, $AE38
    dc.w $E901, $85F5, $98E9, $0085, $F620, $E9AB, $A5B1, $100B
    dc.w $05B0, $85B1, $A4D9, $A5D8, $4C3F, $AEA5, $D6A4, $D7A6
    dc.w $B0F0, $10C6, $B0C4, $9890, $35D0, $04C5, $9790, $2FA4
    dc.w $98A5, $9738, $E5F5, $85D6, $AA98, $E5F6, $85D7, $901E
    dc.w $A8D0, $038A, $F018, $2093, $AB18, $A5D4, $65F5, $85D4
    dc.w $A5D5, $65F6, $85D5, $24B1, $1001, $604C, $B2AB, $202A
    dc.w $B920, $DAAB, $A5D4, $A4D5, $D003, $AAF0, $F160, $2090
    dc.w $ABA5, $D485, $99A5, $D585, $9AA5, $D685, $A2A4, $D784
    dc.w $A3A4, $A9C0, $FFF0, $0FA9, $8085, $B120, $04AB, $A5D7
    dc.w $A4D6, $26B1, $B007, $2090, $ABA5, $D9A4, $D8C5, $A390
    dc.w $06D0, $08C4, $A2B0, $0485, $A384, $A218, $A5D4, $65A2
    dc.w $A8A5, $D565, $A3AA, $3898, $E58C, $85F9, $8AE5, $8D85
    dc.w $FA38, $A900, $E5A2, $85A2, $38A5, $99E5, $A285, $99A5
    dc.w $9AE9, $0085, $9A38, $A5D4, $E5A2, $859B, $A5D5, $E900
; $AF00
    dc.w $859C, $2044, $A9A5, $D320, $81AB, $38A5, $F9E5, $D4A8
    dc.w $A5FA, $E5D5, $AAA9, $0225, $B1F0, $0FA9, $0085, $B1E4
    dc.w $D790, $06D0, $05C4, $D6B0, $0160, $84D6, $86D7, $4C0C
    dc.w $AC06, $F526, $F6A4, $F6A5, $F506, $F526, $F618, $65F5
    dc.w $85F5, $9865, $F685, $F660, $A900, $85F7, $85F8, $A010
    dc.w $A5F5, $4A90, $0C18, $A2FE, $B5F9, $75DA, $95F9, $E8D0
    dc.w $F7A2, $0376, $F5CA, $10FB, $88D0, $E560, $2090, $AB20
    dc.w $B6DD, $2090, $ABA2, $D620, $A7AF, $08A2, $E220, $A7AF
    dc.w $F013, $28F0, $0DA0, $00B1, $D4D1, $E0F0, $0C90, $03A9
    dc.w $0160, $A980, $6028, $D0F7, $60E6, $D4D0, $02E6, $D5E6
    dc.w $E0D0, $D2E6, $E1D0, $CEB5, $00D0, $06B5, $01F0, $05D6
    dc.w $01D6, $00A8, $6020, $90AB, $A5D6, $A4D7, $85D4, $84D5
    dc.w $20AA, $D9A9, $0085, $D285, $D34C, $B2AB, $20DA, $ABA0
    dc.w $00B1, $D44C, $BCAF, $20E9, $AB38, $ADE5, $02E5, $9085
    dc.w $D4AD, $E602, $E591, $85D5, $4CC0, $AF20, $7DBD, $A900
    dc.w $85F2, $2000, $D820, $9DBD, $90C9, $2010, $B920, $90AB
; $B000
    dc.w $A000, $B1D4, $4CBC, $AF20, $90AB, $4CC0, $AFA9, $00F0
    dc.w $0AA9, $08D0, $06A9, $0CD0, $02A9, $1448, $20DA, $ABA5
    dc.w $D5D0, $0EA5, $D468, $1865, $D4AA, $BD70, $02A0, $00F0
    dc.w $8B20, $2EB9, $20E9, $AB20, $E6D8, $A5F3, $85D4, $A5F4
    dc.w $85D5, $A0FF, $C8B1, $F310, $FB29, $7F91, $F3C8, $84D6
    dc.w $D017, $20E9, $AB20, $41AD, $A5D4, $8DC0, $05A9, $0585
    dc.w $D5A9, $C085, $D4A9, $0185, $D6A9, $0085, $D785, $D3A9
    dc.w $8385, $D24C, $B2AB, $A293, $A0B0, $2098, $DD20, $E9AB
    dc.w $AC0A, $D284, $D4AC, $0AD2, $84D5, $20AA, $D920, $38AD
    dc.w $4CB2, $AB42, $0655, $3600, $0020, $E9AB, $A5D4, $297F
    dc.w $85D4, $4CB2, $AB20, $AEB0, $20AA, $D94C, $B2AB, $A5B0
    dc.w $85C6, $20DA, $ABC6, $C630, $09A5, $D448, $A5D5, $484C
    dc.w $B2B0, $A5B0, $486C, $D400, $20E9, $AB20, $D1B0, $4CB2
    dc.w $ABA5, $D429, $7F38, $E93F, $1002, $A900, $AAA9, $00A8
    dc.w $E005, $B007, $15D5, $94D5, $E8D0, $F5A6, $D410, $14AA
    dc.w $F011, $A2E0, $2046, $DAA9, $C085, $E0A9, $0185, $E120
; $B100
    dc.w $26AD, $604C, $00DC, $20E9, $AB20, $05BE, $4C59, $B120
    dc.w $E9AB, $200F, $BE4C, $59B1, $20E9, $AB20, $D5BE, $4C59
    dc.w $B120, $E9AB, $A5D4, $F033, $20CD, $DEB0, $2EA5, $D449
    dc.w $3BD0, $39A5, $D529, $F8D0, $3385, $D4F0, $2F20, $E9AB
    dc.w $A5D4, $F017, $20D1, $DE4C, $2BB1, $20E9, $AB20, $C0DD
    dc.w $4C59, $B120, $E9AB, $2043, $BF90, $1120, $2EB9, $20FD
    dc.w $ABA5, $E0F0, $0A2A, $A4D4, $D008, $B0EF, $4CB2, $AB4C
    dc.w $F0AC, $A2D4, $2076, $BA6A, $48A2, $E020, $76BA, $9810
    dc.w $1E29, $7F85, $D4B0, $0368, $90D1, $A5E0, $1001, $1808
    dc.w $A6F7, $E005, $B00F, $B5E1, $6A90, $0AA9, $80D0, $08A5
    dc.w $E010, $0118, $08A9, $0048, $A205, $B5E0, $48CA, $10FA
    dc.w $20D1, $DEA2, $00A0, $0568, $95E0, $E888, $10F9, $2032
    dc.w $AD20, $CCDD, $B03D, $6805, $D485, $D428, $6810, $9D90
    dc.w $9BA2, $D420, $76BA, $B094, $A5D4, $3829, $7FE9, $3FC9
    dc.w $06B0, $1DAA, $A8F8, $38B5, $D469, $0095, $D4CA, $D0F7
    dc.w $D890, $04E6, $D4E6, $D5C8, $C006, $B004, $96D4, $90F7
; $B200
    dc.w $4CB2, $AB20, $1EB9, $A4A8, $C4A7, $9001, $6020, $DAAA
    dc.w $A5D2, $6A90, $0320, $22B9, $382A, $85D2, $302E, $A4F5
    dc.w $A6F6, $C8D0, $03E8, $30ED, $84D6, $86D7, $84F5, $86F6
    dc.w $A497, $A698, $C8D0, $03E8, $30DB, $84D8, $86D9, $2048
    dc.w $AF20, $31AF, $A4F5, $A5F6, $30CB, $1014, $A900, $85D6
    dc.w $85D7, $A4F5, $84D8, $A5F6, $85D9, $D004, $C000, $F0B5
    dc.w $A28E, $207C, $A838, $A597, $E58C, $85D4, $A598, $E58D
    dc.w $85D5, $200C, $AC4C, $06B2, $20D7, $ABA5, $D485, $95A5
    dc.w $D585, $9620, $E0AB, $A5D4, $A000, $9195, $60A9, $06D0
    dc.w $02A9, $0085, $FB60, $A900, $85B6, $2004, $B990, $03A8
    dc.w $F007, $20CD, $ABA5, $D5A4, $D485, $B884, $B760, $A5A8
    dc.w $4820, $F9B6, $A5B7, $85A0, $A5B8, $85A1, $20A2, $A9A5
    dc.w $8A85, $F3A5, $8B85, $F420, $A8BD, $6885, $A8A0, $0084
    dc.w $F220, $2FB3, $85B7, $202D, $B385, $B820, $2DB3, $85F5
    dc.w $202D, $B385, $F620, $2DB3, $4901, $F026, $A4F6, $C4F5
    dc.w $B005, $8884, $F290, $E984, $F2C6, $F2A0, $01B1, $F330
; $B300
    dc.w $3A38, $A5F2, $65F3, $85F3, $A900, $85B6, $65F4, $85F4
    dc.w $90BB, $85F5, $A5F5, $C5B6, $B00B, $202D, $B3D0, $FBB0
    dc.w $DAE6, $F5D0, $EFA9, $4085, $A6E6, $F2B0, $32E6, $F2A4
    dc.w $F2B1, $F3C9, $2C18, $F002, $C99B, $6020, $28B9, $A93F
    dc.w $85C2, $2036, $ABC6, $A890, $0520, $07BD, $85B4, $2051
    dc.w $DA20, $E4BD, $20F2, $A9F0, $1FA0, $0084, $A684, $F220
    dc.w $36AB, $E6A8, $A5D2, $301A, $2000, $D8B0, $0E20, $2FB3
    dc.w $D009, $200C, $AC4C, $ADB3, $4C92, $B7A9, $0085, $B420
    dc.w $24B9, $2026, $AB20, $B2AB, $C6F2, $A5F2, $85F5, $A2FF
    dc.w $E820, $2DB3, $D0FA, $B004, $24A6, $50F4, $A4F5, $A5A8
    dc.w $488A, $A2F3, $205C, $AB68, $85A8, $2091, $AE24, $A650
    dc.w $0FE6, $B620, $04B9, $B00D, $202F, $B390, $184C, $FBB2
    dc.w $2004, $B990, $0820, $51DA, $A900, $85B4, $6020, $2FB3
    dc.w $9003, $4C4E, $B3E6, $F24C, $5FB3, $A5C9, $85AF, $A900
    dc.w $8594, $A4A8, $B18A, $C912, $F05F, $C916, $F079, $C914
    dc.w $F075, $C915, $F07E, $C91C, $F070, $20DA, $AA20, $E9AB
; $B400
    dc.w $C6A8, $24D2, $3022, $A5D5, $C910, $9006, $A5D9, $29F0
    dc.w $85D9, $20E6, $D8A9, $0085, $F2A4, $F2B1, $F348, $E6F2
    dc.w $208F, $B468, $10F3, $30BA, $2093, $ABA9, $0085, $F2A5
    dc.w $D6D0, $04C6, $D730, $ABC6, $D6A4, $F2B1, $D4E6, $F2D0
    dc.w $02E6, $D520, $91B4, $4C2F, $B4A4, $94C8, $C4AF, $9009
    dc.w $18A5, $C965, $AF85, $AF90, $F0A4, $94C4, $AFB0, $15A9
    dc.w $2020, $8FB4, $4C59, $B44C, $85B4, $2007, $BD85, $B5C6
    dc.w $A84C, $E2B3, $E6A8, $A4A8, $B18A, $C916, $F00C, $C914
    dc.w $F008, $4CE2, $B3A9, $9B20, $91B4, $A900, $85B5, $6029
    dc.w $7FE6, $944C, $99BA, $A9B2, $85F3, $A9B4, $85F4, $A207
    dc.w $86B5, $A900, $A008, $20D8, $BB20, $BBBC, $20DA, $B34C
    dc.w $F7BC, $503A, $9BA0, $0084, $A084, $A188, $84AD, $A97F
    dc.w $85AE, $8DFE, $02A9, $9B20, $99BA, $20F9, $B6A4, $A8C8
    dc.w $C4A7, $B02D, $A5A8, $4820, $06AC, $6885, $A8A5, $D210
    dc.w $0620, $CFBA, $4CCD, $B420, $CDAB, $85A1, $A5D4, $85A0
    dc.w $A4A8, $C4A7, $F003, $20CD, $ABA5, $D485, $ADA5, $D585
; $B500
    dc.w $AE20, $A2A9, $20E1, $A930, $24A0, $01B1, $8AC5, $AE90
    dc.w $0BD0, $1A88, $B18A, $C5AD, $9002, $D011, $208E, $B520
    dc.w $F2A9, $F009, $20DC, $A920, $D0A9, $4C04, $B5A5, $B5F0
    dc.w $0720, $F7BC, $A900, $85B5, $8DFE, $024C, $A8BD, $86AA
    dc.w $2062, $B5A4, $AAC6, $AF30, $0EB1, $9530, $03C8, $D0F9
    dc.w $C820, $57B5, $4C43, $B518, $9865, $9585, $95A8, $A596
    dc.w $6900, $8596, $8495, $60A0, $FF84, $AFE6, $AFA4, $AFB1
    dc.w $9548, $C99B, $F004, $297F, $F003, $2099, $BA68, $10EB
    dc.w $60A9, $2020, $99BA, $2067, $B5A9, $204C, $99BA, $A000
    dc.w $B18A, $85D4, $C8B1, $8A85, $D520, $AAD9, $20E6, $D8A5
    dc.w $F385, $95A5, $F485, $9620, $86B5, $A002, $B18A, $859F
    dc.w $C8B1, $8A85, $A7C8, $84A8, $20C2, $B5A4, $A7C4, $9F90
    dc.w $F060, $2063, $B6C9, $36F0, $1720, $6FB6, $2063, $B6C9
    dc.w $37F0, $04C9, $02B0, $0920, $61B6, $2099, $BA4C, $D7B5
    dc.w $2061, $B610, $1A29, $7F85, $AFA2, $00A5, $83A4, $8220
    dc.w $3EB5, $2067, $B5C9, $A8D0, $E720, $61B6, $4CE0, $B5C9
; $B600
    dc.w $0FF0, $18B0, $3620, $45AB, $C6A8, $20E6, $D8A5, $F385
    dc.w $95A5, $F485, $9620, $67B5, $4CE0, $B520, $61B6, $85AF
    dc.w $A922, $2099, $BAA5, $AFF0, $0A20, $61B6, $2099, $BAC6
    dc.w $AFD0, $F6A9, $2220, $99BA, $4CE0, $B538, $E910, $85AF
    dc.w $A200, $A9A7, $A0DE, $203E, $B520, $63B6, $C93D, $B0C5
    dc.w $A000, $B195, $297F, $20EC, $A3B0, $BA20, $81B5, $4CE0
    dc.w $B5E6, $A8A4, $A8C4, $A7B0, $03B1, $8A60, $6868, $6085
    dc.w $AFA2, $02A9, $A4A0, $9F20, $3EB5, $4C86, $B520, $83B8
    dc.w $20DA, $AAA5, $D309, $8048, $2023, $B8A9, $0C20, $71B8
    dc.w $2006, $ACA2, $D4A0, $0020, $88B8, $2044, $DAA9, $0185
    dc.w $D5A9, $4085, $D420, $04B9, $B003, $2006, $ACA2, $D4A0
    dc.w $0620, $88B8, $6848, $A904, $2071, $B868, $A000, $91C4
    dc.w $B18A, $C891, $C4B1, $8AC8, $91C4, $A6B3, $CA8A, $C891
    dc.w $C460, $20F9, $B620, $CDAB, $A5D5, $85A1, $A5D4, $85A0
    dc.w $20A2, $A9B0, $0568, $684C, $5EA9, $20F0, $B620, $1CB9
    dc.w $A5BE, $858A, $A5BF, $858B, $6020, $83B8, $A900, $F0B5
; $B700
    dc.w $A4A8, $B18A, $85C7, $203E, $B8B0, $3EF0, $3CC5, $C7D0
    dc.w $F5A0, $0620, $97B8, $A5E0, $48A5, $C720, $81AB, $2026
    dc.w $AD20, $0CAC, $A000, $2097, $B868, $1006, $2020, $AD10
    dc.w $0960, $2020, $ADF0, $0330, $0160, $A910, $2071, $B820
    dc.w $CBBD, $C908, $F0F3, $4CC2, $BD20, $1AB9, $2004, $B9B0
    dc.w $0320, $F7BA, $EAA9, $0085, $A085, $A120, $16B8, $20E1
    dc.w $A930, $1220, $F1B8, $20B9, $B820, $A8B8, $A900, $85B7
    dc.w $85B8, $85B6, $604C, $50A0, $2006, $ACA5, $D5F0, $0820
    dc.w $04B9, $B007, $4CD5, $B6A5, $9F85, $A760, $20A6, $B74C
    dc.w $50A0, $20A6, $B720, $79BD, $A9FD, $8595, $A9A5, $8596
    dc.w $2067, $B54C, $68B9, $20E1, $A930, $0785, $BB88, $B18A
    dc.w $85BA, $4C5B, $BD20, $E1A9, $10F8, $A5BA, $85A0, $A5BB
    dc.w $85A1, $20A2, $A920, $E1A9, $30AB, $20DC, $A920, $D0A9
    dc.w $20E1, $A930, $A04C, $19B8, $20D7, $ABA5, $D485, $BCA5
    dc.w $D585, $BD60, $2083, $B820, $E0AB, $A5D4, $F023, $A4A8
    dc.w $88B1, $8AC9, $1708, $F003, $20FC, $B6A5, $D485, $B320
; $B800
    dc.w $CDAB, $C6B3, $F00C, $2004, $B990, $F428, $F003, $203E
    dc.w $B860, $284C, $D8B6, $20A2, $A9A0, $02B1, $8A85, $9FC8
    dc.w $84A7, $6085, $C720, $7AB8, $203E, $B8B0, $08F0, $06C5
    dc.w $C7F0, $0AD0, $F3A5, $C485, $90A5, $C585, $9160, $A58F
    dc.w $C591, $9006, $A58E, $C590, $B0F3, $A904, $A290, $20F7
    dc.w $A8A0, $03B1, $9085, $B288, $B190, $85A1, $88B1, $9085
    dc.w $A088, $B190, $F009, $48A9, $0CA2, $9020, $F7A8, $6818
    dc.w $6020, $7AB8, $A8A2, $904C, $7AA8, $A690, $86C4, $A691
    dc.w $86C5, $60A4, $A884, $B360, $A906, $85C6, $B500, $91C4
    dc.w $E8C8, $C6C6, $D0F6, $60A9, $0685, $C6A2, $E0B1, $9095
    dc.w $00E8, $C8C6, $C6D0, $F660, $A58C, $858E, $8590, $850E
    dc.w $A58D, $858F, $8591, $850F, $60A6, $8686, $F5A4, $8784
    dc.w $F6A6, $F6E4, $8990, $07A6, $F5E4, $8890, $0160, $A000
    dc.w $B1F5, $29FE, $91F5, $A002, $A206, $A900, $91F5, $C8CA
    dc.w $D0FA, $A5F5, $1869, $0885, $F5A5, $F669, $0085, $F6D0
    dc.w $D0A2, $05A0, $0094, $B6CA, $10FB, $84FB, $8884, $BD84
; $B900
    dc.w $114C, $45BD, $A6A8, $E8E4, $A760, $E6B9, $E6B9, $E6B9
    dc.w $E6B9, $E6B9, $E6B9, $E6B9, $E6B9, $E6B9, $E6B9, $E6B9
    dc.w $E6B9, $E6B9, $E6B9, $E6B9, $E6B9, $E6B9, $E6B9, $E6B9
    dc.w $E6B9, $E6B9, $A900, $8DFE, $0220, $A6B7, $A5BD, $3015
    dc.w $85A1, $A5BC, $85A0, $A980, $85BD, $A5B9, $85C3, $A900
    dc.w $85B9, $4CE0, $B620, $79BD, $A937, $206F, $B6A5, $B985
    dc.w $D4A9, $0085, $D520, $93B9, $20E1, $A930, $19A9, $A485
    dc.w $95A9, $B985, $9620, $67B5, $A001, $B18A, $85D5, $88B1
    dc.w $8A85, $D420, $93B9, $2079, $BDA9, $0085, $B920, $5BBD
    dc.w $4C60, $A020, $AAD9, $20E6, $D8A5, $F385, $95A5, $F485
    dc.w $964C, $67B5, $2041, $5420, $4C49, $4E45, $A020, $E0AB
    dc.w $A5D4, $C905, $B01A, $4820, $D7AB, $A5D4, $0A0A, $0A0A
    dc.w $4820, $D7AB, $6818, $65D4, $A868, $AA98, $9DC4, $0260
    dc.w $202E, $B920, $E0AB, $A5D4, $C904, $B0F4, $0A48, $A900
    dc.w $8D08, $D2A9, $038D, $0FD2, $20D7, $AB68, $48AA, $A5D4
    dc.w $9D00, $D220, $D7AB, $A5D4, $0A0A, $0A0A, $4820, $D7AB
; $BA00
    dc.w $68A8, $68AA, $9818, $65D4, $9D01, $D260, $20D7, $ABA5
    dc.w $D485, $55A5, $D585, $5620, $E0AB, $A5D4, $8554, $6020
    dc.w $D7AB, $A5D4, $85C8, $6020, $0CBA, $A5C8, $8DFB, $02A9
    dc.w $11A2, $0620, $BEBA, $A90C, $9D4A, $03A9, $009D, $4B03
    dc.w $2029, $BD4C, $BBBC, $A206, $86C1, $20F7, $BC20, $D7AB
    dc.w $A269, $A0BA, $86F3, $84F4, $A206, $A5D4, $29F0, $491C
    dc.w $A8A5, $D420, $D8BB, $4CBB, $BC53, $3A9B, $200C, $BAA5
    dc.w $C8A2, $064C, $9BBA, $38B5, $0029, $7FE9, $4090, $1985
    dc.w $F585, $F78A, $65F5, $E8E8, $E8E8, $E8E8, $86F5, $AAE8
    dc.w $E4F5, $B004, $B500, $F0F7, $60A6, $B548, $20C0, $BABD
    dc.w $4A03, $852A, $BD4B, $0385, $2B68, $A820, $B2BA, $984C
    dc.w $BEBC, $BD47, $0348, $BD46, $0348, $98A0, $9260, $85C0
    dc.w $86C1, $4CAF, $BCA9, $0420, $D7BA, $85B4, $4C60, $A0A9
    dc.w $0820, $D7BA, $85B5, $6048, $A007, $84C1, $20AF, $BCA9
    dc.w $0C20, $2BBD, $A003, $84C0, $68A0, $0020, $02BC, $A907
    dc.w $6040, $0200, $0000, $00A9, $FFD0, $02A9, $0048, $A904
; $BB00
    dc.w $20D7, $BA68, $48A9, $0785, $C085, $CA20, $AFBC, $A00E
    dc.w $2015, $BD20, $BBBC, $AD80, $050D, $8105, $D03F, $A28C
    dc.w $18A5, $807D, $0005, $0818, $6900, $A8A5, $817D, $0105
    dc.w $2869, $00CD, $E602, $900A, $D005, $CCE5, $0290, $034C
    dc.w $0EB9, $9501, $9400, $CACA, $E082, $B0D4, $2098, $BB20
    dc.w $66B7, $A900, $85CA, $68F0, $0160, $4C50, $A0A9, $0085
    dc.w $CA20, $0AB9, $A904, $20B4, $BBA9, $00F0, $97A9, $0820
    dc.w $D7BA, $A90B, $85C0, $A280, $38B5, $00E5, $809D, $0005
    dc.w $E8B5, $00E5, $819D, $0005, $E8E0, $8E90, $EB20, $AFBC
    dc.w $A00E, $2015, $BD20, $BBBC, $20AF, $BCA5, $8285, $F3A5
    dc.w $8385, $F4AC, $8D05, $8898, $AC8C, $0520, $17BD, $20BB
    dc.w $BC4C, $F7BC, $EAEA, $48A2, $CE86, $F3A2, $BB86, $F4A2
    dc.w $0768, $A8A9, $8020, $D8BB, $20BB, $BCA9, $0760, $433A
    dc.w $9BA9, $0820, $B4BB, $D09A, $48A9, $0320, $BEBA, $689D
    dc.w $4B03, $989D, $4A03, $201E, $BD4C, $51DA, $2009, $BD4C
    dc.w $F4BB, $A903, $85C0, $20A8, $BC20, $09BD, $4820, $09BD
; $BC00
    dc.w $A868, $4898, $4820, $DAAA, $207D, $BD20, $AFBC, $689D
    dc.w $4B03, $689D, $4A03, $200F, $BD20, $9DBD, $2051, $DA4C
    dc.w $BBBC, $A90C, $85C0, $20A8, $BC20, $29BD, $4CBB, $BC20
    dc.w $A8BC, $A90D, $202B, $BD20, $00BD, $4C31, $BDA9, $2620
    dc.w $24BC, $BD4C, $03BC, $4D03, $2033, $BD20, $AFBC, $BD4E
    dc.w $034C, $31BD, $20A8, $BC20, $CDAB, $20AF, $BCA5, $D49D
    dc.w $4C03, $A5D5, $9D4D, $0320, $CDAB, $20AF, $BCA5, $D49D
    dc.w $4E03, $A925, $85C0, $D0B1, $20A8, $BC20, $D7AB, $A5D4
    dc.w $A6C1, $4C9B, $BA20, $51DA, $20A8, $BCA9, $0785, $C0A0
    dc.w $0120, $15BD, $20BB, $BCA0, $00B1, $F34C, $31BD, $200C
    dc.w $BAA2, $0620, $C0BA, $D0E3, $2007, $BD85, $C1F0, $09A5
    dc.w $C10A, $0A0A, $0AAA, $104E, $200C, $B920, $00BD, $1046
    dc.w $A000, $8CFE, $02C9, $80D0, $0984, $11A5, $CAF0, $374C
    dc.w $00A0, $A4C1, $C988, $F00F, $85B9, $C007, $D003, $20F7
    dc.w $BC20, $5BBD, $4C34, $B9C0, $07D0, $EDA2, $5DE4, $C2D0
    dc.w $E720, $F7BC, $4C53, $A020, $AFBC, $F00A, $A90C, $D02B
; $BD00
    dc.w $20AF, $BCBD, $4303, $60E6, $A820, $CDAB, $A5D4, $60A0
    dc.w $FFD0, $02A0, $00A9, $009D, $4903, $989D, $4803, $A5F4
    dc.w $A4F3, $9D45, $0398, $9D44, $03A5, $C09D, $4203, $4C56
    dc.w $E4A0, $0048, $9848, $2006, $AC68, $85D5, $6885, $D420
    dc.w $AAD9, $4C0C, $ACA9, $00A2, $079D, $00D2, $CAD0, $FAA0
    dc.w $0784, $C120, $F7BC, $C6C1, $D0F9, $60A9, $0085, $B485
    dc.w $B560, $A206, $86F2, $BD72, $BD20, $99BA, $A6F2, $CA10

; replace the 'READY' prompt...
;    dc.w $F360, $9B59, $4441, $4552, $9BA2, $00F0, $E720, $90AB
; with 'Ready'
     dc.w $F360, $9B79, $6461, $6552, $9BA2, $00F0, $E720, $90AB

    dc.w $A5D4, $85F3, $A5D5, $85F4, $A4D6, $A6D7, $F002, $A0FF
    dc.w $B1F3, $8597, $8498, $A99B, $91F3, $8592, $60A4, $98A5
    dc.w $9791, $F3A9, $0085, $9260, $203E, $B8B0, $1BD0, $F920
    dc.w $CBBD, $C90C, $F024, $C91E, $F020, $C904, $F01C, $C922
    dc.w $F018, $20F0, $B620, $16B9, $2014, $B920, $16B8, $B0F2
    dc.w $A4B2, $88B1, $8A85, $A7C8, $B18A, $60A6, $B4D0, $0EA9
    dc.w $9B20, $99BA, $A6B4, $D005, $A5C2, $2099, $BAA6, $B4A9
    dc.w $0520, $BEBA, $200F, $BD4C, $BBBC, $20FD, $AB20, $26AD
; $BE00
    dc.w $4CB2, $AB38, $60A9, $0424, $D410, $06A9, $02D0, $02A9
    dc.w $0185, $F0A5, $D429, $7F85, $D4A9, $BD18, $65FB, $AAA0
    dc.w $BE20, $98DD, $2028, $DB90, $0160, $A5D4, $297F, $38E9
    dc.w $4030, $2BC9, $0410, $CCAA, $B5D5, $85F1, $2910, $F002
    dc.w $A902, $1865, $F129, $0365, $F085, $F086, $F120, $B6DD
    dc.w $A6F1, $A900, $95E2, $E8E0, $0390, $F920, $60DA, $46F0
    dc.w $900D, $20B6, $DDA2, $CFA0, $BE20, $89DD, $2060, $DAA2
    dc.w $E6A0, $0520, $A7DD, $20B6, $DD20, $DBDA, $B085, $A906
    dc.w $A29F, $A0BE, $2040, $DDA2, $E6A0, $0520, $98DD, $20DB
    dc.w $DA46, $F090, $0918, $A5D4, $F004, $4980, $85D4, $60BD
    dc.w $0355, $1499, $393E, $0160, $4427, $52BE, $4681, $7543
    dc.w $553F, $0796, $9262, $39BF, $6459, $6408, $6740, $0157
    dc.w $0796, $3240, $9000, $0000, $003F, $0174, $5329, $2540
    dc.w $0100, $0000, $00A9, $0085, $F085, $F1A5, $D429, $7FC9
    dc.w $4030, $15A5, $D429, $8085, $F0E6, $F1A9, $7F25, $D485
    dc.w $D4A2, $EAA0, $DF20, $95DE, $A2E6, $A005, $20A7, $DD20
; $BF00
    dc.w $B6DD, $20DB, $DAB0, $39A9, $0BA2, $AEA0, $DF20, $40DD
    dc.w $B02E, $A2E6, $A005, $2098, $DD20, $DBDA, $B022, $A5F1
    dc.w $F010, $A2F0, $A0DF, $2098, $DD20, $66DA, $A5F0, $05D4
    dc.w $85D4, $A5FB, $F00A, $A2C9, $A0BE, $2098, $DD20, $28DB
    dc.w $6038, $60A9, $0085, $F1A5, $D430, $F6C9, $3FF0, $1718
    dc.w $6901, $85F1, $85E0, $A901, $85E1, $A204, $A900, $95E2
    dc.w $CA10, $FB20, $28DB, $A906, $85EF, $A2E6, $A005, $20A7
    dc.w $DD20, $B6DD, $A2F1, $A0BA, $2089, $DD20, $60DA, $A2E6
    dc.w $A005, $2098, $DD20, $DBDA, $A2EC, $A005, $20A7, $DD20
    dc.w $B6DD, $A2E6, $A005, $2089, $DD20, $28DB, $A2EC, $A005
    dc.w $2098, $DD20, $60DA, $A26C, $A0DF, $2098, $DD20, $DBDA
    dc.w $A5D4, $F00E, $A2EC, $A005, $2098, $DD20, $66DA, $C6EF
    dc.w $10C6, $A2EC, $A005, $2089, $DDA5, $F1F0, $2338, $E940
    dc.w $186A, $1869, $4029, $7F85, $E0A5, $F16A, $A901, $9002
    dc.w $A910, $85E1, $A204, $A900, $95E2, $CA10, $FB20, $DBDA
    dc.w $6000, $0000, $0000, $0000, $0000, $00A0, $0005, $F0BF


; Atari XL OS Extra code $C000-$CFFF

_ROMC000::

; $C000
    dc.w $1192, $1005, $8300, $4242, $0000, $0102, $A940, $8D0E
    dc.w $D4AD, $13D0, $8DFA, $0360, $2C0F, $D410, $036C, $0002
    dc.w $D848, $8A48, $9848, $8D0F, $D46C, $2202, $D86C, $1602
    dc.w $48AD, $0ED2, $2920, $D00D, $A9DF, $8D0E, $D2A5, $108D
    dc.w $0ED2, $6C0A, $028A, $48AD, $FFD1, $2D49, $02F0, $036C
    dc.w $3802, $A206, $BDCF, $C0E0, $05D0, $0425, $10F0, $052C
    dc.w $0ED2, $F006, $CA10, $ED4C, $A0C0, $49FF, $8D0E, $D2A5
    dc.w $108D, $0ED2, $E000, $D005, $AD6D, $02D0, $23BD, $D7C0
    dc.w $AABD, $0002, $8D8C, $02BD, $0102, $8D8D, $0268, $AA6C
    dc.w $8C02, $A900, $8511, $8DFF, $028D, $F002, $854D, $6840
    dc.w $68AA, $2C02, $D310, $06AD, $00D3, $6C02, $022C, $03D3
    dc.w $1006, $AD01, $D36C, $0402, $688D, $8C02, $6848, $2910
    dc.w $F007, $AD8C, $0248, $6C06, $02AD, $8C02, $4868, $4080
    dc.w $4004, $0201, $0810, $2036, $0814, $1210, $0E0C, $0A4C
    dc.w $DFC0, $E614, $D008, $E64D, $E613, $D002, $E612, $A9FE
    dc.w $A200, $A44D, $1006, $854D, $A613, $A9F6, $854E, $864F
; $C100
    dc.w $ADC5, $0245, $4F25, $4E8D, $17D0, $A200, $2055, $C2D0
    dc.w $0320, $4FC2, $A542, $D008, $BABD, $0401, $2904, $F003
    dc.w $4C8A, $C2AD, $13D0, $CDFA, $03D0, $B4AD, $0DD4, $8D35
    dc.w $02AD, $0CD4, $8D34, $02AD, $3102, $8D03, $D4AD, $3002
    dc.w $8D02, $D4AD, $2F02, $8D00, $D4AD, $6F02, $8D1B, $D0AD
    dc.w $6C02, $F00E, $CE6C, $02A9, $0838, $ED6C, $0229, $078D
    dc.w $05D4, $A208, $8E1F, $D058, $BDC0, $0245, $4F25, $4E9D
    dc.w $12D0, $CA10, $F2AD, $F402, $8D09, $D4AD, $F302, $8D01
    dc.w $D4A2, $0220, $55C2, $D003, $2052, $C2A2, $02E8, $E8BD
    dc.w $1802, $1D19, $02F0, $0620, $55C2, $9D26, $02E0, $08D0
    dc.w $ECAD, $0FD2, $2904, $F008, $ADF1, $02F0, $03CE, $F102
    dc.w $AD2B, $02F0, $3EAD, $0FD2, $2904, $D032, $CE2B, $02D0
    dc.w $32AD, $6D02, $D02D, $ADDA, $028D, $2B02, $AD09, $D2C9
    dc.w $9FF0, $20C9, $83F0, $1CC9, $84F0, $18C9, $94F0, $1429
    dc.w $3FC9, $11F0, $0EAD, $09D2, $8DFC, $024C, $F3C1, $A900
    dc.w $8D2B, $02AD, $00D3, $4A4A, $4A4A, $8D79, $028D, $7B02
; $C200
    dc.w $AD00, $D329, $0F8D, $7802, $8D7A, $02AD, $10D0, $8D84
    dc.w $028D, $8602, $AD11, $D08D, $8502, $8D87, $02A2, $03BD
    dc.w $00D2, $9D70, $029D, $7402, $CA10, $F48D, $0BD2, $A202
    dc.w $A001, $B978, $024A, $4A4A, $9D7D, $029D, $8102, $A900
    dc.w $2A9D, $7C02, $9D80, $02CA, $CA88, $10E6, $6C24, $026C
    dc.w $2602, $6C28, $02BC, $1802, $D008, $BC19, $02F0, $10DE
    dc.w $1902, $DE18, $02D0, $08BC, $1902, $D003, $A900, $60A9
    dc.w $FF60, $0A8D, $2D02, $8AA2, $058D, $0AD4, $CAD0, $FDAE
    dc.w $2D02, $9D17, $0298, $9D16, $0260, $68A8, $68AA, $6840
    dc.w $78AD, $13D0, $CDFA, $03D0, $2F6A, $9005, $20C9, $C4D0
    dc.w $27AD, $4402, $D022, $A9FF, $D020, $78A2, $8C88, $D0FD
    dc.w $CAD0, $FAAD, $3D03, $C95C, $D00E, $AD3E, $03C9, $93D0
    dc.w $07AD, $3F03, $C925, $F0C8, $A900, $8508, $78D8, $A2FF
    dc.w $9A20, $71C4, $A901, $8501, $A508, $D052, $A900, $A008
    dc.w $8504, $8505, $A9FF, $9104, $D104, $F002, $4601, $A900
    dc.w $9104, $D104, $F002, $4601, $C8D0, $E9E6, $05A6, $05E4
; $C300
    ; jump over code to do self test at bootup
;   dc.w $06D0, $E1A9, $2385, $0AA9, $F285, $0BAD, $01D3, $297F
    dc.w $06D0, $E1A9, $2385, $0AA9, $F285, $0B4C, $27C3, $297F

    dc.w $8D01, $D320, $73FF, $B005, $2092, $FF90, $0246, $01AD
    dc.w $01D3, $0980, $8D01, $D3A9, $FF8D, $4402, $D022, $A200
    dc.w $ADEC, $03F0, $078E, $0E00, $8E0F, $008A, $9D00, $02E0
    dc.w $EDB0, $039D, $0003, $CAD0, $F3A2, $1095, $00E8, $10FB
    dc.w $A200, $AD01, $D329, $02F0, $01E8, $8EF8, $03A9, $5C8D
    dc.w $3D03, $A993, $8D3E, $03A9, $258D, $3F03, $A902, $8552
    dc.w $A927, $8553, $AD14, $D029, $0ED0, $08A9, $05A2, $01A0
    dc.w $28D0, $06A9, $06A2, $00A0, $308D, $DA02, $8662, $8CD9

; change the LDY #$0E to #$11 to copy the extra device driver
;    dc.w $02A2, $25BD, $4BC4, $9D00, $02CA, $10F7, $A20E, $BD2E
     dc.w $02A2, $25BD, $4BC4, $9D00, $02CA, $10F7, $A211, $BD2E

    ; jump over code at $C3AB to check the result of the above test
;   dc.w $C49D, $1A03, $CA10, $F720, $35C5, $58A5, $01D0, $15AD
    dc.w $C49D, $1A03, $CA10, $F720, $35C5, $584C, $C4C3, $15AD

    dc.w $01D3, $297F, $8D01, $D3A9, $028D, $F302, $A9E0, $8DF4
    dc.w $024C, $0350, $A200, $8606, $AEE4, $02E0, $B0B0, $0DAE
    dc.w $FCBF, $D008, $E606, $20C9, $C420, $29C4, $A903, $A200
    dc.w $9D42, $03A9, $489D, $4403, $A9C4, $9D45, $03A9, $0C9D
    dc.w $4A03, $2056, $E410, $034C, $AAC2, $E8D0, $FDC8, $10FA
; $C400
    dc.w $206E, $C6A5, $06F0, $06AD, $FDBF, $6A90, $0620, $8BC5

    ; remove JSR to relocating handler
;   dc.w $2039, $E7A9, $008D, $4402, $A506, $F00A, $ADFD, $BF29
    dc.w $EAEA, $EAA9, $008D, $4402, $A506, $F00A, $ADFD, $BF29

    dc.w $04F0, $036C, $FABF, $6C0A, $006C, $FEBF, $1860, $5030

; this is the device table that gets copied to $31A, followed by
; the string 'BOOT ERROR'
;           C:          E:       S:          K:       B    O O
;   dc.w $E443, $40E4, $4500, $E453, $10E4, $4B20, $E442, $4F4F
;         T      E R    R O    R
;   dc.w $5420, $4552, $524F, $529B, $453A, $9BCE, $C0CD, $C0CD

; replace the C: driver with F: and add the R: at the end.
; Replace the string with '*Error*'
;           R:          E:       S:          K:       F:  $CB90
    dc.w $E452, $80CB, $4500, $E453, $10E4, $4B20, $E446, $90CB
;         * E    R R    O R    *
    dc.w $2D45, $5252, $4F52, $2D9B, $453A, $9BCE, $C0CD, $C0CD

    dc.w $C0CD, $C019, $FC2C, $EBAD, $EAEC, $EACD, $C0CD, $C0CD
    dc.w $C030, $C000, $0000, $0000, $0000, $0000, $00E2, $C08A
    dc.w $C2AD, $13D0, $6A90, $0DAD, $FCBF, $D008, $ADFD, $BF10
    dc.w $036C, $FEBF, $20DA, $C4AD, $01D3, $0902, $8D01, $D3A5
    dc.w $08F0, $07AD, $F803, $D011, $F007, $AD1F, $D029, $04F0
    dc.w $08AD, $01D3, $29FD, $8D01, $D3A9, $00A8, $8505, $A928
    dc.w $8506, $B105, $49FF, $9105, $D105, $D00C, $49FF, $9105
    dc.w $D105, $D004, $E606, $D0EA, $60A9, $00AA, $187D, $F0BF
    dc.w $E8D0, $FACD, $EB03, $8DEB, $0360, $A900, $AA8D, $03D3

    ; prevent store to PIA
;   dc.w $9D00, $D09D, $00D4, $9D00, $D2E0, $01F0, $039D, $00D3
    dc.w $9D00, $D09D, $00D4, $9D00, $D2E0, $01F0, $03EA, $EAEA

    dc.w $E8D0, $EDA9, $3C8D, $03D3, $A9FF, $8D01, $D3A9, $388D
; $C500
    dc.w $02D3, $8D03, $D3A9, $008D, $00D3, $A9FF, $8D01, $D3A9
    dc.w $3C8D, $02D3, $8D03, $D3AD, $01D3, $AD00, $D3A9, $228D
    dc.w $0FD2, $A9A0, $8D05, $D28D, $07D2, $A928, $8D08, $D2A9
    dc.w $FF8D, $0DD2, $60C6, $11A9, $928D, $3602, $A9C0, $8D37
    dc.w $02A5, $068D, $E402, $8DE6, $02A9, $008D, $E502, $A900
    dc.w $8DE7, $02A9, $078D, $E802, $200C, $E420, $1CE4, $202C
    dc.w $E420, $3CE4, $204C, $E420, $6EE4, $2065, $E420, $6BE4
    dc.w $2050, $E4A9, $6E8D, $3802, $A9C9, $8D39, $0220, $9BE4
    dc.w $AD1F, $D029, $0149, $018D, $E903, $60A5, $08F0, $09A5
    dc.w $0929, $01F0, $334C, $3BC6, $A901, $8D01, $03A9, $538D
    dc.w $0203, $2053, $E430, $21A9, $008D, $0B03, $A901, $8D0A
    dc.w $03A9, $008D, $0403, $A904, $8D05, $0320, $59C6, $1009
    dc.w $203E, $C6AD, $EA03, $F0DF, $60A2, $03BD, $0004, $9D40
    dc.w $02CA, $10F7, $AD42, $0285, $04AD, $4302, $8505, $AD04
    dc.w $0485, $0CAD, $0504, $850D, $A07F, $B900, $0491, $0488
    dc.w $10F8, $18A5, $0469, $8085, $04A5, $0569, $0085, $05CE
; $C600
    dc.w $4102, $F012, $EE0A, $0320, $59C6, $10DC, $203E, $C6AD
    dc.w $EA03, $D0AC, $F0F1, $ADEA, $03F0, $0320, $59C6, $2029
    dc.w $C6B0, $9D20, $3BC6, $E609, $6018, $AD42, $0269, $0685

; replace LDX #$3D (lo byte of pointer to "BOOT ERROR"
;   dc.w $04AD, $4302, $6900, $8505, $6C04, $006C, $0C00, $A23D

; with LDX #$40 (pointer to "*ERROR*")
    dc.w $04AD, $4302, $6900, $8505, $6C04, $006C, $0C00, $A240

    dc.w $A0C4, $8AA2, $009D, $4403, $989D, $4503, $A909, $9D42
    dc.w $03A9, $FF9D, $4803, $4C56, $E4AD, $EA03, $F003, $4C7A
    dc.w $E4A9, $528D, $0203, $A901, $8D01, $034C, $53E4, $A508

    ; $C67B put RTS at cassette boot code
;   dc.w $F009, $A509, $2902, $F027, $4CA0, $C6AD, $E903, $F01F
    dc.w $F009, $A509, $2902, $F027, $4CA0, $C660, $E903, $F01F

    dc.w $A980, $853E, $EEEA, $0320, $7DE4, $20BB, $C5A9, $008D
    dc.w $EA03, $8DE9, $0306, $09A5, $0C85, $02A5, $0D85, $0360
    dc.w $6C02, $00A9, $A08D, $4602, $A980, $8DD5, $02A9, $008D
    dc.w $D602, $60A9, $318D, $0003, $AD46, $02AE, $0203, $E021
    dc.w $F002, $A907, $8D06, $03A2, $40AD, $0203, $C950, $F004
    dc.w $C957, $D002, $A280, $C953, $D010, $A9EA, $8D04, $03A9
    dc.w $028D, $0503, $A004, $A900, $F006, $ACD5, $02AD, $D602
    dc.w $8E03, $038C, $0803, $8D09, $0320, $59E4, $1001, $60AD
; $C700
    dc.w $0203, $C953, $D00A, $203A, $C7A0, $02B1, $158D, $4602
    dc.w $AD02, $03C9, $21D0, $1F20, $3AC7, $A0FE, $C8C8, $B115
    dc.w $C9FF, $D0F8, $C8B1, $15C8, $C9FF, $D0F2, $8888, $8C08
    dc.w $03A9, $008D, $0903, $AC03, $0360, $AD04, $0385, $15AD
    dc.w $0503, $8516, $60A2, $05A9, $009D, $C902, $CA10, $F8A9
    dc.w $008D, $3302, $20CF, $C7A0, $9CB0, $398D, $8802, $20CF
    dc.w $C7A0, $9CB0, $2F8D, $4502, $AD88, $02C9, $0BF0, $262A
    dc.w $AABD, $E4C8, $8DC9, $02BD, $E5C8, $8DCA, $02AD, $4502
    dc.w $CD33, $02F0, $CA20, $CFC7, $A09C, $B008, $20D2, $C7EE
    dc.w $3302, $D0E9, $6020, $CFC7, $A09C, $B02C, $8DC9, $0220
    dc.w $CFC7, $A09C, $B022, $8DCA, $02AD, $4502, $C901, $F016
    dc.w $9017, $18AD, $C902, $6DD1, $02A8, $ADCA, $026D, $D202
    dc.w $8CC9, $028D, $CA02, $A001, $60A0, $00A9, $00F0, $F16C
    dc.w $CF02, $6CC9, $02AC, $3302, $C001, $F00A, $B073, $8D4A
    dc.w $028D, $8E02, $906A, $8D4B, $028D, $8F02, $A200, $AD88
    dc.w $02F0, $06C9, $0AF0, $15A2, $0218, $AD4A, $027D, $D102
; $C800
    dc.w $8D8E, $02AD, $4B02, $7DD2, $028D, $8F02, $18AD, $8E02
    dc.w $6D45, $0248, $A900, $6D8F, $02A8, $6838, $E902, $B001
    dc.w $8848, $98DD, $CC02, $6890, $10D0, $05DD, $CB02, $9009
    dc.w $9DCB, $0248, $989D, $CC02, $68AE, $8802, $E001, $F010
    dc.w $CCE6, $0290, $0BD0, $05CD, $E502, $9004, $6868, $A09D
    dc.w $6038, $48AD, $3302, $E902, $186D, $8E02, $8536, $A900
    dc.w $6D8F, $0285, $3768, $A000, $9136, $4C50, $C818, $6D8E
    dc.w $0285, $36A9, $006D, $8F02, $8537, $A000, $B136, $186D
    dc.w $D102, $9136, $E636, $D002, $E637, $B136, $6DD2, $0291
    dc.w $3660, $A200, $AC88, $02C0, $0490, $02A2, $0218, $6D8E
    dc.w $0285, $36A9, $006D, $8F02, $8537, $A000, $B136, $187D
    dc.w $D102, $9136, $6048, $AD33, $026A, $68B0, $1518, $6D8E
    dc.w $0285, $36A9, $006D, $8F02, $8537, $A000, $B136, $8D88
    dc.w $0260, $186D, $D102, $A900, $6DD2, $026D, $8802, $A000
    dc.w $9136, $F0ED, $D5C7, $D5C7, $92C8, $92C8, $92C8, $92C8
    dc.w $6DC8, $6DC8, $B5C8, $B5C8, $D5C7, $95C7, $A9FF, $8D44
; $C900
    dc.w $02AD, $01D3, $297F, $8D01, $D34C, $83E4, $A901, $8D48
    dc.w $02AD, $4802, $8DFF, $D1AD, $03D8, $C980, $D00A, $AD0B
    dc.w $D8C9, $91D0, $0320, $19D8, $0E48, $02D0, $E4A9, $008D
    dc.w $FFD1, $60A9, $018D, $4200, $AD01, $0348, $AD47, $02F0
    dc.w $1AA2, $0820, $AFC9, $F013, $8A48, $2005, $D868, $AA90
    dc.w $F2A9, $008D, $4802, $8DFF, $D1F0, $0320, $71E9, $688D
    dc.w $0103, $A900, $8D42, $008C, $0303, $AC03, $0360, $A208
    dc.w $6AB0, $03CA, $D0FA, $AD48, $0248, $BD20, $CA8D, $4802
    dc.w $8DFF, $D120, $08D8, $688D, $4802, $8DFF, $D168, $AA68
    dc.w $40A0, $014C, $DCC9, $A003, $4CDC, $C9A0, $054C, $DCC9
    dc.w $A007, $4CDC, $C9A0, $094C, $DCC9, $A00B, $4CDC, $C9CA
    dc.w $1009, $A900, $8D48, $028D, $FFD1, $60AD, $4702, $3D21
    dc.w $CAF0, $EC8D, $4802, $8DFF, $D160, $B90D, $D848, $88B9
    dc.w $0DD8, $48AD, $4C02, $AE4D, $02A0, $9260, $8D4C, $028E
    dc.w $4D02, $AD42, $0048, $A901, $8D42, $00A2, $0820, $AFC9
    dc.w $F011, $8A48, $9848, $20CA, $C990, $208D, $4C02, $6868
; $CA00
    dc.w $4C05, $CAA0, $82A9, $008D, $4802, $8DFF, $D168, $8D42
    dc.w $00AD, $4C02, $8C4D, $02AC, $4D02, $6068, $A868, $AA90
    dc.w $CC80, $4020, $1008, $0402, $01AE, $2E00, $BD4D, $0320
    dc.w $DEE7, $B020, $1820, $9EE8, $B01A, $AE2E, $00BD, $4C03
    dc.w $2016, $E7B0, $0FAE, $2E00, $9D40, $0385, $20A9, $0385
    dc.w $174C, $5CE5, $4C10, $E500, $1316, $D1E4, $E4E8, $29EB
    dc.w $EE00, $002D, $252D, $2F32, $3900, $3425, $3334, $0000
    dc.w $0032, $2F2D, $3221, $2D00, $002B, $2539, $222F, $2132
    dc.w $2400, $3425, $3334, $0000, $00B2, $9100, $9200, $9300
    dc.w $9400, $A800, $A100, $A200, $0000, $5B00, $1100, $1200
    dc.w $1300, $1400, $1500, $1600, $1700, $1800, $1900, $1000
    dc.w $1C00, $1E00, $A280, $B300, $0000, $FFFF, $0031, $0037
    dc.w $0025, $0032, $0034, $0039, $0035, $0029, $002F, $0030
    dc.w $000D, $001D, $00B2, $B400, $0000, $80DC, $8000, $2100
    dc.w $3300, $2400, $2600, $2700, $2800, $2A00, $2B00, $2C00
    dc.w $1B00, $0B00, $0A00, $A300, $0000, $80B3, $A880, $003A
; $CB00
    dc.w $0038, $0023, $0036, $0022, $002E, $002D, $000C, $000E
    dc.w $000F, $0080, $B3A8, $8000, $0000, $0000, $0000, $0080
    dc.w $B380, $B080, $A180, $A380, $A580, $8080, $A280, $A180
    dc.w $B280, $0033, $0030, $0021, $0023, $0025, $0000, $0022
    dc.w $0021, $0032, $0000, $3328, $0022, $0033, $005C, $0036
    dc.w $2F29, $2325, $0003, $A011, $A900, $1871, $4A88, $10FB
    dc.w $6900, $49FF, $6000, $0000, $0000, $0000, $0000, $0000

; this chunk has memo pad message "ST XFORMER 3.0"
; $CB70
    dc.w $7D53, $5420, $5846, $4F52, $4D45, $5220, $332E, $309B

; $CB80
; this 128 byte block is normally empty in the XE ROMs.
; Replace with R: and F: device tables
    dc.w $9FCB, $A1CB, $A3CB, $A5CB, $A7CB, $A9CB, $0000, $0000 ; R:
    dc.w $AFCB, $B1CB, $B3CB, $B5CB, $B7CB, $B9CB, $0000, $0000 ; F:

; R: driver
    dc.w $5252, $5353, $5454, $5A5A, $5B5B, $5C5C, $0000, $0000
; F: driver
    dc.w $D2D2, $D3D3, $D4D4, $DADA, $DBDB, $DCDC, $0000, $0000
; SIO driver
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
; memo pad driver
    ; LDX #$70
    ; LDY #$CB
    ; JSR $C642
    ;loop:
    ; JSR $F24A (E: get)
    ; JMP loop ($CBE7)
    dc.w $A270, $A0CB, $2042, $C620, $4AF2, $4CE7, $CB00, $0000
    dc.w $8000, $0000, $0000, $0000, $0000, $0000, $0000, $0000

_fnt_intl::
_ROMCC00::
; $CC00
    dc.w $0000, $0000, $0000, $0000, $0018, $1818, $1800, $1800
    dc.w $0066, $6666, $0000, $0000, $0066, $FF66, $66FF, $6600
    dc.w $183E, $603C, $067C, $1800, $0066, $6C18, $3066, $4600
    dc.w $1C36, $1C38, $6F66, $3B00, $0018, $1818, $0000, $0000
    dc.w $000E, $1C18, $181C, $0E00, $0070, $3818, $1838, $7000
    dc.w $0066, $3CFF, $3C66, $0000, $0018, $187E, $1818, $0000
    dc.w $0000, $0000, $0018, $1830, $0000, $007E, $0000, $0000
    dc.w $0000, $0000, $0018, $1800, $0006, $0C18, $3060, $4000
    dc.w $003C, $666E, $7666, $3C00, $0018, $3818, $1818, $7E00
    dc.w $003C, $660C, $1830, $7E00, $007E, $0C18, $0C66, $3C00
    dc.w $000C, $1C3C, $6C7E, $0C00, $007E, $607C, $0666, $3C00
    dc.w $003C, $607C, $6666, $3C00, $007E, $060C, $1830, $3000
    dc.w $003C, $663C, $6666, $3C00, $003C, $663E, $060C, $3800
    dc.w $0000, $1818, $0018, $1800, $0000, $1818, $0018, $1830
    dc.w $060C, $1830, $180C, $0600, $0000, $7E00, $007E, $0000
    dc.w $6030, $180C, $1830, $6000, $003C, $660C, $1800, $1800
; $CD00
    dc.w $003C, $666E, $6E60, $3E00, $0018, $3C66, $667E, $6600
    dc.w $007C, $667C, $6666, $7C00, $003C, $6660, $6066, $3C00
    dc.w $0078, $6C66, $666C, $7800, $007E, $607C, $6060, $7E00
    dc.w $007E, $607C, $6060, $6000, $003E, $6060, $6E66, $3E00
    dc.w $0066, $667E, $6666, $6600, $007E, $1818, $1818, $7E00
    dc.w $0006, $0606, $0666, $3C00, $0066, $6C78, $786C, $6600
    dc.w $0060, $6060, $6060, $7E00, $0063, $777F, $6B63, $6300
    dc.w $0066, $767E, $7E6E, $6600, $003C, $6666, $6666, $3C00
    dc.w $007C, $6666, $7C60, $6000, $003C, $6666, $666C, $3600
    dc.w $007C, $6666, $7C6C, $6600, $003C, $603C, $0606, $3C00
    dc.w $007E, $1818, $1818, $1800, $0066, $6666, $6666, $7E00
    dc.w $0066, $6666, $663C, $1800, $0063, $636B, $7F77, $6300
    dc.w $0066, $663C, $3C66, $6600, $0066, $663C, $1818, $1800
    dc.w $007E, $0C18, $3060, $7E00, $001E, $1818, $1818, $1E00
    dc.w $0040, $6030, $180C, $0600, $0078, $1818, $1818, $7800
    dc.w $0008, $1C36, $6300, $0000, $0000, $0000, $0000, $FF00
_ROMCE00::
; $CE00
    dc.w $0C18, $3C06, $3E66, $3E00, $3018, $0066, $6666, $3E00
    dc.w $366C, $0076, $767E, $6E00, $0C18, $7E60, $7C60, $7E00
    dc.w $0000, $3C60, $603C, $1830, $3C66, $003C, $6666, $3C00
    dc.w $3018, $003C, $6666, $3C00, $3018, $0038, $1818, $3C00
    dc.w $1C30, $3078, $3030, $7E00, $0066, $0038, $1818, $3C00
    dc.w $0066, $0066, $6666, $3E00, $3600, $3C06, $3E66, $3E00
    dc.w $6600, $3C66, $6666, $3C00, $0C18, $0066, $6666, $3E00
    dc.w $0C18, $003C, $6666, $3C00, $0066, $003C, $6666, $3C00
    dc.w $6600, $6666, $6666, $7E00, $3C66, $1C06, $3E66, $3E00
    dc.w $3C66, $0066, $6666, $3E00, $3C66, $0038, $1818, $3C00
    dc.w $0C18, $3C66, $7E60, $3C00, $3018, $3C66, $7E60, $3C00
    dc.w $366C, $007C, $6666, $6600, $3CC3, $3C66, $7E60, $3C00
    dc.w $1800, $3C06, $3E66, $3E00, $3018, $3C06, $3E66, $3E00
    dc.w $1800, $183C, $667E, $6600, $7860, $7860, $7E18, $1E00
    dc.w $0018, $3C7E, $1818, $1800, $0018, $1818, $7E3C, $1800
    dc.w $0018, $307E, $3018, $0000, $0018, $0C7E, $0C18, $0000
_ROMCF00::
; $CF00
    dc.w $0018, $3C7E, $7E3C, $1800, $0000, $3C06, $3E66, $3E00
    dc.w $0060, $607C, $6666, $7C00, $0000, $3C60, $6060, $3C00
    dc.w $0006, $063E, $6666, $3E00, $0000, $3C66, $7E60, $3C00
    dc.w $000E, $183E, $1818, $1800, $0000, $3E66, $663E, $067C
    dc.w $0060, $607C, $6666, $6600, $0018, $0038, $1818, $3C00
    dc.w $0006, $0006, $0606, $063C, $0060, $606C, $786C, $6600
    dc.w $0038, $1818, $1818, $3C00, $0000, $667F, $7F6B, $6300
    dc.w $0000, $7C66, $6666, $6600, $0000, $3C66, $6666, $3C00
    dc.w $0000, $7C66, $667C, $6060, $0000, $3E66, $663E, $0606
    dc.w $0000, $7C66, $6060, $6000, $0000, $3E60, $3C06, $7C00
    dc.w $0018, $7E18, $1818, $0E00, $0000, $6666, $6666, $3E00
    dc.w $0000, $6666, $663C, $1800, $0000, $636B, $7F3E, $3600
    dc.w $0000, $663C, $183C, $6600, $0000, $6666, $663E, $0C78
    dc.w $0000, $7E0C, $1830, $7E00, $0018, $3C7E, $7E18, $3C00
    dc.w $1818, $1818, $1818, $1818, $007E, $787C, $6E66, $0600
    dc.w $0818, $3878, $3818, $0800, $1018, $1C1E, $1C18, $1000



; hardware registers default values

_ROMD000::
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000 ; GTIA
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0101, $0100, $0F0F, $0F0F, $0F0F, $0F0F, $0F0F, $0F07

_ROMD100::
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1
    dc.w $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1, $D1D1

_ROMD200::
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF ; POKEY
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF
    dc.w $E4E4, $E4E4, $E4E4, $E4E4, $FFFF, $FFFF, $FFE2, $F7FF

_ROMD300::
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C ; PIA
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C
    dc.w $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C, $FFFD, $3C3C

_ROMD400::
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F ; ANTIC
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F
    dc.w $FFFF, $FFFF, $FFFF, $FFFF, $FFFF, $FF00, $00FF, $FF1F

_ROMD500::
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5
    dc.w $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5, $D5D5

_ROMD600::
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6 ; SIO buffer
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6
    dc.w $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6, $D6D6

_ROMD700::
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7 ; R: Z: T:
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7
    dc.w $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7, $D7D7


; Atari OS floating point routines $D800-$DFFF

_ROMD800::


; $D800
    dc.w $20A1, $DB20, $BBDB, $B039, $A2ED, $A004, $2048, $DAA2
    dc.w $FF86, $F120, $44DA, $F004, $A9FF, $85F0, $2094, $DBB0
    dc.w $2148, $A6D5, $D011, $20EB, $DB68, $05D9, $85D9, $A6F1
    dc.w $30E6, $E886, $F1D0, $E168, $A6F1, $1002, $E6ED, $4C18
    dc.w $D860, $C92E, $F014, $C945, $F019, $A6F0, $D068, $C92B
    dc.w $F0C6, $C92D, $F000, $85EE, $F0BE, $A6F1, $1058, $E886
    dc.w $F1F0, $B5A5, $F285, $EC20, $94DB, $B037, $AAA5, $ED48
    dc.w $86ED, $2094, $DBB0, $1748, $A5ED, $0A85, $ED0A, $0A65
    dc.w $ED85, $ED68, $1865, $ED85, $EDA4, $F220, $9DDB, $A5EF
    dc.w $F009, $A5ED, $49FF, $1869, $0185, $ED68, $1865, $ED85
    dc.w $EDD0, $13C9, $2BF0, $06C9, $2DD0, $0785, $EF20, $94DB
    dc.w $90BA, $A5EC, $85F2, $C6F2, $A5ED, $A6F1, $3005, $F003
    dc.w $38E5, $F148, $2A68, $6A85, $ED90, $0320, $EBDB, $A5ED
    dc.w $1869, $4485, $D420, $00DC, $B00B, $A6EE, $F006, $A5D4
    dc.w $0980, $85D4, $1860, $2051, $DAA9, $308D, $7F05, $A5D4
    dc.w $F028, $297F, $C93F, $9028, $C945, $B024, $38E9, $3F20
; $D900
    dc.w $70DC, $20A4, $DC09, $809D, $8005, $AD80, $05C9, $2EF0
    dc.w $034C, $88D9, $20C1, $DC4C, $9CD9, $A9B0, $8D80, $0560
    dc.w $A901, $2070, $DC20, $A4DC, $E886, $F2A5, $D40A, $38E9
    dc.w $80AE, $8005, $E030, $F017, $AE81, $05AC, $8205, $8E82
    dc.w $058C, $8105, $A6F2, $E002, $D002, $E6F2, $1869, $0185
    dc.w $EDA9, $45A4, $F220, $9FDC, $84F2, $A5ED, $100B, $A900
    dc.w $38E5, $ED85, $EDA9, $2DD0, $02A9, $2B20, $9FDC, $A200
    dc.w $A5ED, $38E9, $0A90, $03E8, $D0F8, $1869, $0A48, $8A20
    dc.w $9DDC, $6809, $8020, $9DDC, $AD80, $05C9, $30D0, $0D18
    dc.w $A5F3, $6901, $85F3, $A5F4, $6900, $85F4, $A5D4, $1009
    dc.w $20C1, $DCA0, $00A9, $2D91, $F360, $A5D4, $85F8, $A5D5
    dc.w $85F7, $2044, $DAF8, $A010, $06F8, $26F7, $A203, $B5D4
    dc.w $75D4, $95D4, $CAD0, $F788, $D0EE, $D8A9, $4285, $D44C
    dc.w $00DC, $A900, $85F7, $85F8, $A5D4, $3066, $C943, $B062
    dc.w $38E9, $4090, $3F69, $000A, $85F5, $205A, $DAB0, $53A5
    dc.w $F785, $F9A5, $F885, $FA20, $5ADA, $B046, $205A, $DAB0
; $DA00
    dc.w $4118, $A5F8, $65FA, $85F8, $A5F7, $65F9, $85F7, $B032
    dc.w $20B9, $DC18, $65F8, $85F8, $A5F7, $6900, $B024, $85F7
    dc.w $C6F5, $D0C6, $20B9, $DCC9, $0590, $0D18, $A5F8, $6901
    dc.w $85F8, $A5F7, $6900, $85F7, $A5F8, $85D4, $A5F7, $85D5
    dc.w $1860, $3860, $A2D4, $A006, $A900, $9500, $E888, $D0FA
    dc.w $60A9, $0585, $F4A9, $8085, $F360, $1826, $F826, $F760
    dc.w $A5E0, $4980, $85E0, $A5E0, $297F, $85F7, $A5D4, $297F
    dc.w $38E5, $F710, $10A2, $05B5, $D4B4, $E095, $E098, $95D4
    dc.w $CA10, $F430, $E1F0, $07C9, $05B0, $1920, $3EDC, $F8A5
    dc.w $D445, $E030, $1EA2, $0418, $B5D5, $75E1, $95D5, $CA10
    dc.w $F7D8, $B003, $4C00, $DCA9, $0120, $3ADC, $A901, $85D5
    dc.w $4C00, $DCA2, $0438, $B5D5, $F5E1, $95D5, $CA10, $F790
    dc.w $04D8, $4C00, $DCA5, $D449, $8085, $D438, $A204, $A900
    dc.w $F5D5, $95D5, $CA10, $F7D8, $4C00, $DCA5, $D4F0, $45A5
    dc.w $E0F0, $3E20, $CFDC, $38E9, $4038, $65E0, $3038, $20E0
    dc.w $DCA5, $DF29, $0F85, $F6C6, $F630, $0620, $01DD, $4CF7
; $DB00
    dc.w $DAA5, $DF4A, $4A4A, $4A85, $F6C6, $F630, $0620, $05DD
    dc.w $4C09, $DB20, $62DC, $C6F5, $D0D7, $A5ED, $85D4, $4C04
    dc.w $DC20, $44DA, $1860, $3860, $A5E0, $F0FA, $A5D4, $F0F4
    dc.w $20CF, $DC38, $E5E0, $1869, $4030, $EB20, $E0DC, $E6F5
    dc.w $4C4E, $DBA2, $00B5, $D595, $D4E8, $E00C, $D0F7, $A005
    dc.w $38F8, $B9DA, $00F9, $E600, $99DA, $0088, $10F4, $D890
    dc.w $04E6, $D9D0, $E920, $0FDD, $06D9, $06D9, $06D9, $06D9
    dc.w $A005, $38F8, $B9DA, $00F9, $E000, $99DA, $0088, $10F4
    dc.w $D890, $04E6, $D9D0, $E920, $09DD, $C6F5, $D0B5, $2062
    dc.w $DC4C, $1ADB, $20AF, $DBA4, $F290, $02B1, $F3C8, $84F2
    dc.w $60A4, $F2A9, $20D1, $F3D0, $03C8, $D0F9, $84F2, $60A4
    dc.w $F2B1, $F338, $E930, $9018, $C90A, $60A5, $F248, $2094
    dc.w $DB90, $1FC9, $2EF0, $14C9, $2BF0, $07C9, $2DF0, $0368
    dc.w $3860, $2094, $DB90, $0BC9, $2ED0, $F420, $94DB, $9002
    dc.w $B0ED, $6885, $F218, $60A2, $E7D0, $02A2, $D5A0, $0418
    dc.w $3604, $3603, $3602, $3601, $3600, $26EC, $88D0, $F060
; $DC00
    dc.w $A200, $86DA, $A204, $A5D4, $F02E, $A5D5, $D01A, $A000
    dc.w $B9D6, $0099, $D500, $C8C0, $0590, $F5C6, $D4CA, $D0EA
    dc.w $A5D5, $D004, $85D4, $1860, $A5D4, $297F, $C971, $9001
    dc.w $60C9, $0FB0, $0320, $44DA, $1860, $A2D4, $D002, $A2E0
    dc.w $86F9, $85F7, $85F8, $A004, $B504, $9505, $CA88, $D0F8
    dc.w $A900, $9505, $A6F9, $C6F7, $D0EC, $B500, $1865, $F895
    dc.w $0060, $A20A, $B5D4, $95D5, $CA10, $F9A9, $0085, $D460
    dc.w $85F7, $A200, $A000, $2093, $DC38, $E901, $85F7, $B5D5
    dc.w $4A4A, $4A4A, $209D, $DCB5, $D529, $0F20, $9DDC, $E8E0
    dc.w $0590, $E3A5, $F7D0, $05A9, $2E20, $9FDC, $6009, $3099
    dc.w $8005, $C860, $A20A, $BD80, $05C9, $2EF0, $07C9, $30D0
    dc.w $07CA, $D0F2, $CABD, $8005, $6020, $EBDB, $A5EC, $290F
    dc.w $6038, $A5F3, $E901, $85F3, $A5F4, $E900, $85F4, $60A5
    dc.w $D445, $E029, $8085, $EE06, $E046, $E0A5, $D429, $7F60
    dc.w $05EE, $85ED, $A900, $85D4, $85E0, $2028, $DD20, $E7DB
    dc.w $A5EC, $290F, $85E6, $A905, $85F5, $2034, $DD20, $44DA
; $DD00
    dc.w $60A2, $D9D0, $06A2, $D9D0, $08A2, $DFA0, $E5D0, $04A2
    dc.w $DFA0, $EBA9, $0585, $F718, $F8B5, $0079, $0000, $9500
    dc.w $CA88, $C6F7, $10F3, $D860, $A005, $B9E0, $0099, $E600
    dc.w $8810, $F760, $A005, $B9D4, $0099, $DA00, $8810, $F760
    dc.w $86FE, $84FF, $85EF, $A2E0, $A005, $20A7, $DD20, $B6DD
    dc.w $A6FE, $A4FF, $2089, $DDC6, $EFF0, $2D20, $DBDA, $B028
    dc.w $18A5, $FE69, $0685, $FE90, $06A5, $FF69, $0085, $FFA6
    dc.w $FEA4, $FF20, $98DD, $2066, $DAB0, $0DC6, $EFF0, $09A2
    dc.w $E0A0, $0520, $98DD, $30D3, $6086, $FC84, $FDA0, $05B1
    dc.w $FC99, $D400, $8810, $F860, $86FC, $84FD, $A005, $B1FC
    dc.w $99E0, $0088, $10F8, $6086, $FC84, $FDA0, $05B9, $D400
    dc.w $91FC, $8810, $F860, $A205, $B5D4, $95E0, $CA10, $F960
    dc.w $A289, $A0DE, $2098, $DD20, $DBDA, $B07F, $A900, $85F1
    dc.w $A5D4, $85F0, $297F, $85D4, $38E9, $4030, $26C9, $0410
    dc.w $6AA2, $E6A0, $0520, $A7DD, $20D2, $D9A5, $D485, $F1A5
    dc.w $D5D0, $5820, $AAD9, $20B6, $DDA2, $E6A0, $0520, $89DD
; $DE00
    dc.w $2060, $DAA9, $0AA2, $4DA0, $DE20, $40DD, $20B6, $DD20
    dc.w $DBDA, $A5F1, $F023, $186A, $85E0, $A901, $9002, $A910
    dc.w $85E1, $A204, $A900, $95E2, $CA10, $FBA5, $E018, $6940
    dc.w $B019, $3017, $85E0, $20DB, $DAA5, $F010, $0D20, $B6DD
    dc.w $A28F, $A0DE, $2089, $DD20, $28DB, $6038, $603D, $1794
    dc.w $1900, $003D, $5733, $0500, $003E, $0554, $7662, $003E
    dc.w $3219, $6227, $003F, $0168, $6030, $363F, $0732, $0327
    dc.w $413F, $2543, $3456, $753F, $6627, $3730, $5040, $0115
    dc.w $1292, $553F, $9999, $9999, $993F, $4342, $9448, $1940
    dc.w $0100, $0000, $0086, $FE84, $FFA2, $E0A0, $0520, $A7DD
    dc.w $A6FE, $A4FF, $2098, $DD20, $66DA, $A2E6, $A005, $20A7
    dc.w $DDA2, $E0A0, $0520, $89DD, $A6FE, $A4FF, $2098, $DD20
    dc.w $60DA, $A2E6, $A005, $2098, $DD20, $28DB, $60A9, $01D0
    dc.w $02A9, $0085, $F0A5, $D4F0, $0530, $034C, $F6DF, $3860
    dc.w $E940, $0A85, $F1A5, $D529, $F0D0, $04A9, $01D0, $04E6
    dc.w $F1A9, $1085, $E1A2, $04A9, $0095, $E2CA, $10FB, $2028
; $DF00
    dc.w $DBA2, $66A0, $DF20, $95DE, $A2E6, $A005, $20A7, $DD20
    dc.w $B6DD, $20DB, $DAA9, $0AA2, $72A0, $DF20, $40DD, $A2E6
    dc.w $A005, $2098, $DD20, $DBDA, $A26C, $A0DF, $2098, $DD20
    dc.w $66DA, $20B6, $DDA9, $0085, $D5A5, $F185, $D410, $0749
    dc.w $FF18, $6901, $85D4, $20AA, $D924, $F110, $06A9, $8005
    dc.w $D485, $D420, $66DA, $A5F0, $F00A, $A289, $A0DE, $2098
    dc.w $DD20, $28DB, $1860, $4003, $1622, $7766, $3F50, $0000
    dc.w $0000, $3F49, $1557, $1108, $BF51, $7049, $4708, $3F39
    dc.w $2057, $6195, $BF04, $3963, $0355, $3F10, $0930, $1264
    dc.w $3F09, $3908, $0460, $3F12, $4258, $4742, $3F17, $3712
    dc.w $0608, $3F28, $9529, $7117, $3F86, $8588, $9644, $3E16
    dc.w $0544, $4900, $BE95, $6838, $4500, $3F02, $6879, $9416
    dc.w $BF04, $9278, $9080, $3F07, $0315, $2000, $BF08, $9229
    dc.w $1244, $3F11, $0840, $0911, $BF14, $2831, $5604, $3F19
    dc.w $9998, $7744, $BF33, $3333, $3113, $3F99, $9999, $9999
    dc.w $3F78, $5398, $1634, $A5D4, $85E0, $384C, $E0DE, $0000


; Atari XL OS code $E000-$FFFF

_ROME000::
_fnt_norm::
; since the international font and the normal font differ only
; in the control chars, the other 96 chars are the same.
; The 96 chars are replaced here with the bold font.

; $E000
    dc.w $0000, $0000, $0000, $0000, $003E, $3E3E, $1C00, $1C00
    dc.w $0036, $3636, $0000, $0000, $0036, $7F36, $7F36, $0000
    dc.w $183E, $603C, $067C, $1800, $0066, $6C18, $3066, $4600
    dc.w $1C36, $1C38, $6F66, $3B00, $0C0C, $1830, $0000, $0000
    dc.w $000E, $1C18, $181C, $0E00, $0070, $3818, $1838, $7000
    dc.w $0066, $3CFF, $3C66, $0000, $0018, $187E, $1818, $0000
    dc.w $0000, $0000, $001C, $1C38, $0000, $007E, $0000, $0000
    dc.w $0000, $0000, $0038, $3800, $0007, $0E1C, $3870, $6000
    dc.w $003E, $676F, $7B73, $3E00, $001C, $3C1C, $1C1C, $7F00
    dc.w $003E, $670E, $1C38, $7F00, $007F, $0E1C, $0E67, $3E00
    dc.w $000E, $1E3E, $6E7F, $0E00, $007F, $707E, $0777, $3E00
    dc.w $003E, $707E, $7777, $3E00, $007F, $070E, $1C38, $3800
    dc.w $003E, $773E, $7777, $3E00, $003E, $773F, $070E, $3C00
    dc.w $0000, $1C1C, $001C, $1C00, $0000, $1C1C, $001C, $1C38
    dc.w $0E1C, $3870, $381C, $0E00, $0000, $7E00, $7E00, $0000
    dc.w $7038, $1C0E, $1C38, $7000, $003E, $770E, $1C00, $1C00
; $E100
    dc.w $003C, $666E, $6E60, $3E00, $001C, $3E77, $777F, $7700
    dc.w $007E, $777E, $7777, $7E00, $003E, $7770, $7077, $3E00
    dc.w $007C, $7677, $777E, $7C00, $007F, $787E, $7878, $7F00
    dc.w $007F, $787E, $7878, $7800, $003E, $7770, $7777, $3B00
    dc.w $0077, $777F, $7777, $7700, $007F, $1C1C, $1C1C, $7F00
    dc.w $0007, $0707, $0777, $3E00, $0077, $767C, $7C76, $7700
    dc.w $0078, $7878, $7878, $7F00, $0063, $777F, $7F77, $7700
    dc.w $007B, $7B7F, $7F77, $7700, $003E, $7777, $777F, $3E00
    dc.w $007E, $7777, $7E70, $7000, $003E, $7777, $7F7E, $3B00
    dc.w $007E, $7777, $7E77, $7700, $003E, $7738, $0E77, $3E00
    dc.w $007F, $1C1C, $1C1C, $1C00, $0077, $7777, $777F, $3B00
    dc.w $0077, $7777, $773E, $1C00, $0077, $777F, $7F77, $6300
    dc.w $0077, $773E, $3E77, $7700, $0077, $773E, $1C1C, $1C00
    dc.w $007F, $0E1C, $3870, $7F00, $003E, $3838, $3838, $3E00
    dc.w $0070, $381C, $0E07, $0300, $007C, $1C1C, $1C1C, $7C00
    dc.w $1038, $6CC6, $0000, $0000, $0000, $0000, $0000, $FF00
_ROME200::
; $E200
    dc.w $0036, $7F7F, $3E1C, $0800, $1818, $181F, $1F18, $1818
    dc.w $0303, $0303, $0303, $0303, $1818, $18F8, $F800, $0000
    dc.w $1818, $18F8, $F818, $1818, $0000, $00F8, $F818, $1818
    dc.w $0307, $0E1C, $3870, $E0C0, $C0E0, $7038, $1C0E, $0703
    dc.w $0103, $070F, $1F3F, $7FFF, $0000, $0000, $0F0F, $0F0F
    dc.w $80C0, $E0F0, $F8FC, $FEFF, $0F0F, $0F0F, $0000, $0000
    dc.w $F0F0, $F0F0, $0000, $0000, $FFFF, $0000, $0000, $0000
    dc.w $0000, $0000, $0000, $FFFF, $0000, $0000, $F0F0, $F0F0
    dc.w $001C, $1C77, $7708, $1C00, $0000, $001F, $1F18, $1818
    dc.w $0000, $00FF, $FF00, $0000, $1818, $18FF, $FF18, $1818
    dc.w $0000, $3C7E, $7E7E, $3C00, $0000, $0000, $FFFF, $FFFF
    dc.w $C0C0, $C0C0, $C0C0, $C0C0, $0000, $00FF, $FF18, $1818
    dc.w $1818, $18FF, $FF00, $0000, $F0F0, $F0F0, $F0F0, $F0F0
    dc.w $1818, $181F, $1F00, $0000, $7860, $7860, $7E18, $1E00
    dc.w $0018, $3C7E, $1818, $1800, $0018, $1818, $7E3C, $1800
    dc.w $0018, $307E, $3018, $0000, $0018, $0C7E, $0C18, $0000
; $E300
_ROME300::
    dc.w $3030, $180C, $0000, $0000, $0000, $3E07, $3F77, $3B00
    dc.w $0070, $707E, $7777, $6E00, $0000, $3E77, $7077, $3E00
    dc.w $0007, $073F, $7777, $3B00, $0000, $3E77, $7F70, $3E00
    dc.w $000F, $1C3F, $1C1C, $1C00, $0000, $3B77, $773F, $077E
    dc.w $0070, $707E, $7777, $7700, $001C, $003C, $1C1C, $3E00
    dc.w $0007, $000F, $0707, $073E, $0070, $7376, $7C76, $7300
    dc.w $003C, $1C1C, $1C1C, $3E00, $0000, $667F, $7F6B, $6300
    dc.w $0000, $6E77, $7777, $7700, $0000, $3E77, $7777, $3E00
    dc.w $0000, $6E77, $777E, $7070, $0000, $3B77, $773F, $0707
    dc.w $0000, $6E77, $7070, $7000, $0000, $3F70, $3E07, $7E00
    dc.w $001C, $7F1C, $1C1C, $0F00, $0000, $7777, $7777, $3B00
    dc.w $0000, $7777, $773E, $1C00, $0000, $636B, $7F3E, $3600
    dc.w $0000, $773E, $1C3E, $7700, $0000, $7777, $773F, $0E7C
    dc.w $0000, $7F0E, $1C38, $7F00, $0C18, $1830, $1818, $0C00
    dc.w $1818, $1818, $1818, $1818, $3018, $180C, $1818, $3000
    dc.w $0000, $3B6E, $0000, $0000, $2A55, $2A55, $2A55, $2A00

_ROME400::
; $E400
    dc.w $93EF, $2DF2, $49F2, $AFF2, $1DF2, $2CF2, $4C6E, $EF00
    dc.w $8DEF, $2DF2, $7FF1, $A3F1, $1DF2, $AEF9, $4C6E, $EF00
    dc.w $1DF2, $1DF2, $FCF2, $2CF2, $1DF2, $2CF2, $4C6E, $EF00
    dc.w $C1FE, $06FF, $C0FE, $CAFE, $A2FE, $C0FE, $4C99, $FE00
    dc.w $E5FC, $CEFD, $79FD, $B3FD, $CBFD, $E4FC, $4CDB, $FC00

; patch $E459 with $DF $DF $60 for SIO emulation
;    dc.w $4CA3, $C64C, $B3C6, $4CDF, $E44C, $33C9, $4C72, $C24C
     dc.w $4CA3, $C64C, $B3C6, $4CDF, $E4DF, $DF60, $4C72, $C24C

    dc.w $E2C0, $4C8A, $C24C, $5CE9, $4C17, $EC4C, $0CC0, $4CC1
    dc.w $E44C, $23F2, $4C90, $C24C, $C8C2, $4C8D, $FD4C, $F7FC

; change the JMP $5000 to $CBE0 (the memo pad)
;    dc.w $4C23, $F24C, $0050, $4CBC, $EE4C, $15E9, $4C98, $E890
     dc.w $4C23, $F24C, $E0CB, $4CBC, $EE4C, $15E9, $4C98, $E890

    dc.w $C995, $C99A, $C99F, $C9A4, $C9A9, $C94C, $0CC9, $0000
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $0000, $0000, $0000, $0000, $0000, $0000, $0000, $0000
    dc.w $60A2, $00A9, $FF9D, $4003, $A9DB, $9D46, $03A9, $E49D
    dc.w $4703, $8A18, $6910, $AAC9, $8090, $E860, $A085, $6085
    dc.w $2F86, $2E8A, $290F, $D004, $E080, $9005, $A086, $4C70
    dc.w $E6A0, $00BD, $4003, $9920, $00E8, $C8C0, $0C90, $F4A5
; $E500
    dc.w $20C9, $7FD0, $15A5, $22C9, $0CF0, $71AD, $E902, $D005
    dc.w $A082, $4C70, $E620, $29CA, $30F8, $A084, $A522, $C903
    dc.w $9025, $A8C0, $0E90, $02A0, $0E84, $17B9, $2AE7, $F00F
    dc.w $C902, $F048, $C908, $B05F, $C904, $F076, $4C1E, $E6A5
    dc.w $20C9, $FFF0, $05A0, $814C, $70E6, $ADE9, $02D0, $2720
    dc.w $FFE6, $B022, $A900, $8DEA, $028D, $EB02, $2095, $E6B0
    dc.w $E620, $EAE6, $A90B, $8517, $2095, $E6A5, $2C85, $26A5
    dc.w $2D85, $274C, $72E6, $20F9, $EE4C, $70E6, $A001, $8423
    dc.w $2095, $E6B0, $0320, $EAE6, $A9FF, $8520, $A9E4, $8527
    dc.w $A9DB, $8526, $4C72, $E6A5, $20C9, $FFD0, $0520, $FFE6
    dc.w $B0A5, $2095, $E620, $EAE6, $A62E, $BD40, $0385, $204C
    dc.w $72E6, $A522, $252A, $D005, $A083, $4C70, $E620, $95E6
    dc.w $B0F8, $A528, $0529, $D008, $20EA, $E685, $2F4C, $72E6
    dc.w $20EA, $E685, $2F30, $41A0, $0091, $2420, $D1E6, $A522
    dc.w $2902, $D00C, $A52F, $C99B, $D006, $20BB, $E64C, $18E6
    dc.w $20BB, $E6D0, $DBA5, $2229, $02D0, $1D20, $EAE6, $852F
; $E600
    dc.w $300A, $A52F, $C99B, $D0F3, $A989, $8523, $20C8, $E6A0
    dc.w $00A9, $9B91, $2420, $D1E6, $20D8, $E64C, $72E6, $A522
    dc.w $252A, $D005, $A087, $4C70, $E620, $95E6, $B0F8, $A528
    dc.w $0529, $D006, $A52F, $E628, $D006, $A000, $B124, $852F
    dc.w $20EA, $E608, $20D1, $E620, $BBE6, $2830, $1DA5, $2229
    dc.w $02D0, $06A5, $2FC9, $9BF0, $11A5, $2805, $29D0, $DBA5
    dc.w $2229, $02D0, $05A9, $9B20, $EAE6, $20D8, $E64C, $72E6
    dc.w $8423, $A42E, $B944, $0385, $24B9, $4503, $8525, $A200
    dc.w $8EE9, $02B5, $2099, $4003, $E8C8, $E00C, $90F5, $A52F
    dc.w $A62E, $A423, $60A4, $20C0, $2290, $04A0, $85B0, $1BB9
    dc.w $1B03, $852C, $B91C, $0385, $2DA4, $17B9, $2AE7, $A8B1
    dc.w $2CAA, $C8B1, $2C85, $2D86, $2C18, $60A5, $28D0, $02C6
    dc.w $29C6, $28A5, $2805, $2960, $A524, $D002, $C625, $C624
    dc.w $60E6, $24D0, $02E6, $2560, $A62E, $38BD, $4803, $E528
    dc.w $8528, $BD49, $03E5, $2985, $2960, $A092, $20F4, $E684
    dc.w $23C0, $0060, $AAA5, $2D48, $A52C, $488A, $A62E, $6038
; $E700
    dc.w $A001, $B124, $E931, $3004, $C909, $9002, $A900, $8521
    dc.w $E621, $A000, $B124, $F00C, $A021, $D91A, $03F0, $0988
    dc.w $8888, $10F6, $A082, $3860, $9885, $2018, $6000, $0404
    dc.w $0404, $0606, $0606, $0208, $0AA5, $08F0, $25A9, $E985
    dc.w $4AA9, $0385, $4BA0, $1218, $B14A, $AAC8, $714A, $F026
    dc.w $B14A, $854B, $864A, $2056, $CBD0, $1B20, $94E8, $B016
    dc.w $90E3, $A900, $8DFB, $038D, $FC03, $A94F, $D02D, $A900
    dc.w $A820, $BEE7, $1001, $6018, $ADE7, $026D, $EA02, $8D12
    dc.w $03AD, $E802, $6DEB, $028D, $1303, $38AD, $E502, $ED12
    dc.w $03AD, $E602, $ED13, $03B0, $09A9, $4EA8, $20BE, $E74C
    dc.w $6EE7, $ADEC, $02AE, $E702, $8EEC, $02AE, $E802, $8EED
    dc.w $0220, $DEE7, $30E3, $3820, $9EE8, $B0DD, $90B0, $48A2
    dc.w $09BD, $D4E7, $9D00, $03CA, $10F7, $8C0B, $0368, $8D0A
    dc.w $034C, $59E4, $4F01, $4040, $EA02, $1E00, $0400, $8D13
    dc.w $03A2, $008E, $1203, $CA8E, $1503, $ADEC, $026A, $9008
    dc.w $EEEC, $02D0, $03EE, $ED02, $ADEC, $028D, $D102, $ADED
_ROME800::
; $E800
    dc.w $028D, $D202, $A916, $8DCF, $02A9, $E88D, $D002, $A980
    dc.w $8DD3, $024C, $45C7, $AE15, $03E8, $8E15, $03F0, $08AE
    dc.w $1503, $BD7D, $0318, $60A9, $808D, $1503, $2033, $E810
    dc.w $EE38, $60A2, $0BBD, $51E8, $9D00, $03CA, $10F7, $AE12
    dc.w $038E, $0A03, $E88E, $1203, $AD13, $038D, $0003, $4C59
    dc.w $E400, $0126, $40FD, $031E, $0080, $0000, $008C, $1203
    dc.w $8D13, $03A9, $E985, $4AA9, $0385, $4BA0, $12B1, $4AAA
    dc.w $C8B1, $4ACD, $1303, $D007, $EC12, $03D0, $0218, $60C9
    dc.w $00D0, $06E0, $00D0, $0238, $6086, $4A85, $4B20, $56CB
    dc.w $D0F5, $F0D7, $3808, $B028, $8DED, $028C, $EC02, $08A9
    dc.w $00A8, $205D, $E8B0, $27A0, $12AD, $EC02, $914A, $AAC8
    dc.w $ADED, $0291, $4A86, $4A85, $4BA9, $0091, $4A88, $914A
    dc.w $2000, $E990, $0CAD, $ED02, $ACEC, $0220, $15E9, $2838
    dc.w $6028, $B009, $A900, $A010, $914A, $C891, $4A18, $A010
    dc.w $ADE7, $0271, $4A8D, $E702, $C8AD, $E802, $714A, $8DE8
    dc.w $02A0, $0FA9, $0091, $4A20, $56CB, $A00F, $914A, $1860
; $E900
    dc.w $18A5, $4A69, $0C8D, $1203, $A54B, $6900, $8D13, $036C
    dc.w $1203, $4C72, $C220, $5DE8, $B03B, $A8A5, $4A48, $A54B
    dc.w $4886, $4A84, $4BAD, $4402, $D00F, $A010, $18B1, $4AC8
    dc.w $714A, $D01F, $2056, $CBD0, $1AA0, $12B1, $4AAA, $C8B1
    dc.w $4AA8, $6885, $4B68, $854A, $98A0, $1391, $4A88, $8A91
    dc.w $4A18, $6068, $6838, $6000, $004C, $33C9, $A93C, $8D02
    dc.w $D3A9, $3C8D, $03D3, $A903, $8D32, $0285, $418D, $0FD2
    dc.w $60BA, $8E18, $03A9, $0185, $42AD, $0003, $C960, $D003
    dc.w $4C9D, $EBA9, $008D, $0F03, $A901, $8DBD, $02A9, $0D8D
    dc.w $9C02, $A928, $8D04, $D2A9, $008D, $06D2, $18AD, $0003
    dc.w $6D01, $0369, $FF8D, $3A02, $AD02, $038D, $3B02, $AD0A
    dc.w $038D, $3C02, $AD0B, $038D, $3D02, $18A9, $3A85, $3269
    dc.w $0485, $34A9, $0285, $3385, $35A9, $348D, $03D3, $20AF
    dc.w $ECAD, $3F02, $D003, $98D0, $08CE, $9C02, $10B4, $4C22
    dc.w $EAAD, $0303, $100D, $A90D, $8D9C, $0220, $87EB, $20AF
    dc.w $ECF0, $2F20, $9AEC, $A900, $8D3F, $0220, $C0EC, $F012
; $EA00
    dc.w $2C03, $0370, $07AD, $3F02, $D018, $F01E, $2087, $EB20
    dc.w $FDEA, $AD3F, $02F0, $05AD, $1903, $8530, $A530, $C901
    dc.w $F008, $CEBD, $0230, $034C, $8DE9, $2084, $ECA9, $0085
    dc.w $42A4, $308C, $0303, $60A9, $008D, $3F02, $18A9, $3E85
    dc.w $3269, $0185, $34A9, $0285, $3385, $35A9, $FF85, $3C20
    dc.w $FDEA, $A0FF, $A530, $C901, $D019, $AD3E, $02C9, $41F0
    dc.w $21C9, $43F0, $1DC9, $45D0, $06A9, $9085, $30D0, $04A9
    dc.w $8B85, $30A5, $30C9, $8AF0, $07A9, $FF8D, $3F02, $D002
    dc.w $A000, $A530, $8D19, $0360, $A901, $8530, $2017, $ECA0
    dc.w $0084, $3184, $3B84, $3AB1, $328D, $0DD2, $8531, $A511
    dc.w $D003, $4CC7, $EDA5, $3AF0, $F520, $84EC, $6098, $48E6
    dc.w $32D0, $02E6, $33A5, $32C5, $34A5, $33E5, $3590, $1CA5
    dc.w $3BD0, $0BA5, $318D, $0DD2, $A9FF, $853B, $D009, $A510
    dc.w $0908, $8510, $8D0E, $D268, $A868, $40A0, $00B1, $328D
    dc.w $0DD2, $1865, $3169, $0085, $314C, $D7EA, $A53B, $F00B
    dc.w $853A, $A510, $29F7, $8510, $8D0E, $D268, $40A9, $00AC
; $EB00
    dc.w $0F03, $D002, $8531, $8538, $8539, $A901, $8530, $2040
    dc.w $ECA9, $3C8D, $03D3, $A511, $D003, $4CC7, $EDAD, $1703
    dc.w $F005, $A539, $F0F0, $60A9, $8A85, $3060, $9848, $AD0F
    dc.w $D28D, $0AD2, $3004, $A08C, $8430, $2920, $D004, $A08E
    dc.w $8430, $A538, $F013, $AD0D, $D2C5, $31F0, $04A0, $8F84
    dc.w $30A9, $FF85, $3968, $A868, $40AD, $0DD2, $A000, $9132
    dc.w $1865, $3169, $0085, $31E6, $32D0, $02E6, $33A5, $32C5
    dc.w $34A5, $33E5, $3590, $DEA5, $3CF0, $06A9, $0085, $3CF0
    dc.w $D0A9, $FF85, $38D0, $CE18, $AD04, $0385, $326D, $0803
    dc.w $8534, $AD05, $0385, $336D, $0903, $8535, $60AD, $0303
    dc.w $1032, $A9CC, $8D04, $D2A9, $058D, $06D2, $2017, $ECA6
    dc.w $62BC, $15EE, $AD0B, $0330, $03BC, $11EE, $A200, $20E2
    dc.w $EDA9, $348D, $02D3, $AD17, $03D0, $FB20, $87EB, $2088
    dc.w $EA4C, $04EC, $A9FF, $8D0F, $03A6, $62BC, $17EE, $AD0B
    dc.w $0330, $03BC, $13EE, $A200, $20E2, $EDA9, $348D, $02D3
    dc.w $AD17, $03D0, $FB20, $87EB, $209A, $EC20, $E2ED, $203D
; $EC00
    dc.w $ED20, $FDEA, $AD0B, $0330, $05A9, $3C8D, $02D3, $4C2A
    dc.w $EAA9, $008D, $1703, $60A9, $072D, $3202, $0920, $AC00
    dc.w $03C0, $60D0, $0C09, $08A0, $078C, $02D2, $A005, $8C00
    dc.w $D28D, $3202, $8D0F, $D2A9, $C725, $1009, $104C, $56EC
    dc.w $A907, $2D32, $0209, $108D, $3202, $8D0F, $D28D, $0AD2
    dc.w $A9C7, $2510, $0920, $8510, $8D0E, $D2A9, $288D, $08D2
    dc.w $A206, $A9A8, $A441, $D002, $A9A0, $9D01, $D2CA, $CA10
    dc.w $F9A9, $A08D, $05D2, $AC00, $03C0, $60F0, $068D, $01D2
    dc.w $8D03, $D260, $EAA9, $C725, $1085, $108D, $0ED2, $A206
    dc.w $A900, $9D01, $D2CA, $CA10, $F960, $AD06, $036A, $6AA8
    dc.w $293F, $AA98, $6A29, $C0A8, $602C, $EBAD, $EAEC, $EAA2
    dc.w $01A0, $FF88, $D0FD, $CAD0, $F820, $88EA, $A002, $A200
    dc.w $20E2, $ED20, $37EA, $9860, $8D10, $038C, $1103, $202E
    dc.w $ED8D, $1003, $AD0C, $0320, $2EED, $8D0C, $03AD, $1003
    dc.w $38ED, $0C03, $8D12, $03AD, $1103, $38ED, $0D03, $A8A6
    dc.w $62A9, $0038, $FD19, $EE18, $7D19, $EE88, $10F9, $186D
; $ED00
    dc.w $1203, $A84A, $4A4A, $0A38, $E916, $AA98, $2907, $A8A9
    dc.w $F518, $690B, $8810, $FAA0, $0038, $E907, $1001, $8818
    dc.w $7DF9, $ED8D, $EE02, $987D, $FAED, $8DEF, $0260, $C97C
    dc.w $3004, $38E9, $7C60, $18A6, $627D, $1BEE, $60A5, $11D0
    dc.w $034C, $C7ED, $78AD, $1703, $D002, $F025, $AD0F, $D229
    dc.w $10D0, $EA8D, $1603, $AE0B, $D4A4, $148E, $0C03, $8C0D
    dc.w $03A2, $018E, $1503, $A00A, $A511, $F05B, $AD17, $03D0
    dc.w $0458, $4C27, $EBAD, $0FD2, $2910, $CD16, $03F0, $E98D
    dc.w $1603, $88D0, $E3CE, $1503, $300C, $AD0B, $D4A4, $1420
    dc.w $C8EC, $A009, $D0D2, $ADEE, $028D, $04D2, $ADEF, $028D
    dc.w $06D2, $A900, $8D0F, $D2AD, $3202, $8D0F, $D2A9, $5591
    dc.w $32C8, $9132, $A9AA, $8531, $18A5, $3269, $0285, $32A5
    dc.w $3369, $0085, $3358, $6020, $84EC, $A93C, $8D02, $D3A9
    dc.w $3C8D, $03D3, $A980, $8530, $AE18, $039A, $C611, $584C
    dc.w $2AEA, $A911, $8D26, $02A9, $EC8D, $2702, $A901, $7820
    dc.w $5CE4, $A901, $8D17, $0358, $60E8, $0343, $049E, $04F9
; $EE00
    dc.w $0454, $05AF, $050A, $0665, $06C0, $061A, $0775, $07D0
    dc.w $07B4, $9678, $640F, $0D0A, $0883, $9C07, $2018, $100A
    dc.w $0A10, $1C34, $64C4, $C4C4, $C41C, $1064, $C417, $170B
    dc.w $172F, $2F5F, $5F61, $6161, $6117, $0BBF, $6113, $1309
    dc.w $1327, $274F, $4F41, $4141, $4113, $099F, $4102, $0607
    dc.w $0809, $0A0B, $0D0F, $0F0F, $0F04, $050C, $0E00, $0000
    dc.w $0000, $0000, $0101, $0101, $0100, $0001, $0103, $0202
    dc.w $0101, $0202, $0303, $0303, $0303, $0302, $0328, $1414
    dc.w $2850, $50A0, $A040, $5050, $5028, $28A0, $A018, $180C
    dc.w $1830, $3060, $60C0, $C0C0, $C018, $0CC0, $C000, $0000
    dc.w $0203, $0203, $0203, $0101, $0100, $0003, $02FF, $F00F
    dc.w $C030, $0C03, $8040, $2010, $0804, $0201, $4898, $488A
    dc.w $A200, $DD1A, $03F0, $1EE8, $E8E8, $E022, $30F4, $A200
    dc.w $A8A9, $00DD, $1A03, $F013, $E8E8, $E8E0, $2230, $F468
    dc.w $68A0, $FF38, $6068, $A868, $E838, $6098, $9D1A, $0368

    ; remove 5 bytes at $EEFF to call relocating handler
;   dc.w $9D1B, $0368, $9D1C, $0318, $60A0, $00B1, $24A4, $2120
    dc.w $9D1B, $0368, $9D1C, $0318, $60A0, $00B1, $24A4, $21EA

; $EF00
;   dc.w $BEE7, $1003, $A082, $60A9, $7F85, $20A9, $2585, $26A9
    dc.w $EAEA, $EAEA, $A082, $60A9, $7F85, $20A9, $2585, $26A9

    dc.w $EF85, $27AD, $EC02, $AE2E, $009D, $4D03, $A000, $B124
    dc.w $9D4C, $03A0, $0160, $488A, $4829, $0FD0, $10E0, $8010
    dc.w $0CAD, $E902, $D00B, $A082, $6868, $C000, $60A0, $8630
    dc.w $F78E, $2E00, $A000, $BD40, $0399, $2000, $E8C8, $C00C
    dc.w $30F4, $2029, $CA30, $E168, $AA68, $A8A5, $2748, $A526
    dc.w $4898, $A092, $6000, $0000, $0000, $004C, $05FD, $A9FF
    dc.w $8DFC, $02AD, $E402, $856A, $A940, $8DBE, $02A9, $5185
    dc.w $79A9, $FB85, $7AA9, $1185, $60A9, $FC85, $6160, $A52B
    dc.w $290F, $D008, $A52A, $290F, $852A, $A900, $8557, $C910
    dc.w $9005, $A991, $4C54, $F1A9, $E08D, $F402, $A9CC, $8D6B
    dc.w $02A9, $028D, $F302, $8D2F, $02A9, $0185, $4CA9, $C005
    dc.w $1085, $108D, $0ED2, $A940, $8D0E, $D42C, $6E02, $100C
    dc.w $A9C4, $8D00, $02A9, $FC8D, $0102, $A9C0, $8D0E, $D4A9
    dc.w $008D, $9302, $8564, $857B, $8DF0, $02A0, $0EA9, $0199
    dc.w $A302, $8810, $FAA2, $04BD, $08FB, $9DC4, $02CA, $10F7
; $F000
    dc.w $A46A, $888C, $9502, $A960, $8D94, $02A6, $57BD, $4DEE
    dc.w $8551, $A56A, $8565, $BC1D, $EEA9, $2820, $7AF5, $88D0
    dc.w $F8AD, $6F02, $293F, $8567, $A8E0, $0890, $1FE0, $0FF0
    dc.w $0DE0, $0CB0, $178A, $6A6A, $6A29, $C005, $67A8, $A910
    dc.w $207A, $F5E0, $0BD0, $05A9, $068D, $C802, $8C6F, $02A5

; replace LDA VCOUNT BNE sequence with LDA VCOUNT NOP NOP
;    dc.w $6485, $58A5, $6585, $59AD, $0BD4, $C97A, $D0F9, $2078
     dc.w $6485, $58A5, $6585, $59AD, $0BD4, $C97A, $EAEA, $2078

    dc.w $F5BD, $5DEE, $F006, $A9FF, $8564, $C665, $2065, $F5A5
    dc.w $6485, $68A5, $6585, $69A9, $4120, $70F5, $8666, $A918
    dc.w $8DBF, $02A5, $57C9, $0CB0, $04C9, $09B0, $39A5, $2A29
    dc.w $10F0, $33A9, $048D, $BF02, $A202, $AD6E, $02F0, $0320
    dc.w $A0F5, $A902, $2069, $F5CA, $10F8, $A46A, $8898, $2070
    dc.w $F5A9, $6020, $70F5, $A942, $2069, $F518, $A910, $6566
    dc.w $A8BE, $2DEE, $D015, $A466, $BE2D, $EEA5, $57D0, $0CAD
    dc.w $6E02, $F007, $20A0, $F5A9, $2285, $51A5, $5120, $70F5
    dc.w $CAD0, $F8A5, $57C9, $0890, $26C9, $0FF0, $04C9, $0CB0
    dc.w $1EA2, $5DA5, $6A38, $E910, $2070, $F5A9, $0020, $70F5
; $F100
    dc.w $A551, $0940, $2070, $F5A5, $5120, $70F5, $CAD0, $F8A5
    dc.w $5920, $70F5, $A558, $2070, $F5A5, $5109, $4020, $70F5
    dc.w $A970, $2070, $F5A9, $7020, $70F5, $A564, $8D30, $02A5
    dc.w $658D, $3102, $A970, $2070, $F5A5, $648D, $E502, $A565
    dc.w $8DE6, $02A0, $01AD, $3002, $9168, $C8AD, $3102, $9168
    dc.w $A54C, $1010, $8DEC, $0320, $94EF, $ADEC, $03A0, $008C
    dc.w $EC03, $A860, $A52A, $2920, $D00B, $2020, $F48D, $9002
    dc.w $A552, $8D91, $02A9, $220D, $2F02, $8D2F, $024C, $0BF2
    dc.w $20CA, $F620, $8FF1, $206A, $F720, $0AF6, $4C1E, $F220
    dc.w $ACF5, $B164, $2DA0, $0246, $6FB0, $034A, $10F9, $8DFA
    dc.w $02C9, $0060, $8DFB, $02C9, $7DD0, $0620, $20F4, $4C0B
    dc.w $F220, $CAF6, $ADFB, $02C9, $9BD0, $0620, $61F6, $4C0B
    dc.w $F220, $CAF1, $200E, $F64C, $0BF2, $ADFF, $02D0, $FBA2
    dc.w $02B5, $5495, $5ACA, $10F9, $ADFB, $02A8, $2A2A, $2A2A
    dc.w $2903, $AA98, $299F, $1D49, $FB8D, $FA02, $20AC, $F5AD
    dc.w $FA02, $466F, $B004, $0A4C, $F2F1, $2DA0, $0285, $50AD
; $F200
    dc.w $A002, $49FF, $3164, $0550, $9164, $6020, $8FF1, $855D
    dc.w $A657, $D00A, $AEF0, $02D0, $0549, $8020, $E9F1, $A44C
    dc.w $4C26, $F24C, $FCC8, $A901, $854C, $ADFB, $0260, $2C6E
    dc.w $0210, $EBA9, $408D, $0ED4, $A900, $8D6E, $02A9, $CE8D
    dc.w $0002, $A9C0, $8D01, $024C, $94EF, $2062, $F920, $BCF6
    dc.w $A56B, $D034, $A554, $856C, $A555, $856D, $20FD, $F284
    dc.w $4CAD, $FB02, $C99B, $F012, $20BE, $F220, $62F9, $A563
    dc.w $C971, $D003, $2056, $F54C, $5CF2, $2018, $F720, $B1F8
    dc.w $A56C, $8554, $A56D, $8555, $A56B, $F011, $C66B, $F00D
    dc.w $A54C, $30F8, $2080, $F18D, $FB02, $4C62, $F920, $61F6
    dc.w $A99B, $8DFB, $0220, $0BF2, $844C, $4C62, $F96C, $6400

; hook in John Harris's custom opcodes
;    dc.w $8DFB, $0220, $62F9, $20BC, $F6A9, $008D, $E803, $2018
     dc.w $8282, $EA20, $62F9, $20BC, $F6A9, $008D, $E803, $2018

    dc.w $F720, $3CF9, $F009, $0EA2, $0220, $B4F1, $4C62, $F9AD
    dc.w $FE02, $0DA2, $02D0, $EF0E, $A202, $E8AD, $E803, $F005
    dc.w $8A18, $692D, $AABD, $0DFB, $8564, $BD0E, $FB85, $6520
    dc.w $ADF2, $200B, $F24C, $62F9, $A9FF, $8DFC, $02A9, $008D
; $F300
    dc.w $E803, $A52A, $4AB0, $6FA9, $80A6, $11F0, $65AD, $FC02
    dc.w $C9FF, $F0E9, $857C, $A2FF, $8EFC, $02AE, $DB02, $D003
    dc.w $2083, $F9A8, $C0C0, $B0D0, $B179, $8DFB, $02AA, $3003
    dc.w $4CB4, $F3C9, $80F0, $C1C9, $81D0, $0AAD, $B602, $4980
    dc.w $8DB6, $02B0, $B3C9, $82D0, $0CAD, $BE02, $F00B, $A900
    dc.w $8DBE, $02F0, $A3C9, $83D0, $07A9, $408D, $BE02, $D098
    dc.w $C984, $D008, $A980, $8DBE, $024C, $F8F2, $C985, $D00B
    dc.w $A988, $854C, $8511, $A99B, $4CDA, $F3C9, $89D0, $10AD
    dc.w $DB02, $49FF, $8DDB, $02D0, $0320, $83F9, $4CF8, $F2C9
    dc.w $8EB0, $12C9, $8A90, $F5E9, $8A06, $7C10, $0209, $04A8
    dc.w $B160, $4C2A, $F3C9, $92B0, $0BC9, $8E90, $DFE9, $72EE
    dc.w $E803, $D026, $A57C, $C940, $B015, $ADFB, $02C9, $6190
    dc.w $0EC9, $7BB0, $0AAD, $BE02, $F005, $057C, $4C23, $F320
    dc.w $3CF9, $F009, $ADFB, $024D, $B602, $8DFB, $024C, $1EF2
    dc.w $A980, $8DA2, $0260, $C654, $1006, $AEBF, $02CA, $8654
    dc.w $4C0C, $F9E6, $54A5, $54CD, $BF02, $90F4, $A200, $F0EE
; $F400
    dc.w $C655, $A555, $3004, $C552, $B004, $A553, $8555, $4C8E
    dc.w $F8E6, $55A5, $55C5, $5390, $F5F0, $F3A5, $524C, $0CF4
    dc.w $20A6, $F9A4, $64A9, $0085, $6491, $64C8, $D0FB, $E665
    dc.w $A665, $E46A, $90F3, $A9FF, $99B2, $02C8, $C004, $90F8
    dc.w $2097, $F985, $6385, $6DA9, $0085, $5485, $5685, $6C60
    dc.w $A563, $C552, $F021, $A555, $C552, $D003, $2023, $F920
    dc.w $00F4, $A555, $C553, $D007, $A554, $F003, $20E6, $F3A9
    dc.w $208D, $FB02, $20CA, $F14C, $8EF8, $2011, $F4A5, $55C5
    dc.w $52D0, $0820, $65F6, $2058, $F7B0, $07A5, $6320, $5DF7
    dc.w $90E8, $4C8E, $F8A5, $634C, $3EF7, $A563, $4C4A, $F720
    dc.w $4CF9, $208F, $F185, $7DA9, $008D, $BB02, $20E9, $F1A5
    dc.w $6348, $2012, $F668, $C563, $B00C, $A57D, $4820, $8FF1
    dc.w $857D, $684C, $ACF4, $2057, $F9CE, $BB02, $3004, $C654
    dc.w $D0F7, $4C8E, $F820, $4CF9, $20AC, $F5A5, $6485, $68A5
    dc.w $6585, $69A5, $6348, $200A, $F668, $C563, $B010, $A554
    dc.w $CDBF, $02B0, $0920, $8FF1, $A000, $9168, $F0DA, $A000
; $F500
    dc.w $9891, $6820, $18F9, $2057, $F94C, $8EF8, $3820, $C2F7
    dc.w $A552, $8555, $20AC, $F520, $8EF7, $20E2, $F74C, $8EF8
    dc.w $208E, $F8A4, $5184, $54A4, $5498, $3820, $5BF7, $0898
    dc.w $1869, $7828, $203C, $F7C8, $C018, $D0ED, $ADB4, $0209
    dc.w $018D, $B402, $A900, $8555, $20AC, $F520, $2AF8, $2058
    dc.w $F790, $D44C, $1BF4, $A020, $2083, $F988, $10FA, $6020
    dc.w $40F4, $4CE6, $F3A9, $02D0, $11AC, $6E02, $F002, $0920
    dc.w $A44C, $302B, $A000, $9164, $A901, $8D9E, $02A5, $4C30
    dc.w $1EA5, $6438, $ED9E, $0285, $64B0, $02C6, $65A5, $0FC5
    dc.w $6590, $0CD0, $06A5, $0EC5, $6490, $04A9, $9385, $4C60
    dc.w $A902, $2070, $F5A9, $A220, $70F5, $CA60, $A201, $8666
    dc.w $CA86, $65A5, $540A, $2665, $0A26, $6565, $5485, $6490
    dc.w $02E6, $65A4, $57BE, $6DEE, $0664, $2665, $CAD0, $F9A5
    dc.w $564A, $A555, $BE9D, $EEF0, $066A, $0666, $CAD0, $FA65
    dc.w $6490, $02E6, $6518, $6558, $8564, $855E, $A565, $6559
    dc.w $8565, $855F, $BE9D, $EEBD, $04FB, $2555, $6566, $A8B9
; $F600
    dc.w $ACEE, $8DA0, $0285, $6FA0, $0060, $A900, $F002, $A99B
    dc.w $857D, $E663, $E655, $D002, $E656, $A555, $A657, $DD7D
    dc.w $EEF0, $0AE0, $00D0, $E2C5, $53F0, $DE90, $DCE0, $08D0
    dc.w $04A5, $56F0, $D4A5, $57D0, $2CA5, $63C9, $5190, $0AA5
    dc.w $7DF0, $2220, $61F6, $4CAB, $F620, $65F6, $A554, $1869
    dc.w $7820, $5DF7, $9008, $A57D, $F004, $1820, $0DF5, $4C8E
    dc.w $F8A9, $9B85, $7D20, $97F9, $A900, $8556, $E654, $A657
    dc.w $A018, $247B, $1005, $A004, $98D0, $03BD, $8DEE, $C554
    dc.w $D029, $8C9D, $028A, $D023, $A57D, $F01F, $C99B, $F001
    dc.w $1820, $F7F7, $EEBB, $02C6, $6C10, $02E6, $6CCE, $9D02
    dc.w $ADB2, $0238, $10EB, $AD9D, $0285, $544C, $8EF8, $38B5
    dc.w $70E5, $7495, $70B5, $71E5, $7595, $7160, $ADBF, $02C9
    dc.w $04F0, $07A5, $57F0, $0320, $94EF, $A927, $C553, $B002
    dc.w $8553, $A657, $BD8D, $EEC5, $5490, $2AF0, $28E0, $08D0
    dc.w $0AA5, $56F0, $13C9, $01D0, $1CF0, $04A5, $56D0, $16BD
    dc.w $7DEE, $C555, $900F, $F00D, $A901, $854C, $A980, $A611
; $F700
    dc.w $8511, $F006, $6020, $40F4, $A98D, $854C, $6868, $A57B
    dc.w $1003, $4C62, $F94C, $1EF2, $A000, $A55F, $F004, $A55D
    dc.w $915E, $6048, $2907, $AABD, $B4EE, $856E, $684A, $4A4A
    dc.w $AA60, $2EB4, $022E, $B302, $2EB2, $0260, $900C, $2023
    dc.w $F7BD, $A302, $056E, $9DA3, $0260, $2023, $F7A5, $6E49
    dc.w $FF3D, $A302, $9DA3, $0260, $A554, $1869, $7820, $23F7
    dc.w $18BD, $A302, $256E, $F001, $3860, $ADFA, $02A4, $57C0
    dc.w $0EB0, $17C0, $0CB0, $04C0, $03B0, $0F2A, $2A2A, $2A29
    dc.w $03AA, $ADFA, $0229, $9F1D, $4DFB, $8DFB, $0260, $A66A
    dc.w $CA86, $6986, $67A9, $B085, $68A9, $D885, $66A6, $54E8
    dc.w $ECBF, $02F0, $E8A0, $27B1, $6891, $6688, $10F9, $38A5
    dc.w $6885, $66E9, $2885, $68A5, $6985, $67E9, $0085, $694C
    dc.w $9FF7, $08A0, $1698, $205A, $F708, $9818, $6979, $2820
    dc.w $3CF7, $8830, $04C4, $54B0, $ECA5, $5418, $6978, $284C
    dc.w $3CF7, $A552, $8555, $20AC, $F538, $A553, $E552, $A8A9
    dc.w $0091, $6488, $10FB, $6020, $32F7, $AD6E, $02F0, $28AD
; $F800
    dc.w $6C02, $D0FB, $A908, $8D6C, $02AD, $6C02, $C901, $D0F9
    dc.w $AD0B, $D4C9, $40B0, $F9A2, $0DAD, $BF02, $C904, $D002
    dc.w $A270, $EC0B, $D4B0, $FB20, $A6F9, $A564, $A665, $E8E4
    dc.w $6AF0, $0638, $E910, $4C2E, $F869, $27D0, $0AA6, $65E8
    dc.w $E46A, $F038, $1869, $10A8, $857E, $38A5, $64E5, $7E85
    dc.w $64B0, $02C6, $65A5, $6418, $6928, $857E, $A565, $6900
    dc.w $857F, $B17E, $9164, $C8D0, $F9A0, $10A5, $64C9, $D8F0
    dc.w $0B18, $69F0, $8564, $90DD, $E665, $D0D9, $A66A, $CA86
    dc.w $7FA2, $D886, $7EA9, $00A0, $2791, $7E88, $10FB, $A900
    dc.w $8563, $A554, $8551, $A551, $205A, $F7B0, $0CA5, $6318
    dc.w $6928, $8563, $C651, $4C96, $F818, $A563, $6555, $8563
    dc.w $6020, $4CF9, $A563, $48A5, $6C85, $54A5, $6D85, $55A9
    dc.w $0185, $6BA2, $17A5, $7B10, $02A2, $03E4, $54D0, $0BA5
    dc.w $55C5, $53D0, $05E6, $6B4C, $EAF8, $200A, $F6E6, $6BA5
    dc.w $63C5, $52D0, $DEC6, $5420, $00F4, $208F, $F1D0, $17C6
    dc.w $6BA5, $63C5, $52F0, $0F20, $00F4, $A555, $C553, $D002
; $F900
    dc.w $C654, $A56B, $D0E4, $6885, $634C, $57F9, $208E, $F8A5
    dc.w $5185, $6CA5, $5285, $6D60, $A563, $C552, $D002, $C654
    dc.w $208E, $F8A5, $63C5, $52F0, $EE20, $ACF5, $A553, $38E5
    dc.w $52A8, $B164, $D0E1, $8810, $F94C, $27F5, $A22D, $BD0D
    dc.w $FBCD, $FB02, $F005, $CACA, $CA10, $F360, $A202, $B554
    dc.w $9DB8, $02CA, $10F8, $60A2, $02BD, $B802, $9554, $CA10
    dc.w $F860, $ADBF, $02C9, $18F0, $17A2, $0BB5, $5448, $BD90
    dc.w $0295, $5468, $9D90, $02CA, $10F1, $A57B, $49FF, $857B

    ; $F98F remove loop during keyclick
;   dc.w $4C1E, $F2A2, $7E48, $8E1F, $D0AD, $0BD4, $CD0B, $D4F0
;   dc.w $FBCA, $CA10, $F168, $60A9, $00A6, $7BD0, $04A6, $57D0
    dc.w $4C1E, $F2A2, $7E48, $8E1F, $D0AD, $0BD4, $CD0B, $D4EA
    dc.w $EACA, $CA10, $F168, $60A9, $00A6, $7BD0, $04A6, $57D0

    dc.w $02A5, $5285, $5560, $A558, $8564, $A559, $8565, $60A2
    dc.w $00A5, $22C9, $11F0, $08C9, $12F0, $03A0, $8460, $E88E
    dc.w $B702, $A554, $8DF5, $02A5, $558D, $F602, $A556, $8DF7
    dc.w $02A9, $018D, $F802, $8DF9, $0238, $ADF5, $02E5, $5A85
    dc.w $76B0, $0EA9, $FF8D, $F802, $A576, $49FF, $1869, $0185
    dc.w $7638, $ADF6, $02E5, $5B85, $77AD, $F702, $E55C, $8578
; $FA00
    dc.w $B017, $A9FF, $8DF9, $02A5, $7749, $FF85, $77A5, $7849
    dc.w $FF85, $78E6, $77D0, $02E6, $78A2, $02A0, $0084, $7398
    dc.w $9570, $B55A, $9554, $CA10, $F6A5, $77E8, $A8A5, $7885
    dc.w $7F85, $75D0, $0BA5, $77C5, $76B0, $05A5, $76A2, $02A8
    dc.w $9885, $7E85, $7448, $A575, $4A68, $6A95, $70A5, $7E05
    dc.w $7FD0, $034C, $01FB, $18A5, $7065, $7685, $7090, $02E6
    dc.w $71A5, $71C5, $7590, $15D0, $06A5, $70C5, $7490, $0D18
    dc.w $A554, $6DF8, $0285, $54A2, $0020, $AEF6, $18A5, $7265
    dc.w $7785, $72A5, $7365, $7885, $73C5, $7590, $28D0, $06A5
    dc.w $72C5, $7490, $202C, $F902, $1010, $C655, $A555, $C9FF
    dc.w $D00E, $A556, $F00A, $C656, $1006, $E655, $D002, $E656
    dc.w $A202, $20AE, $F620, $CAF6, $20CA, $F1AD, $B702, $F02F
    dc.w $204C, $F9AD, $FB02, $8DBC, $02A5, $5448, $2012, $F668
    dc.w $8554, $20CA, $F620, $8FF1, $D00C, $ADFD, $028D, $FB02
    dc.w $20CA, $F14C, $C9FA, $ADBC, $028D, $FB02, $2057, $F938
    dc.w $A57E, $E901, $857E, $A57F, $E900, $857F, $3003, $4C4D
; $FB00
    dc.w $FA4C, $1EF2, $0001, $0307, $28CA, $9446, $001B, $E0F3
    dc.w $1CE6, $F31D, $F3F3, $1E00, $F41F, $11F4, $7D20, $F47E
    dc.w $50F4, $7F7A, $F49B, $61F6, $9C20, $F59D, $0CF5, $9E9A
    dc.w $F49F, $95F4, $FD56, $F5FE, $D5F4, $FF9F, $F41C, $40F4
    dc.w $1D5F, $F51E, $1BF4, $1F0A, $F440, $0020, $6020, $4000
    dc.w $606C, $6A3B, $8A8B, $6B2B, $2A6F, $8070, $759B, $692D
    dc.w $3D76, $8063, $8C8D, $6278, $7A34, $8033, $361B, $3532
    dc.w $312C, $202E, $6E80, $6D2F, $8172, $8065, $797F, $7477
    dc.w $7139, $8030, $377E, $383C, $3E66, $6864, $8082, $6773
    dc.w $614C, $4A3A, $8A8B, $4B5C, $5E4F, $8050, $559B, $495F
    dc.w $7C56, $8043, $8C8D, $4258, $5A24, $8023, $261B, $2522
    dc.w $215B, $205D, $4E80, $4D3F, $8152, $8045, $599F, $5457
    dc.w $5128, $8029, $279C, $407D, $9D46, $4844, $8083, $4753
    dc.w $410C, $0A7B, $8080, $0B1E, $1F0F, $8010, $159B, $091C
    dc.w $1D16, $8003, $8980, $0218, $1A80, $8085, $801B, $80FD
    dc.w $8000, $2060, $0E80, $0D80, $8112, $8005, $199E, $1417
; $FC00
    dc.w $1180, $8080, $80FE, $807D, $FF06, $0804, $8084, $0713
    dc.w $011C, $1D1E, $1F8E, $8F90, $918A, $4898, $48AC, $01D3
    dc.w $AD09, $D2CD, $F202, $D005, $AEF1, $02D0, $49AE, $6D02
    dc.w $C983, $D013, $8A49, $FF8D, $6D02, $D005, $9809, $04D0
    dc.w $0398, $29FB, $A8B0, $268A, $D03D, $AD09, $D2AA, $C99F
    dc.w $D00A, $ADFF, $0249, $FF8D, $FF02, $B011, $293F, $C911
    dc.w $D02E, $8EDC, $02F0, $068E, $FC02, $8EF2, $02A9, $038D
    dc.w $F102, $A900, $854D, $ADD9, $028D, $2B02, $AD2F, $02D0

; remove STA $D301 at $FC87
;   dc.w $06AD, $DD02, $8D2F, $028C, $01D3, $68A8, $68AA, $6840
    dc.w $06AD, $DD02, $8D2F, $02EA, $EAEA, $68A8, $68AA, $6840

    dc.w $E084, $F021, $E094, $D0CF, $ADF4, $02AE, $6B02, $8D6B
    dc.w $028E, $F402, $E0CC, $F006, $9809, $08A8, $D0BF, $9829
    dc.w $F7A8, $4C6D, $FCAD, $2F02, $F0CD, $8DDD, $02A9, $008D
    dc.w $2F02, $F0C3, $48AD, $C602, $4D4F, $002D, $4E00, $8D0A
    dc.w $D48D, $17D0, $6840, $0000, $4C83, $F9A9, $CC8D, $EE02
    dc.w $A905, $8DEF, $0260, $A52B, $853E, $A52A, $290C, $C904
    dc.w $F005, $C908, $F03E, $60A9, $008D, $8902, $853F, $A901
; $FD00
    dc.w $20FC, $FD30, $29A9, $348D, $02D3, $A662, $BC93, $FEBD
    dc.w $91FE, $AAA9, $038D, $2A02, $205C, $E4AD, $2A02, $D0FB
    dc.w $A980, $853D, $8D8A, $024C, $77FD, $A080, $C611, $A900
    dc.w $8D89, $0260, $A980, $8D89, $02A9, $0220, $FCFD, $30EE
    dc.w $A9CC, $8D04, $D2A9, $058D, $06D2, $A960, $8D00, $0320
    dc.w $68E4, $A934, $8D02, $D3A6, $62BC, $8FFE, $BD8D, $FEAA
    dc.w $A903, $205C, $E4A9, $FF8D, $2A02, $A511, $F0BC, $AD2A
    dc.w $02D0, $F7A9, $0085, $3DA0, $0160, $A53F, $3033, $A63D
    dc.w $EC8A, $02F0, $08BD, $0004, $E63D, $A001, $60A9, $5220
    dc.w $3FFE, $9830, $F7A9, $0085, $3DA2, $80AD, $FF03, $C9FE
    dc.w $F00D, $C9FA, $D003, $AE7F, $048E, $8A02, $4C7A, $FDC6
    dc.w $3FA0, $8860, $A63D, $9D00, $04E6, $3DA0, $01E0, $7FF0
    dc.w $0160, $A9FC, $207C, $FEA9, $0085, $3D60, $A001, $60AD
    dc.w $8902, $3008, $A001, $A93C, $8D02, $D360, $A63D, $F00A
    dc.w $8E7F, $04A9, $FA20, $7CFE, $30EC, $A27F, $A900, $9D00
    dc.w $04CA, $10FA, $A9FE, $207C, $FE4C, $D6FD, $8540, $A514
; $FE00
    dc.w $18A6, $627D, $95FE, $AAA9, $FF8D, $1FD0, $A900, $A0F0
    dc.w $88D0, $FD8D, $1FD0, $A0F0, $88D0, $FDE4, $14D0, $E8C6
    dc.w $40F0, $0E8A, $18A6, $627D, $97FE, $AAE4, $14D0, $FCF0
    dc.w $CD20, $36FE, $9860, $AD25, $E448, $AD24, $E448, $608D
    dc.w $0203, $A900, $8D09, $03A9, $838D, $0803, $A903, $8D05
    dc.w $03A9, $FD8D, $0403, $A960, $8D00, $03A9, $008D, $0103
    dc.w $A923, $8D06, $03AD, $0203, $A040, $C952, $F002, $A080
    dc.w $8C03, $03A5, $3E8D, $0B03, $2059, $E460, $8DFF, $03A9
    dc.w $558D, $FD03, $8DFE, $03A9, $5720, $3FFE, $6004, $0380
    dc.w $C002, $0140, $E01E, $190A, $08A9, $1E8D, $1403, $60EA
    dc.w $02C0, $03A9, $048D, $DF02, $AE9F, $FEAC, $A0FE, $A953
    dc.w $8D02, $038D, $0A03, $2014, $FF20, $59E4, $3003, $2044
    dc.w $FF60, $20A3, $FEA9, $008D, $DE02, $6048, $BD41, $0385
    dc.w $2120, $4BFF, $AEDE, $0268, $9DC0, $03E8, $ECDF, $02F0
    dc.w $158E, $DE02, $C99B, $F003, $A001, $60A9, $209D, $C003
    dc.w $E8EC, $DF02, $D0F7, $A900, $8DDE, $02AE, $A1FE, $ACA2
; $FF00
    dc.w $FE20, $14FF, $4C59, $E420, $4BFF, $A99B, $AEDE, $02D0
    dc.w $DCA0, $0160, $8E04, $038C, $0503, $A940, $8D00, $03A5
    dc.w $218D, $0103, $A980, $AE02, $03E0, $53D0, $02A9, $408D
    dc.w $0303, $ADDF, $028D, $0803, $A900, $8D09, $03AD, $1403
    dc.w $8D06, $0360, $ADEC, $028D, $1403, $60A0, $57A5, $2BC9
    dc.w $4ED0, $04A2, $28D0, $0EC9, $44D0, $04A2, $14D0, $06C9
    dc.w $53D0, $0CA2, $1D8E, $DF02, $8C02, $038D, $0A03, $60A9
    dc.w $4ED0, $DCA2, $0086, $8B86, $8C20, $A9FF, $E00C, $D0F9
    dc.w $AD00, $C0AE, $01C0, $C58B, $D006, $E48C, $D002, $1860
    dc.w $3860, $A200, $868B, $868C, $A20C, $20A9, $FF20, $A9FF
    dc.w $ADF8, $FFAE, $F9FF, $4C86, $FFA0, $00BD, $D7FF, $999E
    dc.w $00E8, $C8C0, $04D0, $F4A0, $0018, $B19E, $658B, $858B
    dc.w $9002, $E68C, $E69E, $D002, $E69F, $A59E, $C5A0, $D0E9
    dc.w $A59F, $C5A1, $D0E3, $6002, $C000, $D000, $5000, $5800
    dc.w $D800, $E000, $E0F8, $FFFA, $FF00, $0000, $0000, $1005
    dc.w $8302, $4242, $0000, $0102, $8C6C, $18C0, $AAC2, $2CC0


; FastChip floating point routines $D800-$DFFF

_ROMFAST::

; $D800
    dc.w $20A1, $DB20, $B9DB, $B06B, $A2EC, $2046, $DA20, $44DA 
    dc.w $8884, $F185, $F020, $D8DB, $B01B, $A6D4, $D00D, $20E4 
    dc.w $DB05, $D985, $D9A6, $F130, $08E6, $F1A6, $F110, $02E6 
    dc.w $EDA9, $FFD0, $DEC9, $2ED0, $04A6, $F130, $ECC9, $45D0 
    dc.w $41A6, $F220, $D8DB, $901C, $C92B, $F006, $C92D, $D042 
    dc.w $85EF, $20D8, $DBB0, $3BA8, $A5EC, $0A0A, $65EC, $0A85 
    dc.w $EC98, $65EC, $85EC, $20D8, $DB90, $ECB0, $2B09, $3099 
    dc.w $8005, $C860, $C6F7, $D0FB, $A92E, $D0F3, $A9B0, $A000 
    dc.w $F0ED, $A6F0, $D012, $C92B, $F0A7, $C92D, $D00A, $85EE 
    dc.w $F09F, $86F2, $A900, $85EC, $A5ED, $1869, $88A6, $F130 
    dc.w $0338, $E5F1, $A6EF, $D006, $1865, $EC4C, $B1D8, $38E5 
    dc.w $EC4A, $9003, $20E4, $DBA4, $D4F0, $0B69, $01A2, $04B4 
    dc.w $D494, $D5CA, $10F9, $A6EE, $F002, $4980, $C6F2, $4CF9 
    dc.w $D98A, $E964, $AAA9, $31D0, $3920, $C0DC, $0980, $9980 
    dc.w $05D0, $4BFF, $FFFF, $2051, $DAA5, $D4F0, $8F0A, $38E9 
    dc.w $7EC9, $0C90, $E4E9, $0285, $EDA9, $0320, $C0DC, $C8A9 
; $D900
    dc.w $4520, $6FD8, $A92B, $A6ED, $1008, $A900, $38E5, $EDAA 
    dc.w $A92D, $206F, $D8E0, $64B0, $B88A, $C8A2, $FF38, $E90A 
    dc.w $E8B0, $FB69, $8A20, $6DD8, $8A09, $3099, $7E05, $A5D4 
    dc.w $1008, $C6F3, $A000, $A92D, $91F3, $6043, $5059, $5254 
    dc.w $2E31, $3938, $312C, $4D41, $5253, $4C45, $5454, $84D6 
    dc.w $F8A0, $1006, $D52A, $88B0, $0410, $F8D8, $6085, $F9A5 
    dc.w $D765, $D785, $D7A5, $D665, $D685, $D626, $D526, $F988 
    dc.w $10ED, $A942, $D06A, $84D4, $F01F, $0A0A, $0A0A, $AA06 
    dc.w $D826, $D726, $D626, $D590, $0CA5, $D47D, $8EDC, $85D4 
    dc.w $987D, $8FDC, $A8CA, $CAD0, $E6A5, $D5C9, $50A5, $D469 
    dc.w $0085, $D498, $6900, $85D5, $60FF, $A5D5, $A6D4, $86D5 
    dc.w $A000, $84D7, $84D8, $84D9, $F094, $B5D4, $F9E1, $0095 
    dc.w $D4CA, $8810, $F5CA, $301F, $B5D5, $E900, $95D5, $90F5 
    dc.w $B029, $A000, $A5D4, $C943, $B06A, $E93E, $B098, $9064 
    dc.w $D017, $FFFF, $FFFF, $FFB0, $1238, $A205, $A900, $F5D4 
    dc.w $95D4, $CAD0, $F7A5, $D449, $8085, $D4D8, $A005, $A5D5 
; $DA00
    dc.w $F037, $1860, $A2FB, $B5DB, $95DA, $E8D0, $F988, $D0EE 
    dc.w $F031, $49FF, $6904, $90E6, $A8F8, $A5D4, $45E0, $309A 
    dc.w $18B5, $D479, $E100, $95D4, $CA88, $10F5, $CA30, $6EB5 
    dc.w $D569, $0095, $D5B0, $F590, $6485, $DAA5, $D4C6, $D445 
    dc.w $D410, $C118, $A2D4, $A006, $A900, $9500, $E888, $D0FA 
    dc.w $60A9, $0585, $F4A9, $8085, $F360, $06F8, $26F7, $60FF 
    dc.w $A5E0, $4980, $85E0, $A205, $A5E0, $297F, $85F7, $A5D4 
    dc.w $297F, $38E5, $F710, $9B69, $05A8, $F8A5, $D445, $E030 
    dc.w $3418, $8830, $0BB9, $D500, $75E0, $95D4, $CA88, $10F5 
    dc.w $B5E0, $6900, $95D4, $CAD0, $F7A5, $E085, $D490, $14A2 
    dc.w $04B5, $D495, $D5CA, $D0F9, $A901, $85D5, $A5D4, $E6D4 
    dc.w $45D4, $2AD8, $6038, $8830, $0BB5, $E0F9, $D500, $95D4 
    dc.w $CA88, $10F5, $B5E0, $E900, $95D4, $CAD0, $F7A5, $E085 
    dc.w $D44C, $E7D9, $FFA2, $0586, $F9F8, $60A5, $E0F0, $3CA5 
    dc.w $D4F0, $36AA, $38E9, $3F18, $65E0, $2007, $DBB5, $D495 
    dc.w $DA95, $E6A9, $0095, $D4CA, $D0F3, $85DA, $85E6, $85FA 
; $DB00
    dc.w $A2DA, $20E6, $DBF0, $6385, $D48A, $45E0, $45D4, $10C5 
    dc.w $6868, $A5D4, $2A30, $0438, $6018, $604C, $43DA, $FFFF 
    dc.w $FFFF, $FFFF, $FF20, $9CDD, $A5E0, $F0EB, $A5D4, $F0E9 
    dc.w $AA38, $E5E0, $1869, $4020, $07DB, $B5E0, $95E6, $B5D4 
    dc.w $95D5, $CAD0, $F586, $E686, $D5A2, $E620, $E6DB, $38A2 
    dc.w $FA4C, $08DC, $A5D9, $85FA, $A5D8, $85D9, $A5D7, $85D8 
    dc.w $A5D6, $85D7, $A5D5, $85D6, $84D5, $A6F9, $B5E0, $F018 
    dc.w $4A4A, $4A4A, $F007, $A2DA, $2066, $DCA6, $F9B5, $E029 
    dc.w $0FF0, $05A2, $E620, $66DC, $C6F9, $D0C8, $A5FA, $85DA 
    dc.w $D8A5, $D5D0, $84A0, $064C, $3BDA, $FFFF, $FFFF, $FFFF 
    dc.w $FFA4, $F2A9, $20D0, $01C8, $D1F3, $F0FB, $84F2, $60A4 
    dc.w $F2B1, $F338, $E930, $C90A, $6020, $D8DB, $903E, $C92E 
    dc.w $F00E, $C92B, $F004, $C92D, $D00C, $B1F3, $C92E, $F02C 
    dc.w $B1F3, $C930, $B022, $3860, $20AF, $DB90, $02B1, $F3C8 
    dc.w $84F2, $60FF, $A2D4, $A004, $1605, $3604, $3603, $3602 
    dc.w $3601, $3600, $88D0, $F160, $C93A, $B0DA, $18C6, $F260 
; $DC00
    dc.w $4CFB, $D994, $E030, $01C8, $B5E0, $E5EB, $95E0, $B5DF 
    dc.w $E5EA, $95DF, $B5DE, $E5E9, $95DE, $B5DD, $E5E8, $95DD 
    dc.w $B5DC, $E5E7, $95DC, $B5DB, $E5E6, $95DB, $B0D9, $980A 
    dc.w $0A0A, $0A09, $0AA8, $B5E0, $65E5, $95E0, $B5DF, $65E4 
    dc.w $95DF, $B5DE, $65E3, $95DE, $B5DD, $65E2, $95DD, $B5DC 
    dc.w $65E1, $95DC, $B5DB, $6900, $95DB, $8890, $D994, $DBA8 
    dc.w $E830, $A04C, $90DB, $A818, $A5FA, $7505, $85FA, $A5D9 
    dc.w $7504, $85D9, $A5D8, $7503, $85D8, $A5D7, $7502, $85D7 
    dc.w $A5D6, $7501, $85D6, $A5D5, $7500, $85D5, $88D0, $D960 
    dc.w $0000, $0100, $0300, $0700, $0900, $1300, $2700, $4F00 
    dc.w $6300, $C700, $8F01, $1F03, $E703, $CF07, $9F0F, $3F1F 
    dc.w $0F27, $1F4E, $3F9C, $FFFF, $FFFF, $FFFF, $FFFF, $FFFF 
    dc.w $4A66, $F285, $F7A2, $FBA0, $00E6, $F720, $74D8, $B5DA 
    dc.w $4A4A, $4A4A, $206D, $D8B5, $DA29, $0F20, $6DD8, $E830 
    dc.w $EA20, $74D8, $A930, $CD80, $05F0, $0990, $0BC6, $F38D 
    dc.w $7F05, $B015, $E6F3, $B011, $A5F2, $100D, $AD81, $058D 
; $DD00
    dc.w $8205, $A92E, $8D81, $05E6, $EDA0, $0B88, $F00C, $B980 
    dc.w $05C9, $30F0, $F6C9, $2ED0, $0488, $B980, $0560, $FFFF 
    dc.w $FFFF, $A205, $BDE0, $0595, $E0CA, $10F8, $60A2, $05BD 
    dc.w $E005, $95D4, $CA10, $F860, $2078, $DD85, $F2D0, $1A60 
    dc.w $2078, $DD85, $F220, $62DD, $C6F2, $D008, $60C6, $F2F0 
    dc.w $1020, $22DD, $20DB, $DAB0, $0820, $62DD, $2066, $DA90 
    dc.w $EC60, $A005, $B1FE, $99E0, $0088, $10F8, $18A5, $FE69 
    dc.w $0685, $FE90, $02E6, $FF60, $84FF, $86FE, $A8A2, $05B5 
    dc.w $D49D, $E005, $CA10, $F898, $6084, $FD86, $FCA0, $05B1 
    dc.w $FC99, $D400, $8810, $F860, $84FD, $86FC, $A005, $B1FC 
    dc.w $99E0, $0088, $10F8, $6084, $FD86, $FCA0, $05B9, $D400 
    dc.w $91FC, $8810, $F860, $A205, $B5D4, $95E0, $CA10, $F960 
    dc.w $A0DF, $A2A2, $2098, $DD20, $DBDA, $B0F3, $20B6, $DD06 
    dc.w $D446, $D420, $D2D9, $A5E0, $1010, $38A9, $80E5, $D485 
    dc.w $F6A9, $00E5, $D5F0, $104C, $43DA, $18A5, $D469, $8085 
    dc.w $F6A9, $0065, $D5D0, $C885, $F520, $AAD9, $06D4, $A97F 
; $DE00
    dc.w $C5E0, $66D4, $2066, $DAA5, $D429, $7FC9, $3FD0, $1DA5 
    dc.w $D5C9, $2590, $1785, $F5A0, $DFA2, $6C20, $98DD, $A5D4 
    dc.w $06E0, $0A66, $E010, $02C6, $F620, $60DA, $A005, $A2E6 
    dc.w $20A7, $DD20, $B6DD, $20DB, $DAA0, $DEA2, $AFA9, $0220 
    dc.w $40DD, $209C, $DD20, $DBDA, $20AB, $DD20, $2DDD, $A902 
    dc.w $203B, $DD20, $9CDD, $2060, $DA20, $B6DD, $208D, $DD20 
    dc.w $28DB, $A0DF, $A26C, $2098, $DD20, $66DA, $20B6, $DD20 
    dc.w $66DA, $A5F5, $F006, $2062, $DD20, $DBDA, $46F6, $900A 
    dc.w $A0DF, $A2A8, $2098, $DD20, $DBDA, $18A5, $D465, $F6E9 
    dc.w $3F85, $D418, $6020, $98DD, $207C, $DD20, $66DA, $A005 
    dc.w $A2E6, $20A7, $DD20, $2DDD, $2060, $DA4C, $25DB, $FF40 
    dc.w $0870, $3883, $6640, $6901, $0931, $2640, $3404, $4020 
    dc.w $6740, $5994, $2133, $2740, $0316, $2277, $66A9, $80D0 
    dc.w $02A9, $0085, $F6A5, $D40A, $B0BA, $E97D, $85F5, $A5D5 
    dc.w $C910, $B005, $C6F5, $20E4, $DBA2, $3FA5, $D5C9, $31B0 
    dc.w $12C6, $F5E8, $A004, $46D5, $66D6, $66D7, $66D8, $66D9 
; $DF00
    dc.w $88D0, $F386, $D4A0, $DFA2, $EA20, $95DE, $20AB, $DD20 
    dc.w $B6DD, $20DB, $DAA0, $DFA2, $72A9, $0320, $38DD, $A2EC 
    dc.w $20A9, $DD20, $2DDD, $A903, $2043, $DD20, $9CDD, $2028 
    dc.w $DB20, $22DD, $20DB, $DA20, $62DD, $2066, $DAA2, $E620 
    dc.w $9ADD, $20DB, $DA20, $B6DD, $E886, $D5A5, $F510, $0438 
    dc.w $8AE5, $F585, $D420, $AAD9, $06D4, $06F5, $66D4, $2066 
    dc.w $DAA5, $F6F0, $0620, $62DD, $20DB, $DA60, $3F50, $0000 
    dc.w $0000, $C008, $1908, $0045, $4016, $9669, $8140, $C010 
    dc.w $0704, $0696, $BF67, $3581, $6015, $4003, $1630, $3492 
    dc.w $C002, $9156, $8144, $3F86, $8588, $9638, $4002, $3025 
    dc.w $8509, $3F43, $4294, $4819, $4010, $0000, $0000, $3E16 
    dc.w $0544, $4900, $BE95, $6838, $4500, $3F02, $6879, $9416 
    dc.w $BF04, $9278, $9080, $3F07, $0315, $2000, $BF08, $9229 
    dc.w $1244, $3F11, $0840, $0911, $BF14, $2831, $5604, $3F19 
    dc.w $9998, $7744, $BF33, $3333, $3113, $3F99, $9999, $9999 
    dc.w $3F78, $5398, $1634, $FFFF, $FFFF, $0000, $0000, $0000

; add self test ROM here

_ROM5000::
    nop

    .end

