/*
 * This file re-implements portions of the Alcyon portab.h needed
 * by curses. If you have a more complete portab.h that contains
 * the following definitions, use it.
 */

#define	BYTE	char
#define	WORD	int
#define	LONG	long
