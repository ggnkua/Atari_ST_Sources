		EXPORT log

		DATA

log:		;20 dB, for vu
		dc.b	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		dc.b	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		dc.b	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		dc.b	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		dc.b	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		dc.b	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		dc.b	0,0,0,0,0,0,0,1,1,1,2,2,2,3,3,4
		dc.b	4,4,5,5,5,6,6,6,7,7,7,7,8,8,8,9
		dc.b	9,9,10,10,10,11,11,11,11,12,12,12,13,13,13,13
		dc.b	14,14,14,14,15,15,15,15,16,16,16,16,17,17,17,17
		dc.b	18,18,18,18,19,19,19,19,20,20,20,20,20,21,21,21
		dc.b	21,22,22,22,22,22,23,23,23,23,24,24,24,24,24,25
		dc.b	25,25,25,25,26,26,26,26,26,27,27,27,27,27,28,28
		dc.b	28,28,28,28,29,29,29,29,29,30,30,30,30,30,30,31
		dc.b	31,31,31,31,31,32,32,32,32,32,32,33,33,33,33,33
		dc.b	33,34,34,34,34,34,34,35,35,35,35,35,35,36,36,36
		dc.b	36,36,36,36,37,37,37,37,37,37,37,38,38,38,38,38
		dc.b	38,38,39,39,39,39,39,39,39,40,40,40,40,40,40,40
		dc.b	41,41,41,41,41,41,41,41,42,42,42,42,42,42,42,43
		dc.b	43,43,43,43,43,43,43,44,44,44,44,44,44,44,44,45
		dc.b	45,45,45,45,45,45,45,46,46,46,46,46,46,46,46,46
		dc.b	47,47,47,47,47,47,47,47,47,48,48,48,48,48,48,48
		dc.b	48,48,49,49,49,49,49,49,49,49,49,50,50,50,50,50
		dc.b	50,50,50,50,51,51,51,51,51,51,51,51,51,51,52,52
		dc.b	52,52,52,52,52,52,52,52,53,53,53,53,53,53,53,53
		dc.b	53,53,54,54,54,54,54,54,54,54,54,54,55,55,55,55
		dc.b	55,55,55,55,55,55,55,56,56,56,56,56,56,56,56,56
		dc.b	56,56,57,57,57,57,57,57,57,57,57,57,57,58,58,58
		dc.b	58,58,58,58,58,58,58,58,58,59,59,59,59,59,59,59
		dc.b	59,59,59,59,59,60,60,60,60,60,60,60,60,60,60,60
		dc.b	60,61,61,61,61,61,61,61,61,61,61,61,61,62,62,62
		dc.b	62,62,62,62,62,62,62,62,62,62,63,63,63,63,63,63
		dc.b	63,63,63,63,63,63,63,64,64,64,64,64,64,64,64,64
		dc.b	64,64,64,64,64,65,65,65,65,65,65,65,65,65,65,65
		dc.b	65,65,65,66,66,66,66,66,66,66,66,66,66,66,66,66
		dc.b	66,67,67,67,67,67,67,67,67,67,67,67,67,67,67,68
		dc.b	68,68,68,68,68,68,68,68,68,68,68,68,68,68,69,69
		dc.b	69,69,69,69,69,69,69,69,69,69,69,69,69,69,70,70
		dc.b	70,70,70,70,70,70,70,70,70,70,70,70,70,71,71,71
		dc.b	71,71,71,71,71,71,71,71,71,71,71,71,71,72,72,72
		dc.b	72,72,72,72,72,72,72,72,72,72,72,72,72,72,73,73
		dc.b	73,73,73,73,73,73,73,73,73,73,73,73,73,73,73,74
		dc.b	74,74,74,74,74,74,74,74,74,74,74,74,74,74,74,74
		dc.b	75,75,75,75,75,75,75,75,75,75,75,75,75,75,75,75
		dc.b	75,75,76,76,76,76,76,76,76,76,76,76,76,76,76,76
		dc.b	76,76,76,76,77,77,77,77,77,77,77,77,77,77,77,77
		dc.b	77,77,77,77,77,77,77,78,78,78,78,78,78,78,78,78
		dc.b	78,78,78,78,78,78,78,78,78,78,79,79,79,79,79,79
		dc.b	79,79,79,79,79,79,79,79,79,79,79,79,79,79,80,80
		dc.b	80,80,80,80,80,80,80,80,80,80,80,80,80,80,80,80
		dc.b	80,80,80,81,81,81,81,81,81,81,81,81,81,81,81,81
		dc.b	81,81,81,81,81,81,81,82,82,82,82,82,82,82,82,82
		dc.b	82,82,82,82,82,82,82,82,82,82,82,82,82,83,83,83
		dc.b	83,83,83,83,83,83,83,83,83,83,83,83,83,83,83,83
		dc.b	83,83,83,84,84,84,84,84,84,84,84,84,84,84,84,84
		dc.b	84,84,84,84,84,84,84,84,84,85,85,85,85,85,85,85
		dc.b	85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85
		dc.b	86,86,86,86,86,86,86,86,86,86,86,86,86,86,86,86
		dc.b	86,86,86,86,86,86,86,86,87,87,87,87,87,87,87,87
		dc.b	87,87,87,87,87,87,87,87,87,87,87,87,87,87,87,87
		dc.b	88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,88
		dc.b	88,88,88,88,88,88,88,88,88,89,89,89,89,89,89,89
		dc.b	89,89,89,89,89,89,89,89,89,89,89,89,89,89,89,89
		dc.b	89,89,90,90,90,90,90,90,90,90,90,90,90,90,90,90