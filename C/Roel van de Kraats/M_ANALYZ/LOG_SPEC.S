		EXPORT log2

		DATA

log2:	;33 dB, with cutoff. for spectrum analyzer
		dc.b	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		dc.b	0,0,0,0,0,0,0,1,2,3,3,4,5,6,6,7
		dc.b	7,8,9,9,10,10,11,11,12,12,13,13,14,14,15,15
		dc.b	16,16,16,17,17,18,18,18,19,19,19,20,20,20,21,21
		dc.b	21,22,22,22,23,23,23,23,24,24,24,25,25,25,25,26
		dc.b	26,26,26,27,27,27,27,28,28,28,28,29,29,29,29,29
		dc.b	30,30,30,30,30,31,31,31,31,31,32,32,32,32,32,33
		dc.b	33,33,33,33,33,34,34,34,34,34,34,35,35,35,35,35
		dc.b	35,36,36,36,36,36,36,37,37,37,37,37,37,37,38,38
		dc.b	38,38,38,38,38,39,39,39,39,39,39,39,40,40,40,40
		dc.b	40,40,40,40,41,41,41,41,41,41,41,41,41,42,42,42
		dc.b	42,42,42,42,42,43,43,43,43,43,43,43,43,43,44,44
		dc.b	44,44,44,44,44,44,44,44,45,45,45,45,45,45,45,45
		dc.b	45,45,46,46,46,46,46,46,46,46,46,46,47,47,47,47
		dc.b	47,47,47,47,47,47,47,48,48,48,48,48,48,48,48,48
		dc.b	48,48,48,49,49,49,49,49,49,49,49,49,49,49,49,50
		dc.b	50,50,50,50,50,50,50,50,50,50,50,50,51,51,51,51
		dc.b	51,51,51,51,51,51,51,51,51,52,52,52,52,52,52,52
		dc.b	52,52,52,52,52,52,52,53,53,53,53,53,53,53,53,53
		dc.b	53,53,53,53,53,53,54,54,54,54,54,54,54,54,54,54
		dc.b	54,54,54,54,54,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55
		dc.b	55,55,55,55,55,55,55,55,55,55,55,55,55,55,55,55