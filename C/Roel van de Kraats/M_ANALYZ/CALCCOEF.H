/* Resource Datei Indizes f�r CALCCOEF */

#define MAINTREE 0   /* Formular/Dialog */
#define SAMPLEFREQ 1   /* FTEXT in Baum MAINTREE */
#define BARTLETT 4   /* BOXTEXT in Baum MAINTREE */
#define BLACKMAN 5   /* BOXTEXT in Baum MAINTREE */
#define FEJER    6   /* BOXTEXT in Baum MAINTREE */
#define HANN     7   /* BOXTEXT in Baum MAINTREE */
#define HAMM     8   /* BOXTEXT in Baum MAINTREE */
#define LANCZOS  9   /* BOXTEXT in Baum MAINTREE */
#define RECT     10  /* BOXTEXT in Baum MAINTREE */
#define LOWERFREQ 11  /* FTEXT in Baum MAINTREE */
#define UPPERFREQ 12  /* FTEXT in Baum MAINTREE */
#define ORDER    13  /* FTEXT in Baum MAINTREE */
#define BANDSTOP 16  /* BUTTON in Baum MAINTREE */
#define BANDPASS 17  /* BUTTON in Baum MAINTREE */
#define HIGHPASS 18  /* BUTTON in Baum MAINTREE */
#define LOWPASS  19  /* BUTTON in Baum MAINTREE */
#define CALCBUT  20  /* BUTTON in Baum MAINTREE */
#define CANCELBUT 21  /* BUTTON in Baum MAINTREE */
