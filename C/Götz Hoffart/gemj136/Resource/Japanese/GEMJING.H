/* Resource Datei Indizes f�r GEMJING */

#define MENU             0   /* Menuebaum */
#define MEN_ABOUT        8   /* STRING in Baum MENU */
#define MEN_OPEN         17  /* STRING in Baum MENU */
#define MEN_QUIT         19  /* STRING in Baum MENU */
#define MEN_CONTEXT      21  /* STRING in Baum MENU */

#define INFODIAL         1   /* Formular/Dialog */
#define INF_VERSION      3   /* FTEXT in Baum INFODIAL */
#define INF_MAUS         6   /* STRING in Baum INFODIAL */
#define INF_INTERNET     7   /* STRING in Baum INFODIAL */
#define INF_OK           9   /* BUTTON in Baum INFODIAL */

#define IMAGE_DIALOG     2   /* Formular/Dialog */
#define RADIO_SLCT       1   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_DESLCT     2   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_DESLCT   3   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_SLCT     4   /* IMAGE in Baum IMAGE_DIALOG */

#define MEM_ERR          0   /* Alert String */

#define READ_ERR         1   /* Alert String */

#define SND_ERR          2   /* Alert String */

#define STGUIDE_MISSING  3   /* Alert String */

#define SND_LOCK         4   /* Alert String */

#define FSEL_TIT         5   /* Freier String */

#define TITEL            6   /* Freier String */
