WORD lookup[512] = {16513,
0,
16513,
0,
5,
-29450,
5,
-29448,
5,
-29446,
5,
-29444,
16512,
9976,
16512,
9978,
16512,
9980,
16512,
9982,
16512,
-26192,
4,
-17330,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
11,
-7434,
16512,
-25792,
16512,
-24144,
0,
24886,
16512,
-25856,
16512,
-25856,
11,
19502,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
16512,
9988,
295,
4550,
295,
4366,
55,
16384,
16512,
9988,
-1,
72,
72,
1664,
42,
18096,
312,
25600,
0,
0,
298,
-22668,
293,
-11696,
4,
13248,
0,
0,
16518,
-13002,
-1,
-1,
0,
4,
298,
-22656,
0,
21856,
-1,
279,
30828,
0,
0,
-17,
-1,
0,
-13840,
0,
0,
0,
0,
0,
19,
1,
-3937,
1877,
-1,
-1,
0,
0,
21860,
299,
30618,
3,
13411,
1,
-2440,
-32513,
0,
0,
0,
0,
0,
0,
0,
0,
0,
3,
13320,
3,
13320,
24,
6,
16512,
-20160,
16512,
-23914,
16522,
-25770,
16512,
-24758,
16512,
-24758,
6,
-29102,
16512,
-24758,
16512,
-24758,
16512,
-24758,
16512,
-25296,
16512,
-24758,
16512,
-24758,
16512,
-24758,
16512,
-25280,
16512,
-24758,
16512,
-24758,
96,
20720,
0,
20720,
-16352,
20720,
-16352,
20721,
-8192,
-20662,
-2655,
-32767,
32767,
32767,
-1,
-1,
-1,
-1,
-1,
-22528,
-15326,
-13302,
32767,
16718,
17490,
0,
80,
0,
0,
280,
32372,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
16912,
16912,
16912,
16912,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
32767,
0,
60,
-25964,
0,
16718,
17490,
0,
8192,
76,
-4748,
280,
-32636,
0,
0,
280,
-32516,
0,
0,
0,
144,
0,
0,
0,
0,
0,
0,
0,
0,
8224,
8224,
-27407,
28167,
0,
116,
0,
2,
13318,
28910,
258,
8244,
-2454,
4660,
4632,
4630,
5186,
4134,
3676,
8296,
-9208,
1196,
17582,
1537,
-18866,
18433,
257,
257,
402,
3198,
257,
12308,
3120,
9222,
7174,
5188,
5644,
2578,
1036,
2606,
4636,
7182,
4136,
1028,
20504,
6168,
6192,
12336,
12336,
12336,
6156,
-10236,
1028,
1028,
1028,
1028,
1028,
1028,
1028,
0,
-27407,
28167,
0,
890,
280,
-17008,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
-1,
-1,
0,
-1,
0,
0,
0,
-1,
-1,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
280,
-24308,
0,
5716,
280,
-23428,
0,
880,
280,
-17484,
0,
5944,
40,
88,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0,
0};