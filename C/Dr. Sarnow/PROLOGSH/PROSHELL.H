#define LEISTE 0
#define DESK 3
#define INFORM 6
#define OPTFILES 3
#define BUTTON1 3
#define BUTTON3 5
#define BUTTON2 4
#define BUTTON4 6
#define BUTTON5 7
#define BUTTON7 9
#define BUTTON6 8
#define NAME1 10
#define NAME3 13
#define NAME2 12
#define NAME4 14
#define NAME5 15
#define AUTOR 1
#define NAME6 17
#define NAME7 16
#define INFOEX 10
#define KNOEPFE 2
#define CIAO 1
#define EDITOR 2
#define OPTIONEN 4
#define PROLOG 3
#define PROFILE 7
