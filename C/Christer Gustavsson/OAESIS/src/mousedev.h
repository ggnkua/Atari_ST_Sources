#ifndef __MOUDEV__
#define __MOUDEV__

/****************************************************************************
 * Moudev_init_module                                                       *
 *  Initialize mouse device.                                                *
 ****************************************************************************/
void                      /*                                                */
Moudev_init_module(void); /*                                                */
/****************************************************************************/

/****************************************************************************
 * Moudev_exit_module                                                       *
 *  Shutdown mouse device.                                                  *
 ****************************************************************************/
void                      /*                                                */
Moudev_exit_module(void); /*                                                */
/****************************************************************************/

#endif