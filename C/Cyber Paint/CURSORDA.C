#include "flicker.h"

#ifdef SLUFFED
static UWORD ibox[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0xffe,	0x0,	0xffe,	0x0,
	0xffe,	0x0,	0xffe,	0x0,	0xffe,	0x0,	0xffe,	0x0,
	0xffe,	0x0,	0xffe,	0x0,	0xffe,	0x0,	0xffe,	0x0,
	0xffe,	0x0,	0x0,	0x0,
	};
struct cursor cbox = 	{ 0, ibox, 18, 14, 9, 7};

static UWORD ibrush[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,
	0x80,	0x0,	0x380,	0x2000,	0x601,	0x0,	0x404,	0x0,
	0xc08,	0x0,	0x800,	0x0,	0x810,	0x0,	0xe60,	0x0,
	0x3c0,	0x0,	0x0,	0x0,
	};
struct cursor cbrush = 	{ 0, ibrush, 20, 14, 10, 7};

static UWORD icircle[] = 
	{
	0x0,	0x0,	0x1f0,	0x0,	0x7fc,	0x0,	0xffe,	0x0,
	0xffe,	0x0,	0x1fff,	0x0,	0x1fff,	0x0,	0x1fff,	0x0,
	0x1fff,	0x0,	0x1fff,	0x0,	0xffe,	0x0,	0xffe,	0x0,
	0x7fc,	0x0,	0x1f0,	0x0,
	};
struct cursor ccircle = 	{ 0, icircle, 18, 14, 9, 7};

static UWORD icopy[] = 
	{
	0x0,	0x0,	0x2000,	0x0,	0x2000,	0x0,	0x2720,	0x0,
	0x3d20,	0x0,	0x127,	0x0,	0x13d,	0x0,	0x101,	0x0,
	0x101,	0x0,	0x101,	0x0,	0x101,	0x0,	0x1,	0x0,
	0x1,	0x0,	0x0,	0x0,
	};
struct cursor ccopy = 	{ 0, icopy, 18, 14, 9, 7};
#endif SLUFFED

static UWORD idown[] = 
	{
	0x0,	0x0,	0x200,	0x200,	0x200,	0x200,	0x200,	0x2220,
	0x1ac0,	0xf80,	0x700,	0x200,
	};
struct cursor cdown = 	{ 0, idown, 12, 12, 6, 7};

#ifdef SLUFFED
static UWORD idrizzle[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,
	0x0,	0x0,	0x108,	0x0,	0x40,	0x0,	0x100,	0x0,
	0x20,	0x0,	0x80,	0x0,	0x0,	0x0,	0x0,	0x0,
	0x0,	0x0,	0x0,	0x0,
	};
struct cursor cdrizzle = 	{ 0, idrizzle, 19, 14, 9, 7};

static UWORD iflood[] = 
	{
	0x0,	0x0,	0x3f8,	0x0,	0x404,	0x0,	0x802,	0x0,
	0x1001,	0x0,	0x1fff,	0x0,	0x3fff,	0x8000,	0x3fff,	0x8000,
	0x3fff,	0x8000,	0x1fff,	0x0,	0x1fff,	0x0,	0x802,	0x0,
	0x404,	0x0,	0x3f8,	0x0,
	};
struct cursor cflood = 	{ 0, iflood, 18, 14, 9, 7};
#endif SLUFFED

static UWORD ileft[] = 
	{
	0x0,	0x0,	0x200,	0x400,	0xc00,	0x1800,	0x3fc0,	0x1800,
	0xc00,	0x400,	0x200,	0x0,
	};
struct cursor cleft = 	{ 0, ileft, 11, 12, 5, 6};

#ifdef SLUFFED
static UWORD iline[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,	0x1,	0x0,
	0x6,	0x0,	0x18,	0x0,	0x60,	0x0,	0x80,	0x0,
	0x300,	0x0,	0xc00,	0x0,	0x1000,	0x0,	0x0,	0x0,
	0x0,	0x0,	0x0,	0x0,
	};
struct cursor cline = 	{ 0, iline, 18, 14, 9, 7};

static UWORD ipen[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,	0x0,	0x8000,
	0x3,	0x0,	0x3fe,	0x0,	0x600,	0x0,	0xc00,	0x0,
	0x800,	0x0,	0x800,	0x0,	0x800,	0x0,	0x0,	0x0,
	0x0,	0x0,	0x0,	0x0,
	};
struct cursor cpen = 	{ 0, ipen, 18, 14, 9, 7};

static UWORD ipolygon[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0x1c0,	0x0,	0x3fc,	0x0,
	0x3ff,	0x8000,	0x7ff,	0x8000,	0x7ff,	0x0,	0xfff,	0x0,
	0x1ffe,	0x0,	0x1ffe,	0x0,	0x3ffc,	0x0,	0x0,	0x0,
	0x0,	0x0,	0x0,	0x0,
	};
struct cursor cpolygon = 	{ 0, ipolygon, 18, 14, 9, 7};
#endif SLUFFED

static UWORD iright[] = 
	{
	0x0,	0x0,	0x400,	0x200,	0x300,	0x180,	0x3fc0,	0x180,
	0x300,	0x200,	0x400,	0x0,
	};
struct cursor cright = 	{ 0, iright, 11, 12, 5, 6};

#ifdef SLUFFED
static UWORD iseparate[] = 
	{
	0x0,	0x0,	0x1fff,	0x0,	0x1001,	0x0,	0x1001,	0x0,
	0x1001,	0x0,	0x1001,	0x0,	0x1001,	0x0,	0x1001,	0x0,
	0x1001,	0x0,	0x1fff,	0x0,	0x1fff,	0x0,	0x1fff,	0x0,
	0x1fff,	0x0,	0x1fff,	0x0,
	};
struct cursor cseparate = 	{ 0, iseparate, 18, 14, 9, 7};
#endif SLUFFED

static UWORD isleft[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0x107,	0x0,	0x207,	0x0,
	0x607,	0x0,	0xc07,	0x0,	0x1fe7,	0x0,	0xc07,	0x0,
	0x607,	0x0,	0x207,	0x0,	0x107,	0x0,	0x0,	0x0,
	};
struct cursor csleft = 	{ 0, isleft, 19, 12, 9, 6};

#ifdef SLUFFED
static UWORD ispray[] = 
	{
	0x0,	0x0,	0x8,	0x0,	0x0,	0x0,	0x489,	0x0,
	0x80,	0x0,	0x112,	0x8000,	0xe4,	0x0,	0x578,	0x0,
	0xf8,	0x8000,	0x138,	0x0,	0x844,	0x0,	0x110,	0x0,
	0x140,	0x0,	0x8,	0x2000,
	};
struct cursor cspray = 	{ 0, ispray, 19, 14, 9, 7};
#endif SLUFFED

static UWORD isright[] = 
	{
	0x0,	0x0,	0x0,	0x0,	0xe08,	0x0,	0xe04,	0x0,
	0xe06,	0x0,	0xe03,	0x0,	0xe7f,	0x8000,	0xe03,	0x0,
	0xe06,	0x0,	0xe04,	0x0,	0xe08,	0x0,	0x0,	0x0,
	};
struct cursor csright = 	{ 0, isright, 19, 12, 9, 6};

static UWORD iup[] = 
	{
	0x0,	0x200,	0x700,	0xf80,	0x1ac0,	0x2220,	0x200,	0x200,
	0x200,	0x200,	0x200,	0x0,
	};
struct cursor cup = 	{ 0, iup, 12, 12, 6, 6};


static UWORD icin[] = 
	{
	0x1f80,	0x380,	0x380,	0x480,	0x880,	0x1080,	0x2000,	0x4000,
	0x8000,
	};
struct cursor cin = 	{ 0, icin, 9, 9, 4, 4};

static UWORD icout[] = 
	{
	0x80,	0x100,	0x200,	0x8400,	0x8800,	0x9000,	0xe000,	0xe000,
	0xfc00,
	};
struct cursor cout = 	{ 0, icout, 9, 9, 4, 4};


#ifdef SLUFFED
static UWORD icclip[] = 
	{
	0xffff,	0x8801,	0x9801,	0xbf01,	0xffff,	0xbff9,	0x8f19,	0x840d,
	0x8201,	0xffff,
	};
struct cursor cclip = 	{ 0, icclip, 16, 10, 8, 5};

static UWORD iccut[] = 
	{
	0x200,	0x0,	0x200,	0x0,	0xffff,	0xfff0,	0x201,	0x0,
	0x202,	0x0,	0x206,	0x0,	0x20f,	0xc000,	0x23f,	0xffc0,
	0x20f,	0xfe00,	0x203,	0xc600,	0x201,	0x300,	0x200,	0x8000,
	0x200,
	};
struct cursor ccut = 	{ 0, iccut, 28, 12, 14, 6};

static UWORD icblur[] = 
	{
	0x1040,	0x1040,	0x1040,	0x1040,	0x1040,	0xfff8,	0x1040,	0x820,
	0x1040,	0x820,	0x1040,
	};
struct cursor cblur = 	{ 0, icblur, 13, 11, 6, 5};

static UWORD icflip[] = 
	{
	0x100,	0x100,	0x100,	0x7d7c,	0x3d78,	0x1d70,	0xd60,	0x1d70,
	0x3d78,	0x3118,	0x4104,	0x100,
	};
struct cursor cflip = 	{ 0, icflip, 14, 12, 7, 6};

static UWORD izrotc[14] = 
	{
	0x70,	0xFF0,	0xFFF0,	0xFC70,	0xEB98,	0x67D8,	0x63E8,	0x7EE8,
	0x7FE8,	0x7FDC,	0x339C,	0x3C7C,	0x3FC0,	0x3800,
	};
struct cursor zrotc = 	{ 0, izrotc, 14, 14, 7, 7};

static UWORD	irotate_cursor_image[16] = {
		0x0000, 0x0000, 0x0F00, 0x10C0, 0x2020, 0x4010, 0x4010, 0x8720,
		0x0620, 0x07C0, 0x0400, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
		};
struct cursor rotate_cursor =
    {
    0,
    irotate_cursor_image,
    12, 14, 5, 6,
    };

static UWORD ikillc[11] = 
	{
	0xF00,	0x3FC0,	0x70E0,	0x61E0,	0xC330,	0xC630,	0xCC30,	0x7860,
	0x70E0,	0x3FC0,	0xF00,
	};
struct cursor killc = 	{ 0, ikillc, 12, 11, 6, 5};

static UWORD igrabc[12] = 
	{
	0x60,	0x30,	0x630,	0xC78,	0xCF8,	0xFF0,	0xFE0,	0x1F80,
	0x3C00,	0x7800,	0x7800,	0x3000,
	};
struct cursor grabc = 	{ 0, igrabc, 13, 12, 6, 6};


static UWORD icamerac[11] = 
	{
	0x70,	0x26F8,	0xFF9C,	0xFF9C,	0xFFFC,	0x8F04,	0x9994,	0x90A4,
	0x9084,	0x9984,	0xEF7C,
	};
struct cursor camerac = 	{ 0, icamerac, 14, 11, 7, 5};

static UWORD iclockc[13] = 
	{
	0x1040,	0xF80,	0x3560,	0x7DF0,	0x5DD0,	0xFDF8,	0xB1EC,	0xFFF8,
	0x5FD0,	0x7FF0,	0x3560,	0xF80,	0x1040,
	};
struct cursor clockc = 	{ 0, iclockc, 14, 13, 7, 6};

static UWORD	ilreplay_cursor_image[16] = {
		0x0000, 0x1830, 0x2448, 0x2448, 0x1830, 0x0440, 0x0280, 0x0FE0,
		0x0830, 0x0830, 0x0FE0, 0x0440, 0x0000, 0x0000, 0x0000, 0x0000,
		};
struct cursor lreplay_cursor =
    {
    0,
    ilreplay_cursor_image,
    16, 16, 7, 7,
    };

static UWORD	ibreplay_cursor_image[16] = {
		0x381C, 0x4422, 0xAA55, 0x9249, 0xAA55, 0x4422, 0x3A5C, 0x0180,
		0x0FF0, 0x0818, 0x0818, 0x0810, 0x0FF0, 0x0420, 0x0810, 0x0000,
		};
struct cursor breplay_cursor =
    {
    0,
    ibreplay_cursor_image,
    16, 16, 7, 7,
    };

static UWORD	isize_cursor_image[16] = {
		0x2008, 0x1450, 0x0C60, 0x1C70, 0x0000, 0x0000,
		0x0000, 0x1C70, 0x0C60, 0x1450, 0x2008,
		};
struct cursor size_cursor =
    {
    0,
    isize_cursor_image,
    16, 11, 7, 5,
    };

static UWORD	idiskc[16] = {
		0x0000, 0x0000, 0x0000, 0x3FF0, 0x2010, 0x2030, 0x2010, 0x2010,
		0x2010, 0x2FD0, 0x2BD0, 0x2BD0, 0x3FF0, 0x0000, 0x0000, 0x0000,
		};
struct cursor diskc =
    {
    0,
    idiskc,
    14, 16, 7, 8,
    };

static UWORD ipalette_cursor_image[] = {
	0x70, 0x30f8, 0x79fc, 0xfffc, 0xfbfc, 0xf1fc, 0xf1f8, 0xfbf8,
	0x7ff0, 0x7ff0, 0x3fe0, 0xf80,
	};
struct cursor palette_cursor =
    {
    0,
    ipalette_cursor_image,
    14, 12, 7, 6,
    };
#endif SLUFFED


static UWORD icright2[] = 
	{
	0x8400,	0x4200,	0x6300,	0x3180,	0x39c0,	0x3180,	0x6300,	0x4200,
	0x8400,
	};
struct cursor cright2 = 	{ 0, icright2, 10, 9, 5, 4};

static UWORD icleft2[] = 
	{
	0x840,	0x1080,	0x3180,	0x6300,	0xe700,	0x6300,	0x3180,	0x1080,
	0x840,	0x0,
	};
struct cursor cleft2 = 	{ 0, icleft2, 10, 10, 5, 4};

static UWORD icinsert[] = 
	{
	0xc0,	0xc0,	0xc0,	0xc0,	0xfff0,	0x10c0,	0x28c0,	0x44c0,
	0xc0,
	};
struct cursor cinsert = 	{ 0, icinsert, 12, 9, 6, 4};

static UWORD icappend[] = 
	{
	0x0,	0x1800,	0x1800,	0x1800,	0x1800,	0x7ff8,	0x1840,	0x18a0,
	0x1910,	0x1800,
	};
struct cursor cappend = 	{ 0, icappend, 13, 10, 6, 5};

