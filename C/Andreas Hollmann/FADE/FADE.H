voidcdecladd1fade(void *Buffer1, void *Buffer2, longmode);
voidcdecladd8fade(void *Buffer1, void *Buffer2, longmode);
voidcdeclrnd1fade(void *Buffer1, void *Buffer2);
voidcdeclrnd8fade(void *Buffer1, void *Buffer2);
