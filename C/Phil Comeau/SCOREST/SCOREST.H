#define IMEZZO 46
#define IFLAT 12
#define IFORTE 13
#define INAT 43
#define IN4HEAD 48
#define IBCLEF 50
#define IPIANO 44
#define IACLEF 15
#define ITCLEF 49
#define ISEGNE 53
#define ICODA 54
#define ITURN 52
#define IUPCRV 21
#define IBEAM 22
#define ILINE 17
#define ILDGRLN 18
#define IBRACE 23
#define ITEXT 36
#define ISTAFF 37
#define ITRILL 35
#define ISELECT 24
#define IDOT 14
#define IDNCRV 2
#define IDSHARP 16
#define IGRACE 19
#define IFERMATA 20
#define TXSZDLG 5
#define LNWDDLG 2
#define LNWD7 2
#define TXSZ9 4
#define TXSZ10 3
#define LNWD5 3
#define TXSZ8 5
#define LNWD3 4
#define TXSZ16 6
#define LNWDOK 10
#define LNWD1 5
#define TXSZ20 10
#define TXSZ18 7
#define LNWD9 6
#define TXSZCAN 9
#define LNWD11 7
#define TXSZOK 8
#define LNENDDLG 4
#define LNWDCAN 11
#define LNWD13 8
#define LNWD15 9
#define LNENDCAN 6
#define LNENDOK 5
#define LNENDARW 3
#define LNENDSQR 7
#define LNENDRND 4
#define TXSTYDLG 6
#define TXSTYCAN 9
#define TXSTYOK 8
#define TXSTYUL 2
#define TXSTYOL 3
#define TXSTYITL 5
#define TXSTYLT 4
#define TXSTYBLD 6
#define TOPGDLG 7
#define TOPGFLD 2
#define TOPGCAN 4
#define TOPGOK 3
#define MENUBAR 1
#define DESKMNU 3
#define EDITMNU 5
#define FILEMNU 4
#define PAGEMNU 6
#define OPTMNU 7
#define INFOITM 10
#define OPENITM 19
#define NEWITM 20
#define SVITM 22
#define SVASITM 23
#define CLSITM 24
#define PRTDITM 26
#define PRTFITM 27
#define QUITITM 29
#define COPYITM 31
#define PSTITM 33
#define CUTITM 32
#define ERAITM 34
#define DELPGITM 37
#define CRTPGITM 36
#define TOPGITM 39
#define NXTPGITM 41
#define PRVPGITM 40
#define FSTPGITM 42
#define LSTPGITM 43
#define LNWDITM 45
#define LNPATITM 46
#define LNENDITM 47
#define TXTSZITM 49
#define TXTATITM 50
#define GRIDITM 52
#define INFODLG 8
#define INVERFLD 10
#define ICONS 0
#define IN4DN 34
#define IN4UP 6
#define IR4 7
#define IN8UP 8
#define IR8 26
#define IN8DN 9
#define IN16UP 29
#define LNPATDLG 3
#define IN16DN 28
#define IN32UP 30
#define IR16 27
#define LNPATCAN 5
#define IN32DN 31
#define LNPATOK 6
#define IR32 10
#define LNPATDOT 4
#define LNPATDSH 3
#define IN64DN 32
#define IN64UP 42
#define LNPATSOL 7
#define IR64 11
#define CRTPGDLG 9
#define IN2HEAD 47
#define IN2DN 33
#define IN2UP 4
#define IR2 5
#define IR1 3
#define CRTPGFLD 5
#define IN1 1
#define ISTAC 51
#define CRTPGOK 6
#define ISHARP 45
#define CRTPGCAN 7
