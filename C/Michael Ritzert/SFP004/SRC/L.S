	.text
	.even
	.word	0x4a68,0xfff0,0x6bfa
	.long	0x0c688900, 0xfff067f8
