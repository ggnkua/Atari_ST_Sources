/* Resource Datei Indizes f�r CALLUFSL */

#define SETFLAGS 0   /* Formular/Dialog */
#define U_TITLE  2   /* FTEXT in Baum SETFLAGS */
#define U_INFO   3   /* FTEXT in Baum SETFLAGS */
#define U_BSP    4   /* FTEXT in Baum SETFLAGS */
#define U_WINDOW 6   /* BUTTON in Baum SETFLAGS */
#define U_DIALOG 7   /* BUTTON in Baum SETFLAGS */
#define U_ID10   9   /* FTEXT in Baum SETFLAGS */
#define U_ID8    10  /* FTEXT in Baum SETFLAGS */
#define U_PROP   12  /* BUTTON in Baum SETFLAGS */
#define U_GDOS   13  /* BUTTON in Baum SETFLAGS */
#define U_CSIZE  14  /* BUTTON in Baum SETFLAGS */
#define U_DSIZE  15  /* BUTTON in Baum SETFLAGS */
#define U_CWIDTH 16  /* BUTTON in Baum SETFLAGS */
#define U_CKERN  17  /* BUTTON in Baum SETFLAGS */
#define U_CATTR  18  /* BUTTON in Baum SETFLAGS */
#define U_IATTR  19  /* BUTTON in Baum SETFLAGS */
#define U_CCOLOR 20  /* BUTTON in Baum SETFLAGS */
#define U_CSKEW  21  /* BUTTON in Baum SETFLAGS */
#define U_ID     23  /* FTEXT in Baum SETFLAGS */
#define U_SIZE   24  /* FTEXT in Baum SETFLAGS */
#define U_WIDTH  25  /* FTEXT in Baum SETFLAGS */
#define U_KERN   26  /* FTEXT in Baum SETFLAGS */
#define U_PKERN  27  /* BOXCHAR in Baum SETFLAGS */
#define U_ATTR   28  /* FTEXT in Baum SETFLAGS */
#define U_COLOR  29  /* FTEXT in Baum SETFLAGS */
#define U_SKEW   30  /* FTEXT in Baum SETFLAGS */
#define U_NSKEW  31  /* BOXCHAR in Baum SETFLAGS */
#define UFSL_ID  37  /* TEXT in Baum SETFLAGS */
#define UFSL_VER 38  /* TEXT in Baum SETFLAGS */
#define U_CALL   39  /* BUTTON in Baum SETFLAGS */
#define U_SET    40  /* BUTTON in Baum SETFLAGS */
#define U_STOP   41  /* BUTTON in Baum SETFLAGS */
