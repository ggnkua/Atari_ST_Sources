/* Resource Datei Indizes f�r IF_DIF */

#define VORTEXT  0   /* Freier String */

#define TXTZEILE 1   /* Freier String */

#define NACHTEXT 2   /* Freier String */
