/* Resource Datei Indizes f�r EXTHELP */

#define HELP_EXTEND 0   /* Formular/Dialog */

#define EXITBUT3D 0   /* Alert String */

#define EXITBUT  1   /* Alert String */

#define ASCII_HEADER 2   /* Freier String */

#define MODE3D_ON 3   /* Freier String */

#define MODE3D_OFF 4   /* Freier String */
