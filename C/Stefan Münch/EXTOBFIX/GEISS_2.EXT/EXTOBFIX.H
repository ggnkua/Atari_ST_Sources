/* Resource Datei Indizes f�r EXTOBFIX */

#define USERIMG  0   /* Formular/Dialog */
#define RBHNORM  1   /* IMAGE in Baum USERIMG */
#define RBHSEL   2   /* IMAGE in Baum USERIMG */
#define RBLNORM  3   /* IMAGE in Baum USERIMG */
#define RBLSEL   4   /* IMAGE in Baum USERIMG */
#define CBHNORM  5   /* IMAGE in Baum USERIMG */
#define CBHSEL   6   /* IMAGE in Baum USERIMG */
#define CBLNORM  7   /* IMAGE in Baum USERIMG */
#define CBLSEL   8   /* IMAGE in Baum USERIMG */

#define HELP_EXT 1   /* Formular/Dialog */
