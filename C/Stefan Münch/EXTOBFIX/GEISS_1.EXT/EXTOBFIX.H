/* Resource Datei Indizes f�r EXTOBFIX */

#define USERIMG  0   /* Formular/Dialog */
#define RBHNORM  1   /* IMAGE in Baum USERIMG */
#define RBHSEL   2   /* IMAGE in Baum USERIMG */
#define CIRCELH  3   /* IMAGE in Baum USERIMG */
#define RBLNORM  4   /* IMAGE in Baum USERIMG */
#define RBLSEL   5   /* IMAGE in Baum USERIMG */
#define CIRCELL  6   /* IMAGE in Baum USERIMG */

#define HELP_EXT 1   /* Formular/Dialog */
