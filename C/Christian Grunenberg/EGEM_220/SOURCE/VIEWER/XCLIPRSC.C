#define T0OBJ 0
#define T1OBJ 8
#define FREEBB 6
#define FREEIMG 6
#define FREESTR 0

char *rs_strings[] = {
0};

USERBLK rs_userblks[] = {
0};


int  IMAG0[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x8000, 
0x0, 0x1, 0x8007, 0xF800, 
0x1, 0x807C, 0xF80, 0x1, 
0x9FC0, 0xC0FE, 0x1, 0x90C0, 
0xC2, 0x1, 0x9780, 0x7A, 
0x181, 0x95FF, 0xFFEA, 0x381, 
0x9400, 0xA, 0x7F9, 0x95F7, 
0xD80A, 0xFF1, 0x9400, 0xA, 
0x1FE1, 0x95BA, 0x800A, 0xFF1, 
0x9400, 0x200A, 0x7F9, 0x95E0, 
0x300A, 0x381, 0x9402, 0x300A, 
0x181, 0x9583, 0x300A, 0x1, 
0x9401, 0xB00A, 0x1, 0x95D0, 
0xF00A, 0x1, 0x9400, 0x700A, 
0x1, 0x9400, 0x300A, 0x1, 
0x9400, 0x390A, 0x1, 0x9400, 
0x3E8A, 0x1, 0x9400, 0x76BA, 
0x1089, 0x9400, 0xB312, 0x2889, 
0x9400, 0xB0A2, 0x4451, 0x9400, 
0x60C2, 0x21, 0x97FF, 0x9F82, 
0x51, 0x9000, 0x2, 0x89, 
0x9FFF, 0xFFFE, 0x89, 0x8000, 
0x0, 0x1, 0x8000, 0x0, 
0x1, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG1[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x8000, 
0x0, 0x1, 0x8007, 0xF800, 
0x1, 0x807C, 0xF80, 0x1, 
0x9FC0, 0xC0FE, 0x1, 0x90C0, 
0xC2, 0x1, 0x9780, 0x7A, 
0x181, 0x95FF, 0xFFEA, 0x381, 
0x9400, 0xA, 0x7F9, 0x95F7, 
0xD80A, 0xFF1, 0x9400, 0xA, 
0x1FE1, 0x95BA, 0xE00A, 0xFF1, 
0x9400, 0xA, 0x7F9, 0x95E0, 
0xA, 0x381, 0x9400, 0xA, 
0x181, 0x9580, 0xA, 0x1, 
0x9400, 0xA, 0x1, 0x95D0, 
0xA, 0x1, 0x9400, 0xA, 
0x1, 0x9400, 0xA, 0x1, 
0x9400, 0xA, 0x1, 0x9400, 
0xA, 0x1, 0x9400, 0xFA, 
0x1071, 0x9400, 0x92, 0x2889, 
0x9400, 0xA2, 0x4481, 0x9400, 
0xC2, 0x81, 0x97FF, 0xFF82, 
0x81, 0x9000, 0x2, 0x89, 
0x9FFF, 0xFFFE, 0x71, 0x8000, 
0x0, 0x1, 0x8000, 0x0, 
0x1, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG2[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x8000, 
0x0, 0x1, 0x8007, 0xF800, 
0x1, 0x807C, 0xF80, 0x1, 
0x9FC0, 0xC0FE, 0x1, 0x90C0, 
0xC2, 0x1, 0x9780, 0x7A, 
0x81, 0x95FF, 0xFFEA, 0xC1, 
0x9400, 0xA, 0x1FE1, 0x95F7, 
0xD80A, 0xFF1, 0x9400, 0xA, 
0x7F9, 0x95BA, 0xE00A, 0xFF1, 
0x9400, 0xA, 0x1FE1, 0x95E0, 
0xA, 0xC1, 0x9400, 0xA, 
0x81, 0x9580, 0xA, 0x1, 
0x9400, 0xA, 0x1, 0x95D0, 
0xA, 0x1, 0x9400, 0xA, 
0x1, 0x9400, 0xA, 0x1, 
0x9400, 0xA, 0x1, 0x9400, 
0xA, 0x1, 0x9400, 0xFA, 
0x1089, 0x9400, 0x92, 0x2889, 
0x9400, 0xA2, 0x4489, 0x9400, 
0xC2, 0x51, 0x97FF, 0xFF82, 
0x51, 0x9000, 0x2, 0x21, 
0x9FFF, 0xFFFE, 0x21, 0x8000, 
0x0, 0x1, 0x8000, 0x0, 
0x1, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG3[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x8000, 
0x0, 0x1, 0x8000, 0x0, 
0x1, 0x8000, 0x0, 0x1, 
0x8001, 0xF000, 0x1, 0x803F, 
0x1F80, 0x1, 0x80E3, 0x18E0, 
0x1, 0x8100, 0x10, 0x1, 
0x81E0, 0xF0, 0x1, 0x80BF, 
0xFFA0, 0x1, 0x8080, 0x20, 
0x1, 0x80A2, 0x1120, 0x1, 
0x80A2, 0x1120, 0x1, 0x80A2, 
0x1120, 0x1, 0x80A2, 0x1120, 
0x1, 0x80A2, 0x1120, 0x1, 
0x80A2, 0x4520, 0x1, 0x80A2, 
0x6D20, 0x1, 0x80A2, 0x3920, 
0x1, 0x80A2, 0x1120, 0x1, 
0x80A2, 0x1120, 0x1, 0x80A2, 
0x1120, 0x1, 0x80A2, 0x1120, 
0x1089, 0x80A2, 0x1120, 0x2889, 
0x80A2, 0x1120, 0x4489, 0x80B2, 
0x1320, 0x51, 0x80C3, 0x3060, 
0x21, 0x8070, 0x1C0, 0x21, 
0x801F, 0xFF00, 0x21, 0x8000, 
0x0, 0x1, 0x8000, 0x0, 
0x1, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG4[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x8000, 
0x0, 0x1, 0x8000, 0xFE00, 
0x1, 0x8003, 0xFF80, 0x1, 
0x8FFF, 0xFFFF, 0xC001, 0x880F, 
0xFFE0, 0x4001, 0x881F, 0xFFE0, 
0x4001, 0x881F, 0x87F0, 0x4001, 
0x881F, 0x3F0, 0x4001, 0x880E, 
0x1F0, 0x4001, 0x8800, 0x1F0, 
0x4001, 0x8800, 0x1F0, 0x4001, 
0x8800, 0x3E0, 0x4001, 0x8800, 
0x7E0, 0x4001, 0x8800, 0xFC0, 
0x4001, 0x8800, 0x1F80, 0x4001, 
0x8800, 0x3F00, 0x4001, 0x8800, 
0x3E00, 0x4001, 0x8800, 0x7E00, 
0x4001, 0x8800, 0x7C00, 0x4001, 
0x800, 0x7C00, 0x4001, 0x8800, 
0x7C00, 0x4001, 0x8800, 0x0, 
0x4001, 0x8800, 0x0, 0x4001, 
0x8800, 0x3800, 0x4001, 0x8800, 
0x7C00, 0x4001, 0x8800, 0x7C00, 
0x4001, 0x8FFF, 0x39FF, 0xC001, 
0x8000, 0x0, 0x1, 0x8000, 
0x0, 0x1, 0x8000, 0x0, 
0x1, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG5[] = {
0x0, 0x0, 0x0, 0x0, 
0xF, 0xF000, 0xF8, 0x1F00, 
0x3F81, 0x81FC, 0x2180, 0x184, 
0x2F00, 0xF4, 0x2BFF, 0xFFD4, 
0x2800, 0x14, 0x2BEF, 0xB014, 
0x2800, 0x14, 0x2B75, 0xC014, 
0x2800, 0x14, 0x2BC0, 0x14, 
0x2800, 0x14, 0x2B00, 0x14, 
0x2800, 0x14, 0x2BA0, 0x14, 
0x2800, 0x14, 0x2800, 0x14, 
0x2800, 0x14, 0x2800, 0x14, 
0x2800, 0x1F4, 0x2800, 0x124, 
0x2800, 0x144, 0x2800, 0x184, 
0x2FFF, 0xFF04, 0x2000, 0x4, 
0x3FFF, 0xFFFC, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0};

LONG rs_frstr[] = {
0};

BITBLK rs_bitblk[] = {
(WORD *)0L, 6, 32, 0, 0, 1,
(WORD *)1L, 6, 32, 0, 0, 1,
(WORD *)2L, 6, 32, 0, 0, 1,
(WORD *)3L, 6, 32, 0, 0, 1,
(WORD *)4L, 6, 32, 0, 0, 1,
(WORD *)5L, 4, 32, 0, 0, 1};

LONG rs_frimg[] = {
0};

ICONBLK rs_iconblk[] = {
0};

CICONBLK rs_ciconblk[] = {
0};

TEDINFO rs_tedinfo[] = {
0};

OBJECT rs_object[] = {
-1, 1, 7, G_BOX, NONE, NORMAL, 0xFE1100L, 0,0, 48,12,
7, 2, 6, G_BOX, 0x400, NORMAL, 0xFF1101L, 0,0, 6,11,
3, -1, -1, G_IMAGE, 0x5, NORMAL, 0x0L, 0,0, 12288,8192,
4, -1, -1, G_IMAGE, 0x5, NORMAL, 0x1L, 0,2, 12288,8192,
5, -1, -1, G_IMAGE, 0x5, NORMAL, 0x2L, 0,4, 12288,8192,
6, -1, -1, G_IMAGE, 0x5, NORMAL, 0x3L, 0,6, 12288,8192,
1, -1, -1, (0xC<<8)+G_IMAGE, 0x5, NORMAL, 0x4L, 0,8, 12288,8192,
0, -1, -1, G_BOX, 0x60, NORMAL, 0xFF1101L, 7,0, 41,11,
-1, 1, 1, G_BOX, NONE, NORMAL, 0x1100L, 0,0, 8,2,
0, -1, -1, G_IMAGE, LASTOB, NORMAL, 0x5L, 2,0, 8192,8192};

LONG rs_trindex[] = {
0L,
8L};

struct foobar {
	WORD 	dummy;
	WORD 	*image;
	} rs_imdope[] = {
0, &IMAG0[0],
0, &IMAG1[0],
0, &IMAG2[0],
0, &IMAG3[0],
0, &IMAG4[0],
0, &IMAG5[0]};

#define NUM_STRINGS 0
#define NUM_USERDEFS 0
#define NUM_FRSTR 0
#define NUM_IMAGES 6
#define NUM_BB 6
#define NUM_FRIMG 0
#define NUM_IB 0
#define NUM_CIB 0
#define NUM_TI 0
#define NUM_OBS 10
#define NUM_TREE 2

int rs_numstrings = NUM_STRINGS;
int rs_nuser = NUM_USERDEFS;
int rs_numfrstr = NUM_FRSTR;
int rs_numimages = NUM_IMAGES;
int rs_numbb = NUM_BB;
int rs_numfrimg = NUM_FRIMG;
int rs_numib = NUM_IB;
int rs_numcib = NUM_CIB;
int rs_numti = NUM_TI;
int rs_numobs = NUM_OBS;
int rs_numtree = NUM_TREE;

char pname[] = "XCLIPRSC.RSC";

int _rsc_format = 1;
