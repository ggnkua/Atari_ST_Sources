#define T0OBJ 0
#define T1OBJ 63
#define T2OBJ 80
#define FREEBB 0
#define FREEIMG 0
#define FREESTR 130

static char *rs_strings[] = {
"T",
"Font",
"",
"",
"Face",
"",
"",
"Size",
"",
"",
"Options",
"",
"",
"",
"",
"",
"Fat",
"",
"",
"Light",
"",
"",
"Italics",
"",
"",
"Underline",
"",
"",
"Outline",
"",
"",
"Shadow",
"",
"",
"Invers",
"",
"",
"XXX",
"___",
"9",
"pts",
"Skew",
"",
"",
"-00\370",
"",
"",
"Color",
"",
"",
"",
"",
"",
"Info",
"",
"",
"C",
"123456789012",
"",
"",
"White",
"",
"",
"Black",
"",
"",
"Red",
"",
"",
"Green",
"",
"",
"Blue",
"",
"",
"Cyan",
"",
"",
"Yellow",
"",
"",
"Magenta",
"",
"",
"L-white",
"",
"",
"L-black",
"",
"",
"L-red",
"",
"",
"L-green",
"",
"",
"L-blue",
"",
"",
"L-cyan",
"",
"",
"L-yellow",
"",
"",
"L-magenta",
"",
"",
"  Preview",
"",
"",
"  Sort",
"",
"",
"  Redraw",
"",
"",
"-------",
"  None",
"",
"",
"  Iconify",
"",
"",
"  Back",
"",
"",
"  Close",
"",
""};

static LONG rs_frstr[] = {
0};

static BITBLK rs_bitblk[] = {
0};

static LONG rs_frimg[] = {
0};

static ICONBLK rs_iconblk[] = {
0};

static TEDINFO rs_tedinfo[] = {
(char *)1L, (char *)2L, (char *)3L, 5, 0, 2, 0x1100, 0x0, -1, 5,1,
(char *)4L, (char *)5L, (char *)6L, 5, 0, 2, 0x1100, 0x0, -1, 5,1,
(char *)7L, (char *)8L, (char *)9L, 5, 0, 2, 0x1100, 0x0, -1, 5,1,
(char *)10L, (char *)11L, (char *)12L, 5, 0, 2, 0x1180, 0x0, -1, 8,1,
(char *)13L, (char *)14L, (char *)15L, 5, 0, 0, 0x1180, 0x0, 0, 1,1,
(char *)16L, (char *)17L, (char *)18L, 5, 0, 2, 0x1180, 0x0, 1, 4,1,
(char *)19L, (char *)20L, (char *)21L, 5, 0, 2, 0x1180, 0x0, 1, 6,1,
(char *)22L, (char *)23L, (char *)24L, 5, 0, 2, 0x1180, 0x0, 1, 8,1,
(char *)25L, (char *)26L, (char *)27L, 5, 0, 2, 0x1180, 0x0, 1, 10,1,
(char *)28L, (char *)29L, (char *)30L, 5, 0, 2, 0x1180, 0x0, 1, 8,1,
(char *)31L, (char *)32L, (char *)33L, 5, 0, 2, 0x1180, 0x0, 1, 7,1,
(char *)34L, (char *)35L, (char *)36L, 5, 0, 2, 0x1180, 0x0, 1, 7,1,
(char *)37L, (char *)38L, (char *)39L, 3, 0, 2, 0x1180, 0x0, -1, 4,4,
(char *)41L, (char *)42L, (char *)43L, 5, 0, 2, 0x1100, 0x0, 0, 5,1,
(char *)44L, (char *)45L, (char *)46L, 3, 0, 2, 0x1180, 0x0, -1, 5,1,
(char *)47L, (char *)48L, (char *)49L, 5, 0, 2, 0x1100, 0x0, -1, 6,1,
(char *)50L, (char *)51L, (char *)52L, 5, 0, 2, 0x1180, 0x0, -1, 1,1,
(char *)53L, (char *)54L, (char *)55L, 5, 0, 2, 0x1180, 0x0, -1, 5,1,
(char *)57L, (char *)58L, (char *)59L, 5, 0, 2, 0x1180, 0x0, -3, 13,1,
(char *)60L, (char *)61L, (char *)62L, 5, 0, 2, 0x1180, 0x0, -1, 6,1,
(char *)63L, (char *)64L, (char *)65L, 5, 0, 2, 0x1180, 0x0, -1, 6,1,
(char *)66L, (char *)67L, (char *)68L, 5, 0, 2, 0x2280, 0x0, -1, 4,1,
(char *)69L, (char *)70L, (char *)71L, 5, 0, 2, 0x3380, 0x0, -1, 6,1,
(char *)72L, (char *)73L, (char *)74L, 5, 0, 2, 0x4480, 0x0, -1, 5,1,
(char *)75L, (char *)76L, (char *)77L, 5, 0, 2, 0x5580, 0x0, -1, 5,1,
(char *)78L, (char *)79L, (char *)80L, 5, 0, 2, 0x6680, 0x0, -1, 7,1,
(char *)81L, (char *)82L, (char *)83L, 5, 0, 2, 0x7780, 0x0, -1, 8,1,
(char *)84L, (char *)85L, (char *)86L, 5, 0, 2, 0x8880, 0x0, -1, 8,1,
(char *)87L, (char *)88L, (char *)89L, 5, 0, 2, 0x9980, 0x0, -1, 8,1,
(char *)90L, (char *)91L, (char *)92L, 5, 0, 2, 0xAA80, 0x0, -1, 6,1,
(char *)93L, (char *)94L, (char *)95L, 5, 0, 2, 0xBB80, 0x0, -1, 8,1,
(char *)96L, (char *)97L, (char *)98L, 5, 0, 2, 0xCC80, 0x0, -1, 7,1,
(char *)99L, (char *)100L, (char *)101L, 5, 0, 2, 0xDD80, 0x0, -1, 7,1,
(char *)102L, (char *)103L, (char *)104L, 5, 0, 2, 0xEE80, 0x0, -1, 9,1,
(char *)105L, (char *)106L, (char *)107L, 5, 0, 2, 0xFF80, 0x0, -1, 10,1,
(char *)108L, (char *)109L, (char *)110L, 5, 0, 0, 0x1180, 0x0, -1, 10,1,
(char *)111L, (char *)112L, (char *)113L, 5, 0, 0, 0x1180, 0x0, -1, 7,1,
(char *)114L, (char *)115L, (char *)116L, 5, 0, 0, 0x1180, 0x0, -1, 9,1,
(char *)118L, (char *)119L, (char *)120L, 5, 0, 0, 0x1180, 0x0, -1, 7,1,
(char *)121L, (char *)122L, (char *)123L, 5, 0, 0, 0x1180, 0x0, -1, 10,1,
(char *)124L, (char *)125L, (char *)126L, 5, 0, 0, 0x1180, 0x0, -1, 7,1,
(char *)127L, (char *)128L, (char *)129L, 5, 0, 0, 0x1180, 0x0, -1, 8,1};

static OBJECT rs_object[] = {
-1, 1, 4, G_BOX, NONE, OUTLINED, CAST 0x21101L, 0,0, 56,19,
2, -1, -1, (0x9<<8)+G_IBOX, SELECTABLE, NORMAL, CAST 0x57011100L, 54,0, 2,1,
3, -1, -1, G_STRING, 0x400, NORMAL, CAST 0x0L, 2,1, 1,1,
4, -1, -1, (0x4<<8)+G_BOX, NONE, NORMAL, CAST 0x11100L, 1,2, 54,256,
0, 5, 61, G_IBOX, NONE, NORMAL, CAST 0x1101L, 0,2, 55,16,
6, -1, -1, G_TEXT, NONE, NORMAL, CAST 0x0L, 2,0, 34,1,
7, -1, -1, G_TEXT, NONE, NORMAL, CAST 0x1L, 38,0, 16,1,
9, 8, 8, G_BOXCHAR, NONE, NORMAL, CAST 0xFF1100L, 2,1, 32,7,
7, -1, -1, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1101L, 0,0, 32,7,
10, -1, -1, (0x11<<8)+G_IBOX, TOUCHEXIT, DISABLED|OUTLINED, CAST 0x1FF1180L, 34,1, 2,1,
12, 11, 11, G_BOXCHAR, NONE, NORMAL, CAST 0xFF1170L, 38,1, 14,5,
10, -1, -1, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1101L, 0,0, 14,5,
13, -1, -1, (0x11<<8)+G_IBOX, TOUCHEXIT, DISABLED|OUTLINED, CAST 0x1FF1180L, 52,1, 2,1,
15, 14, 14, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1111L, 34,2, 2,5,
13, -1, -1, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1100L, 0,0, 2,1,
17, 16, 16, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1111L, 52,2, 2,3,
15, -1, -1, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1100L, 0,0, 2,1,
18, -1, -1, (0x12<<8)+G_IBOX, TOUCHEXIT, OUTLINED, CAST 0x2FF1180L, 52,5, 2,1,
19, -1, -1, G_TEXT, NONE, NORMAL, CAST 0x2L, 47,6, 7,1,
20, -1, -1, (0x12<<8)+G_IBOX, TOUCHEXIT, OUTLINED, CAST 0x2FF1180L, 34,7, 2,1,
22, 21, 21, G_BOXTEXT, TOUCHEXIT, SHADOWED, CAST 0x3L, 38,7, 7,1,
20, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x70011100L, 2,0, 1536,1,
24, 23, 23, G_BOXCHAR, NONE, NORMAL, CAST 0xFF1170L, 47,7, 5,5,
22, -1, -1, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1101L, 0,0, 5,5,
25, -1, -1, (0x11<<8)+G_IBOX, TOUCHEXIT, DISABLED|OUTLINED, CAST 0x1FF1180L, 52,7, 2,1,
26, -1, -1, G_BOXTEXT, 0x400, NORMAL, CAST 0x4L, 2,8, 34,1,
28, 27, 27, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1111L, 52,8, 2,3,
26, -1, -1, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1100L, 0,0, 2,1,
30, 29, 29, G_BOX, NONE, NORMAL, CAST 0xFF1101L, 2,9, 43,4,
28, -1, -1, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1101L, 0,0, 43,4,
31, -1, -1, (0x12<<8)+G_IBOX, TOUCHEXIT, OUTLINED, CAST 0x2FF1180L, 52,11, 2,1,
46, 32, 44, G_IBOX, NONE, NORMAL, CAST 0x1100L, 2,13, 44,1,
34, 33, 33, G_BOXTEXT, SELECTABLE, NORMAL, CAST 0x5L, 0,0, 262,1,
32, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x46011100L, 1793,0, 1536,1,
36, 35, 35, G_BOXTEXT, SELECTABLE, NORMAL, CAST 0x6L, 6,0, 262,1,
34, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x67011100L, 1282,0, 1536,1,
38, 37, 37, G_BOXTEXT, SELECTABLE, NORMAL, CAST 0x7L, 12,0, 262,1,
36, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x49011100L, 768,0, 1536,1,
40, 39, 39, G_BOXTEXT, SELECTABLE, NORMAL, CAST 0x8L, 18,0, 263,1,
38, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x55011100L, 256,0, 1536,1,
42, 41, 41, G_BOXTEXT, SELECTABLE, NORMAL, CAST 0x9L, 25,0, 262,1,
40, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x74011100L, 1793,0, 1536,1,
44, 43, 43, G_BOXTEXT, SELECTABLE, NORMAL, CAST 0xAL, 31,0, 262,1,
42, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x68011100L, 2,0, 1536,1,
31, 45, 45, G_BOXTEXT, SELECTABLE, NORMAL, CAST 0xBL, 37,0, 262,1,
44, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x76011100L, 514,0, 1536,1,
47, -1, -1, G_FBOXTEXT, EDITABLE, NORMAL, CAST 0xCL, 47,13, 4,1,
48, -1, -1, G_STRING, NONE, NORMAL, CAST 0x28L, 52,13, 3,1,
54, 49, 53, G_IBOX, NONE, NORMAL, CAST 0x1100L, 9,14, 17,2,
50, -1, -1, G_TEXT, NONE, NORMAL, CAST 0xDL, 1,0, 15,1,
51, -1, -1, (0xF<<8)+G_IBOX, TOUCHEXIT, OUTLINED, CAST 0x57011100L, 1,1, 2,1,
53, 52, 52, G_BOX, TOUCHEXIT, NORMAL, CAST 0xFF1141L, 3,1, 11,1,
51, -1, -1, G_BOXTEXT, TOUCHEXIT, NORMAL, CAST 0xEL, 3,0, 5,1,
48, -1, -1, (0x10<<8)+G_IBOX, TOUCHEXIT, OUTLINED, CAST 0x57011100L, 14,1, 2,1,
58, 55, 57, G_IBOX, NONE, NORMAL, CAST 0x1100L, 27,14, 9,2,
57, 56, 56, G_TEXT, TOUCHEXIT, NORMAL, CAST 0xFL, 0,0, 9,1,
55, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x6C011100L, 1282,0, 1536,1,
54, -1, -1, G_BOXTEXT, TOUCHEXIT, SHADOWED, CAST 0x10L, 0,1, 9,1,
59, -1, -1, (0xC<<8)+G_BOXTEXT, SELECTABLE|EXIT, OUTLINED|SHADOWED, CAST 0x11L, 2,15, 6,1,
61, 60, 60, (0x13<<8)+G_BUTTON, SELECTABLE|EXIT|0x600, NORMAL, CAST 0x38L, 38,15, 7,1,
59, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x43011100L, 3,0, 1,1,
4, 62, 62, G_BOXTEXT, SELECTABLE|DEFAULT|EXIT|0x600, NORMAL, CAST 0x12L, 44,15, 10,1,
61, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, CAST 0x70011100L, 1,0, 1536,1,
-1, 1, 16, G_BOX, NONE, SHADOWED, CAST 0xFF1100L, 0,0, 9,16,
2, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x13L, 0,0, 9,1,
3, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x14L, 0,1, 9,1,
4, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x15L, 0,2, 9,1,
5, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x16L, 0,3, 9,1,
6, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x17L, 0,4, 9,1,
7, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x18L, 0,5, 9,1,
8, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x19L, 0,6, 9,1,
9, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x1AL, 0,7, 9,1,
10, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x1BL, 0,8, 9,1,
11, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x1CL, 0,9, 9,1,
12, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x1DL, 0,10, 9,1,
13, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x1EL, 0,11, 9,1,
14, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x1FL, 0,12, 9,1,
15, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x20L, 0,13, 9,1,
16, -1, -1, G_TEXT, SELECTABLE, NORMAL, CAST 0x21L, 0,14, 9,1,
0, -1, -1, G_TEXT, SELECTABLE|LASTOB, NORMAL, CAST 0x22L, 0,15, 9,1,
-1, 1, 14, G_BOX, NONE, SHADOWED, CAST 0xFF1100L, 0,0, 7,8,
3, 2, 2, G_TEXT, SELECTABLE, CHECKED, CAST 0x23L, 0,0, 7,1,
1, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x50011100L, 2,0, 1,1,
5, 4, 4, G_TEXT, SELECTABLE, NORMAL, CAST 0x24L, 0,1, 7,1,
3, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x53011100L, 2,0, 1,1,
7, 6, 6, G_TEXT, SELECTABLE, NORMAL, CAST 0x25L, 0,2, 7,1,
5, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x52011100L, 2,0, 1,1,
8, -1, -1, G_STRING, NONE, DISABLED, CAST 0x75L, 0,3, 7,1,
10, 9, 9, G_TEXT, SELECTABLE, NORMAL, CAST 0x26L, 0,4, 7,1,
8, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x4E011100L, 2,0, 1,1,
12, 11, 11, G_TEXT, SELECTABLE, NORMAL, CAST 0x27L, 0,5, 7,1,
10, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x49011100L, 2,0, 1,1,
14, 13, 13, G_TEXT, SELECTABLE, NORMAL, CAST 0x28L, 0,6, 7,1,
12, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, CAST 0x42011100L, 2,0, 1,1,
0, 15, 15, G_TEXT, SELECTABLE, NORMAL, CAST 0x29L, 0,7, 7,1,
14, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, CAST 0x43011100L, 2,0, 1,1};

static LONG rs_trindex[] = {
0L,
63L,
80L};

static struct foobar {
	WORD 	dummy;
	WORD 	*image;
	} rs_imdope[] = {
0};

#define NUM_STRINGS 130
#define NUM_USERDEFS 0
#define NUM_FRSTR 0
#define NUM_IMAGES 0
#define NUM_BB 0
#define NUM_FRIMG 0
#define NUM_IB 0
#define NUM_CIB 0
#define NUM_TI 42
#define NUM_OBS 96
#define NUM_TREE 3

