
/* benutzerdefinierte Mausformen */
MFORM mouse_v = {7,7,1,BLACK,WHITE,
{ 0x0180, 0x03C0, 0x07E0, 0x0FF0, 0x07E0, 0x03C0, 0x03C0, 0x03C0,
  0x03C0, 0x03C0, 0x03C0, 0x07E0, 0x0FF0, 0x07E0, 0x03C0, 0x0180 },
{ 0x0000, 0x0180, 0x03C0, 0x05A0, 0x0180, 0x0180, 0x0180, 0x0180,
  0x0180, 0x0180, 0x0180, 0x0180, 0x05A0, 0x03C0, 0x0180, 0x0000 }};

MFORM mouse_h = {7,7,1,BLACK,WHITE,
{ 0x0000, 0x0000, 0x0000, 0x0000, 0x1008, 0x381C, 0x7FFE, 0xFFFF,
  0xFFFF, 0x7FFE, 0x381C, 0x1008, 0x0000, 0x0000, 0x0000, 0x0000 },
{ 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x1008, 0x2004, 0x7FFE,
  0x7FFE, 0x2004, 0x1008, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000 }};

MFORM mouse_vh = {7,7,1,BLACK,WHITE,
{ 0x0180, 0x03C0, 0x07E0, 0x0FF0, 0x17E8, 0x3BDC, 0x7FFE, 0xFFFF,
  0xFFFF, 0x7FFE, 0x3BDC, 0x17E8, 0x0FF0, 0x07E0, 0x03C0, 0x0180 },
{ 0x0000, 0x0180, 0x03C0, 0x05A0, 0x0180, 0x1188, 0x2184, 0x7FFE,
  0x7FFE, 0x2184, 0x1188, 0x0180, 0x05A0, 0x03C0, 0x0180, 0x0000 }};

#ifndef SMALLTOOL
/* Icons f�r ikonifizierte Darstellung */
static int IMAGE0[] = {
0x0000, 0x0000, 0x0FFF, 0xFE00, 0x0800, 0x0300, 0x0800, 0x0280, 
0x0800, 0x0240, 0x0B79, 0xC220, 0x0800, 0x03F0, 0x0BAF, 0x5810, 
0x0800, 0x0010, 0x0BDD, 0x7B10, 0x0800, 0x0010, 0x0B7B, 0x7A10, 
0x0800, 0x0010, 0x0B5E, 0xBA10, 0x0800, 0x0010, 0x0A00, 0x0010, 
0x0BDB, 0x8010, 0x0800, 0x0010, 0x0800, 0x0010, 0x0800, 0x0010, 
0x0800, 0x0010, 0x0BD3, 0x8010, 0x0800, 0x0010, 0x0AF5, 0xE010, 
0x0800, 0x0010, 0x0BA3, 0x8010, 0x0800, 0x0010, 0x0800, 0x0010, 
0x0800, 0x0010, 0x0800, 0x0010, 0x0FFF, 0xFFF0, 0x0000, 0x0000};

static int IMAGE1[] = {
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0FC0, 
0x0000, 0x1020, 0x0FFF, 0xF030, 0x1000, 0x1FE8, 0x2000, 0x0004, 
0x2000, 0x0006, 0x2000, 0x0006, 0x2000, 0x0006, 0x2000, 0x0016, 
0x2000, 0x0066, 0x2000, 0x0186, 0x2000, 0x0616, 0x2000, 0x1876, 
0x2000, 0x61A6, 0x2001, 0x8756, 0x2006, 0x1AA6, 0x200A, 0x7576, 
0x2011, 0xABF6, 0x2021, 0x57F6, 0x2040, 0xBFC6, 0x20C0, 0xFF06, 
0x21CD, 0xFC06, 0x23E6, 0xF006, 0x27FF, 0xC006, 0x1000, 0x000E, 
0x0FFF, 0xFFFC, 0x07FF, 0xFFF8, 0x0000, 0x0000, 0x0000, 0x0000};

static int IMAGE2[] = {
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x7FFF, 0xFFFC, 
0x4000, 0x0006, 0x5555, 0x5556, 0x4000, 0x0006, 0x7FFF, 0xFFFE, 
0x4030, 0x0006, 0x4030, 0x0006, 0x4079, 0xF006, 0x407B, 0xF806, 
0x4030, 0x7C06, 0x4078, 0x3E06, 0x4078, 0x1F06, 0x40CC, 0x2F86, 
0x40CC, 0x47C6, 0x41B6, 0x8BC6, 0x4FFF, 0x11F6, 0x4332, 0x2066, 
0x4304, 0x4046, 0x4608, 0x8006, 0x461F, 0x8006, 0x4C3E, 0xC006, 
0x4C7C, 0xC006, 0x58F8, 0x6006, 0x79F0, 0x7006, 0x73E0, 0x3006, 
0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE, 0x0000, 0x0000, 0x0000, 0x0000};

static BITBLK rs_bitblk[] = {{IMAGE0,4,32,0,0,1},{IMAGE1,4,32,0,0,1},{IMAGE2,4,32,0,0,1}};

OBJECT icon[] = {
	{ -1, 1, 1, G_BOX, NONE, NORMAL, (long)(0x1100L), 0,0, 8,4 },
	{ 0, -1, -1, G_IMAGE, LASTOB, NORMAL, (long)(&rs_bitblk[0]), 2,1, 4,2 },
	{ -1, 1, 1, G_BOX, NONE, NORMAL, (long)(0x1100L), 0,0, 8,4 },
	{ 0, -1, -1, G_IMAGE, LASTOB, NORMAL, (long)(&rs_bitblk[2]), 2,1, 4,2 },
	{ -1, 1, 1, G_BOX, NONE, NORMAL, (long)(0x1100L), 0,0, 8,4 },
	{ 0, -1, -1, G_IMAGE, LASTOB, NORMAL, (long)(&rs_bitblk[1]), 2,1, 4,2 }};
#endif
