#define T0OBJ 0
#define T1OBJ 15
#define T2OBJ 31
#define T3OBJ 33
#define FREEBB 6
#define FREEIMG 6
#define FREESTR 27

char *rs_strings[] = {
" File",
"I",
"",
"",
"PreView",
"",
"",
"  Open...    ^O",
"--",
"  Save       ^S",
"  Save as... ^M",
"--",
"  Create pal.",
"  Delete pal.",
"--",
"  Quit       ^Q",
"Create font-palette...",
"Font-Options",
"Bitmap",
"proportional",
"Vector",
"monospaced",
"  1999",
"Size: ___ - ___ pts",
"9",
"Cancel",
"Ok"};

USERBLK rs_userblks[] = {
0};


int  IMAG0[] = {
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0xE180, 
0x0, 0x3, 0x1E60, 0x0, 
0xC, 0xC18, 0x0, 0x30, 
0x306, 0x0, 0xC0, 0xC1, 
0x8000, 0x300, 0x20, 0x6000, 
0xC00, 0x18, 0x1800, 0x800, 
0x4, 0x400, 0x400, 0x6, 
0x1A00, 0x300, 0x18, 0x6200, 
0x180, 0x61, 0x8600, 0x1C0, 
0x186, 0x1E00, 0x1E0, 0x618, 
0x7600, 0x1D8, 0x861, 0xCE00, 
0x1B4, 0x3987, 0x3200, 0x1DE, 
0xD61C, 0xC600, 0x1B7, 0x6873, 
0x1E00, 0x1ED, 0xDDCC, 0x6600, 
0x1BB, 0x7731, 0x8E00, 0x1D6, 
0xDCC6, 0x3200, 0xEB, 0xB718, 
0xC600, 0x75, 0x6C63, 0x1800, 
0x6E, 0xB98C, 0x6000, 0x1B, 
0x5631, 0x8000, 0x6, 0xE8C6, 
0x0, 0x1, 0xB318, 0x0, 
0x0, 0x6C60, 0x0, 0x0, 
0x1980, 0x0, 0x0, 0x600, 
0x0, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG1[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x0, 
0x0, 0x0, 0x7F, 0xFFFF, 
0xFC00, 0x54, 0x0, 0x6C00, 
0x6D, 0x5555, 0x5600, 0x54, 
0x0, 0x6E00, 0x7F, 0xFFFF, 
0xFE00, 0x40, 0x0, 0x5600, 
0x5F, 0xBE4E, 0x6E00, 0x40, 
0x0, 0x4600, 0x5C, 0xF67E, 
0x7E00, 0x40, 0x0, 0x4600, 
0x5F, 0xB3CE, 0x4600, 0x40, 
0x0, 0x4600, 0x5D, 0xDEEE, 
0x4600, 0x40, 0x0, 0x4600, 
0x5C, 0xEEFE, 0x4600, 0x40, 
0x0, 0x4600, 0x5E, 0xF7BE, 
0x7E00, 0x40, 0x0, 0x4600, 
0x5C, 0xEEFA, 0x6E00, 0x40, 
0x0, 0x5600, 0x40, 0x0, 
0x7E00, 0x7F, 0xFFFF, 0x8600, 
0x54, 0xA, 0xBE00, 0x64, 
0x9, 0xB600, 0x54, 0xA, 
0xAE00, 0x7F, 0xFFFF, 0xFE00, 
0x1F, 0xFFFF, 0xFE00, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG2[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x3, 0xFFFE, 0x0, 
0x2, 0x2, 0x0, 0xF, 
0xFFC3, 0xFF00, 0x8, 0x40, 
0x100, 0x3F, 0xF87F, 0xFD00, 
0x20, 0x800, 0x500, 0xFE, 
0xFFF, 0xF500, 0x82, 0x0, 
0x1500, 0x83, 0xFFFF, 0xD500, 
0x80, 0x0, 0x5500, 0x80, 
0x0, 0x5500, 0x9D, 0x13FA, 
0x5500, 0x80, 0x0, 0x5500, 
0x96, 0xF77E, 0x5500, 0x80, 
0x0, 0x5500, 0x9D, 0x7DCE, 
0x5500, 0x80, 0x0, 0x5500, 
0x95, 0xEBBA, 0x5700, 0x80, 
0x0, 0x5600, 0x9B, 0xDBF6, 
0x5D00, 0x80, 0x0, 0x5A00, 
0x95, 0x7B6E, 0x7500, 0x80, 
0x0, 0x6A00, 0xFF, 0xFFFF, 
0xD400, 0xAA, 0xAAAA, 0xA800, 
0x55, 0x5555, 0x5000, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG3[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x1, 0xF000, 0x0, 0x3F, 
0x1F80, 0x0, 0xE3, 0x18E0, 
0x0, 0x100, 0x10, 0x0, 
0x1E0, 0xF0, 0x0, 0xBF, 
0xFFA0, 0x0, 0x80, 0x20, 
0x0, 0xA2, 0x1120, 0x0, 
0xA2, 0x1120, 0x0, 0xA2, 
0x1120, 0x0, 0xA2, 0x1120, 
0x0, 0xA2, 0x1120, 0x0, 
0xA2, 0x4520, 0x0, 0xA2, 
0x6D20, 0x0, 0xA2, 0x3920, 
0x0, 0xA2, 0x1120, 0x0, 
0xA2, 0x1120, 0x0, 0xA2, 
0x1120, 0x0, 0xA2, 0x1120, 
0x0, 0xA2, 0x1120, 0x0, 
0xA2, 0x1120, 0x0, 0xB2, 
0x1320, 0x0, 0xC3, 0x3060, 
0x0, 0x70, 0x1C0, 0x0, 
0x1F, 0xFF00, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG4[] = {
0xFFFF, 0xFFFF, 0xFFFF, 0x0, 
0x0, 0x0, 0x0, 0x7E00, 
0x0, 0x1, 0xFF80, 0x0, 
0xFFF, 0xFFFF, 0xC000, 0x80F, 
0xFFE0, 0x4000, 0x81F, 0xFFE0, 
0x4000, 0x81F, 0x87F0, 0x4000, 
0x81F, 0x3F0, 0x4000, 0x80E, 
0x1F0, 0x4000, 0x800, 0x1F0, 
0x4000, 0x800, 0x1F0, 0x4000, 
0x800, 0x3E0, 0x4000, 0x800, 
0x7E0, 0x4000, 0x800, 0xFC0, 
0x4000, 0x800, 0x1F80, 0x4000, 
0x800, 0x3F00, 0x4000, 0x800, 
0x3E00, 0x4000, 0x800, 0x7E00, 
0x4000, 0x800, 0x7C00, 0x4000, 
0x800, 0x7C00, 0x4000, 0x800, 
0x7C00, 0x4000, 0x800, 0x0, 
0x4000, 0x800, 0x0, 0x4000, 
0x800, 0x3800, 0x4000, 0x800, 
0x7C00, 0x4000, 0x800, 0x7C00, 
0x4000, 0xFFF, 0x39FF, 0xC000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0xFFFF, 0xFFFF, 
0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF};

int  IMAG5[] = {
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0xFFFF, 0xFFFE, 
0x8000, 0x3, 0x807F, 0xC403, 
0x801E, 0x2003, 0x801E, 0x2403, 
0x801F, 0xC003, 0x803F, 0x403, 
0x803F, 0x3, 0x8067, 0x8543, 
0x8067, 0x8003, 0x80CB, 0xC043, 
0x80C3, 0xC003, 0x8189, 0xE043, 
0x8181, 0xE003, 0xABFF, 0xF553, 
0x83FF, 0xF003, 0x8608, 0x7803, 
0x8600, 0x7803, 0x8C08, 0x3C03, 
0xCC00, 0x3CFF, 0xB808, 0x1F47, 
0xBC00, 0x3F4E, 0xFF08, 0xFFDC, 
0x8000, 0x78, 0xFFFF, 0xFFF0, 
0x7FFF, 0xFFE0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0};

LONG rs_frstr[] = {
0};

BITBLK rs_bitblk[] = {
(WORD *)0L, 6, 32, 0, 0, 1,
(WORD *)1L, 6, 32, 0, 0, 1,
(WORD *)2L, 6, 32, 0, 0, 1,
(WORD *)3L, 6, 32, 0, 0, 1,
(WORD *)4L, 6, 32, 0, 0, 1,
(WORD *)5L, 4, 32, 0, 0, 1};

LONG rs_frimg[] = {
0};

ICONBLK rs_iconblk[] = {
0};

CICONBLK rs_ciconblk[] = {
0};

TEDINFO rs_tedinfo[] = {
(char *)1L, (char *)2L, (char *)3L, 5, 0, 0, 0x1180, 0x0, 0, 2,1,
(char *)4L, (char *)5L, (char *)6L, 5, 0, 2, 0x1100, 0x0, -1, 8,1,
(char *)22L, (char *)23L, (char *)24L, 3, 0, 0, 0x1180, 0x0, -1, 7,20};

OBJECT rs_object[] = {
-1, 1, 14, G_BOX, NONE, NORMAL, 0xFE1100L, 0,0, 49,17,
5, 2, 4, G_BOX, NONE, NORMAL, 0xFF1101L, 0,256, 48,769,
4, 3, 3, G_STRING, TOUCHEXIT, NORMAL, 0x0L, 1,512, 6,257,
2, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x46011100L, 1,0, 1,1,
1, -1, -1, G_BOXTEXT, NONE, NORMAL, 0x0L, 9,0, 39,769,
14, 6, 12, G_BOX, 0x400, NORMAL, 0xFE1101L, 0,2, 6,14,
7, -1, -1, G_IMAGE, 0x5, NORMAL, 0x0L, 0,0, 12288,8192,
8, -1, -1, G_IMAGE, 0x5, NORMAL, 0x1L, 0,2, 12288,8192,
9, -1, -1, G_IMAGE, 0x5, NORMAL, 0x2L, 0,4, 12288,8192,
10, -1, -1, G_IMAGE, 0x5, NORMAL, 0x3L, 0,6, 12288,8192,
11, -1, -1, (0xC<<8)+G_IMAGE, 0x5, NORMAL, 0x4L, 0,8, 12288,8192,
12, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, SELECTED, 0x57011100L, 2,11, 2,1,
5, 13, 13, G_TEXT, NONE, NORMAL, 0x1L, 0,12, 518,1,
12, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x50011100L, 1024,0, 1536,1,
0, -1, -1, G_BOX, 0x60, NORMAL, 0xFF1101L, 7,2, 41,11,
-1, 1, 14, G_BOX, NONE, SHADOWED, 0xFF1100L, 0,0, 16,9,
3, 2, 2, G_STRING, SELECTABLE, NORMAL, 0x7L, 0,0, 16,1,
1, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x4F011100L, 2,0, 1,1,
4, -1, -1, G_STRING, SELECTABLE, DISABLED, 0x8L, 0,1, 16,1,
6, 5, 5, G_STRING, SELECTABLE, NORMAL, 0x9L, 0,2, 16,1,
4, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x53011100L, 2,0, 1,1,
8, 7, 7, G_STRING, SELECTABLE, NORMAL, 0xAL, 0,3, 16,1,
6, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x76011100L, 4,0, 1,1,
9, -1, -1, G_STRING, SELECTABLE, DISABLED, 0xBL, 0,4, 16,1,
11, 10, 10, G_STRING, SELECTABLE, NORMAL, 0xCL, 0,5, 16,1,
9, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x43011100L, 2,0, 1,1,
13, 12, 12, G_STRING, SELECTABLE, NORMAL, 0xDL, 0,6, 16,1,
11, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x44011100L, 2,0, 1,1,
14, -1, -1, G_STRING, SELECTABLE, DISABLED, 0xEL, 0,7, 16,1,
0, 15, 15, G_STRING, SELECTABLE, NORMAL, 0xFL, 0,8, 16,1,
14, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, 0x51011100L, 2,0, 1,1,
-1, 1, 1, G_BOX, NONE, NORMAL, 0x1100L, 0,0, 6,4,
0, -1, -1, G_IMAGE, LASTOB, NORMAL, 0x5L, 1,1, 8192,8192,
-1, 1, 21, G_BOX, NONE, OUTLINED, 0x21100L, 0,0, 38,13,
2, -1, -1, (0x9<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 36,0, 2,1,
3, -1, -1, G_STRING, NONE, NORMAL, 0x10L, 2,1, 22,1,
4, -1, -1, (0x4<<8)+G_IBOX, NONE, NORMAL, 0x11100L, 1,2, 24,1,
19, 5, 18, G_BOX, NONE, DRAW3D, 0x11100L, 2,4, 34,6,
6, -1, -1, (0x2<<8)+G_BUTTON, NONE, DRAW3D, 0x11L, 1,0, 14,1,
7, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, SELECTED, 0x57011100L, 2,1, 2,1,
9, 8, 8, G_STRING, NONE, NORMAL, 0x12L, 5,1, 6,1,
7, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x42011100L, 0,0, 1,1,
10, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, SELECTED, 0x57011100L, 17,1, 2,1,
12, 11, 11, G_STRING, NONE, NORMAL, 0x13L, 20,1, 12,1,
10, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x70011100L, 0,0, 1,1,
13, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, SELECTED, 0x57011100L, 2,2, 2,1,
15, 14, 14, G_STRING, NONE, NORMAL, 0x14L, 5,2, 6,1,
13, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x56011100L, 0,0, 1,1,
16, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, SELECTED, 0x57011100L, 17,2, 2,1,
18, 17, 17, G_STRING, NONE, NORMAL, 0x15L, 20,2, 10,1,
16, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x6D011100L, 0,0, 1,1,
4, -1, -1, G_FTEXT, 0x408, NORMAL, 0x2L, 2,4, 19,1,
21, 20, 20, (0x13<<8)+G_BUTTON, 0x605, NORMAL, 0x19L, 16,11, 9,1,
19, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x43011100L, 1025,0, 1,1,
0, 22, 22, G_BUTTON, 0x607, NORMAL, 0x1AL, 27,11, 9,1,
21, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, 0x6F011100L, 1027,0, 1,1};

LONG rs_trindex[] = {
0L,
15L,
31L,
33L};

struct foobar {
	WORD 	dummy;
	WORD 	*image;
	} rs_imdope[] = {
0, &IMAG0[0],
0, &IMAG1[0],
0, &IMAG2[0],
0, &IMAG3[0],
0, &IMAG4[0],
0, &IMAG5[0]};

#define NUM_STRINGS 27
#define NUM_USERDEFS 0
#define NUM_FRSTR 0
#define NUM_IMAGES 6
#define NUM_BB 6
#define NUM_FRIMG 0
#define NUM_IB 0
#define NUM_CIB 0
#define NUM_TI 3
#define NUM_OBS 56
#define NUM_TREE 4

int rs_numstrings = NUM_STRINGS;
int rs_nuser = NUM_USERDEFS;
int rs_numfrstr = NUM_FRSTR;
int rs_numimages = NUM_IMAGES;
int rs_numbb = NUM_BB;
int rs_numfrimg = NUM_FRIMG;
int rs_numib = NUM_IB;
int rs_numcib = NUM_CIB;
int rs_numti = NUM_TI;
int rs_numobs = NUM_OBS;
int rs_numtree = NUM_TREE;

char pname[] = "FONT_RSC.RSC";

int _rsc_format = 1;
