/* resource set indices for EXAMPLE */

#define POP        0 /* form/dialog */
#define POPI1      1 /* STRING in tree POP */
#define POPI2      3 /* STRING in tree POP */
#define POPI3      5 /* STRING in tree POP */
#define POPI4      7 /* STRING in tree POP */
#define POPI5      8 /* STRING in tree POP */
#define POPI6     10 /* STRING in tree POP */

#define DIALOG     1 /* form/dialog */
#define POPINFO    8 /* TEXT in tree DIALOG */
#define POPBTN    10 /* BOXTEXT in tree DIALOG */
#define POPCYCLE  11 /* BOX in tree DIALOG */
#define DATEI     12 /* FTEXT in tree DIALOG */
#define PFAD      14 /* FTEXT in tree DIALOG */
#define HELP      42 /* BOXTEXT in tree DIALOG */
#define CANCEL    43 /* BUTTON in tree DIALOG */
#define SEARCH    45 /* BUTTON in tree DIALOG */

#define TEXTDIAL   2 /* form/dialog */

#define MENU       3 /* menu */
#define INFOBOX   10 /* STRING in tree MENU */
#define QUIT      19 /* STRING in tree MENU */
#define CLOSE     21 /* STRING in tree MENU */
#define CYCLE     22 /* STRING in tree MENU */
#define ATTRMENU  24 /* STRING in tree MENU */
#define EDITMENU  25 /* STRING in tree MENU */
#define TITLMENU  26 /* STRING in tree MENU */
#define ALRTMENU  28 /* STRING in tree MENU */
#define XACCMENU  30 /* STRING in tree MENU */
#define FLYMENU   32 /* STRING in tree MENU */
#define WINMENU   33 /* STRING in tree MENU */
#define MODMENU   34 /* STRING in tree MENU */
#define HELPMENU  36 /* STRING in tree MENU */

#define INFODIAL   4 /* free form */
#define DATE       3 /* TEXT in tree INFODIAL */
#define VERS       9 /* TEXT in tree INFODIAL */

#define HELPDIAL   5 /* free form */
#define HELPUP     1 /* IBOX in tree HELPDIAL */
#define HELPPAR    2 /* BOX in tree HELPDIAL */
#define HELPSLID   3 /* BOX in tree HELPDIAL */
#define HELPDOWN   4 /* IBOX in tree HELPDIAL */
#define HELPVIEW   5 /* IBOX in tree HELPDIAL */

#define ALERTS     6 /* form/dialog */
#define BTNSCNTR   6 /* IBOX in tree ALERTS */
#define BTNSLEFT   9 /* IBOX in tree ALERTS */
#define BTNSRGHT  12 /* IBOX in tree ALERTS */
#define BTNWIDTH  15 /* IBOX in tree ALERTS */
#define NOALERT   19 /* IBOX in tree ALERTS */
#define DOALERT   20 /* BUTTON in tree ALERTS */
#define LEFT      24 /* IBOX in tree ALERTS */
#define PARENT    25 /* BOX in tree ALERTS */
#define SLIDE     26 /* BOXTEXT in tree ALERTS */
#define RIGHT     27 /* IBOX in tree ALERTS */

#define MAIN       7 /* form/dialog */
#define INFOBTN    5 /* BOXTEXT in tree MAIN */
#define TEXTBTN    7 /* BUTTON in tree MAIN */
#define EDITBTN    9 /* BUTTON in tree MAIN */
#define FRAMEBTN  11 /* BUTTON in tree MAIN */
#define ALERTBTN  13 /* BUTTON in tree MAIN */
#define XACCBTN   15 /* BUTTON in tree MAIN */
#define FLYBTN    17 /* BUTTON in tree MAIN */
#define WINBTN    19 /* BUTTON in tree MAIN */
#define MODALBTN  21 /* BUTTON in tree MAIN */

#define RAHMEN     8 /* form/dialog */

#define EDITDEMO   9 /* form/dialog */
#define EDIT1      4 /* FBOXTEXT in tree EDITDEMO */
#define EDIT2      5 /* FBOXTEXT in tree EDITDEMO */
#define EDIT3      6 /* FBOXTEXT in tree EDITDEMO */
#define EDIT4      7 /* FBOXTEXT in tree EDITDEMO */
#define EDIT5      8 /* FBOXTEXT in tree EDITDEMO */
#define EDIT6      9 /* FBOXTEXT in tree EDITDEMO */

#define EGEMICON  10 /* form/dialog */

#define ALERTICN  11 /* form/dialog */
#define USERICON   1 /* IMAGE in tree ALERTICN */

#define XACCDEMO  12 /* form/dialog */
#define XACCCNT    1 /* FBOXTEXT in tree XACCDEMO */
#define AVCNT      2 /* FBOXTEXT in tree XACCDEMO */
#define TIMEDEMO   4 /* TEXT in tree XACCDEMO */
#define AVSERVER   5 /* TEXT in tree XACCDEMO */

