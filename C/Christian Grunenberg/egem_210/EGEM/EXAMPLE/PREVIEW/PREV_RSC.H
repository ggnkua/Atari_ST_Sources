/* resource set indices for PREV_RSC */

#define PREVIEW    0 /* free form */
#define WDIAL      7 /* IBOX in tree PREVIEW */
#define FDIAL     10 /* IBOX in tree PREVIEW */
#define EGEMRSRC  13 /* IBOX in tree PREVIEW */
#define RESOURCE  16 /* FBOXTEXT in tree PREVIEW */
#define TREEDEC   18 /* BOXCHAR in tree PREVIEW */
#define TREE      19 /* BOXTEXT in tree PREVIEW */
#define TREEINC   20 /* BOXCHAR in tree PREVIEW */
#define TESTRSRC  21 /* BUTTON in tree PREVIEW */
#define TREECNT   23 /* FTEXT in tree PREVIEW */
#define LOADRSRC  24 /* BUTTON in tree PREVIEW */
#define EXITRSRC  26 /* BUTTON in tree PREVIEW */

