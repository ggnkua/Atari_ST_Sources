/* resource set indices for WIN_RSC */

#define DIALOG     0 /* free form */
#define ICON       7 /* IMAGE in tree DIALOG */
#define REALTIME   8 /* IBOX in tree DIALOG */
#define SLIDER    11 /* IBOX in tree DIALOG */
#define MOUSE     14 /* IBOX in tree DIALOG */
#define INVERS    17 /* IBOX in tree DIALOG */
#define FOLLOW    22 /* IBOX in tree DIALOG */
#define MONOFF    25 /* IBOX in tree DIALOG */
#define WROUND    28 /* IBOX in tree DIALOG */
#define COMPT     31 /* IBOX in tree DIALOG */
#define BOXES     34 /* IBOX in tree DIALOG */
#define PFAKTOR   37 /* BOX in tree DIALOG */
#define MAL2      39 /* IBOX in tree DIALOG */
#define MAL4      42 /* IBOX in tree DIALOG */
#define MAL8      45 /* IBOX in tree DIALOG */
#define MAL16     48 /* IBOX in tree DIALOG */
#define MALX      51 /* IBOX in tree DIALOG */
#define FAKTOR    52 /* FTEXT in tree DIALOG */
#define SONSTIGE  54 /* BOXTEXT in tree DIALOG */
#define CANCEL    56 /* BOXTEXT in tree DIALOG */
#define SET       58 /* BOXTEXT in tree DIALOG */
#define OKAY      60 /* BUTTON in tree DIALOG */

#define INFODIA    1 /* free form */
#define DATE       3 /* TEXT in tree INFODIA */
#define VERS      12 /* TEXT in tree INFODIA */

#define HELPDIA    2 /* free form */
#define HELPVIEW   5 /* IBOX in tree HELPDIA */
#define HELPUP     6 /* IBOX in tree HELPDIA */
#define HELPPAR    7 /* BOX in tree HELPDIA */
#define HELPSLID   8 /* BOX in tree HELPDIA */
#define HELPDOWN   9 /* IBOX in tree HELPDIA */
#define HELPOK    10 /* BUTTON in tree HELPDIA */

#define OPTIONEN   3 /* free form */
#define PDIALOG    5 /* BOX in tree OPTIONEN */
#define WIND       7 /* IBOX in tree OPTIONEN */
#define DIALWIN    8 /* STRING in tree OPTIONEN */
#define FLY       10 /* IBOX in tree OPTIONEN */
#define PZMODE    13 /* BOX in tree OPTIONEN */
#define SAUBER    15 /* IBOX in tree OPTIONEN */
#define STANDARD  18 /* IBOX in tree OPTIONEN */
#define PIXELPCK  21 /* IBOX in tree OPTIONEN */
#define INTERLV   24 /* IBOX in tree OPTIONEN */
#define LEFT      29 /* IBOX in tree OPTIONEN */
#define PARENT    30 /* BOX in tree OPTIONEN */
#define SLIDE     31 /* BOXTEXT in tree OPTIONEN */
#define RIGHT     32 /* IBOX in tree OPTIONEN */
#define HELP      33 /* BOXTEXT in tree OPTIONEN */
#define INFOBUT   34 /* BOXTEXT in tree OPTIONEN */
#define OPTSET    36 /* BOXTEXT in tree OPTIONEN */
#define OPTCANCL  38 /* BOXTEXT in tree OPTIONEN */
#define SAVE      40 /* BOXTEXT in tree OPTIONEN */
#define OPTOK     42 /* BUTTON in tree OPTIONEN */

#define MENU       4 /* menu */
#define INFOBOX    8 /* STRING in tree MENU */
#define SETUP     17 /* STRING in tree MENU */
#define QUIT      19 /* STRING in tree MENU */
#define OPEN      21 /* STRING in tree MENU */
#define CLOSE     22 /* STRING in tree MENU */
#define WECHSELN  24 /* STRING in tree MENU */

#define WINICON    5 /* form/dialog */

