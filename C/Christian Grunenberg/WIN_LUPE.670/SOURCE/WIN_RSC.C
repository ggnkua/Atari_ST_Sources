#define T0OBJ 0
#define T1OBJ 62
#define T2OBJ 82
#define T3OBJ 94
#define T4OBJ 138
#define T5OBJ 163
#define FREEBB 4
#define FREEIMG 4
#define FREESTR 143

char *rs_strings[] = {
"Setup",
"",
"",
"Freeware",
"",
"",
" Darstellung ",
"",
"",
"Echtzeitvergr”žerung",
"Echtzeitschieber",
"Mauszeiger mitvergr”žern",
"Inverse Darstellung",
" Optionen ",
"",
"",
"Mauszeiger folgen",
"Mauszeiger an-/ausschalten",
"Fenster abrunden",
"Kompatibilit„ts-Modus",
"Grow/Shrink-Boxen zeichnen",
" Vergr”žerung ",
"",
"",
"* 2",
"* 4",
"* 8",
"* 16",
"03",
"stufenloser Zoom (02 - 32) : __",
"9",
"Sonstiges",
"",
"",
"Abbruch",
"",
"",
"Setzen",
"",
"",
"OK",
"Information",
"",
"",
"",
"",
"",
"Faster Than Light",
"",
"",
"Die einzig wahre Lupe",
"",
"",
"(es kann nur eine geben ...)",
"",
"",
"gewidmet",
"",
"",
"Niemand",
"",
"",
"Version X.XX",
"",
"",
"von",
"",
"",
"Christian Grunenberg",
"",
"",
"Traminerweg 5 - 71717 Beilstein",
"",
"",
"E-Mail : Christian Grunenberg@S2  (MAUS)",
"",
"",
"Christian_Grunenberg@S2.maus.de (Usenet)",
"",
"",
"Ok",
"Hilfe",
"",
"",
"Ok",
"Sonstiges",
"",
"",
" Dialoge ",
"",
"",
"Window Dials",
"Flying Dials",
" Zoom-Modus ",
"",
"",
"VDI-Transform",
"Standard",
"Pixel-Packed",
"Interleaved",
" Frequenz ",
"",
"",
"-----",
"",
"",
" Help ",
"",
"",
"Informationen",
"",
"",
"Setzen",
"",
"",
"Abbruch",
"",
"",
"Sichern",
"",
"",
"OK",
" WINLUPE",
" Datei",
" Fenster",
"  Information ...  ^I",
"----------------------",
"  Desk Accessory 1  ",
"  Desk Accessory 2  ",
"  Desk Accessory 3  ",
"  Desk Accessory 4  ",
"  Desk Accessory 5  ",
"  Desk Accessory 6  ",
"  Setup ...  \007P",
"----------------",
"  Beenden    ^Q",
"  ™ffnen     ^O",
"  Schliežen  ^U",
"----------------",
"  Wechseln   ^W",
"WinLupe",
"",
""};

USERBLK rs_userblks[] = {
0};


int  IMAG0[] = {
0x0, 0x3FF, 0x8000, 0x0, 
0x0, 0x3FFF, 0xF000, 0x0, 
0x1, 0xFFFF, 0xFE00, 0x0, 
0x7, 0xFC00, 0x7F80, 0x0, 
0xF, 0xC000, 0xFE0, 0x0, 
0x1F, 0x1FC, 0x83F0, 0x0, 
0x78, 0x1FE0, 0x378, 0x0, 
0xF0, 0x7E00, 0x19E, 0x0, 
0x1E1, 0xE000, 0x187, 0x0, 
0x3C3, 0x8000, 0x183, 0x8000, 
0x78E, 0x0, 0xC1, 0xC000, 
0x71C, 0x78, 0xC0, 0xE000, 
0xE30, 0x9E, 0xC0, 0x6000, 
0x1E20, 0x7, 0x80CF, 0xF000, 
0x1C62, 0x1, 0xE3FF, 0xF000, 
0x1C44, 0x0, 0x7FFF, 0xF800, 
0x3884, 0x0, 0x7FFF, 0xF800, 
0x3882, 0x3, 0xFFFF, 0xF800, 
0x3803, 0xF, 0xFFFF, 0xFC00, 
0x7101, 0xC03F, 0xFFFF, 0xFFC0, 
0x7000, 0xF87F, 0xFFFF, 0xFFF0, 
0x7000, 0x3FFF, 0xFFFF, 0xFF18, 
0x7000, 0x7FF, 0xFFFF, 0xFF84, 
0x7000, 0xFFFF, 0xFFFF, 0xFFD0, 
0x7001, 0xE07F, 0xFFFF, 0xFFF0, 
0x7003, 0x3F, 0xFFFF, 0xFFE0, 
0x3802, 0x1F, 0xFFFF, 0xFF84, 
0x3802, 0x7, 0xFFFF, 0xFF38, 
0x3804, 0x3, 0xFFFF, 0xFFE0, 
0x1C08, 0x0, 0xFFFF, 0xFF80, 
0x1C00, 0x0, 0x3FFF, 0xF800, 
0x1C00, 0x0, 0x7FFF, 0xF000, 
0xE00, 0x0, 0xF7FF, 0xF000, 
0x600, 0x1, 0xE07F, 0xE000, 
0x700, 0x3, 0x80FF, 0xC000, 
0x380, 0x9F, 0xE3, 0x8000, 
0x1C0, 0x78, 0xE3, 0x8000, 
0xE0, 0x0, 0xEF, 0xC000, 
0x70, 0x0, 0xDF, 0xE000, 
0x18, 0x0, 0x1FF, 0xF000, 
0xE, 0x0, 0x3FF, 0xF800, 
0x7, 0xC000, 0xF9F, 0xFC00, 
0x1, 0xFE00, 0x7E0F, 0xFE00, 
0x0, 0x3FFF, 0xF007, 0xFF00, 
0x0, 0x3FF, 0x8003, 0xFF80, 
0x0, 0x0, 0x1, 0xFFC0, 
0x0, 0x11, 0x1C30, 0xFFE0, 
0x0, 0x1B, 0x1240, 0x7FF0, 
0x0, 0x15, 0x1C58, 0x3FF8, 
0x0, 0x11, 0x1048, 0x1FF8, 
0x0, 0x11, 0x5130, 0xFF8, 
0x0, 0x0, 0x0, 0x7F0, 
0x0, 0x0, 0x0, 0x3F0, 
0x0, 0x0, 0x0, 0x1C0, 
0x0, 0x0, 0x0, 0x0};

int  IMAG1[] = {
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x2, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x2, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x2, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x2, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x5, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x100, 0x0, 0x0, 0xB8, 
0xE800, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x5, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x4000, 
0x496F, 0xFFFF, 0xF0FF, 0xFC00, 
0xFF8E, 0x246B, 0x7FFF, 0xFFFE, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x9, 0xBFFF, 
0xC03F, 0xF000, 0x1F1F, 0x0, 
0x4DF, 0xFFFA, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x4000, 
0x0, 0x3F, 0x800F, 0xE000, 
0xE1F, 0x0, 0x0, 0x7F2, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x1F, 
0x7, 0xC000, 0x51F, 0x0, 
0x0, 0x3E0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x4000, 
0x0, 0x1F, 0x7, 0xC000, 
0x50E, 0x0, 0x0, 0x3E2, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x4000, 0x0, 0xF, 
0x8003, 0xE000, 0x540, 0x0, 
0x0, 0x3E0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x4000, 
0x0, 0xF, 0x8003, 0xE000, 
0x1010, 0x0, 0x0, 0x3E0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x4000, 0x0, 0x7, 
0xC001, 0xF000, 0x0, 0x0, 
0x0, 0x3E0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x4000, 
0x0, 0x7, 0xC001, 0xF000, 
0x4104, 0x0, 0x0, 0x3E0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0xE000, 0x0, 0x7, 
0xC001, 0xF000, 0x540, 0x0, 
0x0, 0x3E0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0xA000, 
0x0, 0x3, 0xE000, 0xF800, 
0x9292, 0x0, 0x0, 0x3E0, 
0x0, 0x0, 0x0, 0x0, 
0x1, 0xB000, 0x0, 0x3, 
0xE000, 0xF800, 0x280, 0x0, 
0x0, 0x3E0, 0x0, 0x0, 
0x0, 0x0, 0x7, 0x1C00, 
0x0, 0x3, 0xE000, 0xF801, 
0x2C69, 0xC, 0xF00, 0x3E0, 
0x7, 0xF807, 0xF00C, 0x7800, 
0xBFC, 0x7EA, 0x0, 0x1, 
0xF001, 0x7C96, 0x3018, 0xD23C, 
0x1FC0, 0x3E0, 0x0, 0xF801, 
0xF03C, 0xCE00, 0xFFF, 0x1C00, 
0x0, 0x1, 0xF001, 0x7C01, 
0x2C79, 0xFC, 0x3FE0, 0x3E0, 
0x0, 0x7800, 0xF0FD, 0x380, 
0x1C1F, 0xB000, 0x0, 0x1, 
0xF802, 0x7E00, 0x2F0, 0x3FC, 
0x63E0, 0x3E0, 0x0, 0x7800, 
0xF3FE, 0x1C0, 0x380F, 0xA000, 
0x0, 0x0, 0xF802, 0x3E00, 
0x9293, 0x7C, 0x81F0, 0x3E0, 
0x0, 0x7800, 0xF07E, 0x1E0, 
0x7007, 0xE000, 0x0, 0x0, 
0xF802, 0x3E00, 0x541, 0x3D, 
0xF0, 0x3E0, 0x0, 0x7800, 
0xF03C, 0xE0, 0x7003, 0xC000, 
0x0, 0x0, 0x7C04, 0x1F01, 
0x4107, 0x3E, 0xF0, 0x3E0, 
0x0, 0x7800, 0xF03C, 0xF0, 
0xE001, 0xE000, 0x0, 0x0, 
0x7C04, 0x1F01, 0x7, 0x3C, 
0xF0, 0x3E0, 0x0, 0x7800, 
0xF03C, 0x70, 0xE001, 0xE000, 
0x0, 0x0, 0x7C04, 0x1F01, 
0x101F, 0x3C, 0xF0, 0x3E0, 
0x0, 0x7800, 0xF03C, 0x79, 
0xE003, 0xF000, 0x0, 0x0, 
0x3E08, 0xF82, 0x54F, 0x3C, 
0xF0, 0x3E0, 0x0, 0x7800, 
0xF03C, 0x79, 0xFFFF, 0xF000, 
0x0, 0x0, 0x3E08, 0xF82, 
0x10F, 0x3C, 0xF0, 0x3E0, 
0x0, 0x7800, 0xF03C, 0x79, 
0xE000, 0x0, 0x0, 0x0, 
0x1F10, 0x7C4, 0x10F, 0x3C, 
0xF0, 0x3E0, 0x0, 0x7800, 
0xF03C, 0x79, 0xE000, 0x4000, 
0x0, 0x0, 0x1F10, 0x7C4, 
0xF, 0x3C, 0xF0, 0x3E0, 
0x0, 0x7800, 0xF03C, 0x79, 
0xE000, 0x0, 0x0, 0x0, 
0x1F10, 0x7C4, 0x10F, 0x3C, 
0xF0, 0x3E0, 0x0, 0x7800, 
0xF03C, 0x79, 0xE000, 0x4000, 
0x0, 0x0, 0xFA0, 0x3E8, 
0xF, 0x3C, 0xF0, 0x3E0, 
0x0, 0x7800, 0xF03C, 0x79, 
0xE000, 0x0, 0x0, 0x0, 
0xFA0, 0x3E8, 0xF, 0x3C, 
0xF0, 0x3E0, 0x0, 0x7800, 
0xF03C, 0x79, 0xF000, 0x0, 
0x0, 0x0, 0xFA0, 0x3E8, 
0x10F, 0x3C, 0xF0, 0x3E0, 
0x0, 0x7800, 0xF03C, 0x78, 
0xF000, 0x1000, 0x0, 0x0, 
0x7C0, 0x1F0, 0xF, 0x3C, 
0xF0, 0x3E0, 0x2, 0x7800, 
0xF03C, 0x70, 0xF800, 0x2000, 
0x0, 0x0, 0x7C0, 0x1F0, 
0xF, 0x3C, 0xF0, 0x3E0, 
0x4, 0x7800, 0xF03E, 0xF0, 
0x7800, 0x4000, 0x0, 0x0, 
0x380, 0xE0, 0xF, 0x3C, 
0xF0, 0x3E0, 0xC, 0x7C01, 
0xF03E, 0xE0, 0x7E01, 0xC000, 
0x0, 0x0, 0x380, 0xE0, 
0xF, 0x3C, 0xF0, 0x3E0, 
0x18, 0x3E03, 0xFC3F, 0x1E0, 
0x3F87, 0x8000, 0x0, 0x0, 
0x380, 0xE0, 0xF, 0x3C, 
0xF0, 0x7F8, 0x78, 0x3FFE, 
0xFC3F, 0x1C0, 0x1FFF, 0x0, 
0x0, 0x26, 0xFF00, 0x40, 
0x1F, 0x807E, 0x1F8, 0xFFF, 
0xFFF0, 0x1FFC, 0xF03D, 0x8380, 
0xFFE, 0x0, 0x44, 0xCEFF, 
0xFF00, 0x40, 0xFF, 0xE3FF, 
0x87FC, 0x7FFF, 0xFFF0, 0x7F0, 
0xC03C, 0xC600, 0x3F8, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x3C, 0xB800, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x3C, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x3C, 0x8000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x3C, 0x8000, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x3C, 0x8000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x3D, 0x4000, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x3D, 0x4000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x3E, 0x3000, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x2BC, 0x1E90, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x7E, 0x3000, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x3FF, 0x4000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x1, 0x4000, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x8000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x8000, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x8000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x8000, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0};

int  IMAG2[] = {
0x0, 0x78, 0x0, 0x0, 
0x0, 0x0, 0xA6, 0x0, 
0x0, 0x0, 0x0, 0x121, 
0xC000, 0x1C00, 0x0, 0x0, 
0x210, 0x3000, 0x2600, 0x0, 
0x0, 0x410, 0xE00, 0x4200, 
0x0, 0x0, 0x810, 0x180, 
0x8200, 0x0, 0x0, 0x1008, 
0x71, 0x400, 0x0, 0x0, 
0x2008, 0xA, 0x800, 0x0, 
0x0, 0x4004, 0x4, 0x1000, 
0x0, 0x0, 0x8004, 0x8, 
0x2000, 0x0, 0x1, 0x184, 
0x10, 0x4000, 0x0, 0x2, 
0x382, 0x20, 0x8000, 0x0, 
0x4, 0x382, 0x41, 0x4000, 
0x0, 0x8, 0x3C1, 0x82, 
0x2000, 0x0, 0x10, 0x1C1, 
0x104, 0x2000, 0x0, 0x20, 
0x38E1, 0x108, 0x2000, 0x0, 
0x40, 0x78F0, 0x8190, 0x1000, 
0x0, 0x80, 0xF070, 0x80E0, 
0x1000, 0x0, 0x101, 0xE070, 
0x4000, 0x800, 0x0, 0x203, 
0xC070, 0x4000, 0x800, 0x0, 
0x603, 0x8020, 0x4000, 0x800, 
0x0, 0x507, 0x60, 0x2000, 
0x400, 0x0, 0x50E, 0x3E0, 
0x3000, 0x400, 0x0, 0x508, 
0xFC0, 0x4E00, 0x200, 0x0, 
0x480, 0x1F80, 0x8180, 0x200, 
0x0, 0x480, 0x1F01, 0x70, 
0x200, 0x0, 0x440, 0x3E02, 
0xC, 0x100, 0x0, 0x440, 
0x3C04, 0x3, 0x8100, 0x0, 
0x440, 0x3808, 0x0, 0x6080, 
0x0, 0x420, 0x7010, 0x100, 
0x1C80, 0x0, 0x420, 0xE020, 
0x80, 0x380, 0x0, 0x410, 
0xC040, 0xE0, 0x180, 0x0, 
0x411, 0x8080, 0xF0, 0x300, 
0x0, 0x413, 0x100, 0xF0, 
0x600, 0x0, 0x408, 0x200, 
0x70, 0xC00, 0x0, 0x408, 
0x400, 0x3C0, 0x1800, 0x0, 
0x404, 0x801, 0xC7C0, 0x3000, 
0x0, 0x404, 0x1003, 0xEF80, 
0x6000, 0x0, 0x404, 0x2007, 
0xFF00, 0xC000, 0x0, 0x402, 
0x400F, 0xDF01, 0x8000, 0x0, 
0x402, 0x8070, 0x3E03, 0x0, 
0x0, 0x401, 0x0, 0x7806, 
0x0, 0x0, 0x402, 0x8000, 
0x600C, 0x0, 0x0, 0x404, 
0x7000, 0xC018, 0x0, 0x0, 
0x408, 0xE00, 0x8030, 0x0, 
0x0, 0x410, 0x1C0, 0x6A, 
0xAAAA, 0xA800, 0x420, 0x38, 
0xD5, 0x5555, 0x5400, 0x440, 
0x7, 0x1AA, 0xAAAA, 0xAA00, 
0x480, 0x0, 0xE355, 0x5555, 
0x5500, 0x500, 0x0, 0x1EAA, 
0xAAAA, 0xAA80, 0x600, 0x0, 
0xD55, 0x5555, 0x5540, 0x7FF, 
0xFFFF, 0xFAAA, 0xAAAA, 0xAA80, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0};

int  IMAG3[] = {
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x0, 0x0, 
0x0, 0x0, 0x7FFF, 0xFFFC, 
0x4000, 0x6, 0x5555, 0x5556, 
0x4000, 0x6, 0x7FFF, 0xFFFE, 
0x4030, 0x6, 0x4030, 0x6, 
0x4079, 0xF006, 0x407B, 0xF806, 
0x4030, 0x7C06, 0x4078, 0x3E06, 
0x4078, 0x1F06, 0x40CC, 0x2F86, 
0x40CC, 0x47C6, 0x41B6, 0x8BC6, 
0x4FFF, 0x11F6, 0x4332, 0x2066, 
0x4304, 0x4046, 0x4608, 0x8006, 
0x461F, 0x8006, 0x4C3E, 0xC006, 
0x4C7C, 0xC006, 0x58F8, 0x6006, 
0x79F0, 0x7006, 0x73E0, 0x3006, 
0x7FFF, 0xFFFE, 0x3FFF, 0xFFFE};

LONG rs_frstr[] = {
0};

BITBLK rs_bitblk[] = {
(WORD *)0L, 8, 55, 0, 0, 1,
(WORD *)1L, 28, 62, 0, 0, 1,
(WORD *)2L, 10, 54, 0, 0, 1,
(WORD *)3L, 4, 32, 0, 0, 1};

LONG rs_frimg[] = {
0};

ICONBLK rs_iconblk[] = {
0};

CICONBLK rs_ciconblk[] = {
0};

TEDINFO rs_tedinfo[] = {
(char *)0L, (char *)1L, (char *)2L, 3, 0, 2, 0x1100, 0x0, -1, 6,1,
(char *)3L, (char *)4L, (char *)5L, 5, 0, 0, 0x1180, 0x0, -1, 9,1,
(char *)6L, (char *)7L, (char *)8L, 3, 0, 0, 0x1180, 0x0, -1, 14,1,
(char *)13L, (char *)14L, (char *)15L, 3, 0, 0, 0x1180, 0x0, -1, 11,1,
(char *)21L, (char *)22L, (char *)23L, 3, 0, 0, 0x1180, 0x0, -1, 15,1,
(char *)28L, (char *)29L, (char *)30L, 3, 0, 2, 0x1180, 0x0, 0, 3,32,
(char *)31L, (char *)32L, (char *)33L, 5, 0, 2, 0x1101, 0x0, -1, 10,1,
(char *)34L, (char *)35L, (char *)36L, 3, 0, 2, 0x1101, 0x0, -2, 8,1,
(char *)37L, (char *)38L, (char *)39L, 3, 0, 2, 0x1101, 0x0, -2, 7,1,
(char *)41L, (char *)42L, (char *)43L, 3, 0, 2, 0x1100, 0x0, -1, 12,1,
(char *)44L, (char *)45L, (char *)46L, 5, 0, 0, 0x1180, 0x0, -1, 1,1,
(char *)47L, (char *)48L, (char *)49L, 5, 0, 0, 0x1180, 0x0, -1, 18,1,
(char *)50L, (char *)51L, (char *)52L, 3, 0, 2, 0x1180, 0x0, -1, 22,1,
(char *)53L, (char *)54L, (char *)55L, 5, 0, 2, 0x1180, 0x0, -1, 29,1,
(char *)56L, (char *)57L, (char *)58L, 5, 0, 2, 0x1180, 0x0, -1, 9,1,
(char *)59L, (char *)60L, (char *)61L, 3, 0, 2, 0x1180, 0x0, -1, 8,1,
(char *)62L, (char *)63L, (char *)64L, 5, 0, 2, 0x1180, 0x0, -1, 13,1,
(char *)65L, (char *)66L, (char *)67L, 5, 0, 2, 0x1180, 0x0, -1, 4,1,
(char *)68L, (char *)69L, (char *)70L, 3, 0, 2, 0x1180, 0x0, -1, 21,1,
(char *)71L, (char *)72L, (char *)73L, 5, 0, 2, 0x1180, 0x0, -1, 32,1,
(char *)74L, (char *)75L, (char *)76L, 5, 0, 2, 0x1180, 0x0, -1, 41,1,
(char *)77L, (char *)78L, (char *)79L, 5, 0, 2, 0x1180, 0x0, -1, 41,1,
(char *)81L, (char *)82L, (char *)83L, 3, 0, 2, 0x1100, 0x0, -1, 6,1,
(char *)85L, (char *)86L, (char *)87L, 3, 0, 2, 0x1100, 0x0, -1, 10,1,
(char *)88L, (char *)89L, (char *)90L, 3, 0, 0, 0x1180, 0x0, -1, 10,1,
(char *)93L, (char *)94L, (char *)95L, 3, 0, 0, 0x1180, 0x0, -1, 13,1,
(char *)100L, (char *)101L, (char *)102L, 3, 0, 0, 0x1180, 0x0, -1, 11,1,
(char *)103L, (char *)104L, (char *)105L, 3, 0, 2, 0x1180, 0x0, -1, 6,1,
(char *)106L, (char *)107L, (char *)108L, 5, 0, 2, 0x1101, 0x0, -1, 7,1,
(char *)109L, (char *)110L, (char *)111L, 5, 0, 2, 0x1101, 0x0, -1, 14,1,
(char *)112L, (char *)113L, (char *)114L, 3, 0, 2, 0x1101, 0x0, -2, 7,1,
(char *)115L, (char *)116L, (char *)117L, 3, 0, 2, 0x1101, 0x0, -2, 8,1,
(char *)118L, (char *)119L, (char *)120L, 3, 0, 2, 0x1101, 0x0, -2, 8,1,
(char *)140L, (char *)141L, (char *)142L, 5, 0, 2, 0x1180, 0x0, -1, 8,1};

OBJECT rs_object[] = {
-1, 1, 60, G_BOX, NONE, OUTLINED, 0x21101L, 0,0, 38,22,
2, -1, -1, (0x9<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011180L, 36,0, 2,1,
3, -1, -1, G_TEXT, NONE, NORMAL, 0x0L, 2,1, 5,1,
4, -1, -1, G_TEXT, NONE, NORMAL, 0x1L, 30,1, 6,1,
5, -1, -1, (0x4<<8)+G_IBOX, NONE, NORMAL, 0x11100L, 1,2, 36,256,
20, 6, 18, G_BOX, NONE, NORMAL, 0x11180L, 1,3, 36,517,
7, -1, -1, (0x2<<8)+G_BOXTEXT, NONE, NORMAL, 0x2L, 1,0, 13,1,
8, -1, -1, G_IMAGE, NONE, NORMAL, 0x0L, 28,1280, 16384,14336,
9, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,1, 2,1,
11, 10, 10, G_STRING, NONE, NORMAL, 0x9L, 4,1, 20,1,
9, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x45011100L, 0,0, 1,1,
12, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,2, 2,1,
14, 13, 13, G_STRING, NONE, NORMAL, 0xAL, 4,2, 16,1,
12, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x5A011100L, 4,0, 1,1,
15, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,3, 2,1,
17, 16, 16, G_STRING, NONE, NORMAL, 0xBL, 4,3, 24,1,
15, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x56011100L, 14,0, 1,1,
18, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,4, 2,1,
5, 19, 19, G_STRING, NONE, NORMAL, 0xCL, 4,4, 19,1,
18, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x49011100L, 0,0, 1,1,
37, 21, 35, G_BOX, NONE, NORMAL, 0x11180L, 1,9, 36,518,
22, -1, -1, (0x2<<8)+G_BOXTEXT, NONE, NORMAL, 0x3L, 1,0, 10,1,
23, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,1, 2,1,
25, 24, 24, G_STRING, NONE, NORMAL, 0x10L, 4,1, 17,1,
23, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x46011100L, 11,0, 1,1,
26, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,2, 2,1,
28, 27, 27, G_STRING, NONE, NORMAL, 0x11L, 4,2, 26,1,
26, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x55011100L, 16,0, 1,1,
29, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,3, 2,1,
31, 30, 30, G_STRING, NONE, NORMAL, 0x12L, 4,3, 16,1,
29, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x52011100L, 10,0, 1,1,
32, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,4, 2,1,
34, 33, 33, G_STRING, NONE, NORMAL, 0x13L, 4,4, 21,1,
32, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x4B011100L, 0,0, 1,1,
35, -1, -1, (0x6<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011100L, 1,5, 2,1,
20, 36, 36, G_STRING, NONE, NORMAL, 0x14L, 4,5, 26,1,
35, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x67011100L, 0,0, 1,1,
54, 38, 52, G_BOX, NONE, NORMAL, 0x11180L, 1,16, 36,771,
39, -1, -1, (0x2<<8)+G_BOXTEXT, NONE, NORMAL, 0x4L, 1,0, 14,1,
40, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 1,1, 2,1,
42, 41, 41, G_STRING, NONE, NORMAL, 0x18L, 4,1, 3,1,
40, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x32011100L, 2,0, 1,1,
43, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 10,1, 2,1,
45, 44, 44, G_STRING, NONE, NORMAL, 0x19L, 13,1, 3,1,
43, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x34011100L, 2,0, 1,1,
46, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 19,1, 2,1,
48, 47, 47, G_STRING, NONE, NORMAL, 0x1AL, 22,1, 3,1,
46, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x38011100L, 2,0, 1,1,
49, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 28,1, 2,1,
51, 50, 50, G_STRING, NONE, NORMAL, 0x1BL, 31,1, 4,1,
49, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x31011100L, 2,0, 1,1,
52, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 1,258, 2,1,
37, 53, 53, G_FTEXT, EDITABLE, NORMAL, 0x5L, 4,258, 31,1,
52, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x6D011100L, 15,0, 1,1,
56, 55, 55, G_BOXTEXT, SELECTABLE|EXIT, OUTLINED|SHADOWED, 0x6L, 1,20, 8,1,
54, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x4E011100L, 2,0, 1792,1,
58, 57, 57, (0x13<<8)+G_BOXTEXT, SELECTABLE|EXIT|0x600, NORMAL, 0x7L, 11,20, 8,1,
56, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x41011100L, 1024,0, 1,1,
60, 59, 59, G_BOXTEXT, SELECTABLE|EXIT|0x600, NORMAL, 0x8L, 20,20, 8,1,
58, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x54011100L, 3,0, 1,1,
0, 61, 61, G_BUTTON, SELECTABLE|DEFAULT|EXIT|0x600, NORMAL, 0x28L, 29,20, 8,1,
60, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, 0x4F011100L, 3,0, 1,1,
-1, 1, 18, G_BOX, NONE, OUTLINED, 0x21101L, 0,0, 32,22,
2, -1, -1, (0x9<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011180L, 30,0, 2,1,
3, -1, -1, G_TEXT, NONE, NORMAL, 0x9L, 2,1, 11,1,
4, -1, -1, G_TEXT, NONE, NORMAL, 0xAL, 1557,1, 9,1,
5, -1, -1, (0x4<<8)+G_IBOX, NONE, NORMAL, 0x11100L, 1,2, 30,1,
6, -1, -1, G_IMAGE, NONE, NORMAL, 0x1L, 1793,3, 28,3587,
8, 7, 7, (0x4<<8)+G_IBOX, NONE, NORMAL, 0x11100L, 3,6, 26,2560,
6, -1, -1, G_TEXT, NONE, NORMAL, 0xBL, 1797,256, 1548,2048,
9, -1, -1, G_TEXT, NONE, NORMAL, 0xCL, 0,7, 32,1,
10, -1, -1, G_TEXT, NONE, NORMAL, 0xDL, 0,8, 32,1,
11, -1, -1, G_TEXT, NONE, NORMAL, 0xEL, 0,9, 32,1,
12, -1, -1, (0xD<<8)+G_TEXT, NONE, CHECKED, 0xFL, 0,10, 32,1,
13, -1, -1, G_TEXT, NONE, NORMAL, 0x10L, 0,12, 32,1,
14, -1, -1, G_TEXT, NONE, NORMAL, 0x11L, 0,13, 32,1,
15, -1, -1, (0xD<<8)+G_TEXT, NONE, SHADOWED, 0x12L, 0,14, 32,1,
16, -1, -1, G_TEXT, NONE, NORMAL, 0x13L, 0,15, 32,1,
17, -1, -1, G_TEXT, NONE, NORMAL, 0x14L, 0,17, 32,1,
18, -1, -1, G_TEXT, NONE, NORMAL, 0x15L, 0,18, 32,1,
0, 19, 19, G_BUTTON, SELECTABLE|DEFAULT|EXIT|0x600, NORMAL, 0x50L, 1034,20, 11,1,
18, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, 0x4F011100L, 1028,0, 1,1,
-1, 1, 10, G_BOX, NONE, OUTLINED, 0x21101L, 0,0, 36,21,
2, -1, -1, (0x9<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011180L, 34,0, 2,1,
3, -1, -1, G_TEXT, NONE, NORMAL, 0x16L, 2,1, 6,1,
4, -1, -1, (0x4<<8)+G_IBOX, NONE, NORMAL, 0x11100L, 1,2, 34,1,
6, 5, 5, G_BOX, NONE, NORMAL, 0xFF1101L, 1793,3, 286,15,
4, -1, -1, G_IBOX, NONE, NORMAL, 0x11100L, 256,0, 30,15,
7, -1, -1, (0x11<<8)+G_IBOX, TOUCHEXIT, OUTLINED, 0x11100L, 288,3, 2,1,
9, 8, 8, G_BOX, TOUCHEXIT, NORMAL, 0xFF1141L, 288,4, 2,13,
7, -1, -1, G_BOX, TOUCHEXIT, NORMAL, 0xFF1100L, 0,0, 2,1,
10, -1, -1, (0x12<<8)+G_IBOX, TOUCHEXIT, OUTLINED, 0x11100L, 288,17, 2,1,
0, 11, 11, G_BUTTON, SELECTABLE|DEFAULT|EXIT|0x600, NORMAL, 0x54L, 1036,19, 11,1,
10, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, 0x4F011100L, 1028,0, 1,1,
-1, 1, 42, G_BOX, NONE, OUTLINED, 0x21101L, 0,0, 38,18,
2, -1, -1, (0x9<<8)+G_IBOX, SELECTABLE, NORMAL, 0x57011180L, 36,0, 2,1,
3, -1, -1, G_IMAGE, NONE, NORMAL, 0x2L, 27,1024, 20480,13824,
4, -1, -1, G_TEXT, NONE, NORMAL, 0x17L, 2,1, 9,1,
5, -1, -1, (0x4<<8)+G_IBOX, NONE, NORMAL, 0x11100L, 1,2, 25,256,
13, 6, 11, G_BOX, NONE, NORMAL, 0x11180L, 1,4, 36,514,
7, -1, -1, (0x2<<8)+G_BOXTEXT, NONE, NORMAL, 0x18L, 1,0, 9,1,
8, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 1,1, 2,1,
10, 9, 9, G_STRING, NONE, NORMAL, 0x5BL, 4,1, 12,1,
8, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x57011100L, 0,0, 1,1,
11, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 19,1, 2,1,
5, 12, 12, G_STRING, NONE, NORMAL, 0x5CL, 22,1, 12,1,
11, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x46011100L, 0,0, 1,1,
27, 14, 25, G_BOX, NONE, NORMAL, 0x11180L, 1,7, 36,771,
15, -1, -1, (0x2<<8)+G_BOXTEXT, NONE, NORMAL, 0x19L, 1,0, 12,1,
16, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 1,1, 2,1,
18, 17, 17, G_STRING, NONE, NORMAL, 0x60L, 4,1, 13,1,
16, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x56011100L, 0,0, 1,1,
19, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 19,1, 2,1,
21, 20, 20, G_STRING, NONE, NORMAL, 0x61L, 22,1, 8,1,
19, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x74011100L, 1,0, 1,1,
22, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 1,258, 2,1,
24, 23, 23, G_STRING, NONE, NORMAL, 0x62L, 4,258, 12,1,
22, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x58011100L, 2,0, 1,1,
25, -1, -1, (0x7<<8)+G_IBOX, SELECTABLE|RBUTTON, NORMAL, 0x57011100L, 19,258, 2,1,
13, 26, 26, G_STRING, NONE, NORMAL, 0x63L, 22,258, 11,1,
25, -1, -1, (0x8<<8)+G_IBOX, NONE, NORMAL, 0x6E011100L, 1,0, 1,1,
33, 28, 32, G_BOX, NONE, NORMAL, 0x11180L, 1,267, 36,770,
29, -1, -1, (0x2<<8)+G_BOXTEXT, NONE, NORMAL, 0x1AL, 1,0, 10,1,
30, -1, -1, (0xF<<8)+G_IBOX, TOUCHEXIT, OUTLINED, 0x57011100L, 1,1, 2,1,
32, 31, 31, G_BOX, TOUCHEXIT, NORMAL, 0xFF1141L, 4,1, 28,1,
30, -1, -1, G_BOXTEXT, TOUCHEXIT, NORMAL, 0x1BL, 10,0, 5,1,
27, -1, -1, (0x10<<8)+G_IBOX, TOUCHEXIT, OUTLINED, 0x57011100L, 33,1, 2,1,
34, -1, -1, (0xC<<8)+G_BOXTEXT, SELECTABLE|EXIT, OUTLINED|SHADOWED, 0x1CL, 2,14, 10,1,
36, 35, 35, G_BOXTEXT, SELECTABLE|EXIT, OUTLINED|SHADOWED, 0x1DL, 14,14, 10,1,
34, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x49011100L, 0,0, 1792,1,
38, 37, 37, G_BOXTEXT, SELECTABLE|EXIT|0x600, NORMAL, 0x1EL, 26,14, 10,1,
36, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x5A011100L, 5,0, 1,1,
40, 39, 39, (0x13<<8)+G_BOXTEXT, SELECTABLE|EXIT|0x600, NORMAL, 0x1FL, 2,16, 10,1,
38, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x41011100L, 1025,0, 1,1,
42, 41, 41, G_BOXTEXT, SELECTABLE|EXIT|0x600, NORMAL, 0x20L, 14,16, 10,1,
40, -1, -1, (0x5<<8)+G_IBOX, NONE, NORMAL, 0x53011100L, 1025,0, 1,1,
0, 43, 43, G_BUTTON, SELECTABLE|DEFAULT|EXIT|0x600, NORMAL, 0x79L, 26,16, 10,1,
42, -1, -1, (0x5<<8)+G_IBOX, LASTOB, NORMAL, 0x4F011100L, 4,0, 1,1,
-1, 1, 6, G_IBOX, NONE, NORMAL, 0x0L, 0,0, 80,25,
6, 2, 2, G_BOX, NONE, NORMAL, 0x1100L, 0,0, 80,769,
1, 3, 5, G_IBOX, NONE, NORMAL, 0x0L, 2,0, 25,769,
4, -1, -1, G_TITLE, NONE, NORMAL, 0x7AL, 0,0, 9,769,
5, -1, -1, G_TITLE, NONE, NORMAL, 0x7BL, 9,0, 7,769,
2, -1, -1, G_TITLE, NONE, NORMAL, 0x7CL, 16,0, 9,769,
0, 7, 20, G_IBOX, NONE, NORMAL, 0x0L, 0,769, 80,19,
16, 8, 15, G_BOX, NONE, NORMAL, 0xFF1100L, 2,0, 22,8,
9, -1, -1, G_STRING, NONE, NORMAL, 0x7DL, 0,0, 22,1,
10, -1, -1, G_STRING, NONE, DISABLED, 0x7EL, 0,1, 22,1,
11, -1, -1, G_STRING, NONE, NORMAL, 0x7FL, 0,2, 22,1,
12, -1, -1, G_STRING, NONE, NORMAL, 0x80L, 0,3, 22,1,
13, -1, -1, G_STRING, NONE, NORMAL, 0x81L, 0,4, 22,1,
14, -1, -1, G_STRING, NONE, NORMAL, 0x82L, 0,5, 22,1,
15, -1, -1, G_STRING, NONE, NORMAL, 0x83L, 0,6, 22,1,
7, -1, -1, G_STRING, NONE, NORMAL, 0x84L, 0,7, 22,1,
20, 17, 19, G_BOX, NONE, NORMAL, 0xFF1100L, 11,0, 16,3,
18, -1, -1, G_STRING, NONE, NORMAL, 0x85L, 0,0, 16,1,
19, -1, -1, G_STRING, NONE, DISABLED, 0x86L, 0,1, 16,1,
16, -1, -1, G_STRING, NONE, NORMAL, 0x87L, 0,2, 16,1,
6, 21, 24, G_BOX, NONE, NORMAL, 0xFF1100L, 18,0, 16,4,
22, -1, -1, G_STRING, NONE, NORMAL, 0x88L, 0,0, 16,1,
23, -1, -1, G_STRING, NONE, DISABLED, 0x89L, 0,1, 16,1,
24, -1, -1, G_STRING, NONE, DISABLED, 0x8AL, 0,2, 16,1,
20, -1, -1, G_STRING, LASTOB, DISABLED, 0x8BL, 0,3, 16,1,
-1, 1, 2, G_BOX, NONE, NORMAL, 0x1100L, 0,0, 8,515,
2, -1, -1, G_TEXT, NONE, NORMAL, 0x21L, 0,2, 8,1,
0, -1, -1, G_IMAGE, LASTOB, NORMAL, 0x3L, 2,0, 8192,8192};

LONG rs_trindex[] = {
0L,
62L,
82L,
94L,
138L,
163L};

struct foobar {
	WORD 	dummy;
	WORD 	*image;
	} rs_imdope[] = {
0, &IMAG0[0],
0, &IMAG1[0],
0, &IMAG2[0],
0, &IMAG3[0]};

#define NUM_STRINGS 143
#define NUM_USERDEFS 0
#define NUM_FRSTR 0
#define NUM_IMAGES 4
#define NUM_BB 4
#define NUM_FRIMG 0
#define NUM_IB 0
#define NUM_CIB 0
#define NUM_TI 34
#define NUM_OBS 166
#define NUM_TREE 6

int rs_numstrings = NUM_STRINGS;
int rs_nuser = NUM_USERDEFS;
int rs_numfrstr = NUM_FRSTR;
int rs_numimages = NUM_IMAGES;
int rs_numbb = NUM_BB;
int rs_numfrimg = NUM_FRIMG;
int rs_numib = NUM_IB;
int rs_numcib = NUM_CIB;
int rs_numti = NUM_TI;
int rs_numobs = NUM_OBS;
int rs_numtree = NUM_TREE;

char pname[] = "WIN_RSC.RSC";

int _rsc_format = 1;
