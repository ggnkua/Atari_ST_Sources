/* prototypage de fonctions */
extern float som(float a, float b);
extern void mul(void);
extern int compteur(void);

/* variables externes */
extern float mul_op1, mul_op2, resul_mul;