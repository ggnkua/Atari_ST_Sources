/*
		Defines f�r 'View-Protokoll'
		Version V0.00, 15.02.1993
	
	16.02.1993, gsp
*/
#ifndef _VIEWPROT_H
#define _VIEWPROT_H

#define VIEW_FILE    0x5600
#define VIEW_FAILED  0x5601
#define VIEW_OPEN    0x5602
#define VIEW_CLOSED  0x5603
#define VIEW_DATA    0x5604
#define VIEW_GETMFDB 0x5610
#define VIEW_SETMFDB 0x5611
#define VIEW_MFDB    0x5612

#define VIEWERR_ERROR 0
#define VIEWERR_SIZE  1
#define VIEWERR_COLOR 2
#define VIEWERR_WID   3
#define VIEWERR_MEM   4

#endif/*_VIEWPROT_H*/
