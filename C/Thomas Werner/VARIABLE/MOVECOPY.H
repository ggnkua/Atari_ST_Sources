
void	Verschieben(int Copy);