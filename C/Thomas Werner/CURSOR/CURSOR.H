
void Gem_Text(int Modus);
