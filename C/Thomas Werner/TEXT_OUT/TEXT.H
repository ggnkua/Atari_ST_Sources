
void 	cdecl	Text_Init(void);
void 	cdecl	Text_Color(int Col, int Mask, int Mode);
void  cdecl Text_Parameter(int Sin_Alpha, int Cos_Alpha,
													 int Kursiv, int X_size, int Y_size);
void 	cdecl Text_Exec(char *A, int X_pos, int Y_pos);
