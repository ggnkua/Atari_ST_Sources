/*----------------------------------------------------------------*/
/*			             		  LASSO-FUNKTION    					            */
/*			             		  								   					            */
/*		Aufruf: Lasso(Undo, Modus, handle)             							*/
/* 				Undo:   1, wenn Bild gerettet werden soll      					*/
/*				Modus:  Verkn�pfungsart des Ausschnitts (0-15)					*/
/*				handle: Grafik-Handle																		*/
/*----------------------------------------------------------------*/
 
void	Lasso(int Undo, int Modus);
