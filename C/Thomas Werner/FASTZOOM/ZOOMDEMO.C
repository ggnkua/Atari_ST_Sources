/*--------------------------------------------------------------------*/
/*Demo of the Fastzoom-Routine                  */
/*                                  */
/*Original routine in GFA-BASIC: Gerald Schmieder          */
/*C-Convertion: Thomas Werner                      */
/*(c) 1992 MAXON Computer GmbH                    */
/*--------------------------------------------------------------------*/


#include <tos.h>
#include <vdi.h>
#include <aes.h>
#include "fastzoom.h"


externint handle, work_out[];


void gem_prg()
{
inti, j;
MFDBscreen;

void init_MFDB(MFDB *block, int handle);


init_MFDB(&screen, handle);
graf_mouse(M_OFF, 0);

for (i=1; i<9; i+=2)
{
for (j=1; j<12; j+=3)
{
v_clrwk(handle);
v_gtext(handle, 0, 16,"Zoomdemo");
great(i,j,0,0,8*8,16,0,0,3,handle,&screen);
Crawcin();
}
}

graf_mouse(M_ON, 0);
}


void init_MFDB(MFDB *block, int handle)
{
block->fd_addr = 0;
vq_extnd(handle, 1, work_out);
block->fd_nplanes = work_out[4];
