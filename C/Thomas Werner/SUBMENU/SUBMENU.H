
void init_submenus(int handle, OBJECT *menu, OBJECT *submenu,
									 int count,int *menu_index);
void redraw_bg(void);
