/*----------------------------------------------------------------*/
/* Demo of the incremental Circle generator (by Horns Algorithms) */
/*                                              */
/* Original routine in GFA-BASIC by Andreas Hollmann       */
/* C-Convertion : Thomas Werner                  */
/* (c) 1992 Maxon Computer GmbH                 */
/*----------------------------------------------------------------*/

#include <tos.h>
#include <aes.h>
#include <vdi.h>
#include "circle.h"

externinthandle;


void gem_prg()
{
inti, r, type, t[3];


t[0] = 0xFFFF;/* Traversed Line */
t[1] = 0xAAAA;   /* Pointed Line   */
t[2] = 0xEEEE;/* Levelled Line  */

for (i=0; i<3; i++)
{
type = t[i];

  graf_mouse(M_OFF,0);
v_clrwk(handle);
  graf_mouse(M_ON,0);

for (r=2; r<80; r+=5)
{
  vsl_type(handle, 7);
  vsl_udsty(handle,type);
  graf_mouse(M_OFF,0);
  v_arc(handle,480,199,r,0,3600);  /* VDI-'Circle'   */
  graf_mouse(M_ON,0);
vsl_type(handle, 1);
  circle(160,199,r,type);        /* genuine circle */
}
Crawcin();
}
}
