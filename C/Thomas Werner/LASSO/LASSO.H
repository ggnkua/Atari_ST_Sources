/*----------------------------------------------------------------*/
/*               LASSO-FUNCTION                         */
/*                                              */
/*   Call: Lasso(Undo, Mode, handle)                     */
/* Undo:   1, when screen should have been saved         */
/* Mode:  Linking types of cuttings (0-15)               */
/*handle: Graphic-Handle                    */
/*----------------------------------------------------------------*/
 
voidLasso(int Undo, int Mode);
