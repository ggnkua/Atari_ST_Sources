
void circle(int x0, int y0, int r, int type);
