void	cdecl	add1fade(void *Puffer1, void *Puffer2, long	mode);
void	cdecl	add8fade(void *Puffer1, void *Puffer2, long	mode);
void	cdecl	rnd1fade(void *Puffer1, void *Puffer2);
void	cdecl	rnd8fade(void *Puffer1, void *Puffer2);
