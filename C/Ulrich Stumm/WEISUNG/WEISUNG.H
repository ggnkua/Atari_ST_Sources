#define FORMULAR 0
#define EMPF_1 8
#define EMPF_2 9
#define BLZ 12
#define KTO_EMPF 14
#define BANK 17
#define ZWECK_2 22
#define ZWECK_1 21
#define ZWECK_3 23
#define ANSCHR_2 34
#define ANSCHR_1 31
#define BETRAG 26
#define KTO_AUFT 27
#define LOAD 1
#define DATUM 37
#define SAVE 2
#define PRINT 3
#define DATE 38
#define QUIT 4
