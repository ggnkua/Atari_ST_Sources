#define DBMENU 1
#define DESK 3
#define KUDOS 3
#define NFILE 4
#define OPTIONS 5
#define CREDITS 8
#define NEW 17
#define OPEN 18
#define SAVE 20
#define SAVEAS 21
#define ERASE 23
#define EDIT 25
#define QUIT 27
#define SEARCH 31
#define SORT 30
#define PRINT 33
#define OUTPUT 2
#define PRTITLE 10
#define LABEL 4
#define COLUMN 5
#define DBASE 0
#define REGULAR 6
#define STYLES 3
#define VITALS 1
#define SKINNY 7
#define LNAME 2
#define ADDR 4
#define FNAME 3
#define PALL 13
#define CITY 5
#define PSOME 14
#define STATE 6
#define PHONE 8
#define ZIP 7
#define CANCEL 12
#define PRINTIT 11
#define STATUS 9
#define COPIES 16
#define TOYS 10
#define DRIVE 12
#define COMP 11
#define MODEM 13
#define PRNT 14
#define INTR1 16
#define OTHER 15
#define DBSEARCH 4
#define INTR2 17
#define EXIT 18
#define NEXT 20
#define SFNAME 4
#define SLNAME 3
#define PREV 21
#define SCITY 5
#define START 22
#define SSTATE 6
#define END 23
#define SPHONE 8
#define SZIP 7
#define ADD 25
#define DELETE 26
#define SCOMP 10
#define UPDATE 27
#define SMODEM 12
#define SDRIVE 11
#define SPRNTR 13
#define SOTHER 14
#define SSEARCH 17
#define SINTR 15
#define SCANCEL 18
