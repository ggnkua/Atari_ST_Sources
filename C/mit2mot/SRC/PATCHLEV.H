/*
 * Version information for MIT2MOT
 */

#define M2M_VERSION	1
#define M2M_RELEASE	0
#define M2M_PATCHLEVEL	2
