/*------------------------------------------------------------------------*/
/* HELP_MSG.H                                                             */
/* Texte f�r HELP!-Alertboxen                                             */
/*------------------------------------------------------------------------*/

#define AL_MEMORY "[3][ Nicht genug Speicher frei ! ][ B”h! ]"
#define AL_DEPTH  "[3][ Zu tief verschachtelt. | Erst zur�ckgehen ! ][ So? ]"
#define AL_REFNO  "[3][ Zuviele Verweise ! ][ Pech ]"
#define AL_INXDAT "[3][ Kann Indexdatei nicht | ”ffnen! ][ B”h! ]"
#define AL_UNKNWN "[1][ Unbekannter Begriff !][ Pech ]"
#define AL_HLPDAT "[3][ Kann Hilfetextatei | nicht ”ffnen! ][ B”h! ]"
#define AL_WINDOW "[3][ Kein weiteres Fenster | m”glich ! ][ B”h! ]"

