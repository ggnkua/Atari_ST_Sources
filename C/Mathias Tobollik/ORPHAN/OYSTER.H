#define DRIVESD 0  	/* TREE */
#define INFOD 1  	/* TREE */
#define RESULTD 2  	/* TREE */
#define FIXD 3  	/* TREE */
#define DRIVEC 10  	/* OBJECT in TREE #0 */
#define DRIVED 11  	/* OBJECT in TREE #0 */
#define DRIVEE 12  	/* OBJECT in TREE #0 */
#define DRIVEF 13  	/* OBJECT in TREE #0 */
#define DRIVEG 14  	/* OBJECT in TREE #0 */
#define DRIVEH 15  	/* OBJECT in TREE #0 */
#define DRIVEI 16  	/* OBJECT in TREE #0 */
#define DRIVEJ 17  	/* OBJECT in TREE #0 */
#define DRIVEK 18  	/* OBJECT in TREE #0 */
#define DRIVEL 19  	/* OBJECT in TREE #0 */
#define DRIVEM 20  	/* OBJECT in TREE #0 */
#define DRIVEN 21  	/* OBJECT in TREE #0 */
#define DRIVEO 22  	/* OBJECT in TREE #0 */
#define DRIVEP 23  	/* OBJECT in TREE #0 */
#define QUIT 24  	/* OBJECT in TREE #0 */
#define IRECSIZ 5  	/* OBJECT in TREE #1 */
#define ICLSIZ 9  	/* OBJECT in TREE #1 */
#define ICLSIZB 11  	/* OBJECT in TREE #1 */
#define IRDLEN 16  	/* OBJECT in TREE #1 */
#define IFSIZ 21  	/* OBJECT in TREE #1 */
#define IFATREC 26  	/* OBJECT in TREE #1 */
#define IDATREC 31  	/* OBJECT in TREE #1 */
#define INUMCL 36  	/* OBJECT in TREE #1 */
#define IBFLAGS 39  	/* OBJECT in TREE #1 */
#define BPBOK 40  	/* OBJECT in TREE #1 */
#define RFILES 5  	/* OBJECT in TREE #2 */
#define RSUBDIR 8  	/* OBJECT in TREE #2 */
#define RBADCLUS 11  	/* OBJECT in TREE #2 */
#define RORPHAN 15  	/* OBJECT in TREE #2 */
#define RESOK 17  	/* OBJECT in TREE #2 */
#define FIXOK 5  	/* OBJECT in TREE #3 */
#define FIXKO 6  	/* OBJECT in TREE #3 */
