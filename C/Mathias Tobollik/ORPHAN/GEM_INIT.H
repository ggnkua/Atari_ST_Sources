/*------------------------------------------------------*/
/*      Include-File f�r An- und Abmelden beim VDI      */
/*------------------------------------------------------*/
#ifndef FALSE
	#define FALSE 0
	#define TRUE  1
#endif

/* Funktionsprototypen: --------------------------------*/
int open_vwork( void );
void close_vwork( void );

/*------------------ Ende GEM_INIT.H -------------------*/
