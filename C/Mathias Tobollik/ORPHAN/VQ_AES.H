/********************************************************************/
/*	vq_aes() 														*/
/*																	*/
/*	( in VQ_AES.S )													*/
/*																	*/
/*	Stellt fest, ob das AES installiert ist.						*/
/*																	*/
/********************************************************************/
extern int vq_aes( void );