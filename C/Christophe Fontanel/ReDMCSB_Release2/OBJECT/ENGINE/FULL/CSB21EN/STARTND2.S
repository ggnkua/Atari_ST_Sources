BSS SEG "bss"
G562_apuc_:/* global */
	.WORD	#40
G563_puc_G:/* global */
	.WORD	#4
G564_puc_G:/* global */
	.WORD	#4
G565_puc_G:/* global */
	.WORD	#4
G566_puc_G:/* global */
	.WORD	#4
G567_B_Sin:/* global */
	.WORD	#2
G568_i_Dis:/* global */
	.WORD	#2
G569_pc_Sa:/* global */
	.WORD	#4
G570_pc_Sa:/* global */
	.WORD	#4
G571_pc_D1:/* global */
	.WORD	#4
G572_pc_D1:/* global */
	.WORD	#4
G573_i_Gam:/* global */
	.WORD	#2
G574_i_Sav:/* global */
	.WORD	#2
CODE SEG "init!"
	LEA	G575_ac_Sa(A4),A1
	MOVE.B	#65,(A1)+
	MOVE.B	#58,(A1)+
	MOVE.B	#92,(A1)+
	MOVE.B	#67,(A1)+
	MOVE.B	#83,(A1)+
	MOVE.B	#66,(A1)+
	MOVE.B	#71,(A1)+
	MOVE.B	#65,(A1)+
	MOVE.B	#77,(A1)+
	MOVE.B	#69,(A1)+
	MOVE.B	#46,(A1)+
	MOVE.B	#68,(A1)+
	MOVE.B	#65,(A1)+
	MOVE.B	#84,(A1)+
	MOVE.B	#0,(A1)+
BSS SEG "bss"
G575_ac_Sa:/* global */
	.WORD	#16
CODE SEG "init!"
	LEA	G576_ac_Sa(A4),A1
	MOVE.B	#65,(A1)+
	MOVE.B	#58,(A1)+
	MOVE.B	#92,(A1)+
	MOVE.B	#67,(A1)+
	MOVE.B	#83,(A1)+
	MOVE.B	#66,(A1)+
	MOVE.B	#71,(A1)+
	MOVE.B	#65,(A1)+
	MOVE.B	#77,(A1)+
	MOVE.B	#69,(A1)+
	MOVE.B	#46,(A1)+
	MOVE.B	#66,(A1)+
	MOVE.B	#65,(A1)+
	MOVE.B	#75,(A1)+
	MOVE.B	#0,(A1)+
BSS SEG "bss"
G576_ac_Sa:/* global */
	.WORD	#16
CODE SEG "start"
F432_xxxx_:/* global */
	LINK	A6,L$0
	MOVE.L	A3,-(A7)
	CLR	-4(A6)
	MOVE	#2,-(A7)
	MOVE.L	G550_pc_D0(A4),-(A7)
	PEA	-54(A6)
	JSR	F414_xxxx_(PC)
	ADDA	#10,A7
	MOVE	#2,-(A7)
	MOVE.L	G555_pc_D1(A4),-(A7)
	PEA	-104(A6)
	JSR	F414_xxxx_(PC)
	ADDA	#10,A7
	MOVE.L	#0,A3
L2:
	CMPA.L	#0,A3
L5:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	PEA	-54(A6)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	CLR	-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-2(A6)
	CMPI	#2,-2(A6)
	BNE.S	L6
	BRA	L1(PC)
L6:
	MOVE	#2,-(A7)
	JSR	F454_xxxx_(PC)
	ADDQ.L	#2,A7
	CMPI	#1,D0
	BNE.S	L7
	MOVE	#1,-4(A6)
	BRA	L3(PC)
L7:
	CLR	-4(A6)
	MOVE	G568_i_Dis(A4),D0
L8:
	CMP	#0,D0
	BEQ.S	L9
	BRA.S	L11
L9:
	MOVE.L	G537_pc_D0(A4),A3
	BRA	L3(PC)
	BRA.S	L12
L11:
	CMP	#2,D0
	BEQ.S	L12
	BRA.S	L13
L12:
	MOVE.L	G544_pc_D0(A4),A3
	BRA	L3(PC)
	BRA.S	L14
L13:
	CMP	#4,D0
	BEQ.S	L14
	BRA.S	L15
L14:
	LEA	-104(A6),A0
	MOVE.L	A0,A3
	BRA	L3(PC)
	BRA.S	L16
L15:
	CMP	#1,D0
	BEQ.S	L16
	BRA	L17(PC)
L16:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	MOVE.L	G554_pc_D1(A4),-(A7)
	MOVE.L	G543_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-2(A6)
	CMPI	#1,-2(A6)
	BNE.S	L19
	MOVE	#2,-(A7)
	JSR	F452_xxxx_(PC)
	ADDQ.L	#2,A7
L20:
	CMP	#0,D0
	BEQ.S	L21
	BRA.S	L23
L21:
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L22
	BRA.S	L24
L23:
	CMP	#2,D0
	BEQ.S	L24
	BRA.S	L25
L24:
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L22
	BRA.S	L26
L25:
	CMP	#4,D0
	BEQ.S	L26
	BRA.S	L27
L26:
	LEA	-104(A6),A0
	MOVE.L	A0,A3
	BRA.S	L22
	BRA.S	L28
L27:
	CMP	#1,D0
	BEQ.S	L28
L29:
	CMP	#3,D0
	BEQ.S	L28
	BRA.S	L30
L28:
	MOVE	#1,-4(A6)
L30:
L31:
L22:
	BRA.S	L3
L19:
	MOVE.L	#0,A3
L17:
L18:
L10:
L3:
	MOVE	-4(A6),D0
	BEQ	L2(PC)
L4:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G553_pc_D1(A4),-(A7)
	CLR.L	-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F453_xxxx_(PC)
	TST	D0
	BNE.S	L32
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	CLR.L	-(A7)
	MOVE.L	G541_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
L32:
L1:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$0:	.EQU	#-104
F433_AA39_:/* global */
	LINK	A6,L$33
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D7
	JSR	F456_vzzz_(PC)
	CLR	-(A7)
	MOVE.L	#576,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-338(A6)
	MOVE.L	-338(A6),D0
	ADD.L	#512,D0
	MOVE.L	D0,-334(A6)
	CLR	D5
L36:
L35:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L36
L37:
L38:
	CLR	-(A7)
	MOVE	D5,-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	#2,D5
	MOVE.L	A2,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	MOVE	#6,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	-338(A6),-(A7)
	MOVE	#8,-(A7)
	TRAP	#14
	LEA	20(A7),A7
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	TRAP	#1
	MOVE.L	D0,2(A7)
	TST	1086.W
	BNE	L1T433_021(PC)
	MOVE	#1,1086.W
	BSR.S	L1T433_011_
	BSR	L1T433_018_(PC)
	BSR.S	L1T433_004_
	BSR.S	L1T433_011_
	BSR	L1T433_018_(PC)
	BSR.S	L1T433_004_
	BRA	L1T433_021(PC)
L1T433_004_:
	MOVE.L	-338(A6),A0
	LEA	20(A0),A0
	MOVE.L	-334(A6),A1
	MOVE	#489,D0
	MOVEQ	#16,D4
	MOVEQ	#0,D7
L1T433_005:
	MOVEQ	#0,D1
	MOVEQ	#0,D2
L1T433_006_:
	MOVE.B	(A0)+,D3
	BPL.S	L1T433_007
	BSET	D1,D2
	ANDI.B	#127,D3
L1T433_007:
	CMPI.B	#104,D3
	BEQ.S	L1T433_008
	MOVEQ	#0,D7
	RTS
L1T433_008:
	ADDQ	#1,D1
	SUBQ	#1,D0
	BEQ.S	L1T433_009
	CMP	D4,D1
	BNE.S	L1T433_006_
L1T433_009:
	CMP	(A1),D2
	BEQ.S	L1T433_010
	ADDQ	#1,D7
L1T433_010:
	MOVE	D2,(A1)+
	TST	D0
	BNE.S	L1T433_005
	RTS
L1T433_011_:
	MOVE	#-30720,A1
	MOVEQ	#248,D2
	MOVE	SR,D0
	ORI	#1792,SR
	MOVE.B	#14,(A1)
	AND.B	(A1),D2
	ORI.B	#5,D2
	MOVE.B	D2,2(A1)
	MOVE	D0,SR
	MOVE	G317_i_Wai(A4),D3
	ADD	#259,D3
	MOVE	#-31226,A1
	MOVE	#128,(A1)
	MOVEQ	#7,D1
	BSR.S	L1T433_015_
L1T433_012_:
	MOVE	#128,(A1)
	BSR.S	L1T433_016_
	MOVEQ	#2,D1
	AND	-2(A1),D1
	BSR.S	L1T433_016_
	TST	D1
	BEQ.S	L1T433_012_
	MOVE	#128,(A1)
	MOVEQ	#0,D1
	BSR.S	L1T433_015_
	MOVE	#128,(A1)
L1T433_013_:
	MOVEQ	#44,D0
L1T433_014:
	SUBQ	#1,D0
	BNE.S	L1T433_014
	MOVEQ	#1,D0
	AND	-2(A1),D0
	BNE.S	L1T433_013_
	MOVE	#132,(A1)
	MOVEQ	#7,D1
	BSR.S	L1T433_015_
	MOVE.B	-335(A6),34317.W
	MOVE.B	-336(A6),34315.W
	MOVE.B	-337(A6),34313.W
	MOVE	#144,(A1)
	MOVE	#400,(A1)
	MOVE	#144,(A1)
	MOVE	#1,-2(A1)
	MOVE	#128,D1
	MOVE	D1,(A1)
L1T433_015_:
	BSR.S	L1T433_016_
	MOVE	D1,-2(A1)
L1T433_016_:
	MOVEQ	#46,D2
L1T433_017:
	SUBQ	#1,D2
	BNE.S	L1T433_017
	RTS
L1T433_018_:
	CMP	G317_i_Wai(A4),D3
	BMI.S	L1T433_020
	MOVE	G317_i_Wai(A4),D2
	BTST	#5,64001.W
	BNE.S	L1T433_018_
	MOVE	#144,(A1)
	MOVEQ	#1,D0
	AND	(A1),D0
	BEQ.S	L1T433_020
	MOVE	#128,(A1)
	MOVEQ	#44,D0
L1T433_019_:
	SUBQ	#1,D0
	BNE.S	L1T433_019_
	MOVEQ	#16,D0
	AND	-2(A1),D0
	BNE.S	L1T433_020
	RTS
L1T433_020:
	ADDQ.L	#4,A7
L1T433_021:
	CLR	1086.W
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.L	(A7)+,A2
L39:
	MOVE	D7,D0
	BEQ	L38(PC)
L40:
	MOVE.L	#576,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	D7
	JSR	F077_aA39_(PC)
	MOVE.L	#0,A3
	CLR	-(A7)
	MOVE.L	#512,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	MOVE	#2,-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	PEA	-56(A6)
	JSR	F414_xxxx_(PC)
	ADDA	#10,A7
	MOVE	#2,-(A7)
	MOVE.L	G555_pc_D1(A4),-(A7)
	PEA	-106(A6)
	JSR	F414_xxxx_(PC)
	ADDA	#10,A7
L41:
	CMPA.L	#0,A3
L44:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	MOVE.L	G558_pc_D1(A4),-(A7)
	MOVE.L	G557_pc_D1(A4),-(A7)
	PEA	-56(A6)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#4,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	CMPI	#3,D5
	BNE.S	L45
	JSR	F432_xxxx_(PC)
	MOVE.L	#0,A3
	BRA.S	L42
L45:
	CMPI	#4,D5
	BNE.S	L46
	BRA	L1T433_060(PC)
L46:
	CMPI	#1,D5
	SEQ	D6
	AND	#1,D6
	CLR	-(A7)
	JSR	F454_xxxx_(PC)
	ADDQ.L	#2,A7
	CMPI	#1,D0
	BNE.S	L47
	MOVE	#1,D7
	BRA.S	L42
L47:
	CLR	D7
	MOVE	G568_i_Dis(A4),D0
L48:
	CMP	#0,D0
	BEQ.S	L49
	BRA.S	L51
L49:
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L50
	BRA.S	L52
L51:
	CMP	#2,D0
	BEQ.S	L52
	BRA.S	L53
L52:
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L50
	BRA.S	L54
L53:
	CMP	#4,D0
	BEQ.S	L54
	BRA.S	L55
L54:
	LEA	-106(A6),A0
	MOVE.L	A0,A3
	BRA.S	L50
	BRA.S	L56
L55:
	CMP	#3,D0
	BEQ.S	L56
	BRA.S	L57
L56:
	MOVE.L	G545_pc_D0(A4),A3
L57:
L58:
L50:
L42:
	CMPI	#0,D7
	BEQ	L41(PC)
L43:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G551_pc_D0(A4),-(A7)
	CLR.L	-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	MOVE.L	G570_pc_Sa(A4),-(A7)
	MOVE	#65,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	G570_pc_Sa(A4),-(A7)
	MOVE.L	G569_pc_Sa(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE.L	G569_pc_Sa(A4),-(A7)
	MOVE	#60,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L59
	BRA	L1T433_059(PC)
L59:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L60
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D1,-4(A6)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
L60:
	MOVE.L	G313_ul_Ga(A4),-234(A6)
	MOVE.L	G349_ul_La(A4),-230(A6)
	MOVE	G305_ui_Pa(A4),-224(A6)
	MOVE	G306_i_Par(A4),-222(A6)
	MOVE	G307_i_Par(A4),-220(A6)
	MOVE	G308_i_Par(A4),-218(A6)
	MOVE	G309_i_Par(A4),-216(A6)
	MOVE	G411_i_Lea(A4),-214(A6)
	MOVE	G514_i_Mag(A4),-212(A6)
	MOVE	G372_ui_Ev(A4),-210(A6)
	MOVE	G373_ui_Fi(A4),-208(A6)
	MOVE	G369_ui_Ev(A4),-206(A6)
	MOVE	G377_ui_Cu(A4),-204(A6)
	MOVE.L	G361_l_Las(A4),-202(A6)
	MOVE.L	G362_l_Las(A4),-198(A6)
	MOVE	G310_i_Dis(A4),-194(A6)
	MOVE	G311_i_Pro(A4),-192(A6)
	MOVE	G312_i_Las(A4),-190(A6)
	MOVE	G414_T_Lea(A4),-226(A6)
	MOVE	G376_ui_Ma(A4),-188(A6)
	MOVE	#80,-(A7)
	PEA	-186(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#96,-(A7)
	PEA	-330(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	LEA	-234(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-330(A6)
	MOVE	#128,-326(A6)
	MOVE.L	G375_ps_Ac(A4),D0
	MOVE.L	D0,-324(A6)
	MOVE	G376_ui_Ma(A4),D0
	MULU	#16,D0
	MOVE	D0,-320(A6)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-318(A6)
	MOVE	#3328,-314(A6)
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,-312(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	MOVE	D0,-308(A6)
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,-306(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	MOVE	D0,-302(A6)
	MOVE	D6,306(A2)
	MOVE	#132,-(A7)
	LEA	380(A2),A0
	MOVE.L	A0,-(A7)
	PEA	G534_ac_Sa(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G525_l_Gam(A4),308(A2)
	MOVE	G528_i_For(A4),D0
	MOVE.B	D0,301(A2)
	MOVE	G529_i_Use(A4),D0
	MOVE.B	D0,300(A2)
	MOVE	G527_i_Pla(A4),376(A2)
	MOVE	G526_ui_Du(A4),378(A2)
	CLR	D5
	BRA.S	L61
L62:
	JSR	F027_AA59_(PC)
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	LEA	312(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L61:
	CMPI	#16,D5
	BLT.S	L62
L63:
	CLR	D5
	BRA.S	L64
L65:
	MOVE	D5,D0
	MULS	#6,D0
	LEA	-326(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	312(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D5,D0
	MULS	#6,D0
	LEA	-330(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F418_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	344(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L66:
	ADDQ	#1,D5
L64:
	CMPI	#5,D5
	BLT.S	L65
L67:
	MOVE.L	A2,-(A7)
	JSR	F430_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L68
	BRA	L1T433_059(PC)
L68:
	CLR	D5
	BRA.S	L69
L70:
	PEA	-2(A6)
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	312(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D5,D0
	MULS	#6,D0
	LEA	-326(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D5,D0
	MULS	#6,D0
	LEA	-330(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F420_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BNE.S	L73
	BRA	L1T433_059(PC)
L73:
L71:
	ADDQ	#1,D5
L69:
	CMPI	#5,D5
	BLT.S	L70
L72:
	LEA	-6(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	CLR	-6(A6)
	MOVE	#44,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L74
	BRA	L1T433_059(PC)
L74:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L75
	BRA	L1T433_059(PC)
L75:
	MOVE	G282_ui_Du(A4),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L76
	BRA	L1T433_059(PC)
L76:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L77
	BRA	L1T433_059(PC)
L77:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L78
	BRA	L1T433_059(PC)
L78:
	CLR	D5
	BRA.S	L79
L80:
	MOVE	D5,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	LEA	G235_auc_G(A4),A0
	ADDA	D5,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L83
	BRA.S	L1T433_059
L83:
L81:
	ADDQ	#1,D5
L79:
	CMPI	#16,D5
	BLT.S	L80
L82:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L84
	BRA.S	L1T433_059
L84:
	MOVE	#2,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L85
	BRA.S	L1T433_059
L85:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L86
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L86:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L87
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	-4(A6),D0
	MOVE	D0,(A0)
L87:
	MOVE	#1,G524_B_Res(A4)
	BRA.S	L1T433_060
L1T433_059:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	CLR.L	-(A7)
	MOVE.L	G540_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
L1T433_060:
	MOVE.L	#512,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F457_AA08_(PC)
	JSR	F078_xzzz_(PC)
L34:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$33:	.EQU	#-338
F434_xxxx_:/* global */
	LINK	A6,L$88
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-8(A6)
	CLR	G530_B_Loa(A4)
	MOVE	G298_B_New(A4),D0
	BEQ	L90(PC)
	PEA	-20(A6)
	MOVE.L	#8,-(A7)
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CMPI.L	#8,D0
	BEQ.S	L91
	BRA	L2T434_043(PC)
L91:
	CMPI	#-32508,-20(A6)
	BEQ.S	L92
	CLR	-(A7)
	MOVE	G521_i_Gam(A4),-(A7)
	CLR.L	-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	BRA	L93(PC)
L92:
	MOVE	-14(A6),G526_ui_Du(A4)
	MOVE	#1,G530_B_Loa(A4)
	MOVE	#2,-(A7)
	MOVE.L	-18(A6),D0
	MOVE.L	D0,G532_l_Dec(A4)
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G531_puc_D(A4)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	G521_i_Gam(A4),-(A7)
	CLR.L	-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	SUBQ.L	#8,D0
	MOVE.L	D0,-12(A6)
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A3
	CLR	-(A7)
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE.L	#8,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	A3,-(A7)
	MOVE.L	-12(A6),D0
	MOVE.L	D0,-(A7)
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	-12(A6),D1
	CMP.L	D1,D0
	BEQ.S	L94
	BRA	L2T434_043(PC)
L94:
	MOVE.L	-18(A6),-(A7)
	MOVE.L	G531_puc_D(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F455_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	-12(A6),-(A7)
	JSR	F470_xzzz_(PC)
	ADDQ.L	#4,A7
L93:
L90:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L95
	MOVE	#1,-(A7)
	MOVE.L	#44,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G278_ps_Du(A4)
L95:
	MOVE	#44,-(A7)
	PEA	-8(A6)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L96
	BRA	L2T434_043(PC)
L96:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L97
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	8(A0),D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G306_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G307_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	AND	#3,D0
	MOVE	D0,G308_i_Par(A4)
	CLR	G309_i_Par(A4)
L97:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D7
	AND	#255,D7
	MOVE	G523_B_Res(A4),D0
	BNE.S	L98
	MOVE	#1,-(A7)
	MOVE	#16,D0
	MULS	D7,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G277_ps_Du(A4)
L98:
	MOVE	D7,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L99
	BRA	L2T434_043(PC)
L99:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L100
	MOVE	#1,-(A7)
	MOVE	D7,D0
	ASL	#1,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G281_pi_Du(A4)
L100:
	MOVE	#0,D4
	MOVE	D4,D5
	BRA.S	L101
L102:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
	MOVE	D5,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	ADDQ	#1,D0
	ADD	D0,D4
	ADDQ	#1,D5
L101:
	MOVE	D5,D0
	CMP	D7,D0
	BLT.S	L102
L103:
	MOVE	D4,G282_ui_Du(A4)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L104
	MOVE.L	G278_ps_Du(A4),A0
	ADDI	#300,10(A0)
L104:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L105
	MOVE	#1,-(A7)
	MOVE	D4,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G280_pui_D(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G283_pT_Sq(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	AND.L	#65535,D0
	ASL.L	#1,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G260_pui_D(A4)
L105:
	MOVE	D4,D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L106
	BRA	L2T434_043(PC)
L106:
	MOVE	D5,D0
	MULS	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L107
	BRA	L2T434_043(PC)
L107:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L108
	CLR	D4
	BRA.S	L109
L110:
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L111:
	ADDQ	#1,D4
L109:
	CMPI	#300,D4
	BCS.S	L110
L112:
L108:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L113
	BRA	L2T434_043(PC)
L113:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L114
	MOVE	#100,G369_ui_Ev(A4)
L114:
	CLR	D6
	BRA	L115(PC)
L116:
	MOVE	D6,D5
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D5
	LEA	12(A0),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L119
	MOVE	D5,D0
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	CMPI	#15,D6
	BNE.S	L120
	MOVE	#768,D0
	BRA.S	L121
L120:
	MOVE	#1024,D0
L121:
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L119:
	LEA	G235_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE	G523_B_Res(A4),D0
	BNE.S	L122
	MOVE	#1,-(A7)
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULU	D4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,D1
	ASL.L	#2,D1
	LEA	G284_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L122:
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE	D4,D0
	MULU	D5,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L123
	BRA	L2T434_043(PC)
L123:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L124
	CMPI	#4,D6
	BEQ.S	L126
	CMPI	#14,D6
	BLT.S	L125
L126:
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D0,G369_ui_Ev(A4)
L125:
	MOVE	D4,D1
	LSR	#1,D1
	MOVE	D1,D4
	MOVE	D1,-30(A6)
	MOVE	D5,D1
	MULU	-30(A6),D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	BRA.S	L127
L128:
	MOVE	#-1,(A3)
L129:
	MOVE	D5,D0
	SUBQ	#1,D5
	MOVE	D4,D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
L127:
	MOVE	D5,D0
	BNE.S	L128
L130:
L124:
L117:
	ADDQ	#1,D6
L115:
	CMPI	#16,D6
	BLT	L116(PC)
L118:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L131
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G276_puc_D(A4)
L131:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	PEA	-8(A6)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L132
	BRA	L2T434_043(PC)
L132:
	MOVE	#2,-(A7)
	PEA	-6(A6)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L133
	MOVE	-6(A6),D0
	CMP	-8(A6),D0
	BEQ.S	L133
	BRA	L2T434_043(PC)
L133:
	MOVE	G523_B_Res(A4),D0
	BNE	L134(PC)
	PEA	F433_AA39_(PC)
	JSR	F079_a002_(PC)
	ADDQ.L	#4,A7
	CMPI	#-16488,D0
	BNE	L134(PC)
	MOVE	#1,-(A7)
	MOVE	G282_ui_Du(A4),D0
	ADD	D7,D0
	MULU	#4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G279_pppuc(A4)
	MOVE.L	G279_pppuc(A4),D0
	MOVE	D7,D1
	EXT.L	D1
	ASL.L	#2,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
	CLR	D5
	BRA	L135(PC)
L136:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
	MOVE.L	G276_puc_D(A4),D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
	MOVE	#1,D6
	BRA.S	L139
L140:
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	ADDQ	#1,D1
	MOVE.L	-4(A6),D0
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
L141:
	ADDQ	#1,D6
L139:
	MOVE	D6,D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#1984,D1
	LSR	#6,D1
	CMP	D1,D0
	BLS.S	L140
L142:
L137:
	ADDQ	#1,D5
L135:
	MOVE	D5,D0
	CMP	D7,D0
	BLT	L136(PC)
L138:
L134:
	MOVE	G530_B_Loa(A4),D0
	BEQ.S	L143
	CLR	G530_B_Loa(A4)
	MOVE.L	-18(A6),-(A7)
	JSR	F470_xzzz_(PC)
	ADDQ.L	#4,A7
L143:
	JSR	F423_xxxx_(PC)
	MOVE	#1,D0
	BRA.S	L89
L2T434_043:
	MOVE	#0,D0
L89:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$88:	.EQU	#-30
F435_xxxx_:/* global */
	LINK	A6,L$144
	MOVEM.L	A3/D7-D5,-(A7)
	CLR	D5
	MOVE	#2,G528_i_For(A4)
	MOVE	#1,G529_i_Use(A4)
	MOVE	#1,G527_i_Pla(A4)
	MOVE	#10,G526_ui_Du(A4)
	MOVE.L	#0,A3
	MOVE	G298_B_New(A4),D0
	BEQ.S	L146
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	TST	D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D5
DATA SEG "s!"
s!:
	DATA 5C 44 55 4E 47 45 4F 4E 2E 44 41 54 00 00 
CODE SEG "start"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,G521_i_Gam(A4)
	BGE.S	L147
	MOVE	#50,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L149:
L150:
	BRA.S	L149
L151:
L147:
L3T435_002:
	CLR	G524_B_Res(A4)
	CLR	G305_ui_Pa(A4)
	MOVE	#-1,G414_T_Lea(A4)
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE	D1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,G525_l_Gam(A4)
	BRA	L152(PC)
L146:
	MOVE.L	#0,A3
	MOVE	#2,-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	PEA	-50(A6)
	JSR	F414_xxxx_(PC)
	ADDA	#10,A7
	MOVE	#2,-(A7)
	MOVE.L	G555_pc_D1(A4),-(A7)
	PEA	-100(A6)
	JSR	F414_xxxx_(PC)
	ADDA	#10,A7
L3T435_004:
	CMPI	#1,G567_B_Sin(A4)
	BNE.S	L153
	MOVE	#2,-(A7)
	JSR	F452_xxxx_(PC)
	ADDQ.L	#2,A7
	CMPI	#1,D0
	BNE.S	L154
	BRA.S	L3T435_009
L154:
	BRA.S	L155
L153:
	CMPA.L	#0,A3
	BNE.S	L156
	BRA.S	L3T435_009
L156:
L155:
L157:
	CMPA.L	#0,A3
L160:
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G556_pc_D1(A4),-(A7)
	PEA	-50(A6)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	CMPI	#2,D7
	BNE.S	L161
L3T435_008:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,D0
	BRA	L145(PC)
L161:
L3T435_009:
	MOVE	#1,-(A7)
	JSR	F454_xxxx_(PC)
	ADDQ.L	#2,A7
	CMPI	#1,D0
	BNE.S	L162
	CLR	D6
	CLR	-(A7)
	MOVE.L	G569_pc_Sa(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L163
	CLR	-(A7)
	MOVE.L	G570_pc_Sa(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L164
	MOVE	#1,D6
	BRA.S	L165
L164:
DATA SEG "s!"
	DATA 41 3A 5C 44 55 4E 47 45 4F 4E 2E 46 54 4C 00 00 
CODE SEG "start"
	MOVE	G523_B_Res(A4),D0
	BNE.S	L166
	CLR	-(A7)
	PEA	s!+14(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L166
	MOVE	#1,D5
	MOVE	#1,G298_B_New(A4)
	BRA	L3T435_002(PC)
L166:
	MOVE.L	G539_pc_D0(A4),A3
	MOVE	#3,G568_i_Dis(A4)
L165:
L163:
	BRA.S	L167
L162:
	CMPI	#0,G568_i_Dis(A4)
	BNE.S	L168
	MOVE.L	G542_pc_D0(A4),A3
	BRA.S	L169
L168:
	CMPI	#3,G568_i_Dis(A4)
	BNE.S	L170
	MOVE.L	G545_pc_D0(A4),A3
	BRA.S	L171
L170:
	CMPI	#2,G568_i_Dis(A4)
	BNE.S	L172
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L173
L172:
	CMPI	#4,G568_i_Dis(A4)
	BNE.S	L174
	LEA	-100(A6),A0
	MOVE.L	A0,A3
L174:
L173:
L171:
L169:
L167:
L158:
	CMPI	#1,G568_i_Dis(A4)
	BNE	L157(PC)
L159:
	PEA	-740(A6)
	JSR	F429_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L175
	BRA	L3T435_037(PC)
L175:
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L176
	MOVE.L	-432(A6),D0
	CMP.L	G525_l_Gam(A4),D0
	BEQ.S	L176
	MOVE.L	G546_pc_D0(A4),A3
	BRA	L3T435_004(PC)
L176:
	MOVE.L	-432(A6),G525_l_Gam(A4)
	MOVE	#132,-(A7)
	PEA	G534_ac_Sa(A4)
	PEA	-360(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.B	-439(A6),D0
	AND	#255,D0
	CMP	#1,D0
	BEQ.S	L177
	CMPI	#1,-364(A6)
	BEQ.S	L177
	BRA	L3T435_037(PC)
L177:
	MOVE	-396(A6),-(A7)
	MOVE	-428(A6),-(A7)
	MOVE	#128,-(A7)
	PEA	-228(A6)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L178
	BRA	L3T435_037(PC)
L178:
	MOVE.L	-228(A6),D0
	MOVE.L	D0,G313_ul_Ga(A4)
	MOVE.L	D0,G319_ul_Lo(A4)
	MOVE.L	-224(A6),G349_ul_La(A4)
	MOVE	-218(A6),G305_ui_Pa(A4)
	MOVE	-216(A6),G306_i_Par(A4)
	MOVE	-214(A6),G307_i_Par(A4)
	MOVE	-212(A6),G308_i_Par(A4)
	MOVE	-210(A6),G309_i_Par(A4)
	MOVE	-208(A6),G411_i_Lea(A4)
	MOVE	-206(A6),G514_i_Mag(A4)
	MOVE	-204(A6),G372_ui_Ev(A4)
	MOVE	-202(A6),G373_ui_Fi(A4)
	MOVE	-200(A6),G369_ui_Ev(A4)
	MOVE	-198(A6),G377_ui_Cu(A4)
	MOVE.L	-196(A6),G361_l_Las(A4)
	MOVE.L	-192(A6),G362_l_Las(A4)
	MOVE	-188(A6),G310_i_Dis(A4)
	MOVE	-186(A6),G311_i_Pro(A4)
	MOVE	-184(A6),G312_i_Las(A4)
	MOVE	-220(A6),G414_T_Lea(A4)
	MOVE	-182(A6),G376_ui_Ma(A4)
	MOVE	G523_B_Res(A4),D0
	BNE.S	L179
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
L179:
	MOVE	-394(A6),-(A7)
	MOVE	-426(A6),-(A7)
	MOVE	#16,D0
	MULU	G376_ui_Ma(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G375_ps_Ac(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L180
	BRA	L3T435_037(PC)
L180:
	MOVE	-392(A6),-(A7)
	MOVE	-424(A6),-(A7)
	MOVE	#3328,-(A7)
	PEA	G407_s_Par(A4)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L181
	BRA	L3T435_037(PC)
L181:
	MOVE	-390(A6),-(A7)
	MOVE	-422(A6),-(A7)
	MOVE	#10,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G370_ps_Ev(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L182
	BRA	L3T435_037(PC)
L182:
	MOVE	-388(A6),-(A7)
	MOVE	-420(A6),-(A7)
	MOVE	#2,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G371_pi_Ti(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L183
	BRA	L3T435_037(PC)
L183:
L152:
	JSR	F434_xxxx_(PC)
	TST	D0
	BNE.S	L184
	BRA	L3T435_037(PC)
L184:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	G298_B_New(A4),D0
	BEQ.S	L185
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
	MOVE	D5,D0
	BEQ.S	L186
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L186:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	BRA	L187(PC)
L185:
	MOVE.B	-440(A6),D0
	AND	#255,D0
	MOVE	D0,G529_i_Use(A4)
	MOVE.B	-439(A6),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L188
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D7
	AND	#255,D7
	CMPI	#14,D7
	BNE.S	L189
	MOVE.L	G278_ps_Du(A4),A0
	CMPI	#99,(A0)
	BNE.S	L189
	MOVE	#10,G526_ui_Du(A4)
	BRA.S	L190
L189:
	CMPI	#10,D7
	BNE.S	L191
	MOVE.L	G278_ps_Du(A4),A0
	CMPI	#76,(A0)
	BNE.S	L191
	MOVE	#13,G526_ui_Du(A4)
	BRA.S	L192
L191:
	CLR	G526_ui_Du(A4)
L192:
L190:
	BRA.S	L193
L188:
	MOVE.B	-439(A6),D0
	AND	#255,D0
	MOVE	D0,G528_i_For(A4)
	MOVE	-364(A6),G527_i_Pla(A4)
	MOVE	-362(A6),G526_ui_Du(A4)
L193:
	MOVE	#1,G524_B_Res(A4)
	MOVE	D6,D0
	BEQ.S	L194
	MOVE.L	G569_pc_Sa(A4),-(A7)
	MOVE.L	G570_pc_Sa(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
L194:
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G552_pc_D1(A4),-(A7)
	CLR.L	-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
L187:
	CLR	G303_B_Par(A4)
	MOVE	#1,D0
	BRA.S	L145
L3T435_037:
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L195
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	MOVE.L	G549_pc_D0(A4),-(A7)
	MOVE.L	G547_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L3T435_008(PC)
L195:
	MOVE.L	G547_pc_D0(A4),-(A7)
	MOVE	#9,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L197:
L198:
	BRA.S	L197
L199:
L145:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$144:	.EQU	#-740
F436_xxxx_:/* global */
	LINK	A6,L$200
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	#-32192,A3
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-4(A6)
	CLR	D4
	BRA	L202(PC)
L203:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	BRA	L206(PC)
L207:
	MOVE	D5,D7
	ASL.L	#1,D7
	MOVE.L	A3,A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D5,D6
	ASL.L	#1,D6
	MOVE.L	8(A6),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BLS.S	L210
	SUBQ	#1,D7
L210:
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BCC.S	L211
	ADDQ	#1,D7
L211:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BLS.S	L212
	SUB	#16,D7
L212:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BCC.S	L213
	ADD	#16,D7
L213:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BLS.S	L214
	SUB	#256,D7
L214:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BCC.S	L215
	ADD	#256,D7
L215:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D7,(A0)
L208:
	ADDQ	#1,D5
L206:
	CMPI	#16,D5
	BLT	L207(PC)
L209:
L204:
	ADDQ	#1,D4
L202:
	CMPI	#8,D4
	BLT	L203(PC)
L205:
	MOVE.L	-4(A6),-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L201:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$200:	.EQU	#-4
F437_xxxx_:/* global */
	LINK	A6,L$216
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	G578_B_Use(A4)
	CMPI.L	#138060,G648_l_Ava(A4)
	BGE.S	L218
	BRA	L217(PC)
L218:
	CLR	-(A7)
	MOVE.L	#133056,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D4
	ADD.L	#256,D4
	AND.L	#-256,D4
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	D4,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	ADD.L	#32000,D4
	MOVE.L	G348_pl_Bi(A4),D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,A2
	MOVE.L	A3,D0
	MOVE.L	D0,-8(A6)
	MOVE.L	D0,-92(A6)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-340(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#137,-(A7)
	CLR	-(A7)
	PEA	G005_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#1911,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#80,-(A7)
	CLR	-(A7)
	PEA	G004_s_Gra(A4)
	MOVE.L	D4,D0
	MOVE.L	D0,-96(A6)
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADD.L	#9120,D4
	MOVE	#12,D6
	MOVE	#48,D5
	CLR	D7
	BRA	L219(PC)
L220:
	MOVE.L	D4,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-88(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	PEA	G017_auc_G(A4)
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	#80,-(A7)
	MOVE	#320,-(A7)
	MOVE.L	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	#320,D0
	SUB	D5,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-308(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D5,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-306(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#160,D0
	SUB	D6,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-304(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D6,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-302(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D0
	ADD	#15,D0
	EXT.L	D0
	DIVS	#16,D0
	MULS	#8,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-300(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MULU	D6,D0
	AND.L	#65535,D0
	ADD.L	D0,D4
	ADDQ	#4,D6
	ADD	#16,D5
L221:
	ADDQ	#1,D7
L219:
	CMPI	#18,D7
	BLT	L220(PC)
L222:
	MOVE	#2,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	-92(A6),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	-92(A6),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#1345,-334(A6)
	MOVE	#1057,-332(A6)
	MOVE	#1617,-330(A6)
	MOVE	#1329,-328(A6)
	MOVE	#1906,-324(A6)
	MOVE	#1792,-310(A6)
	MOVE	#2,-320(A6)
	MOVE	#2,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	D7
	BRA	L223(PC)
L224:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-300(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-308(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	-88(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
L225:
	ADDQ	#1,D7
L223:
	CMPI	#18,D7
	BLT	L224(PC)
L226:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G003_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-96(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	CLR	-320(A6)
	MOVE	#1792,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE.L	#133056,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L217:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$216:	.EQU	#-340
F438_xxxx_:/* global */
	LINK	A6,L$227
	MOVEM.L	A3/D7,-(A7)
	LEA	G562_apuc_(A4),A0
	MOVE.L	A0,A3
	MOVE.L	G348_pl_Bi(A4),D0
	ADD.L	#4800,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	36(A3),D0
	MOVE.L	D0,-8(A6)
	MOVE	#1,D7
L229:
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	CMPI	#1,D0
	BNE.S	L232
	MOVE	#1,-(A7)
	MOVE	#145,-(A7)
	MOVE.L	G565_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
L232:
	MOVE	#20608,-(A7)
	MOVE.L	36(A3),-(A7)
	MOVE.L	32(A3),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#112,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G006_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	G007_s_Gra+2(A4),D0
	CMPI	#0,D0
	BLT.S	L233
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#252,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G007_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,G007_s_Gra+2(A4)
L233:
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G008_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	#4,D0
	MOVE	D7,D1
	AND	#3,D1
	ADD	D1,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADDQ	#4,G008_s_Gra(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVEM.L	A6-A2/D7-D4,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.L	-8(A6),A1
	MOVE	#160,D0
L6T438_004:
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,(A0)
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,48(A0)
	MOVEM.L	(A1)+,D1-D4
	MOVEM.L	D1-D4,96(A0)
	MOVE.B	(A1),112(A0)
	MOVE.B	2(A1),114(A0)
	MOVE.B	4(A1),116(A0)
	MOVE.B	6(A1),118(A0)
	LEA	160(A0),A0
	LEA	16(A1),A1
	DBF	D0,L6T438_004
	MOVEM.L	(A7)+,D4-D7/A2-A6
L230:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMPI	#32,D0
	BNE	L229(PC)
L231:
L228:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$227:	.EQU	#-8
F439_xxxx_:/* global */
	LINK	A6,L$234
	MOVE	D7,-(A7)
	MOVE	#255,G309_i_Par(A4)
	MOVE	#1,G297_B_Dra(A4)
	MOVE	#5,G273_i_Cur(A4)
	MOVE	#5,G274_i_Cur(A4)
	LEA	-128(A6),A0
	MOVE.L	A0,G271_ppuc_(A4)
	LEA	-170(A6),A0
	MOVE.L	A0,G269_ps_Cu(A4)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	#25,-(A7)
	PEA	-154(A6)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
	CLR	D7
	BRA.S	L236
L237:
	MOVE	D7,D0
	MULU	#5,D0
	LEA	-154(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-128(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	MOVE	D7,D0
	LEA	-144(A6),A0
	ADDA	D0,A0
	MOVE.B	#32,(A0)
L238:
	ADDQ	#1,D7
L236:
	CMPI	#5,D7
	BCS.S	L237
L239:
	MOVE.B	#32,-147(A6)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G563_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	CLR	G324_B_Dra(A4)
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#160,-(A7)
	MOVE	#30,-(A7)
	CLR	-(A7)
	PEA	G009_s_Gra(A4)
	MOVE.L	G562_apuc_+32(A4),-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G010_s_Gra(A4)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G011_s_Gra(A4)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	PEA	G020_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L235:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$234:	.EQU	#-170
F440_xxxx_:/* global */
	LINK	A6,L$240
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	JSR	F494_ozzz_(PC)
	ADDQ.L	#2,A7
	AND.L	#65535,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	10(A6),A0
	MOVE.L	D0,(A0)
	MOVE.L	D0,-(A7)
	MOVE	8(A6),D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE.L	-4(A6),D0
L241:
	UNLK	A6
	RTS
L$240:	.EQU	#-4
F441_xxxx_:/* global */
	LINK	A6,L$242
	MOVEM.L	D7-D5,-(A7)
	LEA	G445_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	CLR	D7
	BRA.S	L244
L245:
	CLR	-(A7)
	MOVE.L	#10304,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G562_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L246:
	ADDQ	#1,D7
L244:
	CMPI	#8,D7
	BCS.S	L245
L247:
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+32(A4)
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+36(A4)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	MOVE	#3,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	MOVE	#2,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	PEA	G563_puc_G(A4)
	MOVE	#4,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D6
	PEA	G564_puc_G(A4)
	MOVE	#5,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G565_puc_G(A4)
	MOVE	#535,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G566_puc_G(A4)
	MOVE	#534,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	JSR	F478_gzzz_(PC)
	CLR	G578_B_Use(A4)
	CLR	-8(A6)
	MOVE	#100,-6(A6)
	CLR	-4(A6)
	MOVE	#160,-2(A6)
	MOVE	#1,D7
	BRA.S	L248
L249:
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,-6(A6)
L250:
	ADDQ	#1,D7
L248:
	CMPI	#4,D7
	BCS.S	L249
L251:
	MOVE	#127,-6(A6)
	MOVE	#5,D7
	BRA.S	L252
L253:
	ADDQ	#4,-8(A6)
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L254:
	ADDQ	#1,D7
L252:
	CMPI	#8,D7
	BCS.S	L253
L255:
L256:
	JSR	F439_xxxx_(PC)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	MOVE	#99,G298_B_New(A4)
L259:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	JSR	F380_xzzz_(PC)
L260:
	CMPI	#99,G298_B_New(A4)
	BEQ.S	L259
L261:
L257:
	CMPI	#202,G298_B_New(A4)
	BEQ.S	L256
L258:
	MOVE	#1,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G566_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	#20,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L262
	JSR	F438_xxxx_(PC)
L262:
	MOVE.L	D6,D0
	ADD.L	#82432,D0
	ADD.L	#41216,D0
	MOVE.L	D0,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L243:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$242:	.EQU	#-8
F442_AA08_:/* global */
	LINK	A6,L$263
	MOVE	#1800,-2(A6)
	JSR	F077_aA39_(PC)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G564_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L265:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L266:
	SUBQ	#1,-2(A6)
	MOVE	-2(A6),D0
	BEQ.S	L268
	MOVE	G588_i_Mou(A4),D0
	BNE.S	L268
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L265
L268:
L267:
	MOVE	#202,G298_B_New(A4)
L264:
	UNLK	A6
	RTS
L$263:	.EQU	#-2
F443_xxxx_:/* global */
	LINK	A6,L$269
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	14(A6),A3
	LEA	-50(A6),A0
	MOVE.L	A0,A2
	BRA.S	L271
L272:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#65,D0
	BLT.S	L275
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#90,D0
	BGT.S	L275
	SUBI.B	#64,(A2)
L275:
L273:
	ADDQ.L	#1,A2
L271:
	MOVE.B	(A3)+,(A2)
	BNE.S	L272
L274:
	PEA	-50(A6)
	MOVE	#12,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L270:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$269:	.EQU	#-50
F444_AA29_:/* global */
	LINK	A6,L$276
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,-132(A6)
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	CLR.L	G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	MOVE	8(A6),D0
	BEQ.S	L278
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L278
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#6,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	#240,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
L278:
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE.L	G088_apuc_+40(A4),A3
	MOVE	8(A6),D0
	BEQ.S	L279
	MOVE.L	A3,A2
	ADDA.L	#560,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#6,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L280
	MOVE.L	A3,-14(A6)
	ADDA.L	#1376,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	-14(A6),-(A7)
	MOVE	#208,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L280:
L279:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-10(A6)
	MOVE.L	D0,-(A7)
	MOVE	#-32763,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	JSR	F478_gzzz_(PC)
	MOVE	G322_B_Pal(A4),D0
	BEQ	L281(PC)
	MOVE	#32,-(A7)
	PEA	-78(A6)
	PEA	G347_aui_P(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	D6
	BRA.S	L282
L283:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D7
	BRA.S	L286
L287:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G346_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G346_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G347_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G347_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L288:
	ADDQ	#1,D7
L286:
	CMPI	#16,D7
	BLT.S	L287
L289:
L284:
	ADDQ	#1,D6
L282:
	CMPI	#7,D6
	BLE.S	L283
L285:
	CLR	G322_B_Pal(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32,-(A7)
	PEA	G347_aui_P(A4)
	PEA	-78(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	BRA.S	L290
L281:
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L290:
	MOVE	8(A6),D0
	BEQ	L291(PC)
	MOVE	G302_B_Gam(A4),D0
	BEQ	L292(PC)
	MOVE	#4000,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	CLR	D7
	BRA	L293(PC)
L294:
	MOVE	D7,D6
	MULS	#48,D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-6(A6)
	MOVE	#10,-(A7)
	MOVE	#32,-(A7)
	PEA	G015_s_Gra(A4)
	MOVE.L	-14(A6),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#1,-(A7)
	MOVE	#16,-(A7)
	PEA	G016_s_Gra(A4)
	MOVE.L	-6(A6),A0
	LEA	336(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#87,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-142(A6)
	MOVE	#6,D0
	MULS	-142(A6),D0
	ADD	#87,D0
	MOVE	D0,D5
	MOVE.L	-6(A6),A0
	MOVE.B	8(A0),-1(A6)
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#44,D0
	BEQ.S	L297
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#59,D0
	BEQ.S	L297
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#45,D0
	BEQ.S	L297
	ADDQ	#6,D5
L297:
	MOVE.L	-6(A6),A0
	LEA	8(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	CLR	D5
	BRA	L298(PC)
L299:
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#16,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#1,D4
	BNE.S	L302
	BRA.S	L300
L302:
	MOVE	D4,D0
	ASL.L	#2,D0
	LEA	G428_apc_S+-8(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "start"
	PEA	s!+30(A4)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-130(A6)
	MOVE	#13,-(A7)
	MOVE	D6,D0
	ADDQ	#8,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#105,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
L300:
	ADDQ	#1,D5
L298:
	CMPI	#3,D5
	BLE	L299(PC)
L301:
	ADDI	#48,G015_s_Gra+4(A4)
	ADDI	#48,G015_s_Gra+6(A4)
	ADDI	#48,G016_s_Gra+4(A4)
	ADDI	#48,G016_s_Gra+6(A4)
L295:
	ADDQ	#1,D7
L293:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L294(PC)
L296:
	PEA	-78(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L304:
L305:
	BRA.S	L304
L306:
L292:
L12T444_017:
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#40,-(A7)
	PEA	G012_s_Gra(A4)
	MOVE.L	A2,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-110(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#32,-(A7)
	PEA	-46(A6)
	PEA	-110(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1911,-16(A6)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-132(A6),D0
	BEQ.S	L307
	MOVE	#300,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
L307:
	MOVE	G524_B_Res(A4),D0
	BEQ	L308(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	MOVE	#1,-(A7)
	PEA	G013_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G014_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
DATA SEG "s!"
	DATA 52 45 53 54 41 52 54 20 54 48 49 53 20 47 41 4D 45 00 
CODE SEG "start"
	PEA	s!+32(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#154,-(A7)
	MOVE	#110,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	#1079,-44(A6)
	MOVE	#1911,-38(A6)
	LEA	G446_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	JSR	F357_qzzz_(PC)
	JSR	F078_xzzz_(PC)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#900,D7
	BRA.S	L309
L310:
	JSR	F380_xzzz_(PC)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L309:
	SUBQ	#1,D7
	MOVE	D7,D0
	BEQ.S	L312
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L310
L312:
L311:
	JSR	F077_aA39_(PC)
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L313
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G021_aaui_(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32,-(A7)
	PEA	G346_aui_P(A4)
	PEA	G021_aaui_(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	G298_B_New(A4)
	JSR	F435_xxxx_(PC)
	CMPI	#-1,D0
	BEQ.S	L314
	JSR	F462_xxxx_(PC)
	CLR	G523_B_Res(A4)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	BRA.S	L277
L314:
L313:
L308:
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L291:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-10(A6),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L316:
L315:
	MOVE	G588_i_Mou(A4),D0
	BNE.S	L318
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L316
L318:
L317:
	MOVE	G524_B_Res(A4),D0
	BEQ.S	L319
	MOVE	8(A6),D0
	BEQ.S	L319
	CLR	-132(A6)
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L12T444_017(PC)
L319:
L321:
L322:
	BRA.S	L321
L323:
L277:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$276:	.EQU	#-142
F445_xxxx_:/* global */
	LINK	A6,L$324
	JSR	F261_hzzz_(PC)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F065_aanz_(PC)
	ADDQ.L	#1,G313_ul_Ga(A4)
L325:
	UNLK	A6
	RTS
L$324:	.EQU	#0
F446_zzzz_:/* global */
	LINK	A6,L$326
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,G302_B_Gam(A4)
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L328
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L328:
	JSR	F363_pzzz_(PC)
	MOVE	#200,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	MOVE	#100,D0
	MOVE	D0,G407_s_Par+3204(A4)
	MOVE	D0,G407_s_Par+3208(A4)
	MOVE	D0,G407_s_Par+3206(A4)
	JSR	F260_pzzz_(PC)
	JSR	F445_xxxx_(PC)
	MOVE	G306_i_Par(A4),-4(A6)
	MOVE	G307_i_Par(A4),-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#10000,6(A3)
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	#255,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F146_aczz_(PC)
	ADDQ.L	#8,A7
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F148_aayz_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,D7
	MOVE	G306_i_Par(A4),D6
	MOVE	G307_i_Par(A4),D5
L14T446_002:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L329
L330:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE.S	L333
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#50,D0
	BNE.S	L334
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,(A2)
	BRA.S	L14T446_002
L334:
L333:
L331:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L329:
	CMPI	#-2,D4
	BNE.S	L330
L332:
	MOVE	D7,D0
	BEQ.S	L335
	CLR	D7
	MOVE	-4(A6),D6
	MOVE	-6(A6),D5
	BRA.S	L14T446_002
L335:
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L336
L337:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L338:
	ADD	#40,D7
L336:
	CMPI	#255,D7
	BLE.S	L337
L339:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	#25,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L340
L341:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L342:
	ADD	#40,D7
L340:
	CMPI	#255,D7
	BLE.S	L341
L343:
	MOVE	#4,D6
	BRA.S	L344
L345:
	MOVE	#5,D7
	BRA.S	L347
L348:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
	AND	#1,D0
	BEQ.S	L350
	MOVE	#25,D0
	BRA.S	L351
L350:
	MOVE	#23,D0
L351:
	MOVE.B	D0,4(A3)
	MOVE	D6,D5
	BRA.S	L352
L353:
	JSR	F445_xxxx_(PC)
L352:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L353
L354:
L347:
	SUBQ	#1,D7
	BNE.S	L348
L349:
L344:
	SUBQ	#1,D6
	BNE.S	L345
L346:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
	MOVE.B	#26,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#1,G077_B_DoN(A4)
	JSR	F445_xxxx_(PC)
	CLR	D7
	BRA.S	L355
L356:
	CLR	D6
	BRA.S	L359
L360:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L363
	MOVE	D7,D0
	CMP	-4(A6),D0
	BNE.S	L364
	MOVE	D6,D0
	CMP	-6(A6),D0
	BEQ.S	L363
L364:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
L363:
L361:
	ADDQ	#1,D6
L359:
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BLT.S	L360
L362:
L357:
	ADDQ	#1,D7
L355:
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BLT.S	L356
L358:
	JSR	F445_xxxx_(PC)
	CLR	-(A7)
	CLR	-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CLR	D7
	BRA.S	L365
L366:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#2,D0
	BNE.S	L368
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L368:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L365:
	CMPI	#-2,D4
	BNE.S	L366
L367:
	MOVE.B	#65,-9(A6)
	MOVE	D7,D5
	BRA.S	L369
L370:
	CLR	D6
	BRA.S	L372
L373:
	MOVE	#-32767,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	PEA	-226(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	-225(A6),D0
	MOVE.B	-9(A6),D1
	EXT	D1
	EXT	D0
	CMP	D1,D0
	BNE.S	L376
	JSR	F043_aahz_(PC)
	MOVE.B	#10,-225(A6)
	PEA	-225(A6)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F445_xxxx_(PC)
	MOVE	#780,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	ADDQ.B	#1,-9(A6)
	BRA.S	L375
L376:
L374:
	ADDQ	#1,D6
L372:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L373
L375:
L369:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L370
L371:
	MOVE	#600,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	CLR	G524_B_Res(A4)
	MOVE	#1,-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L327:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$326:	.EQU	#-226
F447_xxxx_:/* global */
	LINK	A6,L$377
	MOVE	8(A6),D0
	BNE.S	L379
L381:
L382:
	BRA.S	L381
L383:
L379:
L378:
	UNLK	A6
	RTS
L$377:	.EQU	#0
