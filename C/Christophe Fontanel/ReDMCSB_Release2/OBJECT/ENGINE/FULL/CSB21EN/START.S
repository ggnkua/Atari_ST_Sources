CODE SEG "start"
F456_vzzz_:/* global */
	LINK	A6,L$0
	MOVE	G300_B_Par(A4),D0
	BNE.S	L2
	JSR	F077_aA39_(PC)
	JSR	F363_pzzz_(PC)
	CLR	G578_B_Use(A4)
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L3
	JSR	F334_akzz_(PC)
	BRA.S	L4
L3:
	CLR	-(A7)
	PEA	G002_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
L4:
	CLR	-(A7)
	PEA	G000_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
	CLR	-(A7)
	PEA	G001_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L2:
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#0
F457_AA08_:/* global */
	LINK	A6,L$5
	MOVE	D7,-(A7)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L7
	JSR	F379_jzzz_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L8
L7:
	MOVE	G514_i_Mag(A4),D7
	MOVE	#-1,G514_i_Mag(A4)
	MOVE	D7,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G506_i_Act(A4),D0
	BNE.S	L9
	MOVE	#1,G509_B_Act(A4)
L9:
	JSR	F387_hzzz_(PC)
	MOVE	G423_i_Inv(A4),D7
	BEQ.S	L10
	CLR	G423_i_Inv(A4)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L11
L10:
	JSR	F098_rzzz_(PC)
	JSR	F395_pzzz_(PC)
L11:
	JSR	F069_aaaL_(PC)
L8:
	CLR	G328_i_Tim(A4)
L6:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$5:	.EQU	#0
F458_xxxx_:/* global */
	LINK	A6,L$12
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	_base(A4),D0
	ADD.L	#128,D0
	MOVE.L	D0,A3
	MOVE.B	(A3)+,D7
	AND	#255,D7
	CLR	D6
	BRA.S	L14
L15:
	MOVE.L	A3,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE.L	8(A6),A0
	ADDA	D6,A0
	MOVE.B	D0,(A0)
L16:
	ADDQ	#1,D6
L14:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L15
L17:
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE	D7,D0
L13:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$12:	.EQU	#0
F459_xxxx_:/* global */
	LINK	A6,L$18
	MOVE	8(A6),D0
	MULS	12(A6),D0
	MOVE	12(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	10(A6),D1
	MULS	12(A6),D1
	MOVE	12(A6),D2
	ASR	#1,D2
	ADD	D2,D1
	ASR	#5,D1
	MULS	D1,D0
L19:
	UNLK	A6
	RTS
L$18:	.EQU	#0
F460_xxxx_:/* global */
	LINK	A6,L$20
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,-(A7)
	MOVE.L	#3248,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G085_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#7840,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G084_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#392,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+52(A4)
	MOVE	#1,-(A7)
	MOVE.L	#392,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+56(A4)
	MOVE	#1,-(A7)
	MOVE.L	#3264,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+48(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5112,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+44(A4)
	MOVE	#1,-(A7)
	MOVE.L	#14208,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+40(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+36(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+32(A4)
	MOVE	#1,-(A7)
	MOVE.L	#144,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+28(A4)
	MOVE	#1,-(A7)
	MOVE.L	#256,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+24(A4)
	MOVE	#1,-(A7)
	MOVE.L	#688,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+20(A4)
	MOVE	#1,-(A7)
	MOVE.L	#704,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+16(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1560,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+12(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1504,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+8(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1504,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1968,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+4(A4)
	MOVE	#1,-(A7)
	MOVE.L	#15232,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G296_puc_B(A4)
	MOVE.L	G296_puc_B(A4),D0
	ADD.L	#3248,D0
	MOVE.L	D0,G086_puc_B(A4)
	MOVE.L	G086_puc_B(A4),D0
	ADD.L	#4144,D0
	MOVE.L	D0,G087_puc_B(A4)
	CLR	-(A7)
	CLR	-(A7)
	LEA	G229_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32210,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G479_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32207,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G505_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32208,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G259_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32209,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G067_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32206,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#15232,(A0)
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#4560,2(A0)
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#1184,4(A0)
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#888,6(A0)
	MOVE	#15,D7
	BRA.S	L22
L23:
	MOVE	D7,D0
	ADD	#286,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G103_aai_C(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G103_aai_C+2(A4),A0
	ADDA	D0,A0
	MOVE	#1,(A0)
	MOVE	D7,D0
	MULS	#2,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#984,136(A0)
	MOVE	D7,D0
	MULS	#2,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#1952,138(A0)
L24:
	ADDQ	#1,D7
L22:
	CMPI	#16,D7
	BLE.S	L23
L25:
	MOVE	#241,G102_aai_C+60(A4)
	MOVE	#1,G102_aai_C+62(A4)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G209_as_Gr(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA	L26(PC)
L27:
	MOVE	#104,D5
	MOVE.B	1(A3),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	#16,-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE.B	4(A3),D0
	AND	#255,D0
	AND	#1,D0
	BEQ.S	L30
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ	#1,D5
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ	#1,D5
L30:
	MOVE.B	4(A3),D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L31
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ	#1,D5
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L31:
L28:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#6,A3
L26:
	CMPI	#85,D7
	BLT	L27(PC)
L29:
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G210_as_Gr(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-4(A6)
	BRA	L32(PC)
L33:
	MOVE.L	-4(A6),A0
	MOVE	4(A0),D0
	AND	#256,D0
	BNE	L36(PC)
	MOVE	#282,D5
	MOVE.L	-4(A6),A0
	MOVE.B	1(A0),D3
	AND	#255,D3
	ADD	D3,D5
	CLR	D6
	BRA	L37(PC)
L38:
	LEA	G215_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE.L	-4(A6),A0
	MOVE	4(A0),D0
	AND	#3,D0
	CMPI	#3,D0
	BEQ.S	L41
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	D4,12(A0)
	MOVE.L	-4(A6),A0
	MOVE	4(A0),D0
	AND	#3,D0
	CMPI	#2,D0
	BEQ.S	L42
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	D4,24(A0)
L42:
L41:
L39:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D5,D0
	ADDQ	#1,D5
L37:
	CMPI	#6,D6
	BLT	L38(PC)
L40:
L36:
L34:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,-4(A6)
L32:
	CMPI	#14,D7
	BLT	L33(PC)
L35:
	LEA	G213_auc_G(A4),A0
	MOVE.L	A0,G075_apuc_(A4)
	LEA	G214_auc_G(A4),A0
	MOVE.L	A0,G075_apuc_+4(A4)
	LEA	G017_auc_G(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,G075_apuc_+12(A4)
	MOVE.L	D0,G075_apuc_+8(A4)
	MOVE	#438,D5
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G211_as_Gr(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-8(A6)
	BRA.S	L43
L44:
	MOVE	#4,D6
	BRA.S	L47
L48:
	MOVE	D6,-(A7)
	MOVE.L	-8(A6),A0
	MOVE.B	1(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	-8(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L49:
	ADDQ	#2,D6
L47:
	CMPI	#32,D6
	BLT.S	L48
L50:
	CMPI	#3,D7
	BNE.S	L51
	MOVE.L	-8(A6),A0
	MOVE.B	(A0),D0
	MOVE.L	-8(A6),A0
	MOVE.B	1(A0),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L51:
L45:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	-8(A6),D0
	ADDQ.L	#2,-8(A6)
L43:
	CMPI	#4,D7
	BLT.S	L44
L46:
	MOVE	#495,D5
	CLR	D6
	BRA	L52(PC)
L53:
	MOVE	D6,D0
	MULS	#12,D0
	LEA	G219_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D6,D7
	MULS	#26,D7
	LEA	G243_as_Gr+4(A4),A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D5,2(A2)
	MOVE	#16,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-12(A6)
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-10(A6)
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L56
	MOVE	#16,-(A7)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L56:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L57
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-12(A6),(A0)
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-10(A6),(A0)
L57:
	MOVE	D7,D0
	AND	#32,D0
	BEQ.S	L58
	MOVE	#16,-(A7)
	MOVE.B	9(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	8(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	9(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	8(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L58:
	MOVE	D7,D0
	AND	#3,D0
	MOVE	D0,-12(A6)
	BEQ	L59(PC)
L60:
	MOVE.B	4(A2),D0
	MOVE.B	5(A2),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#16,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L61:
	SUBQ	#1,-12(A6)
	BNE.S	L60
L62:
L59:
L54:
	ADDQ	#1,D6
L52:
	CMPI	#27,D6
	BLT	L53(PC)
L55:
L21:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$20:	.EQU	#-12
F461_AA08_:/* global */
	LINK	A6,L$63
	MOVE	#1,-(A7)
	MOVE.L	#3264,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G090_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5112,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G091_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#14208,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G092_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G093_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G094_puc_B(A4)
L64:
	UNLK	A6
	RTS
L$63:	.EQU	#0
F462_xxxx_:/* global */
	LINK	A6,L$65
	CLR	G331_B_Pre(A4)
	CLR	G332_B_Sto(A4)
	CLR	G333_B_Pre(A4)
	CLR	G334_B_Sto(A4)
	CLR	G340_B_Hig(A4)
	CLR	G341_B_Hig(A4)
	CLR	G300_B_Par(A4)
	MOVE	#15,G069_ui_St(A4)
	CLR	G070_B_Sec(A4)
	CLR	G071_B_Sec(A4)
	CLR	G506_i_Act(A4)
	MOVE	#1,G509_B_Act(A4)
	CLR	G599_ui_Us(A4)
	MOVE.L	#16777215,G374_l_Wat(A4)
	LEA	G447_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	LEA	G448_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	LEA	G458_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	LEA	G459_as_Gr(A4),A0
	MOVE.L	A0,G444_ps_Se(A4)
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F003_aaaS_(PC)
	ADDQ.L	#2,A7
	MOVE	G298_B_New(A4),D0
	BNE	L67(PC)
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	MOVE.L	G536_pc_D0(A4),-(A7)
	CLR.L	-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	G631_i_Gra(A4),-2(A6)
	BEQ.S	L68
	MOVE	#1,G631_i_Gra(A4)
	JSR	F478_gzzz_(PC)
L68:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),D0
	BEQ.S	L69
	JSR	F477_izzz_(PC)
	MOVE	-2(A6),G631_i_Gra(A4)
L69:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	BRA.S	L70
L67:
	CLR	G578_B_Use(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G061_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G062_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G063_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
L70:
	PEA	G021_aaui_(A4)
	MOVE	#6,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	JSR	F395_pzzz_(PC)
	JSR	F278_apzz_(PC)
	MOVE	#1,G301_B_Gam(A4)
L66:
	UNLK	A6
	RTS
L$65:	.EQU	#-2
F463_wzzz_:/* global */
	LINK	A6,L$71
	MOVE	D7,-(A7)
	PEA	S059_aaac_(PC)
	MOVE	#38,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	PEA	-130(A6)
	JSR	F458_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F451_xxxx_(PC)
	JSR	F448_xxxx_(PC)
	MOVE.B	-130(A6),D7
	EXT	D7
	CMP	#65,D7
	SEQ	D7
	TST.B	D7
	BEQ.S	L75
	MOVE.B	-129(A6),D7
	EXT	D7
	CMP	#85,D7
	SEQ	D7
	TST.B	D7
L75:
	TST.B	D7
	BEQ.S	L74
	MOVE.B	-128(A6),D7
	EXT	D7
	CMP	#84,D7
	SEQ	D7
	TST.B	D7
L74:
	TST.B	D7
	BEQ.S	L73
	MOVE.B	-127(A6),D7
	EXT	D7
	CMP	#79,D7
	SEQ	D7
	TST.B	D7
L73:
	AND	#1,D7
	JSR	F479_izzz_(PC)
	JSR	F460_xxxx_(PC)
	MOVE	D7,-(A7)
	JSR	F447_xxxx_(PC)
	ADDQ.L	#2,A7
	JSR	F437_xxxx_(PC)
	CLR	-(A7)
	JSR	F094_mzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	JSR	F095_izzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#7,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	PEA	G295_ac_Se(A4)
	MOVE	#8,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	JSR	F054_aAA1_(PC)
	JSR	F031_aAA2_(PC)
	MOVE	#32,-(A7)
	PEA	G346_aui_P(A4)
	PEA	G021_aaui_(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#32,-(A7)
	PEA	G347_aui_P(A4)
	PEA	G021_aaui_(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	PEA	S080_aaat_(PC)
	JSR	F211_vzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,G626_pfV_S(A4)
	PEA	S081_aaao_(PC)
	JSR	F211_vzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,G627_pfV_S(A4)
	JSR	F066_aalz_(PC)
	PEA	F018_aaat_(PC)
	MOVE	#38,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	MOVE	#5,-(A7)
	MOVE	#26,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#4,A7
	JSR	F062_aalz_(PC)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	JSR	F441_xxxx_(PC)
	BRA.S	L76
L77:
	JSR	F477_izzz_(PC)
	JSR	F441_xxxx_(PC)
L76:
	JSR	F435_xxxx_(PC)
	CMPI	#1,D0
	BNE.S	L77
L78:
	JSR	F477_izzz_(PC)
	JSR	F396_pzzz_(PC)
	JSR	F476_mzzz_(PC)
	JSR	F462_xxxx_(PC)
	JSR	F478_gzzz_(PC)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L79
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L79:
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
L72:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$71:	.EQU	#-130
