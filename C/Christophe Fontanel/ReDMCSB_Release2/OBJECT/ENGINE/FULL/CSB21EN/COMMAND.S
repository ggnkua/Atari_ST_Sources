BSS SEG "bss"
G432_as_Co:/* global */
	.WORD	#30
G433_i_Com:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#4,G434_i_Com(A4)
BSS SEG "bss"
G434_i_Com:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#1,G435_B_Com(A4)
BSS SEG "bss"
G435_B_Com:/* global */
	.WORD	#2
G436_B_Pen:/* global */
	.WORD	#2
G437_i_Pen:/* global */
	.WORD	#2
G438_i_Pen:/* global */
	.WORD	#2
G439_i_Pen:/* global */
	.WORD	#2
G440_B_Con:/* global */
	.WORD	#2
G441_ps_Pr:/* global */
	.WORD	#4
G442_ps_Se:/* global */
	.WORD	#4
G443_ps_Pr:/* global */
	.WORD	#4
G444_ps_Se:/* global */
	.WORD	#4
G445_as_Gr:/* global */
	.WORD	#48
G446_as_Gr:/* global */
	.WORD	#24
G447_as_Gr:/* global */
	.WORD	#240
G448_as_Gr:/* global */
	.WORD	#108
G449_as_Gr:/* global */
	.WORD	#456
G450_as_Gr:/* global */
	.WORD	#36
G451_as_Gr:/* global */
	.WORD	#36
G452_as_Gr:/* global */
	.WORD	#60
G453_as_Gr:/* global */
	.WORD	#60
G454_as_Gr:/* global */
	.WORD	#108
G455_as_Gr:/* global */
	.WORD	#156
G456_as_Gr:/* global */
	.WORD	#108
G457_as_Gr:/* global */
	.WORD	#48
G458_as_Gr:/* global */
	.WORD	#28
G459_as_Gr:/* global */
	.WORD	#28
G460_as_Gr:/* global */
	.WORD	#12
G461_as_Gr:/* global */
	.WORD	#8
G462_as_Gr:/* global */
	.WORD	#16
G463_as_Gr:/* global */
	.WORD	#32
G464_as_Gr:/* global */
	.WORD	#56
G465_ai_Gr:/* global */
	.WORD	#8
G466_ai_Gr:/* global */
	.WORD	#8
G467_s_Gra:/* global */
	.WORD	#8
G468_s_Gra:/* global */
	.WORD	#8
G469_s_Gra:/* global */
	.WORD	#8
G470_s_Gra:/* global */
	.WORD	#8
G471_as_Gr:/* global */
	.WORD	#24
G472_as_Gr:/* global */
	.WORD	#36
G473_as_Gr:/* global */
	.WORD	#48
G474_as_Gr:/* global */
	.WORD	#60
G475_as_Gr:/* global */
	.WORD	#24
G476_as_Gr:/* global */
	.WORD	#36
G477_as_Gr:/* global */
	.WORD	#48
G478_as_Gr:/* global */
	.WORD	#60
G479_i_Gra:/* global */
	.WORD	#2
CODE SEG "init!"
	LEA	G480_aaps_(A4),A1
	LEA	G471_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G472_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G473_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G474_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G475_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G476_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G477_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G478_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
G480_aaps_:/* global */
	.WORD	#32
CODE SEG "user"
F357_qzzz_:/* global */
	LINK	A6,L$0
	BRA.S	L2
L3:
	MOVE	#7,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
L2:
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE.S	L3
L4:
	MOVE	#1,G435_B_Com(A4)
	CLR	G433_i_Com(A4)
	MOVE	#4,G434_i_Com(A4)
	CLR	G435_B_Com(A4)
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#0
F358_xxxx_:/* global */
	LINK	A6,L$5
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	CMPA.L	#0,A3
	BEQ.S	L8
	MOVE	G440_B_Con(A4),D0
	BEQ.S	L7
L8:
	MOVE	#0,D0
	BRA.S	L6
L7:
	BRA.S	L9
L10:
	MOVE	D7,D0
	CMP	4(A3),D0
	BGT.S	L12
	MOVE	D7,D0
	CMP	2(A3),D0
	BLT.S	L12
	MOVE	D6,D0
	CMP	6(A3),D0
	BLT.S	L12
	MOVE	D6,D0
	CMP	8(A3),D0
	BGT.S	L12
	MOVE	D5,D0
	AND	10(A3),D0
	BEQ.S	L12
	BRA.S	L11
L12:
	ADDA	#12,A3
L9:
	MOVE	(A3),D4
	BNE.S	L10
L11:
	MOVE	D4,D0
L6:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$5:	.EQU	#0
F359_hzzz_:/* global */
	LINK	A6,L$13
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	TAS	G435_B_Com(A4)
	BEQ.S	L2T359_002
	MOVE	#1,G436_B_Pen(A4)
	MOVE	D7,G437_i_Pen(A4)
	MOVE	D6,G438_i_Pen(A4)
	MOVE	12(A6),G439_i_Pen(A4)
	MOVE	G440_B_Con(A4),D0
	BNE.S	L15
	PEA	F380_xzzz_(PC)
	JSR	F464_AA07_(PC)
	ADDQ.L	#4,A7
	CMPI	#675,D0
	BEQ.S	L15
	ADDQ	#1,G440_B_Con(A4)
L15:
	BRA	L14(PC)
L2T359_002:
	MOVE	G434_i_Com(A4),D0
	ADDQ	#2,D0
	MOVE	D0,D5
	CMPI	#4,D0
	BLE.S	L16
	SUBQ	#5,D5
L16:
	MOVE	D5,D0
	CMP	G433_i_Com(A4),D0
	BNE.S	L17
	BRA.S	L14
L17:
	MOVE	12(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	G441_ps_Pr(A4),-(A7)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D4
	CMPI	#0,D4
	BNE.S	L18
	MOVE	12(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	G442_ps_Se(A4),-(A7)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D4
L18:
	CMPI	#0,D4
	BEQ.S	L19
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L20
	MOVE	#4,D5
L20:
	MOVE	D5,D0
	MOVE	D0,G434_i_Com(A4)
	MULS	#6,D0
	LEA	G432_as_Co+4(A4),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
	MOVE	D5,D0
	MULS	#6,D0
	LEA	G432_as_Co(A4),A0
	ADDA	D0,A0
	MOVE	D7,(A0)
	MOVE	D5,D0
	MULS	#6,D0
	LEA	G432_as_Co+2(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L19:
	CLR	G435_B_Com(A4)
L14:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$13:	.EQU	#0
F360_xxxx_:/* global */
	LINK	A6,L$21
	MOVE	G436_B_Pen(A4),D0
	BEQ.S	L23
	CLR	G436_B_Pen(A4)
	MOVE	G439_i_Pen(A4),-(A7)
	MOVE	G438_i_Pen(A4),-(A7)
	MOVE	G437_i_Pen(A4),-(A7)
	JSR	F359_hzzz_(PC)
	ADDQ.L	#6,A7
L23:
L22:
	UNLK	A6
	RTS
L$21:	.EQU	#0
F361_nzzz_:/* global */
	LINK	A6,L$24
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	G443_ps_Pr(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L26
	BRA	L25(PC)
L26:
	MOVE	#1,G435_B_Com(A4)
	MOVE.L	D7,D0
	CMPI	#0,D0
	BNE.S	L27
	MOVE.L	D7,D0
	ASR.L	#8,D0
	MOVE.L	D0,D7
L27:
	MOVE	G434_i_Com(A4),D0
	ADDQ	#2,D0
	MOVE	D0,D6
	CMPI	#4,D0
	BLE.S	L28
	SUBQ	#5,D6
L28:
	MOVE	D6,D0
	CMP	G433_i_Com(A4),D0
	BNE.S	L29
	BRA.S	L4T361_014
L29:
	BRA.S	L30
L31:
	MOVE.L	D7,D0
	CMP	2(A3),D0
	BNE.S	L33
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L34
	MOVE	#4,D6
L34:
	MOVE	D6,D0
	MOVE	D0,G434_i_Com(A4)
	MULS	#6,D0
	LEA	G432_as_Co+4(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	BRA.S	L4T361_014
L33:
	ADDQ.L	#4,A3
L30:
	MOVE	(A3),D5
	BNE.S	L31
L32:
	MOVE.L	G444_ps_Se(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L35
	BRA.S	L4T361_014
L35:
	BRA.S	L36
L37:
	MOVE.L	D7,D0
	CMP	2(A3),D0
	BNE.S	L39
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L40
	MOVE	#4,D6
L40:
	MOVE	D6,D0
	MOVE	D0,G434_i_Com(A4)
	MULS	#6,D0
	LEA	G432_as_Co+4(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	BRA.S	L4T361_014
L39:
	ADDQ.L	#4,A3
L36:
	MOVE	(A3),D5
	BNE.S	L37
L38:
L4T361_014:
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
L25:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$24:	.EQU	#0
F362_xxxx_:/* global */
	LINK	A6,L$41
L44:
L43:
	MOVE	G340_B_Hig(A4),D0
	BNE.S	L44
L45:
	MOVE	8(A6),G336_i_Hig(A4)
	MOVE	10(A6),G337_i_Hig(A4)
	MOVE	12(A6),G338_i_Hig(A4)
	MOVE	14(A6),G339_i_Hig(A4)
	MOVE	#1,G340_B_Hig(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L42:
	UNLK	A6
	RTS
L$41:	.EQU	#0
F363_pzzz_:/* global */
	LINK	A6,L$46
L49:
L48:
	MOVE	G340_B_Hig(A4),D0
	BNE.S	L49
L50:
	MOVE	G341_B_Hig(A4),D0
	BEQ.S	L51
	MOVE	#1,G340_B_Hig(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L51:
L47:
	UNLK	A6
	RTS
L$46:	.EQU	#0
F364_xxxx_:/* global */
	LINK	A6,L$52
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	PEA	G307_i_Par(A4)
	PEA	G306_i_Par(A4)
	MOVE	8(A6),D0
	BEQ.S	L54
	MOVE	#-1,D0
	BRA.S	L55
L54:
	MOVE	#1,D0
L55:
	MOVE	D0,-(A7)
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F154_afzz_(PC)
	ADDA	#12,A7
	MOVE	D0,G327_i_New(A4)
	MOVE	G327_i_New(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F155_ahzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F284_czzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L53:
	UNLK	A6
	RTS
L$52:	.EQU	#-2
F365_xxxx_:/* global */
	LINK	A6,L$56
	MOVE	D7,-(A7)
	MOVE	#1,G321_B_Sto(A4)
	CMPI	#1,8(A6)
	BNE.S	L58
	MOVE	#145,-(A7)
	MOVE	#125,-(A7)
	MOVE	#261,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L59
L58:
	MOVE	#145,-(A7)
	MOVE	#125,-(A7)
	MOVE	#318,-(A7)
	MOVE	#291,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
L59:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	CMPI	#3,D0
	BNE.S	L60
	MOVE	D7,D0
	AND	#4,D0
	MOVE	D0,-(A7)
	JSR	F364_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA.S	L57
L60:
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
	MOVE	G308_i_Par(A4),D0
	CMPI	#2,8(A6)
	BNE.S	L61
	MOVE	#1,D1
	BRA.S	L62
L61:
	MOVE	#3,D1
L62:
	ADD	D1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F284_czzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
L57:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$56:	.EQU	#0
F366_xxxx_:/* global */
	LINK	A6,L$63
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,G321_B_Sto(A4)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D4
	BRA.S	L65
L66:
	MOVE	52(A3),D0
	BEQ.S	L68
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-20(A6)
	MOVE	272(A3),D0
	MULU	#3,D0
	AND.L	#65535,D0
	DIVU	-20(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
L68:
	ADDA	#800,A3
	ADDQ	#1,D4
L65:
	MOVE	D4,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L66
L67:
	MOVE	8(A6),D4
	SUBQ	#3,D4
	MOVE	D4,D0
	ASL.L	#3,D0
	LEA	G463_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	6(A2),-(A7)
	MOVE	4(A2),-(A7)
	MOVE	2(A2),-(A7)
	MOVE	(A2),-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	G307_i_Par(A4),D0
	MOVE	D0,-4(A6)
	MOVE	D0,-(A7)
	MOVE	G306_i_Par(A4),D0
	MOVE	D0,-2(A6)
	MOVE	D0,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	CMPI	#3,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-6(A6)
	MOVE	-6(A6),D0
	BEQ.S	L69
	CMPI	#2,D4
	BNE.S	L69
	MOVE	D7,D0
	AND	#4,D0
	MOVE	D0,-(A7)
	JSR	F364_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L64(PC)
L69:
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G466_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G465_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	MOVE	D0,D6
	CMPI	#3,D6
	BNE.S	L70
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	-2(A6),G306_i_Par(A4)
	MOVE	-4(A6),G307_i_Par(A4)
	MOVE	D7,D0
	AND	#4,D0
	MOVE	D0,-(A7)
	JSR	F364_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L64(PC)
L70:
	CLR	D5
	CMPI	#0,D6
	BNE.S	L71
	MOVE	#1,D5
	BRA.S	L72
L71:
	CMPI	#4,D6
	BNE.S	L73
	MOVE	D7,D5
	AND	#7,D5
	CMPI	#0,D5
	SNE	D0
	TST.B	D0
	BEQ.S	L75
	CMPI	#1,D5
	SNE	D0
	TST.B	D0
L75:
	TST.B	D0
	BEQ.S	L74
	CMPI	#5,D5
	SNE	D0
	TST.B	D0
L74:
	AND	#1,D0
	MOVE	D0,D5
	BRA.S	L76
L73:
	CMPI	#6,D6
	BNE.S	L77
	MOVE	D7,D5
	AND	#4,D5
	SEQ	D5
	TST.B	D5
	BEQ.S	L78
	MOVE	D7,D5
	AND	#1,D5
	SEQ	D5
	TST.B	D5
L78:
	AND	#1,D5
L77:
L76:
L72:
	CMPI	#0,G305_ui_Pa(A4)
	BNE.S	L79
	BRA	L80(PC)
L79:
	MOVE	D5,D0
	BEQ	L81(PC)
	MOVE	#2,-(A7)
	MOVE	#24,-(A7)
	MOVE	#1,-(A7)
	MOVE	G308_i_Par(A4),D1
	ADDQ	#2,D1
	MOVE	D4,D0
	ADD	D1,D0
	MOVE	D0,D4
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F286_hzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	MOVE	D4,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F286_hzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-10(A6)
	MOVE	D0,-30(A6)
	MOVE	-8(A6),D0
	CMP	-30(A6),D0
	BEQ.S	L82
	MOVE	#2,-(A7)
	MOVE	#24,-(A7)
	MOVE	#1,-(A7)
	MOVE	-10(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	OR	D0,D5
L82:
	MOVE	D5,D0
	BEQ.S	L83
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#18,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L83:
	BRA.S	L84
L81:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	SNE	D0
	AND	#1,D0
	MOVE	D0,D5
	BEQ.S	L85
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L85:
L84:
L80:
	MOVE	D5,D0
	BEQ.S	L86
	JSR	F357_qzzz_(PC)
	CLR	G321_B_Sto(A4)
	BRA.S	L64
L86:
	MOVE	-6(A6),D0
	BEQ.S	L87
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	BRA.S	L88
L87:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L88:
	MOVE	#1,D7
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D4
	BRA.S	L89
L90:
	MOVE	52(A3),D0
	BEQ.S	L92
	MOVE.L	A3,-(A7)
	JSR	F310_AA08_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
L92:
	ADDA	#800,A3
	ADDQ	#1,D4
L89:
	MOVE	D4,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L90
L91:
	MOVE	D7,G310_i_Dis(A4)
	CLR	G311_i_Pro(A4)
L64:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$63:	.EQU	#-30
F367_xxxx_:/* global */
	LINK	A6,L$93
	MOVEM.L	D7-D5,-(A7)
	MOVE	10(A6),D7
	MOVE	12(A6),D6
	MOVE	8(A6),D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L95
	MOVE	8(A6),-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L94
L95:
	MOVE	#2,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	G455_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	CMPI	#16,D5
	BCS.S	L96
	CMPI	#19,D5
	BHI.S	L96
	MOVE	D5,D0
	SUB	#16,D0
	MOVE	D0,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L94
L96:
	CMPI	#20,D5
	BCS.S	L97
	CMPI	#27,D5
	BHI.S	L97
	MOVE	D5,D0
	SUB	#20,D0
	MOVE	D0,-(A7)
	JSR	F302_mzzz_(PC)
	ADDQ.L	#2,A7
L97:
L94:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$93:	.EQU	#0
F368_fzzz_:/* global */
	LINK	A6,L$98
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G411_i_Lea(A4),D0
	BEQ.S	L101
	CMPI	#-1,D7
	BEQ.S	L100
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L100
L101:
	BRA	L99(PC)
L100:
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L102
	MOVE	G411_i_Lea(A4),D0
	MOVE	D0,D6
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#640,(A0)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
	MOVE	#-1,G411_i_Lea(A4)
	MOVE	D6,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L102:
	CMPI	#-1,D7
	BNE.S	L103
	MOVE	#-1,G411_i_Lea(A4)
	BRA.S	L99
L103:
	MOVE	D7,D0
	MOVE	D0,G411_i_Lea(A4)
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ.S	L104
	ORI	#1664,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L104:
L99:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$98:	.EQU	#0
F369_xxxx_:/* global */
	LINK	A6,L$105
	MOVEM.L	A3/D7,-(A7)
	CMPI	#108,8(A6)
	BNE.S	L107
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+34(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#0,D0
	BNE.S	L108
	BRA	L106(PC)
L108:
	MOVE	#73,-(A7)
	MOVE	#63,-(A7)
	MOVE	#303,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#136,G031_i_Gra(A4)
	BEQ.S	L109
	PEA	G295_ac_Se(A4)
	JSR	F277_jzzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L109
	MOVE	#136,G189_i_Gra(A4)
L109:
	CLR	-(A7)
	JSR	F408_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,G321_B_Sto(A4)
	BRA.S	L110
L107:
	MOVE	8(A6),D7
	SUB	#101,D7
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	G464_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	6(A3),-(A7)
	MOVE	4(A3),-(A7)
	MOVE	2(A3),-(A7)
	MOVE	(A3),-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	JSR	F363_pzzz_(PC)
	CMPI	#6,D7
	BCC.S	L111
	MOVE	D7,-(A7)
	JSR	F399_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA.S	L112
L111:
	JSR	F400_xxxx_(PC)
L112:
L110:
L106:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$105:	.EQU	#0
F370_xxxx_:/* global */
	LINK	A6,L$113
	MOVEM.L	D7-D6,-(A7)
	MOVE	#-1,D6
	CMPI	#48,10(A6)
	BHI	L115(PC)
	MOVE	G514_i_Mag(A4),D0
L116:
	CMP	#0,D0
	BEQ.S	L117
	BRA.S	L119
L117:
	CMPI	#280,8(A6)
	BCS.S	L121
	CMPI	#291,8(A6)
	BHI.S	L121
	MOVE	#1,D6
	BRA.S	L122
L121:
	CMPI	#294,8(A6)
	BCS.S	L123
	CMPI	#305,8(A6)
	BHI.S	L123
	MOVE	#2,D6
	BRA.S	L124
L123:
	CMPI	#308,8(A6)
	BCS.S	L125
	MOVE	#3,D6
L125:
L124:
L122:
	BRA	L118(PC)
	BRA.S	L120
L119:
	CMP	#1,D0
	BEQ.S	L120
	BRA.S	L126
L120:
	CMPI	#233,8(A6)
	BCS.S	L128
	CMPI	#244,8(A6)
	BHI.S	L128
	CLR	D6
	BRA.S	L129
L128:
	CMPI	#294,8(A6)
	BCS.S	L130
	CMPI	#305,8(A6)
	BHI.S	L130
	MOVE	#2,D6
	BRA.S	L131
L130:
	CMPI	#308,8(A6)
	BCS.S	L132
	MOVE	#3,D6
L132:
L131:
L129:
	BRA	L118(PC)
	BRA.S	L127
L126:
	CMP	#2,D0
	BEQ.S	L127
	BRA.S	L133
L127:
	CMPI	#233,8(A6)
	BCS.S	L135
	CMPI	#244,8(A6)
	BHI.S	L135
	CLR	D6
	BRA.S	L136
L135:
	CMPI	#247,8(A6)
	BCS.S	L137
	CMPI	#258,8(A6)
	BHI.S	L137
	MOVE	#1,D6
	BRA.S	L138
L137:
	CMPI	#308,8(A6)
	BCS.S	L139
	MOVE	#3,D6
L139:
L138:
L136:
	BRA.S	L118
	BRA.S	L134
L133:
	CMP	#3,D0
	BEQ.S	L134
	BRA.S	L140
L134:
	CMPI	#247,8(A6)
	BCS.S	L142
	CMPI	#258,8(A6)
	BHI.S	L142
	MOVE	#1,D6
	BRA.S	L143
L142:
	CMPI	#261,8(A6)
	BCS.S	L144
	CMPI	#272,8(A6)
	BHI.S	L144
	MOVE	#2,D6
	BRA.S	L145
L144:
	CMPI	#244,8(A6)
	BHI.S	L146
	CLR	D6
L146:
L145:
L143:
L140:
L141:
L118:
	CMPI	#-1,D6
	BEQ.S	L147
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L147
	MOVE	D6,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
L147:
	BRA.S	L148
L115:
	MOVE	#2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	PEA	G454_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D7
	CMPI	#0,D7
	BEQ.S	L149
	MOVE	D7,-(A7)
	JSR	F369_xxxx_(PC)
	ADDQ.L	#2,A7
L149:
L148:
L114:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$113:	.EQU	#0
F371_xxxx_:/* global */
	LINK	A6,L$150
	MOVE	D7,-(A7)
	MOVE	G506_i_Act(A4),D0
	BEQ	L152(PC)
	MOVE	#2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	PEA	G452_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D7
	CMPI	#0,D7
	BEQ	L153(PC)
	CMPI	#112,D7
	BNE.S	L154
	MOVE	#83,-(A7)
	MOVE	#77,-(A7)
	MOVE	#319,-(A7)
	MOVE	#285,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-(A7)
	JSR	F391_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L155(PC)
L154:
	MOVE	D7,D0
	SUB	#112,D0
	CMP	G507_ui_Ac(A4),D0
	BHI	L156(PC)
	CMPI	#113,D7
	BNE.S	L157
	MOVE	#96,-(A7)
	MOVE	#86,-(A7)
	MOVE	#318,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L158
L157:
	CMPI	#114,D7
	BNE.S	L159
	MOVE	#108,-(A7)
	MOVE	#98,-(A7)
	MOVE	#318,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#136,G031_i_Gra(A4)
	BEQ.S	L160
	PEA	G295_ac_Se(A4)
	JSR	F277_jzzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L160
	MOVE	#136,G189_i_Gra(A4)
L160:
	BRA.S	L161
L159:
	MOVE	#120,-(A7)
	MOVE	#110,-(A7)
	MOVE	#318,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
L161:
L158:
	MOVE	D7,D0
	SUB	#113,D0
	MOVE	D0,-(A7)
	JSR	F391_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,G321_B_Sto(A4)
L156:
L155:
L153:
	BRA.S	L162
L152:
	MOVE	G509_B_Act(A4),D0
	BEQ.S	L163
	MOVE	#2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	PEA	G453_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D7
	CMPI	#0,D7
	BEQ.S	L164
	MOVE	D7,D0
	SUB	#116,D0
	MOVE	D0,D7
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L165
	MOVE	D7,-(A7)
	JSR	F389_xxxx_(PC)
	ADDQ.L	#2,A7
L165:
L164:
L163:
L162:
L151:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$150:	.EQU	#0
F372_xxxx_:/* global */
	LINK	A6,L$166
	MOVE	G306_i_Par(A4),-2(A6)
	MOVE	G307_i_Par(A4),-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	CMPI	#0,-2(A6)
	BCS.S	L168
	MOVE	-2(A6),D0
	MOVE	G273_i_Cur(A4),D1
	CMP	D1,D0
	BCC.S	L168
	CMPI	#0,-4(A6)
	BCS.S	L168
	MOVE	-4(A6),D0
	MOVE	G274_i_Cur(A4),D1
	CMP	D1,D0
	BCC.S	L168
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F275_aszz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,G321_B_Sto(A4)
L168:
L167:
	UNLK	A6
	RTS
L$166:	.EQU	#-4
F373_xxxx_:/* global */
	LINK	A6,L$169
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L171
	BRA	L170(PC)
L171:
	MOVE	G306_i_Par(A4),D6
	MOVE	G307_i_Par(A4),D5
	CMPI	#2,D7
	BCS.S	L172
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,D6
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D5,D0
	ADD	D1,D0
	MOVE	D0,D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L173
	MOVE	#4,-(A7)
	MOVE	D4,-(A7)
	JSR	F264_avzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L173
	MOVE	D7,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L173
	BRA.S	L170
L173:
L172:
	MOVE	D7,D4
	ASL.L	#1,D4
	LEA	G292_aT_Pi(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L174
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	#1,G416_i_Use(A4)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L174:
	MOVE	#1,G321_B_Sto(A4)
L170:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$169:	.EQU	#0
F374_xxxx_:/* global */
	LINK	A6,L$175
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L177
	BRA	L176(PC)
L177:
	MOVE	G306_i_Par(A4),D6
	MOVE	G307_i_Par(A4),D5
	CMPI	#4,D7
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-6(A6)
	BEQ.S	L178
	MOVE	#2,D7
L178:
	CMPI	#1,D7
	BLS.S	L179
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,D6
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D5,D0
	ADD	D1,D0
	MOVE	D0,D5
L179:
	MOVE	G308_i_Par(A4),D0
	ADD	D7,D0
	AND	#3,D0
	MOVE	D0,-4(A6)
	JSR	F298_aqzz_(PC)
	MOVE	D0,D4
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	-4(A6),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	-6(A6),D0
	BEQ.S	L180
	MOVE	G287_B_Fac(A4),D0
	BEQ.S	L180
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#147,D0
	BNE.S	L180
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#1,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-16(A6)
	MOVE.B	#13,-12(A6)
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	D0,-11(A6)
	MOVE	D6,D0
	MOVE.B	D0,-10(A6)
	MOVE	D5,D0
	MOVE.B	D0,-9(A6)
	MOVE	-4(A6),D0
	MOVE.B	D0,-8(A6)
	MOVE.B	#2,-7(A6)
	PEA	-16(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L180:
	MOVE	#1,G321_B_Sto(A4)
L176:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$175:	.EQU	#-16
F375_xxxx_:/* global */
	LINK	A6,L$181
	MOVEM.L	D7-D6,-(A7)
	CMPI	#47,10(A6)
	BLT.S	L184
	CMPI	#102,10(A6)
	BLE.S	L183
L184:
	MOVE	#0,D0
	BRA.S	L182
L183:
	CMPI	#111,8(A6)
	BGT.S	L185
	CMPI	#17,G285_i_Squ(A4)
	BNE.S	L186
	CMPI	#64,8(A6)
	BGE.S	L187
	MOVE	#0,D0
	BRA.S	L182
L187:
	BRA.S	L188
L186:
	CMPI	#32,8(A6)
	BGE.S	L189
	MOVE	#0,D0
	BRA.S	L182
L189:
L188:
	CLR	-(A7)
	JSR	F329_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	BRA.S	L190
L185:
	CMPI	#17,G285_i_Squ(A4)
	BNE.S	L191
	CMPI	#163,8(A6)
	BLE.S	L192
	MOVE	#0,D0
	BRA.S	L182
L192:
	BRA.S	L193
L191:
	CMPI	#191,8(A6)
	BLE.S	L194
	MOVE	#0,D0
	BRA.S	L182
L194:
L193:
	MOVE	#1,-(A7)
	JSR	F329_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L190:
	MOVE	D6,D0
	BEQ.S	L195
	MOVE	#1,G321_B_Sto(A4)
L195:
	MOVE	D6,D0
L182:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$181:	.EQU	#0
F376_xxxx_:/* global */
	LINK	A6,L$196
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	D7,D0
	MOVE.B	1(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SLE	D0
	TST.B	D0
	BEQ.S	L200
	MOVE	D7,D0
	MOVE.B	(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SGE	D0
	TST.B	D0
L200:
	TST.B	D0
	BEQ.S	L199
	MOVE	D6,D0
	MOVE.B	3(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SLE	D0
	TST.B	D0
L199:
	TST.B	D0
	BEQ.S	L198
	MOVE	D6,D0
	MOVE.B	2(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SGE	D0
	TST.B	D0
L198:
	AND	#1,D0
L197:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$196:	.EQU	#0
F377_xxxx_:/* global */
	LINK	A6,L$201
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CMPI	#17,G285_i_Squ(A4)
	BNE	L203(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L204
	BRA	L202(PC)
L204:
	MOVE	G306_i_Par(A4),-8(A6)
	MOVE	G307_i_Par(A4),-10(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-10(A6),D0
	ADD	D1,D0
	MOVE	D0,-10(A6)
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L205
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L206
	MOVE	D6,D0
	SUB	#33,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	PEA	G291_aauc_+20(A4)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L206
	MOVE	#1,G321_B_Sto(A4)
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#1,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#1,D0
	MOVE.L	D0,-(A7)
	MOVE	#2,-(A7)
	CLR	-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	#10,-(A7)
	JSR	F268_fzzz_(PC)
	ADDA	#14,A7
	BRA	L202(PC)
L206:
	BRA.S	L207
L205:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F375_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L208
	BRA	L202(PC)
L208:
L207:
L203:
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L209
	CLR	D5
	BRA.S	L210
L211:
	MOVE	D6,D0
	SUB	#33,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G291_aauc_(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L214
	CMPI	#5,D5
	BNE.S	L215
	MOVE	G286_B_Fac(A4),D0
	BNE.S	L216
	JSR	F372_xxxx_(PC)
L216:
	BRA.S	L217
L215:
	MOVE	D5,-(A7)
	JSR	F373_xxxx_(PC)
	ADDQ.L	#2,A7
L217:
	BRA	L202(PC)
L214:
L212:
	ADDQ	#1,D5
L210:
	CMPI	#6,D5
	BCS.S	L211
L213:
	BRA	L202(PC)
L209:
	MOVE	G414_T_Lea(A4),-2(A6)
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CMPI	#0,G285_i_Squ(A4)
	BNE	L218(PC)
	CLR	D5
	BRA.S	L219
L220:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G462_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L223
	MOVE	D5,-(A7)
	JSR	F374_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L202(PC)
L223:
L221:
	ADDQ	#1,D5
L219:
	CMPI	#2,D5
	BCS.S	L220
L222:
	MOVE	D6,D0
	SUB	#33,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	PEA	G291_aauc_+20(A4)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ	L224(PC)
	MOVE	G286_B_Fac(A4),D0
	BEQ.S	L225
	MOVE	#4,-(A7)
	JSR	F374_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L226(PC)
L225:
	MOVE	G288_B_Fac(A4),D0
	BEQ	L227(PC)
	MOVE	-2(A6),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-4(A6)
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-6(A6)
	CMPI	#8,-4(A6)
	BCS.S	L228
	CMPI	#9,-4(A6)
	BHI.S	L228
	MOVE	#3,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A3)
	OR	D3,2(A3)
	BRA.S	L229
L228:
	CMPI	#195,-4(A6)
	BNE.S	L230
	MOVE	#15,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	AND	#127,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-32513,2(A0)
	OR	D3,2(A0)
	BRA.S	L231
L230:
	BRA.S	L20T377_019
L231:
L229:
	JSR	F296_aizz_(PC)
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	SUB	-6(A6),D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
L227:
L20T377_019:
	JSR	F372_xxxx_(PC)
L226:
L224:
	BRA.S	L202
L218:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F375_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L232
	BRA.S	L202
L232:
	CLR	D5
	BRA.S	L233
L234:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G462_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L237
	MOVE	D5,-(A7)
	JSR	F374_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA.S	L202
L237:
L235:
	ADDQ	#1,D5
L233:
	CMPI	#4,D5
	BCS.S	L234
L236:
L202:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$201:	.EQU	#-10
F378_xxxx_:/* global */
	LINK	A6,L$238
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CMPI	#-1,G411_i_Lea(A4)
	SEQ	D4
	AND	#1,D4
	MOVE	G424_i_Pan(A4),D0
L240:
	CMP	#4,D0
	BEQ.S	L241
	BRA.S	L243
L241:
	MOVE	D4,D0
	BEQ.S	L245
	BRA.S	L242
L245:
	MOVE	#2,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	G456_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	CMPI	#0,D5
	BEQ.S	L246
	MOVE	D5,D0
	SUB	#20,D0
	MOVE	D0,-(A7)
	JSR	F302_mzzz_(PC)
	ADDQ.L	#2,A7
L246:
	BRA.S	L242
	BRA.S	L244
L243:
	CMP	#5,D0
	BEQ.S	L244
	BRA.S	L247
L244:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L249
	BRA.S	L242
L249:
	MOVE	#2,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	G457_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	CMPI	#0,D5
	BEQ.S	L250
	MOVE	D5,-(A7)
	JSR	F282_xzzz_(PC)
	ADDQ.L	#2,A7
L250:
L247:
L248:
L242:
L239:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$238:	.EQU	#0
F379_jzzz_:/* global */
	LINK	A6,L$251
	MOVE	#1904,-(A7)
	CLR	-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
s!:
	DATA 57 41 4B 45 20 55 50 00 
CODE SEG "user"
	PEA	s!(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#69,-(A7)
	MOVE	#93,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L252:
	UNLK	A6
	RTS
L$251:	.EQU	#0
F380_xzzz_:/* global */
	LINK	A6,L$253
BSS SEG "bss"
24G481_ps_:
	.WORD	#4
25G482_ps_:
	.WORD	#4
26G483_ps_:
	.WORD	#4
27G484_ps_:
	.WORD	#4
CODE SEG "user"
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	#1,G435_B_Com(A4)
	MOVE	G434_i_Com(A4),D0
	ADDQ	#1,D0
	MOVE	D0,D7
	CMPI	#4,D0
	BLE.S	L255
	CLR	D7
L255:
	MOVE	D7,D0
	CMP	G433_i_Com(A4),D0
	BNE.S	L256
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
	BRA	L254(PC)
L256:
	MOVE	G433_i_Com(A4),D6
	MULS	#6,D6
	LEA	G432_as_Co+4(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	CMPI	#3,D6
	BLT.S	L257
	CMPI	#6,D6
	BGT.S	L257
	MOVE	G310_i_Dis(A4),D0
	BNE.S	L258
	MOVE	G311_i_Pro(A4),D0
	BEQ.S	L257
	MOVE	G312_i_Las(A4),D0
	MOVE	G308_i_Par(A4),D1
	ADD	D6,D1
	SUBQ	#3,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L257
L258:
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
	BRA	L254(PC)
L257:
	MOVE	G433_i_Com(A4),D5
	MULS	#6,D5
	LEA	G432_as_Co(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	G433_i_Com(A4),D4
	MULS	#6,D4
	LEA	G432_as_Co+2(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	ADDQ	#1,G433_i_Com(A4)
	MOVE	G433_i_Com(A4),D0
	CMPI	#4,D0
	BLE.S	L259
	CLR	G433_i_Com(A4)
L259:
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
	CMPI	#2,D6
	BEQ.S	L261
	CMPI	#1,D6
	BNE.S	L260
L261:
	MOVE	D6,-(A7)
	JSR	F365_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L254(PC)
L260:
	CMPI	#3,D6
	BLT.S	L262
	CMPI	#6,D6
	BGT.S	L262
	MOVE	D6,-(A7)
	JSR	F366_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L254(PC)
L262:
	CMPI	#12,D6
	BLT.S	L263
	CMPI	#15,D6
	BGT.S	L263
	MOVE	D6,D0
	SUB	#12,D0
	MOVE	D0,D7
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L264
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L264
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F367_xxxx_(PC)
	ADDQ.L	#6,A7
L264:
	BRA	L254(PC)
L263:
	CMPI	#125,D6
	BLT.S	L265
	CMPI	#128,D6
	BGT.S	L265
	MOVE	D6,D0
	SUB	#125,D0
	MOVE	D0,-(A7)
	JSR	F070_aajz_(PC)
	ADDQ.L	#2,A7
	BRA	L254(PC)
L265:
	CMPI	#28,D6
	BLT.S	L266
	CMPI	#66,D6
	BGE.S	L266
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L267
	MOVE	D6,D0
	SUB	#20,D0
	MOVE	D0,-(A7)
	JSR	F302_mzzz_(PC)
	ADDQ.L	#2,A7
L267:
	BRA	L254(PC)
L266:
	CMPI	#7,D6
	BLT.S	L268
	CMPI	#11,D6
	BGT.S	L268
	MOVE	D6,D0
	SUBQ	#7,D0
	MOVE	D0,D7
	CMPI	#4,D0
	BEQ.S	L270
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L269
L270:
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L269
	MOVE	D7,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L269:
	BRA	L254(PC)
L268:
	CMPI	#140,D6
	BNE.S	L271
	PEA	F433_AA39_(PC)
	JSR	F464_AA07_(PC)
	ADDQ.L	#4,A7
	CMPI	#26152,D0
	BEQ.S	L271
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	BRA	L254(PC)
L271:
	CMPI	#83,D6
	BNE.S	L272
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L273
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L273:
	BRA	L254(PC)
L272:
	CMPI	#100,D6
	BNE.S	L274
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L275
	CMPI	#-1,G514_i_Mag(A4)
	BEQ.S	L275
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F370_xxxx_(PC)
	ADDQ.L	#4,A7
L275:
	BRA	L254(PC)
L274:
	CMPI	#111,D6
	BNE.S	L276
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L277
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F371_xxxx_(PC)
	ADDQ.L	#4,A7
L277:
	BRA	L254(PC)
L276:
	CMPI	#70,D6
	BNE.S	L278
	JSR	F349_dzzz_(PC)
	BRA	L254(PC)
L278:
	CMPI	#71,D6
	BNE.S	L279
	JSR	F352_aszz_(PC)
	BRA	L254(PC)
L279:
	CMPI	#80,D6
	BNE.S	L280
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F377_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L254(PC)
L280:
	CMPI	#81,D6
	BNE.S	L281
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F378_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L254(PC)
L281:
	MOVE	G331_B_Pre(A4),D0
	BNE.S	L283
	MOVE	G333_B_Pre(A4),D0
	BEQ.S	L282
L283:
	BRA	L254(PC)
L282:
	CMPI	#145,D6
	BNE.S	L284
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L285
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L286
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L286:
	JSR	F456_vzzz_(PC)
	MOVE	#1,G300_B_Par(A4)
	JSR	F379_jzzz_(PC)
	MOVE	#2,-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	CLR	G318_i_Wai(A4)
	LEA	G450_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	LEA	G460_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
L285:
	BRA	L254(PC)
L284:
	CMPI	#146,D6
	BNE.S	L287
	JSR	F314_gzzz_(PC)
	BRA	L254(PC)
L287:
	CMPI	#140,D6
	BNE.S	L288
	CMPI	#0,G305_ui_Pa(A4)
	BLS.S	L289
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L289
	JSR	F433_AA39_(PC)
L289:
	BRA	L254(PC)
L288:
	CMPI	#147,D6
	BNE.S	L290
	CLR	G301_B_Gam(A4)
	JSR	F456_vzzz_(PC)
	MOVE	#1904,-(A7)
	CLR	-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 47 41 4D 45 20 46 52 4F 5A 45 4E 00 
CODE SEG "user"
	PEA	s!+8(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#69,-(A7)
	MOVE	#81,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	MOVE	#2,-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	G441_ps_Pr(A4),26G483_ps_(A4)
	MOVE.L	G442_ps_Se(A4),27G484_ps_(A4)
	MOVE.L	G443_ps_Pr(A4),24G481_ps_(A4)
	MOVE.L	G444_ps_Se(A4),25G482_ps_(A4)
	LEA	G451_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	LEA	G461_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	BRA.S	L254
L290:
	CMPI	#148,D6
	BNE.S	L291
	MOVE	#1,G301_B_Gam(A4)
	JSR	F457_AA08_(PC)
	MOVE.L	26G483_ps_(A4),G441_ps_Pr(A4)
	MOVE.L	27G484_ps_(A4),G442_ps_Se(A4)
	MOVE.L	24G481_ps_(A4),G443_ps_Pr(A4)
	MOVE.L	25G482_ps_(A4),G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	BRA.S	L254
L291:
	CMPI	#200,D6
	BNE.S	L292
	MOVE	#1,G298_B_New(A4)
	BRA.S	L254
L292:
	CMPI	#201,D6
	BNE.S	L293
	CLR	G298_B_New(A4)
	BRA.S	L254
L293:
	CMPI	#202,D6
	BNE.S	L294
	JSR	F442_AA08_(PC)
	BRA.S	L254
L294:
	CMPI	#210,D6
	BLT.S	L295
	CMPI	#213,D6
	BGT.S	L295
	MOVE	D6,D0
	SUB	#209,D0
	MOVE	D0,G335_i_Sel(A4)
	BRA.S	L254
L295:
	CMPI	#215,D6
	BNE.S	L296
	MOVE	#1,G523_B_Res(A4)
L296:
L254:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$253:	.EQU	#0
