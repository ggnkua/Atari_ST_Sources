BSS SEG "bss"
G375_ps_Ac:/* global */
	.WORD	#4
G376_ui_Ma:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#0,G377_ui_Cu(A4)
BSS SEG "bss"
G377_ui_Cu:/* global */
	.WORD	#2
G378_i_Cur:/* global */
	.WORD	#2
G379_i_Cur:/* global */
	.WORD	#2
G380_T_Cur:/* global */
	.WORD	#2
G381_ui_Cu:/* global */
	.WORD	#2
G382_i_Cur:/* global */
	.WORD	#2
G383_i_Cur:/* global */
	.WORD	#2
G384_ac_Gr:/* global */
	.WORD	#4
G385_ac_Fl:/* global */
	.WORD	#4
G386_ui_Fl:/* global */
	.WORD	#2
G387_B_Gro:/* global */
	.WORD	#2
G388_T_Gro:/* global */
	.WORD	#2
G389_B_Gro:/* global */
	.WORD	#2
G390_B_Gro:/* global */
	.WORD	#2
G391_i_Dro:/* global */
	.WORD	#2
G392_auc_D:/* global */
	.WORD	#4
G393_ac_Co:/* global */
	.WORD	#68
CODE SEG "dunman"
F175_gzzz_:/* global */
	LINK	A6,L$0
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L2
L3:
L4:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L2:
	CMPI	#-2,D7
	BEQ.S	L6
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#4,D0
	BNE.S	L3
L6:
L5:
	MOVE	D7,D0
L1:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F176_avzz_:/* global */
	LINK	A6,L$7
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	G272_i_Cur(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F145_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,D6
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L9
	MOVE	#1,D0
	BRA	L8(PC)
L9:
	MOVE	14(A3),D5
	AND	#96,D5
	LSR	#5,D5
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#3,D0
	CMPI	#1,D0
	BNE.S	L10
	MOVE	G272_i_Cur(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F147_aawz_(PC)
	ADDQ.L	#6,A7
	AND	#1,D0
	MOVE	D7,D1
	AND	#1,D1
	CMP	D1,D0
	BNE.S	L11
	MOVE	D7,D0
	SUBQ	#1,D0
	AND	#3,D0
	MOVE	D0,D7
L11:
L12:
	MOVE.B	D6,D0
	MOVE.B	D5,D1
	AND	#255,D1
	ASL	#1,D1
	AND	#255,D0
	ASR	D1,D0
	AND	#3,D0
	MOVE.B	D0,D4
	AND	#255,D0
	CMP	D7,D0
	BEQ.S	L16
	MOVE.B	D4,D0
	MOVE	D7,D1
	ADDQ	#1,D1
	AND	#3,D1
	AND	#255,D0
	CMP	D1,D0
	BNE.S	L15
L16:
	MOVE.B	D5,D0
	AND	#255,D0
	ADDQ	#1,D0
	BRA.S	L8
L15:
L13:
	MOVE.B	D5,D0
	AND	#255,D0
	SUBQ.B	#1,D5
	TST.B	D0
	BNE.S	L12
L14:
	BRA.S	L17
L10:
L18:
	MOVE.B	D6,D0
	MOVE.B	D5,D1
	AND	#255,D1
	ASL	#1,D1
	AND	#255,D0
	ASR	D1,D0
	AND	#3,D0
	CMP	D7,D0
	BNE.S	L21
	MOVE.B	D5,D0
	AND	#255,D0
	ADDQ	#1,D0
	BRA.S	L8
L21:
L19:
	MOVE.B	D5,D0
	AND	#255,D0
	SUBQ.B	#1,D5
	TST.B	D0
	BNE.S	L18
L20:
L17:
	MOVE	#0,D0
L8:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$7:	.EQU	#0
F177_aszz_:/* global */
	LINK	A6,L$22
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE.S	L24
	MOVE	#0,D0
	BRA.S	L23
L24:
	MOVE	D5,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	PEA	-4(A6)
	JSR	F229_hzzz_(PC)
	ADDA	#14,A7
	CLR	D7
L26:
	MOVE	D7,D0
	LEA	-4(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	BEQ.S	L28
	MOVE	D6,D0
	BRA.S	L23
L28:
	ADDQ	#1,D7
L25:
	BRA.S	L26
L27:
L23:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$22:	.EQU	#-4
F178_aazz_:/* global */
	LINK	A6,L$29
	MOVEM.L	D7-D6,-(A7)
	MOVE	10(A6),D7
	MOVE	12(A6),D6
	AND	#3,D6
	MOVE	D7,D1
	ASL	#1,D1
	MOVE	D1,D7
	MOVE	D6,D0
	ASL	D1,D0
	MOVE	D0,D6
	MOVE	8(A6),D0
	MOVE	#3,D1
	ASL	D7,D1
	NOT	D1
	AND	D1,D0
	MOVE	D0,-10(A6)
	MOVE	D6,D0
	OR	-10(A6),D0
L30:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$29:	.EQU	#-10
F179_xxxx_:/* global */
	LINK	A6,L$31
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	(A3),D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	4(A2),D5
	AND	#255,D5
	MOVE	D5,-4(A6)
	MULS	#26,D5
	LEA	G243_as_Gr+4(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	CMPI	#0,D7
	SLT	D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	BEQ.S	L33
	MOVE	14(A2),D7
	AND	#96,D7
	LSR	#5,D7
L33:
L34:
	LEA	12(A3),A0
	ADDA	D7,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	AND	#192,D6
	MOVE	D5,D4
	LSR	#4,D4
	LSR	#8,D4
	AND	#3,D4
	BEQ.S	L37
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D4,D0
	SWAP	D0
	MOVE	D0,D4
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L38
	MOVE	D4,D0
	NEG	D0
	AND	#7,D0
	MOVE	D0,D4
L38:
	OR	D4,D6
L37:
	MOVE	D5,D4
	LSR	#6,D4
	LSR	#8,D4
	AND	#3,D4
	BEQ.S	L39
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D4,D0
	SWAP	D0
	MOVE	D0,D4
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L40
	MOVE	D4,D0
	NEG	D0
	AND	#7,D0
	MOVE	D0,D4
L40:
	MOVE	D4,D0
	ASL	#3,D0
	OR	D0,D6
L39:
	MOVE	14(A6),D0
	BEQ.S	L41
	MOVE	D5,D0
	AND	#512,D0
	BEQ.S	L42
	MOVE	D6,D0
	AND	#128,D0
	BEQ.S	L43
	CMPI	#18,-4(A6)
	BNE.S	L43
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L44
	MOVE	#64,D0
	EOR	D0,D6
	MOVE	#1,-(A7)
	MOVE	G379_i_Cur(A4),-(A7)
	MOVE	G378_i_Cur(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L44:
	BRA.S	L45
L43:
	MOVE	D6,D0
	AND	#128,D0
	BEQ.S	L47
	MOVE	D5,D0
	AND	#1024,D0
	BNE.S	L46
L47:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L48
	OR	#64,D6
	BRA.S	L49
L48:
	AND	#-65,D6
L49:
L46:
L45:
	BRA.S	L50
L42:
	AND	#-65,D6
L50:
	OR	#128,D6
	BRA.S	L51
L41:
	MOVE	D5,D0
	AND	#4,D0
	BEQ.S	L52
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L53
	OR	#64,D6
	BRA.S	L54
L53:
	AND	#-65,D6
L54:
	BRA.S	L55
L52:
	AND	#-65,D6
L55:
	AND	#-129,D6
L51:
	MOVE	D6,D0
	LEA	12(A3),A0
	ADDA	D7,A0
	MOVE.B	D0,(A0)
L35:
	MOVE	-2(A6),D0
	BEQ.S	L56
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE	L34(PC)
L56:
L36:
	MOVE.B	4(A2),D6
	AND	#255,D6
	MULS	#26,D6
	LEA	G243_as_Gr+20(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	14(A6),D1
	BEQ.S	L57
	MOVE	D6,D1
	LSR	#8,D1
	AND	#15,D1
	BRA.S	L58
L57:
	MOVE	D6,D1
	LSR	#4,D1
	AND	#15,D1
L58:
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,-(A7)
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	AND.L	#65535,D1
	ADD.L	D1,D0
L32:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$31:	.EQU	#-4
F180_hzzz_:/* global */
	LINK	A6,L$59
	MOVE.L	A3,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	14(A3),D0
	AND	#15,D0
	CMPI	#4,D0
	BCS.S	L61
	MOVE	#0,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
L61:
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#1,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	#37,-6(A6)
	MOVE	#255,D0
	MOVE.B	4(A3),D1
	AND	#255,D1
	MULS	#26,D1
	LEA	G243_as_Gr+6(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,-5(A6)
	CLR.B	-2(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-4(A6)
	MOVE	10(A6),D0
	MOVE.B	D0,-3(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L60:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$59:	.EQU	#-10
F181_czzz_:/* global */
	LINK	A6,L$62
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L64
L65:
	MOVE.L	(A3),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	CMP	D1,D0
	BNE.S	L67
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,D4
	CMPI	#28,D0
	BLS.S	L67
	CMPI	#42,D4
	BCC.S	L67
	MOVE.B	6(A3),D0
	AND	#255,D0
	CMP	D7,D0
	BNE.S	L67
	MOVE.B	7(A3),D0
	AND	#255,D0
	CMP	D6,D0
	BNE.S	L67
	MOVE	D5,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L67:
	MOVE.L	A3,D0
	ADDA	#10,A3
	MOVE	D5,D0
	ADDQ	#1,D5
L64:
	MOVE	D5,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L65
L66:
L63:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$62:	.EQU	#0
F182_aqzz_:/* global */
	LINK	A6,L$68
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L70
L71:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	8(A6),A0
	LEA	12(A0),A0
	ADDA	D0,A0
	ANDI.B	#-129,(A0)
L70:
	CMPI	#4,D7
	BLT.S	L71
L72:
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F181_czzz_(PC)
	ADDQ.L	#4,A7
L69:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$68:	.EQU	#0
F183_kzzz_:/* global */
	LINK	A6,L$73
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	G375_ps_Ac(A4),A2
	CLR	-8(A6)
	BRA.S	L75
L76:
	ADDQ	#1,-8(A6)
	MOVE	-8(A6),D0
	CMP	G376_ui_Ma(A4),D0
	BCS.S	L78
	BRA	L74(PC)
L78:
	ADDA	#16,A2
L75:
	CMPI	#0,(A2)
	BGE.S	L76
L77:
	ADDQ	#1,G377_ui_Cu(A4)
	MOVE	8(A6),D1
	AND	#1023,D1
	MOVE	D1,(A2)
	MULS	#16,D1
	MOVE.L	G284_apuc_+16(A4),D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
	MOVE.B	5(A3),3(A2)
	MOVE	-8(A6),D0
	MOVE.B	D0,5(A3)
	MOVE	10(A6),D0
	MOVE.B	D0,10(A2)
	MOVE.B	D0,8(A2)
	MOVE	12(A6),D0
	MOVE.B	D0,11(A2)
	MOVE.B	D0,9(A2)
	MOVE.L	G313_ul_Ga(A4),D0
	SUB.L	#127,D0
	MOVE.B	D0,4(A2)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#3,D0
	CMPI	#1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-6(A6)
	MOVE	14(A3),D6
	AND	#96,D6
	LSR	#5,D6
L79:
	MOVE	14(A3),D0
	AND	#768,D0
	LSR	#8,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE.B	2(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,2(A2)
	MOVE	D6,D0
	LEA	12(A2),A0
	ADDA	D0,A0
	CLR.B	(A0)
L80:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L79
L81:
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F179_xxxx_(PC)
	ADDQ.L	#8,A7
L74:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$73:	.EQU	#-8
F184_ahzz_:/* global */
	LINK	A6,L$82
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D0
	CMP	G376_ui_Ma(A4),D0
	BHI.S	L85
	MOVE	8(A6),D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	CMPI	#0,(A0)
	BGE.S	L84
L85:
	BRA.S	L83
L84:
	MOVE	8(A6),D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	(A3),D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	SUBQ	#1,G377_ui_Cu(A4)
	MOVE.B	3(A3),5(A2)
	MOVE.B	2(A3),D0
	AND	#255,D0
	AND	#3,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-769,14(A2)
	OR	D3,14(A2)
	MOVE	14(A2),D0
	AND	#15,D0
	CMPI	#4,D0
	BCS.S	L86
	MOVE	#0,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A2)
	OR	D3,14(A2)
L86:
	MOVE	#-1,(A3)
L83:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$82:	.EQU	#0
F185_auzz_:/* global */
	LINK	A6,L$87
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G377_ui_Cu(A4),D0
	MOVE	G376_ui_Ma(A4),D1
	SUBQ	#5,D1
	CMP	D1,D0
	BCS.S	L91
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BEQ.S	L90
L91:
	MOVE	#4,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L89
L90:
	MOVE	#-1,D0
	BRA	L88(PC)
L89:
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-2,2(A3)
	MOVE	#0,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-1025,14(A3)
	OR	D3,14(A3)
	MOVE	14(A6),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-769,14(A3)
	OR	D3,14(A3)
	MOVE	12(A6),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-97,14(A3)
	OR	D3,14(A3)
	MOVE	12(A6),-2(A6)
	BEQ.S	L92
	JSR	F029_AA19_(PC)
	MOVE	D0,D5
	BRA.S	L93
L92:
	MOVE	#255,D4
L93:
	MOVE	8(A6),D0
	MOVE.B	D0,4(A3)
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A2),D6
	AND	#255,D6
L94:
	JSR	F027_AA59_(PC)
	MOVE	D6,D1
	LSR	#2,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,-12(A6)
	MOVE	D6,D0
	MULU	10(A6),D0
	ADD	-12(A6),D0
	MOVE	12(A6),D1
	ASL.L	#1,D1
	LEA	6(A3),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	-2(A6),D0
	BEQ.S	L97
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	D4,-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D4
	MOVE	2(A2),D0
	AND	#3,D0
	CMPI	#1,D0
	BNE.S	L98
	ADDQ	#1,D5
L98:
	AND	#3,D5
L97:
L95:
	MOVE	12(A6),D0
	SUBQ	#1,12(A6)
	TST	D0
	BNE.S	L94
L96:
	MOVE	D4,D0
	MOVE.B	D0,5(A3)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D7,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L99
	MOVE	#-1,D0
	BRA.S	L88
L99:
	MOVE	#1,-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
L88:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$87:	.EQU	#-12
F186_xxxx_:/* global */
	LINK	A6,L$100
	MOVEM.L	A3-A2/D7-D5,-(A7)
	CLR	-2(A6)
	CLR	-4(A6)
	MOVE	8(A6),D0
	BRA.S	L102
L103:
	BRA	L101(PC)
	BRA.S	L105
L102:
	CMP	#12,D0
	BEQ.S	L105
	BRA.S	L106
L105:
	LEA	G245_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA	L104(PC)
	BRA.S	L107
L106:
	CMP	#9,D0
	BEQ.S	L107
	BRA.S	L108
L107:
	LEA	G246_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA	L104(PC)
	BRA.S	L109
L108:
	CMP	#16,D0
	BEQ.S	L109
	BRA.S	L110
L109:
	LEA	G247_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA.S	L104
	BRA.S	L111
L110:
	CMP	#18,D0
	BEQ.S	L111
	BRA.S	L112
L111:
	MOVE	#1,-2(A6)
	LEA	G248_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA.S	L104
	BRA.S	L113
L112:
	CMP	#7,D0
	BEQ.S	L113
	BRA.S	L114
L113:
	LEA	G249_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA.S	L104
	BRA.S	L115
L114:
	CMP	#4,D0
	BEQ.S	L115
	BRA.S	L116
L115:
	LEA	G250_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA.S	L104
	BRA.S	L117
L116:
	CMP	#6,D0
	BEQ.S	L117
	BRA.S	L118
L117:
	LEA	G251_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA.S	L104
	BRA.S	L119
L118:
	CMP	#15,D0
	BEQ.S	L119
	BRA.S	L120
L119:
	LEA	G252_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA.S	L104
	BRA.S	L121
L120:
	CMP	#24,D0
	BEQ.S	L121
	BRA.S	L122
L121:
	LEA	G253_aui_G(A4),A0
	MOVE.L	A0,A3
	BRA.S	L123
L122:
	BRA	L103(PC)
L123:
L104:
	BRA	L124(PC)
L125:
	MOVE	D7,D0
	AND	#-32768,D0
	BEQ.S	L127
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L127
	BRA	L124(PC)
L127:
	MOVE	D7,D0
	AND	#32767,D0
	MOVE	D0,D7
	CMPI	#127,D0
	BCS.S	L128
	MOVE	#10,D6
	SUB	#127,D7
	BRA.S	L129
L128:
	CMPI	#69,D7
	BCS.S	L130
	MOVE	#6,D6
	SUB	#69,D7
	BRA.S	L131
L130:
	MOVE	#1,-4(A6)
	MOVE	#5,D6
	SUB	#23,D7
L131:
L129:
	MOVE	D6,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L132
	BRA.S	L124
L132:
	MOVE	D5,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	D7,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A2)
	OR	D3,2(A2)
	MOVE	-2(A6),D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-257,2(A2)
	OR	D3,2(A2)
	CMPI	#255,14(A6)
	BEQ.S	L134
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	TST	D1
	BNE.S	L133
L134:
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	BRA.S	L135
L133:
	MOVE	14(A6),D1
L135:
	ASL	#6,D1
	ASL	#8,D1
	MOVE	D5,D0
	AND	#16383,D0
	OR	D1,D0
	MOVE	D0,D5
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L124:
	MOVE	(A3)+,D7
	BNE	L125(PC)
L126:
	MOVE	16(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	-4(A6),D0
	BEQ.S	L136
	MOVE	#0,D0
	BRA.S	L137
L136:
	MOVE	#4,D0
L137:
	MOVE	D0,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L101:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$100:	.EQU	#-4
F187_czzz_:/* global */
	LINK	A6,L$138
	MOVE	G391_i_Dro(A4),D0
	BEQ.S	L140
	MOVE	8(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	BRA.S	L141
L142:
	MOVE	#2,-(A7)
	SUBQ	#1,G391_i_Dro(A4)
	MOVE	G391_i_Dro(A4),D0
	LEA	G392_auc_D(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F186_xxxx_(PC)
	ADDA	#10,A7
L141:
	MOVE	G391_i_Dro(A4),D0
	BNE.S	L142
L143:
L140:
L139:
	UNLK	A6
	RTS
L$138:	.EQU	#-2
F188_aozz_:/* global */
	LINK	A6,L$144
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#0,14(A6)
	BLT.S	L146
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	MULS	#26,D0
	LEA	G243_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#512,D0
	BEQ.S	L146
	MOVE	14(A3),D0
	AND	#96,D0
	LSR	#5,D0
	MOVE	D0,-4(A6)
	MOVE	G272_i_Cur(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F145_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-6(A6)
L147:
	MOVE	14(A6),-(A7)
	CMPI	#255,-6(A6)
	BNE.S	L150
	MOVE	#255,D0
	BRA.S	L151
L150:
	MOVE	-6(A6),D0
	MOVE	-4(A6),D1
	ASL	#1,D1
	LSR	D1,D0
	AND	#3,D0
L151:
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F186_xxxx_(PC)
	ADDA	#10,A7
L148:
	MOVE	-4(A6),D0
	SUBQ	#1,-4(A6)
	TST	D0
	BNE.S	L147
L149:
L146:
	MOVE	2(A3),D0
	MOVE	D0,D5
	CMPI	#-2,D0
	BEQ	L152(PC)
	CLR	-8(A6)
L153:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	ASL	#6,D1
	ASL	#8,D1
	MOVE	D5,D0
	AND	#16383,D0
	OR	D1,D0
	MOVE	D0,D5
	MOVE	D5,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L156
	MOVE	#1,-8(A6)
L156:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L154:
	MOVE	D4,D0
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE.S	L153
L155:
	CMPI	#0,14(A6)
	BLT.S	L157
	MOVE	14(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),D0
	BEQ.S	L158
	MOVE	#0,D0
	BRA.S	L159
L158:
	MOVE	#4,D0
L159:
	MOVE	D0,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L157:
L152:
L145:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$144:	.EQU	#-8
F189_awzz_:/* global */
	LINK	A6,L$160
	MOVEM.L	A3/D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE.S	L162
	BRA.S	L161
L162:
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#8,-(A7)
	LEA	6(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	#-1,(A3)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L163
	MOVE.B	5(A3),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	SUBQ	#1,G377_ui_Cu(A4)
L163:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F181_czzz_(PC)
	ADDQ.L	#4,A7
L161:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$160:	.EQU	#0
F190_zzzz_:/* global */
	LINK	A6,L$164
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	14(A6),D7
	MOVE	16(A6),D6
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	2(A2),D0
	AND	#8192,D0
	BEQ.S	L166
	BRA	L167(PC)
L166:
	MOVE	12(A6),D0
	ASL.L	#1,D0
	LEA	6(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	18(A6),D1
	CMP	D1,D0
	BHI	L168(PC)
	MOVE	G272_i_Cur(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F145_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-14(A6)
	CMPI	#255,-14(A6)
	BNE.S	L169
	MOVE	#255,D0
	BRA.S	L170
L169:
	MOVE	-14(A6),D0
	MOVE	12(A6),D1
	ASL	#1,D1
	LSR	D1,D0
	AND	#3,D0
L170:
	MOVE	D0,-20(A6)
	MOVE	14(A3),D0
	AND	#96,D0
	LSR	#5,D0
	MOVE	D0,-10(A6)
	BNE.S	L171
	MOVE	20(A6),D0
	BEQ.S	L172
	MOVE	#2,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F188_aozz_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
L172:
	MOVE	#2,D4
	BRA	L173(PC)
L171:
	MOVE	G272_i_Cur(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F147_aawz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-16(A6)
	MOVE	2(A2),D0
	AND	#512,D0
	BEQ.S	L174
	MOVE	20(A6),D0
	BEQ.S	L175
	MOVE	#2,-(A7)
	MOVE	-20(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-12(A6),-(A7)
	JSR	F186_xxxx_(PC)
	ADDA	#10,A7
	BRA.S	L176
L175:
	MOVE	-20(A6),D0
	MOVE	G391_i_Dro(A4),D1
	ADDQ	#1,G391_i_Dro(A4)
	LEA	G392_auc_D(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L176:
L174:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-18(A6)
	BEQ.S	L177
	MOVE.B	5(A3),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
L177:
	MOVE	14(A3),D0
	AND	#15,D0
	CMPI	#6,D0
	BNE	L178(PC)
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,-4(A6)
	BRA	L179(PC)
L180:
	MOVE.L	-4(A6),A0
	MOVE.L	(A0),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	CMP	D1,D0
	BNE.S	L182
	MOVE.L	-4(A6),A0
	MOVE.B	6(A0),D0
	AND	#255,D0
	CMP	D7,D0
	BNE.S	L182
	MOVE.L	-4(A6),A0
	MOVE.B	7(A0),D0
	AND	#255,D0
	CMP	D6,D0
	BNE.S	L182
	MOVE.L	-4(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	CMPI	#32,D0
	BLS.S	L182
	CMPI	#42,D4
	BCC.S	L182
	CMPI	#37,D4
	BCC.S	L183
	SUB	#33,D4
	BRA.S	L184
L183:
	SUB	#38,D4
L184:
	MOVE	D4,D0
	CMP	12(A6),D0
	BNE.S	L185
	MOVE	D5,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L186
L185:
	MOVE	D4,D0
	CMP	12(A6),D0
	BLS.S	L187
	MOVE.L	-4(A6),A0
	SUBQ.B	#1,4(A0)
	MOVE	D5,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L187:
L186:
L182:
	MOVE.L	-4(A6),D0
	ADDI.L	#10,-4(A6)
	MOVE	D5,D0
	ADDQ	#1,D5
L179:
	MOVE	D5,D0
	CMP	G369_ui_Ev(A4),D0
	BCS	L180(PC)
L181:
	MOVE	-18(A6),D0
	BEQ.S	L188
	MOVE	16(A2),D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,-12(A6)
	CMPI	#15,D0
	BEQ.S	L188
	MOVE	-10(A6),D1
	SUBQ	#1,D1
	MOVE	-12(A6),D0
	ADD	D1,D0
	MOVE	D0,-12(A6)
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	AND	#15,D1
	CMP	D1,D0
	BCC.S	L188
	JSR	F027_AA59_(PC)
	MOVE	#100,D1
	MOVE	-12(A6),D2
	ASL	#2,D2
	SUB	D2,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	ADD	#20,D0
	MOVE.L	-8(A6),A0
	MOVE.B	D0,5(A0)
	MOVE	#5,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
L188:
L178:
	MOVE	12(A6),D4
	MOVE	D4,D5
	BRA	L189(PC)
L190:
	ADDQ	#1,D4
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	6(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	6(A3),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	-16(A6),D0
	MOVE	D4,D1
	ASL	#1,D1
	LSR	D1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	-16(A6),-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-16(A6)
	MOVE	-14(A6),D0
	MOVE	D4,D1
	ASL	#1,D1
	LSR	D1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	-14(A6),-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-14(A6)
	MOVE	-18(A6),D0
	BEQ.S	L193
	MOVE	D4,D0
	MOVE.L	-8(A6),A0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	MOVE.L	-8(A6),A0
	LEA	12(A0),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
L193:
L191:
	ADDQ	#1,D5
L189:
	MOVE	D5,D0
	CMP	-10(A6),D0
	BCS	L190(PC)
L192:
	ANDI	#63,-14(A6)
	MOVE	G272_i_Cur(A4),-(A7)
	MOVE	-14(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F146_aczz_(PC)
	ADDQ.L	#8,A7
	MOVE	G272_i_Cur(A4),-(A7)
	MOVE	-16(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F148_aayz_(PC)
	ADDQ.L	#8,A7
	MOVE	14(A3),D0
	AND	#96,D0
	LSR	#5,D0
	SUBQ	#1,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-97,14(A3)
	OR	D3,14(A3)
	MOVE	#1,D4
L173:
	MOVE	2(A2),D0
	AND	#3,D0
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L194
	MOVE	#110,D5
	BRA.S	L195
L194:
	CMPI	#1,D5
	BNE.S	L196
	MOVE	#190,D5
	BRA.S	L197
L196:
	MOVE	#255,D5
L197:
L195:
	MOVE	-20(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,-(A7)
	MOVE	#-88,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	MOVE	D4,D0
	BRA.S	L165
L168:
	CMPI	#0,18(A6)
	BLE.S	L198
	MOVE	12(A6),D0
	ASL.L	#1,D0
	LEA	6(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	18(A6),D0
	MOVE	D0,(A0)
L198:
L167:
	MOVE	#0,D0
L165:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$164:	.EQU	#-20
F191_aayz_:/* global */
	LINK	A6,L$199
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	16(A6),D7
	CLR	-6(A6)
	MOVE	#1,-8(A6)
	CLR	G391_i_Dro(A4)
	CMPI	#0,D7
	BLE	L201(PC)
	MOVE	14(A3),D0
	AND	#96,D0
	LSR	#5,D0
	MOVE	D0,-2(A6)
	MOVE	D7,D0
	ASR	#3,D0
	ADDQ	#1,D0
	MOVE	D0,D6
	SUB	D0,D7
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
L202:
	MOVE	18(A6),-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND.L	#65535,D1
	DIVU	D6,D1
	SWAP	D1
	MOVE	D7,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F190_zzzz_(PC)
	ADDA	#14,A7
	MOVE	D0,-4(A6)
	BEQ.S	L205
	MOVE	-8(A6),D0
L205:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-8(A6)
	MOVE	-6(A6),D0
	BNE.S	L206
	MOVE	-4(A6),D0
L206:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-6(A6)
L203:
	MOVE	-2(A6),D0
	SUBQ	#1,-2(A6)
	TST	D0
	BNE.S	L202
L204:
	MOVE	-8(A6),D0
	BEQ.S	L207
	MOVE	#2,D0
	BRA.S	L200
L207:
	MOVE	-6(A6),D0
	BEQ.S	L208
	MOVE	#1,D0
	BRA.S	L200
L208:
	MOVE	#0,D0
	BRA.S	L200
	BRA.S	L209
L201:
	MOVE	#0,D0
L209:
L200:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$199:	.EQU	#-8
F192_ayzz_:/* global */
	LINK	A6,L$210
	MOVE	D7,-(A7)
	MOVE	10(A6),D0
	BEQ.S	L213
	MOVE	8(A6),D0
	MULS	#26,D0
	LEA	G243_as_Gr+18(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	LSR	#8,D0
	AND	#15,D0
	MOVE	D0,D7
	CMPI	#15,D0
	BNE.S	L212
L213:
	MOVE	#0,D0
	BRA.S	L211
L212:
	JSR	F029_AA19_(PC)
	MOVE	D0,-10(A6)
	MOVE	10(A6),D0
	ADD	-10(A6),D0
	ASL	#3,D0
	ADDQ	#1,D7
	MOVE	D7,D1
	AND.L	#65535,D0
	DIVU	D1,D0
L211:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$210:	.EQU	#-10
F193_xxxx_:/* global */
	LINK	A6,L$214
BSS SEG "bss"
19G394_auc:
	.WORD	#8
CODE SEG "dunman"
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	CLR	-2(A6)
	MOVE	12(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	JSR	F311_wzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	#100,D0
	SUB	D1,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND	#7,D0
	MOVE	D0,D5
	BRA	L216(PC)
L217:
	MOVE	D5,D0
	LEA	19G394_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	CMPI	#13,D0
	BNE.S	L219
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#17,D0
	SWAP	D0
	ADD	D0,D6
L219:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A2),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#-1,D0
	BEQ.S	L220
	MOVE	#1,-2(A6)
	MOVE	D6,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,2(A3)
	BNE.S	L221
	MOVE	D4,2(A3)
	BRA.S	L222
L221:
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	2(A3),-(A7)
	MOVE	D4,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
L222:
	MOVE	12(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L220:
	ADDQ	#1,D5
	AND	#7,D5
	SUB	#20,D7
L216:
	CMPI	#0,D7
	BLE.S	L223
	MOVE	D7,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F308_vzzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ	L217(PC)
L223:
L218:
	JSR	F027_AA59_(PC)
	AND	#7,D0
	BEQ.S	L225
	MOVE	-2(A6),D0
	BEQ.S	L224
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L224
L225:
	JSR	F027_AA59_(PC)
	AND	#63,D0
	ADD	#20,D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	MULS	#16,D1
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,5(A0)
	MOVE	#5,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
L224:
L215:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$214:	.EQU	#-2
F194_hzzz_:/* global */
	LINK	A6,L$226
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L228
L229:
	MOVE	D7,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	CMPI	#0,(A0)
	BLT.S	L231
	MOVE	D7,-(A7)
	JSR	F184_ahzz_(PC)
	ADDQ.L	#2,A7
L231:
	ADDQ	#1,D7
L228:
	CMPI	#0,G377_ui_Cu(A4)
	BHI.S	L229
L230:
L227:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$226:	.EQU	#0
F195_akzz_:/* global */
	LINK	A6,L$232
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	G271_ppuc_(A4),A0
	MOVE.L	(A0),A3
	MOVE.L	G270_pui_C(A4),A0
	MOVE	(A0),D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CLR	D7
	BRA.S	L234
L235:
	CLR	D6
	BRA.S	L238
L239:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L242
	MOVE	(A2)+,D5
L243:
	MOVE	D5,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#4,D0
	BNE.S	L246
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F181_czzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,-(A7)
	JSR	F183_kzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F180_hzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L245
L246:
L244:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE.S	L243
L245:
L242:
L240:
	ADDQ	#1,D6
L238:
	MOVE	D6,D0
	MOVE	G274_i_Cur(A4),D1
	CMP	D1,D0
	BCS.S	L239
L241:
L236:
	ADDQ	#1,D7
L234:
	MOVE	D7,D0
	MOVE	G273_i_Cur(A4),D1
	CMP	D1,D0
	BCS.S	L235
L237:
L233:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$232:	.EQU	#0
F196_aozz_:/* global */
	LINK	A6,L$247
	MOVE	D7,-(A7)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L249
	MOVE	#60,G376_ui_Ma(A4)
L249:
	MOVE	#1,-(A7)
	MOVE	G376_ui_Ma(A4),D0
	MULU	#16,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G375_ps_Ac(A4)
	CLR	D7
	BRA.S	L250
L251:
	MOVE	D7,D0
	ADDQ	#1,D7
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L250:
	MOVE	D7,D0
	CMP	G376_ui_Ma(A4),D0
	BCS.S	L251
L252:
L248:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$247:	.EQU	#0
F197_xxxx_:/* global */
	LINK	A6,L$253
	MOVEM.L	D7-D5,-(A7)
	MOVE	10(A6),D0
	MOVE	8(A6),D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	MOVE	D0,D6
	CMPI	#0,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L256
	CMPI	#6,D6
	SEQ	D0
	TST.B	D0
	BEQ.S	L257
	MOVE	D7,D0
	AND	#4,D0
	SEQ	D0
	TST.B	D0
L257:
	TST.B	D0
L256:
	TST.B	D0
	BNE.S	L255
	CMPI	#4,D6
	SEQ	D0
	TST.B	D0
	BEQ.S	L259
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D0,D5
	CMPI	#3,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L260
	CMPI	#4,D5
	SEQ	D0
	TST.B	D0
L260:
	TST.B	D0
L259:
	TST.B	D0
	BEQ.S	L258
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	AND	#1023,D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#1,D0
	ASL.L	#1,D0
	LEA	G275_as_Cu(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#1,D0
	SEQ	D0
	TST.B	D0
L258:
	TST.B	D0
L255:
	AND	#1,D0
L254:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$253:	.EQU	#0
F198_xxxx_:/* global */
	LINK	A6,L$261
	MOVEM.L	D7-D6,-(A7)
	MOVE	10(A6),D0
	MOVE	8(A6),D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	MOVE	D0,D6
	CMPI	#0,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L263
	CMPI	#6,D6
	SEQ	D0
	TST.B	D0
	BEQ.S	L264
	MOVE	D7,D0
	AND	#4,D0
	SEQ	D0
	TST.B	D0
L264:
	TST.B	D0
L263:
	AND	#1,D0
L262:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$261:	.EQU	#0
F199_xxxx_:/* global */
	LINK	A6,L$265
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	16(A6),A3
	MOVE	8(A6),D0
	MOVE	12(A6),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	10(A6),D0
	MOVE	14(A6),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	CMPI	#1,D0
	BGT.S	L267
	MOVE	#1,D0
	BRA	L266(PC)
L267:
	MOVE	12(A6),D0
	SUB	8(A6),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L268
	MOVE	D5,D0
	NEG	D0
	BRA.S	L269
L268:
	MOVE	D5,D0
L269:
	MOVE	D0,D5
	MOVE	14(A6),D1
	SUB	10(A6),D1
	MOVE	D1,D4
	CMPI	#0,D1
	BGE.S	L270
	MOVE	D4,D1
	NEG	D1
	BRA.S	L271
L270:
	MOVE	D4,D1
L271:
	MOVE	D1,D4
	CMP	D1,D0
	SLT	D0
	AND	#1,D0
	MOVE	D0,-4(A6)
	MOVE	D5,D0
	CMP	D4,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-10(A6)
	MOVE	12(A6),D7
	MOVE	D7,D5
	SUB	8(A6),D7
	CMPI	#0,D7
	BLE.S	L272
	MOVE	#-1,D7
	BRA.S	L273
L272:
	MOVE	#1,D7
L273:
	MOVE	14(A6),D6
	MOVE	D6,D4
	SUB	10(A6),D6
	CMPI	#0,D6
	BLE.S	L274
	MOVE	#-1,D6
	BRA.S	L275
L274:
	MOVE	#1,D6
L275:
	MOVE	-4(A6),D0
	BEQ.S	L276
	MOVE	D4,D0
	SUB	10(A6),D0
	MOVE	D0,-2(A6)
	BEQ.S	L277
	MOVE	D5,D0
	SUB	8(A6),D0
	ASL	#6,D0
	EXT.L	D0
	DIVS	-2(A6),D0
	BRA.S	L278
L277:
	MOVE	#128,D0
L278:
	BRA.S	L279
L276:
	MOVE	D5,D0
	SUB	8(A6),D0
	MOVE	D0,-2(A6)
	BEQ.S	L280
	MOVE	D4,D0
	SUB	10(A6),D0
	ASL	#6,D0
	EXT.L	D0
	DIVS	-2(A6),D0
	BRA.S	L281
L280:
	MOVE	#128,D0
L281:
L279:
	MOVE	D0,-12(A6)
L282:
	MOVE	-10(A6),D0
	BEQ.S	L285
	MOVE	D4,-(A7)
	MOVE	D5,D0
	ADD	D7,D0
	MOVE	D0,-(A7)
	JSR	(A3)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L288
	MOVE	D4,D0
	ADD	D6,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	(A3)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L287
L288:
	MOVE	D4,D0
	ADD	D6,D0
	MOVE	D0,D4
	MOVE	D0,-(A7)
	MOVE	D5,D0
	ADD	D7,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	JSR	(A3)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L286
L287:
	MOVE	#0,D0
	BRA	L266(PC)
L286:
	BRA	L289(PC)
L285:
	MOVE	-4(A6),D0
	BEQ.S	L292
	MOVE	D4,D0
	SUB	10(A6),D0
	MOVE	D0,-2(A6)
	BEQ.S	L293
	MOVE	D5,D0
	ADD	D7,D0
	SUB	8(A6),D0
	ASL	#6,D0
	EXT.L	D0
	DIVS	-2(A6),D0
	BRA.S	L294
L293:
	MOVE	#128,D0
L294:
	BRA.S	L295
L292:
	MOVE	D5,D0
	ADD	D7,D0
	SUB	8(A6),D0
	MOVE	D0,-2(A6)
	BEQ.S	L296
	MOVE	D4,D0
	SUB	10(A6),D0
	ASL	#6,D0
	EXT.L	D0
	DIVS	-2(A6),D0
	BRA.S	L297
L296:
	MOVE	#128,D0
L297:
L295:
	SUB	-12(A6),D0
	MOVE	D0,-2(A6)
	CMPI	#0,D0
	BGE.S	L291
	MOVE	-2(A6),D0
	NEG	D0
	BRA.S	L298
L291:
	MOVE	-2(A6),D0
L298:
	MOVE	D0,-6(A6)
	MOVE	-4(A6),D1
	BEQ.S	L300
	MOVE	D4,D1
	ADD	D6,D1
	SUB	10(A6),D1
	MOVE	D1,-2(A6)
	BEQ.S	L301
	MOVE	D5,D1
	SUB	8(A6),D1
	ASL	#6,D1
	EXT.L	D1
	DIVS	-2(A6),D1
	BRA.S	L302
L301:
	MOVE	#128,D1
L302:
	BRA.S	L303
L300:
	MOVE	D5,D1
	SUB	8(A6),D1
	MOVE	D1,-2(A6)
	BEQ.S	L304
	MOVE	D4,D1
	ADD	D6,D1
	SUB	10(A6),D1
	ASL	#6,D1
	EXT.L	D1
	DIVS	-2(A6),D1
	BRA.S	L305
L304:
	MOVE	#128,D1
L305:
L303:
	SUB	-12(A6),D1
	MOVE	D1,-2(A6)
	CMPI	#0,D1
	BGE.S	L299
	MOVE	-2(A6),D1
	NEG	D1
	BRA.S	L306
L299:
	MOVE	-2(A6),D1
L306:
	MOVE	D1,-8(A6)
	CMP	D1,D0
	BGE.S	L290
	ADD	D7,D5
	BRA.S	L307
L290:
	ADD	D6,D4
L307:
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	(A3)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L308
	MOVE	-6(A6),D0
	CMP	-8(A6),D0
	BNE.S	L309
	MOVE	D4,D0
	SUB	D6,D0
	MOVE	D0,D4
	MOVE	D0,-(A7)
	MOVE	D5,D0
	ADD	D7,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	JSR	(A3)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L308
L309:
	MOVE	#0,D0
	BRA.S	L266
L308:
L289:
L283:
	MOVE	D5,D0
	MOVE	8(A6),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	D4,D0
	MOVE	10(A6),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	CMPI	#1,D0
	BGT	L282(PC)
L284:
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F226_ozzz_(PC)
	ADDQ.L	#8,A7
L266:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$265:	.EQU	#-12
F200_xxxx_:/* global */
	LINK	A6,L$310
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	G407_s_Par+3286(A4),D0
	BEQ.S	L312
	MOVE	2(A2),D0
	AND	#2048,D0
	BNE.S	L312
	MOVE	#0,D0
	BRA	L311(PC)
L312:
	MOVE	2(A2),D0
	AND	#4,D0
	BEQ.S	L313
	BRA	L26T200_011(PC)
L313:
	MOVE.B	5(A3),D4
	AND	#255,D4
	MULS	#16,D4
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D4,A0
	MOVE.B	2(A0),D4
	AND	#255,D4
	CMPI	#0,12(A6)
	BGE.S	L314
	CLR	D6
	MOVE	14(A3),D0
	AND	#96,D0
	LSR	#5,D0
	MOVE	D0,12(A6)
	BRA.S	L315
L316:
	MOVE	D4,D7
	MOVE	12(A6),D1
	ASL	#1,D1
	LSR	D1,D7
	AND	#3,D7
	MOVE	D6,D5
	BRA.S	L318
L319:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	CMP	D7,D0
	BNE.S	L321
	BRA.S	L26T200_006
L321:
L318:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L319
L320:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE	D7,(A0)
L26T200_006:
	SUBQ	#1,12(A6)
L315:
	CMPI	#0,12(A6)
	BGE.S	L316
L317:
	BRA.S	L322
L314:
	MOVE	D4,D0
	MOVE	12(A6),D1
	ASL	#1,D1
	LSR	D1,D0
	AND	#3,D0
	MOVE	D0,-8(A6)
	MOVE	#1,D6
L322:
	BRA	L323(PC)
L324:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F227_qzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L326
L26T200_011:
	MOVE	14(A2),D5
	AND	#15,D5
	MOVE	2(A2),D0
	AND	#4096,D0
	BNE.S	L327
	MOVE	G304_i_Dun(A4),D0
	ASR	#1,D0
	SUB	D0,D5
L327:
	MOVE	D5,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-18(A6)
	MOVE	G381_ui_Cu(A4),D0
	CMP	-18(A6),D0
	BLS.S	L328
	MOVE	#0,D0
	BRA.S	L311
L328:
	PEA	F197_xxxx_(PC)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F199_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L311
L326:
L323:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE	L324(PC)
L325:
	MOVE	#0,D0
L311:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$310:	.EQU	#-18
F201_xxxx_:/* global */
	LINK	A6,L$329
	MOVEM.L	D7-D6,-(A7)
	MOVE.L	8(A6),A0
	MOVE	14(A0),D0
	LSR	#8,D0
	AND	#15,D0
	MOVE	D0,D7
	BNE.S	L331
	MOVE	#0,D0
	BRA	L330(PC)
L331:
	MOVE	D7,D0
	ADDQ	#1,D0
	LSR	#1,D0
	CMP	G381_ui_Cu(A4),D0
	BCS.S	L332
	PEA	F198_xxxx_(PC)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F199_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BEQ.S	L332
	MOVE	G383_i_Cur(A4),G363_i_Sec(A4)
	MOVE	G382_i_Cur(A4),D0
	ADDQ	#1,D0
	BRA.S	L330
L332:
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F315_arzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BEQ.S	L333
	JSR	F029_AA19_(PC)
	MOVE	D0,-10(A6)
	LEA	G407_s_Par+3261(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	-10(A6),D0
	MOVE	#30,D1
	MOVE	D7,D2
	ASL	#1,D2
	SUB	D2,D1
	CMP	D1,D0
	BLS.S	L333
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#992,D0
	LSR	#5,D0
	MOVE	D0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#31,D0
	MOVE	D0,-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F228_uzzz_(PC)
	ADDQ.L	#8,A7
	ADDQ	#1,D0
	BRA.S	L330
L333:
	MOVE	#0,D0
L330:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$329:	.EQU	#-10
F202_xxxx_:/* global */
	LINK	A6,L$334
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	16(A6),D0
	LEA	G384_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	#1,(A0)
	MOVE	#-2,G388_T_Gro(A4)
	CLR	G389_B_Gro(A4)
	CLR	G390_B_Gro(A4)
	MOVE.B	6(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L336
	MOVE	#0,D0
	BRA	L335(PC)
L336:
	PEA	14(A6)
	PEA	12(A6)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	16(A6),-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CMPI	#0,D7
	SGE	D0
	TST.B	D0
	BEQ.S	L343
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	SLT	D0
	TST.B	D0
L343:
	TST.B	D0
	BEQ.S	L342
	CMPI	#0,D6
	SGE	D0
	TST.B	D0
	BEQ.S	L344
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	SLT	D0
	TST.B	D0
L344:
	TST.B	D0
L342:
	TST.B	D0
	BEQ.S	L341
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	LSR	#5,D0
	MOVE	D0,D4
	CMPI	#0,D0
	SNE	D0
	TST.B	D0
L341:
	TST.B	D0
	BEQ.S	L340
	CMPI	#3,D4
	SNE	D0
	TST.B	D0
L340:
	TST.B	D0
	BEQ.S	L339
	CMPI	#2,D4
	SNE	D0
	TST.B	D0
	BNE.S	L347
	MOVE	D5,D0
	AND	#1,D0
	BEQ.S	L348
	MOVE	18(A6),D0
L348:
	SNE	D0
	TST.B	D0
L347:
	TST.B	D0
	BNE.S	L346
	MOVE	D5,D0
	AND	#8,D0
	SEQ	D0
	TST.B	D0
L346:
	TST.B	D0
	BNE.S	L345
	MOVE	2(A3),D0
	AND	#32,D0
L345:
	SNE	D0
	TST.B	D0
L339:
	TST.B	D0
	BEQ.S	L338
	CMPI	#6,D4
	SNE	D0
	TST.B	D0
	BNE.S	L350
	MOVE	D5,D0
	AND	#4,D0
L350:
	SNE	D0
	TST.B	D0
	BNE.S	L349
	MOVE	D5,D0
	AND	#1,D0
	BEQ.S	L351
	MOVE	18(A6),D0
L351:
	SNE	D0
	TST.B	D0
L349:
	TST.B	D0
L338:
	TST.B	D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,G387_B_Gro(A4)
	BEQ.S	L337
	MOVE	#0,D0
	BRA	L335(PC)
L337:
	MOVE	2(A3),D0
	AND	#8192,D0
	BEQ.S	L352
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-2(A6)
	BRA.S	L353
L354:
	MOVE	-2(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE.S	L357
	MOVE	-2(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+60(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	CMPI	#50,D0
	BNE.S	L358
	MOVE	16(A6),D0
	LEA	G385_ac_Fl(A4),A0
	ADDA	D0,A0
	MOVE.B	#1,(A0)
	ADDQ	#1,G386_ui_Fl(A4)
	MOVE	#1,G387_B_Gro(A4)
	MOVE	#0,D0
	BRA	L335(PC)
L358:
L357:
L355:
	MOVE	-2(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
L353:
	CMPI	#-2,-2(A6)
	BNE.S	L354
L356:
L352:
	CMPI	#5,D4
	BNE.S	L359
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L359
	MOVE	16(A3),D0
	LSR	#4,D0
	LSR	#8,D0
	CMPI	#10,D0
	BCS.S	L359
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#24576,D0
	LSR	#5,D0
	LSR	#8,D0
	AND	#1,D0
	BEQ.S	L360
	MOVE	4(A2),D0
	AND	#-256,D0
	LSR	#8,D0
	MOVE	D0,-(A7)
	MOVE	G380_T_Cur(A4),-(A7)
	JSR	F139_aqzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L360
	MOVE	#1,G387_B_Gro(A4)
	MOVE	#0,D0
	BRA	L335(PC)
L360:
L359:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L363
	MOVE	D7,D0
	CMP	G306_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
L363:
	TST.B	D0
	BEQ.S	L362
	MOVE	D6,D0
	CMP	G307_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
L362:
	AND	#1,D0
	MOVE	D0,G390_B_Gro(A4)
	BEQ.S	L361
	MOVE	#0,D0
	BRA	L335(PC)
L361:
	CMPI	#4,D4
	SEQ	D0
	TST.B	D0
	BEQ.S	L365
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	AND	#1023,D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#32,D0
	LSR	#5,D0
	BEQ.S	L368
	MOVE	2(A3),D0
	LSR	#7,D0
	AND	#3,D0
	BRA.S	L369
L368:
	MOVE	#1,D0
L369:
	MOVE	D0,-12(A6)
	MOVE	D5,D0
	AND	#7,D0
	CMP	-12(A6),D0
	SLS	D0
	TST.B	D0
	BNE.S	L367
	MOVE	D5,D0
	AND	#7,D0
	CMPI	#5,D0
	SEQ	D0
	TST.B	D0
L367:
	TST.B	D0
	BNE.S	L366
	MOVE	2(A3),D0
	AND	#64,D0
L366:
	SNE	D0
	TST.B	D0
	SEQ	D0
	TST.B	D0
L365:
	AND	#1,D0
	MOVE	D0,G389_B_Gro(A4)
	BEQ.S	L364
	MOVE	#0,D0
	BRA.S	L335
L364:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,G388_T_Gro(A4)
	CMPI	#-2,D0
	SEQ	D0
	AND	#1,D0
L335:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$334:	.EQU	#-12
F203_xxxx_:/* global */
	LINK	A6,L$370
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L372
L373:
	LEA	G384_ac_Gr(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D0
	BNE.S	L376
	MOVE	16(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BEQ.S	L376
	MOVE	D7,D0
	ADDQ	#1,D0
	BRA.S	L371
L376:
L374:
	ADDQ	#1,D7
L372:
	CMPI	#3,D7
	BLE.S	L373
L375:
	MOVE	#0,D0
L371:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$370:	.EQU	#0
F204_xxxx_:/* global */
	LINK	A6,L$377
	MOVE	D7,-(A7)
	MOVE	16(A6),D7
	MOVE	D7,D0
	LEA	G385_ac_Fl(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	BEQ.S	L379
	MOVE	#0,D0
	BRA.S	L378
L379:
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	12(A6),D0
	ADD	D1,D0
	MOVE	D0,12(A6)
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	14(A6),D0
	ADD	D1,D0
	MOVE	D0,14(A6)
	CLR	-(A7)
	MOVE	D7,-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
L378:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$377:	.EQU	#0
F205_xxxx_:/* global */
	LINK	A6,L$380
BSS SEG "bss"
32G395_l_T:
	.WORD	#4
33G396_ps_:
	.WORD	#4
CODE SEG "dunman"
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	16(A6),D0
	BEQ.S	L382
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	32G395_l_T(A4),D0
	BNE.S	L382
	MOVE.L	A3,D0
	CMP.L	33G396_ps_(A4),D0
	BNE.S	L382
	BRA.S	L381
L382:
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,D5
	MOVE	D6,D1
	ASL	#1,D1
	LSR	D1,D0
	AND	#3,D0
	SUB	D7,D0
	AND	#3,D0
	CMPI	#2,D0
	BNE.S	L383
	JSR	F027_AA59_(PC)
	AND	#2,D0
	ADD	D7,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	BRA.S	L384
L383:
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
L384:
	MOVE	16(A6),D0
	BEQ.S	L385
	MOVE	D7,-(A7)
	MOVE	D6,D0
	MOVE	#1,D3
	EOR	D3,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	MOVE.L	G313_ul_Ga(A4),32G395_l_T(A4)
	MOVE.L	A3,33G396_ps_(A4)
L385:
	MOVE	D5,D0
	MOVE.B	D0,2(A3)
L381:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$380:	.EQU	#0
F206_xxxx_:/* global */
	LINK	A6,L$386
	MOVEM.L	D7-D6,-(A7)
	MOVE	14(A6),D7
	MOVE	D7,D6
	BEQ.S	L389
	CMPI	#1,16(A6)
	SEQ	D6
	TST.B	D6
L389:
	SNE	D6
	AND	#1,D6
	BEQ.S	L388
	SUBQ	#1,D7
L388:
L390:
	MOVE	D7,D0
	BEQ.S	L394
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L393
L394:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F205_xxxx_(PC)
	ADDA	#10,A7
L393:
L391:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L390
L392:
L387:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$386:	.EQU	#0
F207_xxxx_:/* global */
	LINK	A6,L$395
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	G313_ul_Ga(A4),G361_l_Las(A4)
	MOVE.B	5(A3),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-20(A6),A0
	MOVEQ	#7,D0
	JSR	_blockmv(PC)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	G382_i_Cur(A4),D6
	MOVE.B	-17(A6),D0
	AND	#255,D0
	MOVE	D0,D5
	CMPI	#255,D0
	BNE.S	L397
	JSR	F028_a000_(PC)
	MOVE	D0,D5
	BRA.S	L398
L397:
	MOVE	D5,D0
	MOVE	16(A6),D1
	ASL	#1,D1
	ASR	D1,D0
	AND	#3,D0
	ADDQ	#5,D0
	SUB	D6,D0
	AND	#2,D0
	LSR	#1,D0
	MOVE	D0,D5
L398:
	ADD	D6,D5
	AND	#3,D5
	MOVE	14(A2),D0
	LSR	#4,D0
	LSR	#8,D0
	CMPI	#1,D0
	BLS	L399(PC)
	CMPI	#1,G381_ui_Cu(A4)
	BHI.S	L400
	JSR	F028_a000_(PC)
	TST	D0
	BEQ	L399(PC)
L400:
	MOVE	D7,D0
L401:
	CMP	#14,D0
	BEQ.S	L402
L404:
	CMP	#23,D0
	BEQ.S	L402
	BRA.S	L405
L402:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L407
	MOVE	#-128,D7
	BRA.S	L408
L407:
	JSR	F029_AA19_(PC)
L409:
	CMP	#0,D0
	BEQ.S	L410
	BRA.S	L412
L410:
	MOVE	#-125,D7
	BRA.S	L411
	BRA.S	L413
L412:
	CMP	#1,D0
	BEQ.S	L413
	BRA.S	L414
L413:
	MOVE	#-126,D7
	BRA.S	L411
	BRA.S	L415
L414:
	CMP	#2,D0
	BEQ.S	L415
	BRA.S	L416
L415:
	MOVE	#-121,D7
	BRA.S	L411
	BRA.S	L417
L416:
	CMP	#3,D0
	BEQ.S	L417
	BRA.S	L418
L417:
	MOVE	#-124,D7
L418:
L419:
L411:
L408:
	BRA.S	L403
	BRA.S	L406
L405:
	CMP	#1,D0
	BEQ.S	L406
	BRA.S	L420
L406:
	MOVE	#-127,D7
	BRA.S	L403
	BRA.S	L421
L420:
	CMP	#3,D0
	BEQ.S	L421
	BRA.S	L422
L421:
	JSR	F027_AA59_(PC)
	AND	#7,D0
	BEQ.S	L424
	MOVE	#-126,D7
	BRA.S	L425
L424:
	MOVE	#-124,D7
L425:
	BRA.S	L403
	BRA.S	L423
L422:
	CMP	#19,D0
	BEQ.S	L423
	BRA.S	L426
L423:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L428
	MOVE	#-121,D7
	BRA.S	L403
L428:
	BRA.S	L427
L426:
	CMP	#22,D0
	BEQ.S	L427
L429:
	CMP	#24,D0
	BEQ.S	L427
	BRA.S	L430
L427:
	MOVE	#-128,D7
L430:
L431:
L403:
	MOVE.B	10(A2),D4
	AND	#255,D4
	ASR	#2,D4
	ADDQ	#1,D4
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D4,D0
	SWAP	D0
	ADD	D0,D4
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D4,D0
	SWAP	D0
	ADD	D0,D4
	MOVE	#8,-(A7)
	MOVE.B	12(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	#255,-(A7)
	MOVE	D4,-(A7)
	MOVE	#20,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-(A7)
	MOVE	G382_i_Cur(A4),-(A7)
	MOVE	D5,-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	BRA	L432(PC)
L399:
	MOVE	2(A2),D0
	AND	#16,D0
	BEQ.S	L433
	MOVE	#0,D0
	MOVE	D0,D4
	JSR	F029_AA19_(PC)
	MOVE	D0,D5
	BRA.S	L434
L435:
	MOVE	D4,D0
	ADDQ	#1,D4
	MOVE	D5,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,D5
L434:
	CMPI	#4,D4
	BGE.S	L437
	MOVE	D5,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BEQ.S	L435
L437:
L436:
	CMPI	#4,D4
	BNE.S	L438
	MOVE	#0,D0
	BRA	L396(PC)
L438:
	BRA.S	L439
L433:
	MOVE	D5,-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F286_hzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L440
	MOVE	#0,D0
	BRA	L396(PC)
L440:
L439:
	CMPI	#2,D7
	BNE.S	L441
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F193_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L442
L441:
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F230_ezzz_(PC)
	ADDQ.L	#6,A7
	ADDQ	#1,D0
	MOVE	D0,D4
	MOVE	D5,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
	MOVE	D4,D0
	MOVE.L	-4(A6),A0
	MOVE.B	41(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BLE.S	L443
	MOVE	D4,D0
	MOVE.L	-4(A6),A0
	MOVE.B	D0,41(A0)
	MOVE	D6,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE.L	-4(A6),A0
	MOVE.B	D0,40(A0)
L443:
L442:
L432:
	MOVE.B	1(A2),D4
	AND	#255,D4
	BEQ.S	L444
	MOVE	#1,-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	SUBQ	#1,D4
	MOVE	D4,D0
	LEA	G244_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L444:
	MOVE	#1,D0
L396:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$395:	.EQU	#-20
F208_xxxx_:/* global */
	LINK	A6,L$445
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),D7
	MOVE.L	D7,D0
	MOVE.L	(A3),D1
	AND.L	#16777215,D1
	CMP.L	D1,D0
	BGE.S	L447
	SUBQ.B	#5,4(A3)
	MOVE.L	(A3),D0
	AND.L	#16777215,D0
	SUB.L	D7,D0
	MOVE.B	D0,8(A3)
	MOVE.L	(A3),D0
	AND.L	#-16777216,D0
	OR.L	D7,D0
	MOVE.L	D0,(A3)
	BRA.S	L448
L447:
	MOVE.L	D7,D0
	MOVE.L	(A3),D1
	AND.L	#16777215,D1
	SUB.L	D1,D0
	MOVE.B	D0,8(A3)
L448:
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L446:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$445:	.EQU	#0
F209_xzzz_:/* global */
	LINK	A6,L$449
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BEQ.S	L451
	MOVE	12(A6),D0
	MOVE	D0,D5
	CMPI	#37,D0
	BEQ.S	L451
	CMPI	#32,D5
	BEQ.S	L451
	CMPI	#38,D5
	BEQ.S	L451
	CMPI	#33,D5
	BEQ.S	L451
	BRA	L450(PC)
L451:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-28(A6)
	CMPI	#-2,D0
	BNE.S	L452
	BRA	L450(PC)
L452:
	MOVE	-28(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-26(A6),A0
	MOVEQ	#12,D0
	JSR	_blockmv(PC)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-70(A6)
	MOVE	#255,D0
	MOVE.B	-20(A6),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,-65(A6)
	MOVE	D7,D0
	MOVE.B	D0,-64(A6)
	MOVE	D6,D0
	MOVE.B	D0,-63(A6)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BEQ	L453(PC)
	CLR	-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BEQ.S	L454
	MOVE	D7,-30(A6)
	MOVE	D6,-32(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-30(A6),D0
	ADD	D1,D0
	MOVE	D0,-30(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-32(A6),D0
	ADD	D1,D0
	MOVE	D0,-32(A6)
	MOVE	-32(A6),-(A7)
	MOVE	-30(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-28(A6),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L455
	BRA	L450(PC)
L455:
	MOVE	G397_i_Mov(A4),D0
	MOVE.B	D0,-64(A6)
	MOVE	G398_i_Mov(A4),D0
	MOVE.B	D0,-63(A6)
L454:
	MOVE.B	#37,-66(A6)
	MOVE.B	-20(A6),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	#10,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
L37T209_005:
	MOVE	D5,D0
	EXT.L	D0
	ADD.L	D0,-70(A6)
	PEA	-70(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L450(PC)
L453:
	MOVE	-24(A6),D0
	AND	#8192,D0
	MOVE	D0,-56(A6)
	BEQ.S	L456
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L457
	BRA	L450(PC)
L457:
	CLR	G386_ui_Fl(A4)
	LEA	G385_ac_Fl(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L456:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.L	G313_ul_Ga(A4),D0
	AND	#255,D0
	MOVE.B	4(A2),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,-54(A6)
	CMPI	#0,D0
	BGE.S	L458
	ADDI	#256,-54(A6)
L458:
	MOVE.B	-20(A6),D0
	AND	#255,D0
	MOVE	D0,-52(A6)
	CMPI	#255,D0
	BNE.S	L459
	MOVE	#100,-52(A6)
L459:
	CMPI	#0,12(A6)
	BGE.S	L460
	MOVE	12(A6),D0
	ADD	#32,D0
	MOVE.B	D0,-66(A6)
	CMPI	#-1,12(A6)
	BEQ.S	L462
	MOVE	-52(A6),D0
	ADDQ	#2,D0
	ASR	#2,D0
	SUB	-54(A6),D0
	MOVE	D0,D5
	CMPI	#1,D0
	BGE.S	L461
L462:
	MOVE	#1,D5
L461:
	BRA	L37T209_005(PC)
L460:
	MOVE.B	G407_s_Par+3211(A4),D0
	BEQ.S	L463
	MOVE	-56(A6),D0
	BNE.S	L463
	MOVE	12(A6),D0
	MOVE.B	D0,-66(A6)
	MOVE	14(A6),D0
	MOVE.B	D0,-62(A6)
	MOVE	#4,D5
	BRA	L37T209_005(PC)
L463:
	MOVE	14(A3),D4
	AND	#15,D4
	MOVE	14(A3),D0
	AND	#96,D0
	LSR	#5,D0
	MOVE	D0,-50(A6)
	MOVE	-24(A6),D0
	AND	#3,D0
	MOVE	D0,-48(A6)
	MOVE	D7,D0
	SUB	G306_i_Par(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L464
	MOVE	D5,D0
	NEG	D0
	BRA.S	L465
L464:
	MOVE	D5,D0
L465:
	MOVE	D0,-30(A6)
	MOVE	D6,D0
	SUB	G307_i_Par(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L466
	MOVE	D5,D0
	NEG	D0
	BRA.S	L467
L466:
	MOVE	D5,D0
L467:
	MOVE	D0,-32(A6)
	MOVE	D7,G378_i_Cur(A4)
	MOVE	D6,G379_i_Cur(A4)
	MOVE	-28(A6),G380_T_Cur(A4)
	LEA	G384_ac_Gr(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F226_ozzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G381_ui_Cu(A4)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F228_uzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G382_i_Cur(A4)
	MOVE	G363_i_Sec(A4),G383_i_Cur(A4)
	CLR.L	-60(A6)
	MOVE	#1,-40(A6)
	CMPI	#31,12(A6)
	BGT	L468(PC)
	MOVE	12(A6),D0
	SUB	#32,D0
	MOVE	D0,12(A6)
L469:
	CMP	#-1,D0
	BEQ.S	L470
	BRA.S	L472
L470:
	CMPI	#6,D4
	BEQ.S	L474
	CMPI	#5,D4
	BEQ.S	L474
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F181_czzz_(PC)
	ADDQ.L	#4,A7
	BRA	L37T209_044(PC)
L474:
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
	BRA	L450(PC)
	BRA.S	L473
L472:
	CMP	#-2,D0
	BEQ.S	L473
	BRA.S	L475
L473:
	CMPI	#6,D4
	BEQ.S	L478
	CMPI	#5,D4
	BNE.S	L477
L478:
	BRA	L450(PC)
L477:
	CMPI	#3,D4
	SEQ	D0
	TST.B	D0
	BNE.S	L481
	CMPI	#2,D4
	SEQ	D0
	TST.B	D0
L481:
	AND	#1,D0
	MOVE	D0,D5
	BNE.S	L480
	JSR	F029_AA19_(PC)
	TST	D0
	BEQ.S	L479
L480:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F200_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L482
	MOVE	#0,D0
	MOVE	D0,-36(A6)
	MOVE	D0,-46(A6)
	BRA	L37T209_073(PC)
L482:
	MOVE	D5,D0
	BNE.S	L484
	JSR	F029_AA19_(PC)
	TST	D0
	BEQ.S	L483
L484:
	BRA	L450(PC)
L483:
L479:
	BRA.S	L476
L475:
	CMP	#-3,D0
	BEQ.S	L476
	BRA.S	L485
L476:
	CMPI	#6,D4
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-46(A6)
	CLR	-36(A6)
	BRA	L37T209_058(PC)
L485:
L486:
L471:
L468:
	CMPI	#37,12(A6)
	BGE	L487(PC)
	MOVE	12(A6),D0
	ADDQ	#5,D0
	MOVE.B	D0,-66(A6)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F200_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L488
	CMPI	#6,D4
	BEQ.S	L489
	CMPI	#5,D4
	BEQ.S	L489
	MOVE	G306_i_Par(A4),D0
	MOVE	D7,D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	G307_i_Par(A4),D0
	MOVE	D6,D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	CMPI	#1,D0
	BGT.S	L490
	BRA	L37T209_044(PC)
L490:
	CMPI	#0,D4
	BEQ.S	L492
	CMPI	#3,D4
	BNE.S	L491
L492:
	CMPI	#7,D4
	BEQ.S	L491
	BRA	L37T209_054(PC)
L491:
L489:
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
L488:
	CMPI	#6,D4
	BNE.S	L493
	MOVE	12(A6),D5
	SUB	#33,D5
	LEA	12(A2),A0
	ADDA	D5,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#128,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F179_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	D0,-60(A6)
	BRA	L37T209_136(PC)
L493:
	CMPI	#3,-30(A6)
	BGT.S	L495
	CMPI	#3,-32(A6)
	BLE.S	L494
L495:
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-6(A6),D1
	LSR	#4,D1
	AND	#15,D1
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,-60(A6)
	BRA	L37T209_136(PC)
L494:
	BRA	L496(PC)
L487:
	CLR	-40(A6)
	MOVE	14(A6),D0
	BEQ.S	L497
	MOVE.L	G313_ul_Ga(A4),-60(A6)
L497:
	CMPI	#37,12(A6)
	BNE	L498(PC)
	CMPI	#0,D4
	BEQ.S	L500
	CMPI	#2,D4
	BEQ.S	L500
	CMPI	#3,D4
	BNE	L499(PC)
L500:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F200_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,-34(A6)
	BEQ	L501(PC)
	MOVE	-34(A6),D0
	MOVE	-12(A6),D1
	LSR	#4,D1
	LSR	#8,D1
	CMP	D1,D0
	BHI	L502(PC)
	MOVE	-30(A6),D0
	BEQ.S	L503
	MOVE	-32(A6),D0
	BNE	L502(PC)
L503:
L37T209_044:
	CMPI	#-2,12(A6)
	BNE.S	L504
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F181_czzz_(PC)
	ADDQ.L	#4,A7
L504:
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
	MOVE	#6,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	MOVE	G382_i_Cur(A4),D5
	MOVE	-50(A6),D4
	BRA	L505(PC)
L506:
	MOVE.B	2(A2),D0
	MOVE	D4,D1
	ASL	#1,D1
	AND	#255,D0
	ASR	D1,D0
	AND	#3,D0
	CMP	D5,D0
	BEQ.S	L509
	MOVE	D4,D0
	BEQ.S	L510
	JSR	F028_a000_(PC)
	TST	D0
	BNE.S	L509
L510:
	MOVE	-50(A6),D0
	BEQ.S	L511
	CMPI	#1,-48(A6)
	SEQ	D0
	TST.B	D0
L511:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F205_xxxx_(PC)
	ADDA	#10,A7
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE	D1,-80(A6)
	MOVE.L	G313_ul_Ga(A4),D1
	MOVE	-80(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D1
	ADDQ.L	#2,D1
	MOVE.L	-70(A6),D0
	AND.L	#-16777216,D0
	OR.L	D1,D0
	MOVE.L	D0,-70(A6)
	BRA.S	L512
L509:
	MOVE.L	-70(A6),D0
	AND.L	#-16777216,D0
	MOVE.L	G313_ul_Ga(A4),D1
	ADDQ.L	#1,D1
	OR.L	D1,D0
	MOVE.L	D0,-70(A6)
L512:
	MOVE	-40(A6),D0
	BEQ.S	L513
	MOVE	14(A6),-(A7)
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE.B	-19(A6),D0
	AND	#255,D0
	ASR	#1,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	EXT.L	D0
	ADD.L	D0,-70(A6)
L513:
	MOVE	#38,D0
	ADD	D4,D0
	MOVE.B	D0,-66(A6)
	CLR	-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F179_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	D0,-(A7)
	PEA	-70(A6)
	JSR	F208_xxxx_(PC)
	ADDQ.L	#8,A7
L507:
	SUBQ	#1,D4
L505:
	CMPI	#0,D4
	BGE	L506(PC)
L508:
	BRA	L450(PC)
L502:
	CMPI	#2,D4
	BEQ.S	L514
L37T209_054:
	MOVE	#7,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
	ADDQ.L	#1,-70(A6)
	BRA	L37T209_134(PC)
L514:
	BRA	L515(PC)
L501:
	CMPI	#0,D4
	BNE	L516(PC)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F201_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-38(A6)
	BEQ.S	L517
	SUBQ	#1,-38(A6)
	CLR	-42(A6)
	BRA	L37T209_085(PC)
L517:
	CLR	-36(A6)
	JSR	F028_a000_(PC)
	TST	D0
	BEQ	L518(PC)
L37T209_058:
	JSR	F029_AA19_(PC)
	MOVE	D0,D5
	MOVE	D5,D4
	CLR	-44(A6)
L519:
	MOVE	D7,-30(A6)
	MOVE	D6,-32(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-30(A6),D0
	ADD	D1,D0
	MOVE	D0,-30(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-32(A6),D0
	ADD	D1,D0
	MOVE	D0,-32(A6)
	MOVE.B	8(A2),D0
	AND	#255,D0
	CMP	-30(A6),D0
	BNE.S	L523
	MOVE.B	9(A2),D0
	AND	#255,D0
	CMP	-32(A6),D0
	BNE.S	L523
	JSR	F029_AA19_(PC)
	TST	D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-44(A6)
	BEQ	L522(PC)
L523:
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BEQ.S	L522
L37T209_061:
	MOVE	-52(A6),D0
	ASR	#1,D0
	SUB	-54(A6),D0
	MOVE	D0,D4
	CMPI	#0,D0
	SLE	D0
	AND	#1,D0
	MOVE	D0,-36(A6)
	BEQ.S	L524
	MOVE	-32(A6),-(A7)
	MOVE	-30(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-28(A6),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L525
	BRA	L450(PC)
L525:
	MOVE	G397_i_Mov(A4),D0
	MOVE.B	D0,-64(A6)
	MOVE	G398_i_Mov(A4),D0
	MOVE.B	D0,-63(A6)
	MOVE	D7,D0
	MOVE.B	D0,8(A2)
	MOVE	D6,D0
	MOVE.B	D0,9(A2)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE.B	D0,4(A2)
	BRA.S	L526
L524:
	MOVE	D4,-52(A6)
	MOVE	#-1,-54(A6)
L526:
	BRA.S	L521
L522:
	MOVE	G390_B_Gro(A4),D0
	BEQ.S	L527
	CMPI	#-3,12(A6)
	BEQ.S	L528
	MOVE	14(A3),D0
	AND	#15,D0
	CMPI	#5,D0
	BNE.S	L529
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F203_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L529
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L528
L529:
	BRA	L37T209_044(PC)
L528:
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
L527:
L520:
	MOVE	D5,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,D5
	CMP	D4,D0
	BNE	L519(PC)
L521:
L518:
	MOVE	-36(A6),D0
	BNE.S	L530
	MOVE	-56(A6),D0
	BEQ.S	L530
	CMPI	#-3,12(A6)
	BEQ.S	L531
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L530
L531:
	BRA	L37T209_089(PC)
L530:
	MOVE	-36(A6),D0
	BNE.S	L533
	JSR	F029_AA19_(PC)
	TST	D0
	BEQ.S	L534
	MOVE	-34(A6),D0
	MOVE	-12(A6),D1
	LSR	#8,D1
	AND	#15,D1
	CMP	D1,D0
	BHI.S	L532
L534:
	CMPI	#-3,12(A6)
	BEQ.S	L532
L533:
L37T209_073:
	MOVE	-36(A6),D0
	BNE.S	L535
	CMPI	#0,-54(A6)
	BLT.S	L535
	JSR	F029_AA19_(PC)
	MOVE	D0,D5
L535:
	MOVE	-48(A6),-(A7)
	MOVE	-50(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F206_xxxx_(PC)
	ADDA	#10,A7
L532:
	CMPI	#-1,12(A6)
	BGE.S	L536
	MOVE	-36(A6),D0
	BNE.S	L537
	BRA	L450(PC)
L537:
	MOVE	-46(A6),D0
	BEQ.S	L538
	MOVE	#7,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
L538:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F182_aqzz_(PC)
	ADDQ.L	#8,A7
L536:
L516:
L515:
	BRA	L539(PC)
L499:
	CMPI	#7,D4
	BNE	L540(PC)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F200_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,-34(A6)
	BEQ.S	L541
	MOVE	-34(A6),D0
	MOVE	-12(A6),D1
	LSR	#4,D1
	LSR	#8,D1
	CMP	D1,D0
	BHI.S	L542
	MOVE	-30(A6),D0
	BEQ.S	L543
	MOVE	-32(A6),D0
	BNE.S	L542
L543:
	BRA	L37T209_044(PC)
L542:
L37T209_081:
	ADDQ	#1,-52(A6)
	MOVE	-52(A6),D0
	ASR	#1,D0
	MOVE	D0,-52(A6)
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	AND	#255,D0
	MOVE	D0,-30(A6)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
	AND	#255,D0
	MOVE	D0,-32(A6)
	BRA.S	L544
L541:
L37T209_082:
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-30(A6)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-32(A6)
	MOVE	D7,D0
	CMP	-30(A6),D0
	BNE.S	L545
	MOVE	D6,D0
	CMP	-32(A6),D0
	BNE.S	L545
	CLR	-36(A6)
	MOVE	#0,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	BRA	L37T209_073(PC)
L545:
L544:
	MOVE	#1,-42(A6)
L37T209_084:
	MOVE	-32(A6),-(A7)
	MOVE	-30(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F228_uzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-38(A6)
L37T209_085:
	MOVE	-42(A6),-(A7)
	MOVE	-38(A6),D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BNE	L547(PC)
	MOVE	-42(A6),D0
	BEQ.S	L548
	JSR	F028_a000_(PC)
	TST	D0
L548:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	G363_i_Sec(A4),D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BNE.S	L547
	CLR	-(A7)
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BNE.S	L547
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L546
	CLR	-(A7)
	MOVE	-38(A6),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F202_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BEQ.S	L546
L547:
	MOVE	D7,-30(A6)
	MOVE	D6,-32(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-30(A6),D0
	ADD	D1,D0
	MOVE	D0,-30(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-32(A6),D0
	ADD	D1,D0
	MOVE	D0,-32(A6)
	BRA	L37T209_061(PC)
L546:
	MOVE	-56(A6),D0
	BEQ	L549(PC)
L37T209_089:
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F203_xxxx_(PC)
	ADDA	#10,A7
	MOVE	-38(A6),D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F204_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L551
	MOVE	G363_i_Sec(A4),D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F204_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L551
	MOVE	G386_ui_Fl(A4),D0
	BEQ.S	L552
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F204_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L551
L552:
	CMPI	#2,G386_ui_Fl(A4)
	BCS.S	L550
	MOVE	-38(A6),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F204_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L550
L551:
	MOVE	D7,-30(A6)
	MOVE	D6,-32(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	#2,D1
	MOVE	-30(A6),D0
	ADD	D1,D0
	MOVE	D0,-30(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	#2,D1
	MOVE	-32(A6),D0
	ADD	D1,D0
	MOVE	D0,-32(A6)
	MOVE	#1,-(A7)
	MOVE	-32(A6),-(A7)
	MOVE	-30(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L37T209_061(PC)
L550:
L549:
	MOVE	-48(A6),-(A7)
	MOVE	-50(A6),-(A7)
	MOVE	-38(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F206_xxxx_(PC)
	ADDA	#10,A7
	BRA	L553(PC)
L540:
	CMPI	#5,D4
	BNE	L554(PC)
L37T209_094:
	MOVE	#1,-42(A6)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F200_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,-34(A6)
	BEQ.S	L555
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	AND	#255,D0
	MOVE	D0,-30(A6)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
	AND	#255,D0
	MOVE	D0,-32(A6)
	BRA	L556(PC)
L555:
	AND	#255,D0
	SUBQ.B	#1,5(A2)
	MOVE.B	5(A2),D0
	BNE.S	L557
L37T209_096:
	CLR	-36(A6)
	MOVE	#0,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	BRA	L37T209_073(PC)
L557:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L558
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-26(A6)
	JSR	F203_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L559
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	CMPI	#1,D0
	BGT.S	L560
	BRA.S	L37T209_096
L560:
L559:
	MOVE.B	10(A2),D0
	AND	#255,D0
	MOVE	D0,-30(A6)
	MOVE.B	11(A2),D0
	AND	#255,D0
	MOVE	D0,-32(A6)
	BRA	L37T209_084(PC)
L558:
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-30(A6)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-32(A6)
L556:
	MOVE	-32(A6),-(A7)
	MOVE	-30(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F228_uzzz_(PC)
	ADDQ.L	#8,A7
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-38(A6)
	MOVE	G363_i_Sec(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	-52(A6),D0
	ASR	#2,D0
	SUB	D0,-52(A6)
	BRA	L37T209_085(PC)
L554:
L553:
L539:
	BRA	L561(PC)
L498:
	CMPI	#5,D4
	BNE.S	L562
	MOVE	-50(A6),D0
	BEQ.S	L563
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F182_aqzz_(PC)
	ADDQ.L	#8,A7
L563:
	BRA	L37T209_094(PC)
L562:
	MOVE	12(A6),D0
	SUB	#38,D0
	MOVE	D0,D4
	LEA	12(A2),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#128,D0
	BEQ.S	L564
	CLR	-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F179_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	D0,-60(A6)
	JSR	F029_AA19_(PC)
	MOVE	D0,-90(A6)
	MOVE.B	-19(A6),D0
	AND	#255,D0
	MOVE	D0,D4
	ADD	-90(A6),D0
	SUBQ	#1,D0
	AND.L	#65535,D0
	ADD.L	D0,-70(A6)
	CMPI	#15,D4
	BLE.S	L565
	JSR	F027_AA59_(PC)
	AND	#7,D0
	SUBQ	#2,D0
	AND.L	#65535,D0
	ADD.L	D0,-70(A6)
L565:
	BRA	L566(PC)
L564:
	MOVE	D4,D0
	CMP	-50(A6),D0
	BLS.S	L567
	BRA	L450(PC)
L567:
	MOVE	G382_i_Cur(A4),-38(A6)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F200_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,-34(A6)
	BEQ.S	L568
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
L568:
	MOVE	-50(A6),D0
	BNE	L569(PC)
	CMPI	#2,-48(A6)
	BEQ	L569(PC)
	JSR	F027_AA59_(PC)
	MOVE	D0,D5
	AND	#192,D0
	BNE	L569(PC)
	MOVE.B	3(A2),D0
	AND	#255,D0
	CMP	#255,D0
	BEQ.S	L570
	MOVE	D5,D0
	AND	#56,D0
	BEQ.S	L571
	MOVE.B	#-1,3(A2)
	BRA.S	L572
L571:
	MOVE.B	3(A2),D0
	AND	#255,D0
	AND	#3,D0
	MOVE	D5,D1
	AND	#1,D1
	BEQ.S	L573
	MOVE	#1,D1
	BRA.S	L574
L573:
	MOVE	#-1,D1
L574:
	ADD	D1,D0
	AND	#3,D0
	MOVE	D0,D5
L572:
L570:
	MOVE	D5,D0
	AND	#56,D0
	BNE.S	L575
	CMPI	#1,-34(A6)
	BEQ.S	L575
	CMPI	#0,-48(A6)
	BNE.S	L575
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	JSR	F218_ezzz_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L576
	CMPI	#2,G364_i_Cre(A4)
	BNE.S	L576
	BRA	L450(PC)
L576:
	MOVE	D5,D0
	AND	#3,D0
	MOVE.B	D0,3(A2)
L575:
L569:
	MOVE	-34(A6),D0
	BEQ	L577(PC)
	MOVE	-24(A6),D0
	AND	#4,D0
	BNE.S	L578
	MOVE.B	2(A2),D0
	MOVE	D4,D1
	ASL	#1,D1
	AND	#255,D0
	ASR	D1,D0
	AND	#3,D0
	CMP	-38(A6),D0
	BNE	L577(PC)
L578:
	MOVE	-34(A6),D0
	MOVE	-12(A6),D1
	LSR	#4,D1
	LSR	#8,D1
	MOVE	D1,D5
	CMP	D1,D0
	BGT	L579(PC)
	MOVE	-30(A6),D0
	BEQ.S	L580
	MOVE	-32(A6),D0
	BNE	L579(PC)
L580:
	JSR	F027_AA59_(PC)
	AND	#15,D0
	ADDQ	#1,D0
	MOVE	D0,-100(A6)
	MOVE	D5,D0
	CMP	-100(A6),D0
	BHI	L579(PC)
	CMPI	#1,D5
	BNE	L581(PC)
	MOVE	-24(A6),D0
	MOVE	D0,D5
	AND	#8,D0
	BEQ.S	L582
	JSR	F029_AA19_(PC)
	TST	D0
	BEQ.S	L582
	MOVE	D5,D0
	AND	#16,D0
	BNE	L581(PC)
L582:
	CMPI	#0,-48(A6)
	BNE	L581(PC)
	MOVE.B	3(A2),D0
	AND	#255,D0
	CMP	#255,D0
	BEQ	L581(PC)
	MOVE.B	3(A2),D0
	MOVE	D4,D1
	ASL	#1,D1
	AND	#255,D0
	ASR	D1,D0
	AND	#3,D0
	MOVE	D0,D5
	CMP	-38(A6),D0
	BEQ	L581(PC)
	MOVE	D5,D0
	MOVE	-38(A6),D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BEQ	L581(PC)
	MOVE	-50(A6),D0
	BNE.S	L583
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L583
	MOVE.B	#-1,3(A2)
	BRA	L584(PC)
L583:
	MOVE	-38(A6),D0
	AND	#1,D0
	MOVE	D5,D1
	AND	#1,D1
	CMP	D1,D0
	BNE.S	L585
	SUBQ	#1,D5
	BRA.S	L586
L585:
	ADDQ	#1,D5
L586:
	MOVE	D5,D0
	AND	#3,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L588
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L587
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,D5
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L587
L588:
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	JSR	F218_ezzz_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L589
	CMPI	#2,G364_i_Cre(A4)
	BNE.S	L589
	BRA	L450(PC)
L589:
	CMPI	#1,G364_i_Cre(A4)
	BEQ.S	L590
	MOVE	D5,-(A7)
	MOVE	D4,-(A7)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,3(A2)
L590:
L587:
L584:
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	MOVE.B	-20(A6),D0
	AND	#255,D0
	ASR	#1,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	EXT.L	D0
	ADD.L	D0,-70(A6)
	MOVE	12(A6),D0
	MOVE.B	D0,-66(A6)
	BRA	L37T209_135(PC)
L581:
	MOVE	D4,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F207_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F179_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	D0,-60(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,-110(A6)
	MOVE	-6(A6),D0
	AND	#15,D0
	ADD	-110(A6),D0
	AND.L	#65535,D0
	ADD.L	D0,-70(A6)
	BRA.S	L591
L579:
	MOVE	#7,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	MOVE	-50(A6),D0
	BEQ.S	L592
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F182_aqzz_(PC)
	ADDQ.L	#8,A7
L592:
	BRA	L37T209_081(PC)
L591:
	BRA	L593(PC)
L577:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F200_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L594
	MOVE	G306_i_Par(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G307_i_Par(A4),D0
	MOVE.B	D0,7(A2)
	MOVE	-50(A6),D0
	BEQ.S	L595
	CMPI	#1,-48(A6)
	SEQ	D0
	TST.B	D0
L595:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE	-38(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F205_xxxx_(PC)
	ADDA	#10,A7
	ADDQ.L	#2,-70(A6)
	MOVE.L	-70(A6),D0
	AND.L	#16777215,D0
	MOVE.L	D0,-60(A6)
	BRA.S	L596
L594:
	MOVE	#7,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	MOVE	-50(A6),D0
	BEQ.S	L597
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F182_aqzz_(PC)
	ADDQ.L	#8,A7
L597:
	BRA	L37T209_082(PC)
L596:
L593:
L566:
	MOVE	12(A6),D0
	MOVE.B	D0,-66(A6)
	BRA.S	L37T209_136
L561:
	JSR	F029_AA19_(PC)
	ADD	-52(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	EXT.L	D0
	ADD.L	D0,-70(A6)
L37T209_134:
	MOVE.B	#37,-66(A6)
L496:
L37T209_135:
	MOVE.L	-60(A6),D0
	BNE.S	L598
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F179_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	D0,-60(A6)
L598:
L37T209_136:
	MOVE	-40(A6),D0
	BEQ.S	L599
	MOVE	14(A6),D0
	AND.L	#65535,D0
	ADD.L	D0,-70(A6)
	BRA.S	L600
L599:
	MOVE	14(A6),D0
	AND.L	#65535,D0
	ADD.L	D0,-60(A6)
L600:
	MOVE.L	-60(A6),-(A7)
	PEA	-70(A6)
	JSR	F208_xxxx_(PC)
	ADDQ.L	#8,A7
L450:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$449:	.EQU	#-110
