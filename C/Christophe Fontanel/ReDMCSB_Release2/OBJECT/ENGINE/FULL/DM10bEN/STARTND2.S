BSS SEG "bss"
G562_apuc_:/* global */
	.WORD	#40
G563_puc_G:/* global */
	.WORD	#4
G564_puc_G:/* global */
	.WORD	#4
G565_puc_G:/* global */
	.WORD	#4
G566_puc_G:/* global */
	.WORD	#4
CODE SEG "start"
F432_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D5
	MOVE.L	#0,A3
L2:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	MOVE.L	G550_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	JSR	F077_aA39_(PC)
	CMPI	#2,D7
	BNE.S	L5
	MOVE	#0,D0
	BRA	L1(PC)
L5:
	JSR	F452_xxxx_(PC)
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L6
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L7
L6:
	CMPI	#2,D6
	BNE.S	L8
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L9
L8:
	MOVE	#1,D5
L9:
L7:
L3:
	MOVE	D5,D0
	BEQ.S	L2
L4:
	MOVE.L	G648_l_Ava(A4),-4(A6)
	CLR	-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	CLR	D4
	BRA.S	L10
L11:
	CMPI	#1,D4
	BGT.S	L14
	MOVE	#0,D0
	BRA.S	L15
L14:
	MOVE	#-6683,D0
L15:
	MOVE	D0,-(A7)
	MOVE.L	#-2023406815,-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	MOVE	#9,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#10,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#26,A7
L12:
	ADDQ	#1,D4
L10:
	CMPI	#80,D4
	BLT.S	L11
L13:
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE.L	#16777217,-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#18,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#9,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	MOVE.L	-4(A6),-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
L1:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-4
F433_AA39_:/* global */
	LINK	A6,L$16
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D7
	JSR	F456_vzzz_(PC)
	CLR	D4
L19:
L18:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L19
L20:
L21:
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D4
	CLR	-(A7)
	MOVE.L	#576,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-232(A6)
	MOVE.L	-232(A6),D0
	ADD.L	#512,D0
	MOVE.L	D0,-236(A6)
	MOVE.L	A2,-(A7)
	JSR	L1T433_003_(PC)
	JSR	L1T433_004_(PC)
	JSR	L1T433_003_(PC)
	JSR	L1T433_004_(PC)
	BRA.S	L1T433_021
L1T433_003_:
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE.L	#458752,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	-232(A6),-(A7)
	MOVE	#8,-(A7)
	TRAP	#14
	LEA	20(A7),A7
	RTS
L1T433_004_:
	MOVE.L	-232(A6),A0
	LEA	20(A0),A0
	MOVE.L	-236(A6),A1
	MOVE	#489,D0
	MOVEQ	#16,D5
	MOVEQ	#0,D7
L1T433_005:
	MOVEQ	#0,D1
	MOVEQ	#0,D2
L1T433_006_:
	MOVE.B	(A0)+,D3
	BPL.S	L1T433_007
	BSET	D1,D2
	ANDI.B	#127,D3
L1T433_007:
	CMPI.B	#104,D3
	BEQ.S	L1T433_008
	MOVEQ	#0,D7
	RTS
L1T433_008:
	ADDQ	#1,D1
	SUBQ	#1,D0
	BEQ.S	L1T433_009
	CMP	D5,D1
	BNE.S	L1T433_006_
L1T433_009:
	CMP	(A1),D2
	BEQ.S	L1T433_010
	ADDQ	#1,D7
L1T433_010:
	MOVE	D2,(A1)+
	TST	D0
	BNE.S	L1T433_005
	RTS
L1T433_021:
	MOVE.L	(A7)+,A2
	MOVE.L	#576,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L22:
	MOVE	D7,D0
	BEQ	L21(PC)
L23:
	CLR	D7
	JSR	F077_aA39_(PC)
	MOVE.L	#0,A3
	CLR	-(A7)
	MOVE.L	#512,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
L24:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	MOVE.L	G558_pc_D1(A4),-(A7)
	MOVE.L	G557_pc_D1(A4),-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#4,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	JSR	F077_aA39_(PC)
	CMPI	#3,D4
	BNE.S	L27
	JSR	F432_xxxx_(PC)
	TST	D0
	BNE.S	L28
	BRA	L1T433_060(PC)
L28:
	BRA.S	L25
L27:
	CMPI	#4,D4
	BNE.S	L29
	BRA	L1T433_060(PC)
L29:
	CMPI	#1,D4
	SEQ	D6
	AND	#1,D6
	JSR	F452_xxxx_(PC)
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L30
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L25
L30:
	CMPI	#2,D5
	BNE.S	L31
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L25
L31:
	CMPI	#3,D5
	BNE.S	L32
	MOVE.L	G545_pc_D0(A4),A3
	BRA.S	L25
L32:
	MOVE	#1,D7
L25:
	MOVE	D7,D0
	BEQ	L24(PC)
L26:
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE	#65,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE	#60,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L33
	BRA	L1T433_059(PC)
L33:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L34
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D1,-4(A6)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
L34:
	MOVE.L	G313_ul_Ga(A4),-132(A6)
	MOVE.L	G349_ul_La(A4),-128(A6)
	MOVE	G305_ui_Pa(A4),-122(A6)
	MOVE	G306_i_Par(A4),-120(A6)
	MOVE	G307_i_Par(A4),-118(A6)
	MOVE	G308_i_Par(A4),-116(A6)
	MOVE	G309_i_Par(A4),-114(A6)
	MOVE	G411_i_Lea(A4),-112(A6)
	MOVE	G514_i_Mag(A4),-110(A6)
	MOVE	G372_ui_Ev(A4),-108(A6)
	MOVE	G373_ui_Fi(A4),-106(A6)
	MOVE	G369_ui_Ev(A4),-104(A6)
	MOVE	G377_ui_Cu(A4),-102(A6)
	MOVE.L	G361_l_Las(A4),-100(A6)
	MOVE.L	G362_l_Las(A4),-96(A6)
	MOVE	G310_i_Dis(A4),-92(A6)
	MOVE	G311_i_Pro(A4),-90(A6)
	MOVE	G312_i_Las(A4),-88(A6)
	MOVE	G414_T_Lea(A4),-124(A6)
	MOVE	G376_ui_Ma(A4),-86(A6)
	MOVE	#80,-(A7)
	PEA	-84(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#96,-(A7)
	PEA	-228(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	LEA	-132(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-228(A6)
	MOVE	#128,-224(A6)
	MOVE.L	G375_ps_Ac(A4),D0
	MOVE.L	D0,-222(A6)
	MOVE	G376_ui_Ma(A4),D0
	MULU	#16,D0
	MOVE	D0,-218(A6)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-216(A6)
	MOVE	#3328,-212(A6)
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,-210(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	MOVE	D0,-206(A6)
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,-204(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	MOVE	D0,-200(A6)
	MOVE	D6,304(A2)
	MOVE.L	G525_l_Gam(A4),306(A2)
	MOVE.B	#1,299(A2)
	MOVE.B	#1,298(A2)
	CLR	D4
	BRA.S	L35
L36:
	JSR	F027_AA59_(PC)
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	LEA	310(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L35:
	CMPI	#16,D4
	BLT.S	L36
L37:
	CLR	D4
	BRA.S	L38
L39:
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-224(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	310(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-228(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F418_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,D1
	ASL.L	#1,D1
	LEA	342(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L40:
	ADDQ	#1,D4
L38:
	CMPI	#5,D4
	BLT.S	L39
L41:
	MOVE.L	A2,-(A7)
	JSR	F430_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L42
	BRA	L1T433_059(PC)
L42:
	CLR	D4
	BRA.S	L43
L44:
	PEA	-2(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	310(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-224(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-228(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F420_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BNE.S	L47
	BRA	L1T433_059(PC)
L47:
L45:
	ADDQ	#1,D4
L43:
	CMPI	#5,D4
	BLT.S	L44
L46:
	MOVE	#44,-(A7)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L48
	BRA	L1T433_059(PC)
L48:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L49
	BRA	L1T433_059(PC)
L49:
	MOVE	G282_ui_Du(A4),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L50
	BRA	L1T433_059(PC)
L50:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L51
	BRA	L1T433_059(PC)
L51:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L52
	BRA	L1T433_059(PC)
L52:
	CLR	D4
	BRA.S	L53
L54:
	MOVE	D4,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	LEA	G235_auc_G(A4),A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L57
	BRA.S	L1T433_059
L57:
L55:
	ADDQ	#1,D4
L53:
	CMPI	#16,D4
	BLT.S	L54
L56:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L58
	BRA.S	L1T433_059
L58:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L59
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L59:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L60
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	-4(A6),D0
	MOVE	D0,(A0)
L60:
	MOVE	#1,G524_B_Res(A4)
	BRA.S	L1T433_060
L1T433_059:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	CLR.L	-(A7)
	MOVE.L	G540_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F077_aA39_(PC)
L1T433_060:
	MOVE.L	#512,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F457_AA08_(PC)
	JSR	F078_xzzz_(PC)
L17:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$16:	.EQU	#-236
F434_xxxx_:/* global */
	LINK	A6,L$61
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G523_B_Res(A4),D0
	BNE.S	L63
	MOVE	#1,-(A7)
	MOVE.L	#44,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G278_ps_Du(A4)
L63:
	MOVE	#44,-(A7)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L64
	MOVE	#0,D0
	BRA	L62(PC)
L64:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L65
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	8(A0),D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G306_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G307_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	AND	#3,D0
	MOVE	D0,G308_i_Par(A4)
	CLR	G309_i_Par(A4)
L65:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D7
	AND	#255,D7
	MOVE	G523_B_Res(A4),D0
	BNE.S	L66
	MOVE	#1,-(A7)
	MOVE	#16,D0
	MULS	D7,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G277_ps_Du(A4)
L66:
	MOVE	D7,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L67
	MOVE	#0,D0
	BRA	L62(PC)
L67:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L68
	MOVE	#1,-(A7)
	MOVE	D7,D0
	ASL	#1,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G281_pi_Du(A4)
L68:
	MOVE	#0,D4
	MOVE	D4,D5
	BRA.S	L69
L70:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
	MOVE	D5,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	ADDQ	#1,D0
	ADD	D0,D4
	ADDQ	#1,D5
L69:
	MOVE	D5,D0
	CMP	D7,D0
	BLT.S	L70
L71:
	MOVE	D4,G282_ui_Du(A4)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L72
	MOVE.L	G278_ps_Du(A4),A0
	ADDI	#300,10(A0)
L72:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L73
	MOVE	#1,-(A7)
	MOVE	D4,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G280_pui_D(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G283_pT_Sq(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	AND.L	#65535,D0
	ASL.L	#1,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G260_pui_D(A4)
L73:
	MOVE	D4,D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L74
	MOVE	#0,D0
	BRA	L62(PC)
L74:
	MOVE	D5,D0
	MULS	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L75
	MOVE	#0,D0
	BRA	L62(PC)
L75:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L76
	CLR	D4
	BRA.S	L77
L78:
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L79:
	ADDQ	#1,D4
L77:
	CMPI	#300,D4
	BCS.S	L78
L80:
L76:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L81
	MOVE	#0,D0
	BRA	L62(PC)
L81:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L82
	MOVE	#100,G369_ui_Ev(A4)
L82:
	CLR	D6
	BRA	L83(PC)
L84:
	MOVE	D6,D5
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D5
	LEA	12(A0),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L87
	MOVE	D5,D0
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	CMPI	#15,D6
	BNE.S	L88
	MOVE	#768,D0
	BRA.S	L89
L88:
	MOVE	#1024,D0
L89:
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L87:
	LEA	G235_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE	G523_B_Res(A4),D0
	BNE.S	L90
	MOVE	#1,-(A7)
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULU	D4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,D1
	ASL.L	#2,D1
	LEA	G284_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L90:
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE	D4,D0
	MULU	D5,D0
	MOVE	D0,-(A7)
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L91
	MOVE	#0,D0
	BRA	L62(PC)
L91:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L92
	CMPI	#4,D6
	BEQ.S	L94
	CMPI	#14,D6
	BLT.S	L93
L94:
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D0,G369_ui_Ev(A4)
L93:
	MOVE	D4,D1
	LSR	#1,D1
	MOVE	D1,D4
	MOVE	D1,-14(A6)
	MOVE	D5,D1
	MULU	-14(A6),D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	BRA.S	L95
L96:
	MOVE	#-1,(A3)
L97:
	MOVE	D5,D0
	SUBQ	#1,D5
	MOVE	D4,D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
L95:
	MOVE	D5,D0
	BNE.S	L96
L98:
L92:
L85:
	ADDQ	#1,D6
L83:
	CMPI	#16,D6
	BLT	L84(PC)
L86:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L99
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G276_puc_D(A4)
L99:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L100
	MOVE	#0,D0
	BRA	L62(PC)
L100:
	MOVE	G523_B_Res(A4),D0
	BNE	L101(PC)
	PEA	F433_AA39_(PC)
	JSR	F079_a002_(PC)
	ADDQ.L	#4,A7
	CMPI	#6293,D0
	BNE	L101(PC)
	MOVE	#1,-(A7)
	MOVE	G282_ui_Du(A4),D0
	ADD	D7,D0
	MULU	#4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G279_pppuc(A4)
	MOVE.L	G279_pppuc(A4),D0
	MOVE	D7,D1
	EXT.L	D1
	ASL.L	#2,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
	CLR	D5
	BRA	L102(PC)
L103:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
	MOVE.L	G276_puc_D(A4),D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
	MOVE	#1,D6
	BRA.S	L106
L107:
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	ADDQ	#1,D1
	MOVE.L	-4(A6),D0
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
L108:
	ADDQ	#1,D6
L106:
	MOVE	D6,D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#1984,D1
	LSR	#6,D1
	CMP	D1,D0
	BLS.S	L107
L109:
L104:
	ADDQ	#1,D5
L102:
	MOVE	D5,D0
	CMP	D7,D0
	BLT	L103(PC)
L105:
L101:
	MOVE	#1,D0
L62:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$61:	.EQU	#-14
F435_xxxx_:/* global */
	LINK	A6,L$110
	MOVEM.L	A3/D7-D4,-(A7)
	CLR	D4
	MOVE.L	#0,A3
	MOVE	G298_B_New(A4),D0
	BEQ.S	L112
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	TST	D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D4
DATA SEG "s!"
s!:
	DATA 5C 44 55 4E 47 45 4F 4E 2E 44 41 54 00 00 
CODE SEG "start"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,G521_i_Gam(A4)
	BGE.S	L113
	MOVE	#50,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L115:
L116:
	BRA.S	L115
L117:
L113:
L3T435_002:
	CLR	G524_B_Res(A4)
	CLR	G305_ui_Pa(A4)
	MOVE	#-1,G414_T_Lea(A4)
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE	D1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,G525_l_Gam(A4)
	BRA	L118(PC)
L112:
	MOVE.L	#0,A3
L3T435_004:
L119:
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G556_pc_D1(A4),-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	JSR	F077_aA39_(PC)
	CMPI	#2,D7
	BNE.S	L122
L3T435_008:
	MOVE	#-1,D0
	BRA	L111(PC)
L122:
L3T435_009:
	JSR	F452_xxxx_(PC)
	MOVE	D0,D5
	CMPI	#1,D0
	BNE.S	L123
	CLR	D6
	CLR	-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L124
	CLR	-(A7)
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L125
	MOVE	#1,D6
	BRA.S	L126
L125:
DATA SEG "s!"
	DATA 41 3A 5C 44 55 4E 47 45 4F 4E 2E 46 54 4C 00 00 
CODE SEG "start"
	MOVE	G523_B_Res(A4),D0
	BNE.S	L127
	CLR	-(A7)
	PEA	s!+14(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L127
	MOVE	#1,D4
	MOVE	#1,G298_B_New(A4)
	BRA	L3T435_002(PC)
L127:
	MOVE.L	G539_pc_D0(A4),A3
	MOVE	#3,D5
L126:
L124:
	BRA.S	L128
L123:
	CMPI	#0,D5
	BNE.S	L129
	MOVE.L	G542_pc_D0(A4),A3
	BRA.S	L130
L129:
	CMPI	#3,D5
	BNE.S	L131
	MOVE.L	G545_pc_D0(A4),A3
	BRA.S	L132
L131:
	CMPI	#2,D5
	BNE.S	L133
	MOVE.L	G544_pc_D0(A4),A3
L133:
L132:
L130:
L128:
L120:
	CMPI	#1,D5
	BNE	L119(PC)
L121:
	PEA	-642(A6)
	JSR	F429_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L134
	BRA	L3T435_037(PC)
L134:
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L135
	MOVE.L	-336(A6),D0
	CMP.L	G525_l_Gam(A4),D0
	BEQ.S	L135
	MOVE.L	G546_pc_D0(A4),A3
	BRA	L3T435_004(PC)
L135:
	MOVE.L	-336(A6),G525_l_Gam(A4)
	MOVE	-300(A6),-(A7)
	MOVE	-332(A6),-(A7)
	MOVE	#128,-(A7)
	PEA	-130(A6)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L136
	BRA	L3T435_037(PC)
L136:
	MOVE.L	-130(A6),D0
	MOVE.L	D0,G313_ul_Ga(A4)
	MOVE.L	D0,G319_ul_Lo(A4)
	MOVE.L	-126(A6),G349_ul_La(A4)
	MOVE	-120(A6),G305_ui_Pa(A4)
	MOVE	-118(A6),G306_i_Par(A4)
	MOVE	-116(A6),G307_i_Par(A4)
	MOVE	-114(A6),G308_i_Par(A4)
	MOVE	-112(A6),G309_i_Par(A4)
	MOVE	-110(A6),G411_i_Lea(A4)
	MOVE	-108(A6),G514_i_Mag(A4)
	MOVE	-106(A6),G372_ui_Ev(A4)
	MOVE	-104(A6),G373_ui_Fi(A4)
	MOVE	-102(A6),G369_ui_Ev(A4)
	MOVE	-100(A6),G377_ui_Cu(A4)
	MOVE.L	-98(A6),G361_l_Las(A4)
	MOVE.L	-94(A6),G362_l_Las(A4)
	MOVE	-90(A6),G310_i_Dis(A4)
	MOVE	-88(A6),G311_i_Pro(A4)
	MOVE	-86(A6),G312_i_Las(A4)
	MOVE	-122(A6),G414_T_Lea(A4)
	MOVE	-84(A6),G376_ui_Ma(A4)
	MOVE	G523_B_Res(A4),D0
	BNE.S	L137
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
L137:
	MOVE	-298(A6),-(A7)
	MOVE	-330(A6),-(A7)
	MOVE	#16,D0
	MULU	G376_ui_Ma(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G375_ps_Ac(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L138
	BRA	L3T435_037(PC)
L138:
	MOVE	-296(A6),-(A7)
	MOVE	-328(A6),-(A7)
	MOVE	#3328,-(A7)
	PEA	G407_s_Par(A4)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L139
	BRA	L3T435_037(PC)
L139:
	MOVE	-294(A6),-(A7)
	MOVE	-326(A6),-(A7)
	MOVE	#10,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G370_ps_Ev(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L140
	BRA	L3T435_037(PC)
L140:
	MOVE	-292(A6),-(A7)
	MOVE	-324(A6),-(A7)
	MOVE	#2,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G371_pi_Ti(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L141
	BRA	L3T435_037(PC)
L141:
L118:
	JSR	F434_xxxx_(PC)
	TST	D0
	BNE.S	L142
	BRA	L3T435_037(PC)
L142:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	G298_B_New(A4),D0
	BEQ.S	L143
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
	MOVE	D4,D0
	BEQ.S	L144
	MOVE	#32,-(A7)
	PEA	-674(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	-674(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L144:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	BRA.S	L145
L143:
	MOVE	#1,G524_B_Res(A4)
	MOVE	D6,D0
	BEQ.S	L146
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE.L	G520_pc_D0(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
L146:
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
L145:
	CLR	G303_B_Par(A4)
	MOVE	#1,D0
	BRA.S	L111
L3T435_037:
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#52,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L147
	MOVE	#600,D7
	BRA.S	L148
L149:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L148:
	SUBQ	#1,D7
	BNE.S	L149
L150:
	MOVE	#-1,D0
	BRA.S	L111
L147:
L152:
L153:
	BRA.S	L152
L154:
L111:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$110:	.EQU	#-674
F436_xxxx_:/* global */
	LINK	A6,L$155
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	#-32192,A3
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-4(A6)
	CLR	D4
	BRA	L157(PC)
L158:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	BRA	L161(PC)
L162:
	MOVE	D5,D7
	ASL.L	#1,D7
	MOVE.L	A3,A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D5,D6
	ASL.L	#1,D6
	MOVE.L	8(A6),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BLS.S	L165
	SUBQ	#1,D7
L165:
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BCC.S	L166
	ADDQ	#1,D7
L166:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BLS.S	L167
	SUB	#16,D7
L167:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BCC.S	L168
	ADD	#16,D7
L168:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BLS.S	L169
	SUB	#256,D7
L169:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BCC.S	L170
	ADD	#256,D7
L170:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D7,(A0)
L163:
	ADDQ	#1,D5
L161:
	CMPI	#16,D5
	BLT	L162(PC)
L164:
L159:
	ADDQ	#1,D4
L157:
	CMPI	#8,D4
	BLT	L158(PC)
L160:
	MOVE.L	-4(A6),-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L156:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$155:	.EQU	#-4
F437_xxxx_:/* global */
	LINK	A6,L$171
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	G578_B_Use(A4)
	CMPI.L	#138060,G648_l_Ava(A4)
	BGE.S	L173
	BRA	L172(PC)
L173:
	CLR	-(A7)
	MOVE.L	#133056,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D4
	ADD.L	#256,D4
	AND.L	#-256,D4
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	D4,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	ADD.L	#32000,D4
	MOVE.L	G348_pl_Bi(A4),D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,A2
	MOVE.L	A3,D0
	MOVE.L	D0,-8(A6)
	MOVE.L	D0,-92(A6)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-340(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#137,-(A7)
	CLR	-(A7)
	PEA	G005_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#1911,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#80,-(A7)
	CLR	-(A7)
	PEA	G004_s_Gra(A4)
	MOVE.L	D4,D0
	MOVE.L	D0,-96(A6)
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADD.L	#9120,D4
	MOVE	#12,D6
	MOVE	#48,D5
	CLR	D7
	BRA	L174(PC)
L175:
	MOVE.L	D4,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-88(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	PEA	G017_auc_G(A4)
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	#80,-(A7)
	MOVE	#320,-(A7)
	MOVE.L	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	#320,D0
	SUB	D5,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-308(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D5,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-306(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#160,D0
	SUB	D6,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-304(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D6,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-302(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D0
	ADD	#15,D0
	EXT.L	D0
	DIVS	#16,D0
	MULS	#8,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-300(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MULU	D6,D0
	AND.L	#65535,D0
	ADD.L	D0,D4
	ADDQ	#4,D6
	ADD	#16,D5
L176:
	ADDQ	#1,D7
L174:
	CMPI	#18,D7
	BLT	L175(PC)
L177:
	MOVE	#2,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	-92(A6),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	-92(A6),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#1345,-334(A6)
	MOVE	#1057,-332(A6)
	MOVE	#1617,-330(A6)
	MOVE	#1329,-328(A6)
	MOVE	#1906,-324(A6)
	MOVE	#1792,-310(A6)
	MOVE	#2,-320(A6)
	MOVE	#2,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	D7
	BRA	L178(PC)
L179:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-300(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-308(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	-88(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
L180:
	ADDQ	#1,D7
L178:
	CMPI	#18,D7
	BLT	L179(PC)
L181:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G003_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-96(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	CLR	-320(A6)
	MOVE	#1792,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE.L	#133056,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L172:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$171:	.EQU	#-340
F438_xxxx_:/* global */
	LINK	A6,L$182
	MOVEM.L	A3/D7,-(A7)
	LEA	G562_apuc_(A4),A0
	MOVE.L	A0,A3
	MOVE.L	G348_pl_Bi(A4),D0
	ADD.L	#4800,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	36(A3),D0
	MOVE.L	D0,-8(A6)
	MOVE	#1,D7
L184:
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	CMPI	#1,D0
	BNE.S	L187
	MOVE	#1,-(A7)
	MOVE	#145,-(A7)
	MOVE.L	G565_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
L187:
	MOVE	#20608,-(A7)
	MOVE.L	36(A3),-(A7)
	MOVE.L	32(A3),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#112,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G006_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	G007_s_Gra+2(A4),D0
	CMPI	#0,D0
	BLT.S	L188
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#252,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G007_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,G007_s_Gra+2(A4)
L188:
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G008_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	#4,D0
	MOVE	D7,D1
	AND	#3,D1
	ADD	D1,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADDQ	#4,G008_s_Gra(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVEM.L	A6-A2/D7-D4,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.L	-8(A6),A1
	MOVE	#160,D0
L6T438_004:
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,(A0)
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,48(A0)
	MOVEM.L	(A1)+,D1-D4
	MOVEM.L	D1-D4,96(A0)
	MOVE.B	(A1),112(A0)
	MOVE.B	2(A1),114(A0)
	MOVE.B	4(A1),116(A0)
	MOVE.B	6(A1),118(A0)
	LEA	160(A0),A0
	LEA	16(A1),A1
	DBF	D0,L6T438_004
	MOVEM.L	(A7)+,D4-D7/A2-A6
L185:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMPI	#32,D0
	BNE	L184(PC)
L186:
L183:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$182:	.EQU	#-8
F439_xxxx_:/* global */
	LINK	A6,L$189
	MOVE	D7,-(A7)
	MOVE	#255,G309_i_Par(A4)
	MOVE	#1,G297_B_Dra(A4)
	MOVE	#5,G273_i_Cur(A4)
	MOVE	#5,G274_i_Cur(A4)
	LEA	-128(A6),A0
	MOVE.L	A0,G271_ppuc_(A4)
	LEA	-170(A6),A0
	MOVE.L	A0,G269_ps_Cu(A4)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	#25,-(A7)
	PEA	-154(A6)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
	CLR	D7
	BRA.S	L191
L192:
	MOVE	D7,D0
	MULU	#5,D0
	LEA	-154(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-128(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	MOVE	D7,D0
	LEA	-144(A6),A0
	ADDA	D0,A0
	MOVE.B	#32,(A0)
L193:
	ADDQ	#1,D7
L191:
	CMPI	#5,D7
	BCS.S	L192
L194:
	MOVE.B	#32,-147(A6)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G563_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	CLR	G324_B_Dra(A4)
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#160,-(A7)
	MOVE	#30,-(A7)
	CLR	-(A7)
	PEA	G009_s_Gra(A4)
	MOVE.L	G562_apuc_+32(A4),-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G010_s_Gra(A4)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G011_s_Gra(A4)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	PEA	G020_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L190:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$189:	.EQU	#-170
F440_xxxx_:/* global */
	LINK	A6,L$195
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	JSR	F494_ozzz_(PC)
	ADDQ.L	#2,A7
	AND.L	#65535,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	10(A6),A0
	MOVE.L	D0,(A0)
	MOVE.L	D0,-(A7)
	MOVE	8(A6),D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE.L	-4(A6),D0
L196:
	UNLK	A6
	RTS
L$195:	.EQU	#-4
F441_xxxx_:/* global */
	LINK	A6,L$197
	MOVEM.L	D7-D5,-(A7)
	LEA	G445_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	CLR	D7
	BRA.S	L199
L200:
	CLR	-(A7)
	MOVE.L	#10304,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G562_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L201:
	ADDQ	#1,D7
L199:
	CMPI	#8,D7
	BCS.S	L200
L202:
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+32(A4)
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+36(A4)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	MOVE	#3,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	MOVE	#2,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	PEA	G563_puc_G(A4)
	MOVE	#4,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D6
	PEA	G564_puc_G(A4)
	MOVE	#5,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G565_puc_G(A4)
	MOVE	#535,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G566_puc_G(A4)
	MOVE	#534,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	JSR	F478_gzzz_(PC)
	CLR	G578_B_Use(A4)
	CLR	-8(A6)
	MOVE	#100,-6(A6)
	CLR	-4(A6)
	MOVE	#160,-2(A6)
	MOVE	#1,D7
	BRA.S	L203
L204:
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,-6(A6)
L205:
	ADDQ	#1,D7
L203:
	CMPI	#4,D7
	BCS.S	L204
L206:
	MOVE	#127,-6(A6)
	MOVE	#5,D7
	BRA.S	L207
L208:
	ADDQ	#4,-8(A6)
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L209:
	ADDQ	#1,D7
L207:
	CMPI	#8,D7
	BCS.S	L208
L210:
L211:
	JSR	F439_xxxx_(PC)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	MOVE	#99,G298_B_New(A4)
L214:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	JSR	F380_xzzz_(PC)
L215:
	CMPI	#99,G298_B_New(A4)
	BEQ.S	L214
L216:
L212:
	CMPI	#202,G298_B_New(A4)
	BEQ.S	L211
L213:
	MOVE	#1,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G566_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	#20,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L217
	JSR	F438_xxxx_(PC)
L217:
	MOVE.L	D6,D0
	ADD.L	#82432,D0
	ADD.L	#41216,D0
	MOVE.L	D0,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L198:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$197:	.EQU	#-8
F442_AA08_:/* global */
	LINK	A6,L$218
	MOVE	#1800,-2(A6)
	JSR	F077_aA39_(PC)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G564_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L220:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L221:
	SUBQ	#1,-2(A6)
	MOVE	-2(A6),D0
	BEQ.S	L223
	MOVE	G588_i_Mou(A4),D0
	BNE.S	L223
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L220
L223:
L222:
	MOVE	#202,G298_B_New(A4)
L219:
	UNLK	A6
	RTS
L$218:	.EQU	#-2
F443_xxxx_:/* global */
	LINK	A6,L$224
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	14(A6),A3
	LEA	-50(A6),A0
	MOVE.L	A0,A2
	BRA.S	L226
L227:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#65,D0
	BLT.S	L230
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#90,D0
	BGT.S	L230
	SUBI.B	#64,(A2)
L230:
L228:
	ADDQ.L	#1,A2
L226:
	MOVE.B	(A3)+,(A2)
	BNE.S	L227
L229:
	PEA	-50(A6)
	MOVE	#12,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L225:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$224:	.EQU	#-50
F444_AA29_:/* global */
	LINK	A6,L$231
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	CLR.L	G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	MOVE	8(A6),D0
	BEQ.S	L233
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L233
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#6,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	#240,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
L233:
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE.L	G088_apuc_+40(A4),A3
	MOVE	8(A6),D0
	BEQ.S	L234
	MOVE.L	A3,A2
	ADDA.L	#560,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#6,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L235
	MOVE.L	A3,-14(A6)
	ADDA.L	#1376,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	-14(A6),-(A7)
	MOVE	#208,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L235:
L234:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-10(A6)
	MOVE.L	D0,-(A7)
	MOVE	#-32763,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	JSR	F478_gzzz_(PC)
	MOVE	G322_B_Pal(A4),D0
	BEQ	L236(PC)
	MOVE	#32,-(A7)
	PEA	-78(A6)
	PEA	G347_aui_P(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	D6
	BRA.S	L237
L238:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D7
	BRA.S	L241
L242:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G346_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G346_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G347_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G347_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L243:
	ADDQ	#1,D7
L241:
	CMPI	#16,D7
	BLT.S	L242
L244:
L239:
	ADDQ	#1,D6
L237:
	CMPI	#7,D6
	BLE.S	L238
L240:
	CLR	G322_B_Pal(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32,-(A7)
	PEA	G347_aui_P(A4)
	PEA	-78(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	BRA.S	L245
L236:
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L245:
	MOVE	8(A6),D0
	BEQ	L246(PC)
	MOVE	G302_B_Gam(A4),D0
	BEQ	L247(PC)
	MOVE	#4000,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	CLR	D7
	BRA	L248(PC)
L249:
	MOVE	D7,D6
	MULS	#48,D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-6(A6)
	MOVE	#10,-(A7)
	MOVE	#32,-(A7)
	PEA	G015_s_Gra(A4)
	MOVE.L	-14(A6),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#1,-(A7)
	MOVE	#16,-(A7)
	PEA	G016_s_Gra(A4)
	MOVE.L	-6(A6),A0
	LEA	336(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#87,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-140(A6)
	MOVE	#6,D0
	MULS	-140(A6),D0
	ADD	#87,D0
	MOVE	D0,D5
	MOVE.L	-6(A6),A0
	MOVE.B	8(A0),-1(A6)
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#44,D0
	BEQ.S	L252
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#59,D0
	BEQ.S	L252
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#45,D0
	BEQ.S	L252
	ADDQ	#6,D5
L252:
	MOVE.L	-6(A6),A0
	LEA	8(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	CLR	D5
	BRA	L253(PC)
L254:
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#16,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#1,D4
	BNE.S	L257
	BRA.S	L255
L257:
	MOVE	D4,D0
	ASL.L	#2,D0
	LEA	G428_apc_S+-8(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "start"
	PEA	s!+30(A4)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-130(A6)
	MOVE	#13,-(A7)
	MOVE	D6,D0
	ADDQ	#8,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#105,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
L255:
	ADDQ	#1,D5
L253:
	CMPI	#3,D5
	BLE	L254(PC)
L256:
	ADDI	#48,G015_s_Gra+4(A4)
	ADDI	#48,G015_s_Gra+6(A4)
	ADDI	#48,G016_s_Gra+4(A4)
	ADDI	#48,G016_s_Gra+6(A4)
L250:
	ADDQ	#1,D7
L248:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L249(PC)
L251:
	PEA	-78(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L259:
L260:
	BRA.S	L259
L261:
L247:
L12T444_017:
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#40,-(A7)
	PEA	G012_s_Gra(A4)
	MOVE.L	A2,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-110(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#32,-(A7)
	PEA	-46(A6)
	PEA	-110(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1911,-16(A6)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#300,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	MOVE	G524_B_Res(A4),D0
	BEQ	L262(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	MOVE	#1,-(A7)
	PEA	G013_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G014_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
DATA SEG "s!"
	DATA 52 45 53 54 41 52 54 20 54 48 49 53 20 47 41 4D 45 00 
CODE SEG "start"
	PEA	s!+32(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#154,-(A7)
	MOVE	#110,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	#1079,-44(A6)
	MOVE	#1911,-38(A6)
	LEA	G446_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	JSR	F357_qzzz_(PC)
	JSR	F078_xzzz_(PC)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#600,D7
	BRA.S	L263
L264:
	JSR	F380_xzzz_(PC)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L263:
	SUBQ	#1,D7
	MOVE	D7,D0
	BEQ.S	L266
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L264
L266:
L265:
	JSR	F077_aA39_(PC)
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L267
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G021_aaui_(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32,-(A7)
	PEA	G346_aui_P(A4)
	PEA	G021_aaui_(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	G298_B_New(A4)
	JSR	F435_xxxx_(PC)
	CMPI	#-1,D0
	BEQ.S	L268
	JSR	F462_xxxx_(PC)
	CLR	G523_B_Res(A4)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	BRA.S	L232
L268:
L267:
L262:
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L246:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-10(A6),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L270:
L271:
	BRA.S	L270
L272:
L232:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$231:	.EQU	#-140
F445_xxxx_:/* global */
	LINK	A6,L$273
	JSR	F261_hzzz_(PC)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F065_aanz_(PC)
	ADDQ.L	#1,G313_ul_Ga(A4)
L274:
	UNLK	A6
	RTS
L$273:	.EQU	#0
F446_zzzz_:/* global */
	LINK	A6,L$275
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,G302_B_Gam(A4)
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L277
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L277:
	JSR	F363_pzzz_(PC)
	MOVE	#200,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	MOVE	#100,D0
	MOVE	D0,G407_s_Par+3204(A4)
	MOVE	D0,G407_s_Par+3208(A4)
	MOVE	D0,G407_s_Par+3206(A4)
	JSR	F260_pzzz_(PC)
	JSR	F445_xxxx_(PC)
	MOVE	G306_i_Par(A4),-4(A6)
	MOVE	G307_i_Par(A4),-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#10000,6(A3)
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	#255,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F146_aczz_(PC)
	ADDQ.L	#8,A7
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F148_aayz_(PC)
	ADDQ.L	#8,A7
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	MOVE	#1,D7
L14T446_002:
	BRA.S	L278
L279:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE.S	L281
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#50,D0
	BNE.S	L282
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,(A2)
L282:
L281:
	MOVE	-2(A6),D4
L278:
	CMPI	#-2,D4
	BNE.S	L279
L280:
	MOVE	D7,D0
	BEQ.S	L283
	CLR	D7
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L14T446_002
L283:
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L284
L285:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L286:
	ADD	#40,D7
L284:
	CMPI	#255,D7
	BLE.S	L285
L287:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	#25,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L288
L289:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L290:
	ADD	#40,D7
L288:
	CMPI	#255,D7
	BLE.S	L289
L291:
	MOVE	#4,D6
	BRA.S	L292
L293:
	MOVE	#5,D7
	BRA.S	L295
L296:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
	AND	#1,D0
	BEQ.S	L298
	MOVE	#25,D0
	BRA.S	L299
L298:
	MOVE	#23,D0
L299:
	MOVE.B	D0,4(A3)
	MOVE	D6,D5
	BRA.S	L300
L301:
	JSR	F445_xxxx_(PC)
L300:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L301
L302:
L295:
	SUBQ	#1,D7
	BNE.S	L296
L297:
L292:
	SUBQ	#1,D6
	BNE.S	L293
L294:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
	MOVE.B	#26,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#1,G077_B_DoN(A4)
	JSR	F445_xxxx_(PC)
	CLR	D7
	BRA.S	L303
L304:
	CLR	D6
	BRA.S	L307
L308:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L311
	MOVE	D7,D0
	CMP	-4(A6),D0
	BNE.S	L312
	MOVE	D6,D0
	CMP	-6(A6),D0
	BEQ.S	L311
L312:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
L311:
L309:
	ADDQ	#1,D6
L307:
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BLT.S	L308
L310:
L305:
	ADDQ	#1,D7
L303:
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BLT.S	L304
L306:
	JSR	F445_xxxx_(PC)
	CLR	-(A7)
	CLR	-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CLR	D7
	BRA.S	L313
L314:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#2,D0
	BNE.S	L316
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L316:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L313:
	CMPI	#-2,D4
	BNE.S	L314
L315:
	MOVE.B	#65,-9(A6)
	MOVE	D7,D5
	BRA.S	L317
L318:
	CLR	D6
	BRA.S	L320
L321:
	MOVE	#-32767,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	PEA	-226(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	-225(A6),D0
	MOVE.B	-9(A6),D1
	EXT	D1
	EXT	D0
	CMP	D1,D0
	BNE.S	L324
	JSR	F043_aahz_(PC)
	MOVE.B	#10,-225(A6)
	PEA	-225(A6)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F445_xxxx_(PC)
	MOVE	#780,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	ADDQ.B	#1,-9(A6)
	BRA.S	L323
L324:
L322:
	ADDQ	#1,D6
L320:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L321
L323:
L317:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L318
L319:
	MOVE	#600,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	CLR	G524_B_Res(A4)
	MOVE	#1,-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L276:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$275:	.EQU	#-226
F447_xxxx_:/* global */
	LINK	A6,L$325
	MOVE	8(A6),D0
	BNE.S	L327
L329:
L330:
	BRA.S	L329
L331:
L327:
L326:
	UNLK	A6
	RTS
L$325:	.EQU	#0
