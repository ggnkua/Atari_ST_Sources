CODE SEG "init!"
	MOVE	#-1,G403_i_Sen(A4)
BSS SEG "bss"
G403_i_Sen:/* global */
	.WORD	#2
G404_i_Sen:/* global */
	.WORD	#2
G405_i_Sen:/* global */
	.WORD	#2
G406_i_Sen:/* global */
	.WORD	#2
CODE SEG "timeline"
F268_fzzz_:/* global */
	LINK	A6,L$0
	MOVE.L	18(A6),D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	9(A6),-6(A6)
	CLR.B	-5(A6)
	MOVE.B	11(A6),-4(A6)
	MOVE.B	13(A6),-3(A6)
	MOVE.B	15(A6),-2(A6)
	MOVE.B	17(A6),-1(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#-10
F269_xxxx_:/* global */
	LINK	A6,L$2
	MOVEM.L	A3/D7,-(A7)
	MOVE	12(A6),D0
	BEQ.S	L4
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L5
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L5:
	BRA.S	L3
L4:
	MOVE	10(A6),D0
	AND.L	#65535,D0
	DIVU	G305_ui_Pa(A4),D0
	MOVE	D0,10(A6)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L6
L7:
	MOVE	52(A3),D0
	BEQ.S	L10
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L10:
L8:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L6:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L7
L9:
L3:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$2:	.EQU	#0
F270_xxxx_:/* global */
	LINK	A6,L$11
	CMPI	#10,8(A6)
	BNE.S	L13
	CMPI	#-1,14(A6)
	SNE	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	#300,-(A7)
	MOVE	#8,-(A7)
	JSR	F269_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L14
L13:
	MOVE	8(A6),G403_i_Sen(A4)
	MOVE	10(A6),G404_i_Sen(A4)
	MOVE	12(A6),G405_i_Sen(A4)
	MOVE	14(A6),G406_i_Sen(A4)
L14:
L12:
	UNLK	A6
	RTS
L$11:	.EQU	#0
F271_xxxx_:/* global */
	LINK	A6,L$15
	MOVEM.L	A3-A2/D7-D6,-(A7)
	CMPI	#-1,G403_i_Sen(A4)
	BNE.S	L17
	BRA	L16(PC)
L17:
	MOVE	G403_i_Sen(A4),D0
L18:
	CMP	#1,D0
	BEQ.S	L19
L21:
	CMP	#2,D0
	BEQ.S	L19
	BRA	L22(PC)
L19:
	MOVE	G405_i_Sen(A4),-(A7)
	MOVE	G404_i_Sen(A4),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L24
L25:
L26:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L24:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L25
	CMPI	#-1,G406_i_Sen(A4)
	BEQ.S	L28
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	G406_i_Sen(A4),D1
	CMP	D1,D0
	BNE.S	L25
L28:
L27:
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	(A3),D6
	BRA.S	L29
L30:
L31:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L29:
	CMPI	#-2,D6
	BEQ.S	L33
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L30
	CMPI	#-1,G406_i_Sen(A4)
	BEQ.S	L34
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	G406_i_Sen(A4),D1
	CMP	D1,D0
	BNE.S	L30
L34:
L33:
L32:
	CMPI	#-2,D6
	BNE.S	L35
	BRA.S	L20
L35:
	MOVE	G405_i_Sen(A4),-(A7)
	MOVE	G404_i_Sen(A4),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	BRA.S	L36
L37:
	CMPI	#-1,G406_i_Sen(A4)
	BEQ.S	L41
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	G406_i_Sen(A4),D1
	CMP	D1,D0
	BNE.S	L40
L41:
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
L40:
L38:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L36:
	CMPI	#-2,D6
	BEQ.S	L42
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BEQ.S	L37
L42:
L39:
	MOVE	(A2),(A3)
	MOVE	D7,(A2)
L22:
L23:
L20:
	MOVE	#-1,G403_i_Sen(A4)
L16:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$15:	.EQU	#0
F272_xxxx_:/* global */
	LINK	A6,L$43
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	4(A3),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L45
	ANDI	#-128,2(A3)
L45:
	MOVE.L	G313_ul_Ga(A4),D5
	MOVE	4(A3),D1
	AND	#1920,D1
	LSR	#7,D1
	AND.L	#65535,D1
	ADD.L	D1,D5
	MOVE	4(A3),D0
	AND	#2048,D0
	LSR	#3,D0
	LSR	#8,D0
	BEQ.S	L46
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	MOVE	D0,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L47
L46:
	MOVE	6(A3),D7
	AND	#1984,D7
	LSR	#6,D7
	MOVE	6(A3),D6
	AND	#-2048,D6
	LSR	#3,D6
	LSR	#8,D6
	MOVE	D7,D4
	ASL.L	#2,D4
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D4,A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	ASR	#5,D4
	CMPI	#0,D4
	BNE.S	L48
	MOVE	6(A3),D0
	AND	#48,D0
	LSR	#4,D0
	MOVE	D0,-2(A6)
	BRA.S	L49
L48:
	CLR	-2(A6)
L49:
	MOVE.L	D5,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,D0
	LEA	G059_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F268_fzzz_(PC)
	ADDA	#14,A7
L47:
L44:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$43:	.EQU	#-2
F273_xxxx_:/* global */
	LINK	A6,L$50
	MOVEM.L	D7-D5,-(A7)
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	BRA.S	L52
L53:
	MOVE	D5,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	D6,D0
	BNE.S	L56
	CMPI	#-1,D7
	BEQ.S	L58
	MOVE	D5,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D7,D1
	CMP	D1,D0
	BNE.S	L57
L58:
	MOVE	D5,D0
	BRA.S	L51
L57:
L56:
L54:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
L52:
	CMPI	#-2,D5
	BNE.S	L53
L55:
	MOVE	#-1,D0
L51:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$50:	.EQU	#0
F274_xxxx_:/* global */
	LINK	A6,L$59
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	CLR	-4(A6)
	MOVE	#0,D0
	MOVE	D0,D6
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA	L61(PC)
L62:
	MOVE	52(A3),D0
	BEQ.S	L65
	LEA	212(A3),A0
	MOVE.L	A0,A2
	CLR	D5
	BRA.S	L66
L67:
	MOVE	(A2)+,D4
L6T274_003:
	MOVE	D4,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMP	D7,D0
	BNE.S	L70
	MOVE	#1,D0
	BRA.S	L60
L70:
	CMPI	#144,-2(A6)
	BNE.S	L71
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-8(A6)
	MOVE.L	-8(A6),A0
	MOVE	2(A0),D4
	BRA.S	L72
L73:
	MOVE	D4,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	D7,D0
	BNE.S	L76
	MOVE	#1,D0
	BRA.S	L60
L76:
L74:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L72:
	CMPI	#-2,D4
	BNE.S	L73
L75:
L71:
L68:
	ADDQ	#1,D5
L66:
	CMPI	#30,D5
	BCC.S	L77
	MOVE	-4(A6),D0
	BEQ.S	L67
L77:
L69:
L65:
L63:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	A3,D0
	ADDA	#800,A3
L61:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L62(PC)
L64:
	MOVE	-4(A6),D0
	BNE.S	L78
	MOVE	#1,-4(A6)
	MOVE	G414_T_Lea(A4),D4
	BRA	L6T274_003(PC)
L78:
	MOVE	#0,D0
L60:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$59:	.EQU	#-8
F275_aszz_:/* global */
	LINK	A6,L$79
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-8(A6)
	MOVE	G414_T_Lea(A4),-18(A6)
	CLR	D5
	BRA.S	L81
L82:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L83:
	ADDQ	#1,D5
L81:
	CMPI	#4,D5
	BCS.S	L82
L84:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	D0,-24(A6)
	BRA.S	L85
L86:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#3,D0
	BNE.S	L89
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	ADDQ	#1,(A0)
	BRA.S	L90
L89:
	CMPI	#4,D6
	BCS.S	L91
	BRA.S	L88
L91:
L90:
L87:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L85:
	CMPI	#-2,D7
	BNE.S	L86
L88:
	MOVE	-24(A6),D0
	MOVE	D0,D7
	MOVE	D0,-22(A6)
	BRA	L92(PC)
L93:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#3,D0
	BNE	L95(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,D5
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	SUBQ	#1,(A0)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D0,-4(A6)
	CMPI	#0,D0
	BNE.S	L96
	BRA	L7T275_058_(PC)
L96:
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L97
	CMPI	#127,-4(A6)
	BEQ.S	L97
	BRA	L7T275_058_(PC)
L97:
	MOVE	D5,D0
	CMP	12(A6),D0
	BEQ.S	L98
	BRA	L7T275_058_(PC)
L98:
	MOVE	2(A2),D0
	LSR	#7,D0
	MOVE	D0,-6(A6)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-2(A6)
	MOVE	-4(A6),D0
L99:
	CMP	#1,D0
	BEQ.S	L100
	BRA.S	L102
L100:
	CLR	D4
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L104
	BRA	L7T275_058_(PC)
L104:
	BRA	L101(PC)
	BRA.S	L103
L102:
	CMP	#2,D0
	BEQ.S	L103
	BRA.S	L105
L103:
	MOVE	G415_B_Lea(A4),D4
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D4
	SNE	D4
	AND	#1,D4
	BRA	L101(PC)
	BRA.S	L106
L105:
	CMP	#17,D0
	BEQ.S	L106
L107:
	CMP	#11,D0
	BEQ.S	L106
	BRA.S	L108
L106:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BEQ.S	L110
	BRA	L7T275_058_(PC)
L110:
	BRA.S	L109
L108:
	CMP	#3,D0
	BEQ.S	L109
L111:
	CMP	#4,D0
	BEQ.S	L109
	BRA	L112(PC)
L109:
	MOVE	-18(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-38(A6)
	MOVE	-6(A6),D0
	CMP	-38(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D4
	MOVE	D4,D0
	BNE.S	L114
	CMPI	#17,-4(A6)
	BNE.S	L114
	MOVE	-22(A6),D0
	CMP	D7,D0
	BNE.S	L115
	BRA	L101(PC)
L115:
	MOVE	-22(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-28(A6)
	MOVE.L	-28(A6),A0
	MOVE	(A2),(A0)
	MOVE	#-1,(A2)
	MOVE	-22(A6),D7
L114:
	MOVE	D4,D0
	BNE.S	L116
	CMPI	#11,-4(A6)
	BNE.S	L116
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#2,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
L116:
	BRA	L101(PC)
	BRA.S	L113
L112:
	CMP	#12,D0
	BEQ.S	L113
	BRA.S	L117
L113:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BEQ.S	L119
	BRA	L7T275_058_(PC)
L119:
	MOVE	G415_B_Lea(A4),D4
	SEQ	D4
	AND	#1,D4
	MOVE	D4,D0
	BNE.S	L120
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#2,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
L120:
	BRA	L101(PC)
	BRA.S	L118
L117:
	CMP	#13,D0
	BEQ.S	L118
	BRA	L121(PC)
L118:
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L123
	MOVE	-6(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F273_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-18(A6)
	CMPI	#-1,D0
	BNE.S	L124
	BRA	L7T275_058_(PC)
L124:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L125
L123:
	MOVE	-18(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-6(A6),D0
	BNE.S	L127
	MOVE	-6(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F273_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#-1,D0
	BEQ.S	L126
L127:
	BRA	L7T275_058_(PC)
L126:
	JSR	F298_aqzz_(PC)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-18(A6),D0
	AND	#16383,D0
	MOVE	D5,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-18(A6)
L125:
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#2,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#3,-2(A6)
	BNE.S	L128
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L128
	MOVE	#1,D4
	BRA.S	L129
L128:
	CLR	D4
L129:
	BRA	L101(PC)
	BRA.S	L122
L121:
	CMP	#16,D0
	BEQ.S	L122
	BRA	L130(PC)
L122:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BEQ.S	L132
	BRA	L7T275_058_(PC)
L132:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-20(A6)
	MOVE	-18(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-6(A6),D0
	BNE.S	L134
	CMPI	#-1,-20(A6)
	BNE.S	L133
L134:
	BRA	L7T275_058_(PC)
L133:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-20(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	JSR	F298_aqzz_(PC)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-18(A6),D0
	AND	#16383,D0
	MOVE	D5,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,-(A7)
	MOVE	-20(A6),-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
	CLR	D4
	BRA.S	L101
	BRA.S	L131
L130:
	CMP	#127,D0
	BEQ.S	L131
	BRA.S	L135
L131:
	MOVE	-6(A6),-(A7)
	JSR	F280_agzz_(PC)
	ADDQ.L	#2,A7
	BRA	L7T275_058_(PC)
	BRA.S	L136
L135:
	CMP	#5,D0
	BEQ.S	L136
L137:
	CMP	#6,D0
	BEQ.S	L136
L138:
	CMP	#7,D0
	BEQ.S	L136
L139:
	CMP	#8,D0
	BEQ.S	L136
L140:
	CMP	#9,D0
	BEQ.S	L136
L141:
	CMP	#10,D0
	BEQ.S	L136
L142:
	CMP	#14,D0
	BEQ.S	L136
L143:
	CMP	#15,D0
	BEQ.S	L136
	BRA.S	L144
L136:
	BRA	L7T275_058_(PC)
L145:
	BRA	L7T275_058_(PC)
	BRA.S	L146
L144:
	BRA.S	L145
L146:
L101:
	CMPI	#3,-2(A6)
	BNE.S	L147
	MOVE	D4,D0
	BEQ.S	L148
	MOVE	#1,D0
	BRA.S	L149
L148:
	MOVE	#0,D0
L149:
	MOVE	D0,-2(A6)
	CLR	D4
L147:
	MOVE	D4,D0
	BNE	L150(PC)
	MOVE	#1,-8(A6)
	MOVE	4(A2),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L151
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#1,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L151:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L152
	CMPI	#4,-4(A6)
	BEQ.S	L153
	CMPI	#11,-4(A6)
	BEQ.S	L153
	CMPI	#17,-4(A6)
	BNE.S	L152
L153:
	MOVE	-18(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#-1,(A3)
	JSR	F298_aqzz_(PC)
	MOVE	#-1,-18(A6)
	BRA.S	L154
L152:
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L155
	CMPI	#12,-4(A6)
	BNE.S	L155
	MOVE	-6(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-18(A6)
	CMPI	#-1,D0
	BEQ.S	L155
	MOVE	#1,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L155:
L154:
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L150:
	BRA.S	L7T275_058_
L95:
	CMPI	#4,D6
	BCS.S	L156
	BRA.S	L94
L156:
L7T275_058_:
	MOVE	D7,-22(A6)
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L92:
	CMPI	#-2,D7
	BNE	L93(PC)
L94:
	JSR	F271_xxxx_(PC)
	MOVE	-8(A6),D0
L80:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$79:	.EQU	#-38
F276_qzzz_:/* global */
	LINK	A6,L$157
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	14(A6),D7
	CMPI	#-1,12(A6)
	BEQ.S	L159
	MOVE	12(A6),D5
	AND	#15360,D5
	LSR	#2,D5
	LSR	#8,D5
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-10(A6)
	BRA.S	L160
L159:
	MOVE	#-1,D5
	MOVE	#-1,-10(A6)
L160:
	MOVE	16(A6),D0
	BNE.S	L161
	CMPI	#-1,D5
	BEQ.S	L161
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	12(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L161:
	MOVE	10(A6),D0
	MOVE	8(A6),D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-16(A6)
	LSR	#5,D0
	CMPI	#0,D0
	BNE.S	L162
	MOVE	12(A6),D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-2(A6)
	BRA.S	L163
L162:
	MOVE	#-1,-2(A6)
L163:
	MOVE	#0,D0
	MOVE	D0,-14(A6)
	MOVE	D0,-12(A6)
	MOVE	D0,-8(A6)
	MOVE	D0,-6(A6)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	CMPI	#-1,-2(A6)
	BNE	L164(PC)
	BRA	L165(PC)
L166:
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-4(A6)
	CMPI	#4,D0
	BNE.S	L168
	MOVE	#1,-8(A6)
	BRA.S	L169
L168:
	CMPI	#2,-4(A6)
	BNE.S	L170
	CMPI	#-1,D5
	BNE.S	L170
	MOVE	16(A6),D0
	BEQ.S	L170
	MOVE	D7,D0
	BNE.S	L170
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	PEA	G353_ac_St(A4)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L171
L170:
	CMPI	#4,-4(A6)
	BLS.S	L172
	CMPI	#14,-4(A6)
	BCC.S	L172
	MOVE	#1,-6(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SEQ	D0
	AND	#1,D0
	OR	D0,-12(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SNE	D0
	AND	#1,D0
	OR	D0,-14(A6)
L172:
L171:
L169:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L165:
	CMPI	#-2,D6
	BNE	L166(PC)
L167:
	BRA.S	L173
L164:
	BRA.S	L174
L175:
	MOVE	-2(A6),D0
	MOVE	D6,D1
	LSR	#6,D1
	LSR	#8,D1
	CMP	D1,D0
	BNE.S	L177
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#4,D0
	BLS.S	L177
	MOVE	#1,-6(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SEQ	D0
	AND	#1,D0
	OR	D0,-12(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SNE	D0
	AND	#1,D0
	OR	D0,-14(A6)
L177:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L174:
	CMPI	#-2,D6
	BNE.S	L175
L176:
L173:
	MOVE	16(A6),D0
	BEQ.S	L178
	CMPI	#-1,D5
	BEQ.S	L178
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	12(A6),-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
L178:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA	L179(PC)
L180:
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-4(A6)
	CMPI	#3,D0
	BNE	L183(PC)
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	2(A3),D0
	AND	#127,D0
	CMPI	#0,D0
	BNE.S	L184
	BRA	L181(PC)
L184:
	MOVE	2(A3),D0
	LSR	#7,D0
	MOVE	D0,-20(A6)
	MOVE	16(A6),D4
	CMPI	#-1,-2(A6)
	BNE	L185(PC)
	MOVE	2(A3),D0
	AND	#127,D0
L186:
	CMP	#1,D0
	BEQ.S	L187
	BRA.S	L189
L187:
	MOVE	D7,D0
	BNE.S	L192
	MOVE	-6(A6),D0
	BNE.S	L192
	MOVE	-8(A6),D0
	BEQ.S	L191
L192:
	BRA	L181(PC)
L191:
	BRA	L188(PC)
	BRA.S	L190
L189:
	CMP	#2,D0
	BEQ.S	L190
	BRA.S	L193
L190:
	CMPI	#4,D5
	BGT.S	L196
	MOVE	D7,D0
	BNE.S	L196
	MOVE	-8(A6),D0
	BEQ.S	L195
L196:
	BRA	L181(PC)
L195:
	BRA	L188(PC)
	BRA.S	L194
L193:
	CMP	#3,D0
	BEQ.S	L194
	BRA.S	L197
L194:
	CMPI	#-1,D5
	BNE.S	L200
	CMPI	#0,G305_ui_Pa(A4)
	BNE.S	L199
L200:
	BRA	L181(PC)
L199:
	CMPI	#0,-20(A6)
	BNE.S	L201
	MOVE	D7,D0
	BEQ.S	L202
	BRA	L181(PC)
L202:
	BRA.S	L203
L201:
	MOVE	16(A6),D0
	BNE.S	L204
	CLR	D4
	BRA.S	L205
L204:
	MOVE	-20(A6),D4
	MOVE	G308_i_Par(A4),D1
	ADDQ	#1,D1
	CMP	D1,D4
	SEQ	D4
	AND	#1,D4
L205:
L203:
	BRA	L188(PC)
	BRA.S	L198
L197:
	CMP	#4,D0
	BEQ.S	L198
	BRA.S	L206
L198:
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-30(A6)
	MOVE	-20(A6),D0
	CMP	-30(A6),D0
	BNE.S	L209
	MOVE	-12(A6),D0
	BEQ.S	L208
L209:
	BRA	L181(PC)
L208:
	BRA	L188(PC)
	BRA.S	L207
L206:
	CMP	#5,D0
	BEQ.S	L207
	BRA.S	L210
L207:
	CMPI	#-1,-4(A6)
	BNE.S	L213
	MOVE	-16(A6),D0
	LSR	#5,D0
	CMPI	#3,D0
	BEQ.S	L212
L213:
	BRA	L181(PC)
L212:
	BRA.S	L188
	BRA.S	L211
L210:
	CMP	#6,D0
	BEQ.S	L211
	BRA.S	L214
L211:
	BRA	L181(PC)
	BRA.S	L215
L214:
	CMP	#7,D0
	BEQ.S	L215
	BRA.S	L216
L215:
	CMPI	#4,D5
	BGT.S	L219
	CMPI	#-1,D5
	BEQ.S	L219
	MOVE	-8(A6),D0
	BEQ.S	L218
L219:
	BRA	L181(PC)
L218:
	BRA.S	L188
	BRA.S	L217
L216:
	CMP	#8,D0
	BEQ.S	L217
	BRA.S	L220
L217:
	CMPI	#-1,D5
	BEQ.S	L222
	BRA	L181(PC)
L222:
	MOVE	-20(A6),-(A7)
	JSR	F274_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	BRA.S	L188
L221:
	BRA	L181(PC)
	BRA.S	L223
L220:
	BRA.S	L221
L223:
L188:
	BRA	L224(PC)
L185:
	MOVE	-2(A6),D0
	MOVE	D6,D1
	LSR	#6,D1
	LSR	#8,D1
	CMP	D1,D0
	BEQ.S	L225
	BRA	L181(PC)
L225:
	MOVE	2(A3),D0
	AND	#127,D0
L226:
	CMP	#1,D0
	BEQ.S	L227
	BRA.S	L229
L227:
	MOVE	-6(A6),D0
	BEQ.S	L231
	BRA	L181(PC)
L231:
	BRA.S	L228
	BRA.S	L230
L229:
	CMP	#2,D0
	BEQ.S	L230
	BRA.S	L232
L230:
	MOVE	-12(A6),D0
	BNE.S	L235
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-40(A6)
	MOVE	2(A3),D0
	LSR	#7,D0
	CMP	-40(A6),D0
	BEQ.S	L234
L235:
	BRA	L181(PC)
L234:
	BRA.S	L228
	BRA.S	L233
L232:
	CMP	#3,D0
	BEQ.S	L233
	BRA.S	L236
L233:
	MOVE	-14(A6),D0
	BNE.S	L239
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-50(A6)
	MOVE	2(A3),D0
	LSR	#7,D0
	CMP	-50(A6),D0
	BNE.S	L238
L239:
	BRA	L181(PC)
L238:
	BRA.S	L228
L237:
	BRA	L181(PC)
	BRA.S	L240
L236:
	BRA.S	L237
L240:
L228:
L224:
	MOVE	4(A3),D0
	AND	#32,D0
	LSR	#5,D0
	EOR	D0,D4
	MOVE	4(A3),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-18(A6)
	CMPI	#3,D0
	BNE.S	L241
	MOVE	D4,D0
	BEQ.S	L242
	MOVE	#0,D0
	BRA.S	L243
L242:
	MOVE	#1,D0
L243:
	MOVE	D0,-18(A6)
	BRA.S	L244
L241:
	MOVE	D4,D0
	BNE.S	L245
	BRA.S	L181
L245:
L244:
	MOVE	4(A3),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L246
	MOVE	#1,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#1,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L246:
	MOVE	#-1,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	-18(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L181
L183:
	CMPI	#4,-4(A6)
	BCS.S	L247
	BRA.S	L182
L247:
L181:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L179:
	CMPI	#-2,D6
	BNE	L180(PC)
L182:
	JSR	F271_xxxx_(PC)
L158:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$157:	.EQU	#-50
