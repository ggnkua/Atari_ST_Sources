BSS SEG "bss"
G432_as_Co:/* global */
	.WORD	#30
G433_i_Com:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#4,G434_i_Com(A4)
BSS SEG "bss"
G434_i_Com:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#1,G435_B_Com(A4)
BSS SEG "bss"
G435_B_Com:/* global */
	.WORD	#2
G436_B_Pen:/* global */
	.WORD	#2
G437_i_Pen:/* global */
	.WORD	#2
G438_i_Pen:/* global */
	.WORD	#2
G439_i_Pen:/* global */
	.WORD	#2
G440_B_Con:/* global */
	.WORD	#2
G441_ps_Pr:/* global */
	.WORD	#4
G442_ps_Se:/* global */
	.WORD	#4
G443_ps_Pr:/* global */
	.WORD	#4
G444_ps_Se:/* global */
	.WORD	#4
G445_as_Gr:/* global */
	.WORD	#48
G446_as_Gr:/* global */
	.WORD	#24
G447_as_Gr:/* global */
	.WORD	#192
G448_as_Gr:/* global */
	.WORD	#108
G449_as_Gr:/* global */
	.WORD	#456
G450_as_Gr:/* global */
	.WORD	#36
G451_as_Gr:/* global */
	.WORD	#36
G452_as_Gr:/* global */
	.WORD	#60
G453_as_Gr:/* global */
	.WORD	#60
G454_as_Gr:/* global */
	.WORD	#108
G455_as_Gr:/* global */
	.WORD	#156
G456_as_Gr:/* global */
	.WORD	#108
G457_as_Gr:/* global */
	.WORD	#48
G458_as_Gr:/* global */
	.WORD	#28
G459_as_Gr:/* global */
	.WORD	#28
G460_as_Gr:/* global */
	.WORD	#12
G461_as_Gr:/* global */
	.WORD	#8
G462_as_Gr:/* global */
	.WORD	#16
G463_as_Gr:/* global */
	.WORD	#32
G464_as_Gr:/* global */
	.WORD	#56
G465_ai_Gr:/* global */
	.WORD	#8
G466_ai_Gr:/* global */
	.WORD	#8
G467_s_Gra:/* global */
	.WORD	#8
G468_s_Gra:/* global */
	.WORD	#8
G469_s_Gra:/* global */
	.WORD	#8
G470_s_Gra:/* global */
	.WORD	#8
G471_as_Gr:/* global */
	.WORD	#24
G472_as_Gr:/* global */
	.WORD	#36
G473_as_Gr:/* global */
	.WORD	#48
G474_as_Gr:/* global */
	.WORD	#60
G475_as_Gr:/* global */
	.WORD	#24
G476_as_Gr:/* global */
	.WORD	#36
G477_as_Gr:/* global */
	.WORD	#48
G478_as_Gr:/* global */
	.WORD	#60
G479_i_Gra:/* global */
	.WORD	#2
CODE SEG "init!"
	LEA	G480_aaps_(A4),A1
	LEA	G471_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G472_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G473_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G474_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G475_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G476_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G477_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
	LEA	G478_as_Gr(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
G480_aaps_:/* global */
	.WORD	#32
CODE SEG "user"
F357_qzzz_:/* global */
	LINK	A6,L$0
	BRA.S	L2
L3:
	MOVE	#7,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
L2:
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE.S	L3
L4:
	MOVE	#1,G435_B_Com(A4)
	CLR	G433_i_Com(A4)
	MOVE	#4,G434_i_Com(A4)
	CLR	G435_B_Com(A4)
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#0
F358_xxxx_:/* global */
	LINK	A6,L$5
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	CMPA.L	#0,A3
	BEQ.S	L8
	MOVE	G440_B_Con(A4),D0
	BEQ.S	L7
L8:
	MOVE	#0,D0
	BRA.S	L6
L7:
	BRA.S	L9
L10:
	MOVE	D7,D0
	CMP	4(A3),D0
	BGT.S	L12
	MOVE	D7,D0
	CMP	2(A3),D0
	BLT.S	L12
	MOVE	D6,D0
	CMP	6(A3),D0
	BLT.S	L12
	MOVE	D6,D0
	CMP	8(A3),D0
	BGT.S	L12
	MOVE	D5,D0
	AND	10(A3),D0
	BEQ.S	L12
	BRA.S	L11
L12:
	ADDA	#12,A3
L9:
	MOVE	(A3),D4
	BNE.S	L10
L11:
	MOVE	D4,D0
L6:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$5:	.EQU	#0
F359_hzzz_:/* global */
	LINK	A6,L$13
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	TAS	G435_B_Com(A4)
	BEQ.S	L2T359_002
	MOVE	#1,G436_B_Pen(A4)
	MOVE	D7,G437_i_Pen(A4)
	MOVE	D6,G438_i_Pen(A4)
	MOVE	12(A6),G439_i_Pen(A4)
	MOVE	G440_B_Con(A4),D0
	BNE.S	L15
	PEA	F380_xzzz_(PC)
	JSR	F464_AA07_(PC)
	ADDQ.L	#4,A7
	CMPI	#1074,D0
	BEQ.S	L15
	ADDQ	#1,G440_B_Con(A4)
L15:
	BRA	L14(PC)
L2T359_002:
	MOVE	G434_i_Com(A4),D0
	ADDQ	#2,D0
	MOVE	D0,D5
	CMPI	#4,D0
	BLE.S	L16
	SUBQ	#5,D5
L16:
	MOVE	D5,D0
	CMP	G433_i_Com(A4),D0
	BNE.S	L17
	BRA.S	L14
L17:
	MOVE	12(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	G441_ps_Pr(A4),-(A7)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D4
	CMPI	#0,D4
	BNE.S	L18
	MOVE	12(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	G442_ps_Se(A4),-(A7)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D4
L18:
	CMPI	#0,D4
	BEQ.S	L19
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L20
	MOVE	#4,D5
L20:
	MOVE	D5,D0
	MOVE	D0,G434_i_Com(A4)
	MULS	#6,D0
	LEA	G432_as_Co+4(A4),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
	MOVE	D5,D0
	MULS	#6,D0
	LEA	G432_as_Co(A4),A0
	ADDA	D0,A0
	MOVE	D7,(A0)
	MOVE	D5,D0
	MULS	#6,D0
	LEA	G432_as_Co+2(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L19:
	CLR	G435_B_Com(A4)
L14:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$13:	.EQU	#0
F360_xxxx_:/* global */
	LINK	A6,L$21
	MOVE	G436_B_Pen(A4),D0
	BEQ.S	L23
	CLR	G436_B_Pen(A4)
	MOVE	G439_i_Pen(A4),-(A7)
	MOVE	G438_i_Pen(A4),-(A7)
	MOVE	G437_i_Pen(A4),-(A7)
	JSR	F359_hzzz_(PC)
	ADDQ.L	#6,A7
L23:
L22:
	UNLK	A6
	RTS
L$21:	.EQU	#0
F361_nzzz_:/* global */
	LINK	A6,L$24
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	G443_ps_Pr(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L26
	BRA	L25(PC)
L26:
	MOVE	#1,G435_B_Com(A4)
	MOVE.L	D7,D0
	CMPI	#0,D0
	BNE.S	L27
	MOVE.L	D7,D0
	ASR.L	#8,D0
	MOVE.L	D0,D7
L27:
	MOVE	G434_i_Com(A4),D0
	ADDQ	#2,D0
	MOVE	D0,D6
	CMPI	#4,D0
	BLE.S	L28
	SUBQ	#5,D6
L28:
	MOVE	D6,D0
	CMP	G433_i_Com(A4),D0
	BNE.S	L29
	BRA.S	L4T361_014
L29:
	BRA.S	L30
L31:
	MOVE.L	D7,D0
	CMP	2(A3),D0
	BNE.S	L33
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L34
	MOVE	#4,D6
L34:
	MOVE	D6,D0
	MOVE	D0,G434_i_Com(A4)
	MULS	#6,D0
	LEA	G432_as_Co+4(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	BRA.S	L4T361_014
L33:
	ADDQ.L	#4,A3
L30:
	MOVE	(A3),D5
	BNE.S	L31
L32:
	MOVE.L	G444_ps_Se(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L35
	BRA.S	L4T361_014
L35:
	BRA.S	L36
L37:
	MOVE.L	D7,D0
	CMP	2(A3),D0
	BNE.S	L39
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L40
	MOVE	#4,D6
L40:
	MOVE	D6,D0
	MOVE	D0,G434_i_Com(A4)
	MULS	#6,D0
	LEA	G432_as_Co+4(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	BRA.S	L4T361_014
L39:
	ADDQ.L	#4,A3
L36:
	MOVE	(A3),D5
	BNE.S	L37
L38:
L4T361_014:
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
L25:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$24:	.EQU	#0
F362_xxxx_:/* global */
	LINK	A6,L$41
L44:
L43:
	MOVE	G340_B_Hig(A4),D0
	BNE.S	L44
L45:
	MOVE	8(A6),G336_i_Hig(A4)
	MOVE	10(A6),G337_i_Hig(A4)
	MOVE	12(A6),G338_i_Hig(A4)
	MOVE	14(A6),G339_i_Hig(A4)
	MOVE	#1,G340_B_Hig(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L42:
	UNLK	A6
	RTS
L$41:	.EQU	#0
F363_pzzz_:/* global */
	LINK	A6,L$46
L49:
L48:
	MOVE	G340_B_Hig(A4),D0
	BNE.S	L49
L50:
	MOVE	G341_B_Hig(A4),D0
	BEQ.S	L51
	MOVE	#1,G340_B_Hig(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L51:
L47:
	UNLK	A6
	RTS
L$46:	.EQU	#0
F364_xxxx_:/* global */
	LINK	A6,L$52
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	PEA	G307_i_Par(A4)
	PEA	G306_i_Par(A4)
	MOVE	8(A6),D0
	BEQ.S	L54
	MOVE	#-1,D0
	BRA.S	L55
L54:
	MOVE	#1,D0
L55:
	MOVE	D0,-(A7)
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F154_afzz_(PC)
	ADDA	#12,A7
	MOVE	D0,G327_i_New(A4)
	MOVE	G327_i_New(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F155_ahzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F284_czzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L53:
	UNLK	A6
	RTS
L$52:	.EQU	#-2
F365_xxxx_:/* global */
	LINK	A6,L$56
	MOVE	D7,-(A7)
	MOVE	#1,G321_B_Sto(A4)
	CMPI	#1,8(A6)
	BNE.S	L58
	MOVE	#145,-(A7)
	MOVE	#125,-(A7)
	MOVE	#261,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L59
L58:
	MOVE	#145,-(A7)
	MOVE	#125,-(A7)
	MOVE	#318,-(A7)
	MOVE	#291,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
L59:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	CMPI	#3,D0
	BNE.S	L60
	MOVE	D7,D0
	AND	#4,D0
	MOVE	D0,-(A7)
	JSR	F364_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA.S	L57
L60:
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
	MOVE	G308_i_Par(A4),D0
	CMPI	#2,8(A6)
	BNE.S	L61
	MOVE	#1,D1
	BRA.S	L62
L61:
	MOVE	#3,D1
L62:
	ADD	D1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F284_czzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
L57:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$56:	.EQU	#0
F366_xxxx_:/* global */
	LINK	A6,L$63
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,G321_B_Sto(A4)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	MOVE	#0,D0
	MOVE	D0,D4
	BRA.S	L65
L66:
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-20(A6)
	MOVE	272(A3),D0
	MULU	#3,D0
	AND.L	#65535,D0
	DIVU	-20(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	A3,D0
	ADDA	#800,A3
	MOVE	D4,D0
	ADDQ	#1,D4
L65:
	MOVE	D4,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L66
L67:
	MOVE	8(A6),D4
	SUBQ	#3,D4
	MOVE	D4,D0
	ASL.L	#3,D0
	LEA	G463_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	6(A2),-(A7)
	MOVE	4(A2),-(A7)
	MOVE	2(A2),-(A7)
	MOVE	(A2),-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	G307_i_Par(A4),D0
	MOVE	D0,-4(A6)
	MOVE	D0,-(A7)
	MOVE	G306_i_Par(A4),D0
	MOVE	D0,-2(A6)
	MOVE	D0,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	CMPI	#3,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-6(A6)
	MOVE	-6(A6),D0
	BEQ.S	L68
	CMPI	#2,D4
	BNE.S	L68
	MOVE	D7,D0
	AND	#4,D0
	MOVE	D0,-(A7)
	JSR	F364_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L64(PC)
L68:
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G466_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G465_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D7
	LSR	#5,D0
	MOVE	D0,D6
	CMPI	#3,D6
	BNE.S	L69
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	-2(A6),G306_i_Par(A4)
	MOVE	-4(A6),G307_i_Par(A4)
	MOVE	D7,D0
	AND	#4,D0
	MOVE	D0,-(A7)
	JSR	F364_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L64(PC)
L69:
	CLR	D5
	CMPI	#0,D6
	BNE.S	L70
	MOVE	#1,D5
	BRA.S	L71
L70:
	CMPI	#4,D6
	BNE.S	L72
	MOVE	D7,D5
	AND	#7,D5
	CMPI	#0,D5
	SNE	D0
	TST.B	D0
	BEQ.S	L74
	CMPI	#1,D5
	SNE	D0
	TST.B	D0
L74:
	TST.B	D0
	BEQ.S	L73
	CMPI	#5,D5
	SNE	D0
	TST.B	D0
L73:
	AND	#1,D0
	MOVE	D0,D5
	BRA.S	L75
L72:
	CMPI	#6,D6
	BNE.S	L76
	MOVE	D7,D5
	AND	#4,D5
	SEQ	D5
	TST.B	D5
	BEQ.S	L77
	MOVE	D7,D5
	AND	#1,D5
	SEQ	D5
	TST.B	D5
L77:
	AND	#1,D5
L76:
L75:
L71:
	CMPI	#0,G305_ui_Pa(A4)
	BNE.S	L78
	BRA	L79(PC)
L78:
	MOVE	D5,D0
	BEQ	L80(PC)
	MOVE	#2,-(A7)
	MOVE	#24,-(A7)
	MOVE	#1,-(A7)
	MOVE	G308_i_Par(A4),D1
	ADDQ	#2,D1
	MOVE	D4,D0
	ADD	D1,D0
	MOVE	D0,D4
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F286_hzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	MOVE	D4,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F286_hzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-10(A6)
	MOVE	D0,-30(A6)
	MOVE	-8(A6),D0
	CMP	-30(A6),D0
	BEQ.S	L81
	MOVE	#2,-(A7)
	MOVE	#24,-(A7)
	MOVE	#1,-(A7)
	MOVE	-10(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	OR	D0,D5
L81:
	MOVE	D5,D0
	BEQ.S	L82
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#18,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L82:
	BRA.S	L83
L80:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	SNE	D0
	AND	#1,D0
	MOVE	D0,D5
	BEQ.S	L84
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L84:
L83:
L79:
	MOVE	D5,D0
	BEQ.S	L85
	JSR	F357_qzzz_(PC)
	CLR	G321_B_Sto(A4)
	BRA	L64(PC)
L85:
	MOVE	-6(A6),D0
	BEQ.S	L86
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	BRA.S	L87
L86:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L87:
	MOVE	#1,D7
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	MOVE	#0,D0
	MOVE	D0,D4
	BRA.S	L88
L89:
	MOVE	52(A3),D0
	BEQ.S	L91
	MOVE.L	A3,-(A7)
	JSR	F310_AA08_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
L91:
	MOVE	D4,D0
	ADDQ	#1,D4
	MOVE.L	A3,D0
	ADDA	#800,A3
L88:
	MOVE	D4,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L89
L90:
	MOVE	D7,G310_i_Dis(A4)
	CLR	G311_i_Pro(A4)
L64:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$63:	.EQU	#-30
F367_xxxx_:/* global */
	LINK	A6,L$92
	MOVEM.L	D7-D5,-(A7)
	MOVE	10(A6),D7
	MOVE	12(A6),D6
	MOVE	8(A6),D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L94
	MOVE	8(A6),-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L93
L94:
	MOVE	#2,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	G455_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	CMPI	#16,D5
	BCS.S	L95
	CMPI	#19,D5
	BHI.S	L95
	MOVE	D5,D0
	SUB	#16,D0
	MOVE	D0,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L93
L95:
	CMPI	#20,D5
	BCS.S	L96
	CMPI	#27,D5
	BHI.S	L96
	MOVE	D5,D0
	SUB	#20,D0
	MOVE	D0,-(A7)
	JSR	F302_mzzz_(PC)
	ADDQ.L	#2,A7
L96:
L93:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$92:	.EQU	#0
F368_fzzz_:/* global */
	LINK	A6,L$97
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G411_i_Lea(A4),D0
	BEQ.S	L100
	CMPI	#-1,D7
	BEQ.S	L99
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L99
L100:
	BRA	L98(PC)
L99:
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L101
	MOVE	G411_i_Lea(A4),D0
	MOVE	D0,D6
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#640,(A0)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
	MOVE	#-1,G411_i_Lea(A4)
	MOVE	D6,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L101:
	CMPI	#-1,D7
	BNE.S	L102
	MOVE	#-1,G411_i_Lea(A4)
	BRA.S	L98
L102:
	MOVE	D7,D0
	MOVE	D0,G411_i_Lea(A4)
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ.S	L103
	ORI	#1664,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L103:
L98:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$97:	.EQU	#0
F369_xxxx_:/* global */
	LINK	A6,L$104
	MOVEM.L	A3/D7,-(A7)
	CMPI	#108,8(A6)
	BNE.S	L106
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+34(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#0,D0
	BNE.S	L107
	BRA	L105(PC)
L107:
	MOVE	#73,-(A7)
	MOVE	#63,-(A7)
	MOVE	#303,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#136,G031_i_Gra(A4)
	BEQ.S	L108
	PEA	G295_ac_Se(A4)
	JSR	F277_jzzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L108
	MOVE	#136,G189_i_Gra(A4)
L108:
	CLR	-(A7)
	JSR	F408_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,G321_B_Sto(A4)
	BRA.S	L109
L106:
	MOVE	8(A6),D7
	SUB	#101,D7
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	G464_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	6(A3),-(A7)
	MOVE	4(A3),-(A7)
	MOVE	2(A3),-(A7)
	MOVE	(A3),-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	JSR	F363_pzzz_(PC)
	CMPI	#6,D7
	BCC.S	L110
	MOVE	D7,-(A7)
	JSR	F399_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA.S	L111
L110:
	JSR	F400_xxxx_(PC)
L111:
L109:
L105:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$104:	.EQU	#0
F370_xxxx_:/* global */
	LINK	A6,L$112
	MOVEM.L	D7-D6,-(A7)
	MOVE	#-1,D6
	CMPI	#48,10(A6)
	BHI	L114(PC)
	MOVE	G514_i_Mag(A4),D0
L115:
	CMP	#0,D0
	BEQ.S	L116
	BRA.S	L118
L116:
	CMPI	#280,8(A6)
	BCS.S	L120
	CMPI	#291,8(A6)
	BHI.S	L120
	MOVE	#1,D6
	BRA.S	L121
L120:
	CMPI	#294,8(A6)
	BCS.S	L122
	CMPI	#305,8(A6)
	BHI.S	L122
	MOVE	#2,D6
	BRA.S	L123
L122:
	CMPI	#308,8(A6)
	BCS.S	L124
	MOVE	#3,D6
L124:
L123:
L121:
	BRA	L117(PC)
	BRA.S	L119
L118:
	CMP	#1,D0
	BEQ.S	L119
	BRA.S	L125
L119:
	CMPI	#233,8(A6)
	BCS.S	L127
	CMPI	#244,8(A6)
	BHI.S	L127
	CLR	D6
	BRA.S	L128
L127:
	CMPI	#294,8(A6)
	BCS.S	L129
	CMPI	#305,8(A6)
	BHI.S	L129
	MOVE	#2,D6
	BRA.S	L130
L129:
	CMPI	#308,8(A6)
	BCS.S	L131
	MOVE	#3,D6
L131:
L130:
L128:
	BRA	L117(PC)
	BRA.S	L126
L125:
	CMP	#2,D0
	BEQ.S	L126
	BRA.S	L132
L126:
	CMPI	#233,8(A6)
	BCS.S	L134
	CMPI	#244,8(A6)
	BHI.S	L134
	CLR	D6
	BRA.S	L135
L134:
	CMPI	#247,8(A6)
	BCS.S	L136
	CMPI	#258,8(A6)
	BHI.S	L136
	MOVE	#1,D6
	BRA.S	L137
L136:
	CMPI	#308,8(A6)
	BCS.S	L138
	MOVE	#3,D6
L138:
L137:
L135:
	BRA.S	L117
	BRA.S	L133
L132:
	CMP	#3,D0
	BEQ.S	L133
	BRA.S	L139
L133:
	CMPI	#247,8(A6)
	BCS.S	L141
	CMPI	#258,8(A6)
	BHI.S	L141
	MOVE	#1,D6
	BRA.S	L142
L141:
	CMPI	#261,8(A6)
	BCS.S	L143
	CMPI	#272,8(A6)
	BHI.S	L143
	MOVE	#2,D6
	BRA.S	L144
L143:
	CMPI	#244,8(A6)
	BHI.S	L145
	CLR	D6
L145:
L144:
L142:
L139:
L140:
L117:
	CMPI	#-1,D6
	BEQ.S	L146
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L146
	MOVE	D6,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
L146:
	BRA.S	L147
L114:
	MOVE	#2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	PEA	G454_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D7
	CMPI	#0,D7
	BEQ.S	L148
	MOVE	D7,-(A7)
	JSR	F369_xxxx_(PC)
	ADDQ.L	#2,A7
L148:
L147:
L113:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$112:	.EQU	#0
F371_xxxx_:/* global */
	LINK	A6,L$149
	MOVE	D7,-(A7)
	MOVE	G506_i_Act(A4),D0
	BEQ	L151(PC)
	MOVE	#2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	PEA	G452_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D7
	CMPI	#0,D7
	BEQ	L152(PC)
	CMPI	#112,D7
	BNE.S	L153
	MOVE	#83,-(A7)
	MOVE	#77,-(A7)
	MOVE	#319,-(A7)
	MOVE	#285,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-(A7)
	JSR	F391_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L154(PC)
L153:
	MOVE	D7,D0
	SUB	#112,D0
	CMP	G507_ui_Ac(A4),D0
	BHI	L155(PC)
	CMPI	#113,D7
	BNE.S	L156
	MOVE	#96,-(A7)
	MOVE	#86,-(A7)
	MOVE	#318,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L157
L156:
	CMPI	#114,D7
	BNE.S	L158
	MOVE	#108,-(A7)
	MOVE	#98,-(A7)
	MOVE	#318,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#136,G031_i_Gra(A4)
	BEQ.S	L159
	PEA	G295_ac_Se(A4)
	JSR	F277_jzzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L159
	MOVE	#136,G189_i_Gra(A4)
L159:
	BRA.S	L160
L158:
	MOVE	#120,-(A7)
	MOVE	#110,-(A7)
	MOVE	#318,-(A7)
	MOVE	#234,-(A7)
	JSR	F362_xxxx_(PC)
	ADDQ.L	#8,A7
L160:
L157:
	MOVE	D7,D0
	SUB	#113,D0
	MOVE	D0,-(A7)
	JSR	F391_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,G321_B_Sto(A4)
L155:
L154:
L152:
	BRA.S	L161
L151:
	MOVE	G509_B_Act(A4),D0
	BEQ.S	L162
	MOVE	#2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	PEA	G453_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D7
	CMPI	#0,D7
	BEQ.S	L163
	MOVE	D7,D0
	SUB	#116,D0
	MOVE	D0,D7
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L164
	MOVE	D7,-(A7)
	JSR	F389_xxxx_(PC)
	ADDQ.L	#2,A7
L164:
L163:
L162:
L161:
L150:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$149:	.EQU	#0
F372_xxxx_:/* global */
	LINK	A6,L$165
	MOVE	G306_i_Par(A4),-2(A6)
	MOVE	G307_i_Par(A4),-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	CMPI	#0,-2(A6)
	BCS.S	L167
	MOVE	-2(A6),D0
	MOVE	G273_i_Cur(A4),D1
	CMP	D1,D0
	BCC.S	L167
	CMPI	#0,-4(A6)
	BCS.S	L167
	MOVE	-4(A6),D0
	MOVE	G274_i_Cur(A4),D1
	CMP	D1,D0
	BCC.S	L167
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F275_aszz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,G321_B_Sto(A4)
L167:
L166:
	UNLK	A6
	RTS
L$165:	.EQU	#-4
F373_xxxx_:/* global */
	LINK	A6,L$168
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L170
	BRA	L169(PC)
L170:
	MOVE	G306_i_Par(A4),D6
	MOVE	G307_i_Par(A4),D5
	CMPI	#2,D7
	BCS.S	L171
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,D6
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D5,D0
	ADD	D1,D0
	MOVE	D0,D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L172
	MOVE	#4,-(A7)
	MOVE	D4,-(A7)
	JSR	F264_avzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L172
	MOVE	D7,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L172
	BRA.S	L169
L172:
L171:
	MOVE	D7,D4
	ASL.L	#1,D4
	LEA	G292_aT_Pi(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L173
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	#1,G416_i_Use(A4)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L173:
	MOVE	#1,G321_B_Sto(A4)
L169:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$168:	.EQU	#0
F374_xxxx_:/* global */
	LINK	A6,L$174
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L176
	BRA	L175(PC)
L176:
	MOVE	G306_i_Par(A4),D6
	MOVE	G307_i_Par(A4),D5
	CMPI	#4,D7
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-6(A6)
	BEQ.S	L177
	MOVE	#2,D7
L177:
	CMPI	#1,D7
	BLS.S	L178
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,D6
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D5,D0
	ADD	D1,D0
	MOVE	D0,D5
L178:
	MOVE	G308_i_Par(A4),D0
	ADD	D7,D0
	AND	#3,D0
	MOVE	D0,-4(A6)
	JSR	F298_aqzz_(PC)
	MOVE	D0,D4
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	-4(A6),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	-6(A6),D0
	BEQ.S	L179
	MOVE	G287_B_Fac(A4),D0
	BEQ.S	L179
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#147,D0
	BNE.S	L179
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#1,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-16(A6)
	MOVE.B	#13,-12(A6)
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	D0,-11(A6)
	MOVE	D6,D0
	MOVE.B	D0,-10(A6)
	MOVE	D5,D0
	MOVE.B	D0,-9(A6)
	MOVE	-4(A6),D0
	MOVE.B	D0,-8(A6)
	MOVE.B	#2,-7(A6)
	PEA	-16(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L179:
	MOVE	#1,G321_B_Sto(A4)
L175:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$174:	.EQU	#-16
F375_xxxx_:/* global */
	LINK	A6,L$180
	MOVE	D7,-(A7)
	CMPI	#47,10(A6)
	BLT.S	L183
	CMPI	#102,10(A6)
	BLE.S	L182
L183:
	MOVE	#0,D0
	BRA.S	L181
L182:
	CMPI	#111,8(A6)
	BGT.S	L184
	CMPI	#17,G285_i_Squ(A4)
	BNE.S	L185
	CMPI	#64,8(A6)
	BGE.S	L186
	MOVE	#0,D0
	BRA.S	L181
L186:
	BRA.S	L187
L185:
	CMPI	#32,8(A6)
	BGE.S	L188
	MOVE	#0,D0
	BRA.S	L181
L188:
L187:
	CLR	-(A7)
	JSR	F329_hzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L181
L184:
	CMPI	#17,G285_i_Squ(A4)
	BNE.S	L189
	CMPI	#163,8(A6)
	BLE.S	L190
	MOVE	#0,D0
	BRA.S	L181
L190:
	BRA.S	L191
L189:
	CMPI	#191,8(A6)
	BLE.S	L192
	MOVE	#0,D0
	BRA.S	L181
L192:
L191:
	MOVE	#1,-(A7)
	JSR	F329_hzzz_(PC)
	ADDQ.L	#2,A7
L181:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$180:	.EQU	#0
F376_xxxx_:/* global */
	LINK	A6,L$193
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	D7,D0
	MOVE.B	1(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SLE	D0
	TST.B	D0
	BEQ.S	L197
	MOVE	D7,D0
	MOVE.B	(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SGE	D0
	TST.B	D0
L197:
	TST.B	D0
	BEQ.S	L196
	MOVE	D6,D0
	MOVE.B	3(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SLE	D0
	TST.B	D0
L196:
	TST.B	D0
	BEQ.S	L195
	MOVE	D6,D0
	MOVE.B	2(A3),D1
	AND	#255,D1
	CMP	D1,D0
	SGE	D0
	TST.B	D0
L195:
	AND	#1,D0
L194:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$193:	.EQU	#0
F377_xxxx_:/* global */
	LINK	A6,L$198
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CMPI	#17,G285_i_Squ(A4)
	BNE	L200(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L201
	BRA	L199(PC)
L201:
	MOVE	G306_i_Par(A4),-8(A6)
	MOVE	G307_i_Par(A4),-10(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-10(A6),D0
	ADD	D1,D0
	MOVE	D0,-10(A6)
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L202
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L203
	MOVE	D6,D0
	SUB	#33,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	PEA	G291_aauc_+20(A4)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L203
	MOVE	#1,G321_B_Sto(A4)
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#1,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#1,D0
	MOVE.L	D0,-(A7)
	MOVE	#2,-(A7)
	CLR	-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	#10,-(A7)
	JSR	F268_fzzz_(PC)
	ADDA	#14,A7
	BRA	L199(PC)
L203:
	BRA.S	L204
L202:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F375_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L205
	BRA	L199(PC)
L205:
L204:
L200:
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L206
	CLR	D5
	BRA.S	L207
L208:
	MOVE	D6,D0
	SUB	#33,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G291_aauc_(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L211
	CMPI	#5,D5
	BNE.S	L212
	MOVE	G286_B_Fac(A4),D0
	BNE.S	L213
	JSR	F372_xxxx_(PC)
L213:
	BRA.S	L214
L212:
	MOVE	D5,-(A7)
	JSR	F373_xxxx_(PC)
	ADDQ.L	#2,A7
L214:
	BRA	L199(PC)
L211:
L209:
	ADDQ	#1,D5
L207:
	CMPI	#6,D5
	BCS.S	L208
L210:
	BRA	L199(PC)
L206:
	MOVE	G414_T_Lea(A4),-2(A6)
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CMPI	#0,G285_i_Squ(A4)
	BNE	L215(PC)
	CLR	D5
	BRA.S	L216
L217:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G462_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L220
	MOVE	D5,-(A7)
	JSR	F374_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L199(PC)
L220:
L218:
	ADDQ	#1,D5
L216:
	CMPI	#2,D5
	BCS.S	L217
L219:
	MOVE	D6,D0
	SUB	#33,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	PEA	G291_aauc_+20(A4)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ	L221(PC)
	MOVE	G286_B_Fac(A4),D0
	BEQ.S	L222
	MOVE	#4,-(A7)
	JSR	F374_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L223(PC)
L222:
	MOVE	G288_B_Fac(A4),D0
	BEQ	L224(PC)
	MOVE	-2(A6),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-4(A6)
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-6(A6)
	CMPI	#8,-4(A6)
	BCS.S	L225
	CMPI	#9,-4(A6)
	BHI.S	L225
	MOVE	#3,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A3)
	OR	D3,2(A3)
	BRA.S	L226
L225:
	CMPI	#195,-4(A6)
	BNE.S	L227
	MOVE	#15,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	AND	#127,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-32513,2(A0)
	OR	D3,2(A0)
	BRA.S	L228
L227:
	BRA.S	L20T377_019
L228:
L226:
	JSR	F296_aizz_(PC)
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	SUB	-6(A6),D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
L224:
L20T377_019:
	JSR	F372_xxxx_(PC)
L223:
L221:
	BRA.S	L199
L215:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F375_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L229
	BRA.S	L199
L229:
	CLR	D5
	BRA.S	L230
L231:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G462_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F376_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L234
	MOVE	D5,-(A7)
	JSR	F374_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA.S	L199
L234:
L232:
	ADDQ	#1,D5
L230:
	CMPI	#4,D5
	BCS.S	L231
L233:
L199:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$198:	.EQU	#-10
F378_xxxx_:/* global */
	LINK	A6,L$235
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CMPI	#-1,G411_i_Lea(A4)
	SEQ	D4
	AND	#1,D4
	MOVE	G424_i_Pan(A4),D0
L237:
	CMP	#4,D0
	BEQ.S	L238
	BRA.S	L240
L238:
	MOVE	D4,D0
	BEQ.S	L242
	BRA.S	L239
L242:
	MOVE	#2,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	G456_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	CMPI	#0,D5
	BEQ.S	L243
	MOVE	D5,D0
	SUB	#20,D0
	MOVE	D0,-(A7)
	JSR	F302_mzzz_(PC)
	ADDQ.L	#2,A7
L243:
	BRA.S	L239
	BRA.S	L241
L240:
	CMP	#5,D0
	BEQ.S	L241
	BRA.S	L244
L241:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L246
	BRA.S	L239
L246:
	MOVE	#2,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	G457_as_Gr(A4)
	JSR	F358_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	CMPI	#0,D5
	BEQ.S	L247
	MOVE	D5,-(A7)
	JSR	F282_xzzz_(PC)
	ADDQ.L	#2,A7
L247:
L244:
L245:
L239:
L236:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$235:	.EQU	#0
F379_jzzz_:/* global */
	LINK	A6,L$248
	MOVE	#1904,-(A7)
	CLR	-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
s!:
	DATA 57 41 4B 45 20 55 50 00 
CODE SEG "user"
	PEA	s!(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#69,-(A7)
	MOVE	#93,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L249:
	UNLK	A6
	RTS
L$248:	.EQU	#0
F380_xzzz_:/* global */
	LINK	A6,L$250
BSS SEG "bss"
24G481_ps_:
	.WORD	#4
25G482_ps_:
	.WORD	#4
26G483_ps_:
	.WORD	#4
27G484_ps_:
	.WORD	#4
CODE SEG "user"
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	#1,G435_B_Com(A4)
	MOVE	G434_i_Com(A4),D0
	ADDQ	#1,D0
	MOVE	D0,D7
	CMPI	#4,D0
	BLE.S	L252
	CLR	D7
L252:
	MOVE	D7,D0
	CMP	G433_i_Com(A4),D0
	BNE.S	L253
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
	BRA	L251(PC)
L253:
	MOVE	G433_i_Com(A4),D6
	MULS	#6,D6
	LEA	G432_as_Co+4(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	CMPI	#3,D6
	BLT.S	L254
	CMPI	#6,D6
	BGT.S	L254
	MOVE	G310_i_Dis(A4),D0
	BNE.S	L255
	MOVE	G311_i_Pro(A4),D0
	BEQ.S	L254
	MOVE	G312_i_Las(A4),D0
	MOVE	G308_i_Par(A4),D1
	ADD	D6,D1
	SUBQ	#3,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L254
L255:
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
	BRA	L251(PC)
L254:
	MOVE	G433_i_Com(A4),D5
	MULS	#6,D5
	LEA	G432_as_Co(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	G433_i_Com(A4),D4
	MULS	#6,D4
	LEA	G432_as_Co+2(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	ADDQ	#1,G433_i_Com(A4)
	MOVE	G433_i_Com(A4),D0
	CMPI	#4,D0
	BLE.S	L256
	CLR	G433_i_Com(A4)
L256:
	CLR	G435_B_Com(A4)
	JSR	F360_xxxx_(PC)
	CMPI	#2,D6
	BEQ.S	L258
	CMPI	#1,D6
	BNE.S	L257
L258:
	MOVE	D6,-(A7)
	JSR	F365_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L251(PC)
L257:
	CMPI	#3,D6
	BLT.S	L259
	CMPI	#6,D6
	BGT.S	L259
	MOVE	D6,-(A7)
	JSR	F366_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L251(PC)
L259:
	CMPI	#12,D6
	BLT.S	L260
	CMPI	#15,D6
	BGT.S	L260
	MOVE	D6,D0
	SUB	#12,D0
	MOVE	D0,D7
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L261
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L261
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F367_xxxx_(PC)
	ADDQ.L	#6,A7
L261:
	BRA	L251(PC)
L260:
	CMPI	#125,D6
	BLT.S	L262
	CMPI	#128,D6
	BGT.S	L262
	MOVE	D6,D0
	SUB	#125,D0
	MOVE	D0,-(A7)
	JSR	F070_aajz_(PC)
	ADDQ.L	#2,A7
	BRA	L251(PC)
L262:
	CMPI	#28,D6
	BLT.S	L263
	CMPI	#66,D6
	BGE.S	L263
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L264
	MOVE	D6,D0
	SUB	#20,D0
	MOVE	D0,-(A7)
	JSR	F302_mzzz_(PC)
	ADDQ.L	#2,A7
L264:
	BRA	L251(PC)
L263:
	CMPI	#7,D6
	BLT.S	L265
	CMPI	#11,D6
	BGT.S	L265
	MOVE	D6,D0
	SUBQ	#7,D0
	MOVE	D0,D7
	CMPI	#4,D0
	BEQ.S	L267
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L266
L267:
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L266
	MOVE	D7,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L266:
	BRA	L251(PC)
L265:
	CMPI	#140,D6
	BNE.S	L268
	PEA	F433_AA39_(PC)
	JSR	F464_AA07_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2463,D0
	BEQ.S	L268
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	BRA	L251(PC)
L268:
	CMPI	#83,D6
	BNE.S	L269
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L270
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L270:
	BRA	L251(PC)
L269:
	CMPI	#100,D6
	BNE.S	L271
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L272
	CMPI	#-1,G514_i_Mag(A4)
	BEQ.S	L272
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F370_xxxx_(PC)
	ADDQ.L	#4,A7
L272:
	BRA	L251(PC)
L271:
	CMPI	#111,D6
	BNE.S	L273
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L274
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F371_xxxx_(PC)
	ADDQ.L	#4,A7
L274:
	BRA	L251(PC)
L273:
	CMPI	#70,D6
	BNE.S	L275
	JSR	F349_dzzz_(PC)
	BRA	L251(PC)
L275:
	CMPI	#71,D6
	BNE.S	L276
	JSR	F352_aszz_(PC)
	BRA	L251(PC)
L276:
	CMPI	#80,D6
	BNE.S	L277
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F377_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L251(PC)
L277:
	CMPI	#81,D6
	BNE.S	L278
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F378_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L251(PC)
L278:
	CMPI	#145,D6
	BNE.S	L279
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L280
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L281
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L281:
	JSR	F456_vzzz_(PC)
	MOVE	#1,G300_B_Par(A4)
	JSR	F379_jzzz_(PC)
	MOVE	#2,-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	CLR	G318_i_Wai(A4)
	LEA	G450_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	LEA	G460_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
L280:
	BRA	L251(PC)
L279:
	CMPI	#146,D6
	BNE.S	L282
	JSR	F314_gzzz_(PC)
	BRA	L251(PC)
L282:
	CMPI	#140,D6
	BNE.S	L283
	CMPI	#0,G305_ui_Pa(A4)
	BLS.S	L284
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L284
	JSR	F433_AA39_(PC)
L284:
	BRA	L251(PC)
L283:
	CMPI	#147,D6
	BNE.S	L285
	CLR	G301_B_Gam(A4)
	JSR	F456_vzzz_(PC)
	MOVE	#1904,-(A7)
	CLR	-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 47 41 4D 45 20 46 52 4F 5A 45 4E 00 
CODE SEG "user"
	PEA	s!+8(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#69,-(A7)
	MOVE	#81,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	MOVE	#2,-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	G441_ps_Pr(A4),26G483_ps_(A4)
	MOVE.L	G442_ps_Se(A4),27G484_ps_(A4)
	MOVE.L	G443_ps_Pr(A4),24G481_ps_(A4)
	MOVE.L	G444_ps_Se(A4),25G482_ps_(A4)
	LEA	G451_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	LEA	G461_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	BRA.S	L251
L285:
	CMPI	#148,D6
	BNE.S	L286
	MOVE	#1,G301_B_Gam(A4)
	JSR	F457_AA08_(PC)
	MOVE.L	26G483_ps_(A4),G441_ps_Pr(A4)
	MOVE.L	27G484_ps_(A4),G442_ps_Se(A4)
	MOVE.L	24G481_ps_(A4),G443_ps_Pr(A4)
	MOVE.L	25G482_ps_(A4),G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	BRA.S	L251
L286:
	CMPI	#200,D6
	BNE.S	L287
	MOVE	#1,G298_B_New(A4)
	BRA.S	L251
L287:
	CMPI	#201,D6
	BNE.S	L288
	CLR	G298_B_New(A4)
	BRA.S	L251
L288:
	CMPI	#202,D6
	BNE.S	L289
	JSR	F442_AA08_(PC)
	BRA.S	L251
L289:
	CMPI	#210,D6
	BLT.S	L290
	CMPI	#213,D6
	BGT.S	L290
	MOVE	D6,D0
	SUB	#209,D0
	MOVE	D0,G335_i_Sel(A4)
	BRA.S	L251
L290:
	CMPI	#215,D6
	BNE.S	L291
	MOVE	#1,G523_B_Res(A4)
L291:
L251:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$250:	.EQU	#0
