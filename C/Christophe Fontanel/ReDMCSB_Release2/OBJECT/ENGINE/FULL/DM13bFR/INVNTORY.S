BSS SEG "bss"
G420_B_Mou:/* global */
	.WORD	#2
G421_i_Obj:/* global */
	.WORD	#2
G422_i_Obj:/* global */
	.WORD	#2
G423_i_Inv:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#0,G424_i_Pan(A4)
BSS SEG "bss"
G424_i_Pan:/* global */
	.WORD	#2
G425_aT_Ch:/* global */
	.WORD	#16
CODE SEG "init!"
	MOVE	#-1,G426_T_Ope(A4)
BSS SEG "bss"
G426_T_Ope:/* global */
	.WORD	#2
G427_ac_Co:/* global */
	.WORD	#68
CODE SEG "init!"
	LEA	G428_apc_S(A4),A1
DATA SEG "s!"
s!:
	DATA 4E 45 4F 50 48 59 54 45 00 00 
CODE SEG "init!"
	LEA	s!(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4E 4F 56 49 43 45 00 00 
CODE SEG "init!"
	LEA	s!+10(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 50 50 52 45 4E 54 49 00 00 
CODE SEG "init!"
	LEA	s!+18(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 43 4F 4D 50 41 47 4E 4F 4E 00 
CODE SEG "init!"
	LEA	s!+28(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 52 54 49 53 41 4E 00 
CODE SEG "init!"
	LEA	s!+38(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 50 41 54 52 4F 4E 00 00 
CODE SEG "init!"
	LEA	s!+46(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 44 45 50 54 45 00 00 
CODE SEG "init!"
	LEA	s!+54(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 45 58 50 45 52 54 00 00 
CODE SEG "init!"
	LEA	s!+62(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4D 41 49 54 52 45 20 27 00 00 
CODE SEG "init!"
	LEA	s!+70(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4D 41 49 54 52 45 20 61 00 00 
CODE SEG "init!"
	LEA	s!+80(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4D 41 49 54 52 45 20 62 00 00 
CODE SEG "init!"
	LEA	s!+90(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4D 41 49 54 52 45 20 63 00 00 
CODE SEG "init!"
	LEA	s!+100(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4D 41 49 54 52 45 20 64 00 00 
CODE SEG "init!"
	LEA	s!+110(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4D 41 49 54 52 45 20 65 00 00 
CODE SEG "init!"
	LEA	s!+120(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 53 55 52 2D 4D 41 49 54 52 45 00 00 
CODE SEG "init!"
	LEA	s!+130(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
G428_apc_S:/* global */
	.WORD	#60
CODE SEG "init!"
	LEA	G429_apc_G(A4),A1
	LEA	G293_ai_Fu(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,(A1)+
	LEA	G031_i_Gra(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,(A1)+
	LEA	G418_l_Las(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,(A1)+
BSS SEG "bss"
G429_apc_G:/* global */
	.WORD	#12
CODE SEG "player"
F332_xxxx_:/* global */
	LINK	A6,L$0
	CLR	-(A7)
	MOVE.L	#128,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-12(A6)
	MOVE	10(A6),D0
	MOVE	D0,-8(A6)
	ADD	#15,D0
	MOVE	D0,-6(A6)
	MOVE	12(A6),D0
	MOVE	D0,-4(A6)
	ADD	#15,D0
	MOVE	D0,-2(A6)
	MOVE.L	-12(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#8,-(A7)
	PEA	-8(A6)
	MOVE.L	-12(A6),-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE.L	#128,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#-12
F333_xxxx_:/* global */
	LINK	A6,L$2
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	10(A6),A3
	MOVE	8(A6),G426_T_Ope(A4)
	MOVE	14(A6),D0
	BNE.S	L4
	MOVE	#145,-(A7)
	MOVE	#9,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
L4:
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#25,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	CLR	D7
	MOVE	2(A3),D6
	BRA.S	L5
L6:
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ADD	#38,D0
	MOVE	D0,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	G425_aT_Ch(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L5:
	CMPI	#-2,D6
	BNE.S	L6
L7:
	BRA.S	L8
L9:
	MOVE	#-1,-(A7)
	MOVE	D7,D0
	ADD	#38,D0
	MOVE	D0,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	G425_aT_Ch(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L8:
	CMPI	#8,D7
	BLT.S	L9
L10:
L3:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$2:	.EQU	#-40
F334_akzz_:/* global */
	LINK	A6,L$11
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,D4
	CMPI	#-1,G426_T_Ope(A4)
	BNE.S	L13
	BRA.S	L12
L13:
	MOVE	G426_T_Ope(A4),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#-1,G426_T_Ope(A4)
	MOVE	#-2,2(A3)
	CLR	D5
	BRA.S	L14
L15:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L18
	MOVE	D4,D0
	BEQ.S	L19
	CLR	D4
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#-2,(A2)
	MOVE	D7,D0
	MOVE	D0,D6
	MOVE	D0,2(A3)
	BRA.S	L20
L19:
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D6
L20:
L18:
L16:
	ADDQ	#1,D5
L14:
	CMPI	#8,D5
	BLT.S	L15
L17:
L12:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$11:	.EQU	#0
F335_xxxx_:/* global */
	LINK	A6,L$21
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#12,D0
	BNE.S	L23
	ADDQ.L	#1,8(A6)
	MOVE	#108,G421_i_Obj(A4)
	MOVE	#59,G422_i_Obj(A4)
L23:
	MOVE.L	8(A6),A0
	MOVE.B	(A0),D0
	BEQ.S	L24
	MOVE.L	8(A6),-(A7)
	PEA	-128(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	LEA	-128(A6),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L25
L26:
	MOVE.L	A3,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	CMPI	#18,D0
	BLE.S	L28
	LEA	17(A3),A0
	MOVE.L	A0,A2
	BRA.S	L29
L30:
	SUBQ.L	#1,A2
L29:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#32,D0
	BNE.S	L30
L31:
	CLR.B	(A2)
	MOVE	#1,D7
L28:
	MOVE.L	A3,-(A7)
	MOVE	#13,-(A7)
	MOVE	G422_i_Obj(A4),-(A7)
	MOVE	G421_i_Obj(A4),-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	ADDQ	#7,G422_i_Obj(A4)
	MOVE	D7,D0
	BEQ.S	L32
	CLR	D7
	ADDQ.L	#1,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A3
	BRA.S	L33
L32:
	CLR.B	(A3)
L33:
L25:
	MOVE.B	(A3),D0
	BNE.S	L26
L27:
L24:
L22:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$21:	.EQU	#-128
F336_xxxx_:/* global */
	LINK	A6,L$34
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE.L	12(A6),A3
	MOVE.L	16(A6),A2
	CLR	-2(A6)
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE	#1,D0
	MOVE	D0,D4
	BRA.S	L36
L37:
	MOVE	D4,D0
	AND	D7,D0
	AND	D6,D0
	BEQ.S	L40
	ADDQ	#1,-2(A6)
L40:
L38:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D0
	ASL	#1,D0
	MOVE	D0,D4
L36:
	CMPI	#16,D5
	BCS.S	L37
L39:
	CMPI	#0,-2(A6)
	BNE.S	L41
	CLR.B	(A2)
	BRA	L35(PC)
L41:
	MOVE.L	20(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE	#1,D0
	MOVE	D0,D4
	BRA.S	L42
L43:
	MOVE	D4,D0
	AND	D7,D0
	AND	D6,D0
	BEQ.S	L46
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	-2(A6),D0
	SUBQ	#1,-2(A6)
	CMPI	#2,D0
	BLS.S	L47
DATA SEG "s!"
	DATA 2C 20 00 00 
CODE SEG "player"
	PEA	s!+142(A4)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	BRA.S	L48
L47:
	CMPI	#1,-2(A6)
	BNE.S	L49
DATA SEG "s!"
	DATA 20 45 54 20 00 00 
CODE SEG "player"
	PEA	s!+146(A4)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
L49:
L48:
L46:
L44:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D0
	ASL	#1,D0
	MOVE	D0,D4
L42:
	CMPI	#16,D5
	BCS.S	L43
L45:
	MOVE.L	24(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
L35:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$34:	.EQU	#-2
F337_akzz_:/* global */
	LINK	A6,L$50
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	CMPI	#0,D0
	BNE.S	L52
	CLR	G304_i_Dun(A4)
	BRA	L53(PC)
L52:
	MOVE	#4,D5
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,-8(A6)
	LEA	-26(A6),A0
	MOVE.L	A0,A3
	BRA	L54(PC)
L55:
	MOVE	#2,D4
	BRA.S	L57
L58:
	MOVE	D4,D0
	MOVE.L	-8(A6),A0
	ASL.L	#1,D0
	LEA	212(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMPI	#4,D0
	BLT.S	L60
	MOVE	D4,D0
	MOVE.L	-8(A6),A0
	ASL.L	#1,D0
	LEA	212(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMPI	#7,D0
	BGT.S	L60
	MOVE	-10(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,(A3)
	BRA.S	L61
L60:
	CLR	(A3)
L61:
	ADDQ.L	#2,A3
L57:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L58
L59:
	ADDI.L	#800,-8(A6)
L54:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE	L55(PC)
L56:
	LEA	-26(A6),A0
	MOVE.L	A0,A3
	CLR	D4
	BRA.S	L62
L63:
	MOVE	#7,D5
	SUB	D4,D5
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	-24(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	BRA.S	L66
L67:
	MOVE	(A2),D0
	CMP	(A3),D0
	BLE.S	L69
	MOVE	(A2),-10(A6)
	MOVE	(A3),(A2)
	MOVE	-10(A6),(A3)
L69:
	ADDQ.L	#2,A2
L66:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L67
L68:
	ADDQ.L	#2,A3
L64:
	ADDQ	#1,D4
L62:
	CMPI	#4,D4
	BNE.S	L63
L65:
	MOVE	#6,D6
	MOVE	#5,D4
	CLR	D7
	LEA	-26(A6),A0
	MOVE.L	A0,A3
	BRA.S	L70
L71:
	MOVE	(A3),D0
	BEQ.S	L73
	MOVE	(A3),D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL	D6,D0
	LSR	#6,D0
	ADD	D0,D7
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
L73:
	ADDQ.L	#2,A3
L70:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L71
L72:
	ADD	G407_s_Par+3200(A4),D7
	LEA	G040_ai_Gr(A4),A0
	MOVE.L	A0,A3
	CMPI	#0,D7
	BLE.S	L74
	CLR	D4
	BRA.S	L75
L76:
	ADDQ	#1,D4
L75:
	MOVE	(A3)+,D0
	CMP	D7,D0
	BGT.S	L76
L77:
	BRA.S	L78
L74:
	MOVE	#5,D4
L78:
	MOVE	D4,G304_i_Dun(A4)
L53:
	MOVE	#1,G342_B_Ref(A4)
L51:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$50:	.EQU	#-26
F338_atzz_:/* global */
	LINK	A6,L$79
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D5
	MOVE	G305_ui_Pa(A4),D7
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L81
	SUBQ	#1,D7
L81:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	BRA	L82(PC)
L83:
	MOVE	#2,D6
	BRA	L85(PC)
L86:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#4,D4
	BLT.S	L88
	CMPI	#7,D4
	BGT.S	L88
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	BEQ.S	L89
	MOVE	2(A2),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-15361,2(A2)
	OR	D3,2(A2)
	MOVE	D0,D0
	CMPI	#0,D0
	BNE.S	L90
	MOVE	#0,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ANDI	#-129,2(A2)
	OR	D3,2(A2)
L90:
	MOVE	#1,D5
L89:
L88:
L85:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE	L86(PC)
L87:
	ADDA	#800,A3
L82:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE	L83(PC)
L84:
	CMPI	#136,G031_i_Gra(A4)
	BEQ.S	L91
	MOVE	#6,-(A7)
	PEA	G368_apc_C(A4)
	PEA	G429_apc_G(A4)
	LEA	G295_ac_Se+-94(A4),A0
	MOVE.L	A0,D0
	ADD.L	#94,D0
	MOVE.L	D0,-(A7)
	MOVE	#21,-(A7)
	PEA	F489_ayzz_(PC)
	PEA	F331_auzz_(PC)
	JSR	F137_pzzz_(PC)
	ADDA	#24,A7
	MOVE	#136,G031_i_Gra(A4)
L91:
	MOVE	D5,D0
	BEQ.S	L92
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
L92:
L80:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$79:	.EQU	#0
F339_xxxx_:/* global */
	LINK	A6,L$93
	MOVE	#8,-(A7)
	MOVE	#8,-(A7)
	PEA	G033_s_Gra(A4)
	MOVE	8(A6),D0
	BEQ.S	L95
	MOVE	#19,D0
	BRA.S	L96
L95:
	MOVE	#18,D0
L96:
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
L94:
	UNLK	A6
	RTS
L$93:	.EQU	#0
F340_xxxx_:/* global */
	LINK	A6,L$97
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	10(A6),A3
	MOVE.L	A3,A2
	BRA.S	L99
L100:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#65,D0
	BLT.S	L102
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#90,D0
	BGT.S	L102
	SUBI.B	#64,(A2)+
	BRA.S	L99
L102:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#123,D0
	BLT.S	L103
	SUBI.B	#96,(A2)+
	BRA.S	L99
L103:
	ADDQ.L	#1,A2
L99:
	MOVE.B	(A2),D0
	BNE.S	L100
L101:
	MOVE.L	A3,-(A7)
	MOVE	#15,-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	D1,-10(A6)
	MOVE	#6,D1
	MULS	-10(A6),D1
	ASR	#1,D1
	MOVE	#162,D0
	SUB	D1,D0
	MOVE	D0,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L98:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$97:	.EQU	#-10
F341_xxxx_:/* global */
	LINK	A6,L$104
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE	#-32766,-(A7)
	MOVE.L	8(A6),A0
	MOVE	2(A0),D0
	AND	#1023,D0
	MOVE	D0,-(A7)
	PEA	-260(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	LEA	-260(A6),A0
	MOVE.L	A0,A2
	BRA.S	L106
L107:
	ADDQ.L	#1,A2
L106:
	MOVE.B	(A2),D0
	BEQ.S	L109
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L107
L109:
L108:
	CLR.B	(A2)
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#23,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#1,D7
	ADDQ.L	#1,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A3
	BRA.S	L110
L111:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L113
	ADDQ	#1,D7
L113:
	ADDQ.L	#1,A3
L110:
	MOVE.B	(A3),D0
	BNE.S	L111
L112:
	MOVE.L	A3,D0
	SUBQ.L	#1,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#10,D0
	BEQ.S	L114
	ADDQ	#1,D7
	BRA.S	L115
L114:
	MOVE.L	A3,D0
	SUBQ.L	#2,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L116
	SUBQ	#1,D7
L116:
L115:
	MOVE	#92,D0
	MOVE	#7,D1
	MULS	D7,D1
	EXT.L	D1
	DIVS	#2,D1
	SUB	D1,D0
	MOVE	D0,D7
	PEA	-260(A6)
	MOVE	D7,-(A7)
	JSR	F340_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	A2,A3
	BRA.S	L117
L118:
	ADDQ	#7,D7
	BRA.S	L120
L121:
	ADDQ.L	#1,A2
L120:
	MOVE.B	(A2),D0
	BEQ.S	L123
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L121
L123:
L122:
	MOVE.B	(A2),D0
	BNE.S	L124
	CLR.B	1(A2)
L124:
	CLR.B	(A2)+
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F340_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	A2,A3
L117:
	MOVE.B	(A3),D0
	BNE.S	L118
L119:
L105:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$104:	.EQU	#-260
F342_xxxx_:/* global */
	LINK	A6,L$125
DATA SEG "s!"
	DATA 29 00 28 00 
CODE SEG "init!"
	LEA	11G430_apc(A4),A1
DATA SEG "s!"
	DATA 41 55 20 4E 4F 52 44 00 
CODE SEG "init!"
	LEA	s!+156(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 20 4C 27 45 53 54 00 
CODE SEG "init!"
	LEA	s!+164(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 55 20 53 55 44 00 00 
CODE SEG "init!"
	LEA	s!+172(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 20 4C 27 4F 55 45 53 54 00 
CODE SEG "init!"
	LEA	s!+180(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
11G430_apc:
	.WORD	#16
CODE SEG "player"
	MOVEM.L	A3-A2/D7-D4,-(A7)
	LEA	s!+152(A4),A0
	MOVE.L	A0,-68(A6)
	LEA	s!+154(A4),A0
	MOVE.L	A0,-72(A6)
	JSR	F334_akzz_(PC)
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
DATA SEG "s!"
	DATA 0C 00 
CODE SEG "player"
	PEA	s!+190(A4)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	8(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-74(A6)
	CMPI	#7,-74(A6)
	BNE.S	L127
	MOVE.L	A2,-(A7)
	JSR	F341_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L128(PC)
L127:
	CMPI	#9,-74(A6)
	BNE.S	L129
	MOVE	10(A6),-(A7)
	MOVE.L	A2,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F333_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L130(PC)
L129:
	MOVE	8(A6),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#20,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G034_s_Gra(A4)
	MOVE	#29,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	CMPI	#147,D6
	BNE.S	L131
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G352_apc_O(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "player"
	PEA	s!+192(A4)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	PEA	-114(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	LEA	-114(A6),A0
	MOVE.L	A0,A3
	BRA.S	L132
L131:
	CMPI	#8,-74(A6)
	BNE.S	L133
	CMPI	#163,D6
	BEQ.S	L133
	MOVE	#2,-(A7)
	MOVE	G423_i_Inv(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	CMPI	#1,D0
	BLS.S	L133
	MOVE	#95,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#255,D1
	AND.L	#65535,D1
	DIVU	#40,D1
	ADD	D1,D0
	MOVE.B	D0,-114(A6)
	MOVE.B	#32,-113(A6)
	CLR.B	-112(A6)
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G352_apc_O(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	LEA	-114(A6),A0
	MOVE.L	A0,A3
	BRA.S	L134
L133:
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G352_apc_O(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
L134:
L132:
	MOVE.L	A3,-(A7)
	MOVE	#13,-(A7)
	MOVE	#68,-(A7)
	MOVE	#134,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	#59,-(A7)
	MOVE	#111,-(A7)
	MOVE	D6,-(A7)
	JSR	F332_xxxx_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 43 4F 4D 45 53 54 49 42 4C 45 00 00 
CODE SEG "player"
	LEA	s!+194(A4),A0
	MOVE.L	A0,-64(A6)
DATA SEG "s!"
	DATA 45 4D 50 4F 49 53 4F 4E 4E 45 00 00 
CODE SEG "player"
	LEA	s!+206(A4),A0
	MOVE.L	A0,-60(A6)
DATA SEG "s!"
	DATA 42 52 49 53 45 00 
CODE SEG "player"
	LEA	s!+218(A4),A0
	MOVE.L	A0,-56(A6)
DATA SEG "s!"
	DATA 4D 41 55 44 49 54 00 00 
CODE SEG "player"
	LEA	s!+224(A4),A0
	MOVE.L	A0,-52(A6)
	MOVE	#87,G422_i_Obj(A4)
	MOVE	-74(A6),D0
L135:
	CMP	#5,D0
	BEQ.S	L136
	BRA.S	L138
L136:
	MOVE	#14,D5
	MOVE.L	A2,D4
	MOVE.L	D4,A0
	MOVE	2(A0),D4
	AND	#256,D4
	LSR	#8,D4
	ASL	#3,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#512,D1
	LSR	#1,D1
	LSR	#8,D1
	ASL	#1,D1
	OR	D1,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#16384,D1
	LSR	#6,D1
	LSR	#8,D1
	ASL	#2,D1
	OR	D1,D4
	CMPI	#4,D6
	BCS.S	L140
	CMPI	#7,D6
	BHI.S	L140
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#0,D0
	BNE.S	L140
DATA SEG "s!"
	DATA 28 43 4F 4E 53 55 4D 45 29 00 
CODE SEG "player"
	PEA	s!+232(A4)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
L140:
	BRA	L137(PC)
	BRA.S	L139
L138:
	CMP	#6,D0
	BEQ.S	L139
	BRA.S	L141
L139:
	MOVE	#12,D5
	MOVE.L	A2,D4
	MOVE.L	D4,A0
	MOVE	2(A0),D4
	AND	#256,D4
	LSR	#8,D4
	ASL	#3,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#8192,D1
	LSR	#5,D1
	LSR	#8,D1
	ASL	#2,D1
	OR	D1,D4
	BRA	L137(PC)
	BRA.S	L142
L141:
	CMP	#8,D0
	BEQ.S	L142
	BRA.S	L143
L142:
	MOVE	#1,D5
	MOVE	#2,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#32512,D1
	LSR	#8,D1
	ADD	D1,D4
	MULS	#6,D4
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	BRA	L137(PC)
	BRA.S	L144
L143:
	CMP	#10,D0
	BEQ.S	L144
	BRA	L145(PC)
L144:
	CMPI	#8,D6
	BCS.S	L147
	CMPI	#9,D6
	BHI.S	L147
	CLR	D5
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
L148:
	CMP	#0,D0
	BEQ.S	L149
	BRA.S	L151
L149:
DATA SEG "s!"
	DATA 28 56 49 44 45 29 00 00 
CODE SEG "player"
	LEA	s!+242(A4),A0
	MOVE.L	A0,A3
	BRA.S	L150
	BRA.S	L152
L151:
	CMP	#1,D0
	BEQ.S	L152
	BRA.S	L153
L152:
DATA SEG "s!"
	DATA 28 50 52 45 53 51 55 45 20 56 49 44 45 29 00 00 
CODE SEG "player"
	LEA	s!+250(A4),A0
	MOVE.L	A0,A3
	BRA.S	L150
	BRA.S	L154
L153:
	CMP	#2,D0
	BEQ.S	L154
	BRA.S	L155
L154:
DATA SEG "s!"
	DATA 28 50 52 45 53 51 55 45 20 50 4C 45 49 4E 45 29 00 00 
CODE SEG "player"
	LEA	s!+266(A4),A0
	MOVE.L	A0,A3
	BRA.S	L150
	BRA.S	L156
L155:
	CMP	#3,D0
	BEQ.S	L156
	BRA.S	L157
L156:
DATA SEG "s!"
	DATA 28 50 4C 45 49 4E 45 29 00 00 
CODE SEG "player"
	LEA	s!+284(A4),A0
	MOVE.L	A0,A3
L157:
L158:
L150:
	MOVE.L	A3,-(A7)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L159
L147:
	CMPI	#0,D6
	BCS.S	L160
	CMPI	#3,D6
	BHI.S	L160
	CLR	D5
DATA SEG "s!"
	DATA 47 52 4F 55 50 45 20 46 41 43 45 20 00 00 
CODE SEG "player"
	PEA	s!+294(A4)
	PEA	-114(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	11G430_apc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-114(A6)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L161
L160:
	MOVE	#1,D5
	MOVE	#127,D4
	MOVE	2(A2),D1
	AND	#127,D1
	ADD	D1,D4
	MULS	#6,D4
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
L161:
L159:
L145:
L146:
L137:
	MOVE	D5,D0
	BEQ.S	L162
	MOVE.L	-68(A6),-(A7)
	MOVE.L	-72(A6),-(A7)
	PEA	-114(A6)
	PEA	-64(A6)
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F336_xxxx_(PC)
	ADDA	#20,A7
	PEA	-114(A6)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
L162:
DATA SEG "s!"
	DATA 50 45 53 45 20 00 
CODE SEG "player"
	PEA	s!+308(A4)
	PEA	-114(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	MOVE	#3,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 4B 47 2C 00 
CODE SEG "player"
	PEA	s!+314(A4)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MULU	#10,D0
	SUB	D0,D7
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2E 00 
CODE SEG "player"
	PEA	s!+318(A4)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-114(A6)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
L130:
L128:
	MOVE	10(A6),-(A7)
	JSR	F339_xxxx_(PC)
	ADDQ.L	#2,A7
L126:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$125:	.EQU	#-114
F343_xxxx_:/* global */
	LINK	A6,L$163
	MOVE	8(A6),D0
	MOVE	D0,-8(A6)
	ADD	12(A6),D0
	MOVE	D0,-6(A6)
	MOVE	10(A6),D0
	MOVE	D0,-4(A6)
	ADDQ	#6,D0
	MOVE	D0,-2(A6)
	CLR	G578_B_Use(A4)
	MOVE	#112,-(A7)
	MOVE	14(A6),-(A7)
	PEA	-8(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
L164:
	UNLK	A6
	RTS
L$163:	.EQU	#-8
F344_xxxx_:/* global */
	LINK	A6,L$165
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	CMPI	#-512,D7
	BGE.S	L167
	MOVE	#8,D6
	BRA.S	L168
L167:
	CMPI	#0,D7
	BGE.S	L169
	MOVE	#11,D6
	BRA.S	L170
L169:
	MOVE	12(A6),D6
L170:
L168:
	MOVE	D7,D5
	ADD	#1024,D5
	CMPI	#3072,D5
	BNE.S	L171
	MOVE	#3071,D5
L171:
	MOVE	D5,D0
	ASR	#5,D0
	MOVE	D0,D5
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),D0
	ADDQ	#2,D0
	MOVE	D0,-(A7)
	MOVE	#115,-(A7)
	JSR	F343_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	#113,-(A7)
	JSR	F343_xxxx_(PC)
	ADDQ.L	#8,A7
L166:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$165:	.EQU	#0
F345_xxxx_:/* global */
	LINK	A6,L$172
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	G423_i_Inv(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	JSR	F334_akzz_(PC)
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#20,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#48,-(A7)
	PEA	G035_s_Gra(A4)
	MOVE	#30,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#24,-(A7)
	PEA	G036_s_Gra(A4)
	MOVE	#31,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE.B	42(A3),D0
	BEQ.S	L174
	MOVE	#12,-(A7)
	MOVE	#48,-(A7)
	PEA	G037_s_Gra(A4)
	MOVE	#32,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
L174:
	MOVE	#5,-(A7)
	MOVE	#69,-(A7)
	MOVE	66(A3),-(A7)
	JSR	F344_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	#14,-(A7)
	MOVE	#92,-(A7)
	MOVE	68(A3),-(A7)
	JSR	F344_xxxx_(PC)
	ADDQ.L	#6,A7
L173:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$172:	.EQU	#0
F346_xxxx_:/* global */
	LINK	A6,L$175
	MOVE	#5,G424_i_Pan(A4)
	MOVE	#6,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#40,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
L176:
	UNLK	A6
	RTS
L$175:	.EQU	#0
F347_xxxx_:/* global */
	LINK	A6,L$177
	MOVEM.L	A3/D7,-(A7)
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L179
	JSR	F346_xxxx_(PC)
	BRA.S	L178
L179:
	MOVE	G423_i_Inv(A4),D7
	MULS	#800,D7
	LEA	G407_s_Par+-588(A4),A0
	ADDA	D7,A0
	MOVE	2(A0),D7
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CLR	G424_i_Pan(A4)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L180:
	CMP	#9,D0
	BEQ.S	L181
	BRA.S	L183
L181:
	MOVE	#4,G424_i_Pan(A4)
	BRA.S	L182
	BRA.S	L184
L183:
	CMP	#7,D0
	BEQ.S	L184
	BRA.S	L185
L184:
	MOVE	#2,G424_i_Pan(A4)
	BRA.S	L182
L186:
	MOVE	#-1,D7
	BRA.S	L187
L185:
	BRA.S	L186
L187:
L182:
	CMPI	#-1,D7
	BNE.S	L188
	JSR	F345_xxxx_(PC)
	BRA.S	L178
L188:
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F342_xxxx_(PC)
	ADDQ.L	#4,A7
L178:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$177:	.EQU	#0
F348_xxxx_:/* global */
	LINK	A6,L$189
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CMPI	#0,D6
	BLT.S	L191
	MOVE	D7,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	CMPI	#120,D0
	BLE.S	L192
	MOVE	D6,D0
	ASR	#1,D0
	MOVE	D0,D6
	CMPI	#150,D5
	BLE.S	L193
	MOVE	D6,D0
	ASR	#1,D0
	MOVE	D0,D6
L193:
	ADDQ	#1,D6
L192:
	MOVE	#170,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	BRA.S	L194
L191:
	MOVE	D7,D0
	MULS	#3,D0
	LEA	72(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D7,D1
	MULS	#3,D1
	LEA	71(A3),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	(A0),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
L194:
	MOVE	D7,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D5,D0
	MOVE.B	D0,(A0)
L190:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$189:	.EQU	#0
F349_dzzz_:/* global */
	LINK	A6,L$195
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L197
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L198
	BRA	L196(PC)
L198:
	MOVE	#1,G597_B_Ign(A4)
	MOVE	#1,G333_B_Pre(A4)
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	BNE.S	L199
	CLR	G597_B_Ign(A4)
	CLR	G333_B_Pre(A4)
	CLR	G334_B_Sto(A4)
	BRA.S	L200
L199:
	JSR	F077_aA39_(PC)
	MOVE	#1,G587_i_Hid(A4)
	JSR	F345_xxxx_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
L200:
	BRA	L201(PC)
L197:
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L202
	BRA	L196(PC)
L202:
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#1,D0
	BNE.S	L203
	BRA	L196(PC)
L203:
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-18(A6)
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-20(A6)
	MOVE	G423_i_Inv(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D5
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CMPI	#8,D6
	BCS.S	L204
	CMPI	#9,D6
	BHI.S	L204
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	BNE.S	L205
	BRA	L196(PC)
L205:
	MOVE	#2048,-(A7)
	MOVE	68(A2),D0
	ADD	#800,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,68(A2)
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A3)
	OR	D3,2(A3)
	CLR	D4
	BRA.S	L206
L204:
	CMPI	#8,-18(A6)
	BNE.S	L207
	CLR	D4
	BRA.S	L208
L207:
	MOVE	#-1,(A3)
	MOVE	#1,D4
L208:
L206:
	JSR	F077_aA39_(PC)
	MOVE	D4,D0
	BEQ.S	L209
	JSR	F298_aqzz_(PC)
L209:
	CMPI	#8,-18(A6)
	BNE	L210(PC)
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	MOVE	#32,D0
	MOVE	-12(A6),D1
	ADDQ	#1,D1
	AND.L	#65535,D1
	DIVU	#8,D1
	ADD	D1,D0
	MOVE	D0,-30(A6)
	MOVE	#511,D0
	SUB	-12(A6),D0
	AND.L	#65535,D0
	DIVU	-30(A6),D0
	LSR	#1,D0
	MOVE	D0,-14(A6)
	MOVE	-12(A6),D0
	AND.L	#65535,D0
	DIVU	#25,D0
	ADDQ	#8,D0
	MOVE	D0,-12(A6)
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#32512,D0
	LSR	#8,D0
L211:
	CMP	#6,D0
	BEQ.S	L212
	BRA.S	L214
L212:
	MOVE	-12(A6),-(A7)
	MOVE	#2,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L213(PC)
	BRA.S	L215
L214:
	CMP	#7,D0
	BEQ.S	L215
	BRA.S	L216
L215:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#255,D0
	AND.L	#65535,D0
	DIVU	#35,D0
	ADDQ	#5,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L213(PC)
	BRA.S	L217
L216:
	CMP	#8,D0
	BEQ.S	L217
	BRA.S	L218
L217:
	MOVE	-12(A6),-(A7)
	MOVE	#3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L213(PC)
	BRA.S	L219
L218:
	CMP	#9,D0
	BEQ.S	L219
	BRA.S	L220
L219:
	MOVE	-12(A6),-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L213(PC)
	BRA.S	L221
L220:
	CMP	#10,D0
	BEQ.S	L221
	BRA.S	L222
L221:
	MOVE	D5,-(A7)
	JSR	F323_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L213(PC)
	BRA.S	L223
L222:
	CMP	#11,D0
	BEQ.S	L223
	BRA.S	L224
L223:
	MOVE	58(A2),D0
	AND.L	#65535,D0
	DIVU	-14(A6),D0
	MOVE	D0,-(A7)
	MOVE	58(A2),D0
	SUB	56(A2),D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,56(A2)
	BRA	L213(PC)
	BRA.S	L225
L224:
	CMP	#12,D0
	BEQ.S	L225
	BRA.S	L226
L225:
	MOVE	-12(A6),D0
	LSR	#1,D0
	ADD	D0,-12(A6)
	CMPI	#50,274(A2)
	BLE.S	L228
	MOVE	-12(A6),D0
	LSR	#2,D0
	MOVE	D0,-12(A6)
L228:
	MOVE	-12(A6),D0
	ADD	D0,274(A2)
	MOVE.B	#72,-6(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-12(A6),D1
	MULU	-12(A6),D1
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE	D5,D0
	MOVE.B	D0,-5(A6)
	MOVE	-12(A6),-4(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	ORI	#4096,48(A2)
	BRA	L213(PC)
	BRA.S	L227
L226:
	CMP	#13,D0
	BEQ.S	L227
	BRA.S	L229
L227:
	MOVE	60(A2),D0
	ADD	-12(A6),D0
	MOVE	-12(A6),D1
	SUBQ	#8,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#900,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-18(A6)
	MOVE	-18(A6),D0
	MOVE	62(A2),D1
	CMP	D1,D0
	BLS.S	L231
	MOVE	62(A2),-(A7)
	MOVE	60(A2),-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-40(A6)
	MOVE	-18(A6),D0
	SUB	-40(A6),D0
	LSR	#1,D0
	SUB	D0,-18(A6)
L231:
	MOVE	-18(A6),60(A2)
	BRA	L213(PC)
	BRA.S	L230
L229:
	CMP	#14,D0
	BEQ.S	L230
	BRA	L232(PC)
L230:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#255,D0
	AND.L	#65535,D0
	DIVU	#42,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-18(A6)
	MOVE	54(A2),D0
	AND.L	#65535,D0
	DIVU	-14(A6),D0
	ADD	D0,52(A2)
	MOVE	50(A2),-16(A6)
	BEQ.S	L234
	MOVE	#10,-14(A6)
L235:
	CLR	-12(A6)
	BRA.S	L238
L239:
	JSR	F027_AA59_(PC)
	AND	D0,50(A2)
L240:
	ADDQ	#1,-12(A6)
L238:
	MOVE	-12(A6),D0
	CMP	-18(A6),D0
	BCS.S	L239
L241:
	MOVE	#1,-18(A6)
L236:
	MOVE	-16(A6),D0
	CMP	50(A2),D0
	BNE.S	L242
	SUBQ	#1,-14(A6)
	MOVE	-14(A6),D0
	BNE.S	L235
L242:
L237:
L234:
	ORI	#8704,48(A2)
	BRA.S	L213
	BRA.S	L233
L232:
	CMP	#15,D0
	BEQ.S	L233
	BRA.S	L243
L233:
	MOVE	#2048,-(A7)
	MOVE	68(A2),D0
	ADD	#1600,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,68(A2)
L243:
L244:
L213:
	MOVE	#20,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	AND	#127,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-32513,2(A0)
	OR	D3,2(A0)
	BRA.S	L245
L210:
	CMPI	#168,D6
	BCS.S	L246
	CMPI	#176,D6
	BCC.S	L246
	MOVE	#2048,-(A7)
	MOVE	66(A2),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G242_ai_Gr+-336(A4),A0
	ADDA	D1,A0
	ADD	(A0),D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,66(A2)
L246:
L245:
	MOVE	56(A2),D0
	CMP	58(A2),D0
	BLE.S	L247
	MOVE	58(A2),56(A2)
L247:
	MOVE	52(A2),D0
	CMP	54(A2),D0
	BLE.S	L248
	MOVE	54(A2),52(A2)
L248:
	MOVE	D4,D0
	BEQ.S	L249
	MOVE	#5,-14(A6)
	BRA.S	L250
L251:
	MOVE	#46,-(A7)
	MOVE	#56,-(A7)
	MOVE	#205,D0
	MOVE	-14(A6),D1
	AND	#1,D1
	SEQ	D1
	AND	#1,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F037_aA29_(PC)
	ADDQ.L	#6,A7
	MOVE	#8,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
L250:
	SUBQ	#1,-14(A6)
	BNE.S	L251
L252:
	BRA.S	L253
L249:
	JSR	F296_aizz_(PC)
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	SUB	-20(A6),D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
L253:
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#8,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	ORI	#256,48(A2)
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L254
	ORI	#2048,48(A2)
L254:
	MOVE	D5,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L201:
L196:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$195:	.EQU	#-40
F350_aqzz_:/* global */
	LINK	A6,L$255
	JSR	F347_xxxx_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
L256:
	UNLK	A6
	RTS
L$255:	.EQU	#0
F351_xxxx_:/* global */
	LINK	A6,L$257
CODE SEG "init!"
	LEA	21G431_apc(A4),A1
DATA SEG "s!"
	DATA 4C 00 
CODE SEG "init!"
	LEA	s!+320(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 46 4F 52 43 45 00 
CODE SEG "init!"
	LEA	s!+322(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 44 45 58 54 45 52 49 54 45 00 
CODE SEG "init!"
	LEA	s!+328(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 53 41 47 45 53 53 45 00 
CODE SEG "init!"
	LEA	s!+338(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 56 49 54 41 4C 49 54 45 00 00 
CODE SEG "init!"
	LEA	s!+346(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 4E 54 49 2D 4D 41 47 49 45 00 00 
CODE SEG "init!"
	LEA	s!+356(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 4E 54 49 2D 46 45 55 00 00 
CODE SEG "init!"
	LEA	s!+368(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
21G431_apc:
	.WORD	#28
CODE SEG "player"
	MOVEM.L	A3/D7-D4,-(A7)
	JSR	F334_akzz_(PC)
	MOVE	G423_i_Inv(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D4
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#20,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#58,D6
	CLR	D7
	BRA.S	L259
L260:
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#16,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	CMPI	#1,D5
	BNE.S	L263
	BRA.S	L261
L263:
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-24(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "player"
	PEA	s!+378(A4)
	PEA	-24(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G428_apc_S+-8(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-24(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-24(A6)
	MOVE	#13,-(A7)
	MOVE	D6,-(A7)
	MOVE	#108,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	ADDQ	#7,D6
L261:
	ADDQ	#1,D7
L259:
	CMPI	#3,D7
	BLS.S	L260
L262:
	MOVE	#86,D6
	MOVE	#1,D7
	BRA	L264(PC)
L265:
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	21G431_apc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	#13,-(A7)
	MOVE	D6,-(A7)
	MOVE	#108,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	D7,D5
	MULS	#3,D5
	LEA	71(A3),A0
	ADDA	D5,A0
	MOVE.B	(A0),D5
	AND	#255,D5
	MOVE	D7,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	MOVE	D5,D0
	CMP	-4(A6),D0
	BCC.S	L268
	MOVE	#8,-2(A6)
	BRA.S	L269
L268:
	MOVE	D5,D0
	CMP	-4(A6),D0
	BLS.S	L270
	MOVE	#7,-2(A6)
	BRA.S	L271
L270:
	MOVE	#13,-2(A6)
L271:
L269:
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	#174,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+380(A4)
	PEA	-24(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	-24(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-24(A6)
	MOVE	#13,-(A7)
	MOVE	D6,-(A7)
	MOVE	#192,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	ADDQ	#7,D6
L266:
	ADDQ	#1,D7
L264:
	CMPI	#6,D7
	BLS	L265(PC)
L267:
L258:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$257:	.EQU	#-24
F352_aszz_:/* global */
	LINK	A6,L$272
	MOVEM.L	D7-D6,-(A7)
	MOVE	#1,G597_B_Ign(A4)
	MOVE	#1,G331_B_Pre(A4)
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	BNE.S	L274
	CLR	G597_B_Ign(A4)
	CLR	G331_B_Pre(A4)
	CLR	G332_B_Sto(A4)
	BRA.S	L273
L274:
	JSR	F357_qzzz_(PC)
	JSR	F077_aA39_(PC)
	MOVE	#8,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	MOVE	#13,-(A7)
	MOVE	#12,-(A7)
	MOVE	#203,-(A7)
	JSR	F332_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L275
	JSR	F351_xxxx_(PC)
	BRA.S	L276
L275:
	JSR	F035_aaaw_(PC)
	MOVE	#1,-(A7)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F342_xxxx_(PC)
	ADDQ.L	#4,A7
L276:
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
L273:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$272:	.EQU	#0
F353_auzz_:/* global */
	LINK	A6,L$277
	MOVE	D7,-(A7)
	MOVE	#13,-(A7)
	MOVE	#12,-(A7)
	MOVE	#202,-(A7)
	JSR	F332_xxxx_(PC)
	ADDQ.L	#6,A7
	JSR	F347_xxxx_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L279
	MOVE	D7,-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L279:
	JSR	F078_xzzz_(PC)
L278:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$277:	.EQU	#0
F354_szzz_:/* global */
	LINK	A6,L$280
	CLR	G578_B_Use(A4)
	CLR	-4(A6)
	MOVE	#28,-2(A6)
	MOVE	8(A6),D0
	MULS	#69,D0
	ADDQ	#7,D0
	MOVE	D0,-8(A6)
	ADD	#31,D0
	MOVE	D0,-6(A6)
	MOVE	#-1,-(A7)
	MOVE	#16,-(A7)
	PEA	-8(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par+336(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
L281:
	UNLK	A6
	RTS
L$280:	.EQU	#-8
F355_hzzz_:/* global */
	LINK	A6,L$282
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	CMPI	#4,D7
	BEQ.S	L284
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L284
	BRA	L283(PC)
L284:
	MOVE	G333_B_Pre(A4),D0
	BNE.S	L286
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L285
L286:
	BRA	L283(PC)
L285:
	MOVE	#1,G321_B_Sto(A4)
	MOVE	G423_i_Inv(A4),D6
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	D6,D0
	BNE.S	L287
	MOVE	#4,D7
L287:
	JSR	F077_aA39_(PC)
	MOVE	D6,D0
	BEQ.S	L288
	CLR	G423_i_Inv(A4)
	JSR	F334_akzz_(PC)
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BEQ.S	L289
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L289
	ORI	#4096,48(A3)
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L289:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L290
	JSR	F078_xzzz_(PC)
	BRA	L283(PC)
L290:
	CMPI	#4,D7
	BNE.S	L291
	MOVE	#1,G326_B_Ref(A4)
	JSR	F395_pzzz_(PC)
	JSR	F078_xzzz_(PC)
	LEA	G448_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	LEA	G459_as_Gr(A4),A0
	MOVE.L	A0,G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	JSR	F098_rzzz_(PC)
	BRA	L283(PC)
L291:
L288:
	CLR	G578_B_Use(A4)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,G423_i_Inv(A4)
	MOVE	D6,D0
	BNE.S	L292
	CLR	-(A7)
	PEA	G002_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
L292:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	#17,-(A7)
	JSR	F488_bzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L293
	MOVE	#112,-(A7)
	MOVE	#12,-(A7)
	PEA	G041_s_Gra(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
L293:
DATA SEG "s!"
	DATA 53 41 4E 54 45 00 
CODE SEG "player"
	PEA	s!+382(A4)
	MOVE	#13,-(A7)
	MOVE	#116,-(A7)
	MOVE	#5,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 56 49 47 55 45 55 52 00 
CODE SEG "player"
	PEA	s!+388(A4)
	MOVE	#13,-(A7)
	MOVE	#124,-(A7)
	MOVE	#5,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 4D 41 4E 41 00 00 
CODE SEG "player"
	PEA	s!+396(A4)
	MOVE	#13,-(A7)
	MOVE	#132,-(A7)
	MOVE	#5,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	CLR	D6
	BRA.S	L294
L295:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
L296:
	ADDQ	#1,D6
L294:
	CMPI	#30,D6
	BCS.S	L295
L297:
	ORI	#23424,48(A3)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,G598_B_Mou(A4)
	JSR	F078_xzzz_(PC)
	LEA	G449_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	CLR.L	G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
L283:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$282:	.EQU	#0
