CODE SEG "start"
F456_vzzz_:/* global */
	LINK	A6,L$0
	MOVE	G300_B_Par(A4),D0
	BNE.S	L2
	JSR	F077_aA39_(PC)
	JSR	F363_pzzz_(PC)
	CLR	G578_B_Use(A4)
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L3
	CMPI	#4,G424_i_Pan(A4)
	BNE.S	L4
	JSR	F347_xxxx_(PC)
L4:
	BRA.S	L5
L3:
	CLR	-(A7)
	PEA	G002_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
L5:
	CLR	-(A7)
	PEA	G000_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
	CLR	-(A7)
	PEA	G001_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L2:
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#0
F457_AA08_:/* global */
	LINK	A6,L$6
	MOVE	D7,-(A7)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L8
	JSR	F379_jzzz_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L9
L8:
	MOVE	G514_i_Mag(A4),D7
	MOVE	#-1,G514_i_Mag(A4)
	MOVE	D7,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G506_i_Act(A4),D0
	BNE.S	L10
	MOVE	#1,G509_B_Act(A4)
L10:
	JSR	F387_hzzz_(PC)
	MOVE	G423_i_Inv(A4),D7
	BEQ.S	L11
	CLR	G423_i_Inv(A4)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L12
L11:
	JSR	F098_rzzz_(PC)
	JSR	F395_pzzz_(PC)
L12:
	JSR	F069_aaaL_(PC)
L9:
	CLR	G328_i_Tim(A4)
L7:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$6:	.EQU	#0
F458_xxxx_:/* global */
	LINK	A6,L$13
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	_base(A4),D0
	ADD.L	#128,D0
	MOVE.L	D0,A3
	MOVE.B	(A3)+,D7
	AND	#255,D7
	CLR	D6
	BRA.S	L15
L16:
	MOVE.L	A3,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE.L	8(A6),A0
	ADDA	D6,A0
	MOVE.B	D0,(A0)
L17:
	ADDQ	#1,D6
L15:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L16
L18:
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE	D7,D0
L14:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$13:	.EQU	#0
F459_xxxx_:/* global */
	LINK	A6,L$19
	MOVE	8(A6),D0
	MULS	12(A6),D0
	MOVE	12(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	10(A6),D1
	MULS	12(A6),D1
	MOVE	12(A6),D2
	ASR	#1,D2
	ADD	D2,D1
	ASR	#5,D1
	MULS	D1,D0
L20:
	UNLK	A6
	RTS
L$19:	.EQU	#0
F460_xxxx_:/* global */
	LINK	A6,L$21
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,-(A7)
	MOVE.L	#3248,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G085_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#7840,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G084_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#392,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+52(A4)
	MOVE	#1,-(A7)
	MOVE.L	#392,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+56(A4)
	MOVE	#1,-(A7)
	MOVE.L	#3264,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+48(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5112,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+44(A4)
	MOVE	#1,-(A7)
	MOVE.L	#14208,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+40(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+36(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+32(A4)
	MOVE	#1,-(A7)
	MOVE.L	#144,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+28(A4)
	MOVE	#1,-(A7)
	MOVE.L	#256,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+24(A4)
	MOVE	#1,-(A7)
	MOVE.L	#688,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+20(A4)
	MOVE	#1,-(A7)
	MOVE.L	#704,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+16(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1560,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+12(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1504,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+8(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1504,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1968,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G088_apuc_+4(A4)
	MOVE	#1,-(A7)
	MOVE.L	#15232,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G296_puc_B(A4)
	MOVE.L	G296_puc_B(A4),D0
	ADD.L	#3248,D0
	MOVE.L	D0,G086_puc_B(A4)
	MOVE.L	G086_puc_B(A4),D0
	ADD.L	#4144,D0
	MOVE.L	D0,G087_puc_B(A4)
	CLR	-(A7)
	CLR	-(A7)
	LEA	G229_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32210,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G479_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32207,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G505_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32208,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G259_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32209,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	LEA	G067_i_Gra(A4),A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE	#-32206,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#15232,(A0)
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#4560,2(A0)
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#1184,4(A0)
	MOVE.L	G639_pi_De(A4),A0
	MOVE	#888,6(A0)
	MOVE	#15,D7
	BRA.S	L23
L24:
	MOVE	D7,D0
	ADD	#286,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G103_aai_C(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G103_aai_C+2(A4),A0
	ADDA	D0,A0
	MOVE	#1,(A0)
	MOVE	D7,D0
	MULS	#2,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#984,136(A0)
	MOVE	D7,D0
	MULS	#2,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#1952,138(A0)
L25:
	ADDQ	#1,D7
L23:
	CMPI	#16,D7
	BLE.S	L24
L26:
	MOVE	#241,G102_aai_C+60(A4)
	MOVE	#1,G102_aai_C+62(A4)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G209_as_Gr(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA	L27(PC)
L28:
	MOVE	#104,D5
	MOVE.B	1(A3),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	#16,-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE.B	4(A3),D0
	AND	#255,D0
	AND	#1,D0
	BEQ.S	L31
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ	#1,D5
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ	#1,D5
L31:
	MOVE.B	4(A3),D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L32
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ	#1,D5
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-4(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L32:
L29:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#6,A3
L27:
	CMPI	#85,D7
	BLT	L28(PC)
L30:
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G210_as_Gr(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-4(A6)
	BRA	L33(PC)
L34:
	MOVE.L	-4(A6),A0
	MOVE	4(A0),D0
	AND	#256,D0
	BNE	L37(PC)
	MOVE	#282,D5
	MOVE.L	-4(A6),A0
	MOVE.B	1(A0),D3
	AND	#255,D3
	ADD	D3,D5
	CLR	D6
	BRA	L38(PC)
L39:
	LEA	G215_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE.L	-4(A6),A0
	MOVE	4(A0),D0
	AND	#3,D0
	CMPI	#3,D0
	BEQ.S	L42
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	D4,12(A0)
	MOVE.L	-4(A6),A0
	MOVE	4(A0),D0
	AND	#3,D0
	CMPI	#2,D0
	BEQ.S	L43
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	D4,24(A0)
L43:
L42:
L40:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D5,D0
	ADDQ	#1,D5
L38:
	CMPI	#6,D6
	BLT	L39(PC)
L41:
L37:
L35:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,-4(A6)
L33:
	CMPI	#14,D7
	BLT	L34(PC)
L36:
	LEA	G213_auc_G(A4),A0
	MOVE.L	A0,G075_apuc_(A4)
	LEA	G214_auc_G(A4),A0
	MOVE.L	A0,G075_apuc_+4(A4)
	LEA	G017_auc_G(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,G075_apuc_+12(A4)
	MOVE.L	D0,G075_apuc_+8(A4)
	MOVE	#438,D5
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G211_as_Gr(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-8(A6)
	BRA.S	L44
L45:
	MOVE	#4,D6
	BRA.S	L48
L49:
	MOVE	D6,-(A7)
	MOVE.L	-8(A6),A0
	MOVE.B	1(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	-8(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L50:
	ADDQ	#2,D6
L48:
	CMPI	#32,D6
	BLT.S	L49
L51:
	CMPI	#3,D7
	BNE.S	L52
	MOVE.L	-8(A6),A0
	MOVE.B	(A0),D0
	MOVE.L	-8(A6),A0
	MOVE.B	1(A0),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L52:
L46:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	-8(A6),D0
	ADDQ.L	#2,-8(A6)
L44:
	CMPI	#4,D7
	BLT.S	L45
L47:
	MOVE	#495,D5
	CLR	D6
	BRA	L53(PC)
L54:
	MOVE	D6,D0
	MULS	#12,D0
	LEA	G219_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D6,D7
	MULS	#26,D7
	LEA	G243_as_Gr+4(A4),A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D5,2(A2)
	MOVE	#16,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-12(A6)
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-10(A6)
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L57
	MOVE	#16,-(A7)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L57:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L58
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-12(A6),(A0)
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	-10(A6),(A0)
L58:
	MOVE	D7,D0
	AND	#32,D0
	BEQ.S	L59
	MOVE	#16,-(A7)
	MOVE.B	9(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	8(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	9(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	8(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L59:
	MOVE	D7,D0
	AND	#3,D0
	MOVE	D0,-12(A6)
	BEQ	L60(PC)
L61:
	MOVE.B	4(A2),D0
	MOVE.B	5(A2),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#16,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#20,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F459_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D1
	ADDQ	#1,D5
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L62:
	SUBQ	#1,-12(A6)
	BNE.S	L61
L63:
L60:
L55:
	ADDQ	#1,D6
L53:
	CMPI	#27,D6
	BLT	L54(PC)
L56:
L22:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$21:	.EQU	#-12
F461_AA08_:/* global */
	LINK	A6,L$64
	MOVE	#1,-(A7)
	MOVE.L	#3264,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G090_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5112,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G091_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#14208,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G092_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G093_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#2176,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G094_puc_B(A4)
L65:
	UNLK	A6
	RTS
L$64:	.EQU	#0
F462_xxxx_:/* global */
	LINK	A6,L$66
	CLR	G331_B_Pre(A4)
	CLR	G332_B_Sto(A4)
	CLR	G333_B_Pre(A4)
	CLR	G334_B_Sto(A4)
	CLR	G340_B_Hig(A4)
	CLR	G341_B_Hig(A4)
	CLR	G300_B_Par(A4)
	MOVE	#15,G069_ui_St(A4)
	CLR	G070_B_Sec(A4)
	CLR	G071_B_Sec(A4)
	CLR	G506_i_Act(A4)
	MOVE	#1,G509_B_Act(A4)
	CLR	G599_ui_Us(A4)
	MOVE.L	#16777215,G374_l_Wat(A4)
	LEA	G447_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	LEA	G448_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	LEA	G458_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	LEA	G459_as_Gr(A4),A0
	MOVE.L	A0,G444_ps_Se(A4)
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F003_aaaS_(PC)
	ADDQ.L	#2,A7
	MOVE	G298_B_New(A4),D0
	BNE.S	L68
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	MOVE.L	G536_pc_D0(A4),-(A7)
	CLR.L	-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F077_aA39_(PC)
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	BRA.S	L69
L68:
	CLR	G578_B_Use(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G061_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G062_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G063_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
L69:
	PEA	G021_aaui_(A4)
	MOVE	#6,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	JSR	F395_pzzz_(PC)
	JSR	F278_apzz_(PC)
	MOVE	#1,G301_B_Gam(A4)
L67:
	UNLK	A6
	RTS
L$66:	.EQU	#0
