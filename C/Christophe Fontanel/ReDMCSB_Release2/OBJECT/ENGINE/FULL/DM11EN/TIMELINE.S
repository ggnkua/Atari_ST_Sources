BSS SEG "bss"
G369_ui_Ev:/* global */
	.WORD	#2
G370_ps_Ev:/* global */
	.WORD	#4
G371_pi_Ti:/* global */
	.WORD	#4
G372_ui_Ev:/* global */
	.WORD	#2
G373_ui_Fi:/* global */
	.WORD	#2
G374_l_Wat:/* global */
	.WORD	#4
CODE SEG "timeline"
F233_wzzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3/D7,-(A7)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G370_ps_Ev(A4)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G371_pi_Ti(A4)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L2
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L3
L4:
	CLR.B	4(A3)
L5:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#10,A3
L3:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L4
L6:
	CLR	G372_ui_Ev(A4)
	CLR	G373_ui_Fi(A4)
	JSR	F256_xxxx_(PC)
L2:
L1:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F234_xxxx_:/* global */
	LINK	A6,L$7
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.L	(A3),D0
	AND.L	#16777215,D0
	MOVE.L	(A2),D1
	AND.L	#16777215,D1
	CMP.L	D1,D0
	SLT	D0
	TST.B	D0
	BNE.S	L10
	MOVE.L	(A3),D0
	AND.L	#16777215,D0
	MOVE.L	(A2),D1
	AND.L	#16777215,D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D7
	BEQ.S	L11
	MOVE	4(A3),D0
	CMP	4(A2),D0
	SHI	D0
	TST.B	D0
L11:
	SNE	D0
	TST.B	D0
L10:
	TST.B	D0
	BNE.S	L9
	MOVE	D7,D0
	BEQ.S	L13
	MOVE	4(A3),D0
	CMP	4(A2),D0
	SEQ	D0
	TST.B	D0
L13:
	SNE	D0
	TST.B	D0
	BEQ.S	L12
	MOVE.L	A3,D0
	CMP.L	A2,D0
	SLE	D0
	TST.B	D0
L12:
	TST.B	D0
L9:
	AND	#1,D0
L8:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$7:	.EQU	#0
F235_bzzz_:/* global */
	LINK	A6,L$14
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,A3
	BRA.S	L16
L17:
	MOVE	(A3)+,D0
	CMP	D7,D0
	BNE.S	L20
	BRA.S	L19
L20:
L18:
	ADDQ	#1,D6
L16:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L17
L19:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L21
	CLR	D6
L21:
	MOVE	D6,D0
L15:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$14:	.EQU	#0
F236_pzzz_:/* global */
	LINK	A6,L$22
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D4
	CMPI	#1,D0
	BNE.S	L24
	BRA	L23(PC)
L24:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	-2(A6)
	BRA.S	L25
L26:
	MOVE	D7,D6
	SUBQ	#1,D6
	LSR	#1,D6
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L28
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	MOVE	#1,-2(A6)
	BRA.S	L25
L28:
	BRA.S	L27
L25:
	CMPI	#0,D7
	BHI.S	L26
L27:
	MOVE	-2(A6),D0
	BEQ.S	L29
	BRA	L3T236_011(PC)
L29:
	MOVE	D4,D0
	SUBQ	#1,D0
	SUBQ	#1,D0
	LSR	#1,D0
	MOVE	D0,D4
	BRA	L30(PC)
L31:
	MOVE	D7,D6
	ASL	#1,D6
	ADDQ	#1,D6
	MOVE	D6,D0
	ADDQ	#1,D0
	CMP	G372_ui_Ev(A4),D0
	BCC.S	L33
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L33
	ADDQ	#1,D6
L33:
	MOVE.L	A3,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L34
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	BRA.S	L30
L34:
	BRA.S	L32
L30:
	MOVE	D7,D0
	CMP	D4,D0
	BLS	L31(PC)
L32:
L3T236_011:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
L23:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$22:	.EQU	#-2
F237_rzzz_:/* global */
	LINK	A6,L$35
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	CLR.B	4(A0)
	MOVE	D7,D0
	CMP	G373_ui_Fi(A4),D0
	BCC.S	L37
	MOVE	D7,G373_ui_Fi(A4)
L37:
	SUBQ	#1,G372_ui_Ev(A4)
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L38
	BRA.S	L36
L38:
	MOVE	D7,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	D6,D0
	CMP	D5,D0
	BNE.S	L39
	BRA.S	L36
L39:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L36:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$35:	.EQU	#0
F238_pzzz_:/* global */
	LINK	A6,L$40
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	G372_ui_Ev(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L42
L5T238_001:
	MOVE	#0,D0
	BRA	L41(PC)
L42:
	CMPI	#3217,G189_i_Gra(A4)
	BEQ.S	L43
	BRA.S	L5T238_001
L43:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#5,D0
	BLT	L44(PC)
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#10,D0
	BGT	L44(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA	L45(PC)
L46:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#5,D0
	BLT.S	L49
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BGT.S	L49
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L50
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L50
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#6,D0
	BNE.S	L51
	MOVE.B	8(A2),D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BNE.S	L50
L51:
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L41(PC)
L50:
	BRA.S	L47
	BRA.S	L52
L49:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L53
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L53
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L53
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L54
	MOVE	#1,D0
	MOVE.B	9(A2),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A3)
L54:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L48
L53:
L52:
L47:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L45:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS	L46(PC)
L48:
	BRA	L55(PC)
L44:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#1,D0
	BNE	L56(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L57
L58:
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L61
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L61
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L62
	MOVE.B	9(A2),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L63
	MOVE	#1,D0
	MOVE.B	9(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A2)
L63:
	MOVE	D7,D0
	BRA	L41(PC)
L62:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L64
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L41(PC)
L64:
L61:
L59:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L57:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L58
L60:
	BRA.S	L65
L56:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L66
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L67
L68:
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L71
	MOVE.L	(A3),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE.L	(A2),D1
	MOVE.L	#24,D3
	ASR.L	D3,D1
	CMP	D1,D0
	BNE.S	L71
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BEQ.S	L73
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L72
L73:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L72:
L71:
L69:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L67:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L68
L70:
L66:
L65:
L55:
	LEA	(A3),A1
	MOVE	G373_ui_Fi(A4),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
L74:
	MOVE	G373_ui_Fi(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L77
	BRA.S	L76
L77:
	ADDQ	#1,G373_ui_Fi(A4)
L75:
	MOVE	G373_ui_Fi(A4),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L74
L76:
	MOVE	G372_ui_Ev(A4),D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	G372_ui_Ev(A4),D0
	ADDQ	#1,G372_ui_Ev(A4)
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
L41:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$40:	.EQU	#0
F239_xxxx_:/* global */
	LINK	A6,L$78
	MOVE	D7,-(A7)
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MOVE	D0,D7
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	MOVE.L	8(A6),A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L79:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$78:	.EQU	#0
F240_xxxx_:/* global */
	LINK	A6,L$80
	MOVE	G372_ui_Ev(A4),D0
	BEQ.S	L83
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	AND.L	#16777215,D0
	MOVE.L	G313_ul_Ga(A4),D1
	CMP.L	D1,D0
	SLE	D0
	TST.B	D0
L83:
	SNE	D0
	TST.B	D0
	BEQ.S	L82
	CMPI	#2,G330_i_Sto(A4)
	SLT	D0
	TST.B	D0
L82:
	AND	#1,D0
L81:
	UNLK	A6
	RTS
L$80:	.EQU	#0
F241_xxxx_:/* global */
	LINK	A6,L$84
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D4
	CMPI	#5,D0
	BNE.S	L86
	BRA	L85(PC)
L86:
	ADDQ.L	#1,(A3)
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#1,D5
	BNE	L87(PC)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#32,D0
	LSR	#5,D0
	MOVE	D0,-10(A6)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE	L88(PC)
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L88
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L88
	CMPI	#0,D4
	BEQ.S	L88
	CMPI	#0,G305_ui_Pa(A4)
	BLS.S	L89
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#0,D0
	MOVE.B	D0,(A2)
	MOVE	#2,-(A7)
	MOVE	#8,D0
	OR	-10(A6),D0
	BEQ.S	L91
	MOVE	#4,D0
	BRA.S	L92
L91:
	MOVE	#3,D0
L92:
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L90
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#18,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L90:
L89:
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L85(PC)
L88:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-6(A6)
	CMPI	#-2,D0
	BEQ	L93(PC)
	MOVE	-6(A6),-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-8(A6)
	AND	#64,D0
	BNE	L93(PC)
	MOVE	D4,D0
	MOVE	-10(A6),D1
	BEQ.S	L95
	MOVE	-8(A6),D1
	LSR	#7,D1
	AND	#3,D1
	BRA.S	L96
L95:
	MOVE	#1,D1
L96:
	CMP	D1,D0
	BCS.S	L94
	MOVE	#1,-(A7)
	MOVE	#5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	CMPI	#2,D0
	BEQ.S	L97
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L97:
	CMPI	#0,D4
	BNE.S	L98
	MOVE	#0,D0
	BRA.S	L99
L98:
	MOVE	D4,D0
	SUBQ	#1,D0
L99:
	MOVE	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#4,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L85
L94:
L93:
L87:
	CMPI	#0,D5
	BNE.S	L102
	CMPI	#0,D4
	BEQ.S	L101
L102:
	CMPI	#1,D5
	BNE.S	L100
	CMPI	#4,D4
	BNE.S	L100
L101:
	BRA.S	L85
L100:
	CMPI	#0,D5
	BNE.S	L103
	MOVE	#-1,D0
	BRA.S	L104
L103:
	MOVE	#1,D0
L104:
	ADD	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#2,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	CMPI	#0,D5
	BNE.S	L105
	CMPI	#0,D4
	BNE.S	L106
	BRA.S	L85
L106:
	BRA.S	L107
L105:
	CMPI	#4,D4
	BNE.S	L108
	BRA.S	L85
L108:
L107:
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L85:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$84:	.EQU	#-10
F242_xxxx_:/* global */
	LINK	A6,L$109
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#2,D5
	BNE.S	L111
	MOVE.B	(A2),D5
	AND	#255,D5
	AND	#4,D5
	BEQ.S	L112
	MOVE	#1,D5
	BRA.S	L113
L112:
	MOVE	#0,D5
L113:
L111:
	CMPI	#1,D5
	BNE.S	L114
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L115
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L115
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L115
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L116
L115:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L117
	MOVE	D4,-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#64,D0
	BNE.S	L117
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L118
L117:
	ANDI.B	#-5,(A2)
L118:
L116:
	BRA.S	L119
L114:
	ORI.B	#4,(A2)
L119:
L110:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$109:	.EQU	#0
F243_xxxx_:/* global */
	LINK	A6,L$120
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#5,D0
	MOVE.B	D0,(A2)
L121:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$120:	.EQU	#0
F244_xxxx_:/* global */
	LINK	A6,L$122
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D7
	CMPI	#5,D0
	BNE.S	L124
	BRA.S	L123
L124:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L125
	CMPI	#0,D7
	BNE.S	L126
	MOVE	#1,D0
	BRA.S	L127
L126:
	MOVE	#0,D0
L127:
	MOVE.B	D0,9(A3)
	BRA.S	L128
L125:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L129
	CMPI	#0,D7
	BNE.S	L130
	BRA.S	L123
L130:
	BRA.S	L131
L129:
	CMPI	#4,D7
	BNE.S	L132
	BRA.S	L123
L132:
L131:
L128:
	MOVE.B	#1,4(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L123:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$122:	.EQU	#0
F245_xxxx_:/* global */
	LINK	A6,L$133
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L135(PC)
L136:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D7
	CMPI	#2,D0
	BNE	L139(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D6
	AND	#1,D6
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L140
	MOVE	D6,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L141
L140:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L141:
	MOVE	D6,D0
	BNE.S	L142
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	BEQ.S	L142
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L142
	MOVE	-6(A6),D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L142
	MOVE	-8(A6),D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L142
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	PEA	G353_ac_St(A4)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L142:
	BRA	L143(PC)
L139:
	CMPI	#3,D7
	BNE	L144(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#6,D0
	BNE	L145(PC)
	MOVE	4(A2),D5
	AND	#1920,D5
	LSR	#7,D5
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L146
	JSR	F027_AA59_(PC)
	MOVE	D5,D1
	AND	#7,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D5
	BRA.S	L147
L146:
	SUBQ	#1,D5
L147:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BNE.S	L148
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-10(A6)
L148:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	2(A2),D0
	LSR	#7,D0
	MOVE	D0,-(A7)
	JSR	F185_auzz_(PC)
	ADDA	#12,A7
	MOVE	4(A2),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L149
	MOVE	#1,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L149:
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L150
	ANDI	#-128,2(A2)
	BRA.S	L151
L150:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#4,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BEQ.S	L152
	ANDI	#-128,2(A2)
	CMPI	#127,-10(A6)
	BLS.S	L153
	MOVE	-10(A6),D0
	SUB	#126,D0
	ASL	#6,D0
	MOVE	D0,-10(A6)
L153:
	MOVE.B	#65,-16(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	CLR.B	-15(A6)
	MOVE	-6(A6),D0
	MOVE.B	D0,-14(A6)
	MOVE	-8(A6),D0
	MOVE.B	D0,-13(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L152:
L151:
L145:
L144:
L143:
L137:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L135:
	CMPI	#-2,D4
	BNE	L136(PC)
L138:
L134:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$133:	.EQU	#-20
F246_xxxx_:/* global */
	LINK	A6,L$154
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L156
L157:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L160
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#0,D0
	BNE.S	L161
	ORI	#6,2(A2)
	BRA.S	L155
L161:
L160:
L158:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L156:
	CMPI	#-1,D7
	BNE.S	L157
L159:
L155:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$154:	.EQU	#0
F247_xxxx_:/* global */
	LINK	A6,L$162
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	MOVE.B	8(A2),D5
	AND	#255,D5
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-6(A6)
	MOVE	2(A3),D4
	AND	#127,D4
	MOVE	2(A3),D0
	LSR	#7,D0
	MOVE	D0,-8(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-12(A6)
	CMPI	#7,D4
	SEQ	D0
	TST.B	D0
	BNE.S	L165
	CMPI	#8,D4
	SEQ	D0
	TST.B	D0
L165:
	TST.B	D0
	BNE.S	L164
	CMPI	#14,D4
	SEQ	D0
	TST.B	D0
L164:
	AND	#1,D0
	MOVE	D0,-14(A6)
	CMPI	#8,D4
	BEQ.S	L167
	CMPI	#10,D4
	BNE.S	L166
L167:
	MOVE	-8(A6),D7
	ADD	#-128,D7
	MOVE	D7,D6
	BRA	L168(PC)
L166:
	CMPI	#14,D4
	BEQ.S	L170
	CMPI	#15,D4
	BNE	L169(PC)
L170:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L171
L172:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L175
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L176
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L175
L176:
	BRA.S	L174
L175:
L173:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L171:
	CMPI	#-1,D7
	BNE.S	L172
L174:
	CMPI	#-1,D7
	BNE.S	L177
	BRA	L163(PC)
L177:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-14(A6),D0
	BNE.S	L178
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA.S	L179
L180:
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L183
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L184
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L183
L184:
	BRA.S	L182
L183:
L181:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L179:
	CMPI	#-1,D6
	BNE.S	L180
L182:
	CMPI	#-1,D6
	BNE.S	L185
	MOVE	#1,-14(A6)
	BRA.S	L186
L185:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L186:
L178:
	BRA.S	L187
L169:
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L188
	BRA	L163(PC)
L188:
	MOVE	-14(A6),D0
	BNE.S	L189
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L189
	MOVE	#1,-14(A6)
L189:
L187:
L168:
	MOVE	-14(A6),D0
	BEQ.S	L190
	JSR	F028_a000_(PC)
	MOVE	D0,-26(A6)
	MOVE	-6(A6),D0
	ADD	-26(A6),D0
	AND	#3,D0
	MOVE	D0,-6(A6)
L190:
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	#1,G365_B_Cre(A4)
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	-14(A6),D0
	BNE.S	L191
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L191:
	CLR	G365_B_Cre(A4)
L163:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$162:	.EQU	#-26
F248_xxxx_:/* global */
	LINK	A6,L$192
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE.B	8(A3),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	BRA	L194(PC)
L195:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#2,D0
	BNE	L197(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L197
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L198
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L199
L198:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L199:
	BRA	L200(PC)
L197:
	CMPI	#3,D6
	BNE	L201(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D0,-6(A6)
	MOVE	2(A2),D4
	LSR	#7,D4
	CMPI	#6,-6(A6)
	BNE	L202(PC)
	CMPI	#0,D4
	BLS	L203(PC)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L204
	CMPI	#511,D4
	BCC.S	L205
	ADDQ	#1,D4
L205:
	BRA.S	L206
L204:
	SUBQ	#1,D4
L206:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L207
	CMPI	#0,D4
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L208
	MOVE	#0,D0
	BRA.S	L209
L208:
	MOVE	#1,D0
L209:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L210
L207:
	CMPI	#0,D4
	BNE.S	L211
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L211:
L210:
L203:
	BRA	L212(PC)
L202:
	CMPI	#5,-6(A6)
	BNE	L213(PC)
	MOVE	#1,D5
	MOVE.B	8(A3),D3
	ASL	D3,D5
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L214
	MOVE	D4,D0
	AND	D5,D0
	BEQ.S	L215
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L216
L215:
	OR	D5,D4
L216:
	BRA.S	L217
L214:
	MOVE.B	9(A3),D0
	BEQ.S	L218
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L219
L218:
	OR	D5,D4
L219:
L217:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	D4,D5
	AND	#15,D5
	MOVE	D4,D1
	AND	#240,D1
	LSR	#4,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L220
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L221
	MOVE	#0,D0
	BRA.S	L222
L221:
	MOVE	#1,D0
L222:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L223
L220:
	MOVE	D5,D0
	BEQ.S	L224
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L224:
L223:
	BRA.S	L225
L213:
	CMPI	#7,-6(A6)
	BCS.S	L228
	CMPI	#10,-6(A6)
	BLS.S	L227
L228:
	CMPI	#14,-6(A6)
	BEQ.S	L227
	CMPI	#15,-6(A6)
	BNE.S	L226
L227:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L226
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F247_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L229
	ANDI	#-128,2(A2)
L229:
L226:
L225:
L212:
L201:
L200:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L194:
	CMPI	#-2,D7
	BNE	L195(PC)
L196:
	JSR	F271_xxxx_(PC)
L193:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$192:	.EQU	#-12
F249_xxxx_:/* global */
	LINK	A6,L$230
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L232
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L232
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L232
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	JSR	F296_aizz_(PC)
L232:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L233(PC)
L234:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	D4,D5
	AND	#15360,D5
	LSR	#2,D5
	LSR	#8,D5
	CMPI	#4,D5
	BCS.S	L236
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L236:
	CMPI	#14,D5
	BNE	L237(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	6(A3),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	G397_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,8(A2)
	OR	D3,8(A2)
	MOVE	G398_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,8(A2)
	OR	D3,8(A2)
	MOVE	G400_i_Mov(A4),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-3073,8(A2)
	OR	D3,8(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,6(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	BRA	L238(PC)
L237:
	CMPI	#15,D5
	BNE.S	L239
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L240
L241:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#25,D0
	BNE.S	L244
	MOVE	8(A2),D0
	CMP	D4,D0
	BNE.S	L244
	MOVE	G397_i_Mov(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G398_i_Mov(A4),D0
	MOVE.B	D0,7(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,8(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
L244:
L242:
	MOVE.L	A2,D0
	ADDA	#10,A2
	MOVE	D5,D0
	ADDQ	#1,D5
L240:
	MOVE	D5,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L241
L243:
L239:
L238:
	MOVE	-2(A6),D4
L233:
	CMPI	#-2,D4
	BNE	L234(PC)
L235:
L231:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$230:	.EQU	#-2
F250_xxxx_:/* global */
	LINK	A6,L$245
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L247
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L248
	MOVE	#1,D0
	BRA.S	L249
L248:
	MOVE	#0,D0
L249:
	MOVE.B	D0,9(A3)
L247:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L250
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L251
L250:
	ANDI.B	#-9,(A2)
L251:
L246:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$245:	.EQU	#0
F251_xxxx_:/* global */
	LINK	A6,L$252
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L254
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L255
	MOVE	#1,D0
	BRA.S	L256
L255:
	MOVE	#0,D0
L256:
	MOVE.B	D0,9(A3)
L254:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L257
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L258
L257:
	ANDI.B	#-9,(A2)
L258:
L253:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$252:	.EQU	#0
F252_xxxx_:/* global */
	LINK	A6,L$259
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	CLR	-2(A6)
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
L19T252_001:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L262
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L262
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L261
L262:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BNE.S	L261
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#61,D0
	BNE.S	L263
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L263:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	8(A3),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	BRA	L260(PC)
L261:
	MOVE	-2(A6),D0
	BNE.S	L264
	MOVE	#1,-2(A6)
	MOVE	8(A3),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#23,D0
	BNE.S	L265
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L265
	JSR	F029_AA19_(PC)
L266:
	CMP	#0,D0
	BEQ.S	L267
	BRA.S	L269
L267:
	SUBQ	#1,D7
	BRA.S	L268
	BRA.S	L270
L269:
	CMP	#1,D0
	BEQ.S	L270
	BRA.S	L271
L270:
	ADDQ	#1,D7
	BRA.S	L268
	BRA.S	L272
L271:
	CMP	#2,D0
	BEQ.S	L272
	BRA.S	L273
L272:
	SUBQ	#1,D6
	BRA.S	L268
	BRA.S	L274
L273:
	CMP	#3,D0
	BEQ.S	L274
	BRA.S	L275
L274:
	ADDQ	#1,D6
L275:
L276:
L268:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F223_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L277
	BRA	L19T252_001(PC)
L277:
L265:
L264:
	ADDQ.L	#5,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L260:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$259:	.EQU	#-2
F253_xxxx_:/* global */
	LINK	A6,L$278
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,44(A3)
	ANDI	#-9,48(A3)
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BEQ.S	L280
	MOVE.B	32(A3),D0
	AND	#255,D0
	LEA	G495_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	SUB	D0,64(A3)
L280:
	MOVE	52(A3),D0
	BEQ.S	L281
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#32,D0
	BNE.S	L282
	CMPI	#-1,212(A3)
	BNE.S	L282
	MOVE	#12,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L283
L20T253_002:
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L284
L283:
	CLR	D5
	BRA.S	L285
L286:
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L289
	BRA.S	L20T253_002
L289:
L287:
	ADDQ	#1,D5
L285:
	CMPI	#3,D5
	BLT.S	L286
L288:
L284:
L282:
	ORI	#-32768,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L281:
	MOVE.B	#-1,32(A3)
L279:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$278:	.EQU	#0
F254_xxxx_:/* global */
	LINK	A6,L$290
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,46(A3)
	MOVE	52(A3),D0
	BNE.S	L292
	BRA.S	L291
L292:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L293
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	BRA.S	L294
L293:
	ORI	#128,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L294:
L291:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$290:	.EQU	#0
F255_xxxx_:/* global */
	LINK	A6,L$295
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
	MOVE.B	8(A3),D5
	AND	#255,D5
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
L297:
	CMP	#2,D0
	BEQ.S	L298
	BRA.S	L300
L298:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-28,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	ADDQ.L	#5,(A3)
L22T255_002:
	SUBQ	#1,-4(A6)
	MOVE	-4(A6),D0
	MOVE.B	D0,9(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L299(PC)
	BRA.S	L301
L300:
	CMP	#1,D0
	BEQ.S	L301
	BRA	L302(PC)
L301:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L304
L305:
	MOVE	D4,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	D5,D0
	BNE.S	L308
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#10,D0
	BNE.S	L308
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#147,-2(A6)
	BNE.S	L309
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-6(A6),D0
	BNE.S	L310
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	BRA	L22T255_002(PC)
L310:
L309:
L308:
L306:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L304:
	CMPI	#-2,D4
	BNE.S	L305
L307:
	BRA.S	L299
	BRA.S	L303
L302:
	CMP	#0,D0
	BEQ.S	L303
	BRA.S	L311
L303:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F283_azzz_(PC)
	ADDQ.L	#2,A7
L311:
L312:
L299:
L296:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$295:	.EQU	#-6
F256_xxxx_:/* global */
	LINK	A6,L$313
	MOVE.B	#53,-6(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#300,D0
	MOVE.L	D0,G374_l_Wat(A4)
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L314:
	UNLK	A6
	RTS
L$313:	.EQU	#-10
F257_xxxx_:/* global */
	LINK	A6,L$315
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	6(A3),D0
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L317
	BRA.S	L316
L317:
	CMPI	#0,D6
	SLT	D5
	AND	#1,D5
	BEQ.S	L318
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
L318:
	MOVE	D6,D7
	SUBQ	#1,D7
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G039_ai_Gr(A4),A0
	ADDA	D1,A0
	SUB	(A0),D0
	MOVE	D0,D6
	MOVE	D5,D0
	BEQ.S	L319
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
	MOVE	D7,D0
	NEG	D0
	MOVE	D0,D7
L319:
	MOVE	D6,D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	D7,D0
	BEQ.S	L320
	MOVE.B	#70,-6(A6)
	MOVE	D7,-4(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#4,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	CLR.B	-5(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L320:
L316:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$315:	.EQU	#-10
F258_xxxx_:/* global */
	LINK	A6,L$321
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L323
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	BRA.S	L322
L323:
	MOVE	#0,D0
L322:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$321:	.EQU	#0
F259_xxxx_:/* global */
	LINK	A6,L$324
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L326
	BRA.S	L325
L326:
	MOVE	D6,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L327
	BRA.S	L325
L327:
	MOVE	#7,D5
	BRA.S	L328
L329:
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L332
	BRA.S	L325
L332:
L330:
	ADDQ	#1,D5
L328:
	CMPI	#9,D5
	BLS.S	L329
L331:
L325:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$324:	.EQU	#0
F260_pzzz_:/* global */
	LINK	A6,L$333
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L335
L336:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L337:
	ADDQ	#1,D7
L335:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L336
L338:
	JSR	F293_ahzz_(PC)
L334:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$333:	.EQU	#0
F261_hzzz_:/* global */
	LINK	A6,L$339
	MOVEM.L	A3/D7,-(A7)
	BRA	L341(PC)
L342:
	LEA	-10(A6),A0
	MOVE.L	A0,A3
	MOVE.L	A3,-(A7)
	JSR	F239_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	-10(A6),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	G319_ul_Lo(A4),D0
	CMP.L	G313_ul_Ga(A4),D0
	BHI.S	L344
	MOVE.B	-6(A6),D7
	AND	#255,D7
L344:
	CMPI	#28,D7
	BLS.S	L345
	CMPI	#42,D7
	BCC.S	L345
	MOVE.B	-2(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
	BRA	L346(PC)
L345:
	MOVE	D7,D0
L347:
	CMP	#48,D0
	BEQ.S	L348
L350:
	CMP	#49,D0
	BEQ.S	L348
	BRA.S	L351
L348:
	MOVE.L	A3,-(A7)
	JSR	F219_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L352
L351:
	CMP	#1,D0
	BEQ.S	L352
	BRA.S	L353
L352:
	MOVE.L	A3,-(A7)
	JSR	F241_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L354
L353:
	CMP	#25,D0
	BEQ.S	L354
	BRA.S	L355
L354:
	MOVE.L	A3,-(A7)
	JSR	F220_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L356
L355:
	CMP	#7,D0
	BEQ.S	L356
	BRA.S	L357
L356:
	MOVE.L	A3,-(A7)
	JSR	F242_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L358
L357:
	CMP	#2,D0
	BEQ.S	L358
	BRA.S	L359
L358:
	MOVE.L	A3,-(A7)
	JSR	F243_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L360
L359:
	CMP	#10,D0
	BEQ.S	L360
	BRA.S	L361
L360:
	MOVE.L	A3,-(A7)
	JSR	F244_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L362
L361:
	CMP	#9,D0
	BEQ.S	L362
	BRA.S	L363
L362:
	MOVE.L	A3,-(A7)
	JSR	F251_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L364
L363:
	CMP	#8,D0
	BEQ.S	L364
	BRA.S	L365
L364:
	MOVE.L	A3,-(A7)
	JSR	F250_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L366
L365:
	CMP	#6,D0
	BEQ.S	L366
	BRA.S	L367
L366:
	MOVE.L	A3,-(A7)
	JSR	F248_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L368
L367:
	CMP	#5,D0
	BEQ.S	L368
	BRA.S	L369
L368:
	MOVE.L	A3,-(A7)
	JSR	F245_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L370
L369:
	CMP	#60,D0
	BEQ.S	L370
L371:
	CMP	#61,D0
	BEQ.S	L370
	BRA.S	L372
L370:
	MOVE.L	A3,-(A7)
	JSR	F252_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L373
L372:
	CMP	#65,D0
	BEQ.S	L373
	BRA.S	L374
L373:
	MOVE.L	A3,-(A7)
	JSR	F246_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L375
L374:
	CMP	#20,D0
	BEQ.S	L375
	BRA.S	L376
L375:
	MOVE	#1,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L349(PC)
	BRA.S	L377
L376:
	CMP	#24,D0
	BEQ.S	L377
	BRA.S	L378
L377:
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L380
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-2(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+60(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L380:
	BRA	L349(PC)
	BRA.S	L379
L378:
	CMP	#22,D0
	BEQ.S	L379
	BRA.S	L381
L379:
	PEA	G295_ac_Se(A4)
	JSR	F210_uzzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L383
	MOVE	#136,G022_i_Gra(A4)
L383:
	BRA	L349(PC)
	BRA.S	L382
L381:
	CMP	#11,D0
	BEQ.S	L382
	BRA.S	L384
L382:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F253_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.B	-4(A6),D0
	BEQ.S	L386
	MOVE.B	-4(A6),D0
	EXT	D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F259_xxxx_(PC)
	ADDQ.L	#4,A7
L386:
	BRA	L28T261_048(PC)
	BRA.S	L385
L384:
	CMP	#12,D0
	BEQ.S	L385
	BRA.S	L387
L385:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F254_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L349(PC)
	BRA.S	L388
L387:
	CMP	#53,D0
	BEQ.S	L388
	BRA.S	L389
L388:
	MOVE.L	A3,-(A7)
	JSR	F256_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L349(PC)
	BRA.S	L390
L389:
	CMP	#70,D0
	BEQ.S	L390
	BRA.S	L391
L390:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F257_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F337_akzz_(PC)
	BRA	L349(PC)
	BRA.S	L392
L391:
	CMP	#71,D0
	BEQ.S	L392
	BRA.S	L393
L392:
	SUBQ.B	#1,G407_s_Par+3286(A4)
	BRA	L349(PC)
	BRA.S	L394
L393:
	CMP	#72,D0
	BEQ.S	L394
	BRA.S	L395
L394:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+274(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	-4(A6),D0
	MOVE	D0,(A0)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L28T261_048:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	BRA	L349(PC)
	BRA.S	L396
L395:
	CMP	#73,D0
	BEQ.S	L396
	BRA.S	L397
L396:
	SUBQ.B	#1,G407_s_Par+3202(A4)
	BRA	L349(PC)
	BRA.S	L398
L397:
	CMP	#74,D0
	BEQ.S	L398
	BRA.S	L399
L398:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3204(A4)
L28T261_053:
	JSR	F260_pzzz_(PC)
	BRA.S	L349
	BRA.S	L400
L399:
	CMP	#77,D0
	BEQ.S	L400
	BRA.S	L401
L400:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3208(A4)
	BRA.S	L28T261_053
	BRA.S	L402
L401:
	CMP	#78,D0
	BEQ.S	L402
	BRA.S	L403
L402:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3206(A4)
	BRA.S	L28T261_053
	BRA.S	L404
L403:
	CMP	#75,D0
	BEQ.S	L404
	BRA.S	L405
L404:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	SUBQ.B	#1,(A0)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L349
	BRA.S	L406
L405:
	CMP	#13,D0
	BEQ.S	L406
	BRA.S	L407
L406:
	MOVE.L	A3,-(A7)
	JSR	F255_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L349
	BRA.S	L408
L407:
	CMP	#79,D0
	BEQ.S	L408
	BRA.S	L409
L408:
	SUBQ.B	#1,G407_s_Par+3203(A4)
L409:
L410:
L349:
L346:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L341:
	JSR	F240_xxxx_(PC)
	TST	D0
	BNE	L342(PC)
L343:
L340:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$339:	.EQU	#-10
