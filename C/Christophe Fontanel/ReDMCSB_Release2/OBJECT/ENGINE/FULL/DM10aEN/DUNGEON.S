BSS SEG "bss"
G233_ai_Gr:/* global */
	.WORD	#8
G234_ai_Gr:/* global */
	.WORD	#8
G235_auc_G:/* global */
	.WORD	#16
G236_auc_G:/* global */
	.WORD	#16
G237_as_Gr:/* global */
	.WORD	#1080
G238_as_Gr:/* global */
	.WORD	#276
G239_as_Gr:/* global */
	.WORD	#232
G240_i_Gra:/* global */
	.WORD	#2
G241_ac_Gr:/* global */
	.WORD	#54
G242_ai_Gr:/* global */
	.WORD	#16
G243_as_Gr:/* global */
	.WORD	#702
G244_auc_G:/* global */
	.WORD	#8
G245_aui_G:/* global */
	.WORD	#6
G246_aui_G:/* global */
	.WORD	#4
G247_aui_G:/* global */
	.WORD	#4
G248_aui_G:/* global */
	.WORD	#14
G249_aui_G:/* global */
	.WORD	#10
G250_aui_G:/* global */
	.WORD	#6
G251_aui_G:/* global */
	.WORD	#6
G252_aui_G:/* global */
	.WORD	#8
G253_aui_G:/* global */
	.WORD	#22
G254_as_Gr:/* global */
	.WORD	#8
G255_aac_G:/* global */
	.WORD	#256
G256_aac_G:/* global */
	.WORD	#64
G257_aac_G:/* global */
	.WORD	#256
G258_auc_G:/* global */
	.WORD	#4
G259_i_Gra:/* global */
	.WORD	#2
G260_pui_D:/* global */
	.WORD	#4
G261_auc_C:/* global */
	.WORD	#16
G262_auc_C:/* global */
	.WORD	#16
G263_auc_C:/* global */
	.WORD	#18
G264_puc_C:/* global */
	.WORD	#4
G265_i_Cur:/* global */
	.WORD	#2
G266_i_Cur:/* global */
	.WORD	#2
G267_ai_Cu:/* global */
	.WORD	#6
G268_ai_Cu:/* global */
	.WORD	#2
G269_ps_Cu:/* global */
	.WORD	#4
G270_pui_C:/* global */
	.WORD	#4
G271_ppuc_:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#-1,G272_i_Cur(A4)
BSS SEG "bss"
G272_i_Cur:/* global */
	.WORD	#2
G273_i_Cur:/* global */
	.WORD	#2
G274_i_Cur:/* global */
	.WORD	#2
G275_as_Cu:/* global */
	.WORD	#4
G276_puc_D:/* global */
	.WORD	#4
G277_ps_Du:/* global */
	.WORD	#4
G278_ps_Du:/* global */
	.WORD	#4
G279_pppuc:/* global */
	.WORD	#4
G280_pui_D:/* global */
	.WORD	#4
G281_pi_Du:/* global */
	.WORD	#4
G282_ui_Du:/* global */
	.WORD	#2
G283_pT_Sq:/* global */
	.WORD	#4
G284_apuc_:/* global */
	.WORD	#64
CODE SEG "dunman"
F139_aqzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D6
	AND	#1023,D6
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D6
	MOVE.L	D1,A0
	ADDA	D6,A0
	MOVE.B	4(A0),D6
	AND	#255,D6
	MOVE	10(A6),D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	8(A2),D0
	AND	#1984,D0
	LSR	#6,D0
	MOVE	10(A6),D1
	ASL.L	#2,D1
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D1,A0
	ASL.L	#2,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE	8(A2),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	AND.L	#65535,D1
	ADD.L	D1,D0
	ADDQ.L	#1,D0
	MOVE.L	D0,A3
	MOVE	12(A2),D7
	AND	#240,D7
	LSR	#4,D7
	BRA.S	L2
L3:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	D6,D0
	BNE.S	L6
	MOVE	#1,D0
	BRA.S	L1
L6:
L4:
	SUBQ	#1,D7
L2:
	CMPI	#0,D7
	BGT.S	L3
L5:
	MOVE	#0,D0
L1:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F140_yzzz_:/* global */
	LINK	A6,L$7
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	CMPI	#-1,D7
	BNE.S	L9
	MOVE	#0,D0
	BRA	L8(PC)
L9:
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L10:
	CMP	#5,D0
	BEQ.S	L11
	BRA.S	L13
L11:
	MOVE.L	A3,D6
	MOVE.L	D6,A0
	MOVE	2(A0),D6
	AND	#127,D6
	MULS	#6,D6
	LEA	G238_as_Gr(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	BRA	L12(PC)
	BRA.S	L14
L13:
	CMP	#6,D0
	BEQ.S	L14
	BRA.S	L15
L14:
	MOVE.L	A3,D6
	MOVE.L	D6,A0
	MOVE	2(A0),D6
	AND	#127,D6
	ASL.L	#2,D6
	LEA	G239_as_Gr(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	BRA	L12(PC)
	BRA.S	L16
L15:
	CMP	#10,D0
	BEQ.S	L16
	BRA.S	L17
L16:
	MOVE	2(A3),D6
	AND	#127,D6
	LEA	G241_ac_Gr(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE	2(A3),D0
	AND	#127,D0
	CMPI	#1,D0
	BNE.S	L19
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	ASL	#1,D0
	ADD	D0,D6
L19:
	BRA.S	L12
	BRA.S	L18
L17:
	CMP	#9,D0
	BEQ.S	L18
	BRA.S	L20
L18:
	MOVE	#50,D6
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE	2(A0),D7
	BRA.S	L22
L23:
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	ADD	D0,D6
L24:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L22:
	CMPI	#-2,D7
	BNE.S	L23
L25:
	BRA.S	L12
	BRA.S	L21
L20:
	CMP	#8,D0
	BEQ.S	L21
	BRA.S	L26
L21:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#32512,D0
	LSR	#8,D0
	CMPI	#20,D0
	BNE.S	L28
	MOVE	#1,D6
	BRA.S	L29
L28:
	MOVE	#3,D6
L29:
	BRA.S	L12
	BRA.S	L27
L26:
	CMP	#7,D0
	BEQ.S	L27
	BRA.S	L30
L27:
	MOVE	#1,D6
L30:
L31:
L12:
	MOVE	D6,D0
L8:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$7:	.EQU	#0
F141_anzz_:/* global */
	LINK	A6,L$32
	MOVE.L	A3,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	8(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L34:
	CMP	#7,D0
	BEQ.S	L35
	BRA.S	L37
L35:
	MOVE	#0,D0
	BRA	L33(PC)
	BRA.S	L38
L37:
	CMP	#9,D0
	BEQ.S	L38
	BRA.S	L39
L38:
	MOVE	#1,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	4(A0),D1
	AND	#6,D1
	LSR	#1,D1
	ADD	D1,D0
	BRA	L33(PC)
	BRA.S	L40
L39:
	CMP	#10,D0
	BEQ.S	L40
	BRA.S	L41
L40:
	MOVE	#127,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#127,D1
	ADD	D1,D0
	BRA.S	L33
	BRA.S	L42
L41:
	CMP	#5,D0
	BEQ.S	L42
	BRA.S	L43
L42:
	MOVE	#23,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#127,D1
	ADD	D1,D0
	BRA.S	L33
	BRA.S	L44
L43:
	CMP	#6,D0
	BEQ.S	L44
	BRA.S	L45
L44:
	MOVE	#69,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#127,D1
	ADD	D1,D0
	BRA.S	L33
	BRA.S	L46
L45:
	CMP	#8,D0
	BEQ.S	L46
	BRA.S	L47
L46:
	MOVE	#2,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#32512,D1
	LSR	#8,D1
	ADD	D1,D0
	BRA.S	L33
L48:
	MOVE	#-1,D0
	BRA.S	L33
	BRA.S	L49
L47:
	BRA.S	L48
L49:
L36:
L33:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$32:	.EQU	#0
F142_aqzz_:/* global */
	LINK	A6,L$50
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#15,D0
	BNE.S	L52
	CMPI	#-128,D7
	BNE.S	L53
	MOVE	#-11,D0
	BRA	L51(PC)
L53:
	CMPI	#-127,D7
	BNE.S	L54
	MOVE	#-13,D0
	BRA.S	L51
L54:
	CMPI	#-126,D7
	BNE.S	L55
	MOVE	#-4,D0
	BRA.S	L51
L55:
	CMPI	#-122,D7
	BEQ.S	L57
	CMPI	#-121,D7
	BNE.S	L56
L57:
	MOVE	#-14,D0
	BRA.S	L51
L56:
	MOVE	#-12,D0
	BRA.S	L51
	BRA.S	L58
L52:
	CMPI	#5,D6
	BNE.S	L59
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+20(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	LSR	#8,D0
	AND	#31,D0
	MOVE	D0,D5
	BEQ.S	L59
	MOVE	D5,D0
	NEG	D0
	BRA.S	L51
L59:
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
L58:
L51:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$50:	.EQU	#0
F143_mzzz_:/* global */
	LINK	A6,L$60
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	1(A3),D7
	AND	#255,D7
	MOVE	12(A6),D0
	BEQ.S	L62
	MOVE.B	2(A3),D0
	AND	#255,D0
	AND	#7,D0
	ADDQ	#4,D0
	MOVE	D0,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L62:
	MOVE	D7,D0
L61:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$60:	.EQU	#0
F144_amzz_:/* global */
	LINK	A6,L$63
	MOVE	8(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L64:
	UNLK	A6
	RTS
L$63:	.EQU	#0
F145_rzzz_:/* global */
	LINK	A6,L$65
	MOVE	D7,-(A7)
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D7
	AND	#255,D7
	MOVE	12(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L67
	MOVE.B	D7,D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	MOVE.B	3(A0),D7
L67:
	MOVE.B	D7,D0
	AND	#255,D0
L66:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$65:	.EQU	#0
F146_aczz_:/* global */
	LINK	A6,L$68
	MOVE	14(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L70
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D1
	AND	#255,D1
	MULS	#16,D1
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,3(A0)
	BRA.S	L71
L70:
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MOVE.B	D0,5(A0)
L71:
L69:
	UNLK	A6
	RTS
L$68:	.EQU	#0
F147_aawz_:/* global */
	LINK	A6,L$72
	MOVE	12(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L74
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	BRA.S	L73
L74:
	MOVE.L	8(A6),A0
	MOVE	14(A0),D0
	AND	#768,D0
	LSR	#8,D0
	LEA	G258_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
L73:
	UNLK	A6
	RTS
L$72:	.EQU	#0
F148_aayz_:/* global */
	LINK	A6,L$75
	MOVE	14(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L77
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D1
	AND	#255,D1
	MULS	#16,D1
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,2(A0)
	BRA.S	L78
L77:
	MOVE	12(A6),D0
	AND	#3,D0
	MOVE.L	8(A6),A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-769,14(A0)
	OR	D3,14(A0)
L78:
L76:
	UNLK	A6
	RTS
L$75:	.EQU	#0
F149_aawz_:/* global */
	LINK	A6,L$79
	MOVE	D7,-(A7)
	CMPI	#0,8(A6)
	BLT.S	L81
	CLR	D7
	BRA.S	L82
L83:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G267_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	CMP	8(A6),D0
	BNE.S	L86
	MOVE	#1,D0
	BRA.S	L80
L86:
L84:
	ADDQ	#1,D7
L82:
	CMPI	#3,D7
	BLT.S	L83
L85:
L81:
	MOVE	#0,D0
L80:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$79:	.EQU	#0
F150_wzzz_:/* global */
	LINK	A6,L$87
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE.L	14(A6),A3
	MOVE.L	18(A6),A2
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D6,D1
	MOVE	(A3),D0
	ADD	D1,D0
	MOVE	D0,(A3)
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D6,D1
	MOVE	(A2),D0
	ADD	D1,D0
	MOVE	D0,(A2)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,D7
	MOVE	D7,D0
	AND	#3,D0
	MOVE	D0,D7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D5,D1
	MOVE	(A3),D0
	ADD	D1,D0
	MOVE	D0,(A3)
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D5,D1
	MOVE	(A2),D0
	ADD	D1,D0
	MOVE	D0,(A2)
L88:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$87:	.EQU	#0
F151_rzzz_:/* global */
	LINK	A6,L$89
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CMPI	#0,D6
	SGE	D4
	TST.B	D4
	BEQ.S	L91
	MOVE	D6,D4
	CMP	G274_i_Cur(A4),D4
	SLT	D4
	TST.B	D4
L91:
	AND	#1,D4
	CMPI	#0,D7
	SGE	D0
	TST.B	D0
	BEQ.S	L93
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	SLT	D0
	TST.B	D0
L93:
	AND	#1,D0
	MOVE	D0,D5
	BEQ.S	L92
	MOVE	D4,D0
	BEQ.S	L92
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	BRA	L90(PC)
L92:
	MOVE	D4,D0
	BEQ.S	L94
	CMPI	#-1,D7
	BNE.S	L97
	MOVE.L	G271_ppuc_(A4),A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D4
	CMPI	#1,D0
	BEQ.S	L96
L97:
	CMPI	#2,D4
	BNE.S	L95
L96:
	MOVE	#4,D0
	BRA	L90(PC)
L95:
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BNE.S	L100
	MOVE	G273_i_Cur(A4),D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	-4(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D4
	CMPI	#1,D0
	BEQ.S	L99
L100:
	CMPI	#2,D4
	BNE.S	L98
L99:
	MOVE	#1,D0
	BRA.S	L90
L98:
	BRA.S	L101
L94:
	MOVE	D5,D0
	BEQ.S	L102
	CMPI	#-1,D6
	BNE.S	L105
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D5
	CMPI	#1,D0
	BEQ.S	L104
L105:
	CMPI	#2,D5
	BNE.S	L103
L104:
	MOVE	#2,D0
	BRA.S	L90
L103:
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BNE.S	L108
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	G274_i_Cur(A4),A0
	MOVE.B	-1(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D5
	CMPI	#1,D0
	BEQ.S	L107
L108:
	CMPI	#2,D5
	BNE.S	L106
L107:
	MOVE	#8,D0
	BRA.S	L90
L106:
L102:
L101:
	MOVE	#0,D0
L90:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$89:	.EQU	#0
F152_xxxx_:/* global */
	LINK	A6,L$109
	PEA	16(A6)
	PEA	14(A6)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
L110:
	UNLK	A6
	RTS
L$109:	.EQU	#0
F153_yzzz_:/* global */
	LINK	A6,L$111
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F152_xxxx_(PC)
	ADDA	#10,A7
	AND	#255,D0
	ASR	#5,D0
L112:
	UNLK	A6
	RTS
L$111:	.EQU	#0
F154_afzz_:/* global */
	LINK	A6,L$113
	MOVEM.L	A3/D7-D4,-(A7)
	CMPI	#255,G309_i_Par(A4)
	BNE.S	L115
	MOVE	#-1,D0
	BRA	L114(PC)
L115:
	MOVE.L	G277_ps_Du(A4),D0
	MOVE	8(A6),D1
	MULS	#16,D1
	ADD.L	D1,D0
	MOVE.L	D0,A3
	MOVE.B	6(A3),D7
	MOVE.L	12(A6),A0
	AND	#255,D7
	ADD	(A0),D7
	MOVE.B	7(A3),D6
	MOVE.L	16(A6),A0
	AND	#255,D6
	ADD	(A0),D6
	MOVE	8(A3),D5
	AND	#63,D5
	ADD	10(A6),D5
	MOVE	#0,D0
	MOVE	D0,-2(A6)
	MOVE.L	G277_ps_Du(A4),D0
	MOVE.L	D0,A3
	BRA	L116(PC)
L117:
	MOVE	8(A3),D0
	AND	#63,D0
	MOVE	D5,D1
	CMP	D1,D0
	BNE.S	L119
	MOVE	D7,D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D4
	CMP	D1,D0
	BLT.S	L119
	MOVE	D4,D0
	MOVE	8(A3),D1
	AND	#1984,D1
	LSR	#6,D1
	ADD	D1,D0
	MOVE	D0,-12(A6)
	MOVE	D7,D0
	CMP	-12(A6),D0
	BHI.S	L119
	MOVE	D6,D0
	MOVE.B	7(A3),D1
	AND	#255,D1
	MOVE	D1,D4
	CMP	D1,D0
	BLT.S	L119
	MOVE	D4,D0
	MOVE	8(A3),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	ADD	D1,D0
	MOVE	D0,-12(A6)
	MOVE	D6,D0
	CMP	-12(A6),D0
	BHI.S	L119
	MOVE	D6,D0
	SUB	D4,D0
	MOVE.L	16(A6),A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	MOVE.B	6(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.L	12(A6),A0
	MOVE	D0,(A0)
	MOVE	-2(A6),D0
	BRA.S	L114
L119:
	MOVE	-2(A6),D0
	ADDQ	#1,-2(A6)
	MOVE.L	A3,D0
	ADDA	#16,A3
L116:
	MOVE	-2(A6),D0
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BLT	L117(PC)
L118:
	MOVE	#-1,D0
L114:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$113:	.EQU	#-12
F155_ahzz_:/* global */
	LINK	A6,L$120
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	AND	#8,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D4
	BEQ.S	L122
	MOVE	D7,D0
	ADD	G233_ai_Gr+2(A4),D0
	MOVE	D0,D7
	MOVE	D6,D0
	ADD	G234_ai_Gr+2(A4),D0
	MOVE	D0,D6
	BRA.S	L123
L122:
	MOVE	D7,D0
	ADD	G233_ai_Gr(A4),D0
	MOVE	D0,D7
	MOVE	D6,D0
	ADD	G234_ai_Gr(A4),D0
	MOVE	D0,D6
L123:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D5
	CMPI	#0,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L124
	CMPI	#3,D5
	SEQ	D0
	TST.B	D0
L124:
	AND	#1,D0
	ASL	#1,D0
	ADD	D4,D0
L121:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$120:	.EQU	#0
F156_afzz_:/* global */
	LINK	A6,L$125
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#1023,D0
	MOVE	D7,D1
	AND	#15360,D1
	LSR	#2,D1
	LSR	#8,D1
	LEA	G235_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULU	D1,D0
	MOVE	D0,-10(A6)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE	-10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
L126:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$125:	.EQU	#-10
F159_rzzz_:/* global */
	LINK	A6,L$127
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	(A0),D0
L128:
	UNLK	A6
	RTS
L$127:	.EQU	#-4
F160_xxxx_:/* global */
	LINK	A6,L$129
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	CMPI	#0,D7
	BLT.S	L132
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BGE.S	L132
	CMPI	#0,D6
	BLT.S	L132
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BGE.S	L132
	MOVE.L	A3,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#16,D0
	BNE.S	L131
L132:
	MOVE	#-1,D0
	BRA.S	L130
L131:
	CLR	D4
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	G270_pui_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L133
L134:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L136
	ADDQ	#1,D5
L136:
L133:
	MOVE	D4,D0
	ADDQ	#1,D4
	CMP	D6,D0
	BNE.S	L134
L135:
	MOVE	D5,D0
L130:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$129:	.EQU	#0
F161_szzz_:/* global */
	LINK	A6,L$137
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F160_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-2(A6)
	CMPI	#-1,D0
	BNE.S	L139
	MOVE	#-2,D0
	BRA.S	L138
L139:
	MOVE	-2(A6),D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L138:
	UNLK	A6
	RTS
L$137:	.EQU	#-2
F162_afzz_:/* global */
	LINK	A6,L$140
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L142
L143:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L142:
	CMPI	#-2,D7
	BEQ.S	L145
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#4,D0
	BCS.S	L143
L145:
L144:
	MOVE	D7,D0
L141:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$140:	.EQU	#0
F163_amzz_:/* global */
	LINK	A6,L$146
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CMPI	#-2,8(A6)
	BNE.S	L148
	BRA	L147(PC)
L148:
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	#-2,(A0)
	CMPI	#0,D7
	BLT	L149(PC)
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L150
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,10(A6)
	BRA	L151(PC)
L150:
	ORI.B	#16,(A2)
	MOVE.L	G270_pui_C(A4),D0
	MOVE	D7,D1
	EXT.L	D1
	ASL.L	#1,D1
	ADD.L	D1,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,A3
	MOVE	G282_ui_Du(A4),D4
	MOVE	G272_i_Cur(A4),D1
	ASL.L	#1,D1
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	ADD	D7,D1
	SUB	D1,D4
	SUBQ	#1,D4
	BRA.S	L152
L153:
	ADDQ	#1,(A3)+
L152:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L153
L154:
	CLR	-6(A6)
	MOVE	D6,D0
	EXT.L	D0
	SUBA.L	D0,A2
	MOVE	D7,D4
	ASL.L	#1,D4
	MOVE.L	G270_pui_C(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	BRA.S	L155
L156:
	MOVE.B	(A2)+,D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L158
	ADDQ	#1,D4
L158:
L155:
	MOVE	-6(A6),D0
	ADDQ	#1,-6(A6)
	MOVE	D6,D1
	CMP	D1,D0
	BNE.S	L156
L157:
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	SUB	D4,D0
	SUBQ	#1,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	8(A6),(A3)
	BRA.S	L147
L151:
L149:
	MOVE	10(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	BRA.S	L159
L160:
L161:
	MOVE	D5,D0
	MOVE	D0,10(A6)
	MOVE	D0,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
L159:
	CMPI	#-2,D5
	BNE.S	L160
L162:
	MOVE	10(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	8(A6),(A0)
L147:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$146:	.EQU	#-6
F164_dzzz_:/* global */
	LINK	A6,L$163
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	CMPI	#-2,D7
	BNE.S	L165
	BRA	L164(PC)
L165:
	AND	#16383,D7
	CMPI	#0,12(A6)
	BLT	L166(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F160_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#-2,(A3)
	BNE	L167(PC)
	MOVE	(A2),D0
	AND	#16383,D0
	CMP	D7,D0
	BNE	L167(PC)
	MOVE	12(A6),D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	14(A6),A0
	ANDI.B	#-17,(A0)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	SUBQ	#1,D0
	MOVE	D0,D5
	SUB	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	A2,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	G270_pui_C(A4),D0
	MOVE	12(A6),D1
	EXT.L	D1
	ASL.L	#1,D1
	ADD.L	D1,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,A2
	MOVE	G282_ui_Du(A4),D5
	MOVE	G272_i_Cur(A4),D1
	ASL.L	#1,D1
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	ADD	12(A6),D1
	SUB	D1,D5
	SUBQ	#1,D5
	BRA.S	L168
L169:
	SUBQ	#1,(A2)+
L168:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L169
L170:
	BRA.S	L23T164_011
L167:
	MOVE	(A2),D0
	AND	#16383,D0
	CMP	D7,D0
	BNE.S	L171
	MOVE	(A3),(A2)
	BRA.S	L23T164_011
L171:
	MOVE	(A2),10(A6)
L166:
	MOVE	10(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	BRA.S	L172
L173:
	CMPI	#-2,D4
	BEQ.S	L177
	CMPI	#-1,D4
	BNE.S	L176
L177:
	BRA.S	L23T164_011
L176:
L174:
	MOVE	D4,D0
	MOVE	D0,10(A6)
	MOVE	D0,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L172:
	MOVE	D4,D0
	AND	#16383,D0
	CMP	D7,D0
	BNE.S	L173
L175:
	MOVE	10(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,(A3)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
L23T164_011:
	MOVE	#-2,(A3)
L164:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$163:	.EQU	#0
F165_xxxx_:/* global */
	LINK	A6,L$178
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CMPI	#15,8(A6)
	BNE.S	L180
	MOVE	#-1,D0
	BRA	L179(PC)
L180:
	MOVE	G272_i_Cur(A4),-8(A6)
	MOVE	8(A6),D0
	LEA	G294_auc_L(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L181
	ADDQ	#1,D4
	MOVE	D4,D0
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BCS.S	L181
	CLR	D4
L181:
	MOVE	D4,-6(A6)
L182:
	MOVE	D4,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	MOVE	D0,-10(A6)
	MOVE	D4,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#-2048,D0
	LSR	#3,D0
	LSR	#8,D0
	MOVE	D0,-12(A6)
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	MOVE.L	(A0),A3
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#1,D0
	MOVE.L	G280_pui_D(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CLR	D7
	BRA	L185(PC)
L186:
	CLR	D6
	BRA	L189(PC)
L190:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	AND	#16,D0
	BEQ	L193(PC)
	MOVE	(A2)+,D5
	MOVE	D4,D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L194
	MOVE	D7,D0
	SUB	G306_i_Par(A4),D0
	ADDQ	#5,D0
	CMPI	#10,D0
	BHI.S	L194
	MOVE	D6,D0
	SUB	G307_i_Par(A4),D0
	ADDQ	#5,D0
	CMPI	#10,D0
	BHI.S	L194
	BRA	L195(PC)
L194:
L196:
	MOVE	D5,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMP	8(A6),D0
	BNE	L199(PC)
	MOVE	D5,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE	8(A6),D0
L200:
	CMP	#4,D0
	BEQ.S	L201
	BRA.S	L203
L201:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	14(A0),D0
	AND	#1024,D0
	LSR	#2,D0
	LSR	#8,D0
	BEQ.S	L205
	BRA	L197(PC)
L205:
	BRA.S	L204
L203:
	CMP	#14,D0
	BEQ.S	L204
	BRA.S	L206
L204:
	MOVE	D4,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#4,8(A6)
	BNE.S	L208
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F188_aozz_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L209
L208:
	MOVE	D5,-(A7)
	JSR	F214_pzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR.L	-(A7)
	MOVE	D5,-(A7)
	JSR	F215_lzzz_(PC)
	ADDA	#10,A7
L209:
	BRA	L202(PC)
	BRA.S	L207
L206:
	CMP	#6,D0
	BEQ.S	L207
	BRA.S	L210
L207:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L212
	BRA	L197(PC)
L212:
	BRA.S	L24T165_026
	BRA.S	L211
L210:
	CMP	#5,D0
	BEQ.S	L211
	BRA.S	L213
L211:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L215
	BRA	L197(PC)
L215:
	BRA.S	L24T165_026
	BRA.S	L214
L213:
	CMP	#10,D0
	BEQ.S	L214
	BRA.S	L216
L214:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L218
	BRA.S	L197
L218:
	BRA.S	L24T165_026
	BRA.S	L217
L216:
	CMP	#8,D0
	BEQ.S	L217
	BRA.S	L219
L217:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#-32768,D0
	LSR	#7,D0
	LSR	#8,D0
	BEQ.S	L221
	BRA.S	L197
L221:
L24T165_026:
	MOVE	D4,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L219:
L220:
L202:
	MOVE	-8(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D4,D0
	MOVE	8(A6),D1
	LEA	G294_auc_L(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D5,D0
	AND	#16383,D0
	BRA	L179(PC)
L199:
L197:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE	L196(PC)
L198:
L195:
L193:
L191:
	ADDQ	#1,D6
L189:
	MOVE	D6,D0
	CMP	-12(A6),D0
	BLS	L190(PC)
L192:
L187:
	ADDQ	#1,D7
L185:
	MOVE	D7,D0
	CMP	-10(A6),D0
	BLS	L186(PC)
L188:
	MOVE	D4,D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L223
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#1,D0
	BGT.S	L222
L223:
	MOVE	D4,D0
	MOVE	8(A6),D1
	LEA	G294_auc_L(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	#-1,D0
	BRA.S	L179
L222:
L224:
	ADDQ	#1,D4
	MOVE	D4,D0
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BCS.S	L227
	CLR	D4
L227:
L225:
	MOVE	D4,D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L224
L226:
	MOVE	D4,D0
	CMP	-6(A6),D0
	BNE.S	L228
	MOVE	G309_i_Par(A4),D4
L228:
L183:
	BRA	L182(PC)
L184:
L179:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$178:	.EQU	#-12
F166_szzz_:/* global */
	LINK	A6,L$229
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D4
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D4
	LEA	12(A0),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	CMPI	#-32758,D7
	BNE.S	L231
	MOVE	#10,D7
	BRA.S	L232
L231:
	CMPI	#10,D7
	BNE.S	L233
	SUBQ	#3,D4
L233:
L232:
	MOVE	D4,D6
	MOVE	D7,D5
	LEA	G235_auc_G(A4),A0
	ADDA	D5,A0
	MOVE.B	(A0),D5
	AND	#255,D5
	ASR	#1,D5
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
L234:
	CMPI	#-1,(A3)
	BNE.S	L237
	MOVE	D7,D0
	ASL	#2,D0
	ASL	#8,D0
	MOVE	D4,D1
	SUB	D6,D1
	OR	D1,D0
	MOVE	D0,-2(A6)
	BRA.S	L236
L237:
	SUBQ	#1,D6
	BEQ.S	L238
	MOVE	D5,D0
	EXT.L	D0
	ASL.L	#1,D0
	ADDA.L	D0,A3
	BRA.S	L239
L238:
	MOVE	D7,-(A7)
	JSR	F165_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#-1,D0
	BNE.S	L240
	MOVE	#-1,D0
	BRA.S	L230
L240:
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L236
L239:
L235:
	BRA.S	L234
L236:
	MOVE	D5,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-2,(A3)
	MOVE	-2(A6),D0
L230:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$229:	.EQU	#-2
F167_aozz_:/* global */
	LINK	A6,L$241
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	#5,D5
	CMPI	#4,D7
	BCS.S	L243
	CMPI	#7,D7
	BHI.S	L243
	MOVE	#4,D7
L243:
	MOVE	D7,D0
L244:
	CMP	#54,D0
	BEQ.S	L245
	BRA.S	L247
L245:
	MOVE	#30,D6
	BRA	L246(PC)
	BRA.S	L248
L247:
	CMP	#128,D0
	BEQ.S	L248
	BRA.S	L249
L248:
	MOVE	#25,D6
	MOVE	#10,D5
	BRA.S	L246
	BRA.S	L250
L249:
	CMP	#51,D0
	BEQ.S	L250
	BRA.S	L251
L250:
	MOVE	#27,D6
	BRA.S	L246
	BRA.S	L252
L251:
	CMP	#52,D0
	BEQ.S	L252
	BRA.S	L253
L252:
	MOVE	#28,D6
	BRA.S	L246
	BRA.S	L254
L253:
	CMP	#55,D0
	BEQ.S	L254
	BRA.S	L255
L254:
	MOVE	#31,D6
	BRA.S	L246
	BRA.S	L256
L255:
	CMP	#56,D0
	BEQ.S	L256
	BRA.S	L257
L256:
	MOVE	#32,D6
	BRA.S	L246
	BRA.S	L258
L257:
	CMP	#32,D0
	BEQ.S	L258
	BRA.S	L259
L258:
	MOVE	#8,D6
	BRA.S	L246
	BRA.S	L260
L259:
	CMP	#4,D0
	BEQ.S	L260
	BRA.S	L261
L260:
	MOVE	#2,D6
	BRA.S	L246
L262:
	MOVE	#-1,D0
	BRA.S	L242
	BRA.S	L263
L261:
	BRA.S	L262
L263:
L246:
	MOVE	D5,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#-1,D0
	BNE.S	L264
	MOVE	#-1,D0
	BRA.S	L242
L264:
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D6,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A3)
	OR	D3,2(A3)
	CMPI	#4,D7
	BNE.S	L265
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#-32768,D0
	LSR	#7,D0
	LSR	#8,D0
	BEQ.S	L265
	MOVE	#15,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-15361,2(A0)
	OR	D3,2(A0)
L265:
	MOVE	D4,D0
L242:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$241:	.EQU	#0
F168_ajzz_:/* global */
	LINK	A6,L$266
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	14(A6),D7
	MOVE	12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+8(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-12(A6),A0
	MOVEQ	#1,D0
	JSR	_blockmv(PC)
	MOVE	-10(A6),D0
	AND	#1,D0
	BNE.S	L269
	MOVE	D7,D0
	AND	#-32768,D0
	BEQ	L268(PC)
L269:
	AND	#32767,D7
	CMPI	#1,D7
	BNE.S	L270
	MOVE.B	#10,(A3)+
	MOVE.B	#32,-1(A6)
	BRA.S	L271
L270:
	CMPI	#0,D7
	BNE.S	L272
	MOVE.B	#-128,-1(A6)
	BRA.S	L273
L272:
	MOVE.B	#10,-1(A6)
L273:
L271:
	CLR	D5
	CLR	-4(A6)
	MOVE.L	G260_pui_D(A4),D0
	MOVE	-10(A6),D1
	AND	#-8,D1
	LSR	#3,D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
L274:
	MOVE	D5,D0
	BNE.S	L277
	MOVE	(A2)+,D6
	MOVE	D6,D4
	LSR	#2,D4
	LSR	#8,D4
	AND	#31,D4
	BRA.S	L278
L277:
	CMPI	#1,D5
	BNE.S	L279
	MOVE	D6,D4
	LSR	#5,D4
	AND	#31,D4
	BRA.S	L280
L279:
	MOVE	D6,D4
	AND	#31,D4
L280:
L278:
	ADDQ	#1,D5
	MOVE	D5,D0
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	MOVE	D0,D5
	MOVE	-4(A6),D0
	BEQ.S	L281
	CLR.B	(A3)
	CMPI	#30,-4(A6)
	BNE.S	L282
	CMPI	#0,D7
	BEQ.S	L283
	MOVE	D4,D0
	ASL.L	#3,D0
	LEA	G255_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
	BRA.S	L284
L283:
	MOVE	D4,D0
	ASL.L	#3,D0
	LEA	G257_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
L284:
	BRA.S	L285
L282:
	CMPI	#0,D7
	BEQ.S	L286
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G256_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
	BRA.S	L287
L286:
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G256_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
L287:
L285:
	MOVE.L	-8(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE.L	-8(A6),-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	EXT.L	D0
	ADDA.L	D0,A3
	CLR	-4(A6)
	BRA.S	L288
L281:
	CMPI	#28,D4
	BCC.S	L289
	CMPI	#0,D7
	BEQ.S	L290
	CMPI	#26,D4
	BNE.S	L291
	MOVE	#32,D4
	BRA.S	L292
L291:
	CMPI	#27,D4
	BNE.S	L293
	MOVE	#46,D4
	BRA.S	L294
L293:
	ADD	#65,D4
L294:
L292:
L290:
	MOVE	D4,D0
	MOVE.B	D0,(A3)+
	BRA.S	L295
L289:
	CMPI	#28,D4
	BNE.S	L296
	MOVE.B	-1(A6),(A3)+
	BRA.S	L297
L296:
	CMPI	#30,D4
	BHI.S	L298
	MOVE	D4,-4(A6)
	BRA.S	L299
L298:
	BRA.S	L276
L299:
L297:
L295:
L288:
L275:
	BRA	L274(PC)
L276:
L268:
	CMPI	#0,D7
	BNE.S	L300
	MOVE.B	#-127,(A3)
	BRA.S	L301
L300:
	CLR.B	(A3)
L301:
L267:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$266:	.EQU	#-12
F169_xxxx_:/* global */
	LINK	A6,L$302
	MOVE	8(A6),D0
	MULU	#31417,D0
	LSR	#1,D0
	MOVE	10(A6),D1
	MULU	#11,D1
	ADD	D1,D0
	MOVE.L	G278_ps_Du(A4),A0
	ADD	(A0),D0
	LSR	#2,D0
	AND.L	#65535,D0
	DIVU	12(A6),D0
	SWAP	D0
L303:
	UNLK	A6
	RTS
L$302:	.EQU	#0
F170_xxxx_:/* global */
	LINK	A6,L$304
	MOVE	8(A6),D0
	BEQ.S	L306
	MOVE	16(A6),-(A7)
	MOVE	#3000,D0
	MOVE	G272_i_Cur(A4),D1
	ASL	#6,D1
	ADD	D1,D0
	ADD	G273_i_Cur(A4),D0
	ADD	G274_i_Cur(A4),D0
	MOVE	D0,-(A7)
	MOVE	#2000,D0
	MOVE	12(A6),D1
	ASL	#5,D1
	ADD	D1,D0
	ADD	14(A6),D0
	MOVE	D0,-(A7)
	JSR	F169_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-2(A6)
	CMP	10(A6),D0
	BGE.S	L306
	MOVE	-2(A6),D0
	ADDQ	#1,D0
	BRA.S	L305
L306:
	MOVE	#0,D0
L305:
	UNLK	A6
	RTS
L$304:	.EQU	#-2
F171_xxxx_:/* global */
	LINK	A6,L$307
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	18(A6),D7
	MOVE	20(A6),D6
	MOVE	22(A6),D5
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D4
	AND	#240,D4
	LSR	#4,D4
	MOVE	#30,-(A7)
	ADDQ	#1,D5
	MOVE	D5,D0
	ADDQ	#1,D7
	MOVE	D7,D1
	AND	#3,D1
	ADDQ	#1,D1
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,4(A3)
	MOVE	#30,-(A7)
	MOVE	D5,D0
	ADDQ	#1,D7
	MOVE	D7,D1
	AND	#3,D1
	ADDQ	#1,D1
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	MOVE	14(A6),-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,6(A3)
	MOVE	#30,-(A7)
	MOVE	D5,D0
	SUBQ	#1,D5
	ADDQ	#1,D7
	MOVE	D7,D1
	AND	#3,D1
	ADDQ	#1,D1
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	MOVE	16(A6),-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,8(A3)
	MOVE	24(A6),D0
	BNE.S	L310
	CMPI	#0,D6
	BLT.S	L310
	MOVE	D6,D0
	CMP	G273_i_Cur(A4),D0
	BGE.S	L310
	CMPI	#0,D5
	BLT.S	L310
	MOVE	D5,D0
	CMP	G274_i_Cur(A4),D0
	BLT.S	L309
L310:
	MOVE	#2,D4
	BRA.S	L311
L312:
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F149_aawz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L315
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	CLR	(A0)
L315:
L313:
	ADDQ	#1,D4
L311:
	CMPI	#4,D4
	BLE.S	L312
L314:
L309:
L308:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$307:	.EQU	#0
F172_awzz_:/* global */
	LINK	A6,L$316
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	MOVE	#10,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-12(A6)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,D4
	MOVE.B	D4,D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,(A3)
L318:
	CMP	#0,D0
	BEQ.S	L319
	BRA	L321(PC)
L319:
	MOVE	D7,D0
L323:
	CMP	#0,D0
	BEQ.S	L324
	BRA.S	L326
L324:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#2,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#1,D0
	MOVE	D0,-6(A6)
	BRA	L325(PC)
	BRA.S	L327
L326:
	CMP	#1,D0
	BEQ.S	L327
	BRA.S	L328
L327:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#2,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#1,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-6(A6)
	BRA.S	L325
	BRA.S	L329
L328:
	CMP	#2,D0
	BEQ.S	L329
	BRA.S	L330
L329:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,-6(A6)
	BRA.S	L325
	BRA.S	L331
L330:
	CMP	#3,D0
	BEQ.S	L331
	BRA.S	L332
L331:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#2,D0
	MOVE	D0,-6(A6)
L332:
L333:
L325:
	CLR	G289_i_Dun(A4)
	CLR	-10(A6)
L31T172_010:
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F171_xxxx_(PC)
	ADDA	#18,A7
	BRA	L334(PC)
L335:
	MOVE	-12(A6),D0
	LSR	#6,D0
	LSR	#8,D0
	SUB	D7,D0
	AND	#3,D0
	MOVE	D0,-4(A6)
	BEQ	L337(PC)
	CMPI	#2,-8(A6)
	BNE.S	L338
	MOVE	-12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+8(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#1,D0
	BEQ.S	L339
	MOVE	G265_i_Cur(A4),D0
	ADDQ	#1,D0
	MOVE	-4(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,2(A0)
	MOVE	-12(A6),G290_T_Dun(A4)
L339:
	BRA.S	L340
L338:
	MOVE	-12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+12(A4),D1
	ASL.L	#3,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	4(A2),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	-4(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,2(A0)
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#127,D0
	BNE.S	L341
	MOVE	2(A2),D0
	LSR	#7,D0
	ADDQ	#1,D0
	MOVE	D0,G289_i_Dun(A4)
L341:
L340:
L337:
	MOVE	-12(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
L334:
	CMPI	#-2,-12(A6)
	BEQ.S	L342
	MOVE	-12(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-8(A6)
	CMPI	#3,D0
	BLE	L335(PC)
L342:
L336:
	MOVE	-10(A6),D0
	BEQ.S	L343
	MOVE	G306_i_Par(A4),D0
	CMP	D6,D0
	BEQ.S	L343
	MOVE	G307_i_Par(A4),D0
	CMP	D5,D0
	BEQ.S	L343
	MOVE	#-2,2(A3)
	BRA	L317(PC)
L343:
	BRA	L320(PC)
	BRA.S	L322
L321:
	CMP	#2,D0
	BEQ.S	L322
	BRA.S	L344
L322:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L346
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,4(A3)
	AND.B	#1,D4
	BRA.S	L347
L346:
	MOVE	#1,(A3)
	MOVE.B	#1,D4
L347:
	BRA	L31T172_030(PC)
	BRA.S	L345
L344:
	CMP	#6,D0
	BEQ.S	L345
	BRA.S	L348
L345:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	BNE.S	L350
	CLR	(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-4(A6)
	MOVE	D0,-6(A6)
	MOVE	D0,-2(A6)
	MOVE	#1,-10(A6)
	BRA	L31T172_010(PC)
L350:
	MOVE	#1,(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L351
	MOVE	#8,D0
	BRA.S	L352
L351:
	MOVE	#0,D0
L352:
	MOVE.B	D0,D4
	BRA.S	L349
L348:
	CMP	#1,D0
	BEQ.S	L349
	BRA	L353(PC)
L349:
	MOVE	#30,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-(A7)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,8(A3)
L31T172_029:
	MOVE.B	#1,D4
L31T172_030:
	BRA.S	L355
L356:
	CMPI	#3,D7
	BNE.S	L358
	MOVE	-12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+12(A4),D1
	ASL.L	#3,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	4(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,8(A3)
L358:
	MOVE	-12(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
L355:
	CMPI	#-2,-12(A6)
	BEQ.S	L359
	MOVE	-12(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D7
	CMPI	#3,D0
	BLE.S	L356
L359:
L357:
	BRA	L31T172_049(PC)
	BRA.S	L354
L353:
	CMP	#5,D0
	BEQ.S	L354
	BRA.S	L360
L354:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L362
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
L362:
	SNE	D0
	AND	#1,D0
	MOVE	D0,4(A3)
	BRA	L31T172_029(PC)
	BRA.S	L361
L360:
	CMP	#3,D0
	BEQ.S	L361
	BRA.S	L363
L361:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	ASR	#3,D0
	MOVE	D7,D1
	AND	#1,D1
	CMP	D1,D0
	BNE.S	L365
	MOVE	#18,D0
	BRA.S	L366
L365:
	MOVE	#19,D0
L366:
	MOVE	D0,(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,4(A3)
	CLR.B	D4
	BRA.S	L31T172_046
	BRA.S	L364
L363:
	CMP	#4,D0
	BEQ.S	L364
	BRA	L367(PC)
L364:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	ASR	#3,D0
	MOVE	D7,D1
	AND	#1,D1
	CMP	D1,D0
	BNE.S	L369
	MOVE	#16,(A3)
	BRA.S	L370
L369:
	MOVE	#17,(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,4(A3)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	AND	#1023,D0
	MOVE	D0,6(A3)
L370:
	MOVE.B	#1,D4
L31T172_046:
	BRA.S	L371
L372:
	MOVE	-12(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
L371:
	CMPI	#-2,-12(A6)
	BEQ.S	L374
	MOVE	-12(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L372
L374:
L373:
L31T172_049:
	MOVE.B	D4,D0
	BEQ.S	L375
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F315_arzz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,D4
	BEQ.S	L375
	AND	#255,D0
	SUBQ.B	#1,D4
	MOVE.B	D4,D0
	MOVE.B	G407_s_Par+3212(A4),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BLT.S	L375
	MOVE.B	D4,D0
	MOVE.B	G407_s_Par+3213(A4),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGE.S	L375
	ORI	#-32768,8(A3)
L375:
L367:
L368:
L320:
	MOVE	-12(A6),2(A3)
L317:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$316:	.EQU	#-12
F173_gzzz_:/* global */
	LINK	A6,L$376
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE	G272_i_Cur(A4),D0
	CMP	D7,D0
	BNE.S	L378
	BRA	L377(PC)
L378:
	MOVE	D7,G272_i_Cur(A4)
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),G271_ppuc_(A4)
	MOVE.L	G277_ps_Du(A4),D0
	MOVE	D7,D1
	MULU	#16,D1
	ADD.L	D1,D0
	MOVE.L	D0,G269_ps_Cu(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	ADDQ	#1,D0
	MOVE	D0,G273_i_Cur(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	8(A0),D0
	AND	#-2048,D0
	LSR	#3,D0
	LSR	#8,D0
	ADDQ	#1,D0
	MOVE	D0,G274_i_Cur(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#3840,D0
	LSR	#8,D0
	ASL.L	#1,D0
	LEA	G254_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	G275_as_Cu(A4),A0
	MOVEQ	#0,D0
	JSR	_blockmv(PC)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	ASL.L	#1,D0
	LEA	G254_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	G275_as_Cu+2(A4),A0
	MOVEQ	#0,D0
	JSR	_blockmv(PC)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#1,D0
	MOVE.L	G280_pui_D(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,G270_pui_C(A4)
L377:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$376:	.EQU	#0
F174_aozz_:/* global */
	LINK	A6,L$379
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MOVE	D0,G309_i_Par(A4)
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G273_i_Cur(A4),D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	-4(A0),D0
	MOVE	G274_i_Cur(A4),D3
	EXT.L	D3
	ADD.L	D3,D0
	MOVE.L	D0,A3
	MOVE.L	A3,G264_puc_C(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D0
	AND	#15,D0
	MOVE	D0,G265_i_Cur(A4)
	MOVE	D0,-(A7)
	PEA	G261_auc_C(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D1
	AND	#240,D1
	LSR	#4,D1
	MOVE.L	A3,D0
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D0
	AND	#3840,D0
	LSR	#8,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	PEA	G262_auc_C(A4)
	MOVE.L	A3,D0
	MOVE	G265_i_Cur(A4),D3
	EXT.L	D3
	ADD.L	D3,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#15,D0
	MOVE	D0,-(A7)
	PEA	G263_auc_C(A4)
	MOVE.L	A3,D0
	EXT.L	D6
	ADD.L	D6,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	LEA	G261_auc_C(A4),A0
	ADDA	G265_i_Cur(A4),A0
	CLR.B	(A0)
L380:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$379:	.EQU	#0
