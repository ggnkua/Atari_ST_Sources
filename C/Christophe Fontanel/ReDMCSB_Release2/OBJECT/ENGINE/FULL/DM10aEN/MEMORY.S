BSS SEG "bss"
G630_i_Gra:/* global */
	.WORD	#2
G631_i_Gra:/* global */
	.WORD	#2
G632_ui_Gr:/* global */
	.WORD	#2
G633_l_Gra:/* global */
	.WORD	#4
G634_pui_G:/* global */
	.WORD	#4
G635_pui_G:/* global */
	.WORD	#4
G636_ppuc_:/* global */
	.WORD	#4
G637_pi_Na:/* global */
	.WORD	#4
G638_pi_De:/* global */
	.WORD	#4
G639_pi_De:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#-1,G640_i_Flo(A4)
BSS SEG "bss"
G640_i_Flo:/* global */
	.WORD	#2
G641_puc_C:/* global */
	.WORD	#4
G642_puc_G:/* global */
	.WORD	#4
G643_puc_F:/* global */
	.WORD	#4
G644_i_Flo:/* global */
	.WORD	#2
G645_puc_H:/* global */
	.WORD	#4
G646_puc_A:/* global */
	.WORD	#4
G647_l_Unr:/* global */
	.WORD	#4
G648_l_Ava:/* global */
	.WORD	#4
G649_puc_G:/* global */
	.WORD	#4
G650_puc_G:/* global */
	.WORD	#4
G651_puc_C:/* global */
	.WORD	#4
G652_puc_A:/* global */
	.WORD	#4
G653_l_Ava:/* global */
	.WORD	#4
G654_B_Gra:/* global */
	.WORD	#2
G655_ppuc_:/* global */
	.WORD	#4
G656_l_Ava:/* global */
	.WORD	#4
G657_puc_F:/* global */
	.WORD	#4
G658_puc_F:/* global */
	.WORD	#4
G659_puc_L:/* global */
	.WORD	#4
G660_puc_F:/* global */
	.WORD	#4
G661_B_Lar:/* global */
	.WORD	#2
G662_l_Las:/* global */
	.WORD	#4
CODE SEG "memory"
F467_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	#2,D6
	MOVE	G632_ui_Gr(A4),D1
	ASL	#2,D1
	ADD	D1,D6
	AND.L	#65535,D6
	CLR	D5
	BRA.S	L2
L3:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	ADD.L	D0,D6
L4:
	ADDQ	#1,D5
L2:
	MOVE	D5,D0
	CMP	D7,D0
	BCS.S	L3
L5:
	MOVE.L	D6,D0
L1:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F468_ozzz_:/* global */
	LINK	A6,L$6
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L8
	ADDQ.L	#1,D7
L8:
	MOVE	12(A6),D0
	BEQ.S	L9
	MOVE.L	G653_l_Ava(A4),D0
	CMP.L	D7,D0
	BLT.S	L9
	MOVE.L	D7,D0
	SUB.L	D0,G653_l_Ava(A4)
	MOVE.L	G652_puc_A(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G652_puc_A(A4)
	MOVE.L	A3,D0
	BRA.S	L7
L9:
	MOVE.L	D7,D0
	CMP.L	G648_l_Ava(A4),D0
	BLE.S	L10
	MOVE	#40,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L10:
	MOVE.L	D7,D0
	SUB.L	D0,G648_l_Ava(A4)
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	D7,D0
	MOVE.L	D0,G646_puc_A(A4)
L7:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$6:	.EQU	#0
F469_rzzz_:/* global */
	LINK	A6,L$11
	MOVE.L	D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L13
	ADDQ.L	#1,D7
L13:
	MOVE.L	D7,D0
	ADD.L	D0,G648_l_Ava(A4)
	MOVE.L	D7,D0
	ADD.L	D0,G646_puc_A(A4)
L12:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$11:	.EQU	#0
F471_xxxx_:/* global */
	LINK	A6,L$14
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),-4(A6)
	CMPA.L	#0,A2
	BNE.S	L16
	CMPI.L	#0,-4(A6)
	BNE.S	L17
	CLR.L	G657_puc_F(A4)
	BRA.S	L18
L17:
	MOVE.L	-4(A6),G657_puc_F(A4)
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L18:
	BRA.S	L19
L16:
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	-4(A6),(A0)
	CMPI.L	#0,-4(A6)
	BEQ.S	L20
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
L20:
L19:
L15:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$14:	.EQU	#-4
F472_xxxx_:/* global */
	LINK	A6,L$21
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A2
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L23
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	#0,D0
	MOVE.L	A2,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	BRA	L24(PC)
L23:
	MOVE.L	G657_puc_F(A4),A3
	MOVE.L	A2,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	MOVE.L	D7,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L25
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	BRA.S	L26
L25:
	CLR	D6
	BRA.S	L27
L28:
	MOVE.L	D7,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L30
	MOVE.L	8(A6),D0
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	MOVE	#1,D6
	BRA.S	L29
L30:
	MOVE.L	A2,A3
L27:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	TST.L	D0
	BNE.S	L28
L29:
	MOVE	D6,D0
	BNE.S	L31
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	8(A6),(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L31:
L26:
L24:
L22:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$21:	.EQU	#-4
F473_xxxx_:/* global */
	LINK	A6,L$32
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	CLR	-4(A6)
	MOVE	12(A6),-2(A6)
	BRA.S	L34
L35:
	ADDQ	#1,-4(A6)
L34:
	MOVE	-2(A6),D0
	ASR	#1,D0
	MOVE	D0,-2(A6)
	BNE.S	L35
L36:
	MOVE	-4(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-2(A6)
	BRA	L37(PC)
L38:
	MOVE	#1,D0
	MOVE	-2(A6),D3
	ASL	D3,D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	ASL	#1,D0
	MOVE	D0,-8(A6)
	MOVE	-6(A6),D6
	BRA.S	L41
L42:
	MOVE	D6,D4
	MOVE	D4,D7
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
L45:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	CMP	12(A6),D0
	BCS.S	L48
	BRA.S	L47
L48:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	12(A6),D0
	BCC.S	L49
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L49
	ADDQ	#1,D5
L49:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L50
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L51
L50:
	BRA.S	L47
L51:
L46:
	BRA.S	L45
L47:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L43:
	ADDQ	#1,D6
L41:
	MOVE	D6,D0
	CMP	-8(A6),D0
	BLS.S	L42
L44:
L39:
	SUBQ	#1,-2(A6)
L37:
	CMPI	#0,-2(A6)
	BGE	L38(PC)
L40:
	MOVE	12(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	BRA	L52(PC)
L53:
	MOVE	-6(A6),D4
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	#0,D0
	MOVE	D0,D7
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	-6(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L56:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	MOVE	-6(A6),D1
	SUBQ	#1,D1
	CMP	D1,D0
	BLS.S	L59
	BRA.S	L58
L59:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	-6(A6),D0
	BCC.S	L60
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L60
	ADDQ	#1,D5
L60:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L61
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L62
L61:
	BRA.S	L58
L62:
L57:
	BRA.S	L56
L58:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L54:
	SUBQ	#1,-6(A6)
L52:
	CMPI	#1,-6(A6)
	BCC	L53(PC)
L55:
L33:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$32:	.EQU	#-8
F474_xxxx_:/* global */
	LINK	A6,L$63
	MOVEM.L	D7-D4,-(A7)
L66:
L65:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L66
L67:
	MOVE	8(A6),-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D7
	MOVE	8(A6),D5
	ASL.L	#1,D5
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE.L	D7,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D0,-2(A6)
	MOVE	-2(A6),D6
	EXT.L	D6
	ASL.L	#2,D6
	ASL.L	#8,D6
	BRA	L68(PC)
L69:
	MOVE	-2(A6),D0
	CMP	G640_i_Flo(A4),D0
	BNE.S	L72
	MOVE	G644_i_Flo(A4),D0
	BEQ.S	L71
L72:
	MOVE	-2(A6),G640_i_Flo(A4)
	MOVE.L	G633_l_Gra(A4),D0
	SUB.L	D6,D0
	MOVE.L	D0,-8(A6)
	CMPI.L	#1024,D0
	BLE.S	L73
	MOVE.L	#1024,-8(A6)
L73:
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE.L	D6,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	G643_puc_F(A4),-(A7)
	MOVE.L	-8(A6),D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	-8(A6),D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
	CLR	G644_i_Flo(A4)
L71:
	MOVE.L	D7,D4
	SUB.L	D6,D4
	MOVE	#1024,D0
	SUB	D4,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	-4(A6),-(A7)
	MOVE.L	10(A6),-(A7)
	MOVE.L	G643_puc_F(A4),D0
	EXT.L	D4
	ADD.L	D4,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	SUB	-4(A6),D5
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,D7
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,10(A6)
	ADDQ	#1,-2(A6)
	ADD.L	#1024,D6
L68:
	CMPI	#0,D5
	BGT	L69(PC)
L70:
L64:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$63:	.EQU	#-8
F475_ozzz_:/* global */
	LINK	A6,L$74
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),D7
	MOVE.L	A3,D0
	MOVE.L	D0,G651_puc_C(A4)
	MOVE.L	D0,G641_puc_C(A4)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,G645_puc_H(A4)
	MOVE.L	D0,G646_puc_A(A4)
	MOVE.L	D7,G648_l_Ava(A4)
	MOVE.L	16(A6),G652_puc_A(A4)
	MOVE.L	20(A6),G653_l_Ava(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1024,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G643_puc_F(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5100,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G655_ppuc_(A4)
	MOVE	#5100,-(A7)
	MOVE.L	G655_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G638_pi_De(A4)
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#730,-(A7)
	MOVE.L	G638_pi_De(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G639_pi_De(A4)
	MOVE.L	#0,D0
	MOVE.L	D0,G657_puc_F(A4)
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G659_puc_L(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	#-1,G662_l_Las(A4)
L75:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$74:	.EQU	#0
F476_mzzz_:/* global */
	LINK	A6,L$76
	MOVE.L	G646_puc_A(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	CMPI.L	#370000,D0
	SGT	D0
	AND	#1,D0
	MOVE	D0,G661_B_Lar(A4)
	BEQ.S	L78
	JSR	F461_AA08_(PC)
L78:
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	#10000,D0
	MOVE.L	D0,G642_puc_G(A4)
	MOVE	#1,G654_B_Gra(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	D0,G650_puc_G(A4)
	MOVE.L	D0,G649_puc_G(A4)
	MOVE.L	#10000,G648_l_Ava(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,G656_l_Ava(A4)
L77:
	UNLK	A6
	RTS
L$76:	.EQU	#0
F477_izzz_:/* global */
	LINK	A6,L$79
L82:
L81:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L82
L83:
	MOVE	G631_i_Gra(A4),D0
	ADDQ	#1,G631_i_Gra(A4)
	TST	D0
	BEQ.S	L84
	BRA.S	L80
L84:
DATA SEG "s!"
s!:
	DATA 41 3A 5C 47 52 41 50 48 49 43 53 2E 44 41 54 00 
CODE SEG "memory"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G630_i_Gra(A4)
	CMPI	#0,G630_i_Gra(A4)
	BGE.S	L85
	MOVE	#41,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L85:
L80:
	UNLK	A6
	RTS
L$79:	.EQU	#0
F478_gzzz_:/* global */
	LINK	A6,L$86
	SUBQ	#1,G631_i_Gra(A4)
	BEQ.S	L88
	BRA.S	L87
L88:
L90:
L89:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L90
L91:
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
L87:
	UNLK	A6
	RTS
L$86:	.EQU	#0
F479_izzz_:/* global */
	LINK	A6,L$92
	MOVEM.L	D7-D6,-(A7)
	CLR	G631_i_Gra(A4)
	JSR	F477_izzz_(PC)
	PEA	G632_ui_Gr(A4)
	MOVE.L	#2,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CMPI.L	#2,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L100
	MOVE	G632_ui_Gr(A4),D0
	ASL	#1,D0
	MOVE	D0,D6
L100:
	SNE	D0
	TST.B	D0
	BEQ.S	L99
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G634_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L99:
	TST.B	D0
	BEQ.S	L98
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G635_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L98:
	TST.B	D0
	BEQ.S	L97
	MOVE.L	G634_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L97:
	TST.B	D0
	BEQ.S	L96
	MOVE.L	G635_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L96:
	TST.B	D0
	BEQ.S	L95
	MOVE	#1,-(A7)
	MOVE	D6,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G636_ppuc_(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L95:
	TST.B	D0
	BEQ.S	L94
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G637_pi_Na(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L94:
	AND	#1,D0
	MOVE	D0,D7
	MOVE	D7,D0
	BNE.S	L101
	BRA	L102(PC)
L101:
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	G636_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE.L	G637_pi_Na(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	SUBQ	#1,D6
	MOVE	D6,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,G633_l_Gra(A4)
	MOVE	#1,-(A7)
	MOVE.L	G635_pui_G(A4),A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G343_puc_G(A4)
	CMPI.L	#0,D0
	BNE.S	L103
	BRA.S	L104
L103:
	MOVE.L	G343_puc_G(A4),-(A7)
	CLR	-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L93
L104:
L102:
	MOVE	#42,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L93:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$92:	.EQU	#0
F480_AA07_:/* global */
	LINK	A6,L$105
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CMPI	#0,8(A6)
	BLT.S	L107
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L108
	BRA	L106(PC)
L108:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L109
L107:
	ANDI	#32767,8(A6)
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L110
	BRA	L106(PC)
L110:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L109:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	NEG.L	D7
	MOVE.L	D7,D0
	ADD.L	D0,G656_l_Ava(A4)
	MOVE.L	A3,D5
	ADDQ.L	#6,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	MOVE.L	A3,D4
	ADDQ.L	#8,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#-1,D5
	BNE.S	L111
	CMPI	#-1,D4
	BNE.S	L112
	CLR.L	G658_puc_F(A4)
	CLR.L	G659_puc_L(A4)
	CLR.L	G660_puc_F(A4)
	BRA.S	L113
L112:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),G658_puc_F(A4)
	MOVE.L	G658_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L114
	MOVE.L	G658_puc_F(A4),G660_puc_F(A4)
L114:
L113:
	BRA.S	L115
L111:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D4,(A0)
	CMPI	#-1,D4
	BNE.S	L116
	MOVE.L	A2,G659_puc_L(A4)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L117
	CLR.L	G660_puc_F(A4)
L117:
	BRA.S	L118
L116:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L119
	MOVE.L	A2,G660_puc_F(A4)
L119:
L118:
L115:
	MOVE.L	A3,D0
	CMP.L	G641_puc_C(A4),D0
	BEQ.S	L120
	MOVE.L	A3,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L120
	SUBA.L	D6,A3
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L120:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	CMP.L	G651_puc_C(A4),D0
	BNE.S	L121
	MOVE.L	A3,G651_puc_C(A4)
	BRA.S	L106
L121:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L122
	MOVE.L	A2,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L122:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
L106:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$105:	.EQU	#0
F481_xxxx_:/* global */
	LINK	A6,L$123
	BRA.S	L125
L126:
	CMPI.L	#0,G658_puc_F(A4)
	BNE.S	L128
	MOVE	#43,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L128:
	MOVE.L	G658_puc_F(A4),D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	(A0),-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L125:
	MOVE.L	G656_l_Ava(A4),D0
	CMP.L	8(A6),D0
	BLT.S	L126
L127:
L124:
	UNLK	A6
	RTS
L$123:	.EQU	#0
F482_xxxx_:/* global */
	LINK	A6,L$129
	MOVEM.L	A3-A2/D7-D5,-(A7)
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L131
	BRA	L130(PC)
L131:
	MOVE.L	G641_puc_C(A4),D0
	MOVE.L	D0,A2
	MOVE.L	D0,A3
L132:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D7
	CMPI.L	#0,D0
	BLE.S	L135
	ADDA.L	D7,A2
	BRA	L136(PC)
L135:
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	D0,D7
	MOVE.L	A2,D0
	CMP.L	A3,D0
	BEQ.S	L137
	MOVE.L	A2,D6
	ADD.L	#10,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	CMPI	#0,D6
	BLT.S	L138
	MOVE	D6,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L139
L138:
	MOVE	D6,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L139:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	D7,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G658_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L140
	MOVE.L	A3,G658_puc_F(A4)
L140:
	MOVE.L	G659_puc_L(A4),D0
	CMP.L	A2,D0
	BNE.S	L141
	MOVE.L	A3,G659_puc_L(A4)
L141:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L142
	MOVE.L	A3,G660_puc_F(A4)
L142:
L137:
	ADDA.L	D7,A2
	ADDA.L	D7,A3
L136:
L133:
	MOVE.L	A2,D0
	CMP.L	G651_puc_C(A4),D0
	BNE	L132(PC)
L134:
	MOVE.L	A3,G651_puc_C(A4)
	CLR.L	G657_puc_F(A4)
L130:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$129:	.EQU	#0
F483_xxxx_:/* global */
	LINK	A6,L$143
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G651_puc_C(A4),D1
	SUB.L	D1,D0
	CMP.L	D7,D0
	BLT.S	L145
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L146(PC)
L145:
	MOVE.L	G657_puc_F(A4),D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BGE.S	L147
	JSR	F482_xxxx_(PC)
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L148(PC)
L147:
	MOVE.L	G657_puc_F(A4),A3
	CLR	D6
L149:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BNE.S	L152
	MOVE	#1,D6
	BRA.S	L153
L152:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BLT.S	L155
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	CMPI.L	#0,D0
	BNE.S	L154
L155:
	MOVE.L	G657_puc_F(A4),A3
	MOVE	#1,D6
	BRA.S	L156
L154:
	MOVE.L	A2,A3
L156:
L153:
L150:
	MOVE	D6,D0
	BEQ.S	L149
L151:
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.L	(A0),D5
	SUB.L	D7,D5
	CMPI.L	#24,D5
	BLT.S	L157
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D5,D0
	MOVE.L	A2,D1
	ADD.L	D5,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L158
L157:
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
L158:
L148:
L146:
	MOVE.L	D7,D0
	SUB.L	D0,G656_l_Ava(A4)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D7,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D0
L144:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$143:	.EQU	#0
F484_gzzz_:/* global */
	LINK	A6,L$159
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-14(A6)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F473_xxxx_(PC)
	ADDQ.L	#6,A7
	CLR.L	-4(A6)
	CLR	D7
	BRA	L161(PC)
L162:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L165
L166:
	MOVE	12(A6),D0
	SUBQ	#1,12(A6)
	SUB	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L165:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,D6
	CMP	12(A6),D0
	BGE.S	L168
	MOVE	D5,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L166
L168:
L167:
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L169
	ADDQ.L	#1,D4
L169:
	MOVE.L	D4,D0
	ADD.L	D0,-4(A6)
L163:
	ADDQ	#1,D7
L161:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L162(PC)
L164:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L170
	MOVE.L	G649_puc_G(A4),D0
	SUB.L	-4(A6),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
	BRA.S	L171
L170:
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
L171:
	MOVE.L	G348_pl_Bi(A4),A0
	MOVE.L	-8(A6),32000(A0)
	MOVE.L	#19576,D0
	CMP.L	-8(A6),D0
	BLE.S	L172
	MOVE	#44,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L172:
	CLR	D7
	BRA.S	L173
L174:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L177
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L177:
L175:
	ADDQ	#1,D7
L173:
	CMPI	#730,D7
	BLT.S	L174
L176:
	MOVE	#0,D6
	MOVE	D6,D7
L178:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L181
L182:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	TST.L	D0
	BEQ.S	L184
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L185
	ADDQ.L	#1,D4
L185:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L184:
	ADDQ	#1,D6
L181:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L182
L183:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BEQ.S	L186
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L186:
L179:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L178(PC)
L180:
	BRA.S	L187
L188:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BEQ.S	L190
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L191
	ADDQ.L	#1,D4
L191:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L190:
	ADDQ	#1,D6
L187:
	MOVE	D6,D0
	CMP	G632_ui_Gr(A4),D0
	BCS.S	L188
L189:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L192
	MOVE.L	G650_puc_G(A4),D4
	MOVE.L	G649_puc_G(A4),D1
	SUB.L	-4(A6),D1
	SUB.L	D1,D4
	CMPI.L	#0,D4
	BLE.S	L193
	MOVE.L	D4,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
L193:
	JSR	F482_xxxx_(PC)
	MOVE.L	D4,D0
	SUB.L	D0,G656_l_Ava(A4)
L192:
	MOVE.L	G649_puc_G(A4),D0
	MOVE.L	D0,A2
	SUBQ.L	#2,D0
	MOVE.L	D0,A3
	BRA.S	L194
L195:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L197
	MOVE	D5,D0
	SUBQ	#2,D0
	EXT.L	D0
	ADDA.L	D0,A3
	BRA.S	L198
L197:
	MOVE.L	A3,D4
	MOVE	D5,D1
	ASL.L	#2,D1
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),D1
	SUB.L	D1,D4
	MOVE.L	D4,-24(A6)
	MOVE.L	#2,D4
	ADD.L	-24(A6),D4
	SUBA.L	D4,A2
	SUBA.L	D4,A3
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	CMP.L	A2,D0
	BEQ.S	L199
	MOVE.L	D4,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L199:
L198:
L194:
	MOVE.L	A3,D0
	CMP.L	G650_puc_G(A4),D0
	BGT.S	L195
L196:
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-12(A6)
L201:
L200:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L201
L202:
	CLR	D7
	BRA	L203(PC)
L204:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L207
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA	L208(PC)
L207:
	MOVE.L	A2,D0
	SUBQ.L	#2,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L209
	ADDQ.L	#1,D4
L209:
	SUBA.L	D4,A2
	MOVE	-14(A6),D0
	BNE.S	L210
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE	#1,-14(A6)
L210:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L211
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D5,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	-12(A6),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	BRA.S	L212
L211:
	MOVE.L	A2,-(A7)
	MOVE	D5,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L212:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L208:
L205:
	ADDQ	#1,D7
L203:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L204(PC)
L206:
	MOVE	-14(A6),D0
	BEQ.S	L213
	JSR	F478_gzzz_(PC)
L213:
	MOVE.L	A2,G650_puc_G(A4)
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L214
	MOVE.L	G650_puc_G(A4),G642_puc_G(A4)
L214:
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#7,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	PEA	G295_ac_Se(A4)
	MOVE	#8,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L160:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$159:	.EQU	#-24
F485_xxxx_:/* global */
	LINK	A6,L$215
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	G313_ul_Ga(A4),G662_l_Las(A4)
	CLR.L	G660_puc_F(A4)
	MOVE.L	G659_puc_L(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L217
	BRA.S	L216
L217:
	BRA.S	L218
L219:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR	(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L221
	BRA.S	L216
L221:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
L218:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CMPI	#0,(A0)
	BNE.S	L219
L220:
L216:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$215:	.EQU	#0
F486_xxxx_:/* global */
	LINK	A6,L$222
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	CMPI.L	#0,G660_puc_F(A4)
	BNE.S	L224
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	CMPI.L	#0,G659_puc_L(A4)
	BNE.S	L225
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	A3,G658_puc_F(A4)
	BRA.S	L226
L225:
	MOVE.L	G659_puc_L(A4),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	G659_puc_L(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L227
	MOVE	D4,D6
	ASL.L	#1,D6
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	BRA.S	L228
L227:
	MOVE	D4,D6
	AND	#32767,D6
	ASL.L	#1,D6
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
L228:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L226:
	MOVE.L	A3,G659_puc_L(A4)
	BRA	L229(PC)
L224:
	MOVE.L	G660_puc_F(A4),D6
	ADDQ.L	#6,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	MOVE.L	G660_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	CMPI	#-1,D6
	BEQ.S	L230
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	BRA.S	L231
L230:
	MOVE.L	G660_puc_F(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L232
	MOVE	D4,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L233
L232:
	MOVE	D4,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L233:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A3,G658_puc_F(A4)
L231:
L229:
	MOVE.L	A3,G660_puc_F(A4)
L223:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$222:	.EQU	#0
F487_xxxx_:/* global */
	LINK	A6,L$234
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE.L	D0,-4(A6)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#0,D0
	BNE.S	L236
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L237
	MOVE.L	A3,G660_puc_F(A4)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	MOVE.L	A3,D0
	BRA	L235(PC)
L237:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L238
	MOVE.L	A2,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L239
L238:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L239:
	MOVE	D7,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	-4(A6),D0
	BRA	L235(PC)
L236:
	MOVE	D4,D0
	ADDQ	#1,D0
	MOVE	D0,D4
	MOVE.L	A3,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A3,D0
	CMP.L	G659_puc_L(A4),D0
	BNE.S	L240
	MOVE.L	A3,D0
	BRA	L235(PC)
L240:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L241
	MOVE.L	A3,D0
	BRA	L235(PC)
L241:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L242
	MOVE.L	A2,D0
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L243
L242:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L244
	MOVE.L	A2,G660_puc_F(A4)
L244:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L243:
L245:
	MOVE.L	A2,A3
	MOVE	D5,D6
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L248
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	-4(A6),D0
	MOVE.L	D0,G659_puc_L(A4)
	BRA.S	L235
L248:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L249
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	BRA.S	L235
L249:
L246:
	MOVE	#1,D0
	BNE	L245(PC)
L247:
L235:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$234:	.EQU	#-4
F488_bzzz_:/* global */
	LINK	A6,L$250
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	10(A6),A3
	MOVE	8(A6),D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
L251:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$250:	.EQU	#0
F489_ayzz_:/* global */
	LINK	A6,L$252
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#-32768,D0
	BEQ.S	L254
	MOVE	D7,D0
	AND	#32767,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	BRA	L253(PC)
L254:
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L255
	JSR	F485_xxxx_(PC)
L255:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L256
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	ADD.L	#12,D0
	BRA	L253(PC)
L256:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	ASR	#1,D5
	MOVE.L	A2,D1
	ADDQ.L	#2,D1
	MOVE.L	D1,A0
	MULS	(A0),D5
	MOVE	D5,-10(A6)
	MOVE	#16,D5
	ADD	-10(A6),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L258:
L257:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L258
L259:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE	D6,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	ADDA.L	#12,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	A3,D0
L253:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$252:	.EQU	#-10
F490_lzzz_:/* global */
	LINK	A6,L$260
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	JSR	F477_izzz_(PC)
	MOVE	D7,D6
	AND	#-32768,D6
	AND	#32767,D7
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ	L262(PC)
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D7,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L263
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L263:
	BRA.S	L264
L262:
	MOVE	D6,D0
	BEQ.S	L265
	MOVE.L	A3,D0
	BRA.S	L266
L265:
	MOVE.L	G296_puc_B(A4),D0
L266:
	MOVE.L	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L264:
	MOVE	D6,D0
	BNE.S	L267
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE	#1,G297_B_Dra(A4)
L267:
	JSR	F478_gzzz_(PC)
L261:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$260:	.EQU	#0
F491_xzzz_:/* global */
	LINK	A6,L$268
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L270
	JSR	F485_xxxx_(PC)
L270:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L271
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D0
	BRA.S	L269
L271:
	MOVE	#16,D5
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	ADD	(A0),D5
	AND.L	#65535,D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L273:
L272:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L273
L274:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE.L	A3,D1
	ADD.L	#10,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE	#0,D0
L269:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$268:	.EQU	#0
F492_mzzz_:/* global */
	LINK	A6,L$275
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	ADD.L	#12,D0
L276:
	UNLK	A6
	RTS
L$275:	.EQU	#0
F493_hzzz_:/* global */
	LINK	A6,L$277
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
L278:
	UNLK	A6
	RTS
L$277:	.EQU	#0
F494_ozzz_:/* global */
	LINK	A6,L$279
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L280:
	UNLK	A6
	RTS
L$279:	.EQU	#0
