BSS SEG "bss"
G369_ui_Ev:/* global */
	.WORD	#2
G370_ps_Ev:/* global */
	.WORD	#4
G371_pi_Ti:/* global */
	.WORD	#4
G372_ui_Ev:/* global */
	.WORD	#2
G373_ui_Fi:/* global */
	.WORD	#2
G374_l_Wat:/* global */
	.WORD	#4
CODE SEG "timeline"
F233_wzzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3/D7,-(A7)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G370_ps_Ev(A4)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G371_pi_Ti(A4)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L2
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L3
L4:
	CLR.B	4(A3)
L5:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#10,A3
L3:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L4
L6:
	CLR	G372_ui_Ev(A4)
	CLR	G373_ui_Fi(A4)
	JSR	F256_xxxx_(PC)
L2:
L1:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F234_xxxx_:/* global */
	LINK	A6,L$7
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVEQ	#1,D0
	MOVE.L	#16777215,D1
	MOVE.L	(A3)+,D2
	AND.L	D1,D2
	AND.L	(A2)+,D1
	CMP.L	D1,D2
	BLT.S	L1T234_005_
	BNE.S	L1T234_001
	MOVE	(A3),D2
	CMP	(A2),D2
	BHI.S	L1T234_005_
	BNE.S	L1T234_001
	CMPA.L	A3,A2
	BCC.S	L1T234_005_
L1T234_001:
	MOVEQ	#0,D0
L1T234_005_:
L8:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$7:	.EQU	#0
F235_bzzz_:/* global */
	LINK	A6,L$9
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,A3
	BRA.S	L11
L12:
	MOVE	(A3)+,D0
	CMP	D7,D0
	BNE.S	L15
	BRA.S	L14
L15:
L13:
	ADDQ	#1,D6
L11:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L12
L14:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L16
	CLR	D6
L16:
	MOVE	D6,D0
L10:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$9:	.EQU	#0
F236_pzzz_:/* global */
	LINK	A6,L$17
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D4
	CMPI	#1,D0
	BNE.S	L19
	BRA	L18(PC)
L19:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	-2(A6)
	BRA.S	L20
L21:
	MOVE	D7,D6
	SUBQ	#1,D6
	LSR	#1,D6
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L23
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	MOVE	#1,-2(A6)
	BRA.S	L20
L23:
	BRA.S	L22
L20:
	CMPI	#0,D7
	BHI.S	L21
L22:
	MOVE	-2(A6),D0
	BEQ.S	L24
	BRA	L3T236_011(PC)
L24:
	MOVE	D4,D0
	SUBQ	#1,D0
	SUBQ	#1,D0
	LSR	#1,D0
	MOVE	D0,D4
	BRA	L25(PC)
L26:
	MOVE	D7,D6
	ASL	#1,D6
	ADDQ	#1,D6
	MOVE	D6,D0
	ADDQ	#1,D0
	CMP	G372_ui_Ev(A4),D0
	BCC.S	L28
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L28
	ADDQ	#1,D6
L28:
	MOVE.L	A3,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L29
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	BRA.S	L25
L29:
	BRA.S	L27
L25:
	MOVE	D7,D0
	CMP	D4,D0
	BLS	L26(PC)
L27:
L3T236_011:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
L18:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$17:	.EQU	#-2
F237_rzzz_:/* global */
	LINK	A6,L$30
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	CLR.B	4(A0)
	MOVE	D7,D0
	CMP	G373_ui_Fi(A4),D0
	BCC.S	L32
	MOVE	D7,G373_ui_Fi(A4)
L32:
	SUBQ	#1,G372_ui_Ev(A4)
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L33
	BRA.S	L31
L33:
	MOVE	D7,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	D6,D0
	CMP	D5,D0
	BNE.S	L34
	BRA.S	L31
L34:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L31:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$30:	.EQU	#0
F238_pzzz_:/* global */
	LINK	A6,L$35
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	G372_ui_Ev(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L37
	MOVE	#45,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L37:
	CMPI	#3217,G189_i_Gra(A4)
	BEQ.S	L38
	MOVE	#0,D0
	BRA	L36(PC)
L38:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#5,D0
	BLT	L39(PC)
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#10,D0
	BGT	L39(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA	L40(PC)
L41:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#5,D0
	BLT.S	L44
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BGT.S	L44
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L45
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L45
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#6,D0
	BNE.S	L46
	MOVE.B	8(A2),D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BNE.S	L45
L46:
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L36(PC)
L45:
	BRA.S	L42
	BRA.S	L47
L44:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L48
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L48
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L48
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L49
	MOVE	#1,D0
	MOVE.B	9(A2),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A3)
L49:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L43
L48:
L47:
L42:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L40:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS	L41(PC)
L43:
	BRA	L50(PC)
L39:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#1,D0
	BNE	L51(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L52
L53:
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L56
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L56
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L57
	MOVE.B	9(A2),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L58
	MOVE	#1,D0
	MOVE.B	9(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A2)
L58:
	MOVE	D7,D0
	BRA	L36(PC)
L57:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L59
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L36(PC)
L59:
L56:
L54:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L52:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L53
L55:
	BRA.S	L60
L51:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L61
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L62
L63:
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L66
	MOVE.L	(A3),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE.L	(A2),D1
	MOVE.L	#24,D3
	ASR.L	D3,D1
	CMP	D1,D0
	BNE.S	L66
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BEQ.S	L68
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L67
L68:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L67:
L66:
L64:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L62:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L63
L65:
L61:
L60:
L50:
	LEA	(A3),A1
	MOVE	G373_ui_Fi(A4),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
L69:
	MOVE	G373_ui_Fi(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L72
	BRA.S	L71
L72:
	ADDQ	#1,G373_ui_Fi(A4)
L70:
	MOVE	G373_ui_Fi(A4),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L69
L71:
	MOVE	G372_ui_Ev(A4),D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	G372_ui_Ev(A4),D0
	ADDQ	#1,G372_ui_Ev(A4)
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
L36:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$35:	.EQU	#0
F239_xxxx_:/* global */
	LINK	A6,L$73
	MOVE	D7,-(A7)
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MOVE	D0,D7
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	MOVE.L	8(A6),A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L74:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$73:	.EQU	#0
F240_xxxx_:/* global */
	LINK	A6,L$75
	MOVE	G372_ui_Ev(A4),D0
	BEQ.S	L78
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	AND.L	#16777215,D0
	MOVE.L	G313_ul_Ga(A4),D1
	CMP.L	D1,D0
	SLE	D0
	TST.B	D0
L78:
	SNE	D0
	TST.B	D0
	BEQ.S	L77
	CMPI	#2,G330_i_Sto(A4)
	SLT	D0
	TST.B	D0
L77:
	AND	#1,D0
L76:
	UNLK	A6
	RTS
L$75:	.EQU	#0
F241_xxxx_:/* global */
	LINK	A6,L$79
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D4
	CMPI	#5,D0
	BNE.S	L81
	BRA	L80(PC)
L81:
	ADDQ.L	#1,(A3)
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#1,D5
	BNE	L82(PC)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#32,D0
	LSR	#5,D0
	MOVE	D0,-10(A6)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE	L83(PC)
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L83
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L83
	CMPI	#0,D4
	BEQ.S	L83
	CMPI	#0,G305_ui_Pa(A4)
	BLS.S	L84
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#0,D0
	MOVE.B	D0,(A2)
	MOVE	#2,-(A7)
	MOVE	#8,D0
	OR	-10(A6),D0
	BEQ.S	L86
	MOVE	#4,D0
	BRA.S	L87
L86:
	MOVE	#3,D0
L87:
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L85
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#18,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L85:
L84:
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L80(PC)
L83:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-6(A6)
	CMPI	#-2,D0
	BEQ	L88(PC)
	MOVE	-6(A6),-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-8(A6)
	AND	#64,D0
	BNE	L88(PC)
	MOVE	D4,D0
	MOVE	-10(A6),D1
	BEQ.S	L90
	MOVE	-8(A6),D1
	LSR	#7,D1
	AND	#3,D1
	BRA.S	L91
L90:
	MOVE	#1,D1
L91:
	CMP	D1,D0
	BCS.S	L89
	MOVE	#1,-(A7)
	MOVE	#5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	CMPI	#2,D0
	BEQ.S	L92
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L92:
	CMPI	#0,D4
	BNE.S	L93
	MOVE	#0,D0
	BRA.S	L94
L93:
	MOVE	D4,D0
	SUBQ	#1,D0
L94:
	MOVE	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#4,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L80
L89:
L88:
L82:
	CMPI	#0,D5
	BNE.S	L97
	CMPI	#0,D4
	BEQ.S	L96
L97:
	CMPI	#1,D5
	BNE.S	L95
	CMPI	#4,D4
	BNE.S	L95
L96:
	BRA.S	L80
L95:
	CMPI	#0,D5
	BNE.S	L98
	MOVE	#-1,D0
	BRA.S	L99
L98:
	MOVE	#1,D0
L99:
	ADD	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#2,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	CMPI	#0,D5
	BNE.S	L100
	CMPI	#0,D4
	BNE.S	L101
	BRA.S	L80
L101:
	BRA.S	L102
L100:
	CMPI	#4,D4
	BNE.S	L103
	BRA.S	L80
L103:
L102:
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L80:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$79:	.EQU	#-10
F242_xxxx_:/* global */
	LINK	A6,L$104
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#2,D5
	BNE.S	L106
	MOVE.B	(A2),D5
	AND	#255,D5
	AND	#4,D5
	BEQ.S	L107
	MOVE	#1,D5
	BRA.S	L108
L107:
	MOVE	#0,D5
L108:
L106:
	CMPI	#1,D5
	BNE.S	L109
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L110
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L110
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L110
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L111
L110:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L112
	MOVE	D4,-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#64,D0
	BNE.S	L112
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L113
L112:
	ANDI.B	#-5,(A2)
L113:
L111:
	BRA.S	L114
L109:
	ORI.B	#4,(A2)
L114:
L105:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$104:	.EQU	#0
F243_xxxx_:/* global */
	LINK	A6,L$115
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#5,D0
	MOVE.B	D0,(A2)
L116:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$115:	.EQU	#0
F244_xxxx_:/* global */
	LINK	A6,L$117
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D7
	CMPI	#5,D0
	BNE.S	L119
	BRA.S	L118
L119:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L120
	CMPI	#0,D7
	BNE.S	L121
	MOVE	#1,D0
	BRA.S	L122
L121:
	MOVE	#0,D0
L122:
	MOVE.B	D0,9(A3)
	BRA.S	L123
L120:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L124
	CMPI	#0,D7
	BNE.S	L125
	BRA.S	L118
L125:
	BRA.S	L126
L124:
	CMPI	#4,D7
	BNE.S	L127
	BRA.S	L118
L127:
L126:
L123:
	MOVE.B	#1,4(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L118:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$117:	.EQU	#0
F245_xxxx_:/* global */
	LINK	A6,L$128
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L130(PC)
L131:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D7
	CMPI	#2,D0
	BNE	L134(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D6
	AND	#1,D6
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L135
	MOVE	D6,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L136
L135:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L136:
	MOVE	D6,D0
	BNE.S	L137
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	BEQ.S	L137
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L137
	MOVE	-6(A6),D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L137
	MOVE	-8(A6),D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L137
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	PEA	G353_ac_St(A4)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L137:
	BRA	L138(PC)
L134:
	CMPI	#3,D7
	BNE	L139(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#6,D0
	BNE	L140(PC)
	MOVE	4(A2),D5
	AND	#1920,D5
	LSR	#7,D5
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L141
	JSR	F027_AA59_(PC)
	MOVE	D5,D1
	AND	#7,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D5
	BRA.S	L142
L141:
	SUBQ	#1,D5
L142:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BNE.S	L143
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-10(A6)
L143:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	2(A2),D0
	LSR	#7,D0
	MOVE	D0,-(A7)
	JSR	F185_auzz_(PC)
	ADDA	#12,A7
	MOVE	4(A2),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L144
	MOVE	#1,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L144:
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L145
	ANDI	#-128,2(A2)
	BRA.S	L146
L145:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#4,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BEQ.S	L147
	ANDI	#-128,2(A2)
	CMPI	#127,-10(A6)
	BLS.S	L148
	MOVE	-10(A6),D0
	SUB	#126,D0
	ASL	#6,D0
	MOVE	D0,-10(A6)
L148:
	MOVE.B	#65,-16(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	CLR.B	-15(A6)
	MOVE	-6(A6),D0
	MOVE.B	D0,-14(A6)
	MOVE	-8(A6),D0
	MOVE.B	D0,-13(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L147:
L146:
L140:
L139:
L138:
L132:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L130:
	CMPI	#-2,D4
	BNE	L131(PC)
L133:
L129:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$128:	.EQU	#-20
F246_xxxx_:/* global */
	LINK	A6,L$149
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L151
L152:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L155
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#0,D0
	BNE.S	L156
	ORI	#6,2(A2)
	BRA.S	L150
L156:
L155:
L153:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L151:
	CMPI	#-1,D7
	BNE.S	L152
L154:
L150:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$149:	.EQU	#0
F247_xxxx_:/* global */
	LINK	A6,L$157
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	MOVE.B	8(A2),D5
	AND	#255,D5
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-6(A6)
	MOVE	2(A3),D4
	AND	#127,D4
	MOVE	2(A3),D0
	LSR	#7,D0
	MOVE	D0,-8(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-12(A6)
	CMPI	#7,D4
	SEQ	D0
	TST.B	D0
	BNE.S	L160
	CMPI	#8,D4
	SEQ	D0
	TST.B	D0
L160:
	TST.B	D0
	BNE.S	L159
	CMPI	#14,D4
	SEQ	D0
	TST.B	D0
L159:
	AND	#1,D0
	MOVE	D0,-14(A6)
	CMPI	#8,D4
	BEQ.S	L162
	CMPI	#10,D4
	BNE.S	L161
L162:
	MOVE	-8(A6),D7
	ADD	#-128,D7
	MOVE	D7,D6
	BRA	L163(PC)
L161:
	CMPI	#14,D4
	BEQ.S	L165
	CMPI	#15,D4
	BNE	L164(PC)
L165:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L166
L167:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L170
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L171
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L170
L171:
	BRA.S	L169
L170:
L168:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L166:
	CMPI	#-1,D7
	BNE.S	L167
L169:
	CMPI	#-1,D7
	BNE.S	L172
	BRA	L158(PC)
L172:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-14(A6),D0
	BNE.S	L173
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA.S	L174
L175:
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L178
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L179
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L178
L179:
	BRA.S	L177
L178:
L176:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L174:
	CMPI	#-1,D6
	BNE.S	L175
L177:
	CMPI	#-1,D6
	BNE.S	L180
	MOVE	#1,-14(A6)
	BRA.S	L181
L180:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L181:
L173:
	BRA.S	L182
L164:
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L183
	BRA	L158(PC)
L183:
	MOVE	-14(A6),D0
	BNE.S	L184
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L184
	MOVE	#1,-14(A6)
L184:
L182:
L163:
	MOVE	-14(A6),D0
	BEQ.S	L185
	JSR	F028_a000_(PC)
	MOVE	D0,-26(A6)
	MOVE	-6(A6),D0
	ADD	-26(A6),D0
	AND	#3,D0
	MOVE	D0,-6(A6)
L185:
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	#1,G365_B_Cre(A4)
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	-14(A6),D0
	BNE.S	L186
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L186:
	CLR	G365_B_Cre(A4)
L158:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$157:	.EQU	#-26
F248_xxxx_:/* global */
	LINK	A6,L$187
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE.B	8(A3),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	BRA	L189(PC)
L190:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#2,D0
	BNE	L192(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L192
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L193
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L194
L193:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L194:
	BRA	L195(PC)
L192:
	CMPI	#3,D6
	BNE	L196(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D0,-6(A6)
	MOVE	2(A2),D4
	LSR	#7,D4
	CMPI	#6,-6(A6)
	BNE	L197(PC)
	CMPI	#0,D4
	BLS	L198(PC)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L199
	CMPI	#511,D4
	BCC.S	L200
	ADDQ	#1,D4
L200:
	BRA.S	L201
L199:
	SUBQ	#1,D4
L201:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L202
	CMPI	#0,D4
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L203
	MOVE	#0,D0
	BRA.S	L204
L203:
	MOVE	#1,D0
L204:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L205
L202:
	CMPI	#0,D4
	BNE.S	L206
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L206:
L205:
L198:
	BRA	L207(PC)
L197:
	CMPI	#5,-6(A6)
	BNE	L208(PC)
	MOVE	#1,D5
	MOVE.B	8(A3),D3
	ASL	D3,D5
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L209
	MOVE	D4,D0
	AND	D5,D0
	BEQ.S	L210
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L211
L210:
	OR	D5,D4
L211:
	BRA.S	L212
L209:
	MOVE.B	9(A3),D0
	BEQ.S	L213
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L214
L213:
	OR	D5,D4
L214:
L212:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	D4,D5
	AND	#15,D5
	MOVE	D4,D1
	AND	#240,D1
	LSR	#4,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L215
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L216
	MOVE	#0,D0
	BRA.S	L217
L216:
	MOVE	#1,D0
L217:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L218
L215:
	MOVE	D5,D0
	BEQ.S	L219
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L219:
L218:
	BRA.S	L220
L208:
	CMPI	#7,-6(A6)
	BCS.S	L223
	CMPI	#10,-6(A6)
	BLS.S	L222
L223:
	CMPI	#14,-6(A6)
	BEQ.S	L222
	CMPI	#15,-6(A6)
	BNE.S	L221
L222:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L221
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F247_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L224
	ANDI	#-128,2(A2)
L224:
L221:
L220:
L207:
L196:
L195:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L189:
	CMPI	#-2,D7
	BNE	L190(PC)
L191:
	JSR	F271_xxxx_(PC)
L188:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$187:	.EQU	#-12
F249_xxxx_:/* global */
	LINK	A6,L$225
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L227
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L227
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L227
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	JSR	F296_aizz_(PC)
L227:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L228(PC)
L229:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	D4,D5
	AND	#15360,D5
	LSR	#2,D5
	LSR	#8,D5
	CMPI	#4,D5
	BCS.S	L231
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L231:
	CMPI	#14,D5
	BNE	L232(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	6(A3),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	G397_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,8(A2)
	OR	D3,8(A2)
	MOVE	G398_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,8(A2)
	OR	D3,8(A2)
	MOVE	G400_i_Mov(A4),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-3073,8(A2)
	OR	D3,8(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,6(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	BRA	L233(PC)
L232:
	CMPI	#15,D5
	BNE.S	L234
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L235
L236:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#25,D0
	BNE.S	L239
	MOVE	8(A2),D0
	CMP	D4,D0
	BNE.S	L239
	MOVE	G397_i_Mov(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G398_i_Mov(A4),D0
	MOVE.B	D0,7(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,8(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
L239:
L237:
	MOVE.L	A2,D0
	ADDA	#10,A2
	MOVE	D5,D0
	ADDQ	#1,D5
L235:
	MOVE	D5,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L236
L238:
L234:
L233:
	MOVE	-2(A6),D4
L228:
	CMPI	#-2,D4
	BNE	L229(PC)
L230:
L226:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$225:	.EQU	#-2
F250_xxxx_:/* global */
	LINK	A6,L$240
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L242
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L243
	MOVE	#1,D0
	BRA.S	L244
L243:
	MOVE	#0,D0
L244:
	MOVE.B	D0,9(A3)
L242:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L245
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L246
L245:
	ANDI.B	#-9,(A2)
L246:
L241:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$240:	.EQU	#0
F251_xxxx_:/* global */
	LINK	A6,L$247
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L249
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L250
	MOVE	#1,D0
	BRA.S	L251
L250:
	MOVE	#0,D0
L251:
	MOVE.B	D0,9(A3)
L249:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L252
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L253
L252:
	ANDI.B	#-9,(A2)
L253:
L248:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$247:	.EQU	#0
F252_xxxx_:/* global */
	LINK	A6,L$254
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	CLR	-2(A6)
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
L19T252_001:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L257
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L257
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L256
L257:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BNE.S	L256
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#61,D0
	BNE.S	L258
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L258:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	8(A3),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	BRA	L255(PC)
L256:
	MOVE	-2(A6),D0
	BNE.S	L259
	MOVE	#1,-2(A6)
	MOVE	8(A3),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#23,D0
	BNE.S	L260
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L260
	JSR	F029_AA19_(PC)
L261:
	CMP	#0,D0
	BEQ.S	L262
	BRA.S	L264
L262:
	SUBQ	#1,D7
	BRA.S	L263
	BRA.S	L265
L264:
	CMP	#1,D0
	BEQ.S	L265
	BRA.S	L266
L265:
	ADDQ	#1,D7
	BRA.S	L263
	BRA.S	L267
L266:
	CMP	#2,D0
	BEQ.S	L267
	BRA.S	L268
L267:
	SUBQ	#1,D6
	BRA.S	L263
	BRA.S	L269
L268:
	CMP	#3,D0
	BEQ.S	L269
	BRA.S	L270
L269:
	ADDQ	#1,D6
L270:
L271:
L263:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F223_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L272
	BRA	L19T252_001(PC)
L272:
L260:
L259:
	ADDQ.L	#5,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L255:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$254:	.EQU	#-2
F253_xxxx_:/* global */
	LINK	A6,L$273
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,44(A3)
	ANDI	#-9,48(A3)
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BEQ.S	L275
	MOVE.B	32(A3),D0
	AND	#255,D0
	LEA	G495_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	SUB	D0,64(A3)
L275:
	MOVE	52(A3),D0
	BEQ.S	L276
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#32,D0
	BNE.S	L277
	CMPI	#-1,212(A3)
	BNE.S	L277
	MOVE	#12,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L278
L20T253_002:
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L279
L278:
	CLR	D5
	BRA.S	L280
L281:
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L284
	BRA.S	L20T253_002
L284:
L282:
	ADDQ	#1,D5
L280:
	CMPI	#3,D5
	BLT.S	L281
L283:
L279:
L277:
	ORI	#-32768,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L276:
	MOVE.B	#-1,32(A3)
L274:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$273:	.EQU	#0
F254_xxxx_:/* global */
	LINK	A6,L$285
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,46(A3)
	MOVE	52(A3),D0
	BNE.S	L287
	BRA.S	L286
L287:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L288
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	BRA.S	L289
L288:
	ORI	#128,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L289:
L286:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$285:	.EQU	#0
F255_xxxx_:/* global */
	LINK	A6,L$290
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
	MOVE.B	8(A3),D5
	AND	#255,D5
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
L292:
	CMP	#2,D0
	BEQ.S	L293
	BRA.S	L295
L293:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-28,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	ADDQ.L	#5,(A3)
L22T255_002:
	SUBQ	#1,-4(A6)
	MOVE	-4(A6),D0
	MOVE.B	D0,9(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L294(PC)
	BRA.S	L296
L295:
	CMP	#1,D0
	BEQ.S	L296
	BRA	L297(PC)
L296:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L299
L300:
	MOVE	D4,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	D5,D0
	BNE.S	L303
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#10,D0
	BNE.S	L303
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#147,-2(A6)
	BNE.S	L304
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-6(A6),D0
	BNE.S	L305
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	BRA	L22T255_002(PC)
L305:
L304:
L303:
L301:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L299:
	CMPI	#-2,D4
	BNE.S	L300
L302:
	BRA.S	L294
	BRA.S	L298
L297:
	CMP	#0,D0
	BEQ.S	L298
	BRA.S	L306
L298:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F283_azzz_(PC)
	ADDQ.L	#2,A7
L306:
L307:
L294:
L291:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$290:	.EQU	#-6
F256_xxxx_:/* global */
	LINK	A6,L$308
	MOVE.B	#53,-6(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#300,D0
	MOVE.L	D0,G374_l_Wat(A4)
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L309:
	UNLK	A6
	RTS
L$308:	.EQU	#-10
F257_xxxx_:/* global */
	LINK	A6,L$310
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	6(A3),D0
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L312
	BRA.S	L311
L312:
	CMPI	#0,D6
	SLT	D5
	AND	#1,D5
	BEQ.S	L313
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
L313:
	MOVE	D6,D7
	SUBQ	#1,D7
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G039_ai_Gr(A4),A0
	ADDA	D1,A0
	SUB	(A0),D0
	MOVE	D0,D6
	MOVE	D5,D0
	BEQ.S	L314
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
	MOVE	D7,D0
	NEG	D0
	MOVE	D0,D7
L314:
	MOVE	D6,D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	D7,D0
	BEQ.S	L315
	MOVE.B	#70,-6(A6)
	MOVE	D7,-4(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#4,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	CLR.B	-5(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L315:
L311:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$310:	.EQU	#-10
F258_xxxx_:/* global */
	LINK	A6,L$316
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L318
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	BRA.S	L317
L318:
	MOVE	#0,D0
L317:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$316:	.EQU	#0
F259_xxxx_:/* global */
	LINK	A6,L$319
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L321
	BRA.S	L320
L321:
	MOVE	D6,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L322
	BRA.S	L320
L322:
	MOVE	#7,D5
	BRA.S	L323
L324:
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L327
	BRA.S	L320
L327:
L325:
	ADDQ	#1,D5
L323:
	CMPI	#9,D5
	BLS.S	L324
L326:
L320:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$319:	.EQU	#0
F260_pzzz_:/* global */
	LINK	A6,L$328
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L330
L331:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L332:
	ADDQ	#1,D7
L330:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L331
L333:
	JSR	F293_ahzz_(PC)
L329:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$328:	.EQU	#0
F261_hzzz_:/* global */
	LINK	A6,L$334
	MOVEM.L	A3/D7,-(A7)
	BRA	L336(PC)
L337:
	LEA	-10(A6),A0
	MOVE.L	A0,A3
	MOVE.L	A3,-(A7)
	JSR	F239_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	-10(A6),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	G319_ul_Lo(A4),D0
	CMP.L	G313_ul_Ga(A4),D0
	BHI.S	L339
	MOVE.B	-6(A6),D7
	AND	#255,D7
L339:
	CMPI	#28,D7
	BLS.S	L340
	CMPI	#42,D7
	BCC.S	L340
	MOVE.B	-2(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
	BRA	L341(PC)
L340:
	MOVE	D7,D0
L342:
	CMP	#48,D0
	BEQ.S	L343
L345:
	CMP	#49,D0
	BEQ.S	L343
	BRA.S	L346
L343:
	MOVE.L	A3,-(A7)
	JSR	F219_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L347
L346:
	CMP	#1,D0
	BEQ.S	L347
	BRA.S	L348
L347:
	MOVE.L	A3,-(A7)
	JSR	F241_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L349
L348:
	CMP	#25,D0
	BEQ.S	L349
	BRA.S	L350
L349:
	MOVE.L	A3,-(A7)
	JSR	F220_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L351
L350:
	CMP	#7,D0
	BEQ.S	L351
	BRA.S	L352
L351:
	MOVE.L	A3,-(A7)
	JSR	F242_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L353
L352:
	CMP	#2,D0
	BEQ.S	L353
	BRA.S	L354
L353:
	MOVE.L	A3,-(A7)
	JSR	F243_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L355
L354:
	CMP	#10,D0
	BEQ.S	L355
	BRA.S	L356
L355:
	MOVE.L	A3,-(A7)
	JSR	F244_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L357
L356:
	CMP	#9,D0
	BEQ.S	L357
	BRA.S	L358
L357:
	MOVE.L	A3,-(A7)
	JSR	F251_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L359
L358:
	CMP	#8,D0
	BEQ.S	L359
	BRA.S	L360
L359:
	MOVE.L	A3,-(A7)
	JSR	F250_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L361
L360:
	CMP	#6,D0
	BEQ.S	L361
	BRA.S	L362
L361:
	MOVE.L	A3,-(A7)
	JSR	F248_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L363
L362:
	CMP	#5,D0
	BEQ.S	L363
	BRA.S	L364
L363:
	MOVE.L	A3,-(A7)
	JSR	F245_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L365
L364:
	CMP	#60,D0
	BEQ.S	L365
L366:
	CMP	#61,D0
	BEQ.S	L365
	BRA.S	L367
L365:
	MOVE.L	A3,-(A7)
	JSR	F252_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L368
L367:
	CMP	#65,D0
	BEQ.S	L368
	BRA.S	L369
L368:
	MOVE.L	A3,-(A7)
	JSR	F246_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L370
L369:
	CMP	#20,D0
	BEQ.S	L370
	BRA.S	L371
L370:
	MOVE	#1,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L344(PC)
	BRA.S	L372
L371:
	CMP	#24,D0
	BEQ.S	L372
	BRA.S	L373
L372:
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L375
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
L375:
	BRA	L344(PC)
	BRA.S	L374
L373:
	CMP	#22,D0
	BEQ.S	L374
	BRA.S	L376
L374:
	PEA	G295_ac_Se(A4)
	JSR	F210_uzzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L378
	MOVE	#136,G022_i_Gra(A4)
L378:
	BRA	L344(PC)
	BRA.S	L377
L376:
	CMP	#11,D0
	BEQ.S	L377
	BRA.S	L379
L377:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F253_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.B	-4(A6),D0
	BEQ.S	L381
	MOVE.B	-4(A6),D0
	EXT	D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F259_xxxx_(PC)
	ADDQ.L	#4,A7
L381:
	BRA	L28T261_048(PC)
	BRA.S	L380
L379:
	CMP	#12,D0
	BEQ.S	L380
	BRA.S	L382
L380:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F254_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L344(PC)
	BRA.S	L383
L382:
	CMP	#53,D0
	BEQ.S	L383
	BRA.S	L384
L383:
	MOVE.L	A3,-(A7)
	JSR	F256_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L344(PC)
	BRA.S	L385
L384:
	CMP	#70,D0
	BEQ.S	L385
	BRA.S	L386
L385:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F257_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F337_akzz_(PC)
	BRA	L344(PC)
	BRA.S	L387
L386:
	CMP	#71,D0
	BEQ.S	L387
	BRA.S	L388
L387:
	SUBQ.B	#1,G407_s_Par+3286(A4)
	BRA	L344(PC)
	BRA.S	L389
L388:
	CMP	#72,D0
	BEQ.S	L389
	BRA.S	L390
L389:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+274(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	-4(A6),D0
	MOVE	D0,(A0)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L28T261_048:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	BRA	L344(PC)
	BRA.S	L391
L390:
	CMP	#73,D0
	BEQ.S	L391
	BRA.S	L392
L391:
	SUBQ.B	#1,G407_s_Par+3202(A4)
	BRA	L344(PC)
	BRA.S	L393
L392:
	CMP	#74,D0
	BEQ.S	L393
	BRA.S	L394
L393:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3204(A4)
L28T261_053:
	JSR	F260_pzzz_(PC)
	BRA.S	L344
	BRA.S	L395
L394:
	CMP	#77,D0
	BEQ.S	L395
	BRA.S	L396
L395:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3208(A4)
	BRA.S	L28T261_053
	BRA.S	L397
L396:
	CMP	#78,D0
	BEQ.S	L397
	BRA.S	L398
L397:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3206(A4)
	BRA.S	L28T261_053
	BRA.S	L399
L398:
	CMP	#75,D0
	BEQ.S	L399
	BRA.S	L400
L399:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	SUBQ.B	#1,(A0)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L344
	BRA.S	L401
L400:
	CMP	#13,D0
	BEQ.S	L401
	BRA.S	L402
L401:
	MOVE.L	A3,-(A7)
	JSR	F255_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L344
	BRA.S	L403
L402:
	CMP	#79,D0
	BEQ.S	L403
	BRA.S	L404
L403:
	SUBQ.B	#1,G407_s_Par+3203(A4)
L404:
L405:
L344:
L341:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L336:
	JSR	F240_xxxx_(PC)
	TST	D0
	BNE	L337(PC)
L338:
L335:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$334:	.EQU	#-10
