BSS SEG "bss"
G407_s_Par:/* global */
	.WORD	#3328
G408_ac_Co:/* global */
	.WORD	#68
G409_ai_Ch:/* global */
	.WORD	#8
G410_ai_Ch:/* global */
	.WORD	#8
CODE SEG "init!"
	MOVE	#-1,G411_i_Lea(A4)
BSS SEG "bss"
G411_i_Lea:/* global */
	.WORD	#2
G412_puc_B:/* global */
	.WORD	#4
G413_i_Lea:/* global */
	.WORD	#2
G414_T_Lea:/* global */
	.WORD	#2
G415_B_Lea:/* global */
	.WORD	#2
G416_i_Use:/* global */
	.WORD	#2
CODE SEG "init!"
	LEA	G417_apc_B(A4),A1
DATA SEG "s!"
s!:
	DATA 4B 41 4D 50 46 45 52 00 
CODE SEG "init!"
	LEA	s!(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4E 49 4E 4A 41 00 
CODE SEG "init!"
	LEA	s!+8(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 50 52 49 45 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+14(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4D 41 47 49 45 52 00 00 
CODE SEG "init!"
	LEA	s!+24(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
G417_apc_B:/* global */
	.WORD	#16
G418_l_Las:/* global */
	.WORD	#4
CODE SEG "player"
F278_apzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	G298_B_New(A4),D0
	BNE	L2(PC)
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L3
	MOVE	#1,G415_B_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	JSR	F069_aaaL_(PC)
	BRA.S	L4
L3:
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L4:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L5
L6:
	ANDI	#127,48(A3)
	ORI	#-27648,48(A3)
L7:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L5:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L6
L8:
	JSR	F293_ahzz_(PC)
	MOVE	G411_i_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L9
	MOVE	#-1,G411_i_Lea(A4)
	MOVE	D7,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L9:
	MOVE	G514_i_Mag(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L10
	MOVE	#-1,G514_i_Mag(A4)
	MOVE	D7,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
L10:
	BRA.S	L11
L2:
	MOVE	#-1,G414_T_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	MOVE	#1,G415_B_Lea(A4)
L11:
L1:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-8
F279_xxxx_:/* global */
	LINK	A6,L$12
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	CLR	D5
	CLR	D6
	BRA.S	L14
L15:
	MOVE	D5,D0
	ASL	#4,D0
	MOVE.B	(A3)+,D1
	EXT	D1
	SUB	#65,D1
	ADD	D1,D0
	MOVE	D0,D5
L16:
	ADDQ	#1,D6
L14:
	MOVE	D6,D0
	CMP	D7,D0
	BCS.S	L15
L17:
	MOVE	D5,D0
L13:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$12:	.EQU	#0
F280_agzz_:/* global */
	LINK	A6,L$18
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L20
	BRA	L19(PC)
L20:
	CMPI	#4,G305_ui_Pa(A4)
	BNE.S	L21
	BRA	L19(PC)
L21:
	MOVE	G305_ui_Pa(A4),D0
	MOVE	D0,-2(A6)
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#800,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#-1,-(A7)
	MOVE	#16,-(A7)
	MOVE	#128,-(A7)
	MOVE	8(A6),D0
	LSR	#3,D0
	MULU	#29,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),D0
	AND	#7,D0
	ASL	#5,D0
	MOVE	D0,-(A7)
	PEA	G047_s_Gra(A4)
	LEA	336(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#26,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE.B	#1,30(A3)
	MOVE.B	#2,31(A3)
	MOVE.B	#-1,32(A3)
	MOVE	#-1,44(A3)
	MOVE	#-1,46(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR	D6
	BRA.S	L22
L23:
L24:
	ADDQ	#1,D6
L22:
	MOVE	D6,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BNE.S	L23
L25:
	MOVE	D6,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE.B	D0,29(A3)
	MOVE	#1024,48(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,40(A3)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#255,D1
	MOVE	#1500,D0
	ADD	D1,D0
	MOVE	D0,66(A3)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#255,D1
	MOVE	#1500,D0
	ADD	D1,D0
	MOVE	D0,68(A3)
	CLR	D6
	BRA.S	L26
L27:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L28:
	ADDQ	#1,D6
L26:
	CMPI	#30,D6
	BCS.S	L27
L29:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L30
L31:
L32:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L30:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#2,D0
	BNE.S	L31
L33:
	MOVE	#-32766,-(A7)
	MOVE	D7,-(A7)
	LEA	-96(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	CLR	D6
	BRA.S	L34
L35:
	MOVE	D4,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	LEA	(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L34:
	MOVE.B	(A2)+,D0
	AND	#255,D0
	MOVE	D0,D4
	CMPI	#10,D0
	BNE.S	L35
L36:
	MOVE	D6,D0
	LEA	(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	CLR	D6
	CLR	-4(A6)
L37:
	MOVE.B	(A2)+,D4
	AND	#255,D4
	CMPI	#10,D4
	BNE.S	L40
	MOVE	-4(A6),D0
	BEQ.S	L41
	BRA.S	L39
L41:
	MOVE	#1,-4(A6)
	BRA.S	L42
L40:
	MOVE	D4,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	LEA	8(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L42:
L38:
	BRA.S	L37
L39:
	MOVE	D6,D0
	LEA	8(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE.B	(A2)+,D0
	EXT	D0
	CMP	#77,D0
	BNE.S	L43
	ORI	#16,48(A3)
L43:
	ADDQ.L	#1,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,54(A3)
	MOVE	D0,52(A3)
	ADDQ.L	#4,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,58(A3)
	MOVE	D0,56(A3)
	ADDQ.L	#4,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,62(A3)
	MOVE	D0,60(A3)
	ADDQ.L	#4,A2
	ADDQ.L	#1,A2
	CLR	D6
	BRA.S	L44
L45:
	MOVE	D6,D0
	MULS	#3,D0
	LEA	72(A3),A0
	ADDA	D0,A0
	MOVE.B	#30,(A0)
	MOVE	#2,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,D1
	MULS	#3,D1
	LEA	70(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D6,D1
	MULS	#3,D1
	LEA	71(A3),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
	ADDQ.L	#2,A2
L46:
	ADDQ	#1,D6
L44:
	CMPI	#6,D6
	BLS.S	L45
L47:
	MOVE.B	#10,72(A3)
	ADDQ.L	#1,A2
	MOVE	#4,D6
	BRA.S	L48
L49:
	MOVE.B	(A2)+,D0
	EXT	D0
	SUB	#65,D0
	MOVE	D0,D4
	CMPI	#0,D0
	BLS.S	L52
	MOVE.L	#125,D0
	ASL.L	D4,D0
	MOVE	D6,D1
	MULS	#6,D1
	LEA	94(A3),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L52:
L50:
	ADDQ	#1,D6
L48:
	CMPI	#19,D6
	BLS.S	L49
L51:
	CLR	D6
	BRA.S	L53
L54:
	CLR.L	-18(A6)
	MOVE	D6,D5
	ADDQ	#1,D5
	ASL	#2,D5
	CLR	-4(A6)
	BRA.S	L57
L58:
	MOVE	D5,D0
	ADD	-4(A6),D0
	MULS	#6,D0
	LEA	94(A3),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	ADD.L	D0,-18(A6)
L59:
	ADDQ	#1,-4(A6)
L57:
	CMPI	#4,-4(A6)
	BCS.S	L58
L60:
	MOVE	D6,D0
	MULS	#6,D0
	LEA	94(A3),A0
	ADDA	D0,A0
	MOVE.L	-18(A6),(A0)
L55:
	ADDQ	#1,D6
L53:
	CMPI	#3,D6
	BLS.S	L54
L56:
	MOVE	-2(A6),D0
	ADDQ	#1,D0
	MOVE	D0,G299_ui_Ca(A4)
	ADDQ	#1,G305_ui_Pa(A4)
	MOVE	G305_ui_Pa(A4),D0
	CMPI	#1,D0
	BNE.S	L61
	CLR	-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,G508_B_Ref(A4)
	BRA.S	L62
L61:
	JSR	F388_rzzz_(PC)
	MOVE	G305_ui_Pa(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L62:
	MOVE	G306_i_Par(A4),-8(A6)
	MOVE	G307_i_Par(A4),-10(A6)
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-12(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-10(A6),D0
	ADD	D1,D0
	MOVE	D0,-10(A6)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	#13,D6
	BRA	L63(PC)
L64:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D4
	CMPI	#3,D0
	BLS	L66(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-12(A6),D0
	BNE	L66(PC)
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-14(A6)
	MOVE	D4,D0
L67:
	CMP	#6,D0
	BEQ.S	L68
	BRA.S	L70
L68:
	MOVE	#2,-6(A6)
	BRA.S	L72
L73:
	MOVE	-14(A6),D0
	MOVE	-6(A6),D1
	ASL.L	#1,D1
	LEA	G038_ai_Gr(A4),A0
	ADDA	D1,A0
	AND	(A0),D0
	BEQ.S	L76
	BRA	L2T280_048(PC)
L76:
L74:
	ADDQ	#1,-6(A6)
L72:
	CMPI	#5,-6(A6)
	BLS.S	L73
L75:
	MOVE	-14(A6),D0
	AND	G038_ai_Gr+20(A4),D0
	BEQ.S	L77
	CMPI	#-1,232(A3)
	BNE.S	L77
	MOVE	#10,-6(A6)
	BRA.S	L78
L77:
	BRA.S	L2T280_046
L78:
	BRA	L69(PC)
	BRA.S	L71
L70:
	CMP	#5,D0
	BEQ.S	L71
	BRA.S	L79
L71:
	CMPI	#-1,214(A3)
	BNE.S	L81
	MOVE	#1,-6(A6)
	BRA.S	L82
L81:
	BRA.S	L2T280_046
L82:
	BRA.S	L69
	BRA.S	L80
L79:
	CMP	#7,D0
	BEQ.S	L80
L83:
	CMP	#8,D0
	BEQ.S	L80
	BRA.S	L84
L80:
	CMPI	#-1,234(A3)
	BNE.S	L86
	MOVE	#11,-6(A6)
	BRA.S	L87
L86:
	CMPI	#-1,224(A3)
	BNE.S	L88
	MOVE	#6,-6(A6)
	BRA.S	L89
L88:
	BRA.S	L2T280_046
L89:
L87:
	BRA.S	L69
	BRA.S	L85
L84:
	CMP	#9,D0
	BEQ.S	L85
L90:
	CMP	#10,D0
	BEQ.S	L85
	BRA.S	L91
L85:
L2T280_046:
	MOVE	-14(A6),D0
	AND	G038_ai_Gr+20(A4),D0
	BEQ.S	L93
	CMPI	#-1,232(A3)
	BNE.S	L93
	MOVE	#10,-6(A6)
	BRA.S	L94
L93:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D0,-6(A6)
L94:
L91:
L92:
L69:
L2T280_048:
	MOVE	-6(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L95
	BRA.S	L2T280_046
L95:
	MOVE	-6(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
L66:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L63:
	CMPI	#-2,D7
	BNE	L64(PC)
L65:
	MOVE	-2(A6),-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	JSR	F456_vzzz_(PC)
L19:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$18:	.EQU	#-96
F281_xxxx_:/* global */
	LINK	A6,L$96
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	#3,-8(A6)
	MOVE	#8,-6(A6)
	MOVE	#3,D0
	MOVE	D0,-12(A6)
	ADD	#167,D0
	MOVE	D0,-10(A6)
	MOVE	#112,-(A7)
	MOVE	#12,-(A7)
	PEA	-12(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#4,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#27,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
DATA SEG "s!"
	DATA 5F 5F 5F 5F 5F 5F 5F 00 
CODE SEG "player"
	PEA	s!+32(A4)
	MOVE	#13,-(A7)
	MOVE	#58,-(A7)
	MOVE	#177,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 00 
CODE SEG "player"
	PEA	s!+40(A4)
	MOVE	#13,-(A7)
	MOVE	#76,-(A7)
	MOVE	#105,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	JSR	F077_aA39_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	CLR.B	8(A3)
	MOVE	#1,D6
	LEA	(A3),A0
	MOVE.L	A0,A2
	MOVE	#177,-2(A6)
	MOVE	#91,-4(A6)
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	MOVE	D0,-20(A6)
L98:
	CMPI	#2,D6
	SEQ	D0
	TST.B	D0
	BEQ.S	L102
	CMPI	#19,D7
	SEQ	D0
	TST.B	D0
L102:
	AND	#1,D0
	MOVE	D0,D4
	BNE.S	L101
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#9,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L101:
	BRA	L103(PC)
L104:
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	MOVE	D0,-18(A6)
	MOVE	-18(A6),D0
	BEQ	L106(PC)
	MOVE	-20(A6),D0
	BNE	L106(PC)
	MOVE	G589_i_Mou(A4),-14(A6)
	MOVE	G590_i_Mou(A4),-16(A6)
	CMPI	#2,D6
	BEQ.S	L108
	CMPI	#0,D7
	BLS	L107(PC)
L108:
	CMPI	#197,-14(A6)
	BCS	L107(PC)
	CMPI	#215,-14(A6)
	BHI	L107(PC)
	CMPI	#147,-16(A6)
	BCS	L107(PC)
	CMPI	#155,-16(A6)
	BHI	L107(PC)
	MOVE	D7,-22(A6)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	PEA	-30(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L109
L110:
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
L109:
	SUBQ	#1,D7
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#32,D0
	BEQ.S	L110
L111:
	CLR	D7
	BRA.S	L112
L113:
	MOVE.L	A2,-(A7)
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	strcmp(PC)
	ADDQ.L	#8,A7
	TST	D0
	BNE.S	L116
	BRA.S	L3T281_011_
L116:
L114:
	ADDQ	#1,D7
L112:
	MOVE	D7,D0
	MOVE	G305_ui_Pa(A4),D1
	SUBQ	#1,D1
	CMP	D1,D0
	BCS.S	L113
L115:
	BRA	L97(PC)
L3T281_011_:
	CMPI	#2,D6
	BNE.S	L117
	LEA	8(A3),A0
	MOVE.L	A0,A2
L117:
	PEA	-30(A6)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	-22(A6),D7
	BRA	L118(PC)
L107:
	CMPI	#107,-14(A6)
	BCS.S	L119
	CMPI	#175,-14(A6)
	BHI.S	L119
	CMPI	#147,-16(A6)
	BCS.S	L119
	CMPI	#155,-16(A6)
	BHI.S	L119
	MOVE	#8,D5
	BRA	L105(PC)
L119:
	CMPI	#107,-14(A6)
	BCS.S	L121
	CMPI	#215,-14(A6)
	BHI.S	L121
	CMPI	#116,-16(A6)
	BCS.S	L121
	CMPI	#144,-16(A6)
	BLS.S	L120
L121:
	BRA	L3T281_023(PC)
L120:
	MOVE	-14(A6),D0
	ADDQ	#4,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	TST	D0
	BEQ.S	L123
	MOVE	-16(A6),D0
	ADDQ	#5,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	TST	D0
	BNE.S	L122
	CMPI	#207,-14(A6)
	BCS.S	L124
	CMPI	#135,-16(A6)
	BEQ.S	L122
L124:
L123:
	BRA.S	L3T281_023
L122:
	MOVE	#11,D5
	MOVE	-16(A6),D1
	SUB	#116,D1
	AND.L	#65535,D1
	DIVU	#10,D1
	MULU	D1,D5
	MOVE	D5,-40(A6)
	MOVE	#65,D5
	ADD	-40(A6),D5
	MOVE	-14(A6),D1
	SUB	#107,D1
	AND.L	#65535,D1
	DIVU	#10,D1
	ADD	D1,D5
	CMPI	#86,D5
	BEQ.S	L126
	CMPI	#97,D5
	BNE.S	L125
L126:
	MOVE	#13,D5
	BRA.S	L105
L125:
	CMPI	#87,D5
	BLT.S	L127
	SUBQ	#1,D5
L127:
	CMPI	#90,D5
	BLE.S	L128
	MOVE	D5,D0
	SUB	#90,D0
	LEA	G053_ac_Gr+-1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	MOVE	D0,D5
L128:
	BRA.S	L105
L118:
L106:
L3T281_023:
	MOVE	-18(A6),-20(A6)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L103:
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ	L104(PC)
L105:
	MOVE	-18(A6),-20(A6)
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L129
	MOVE	#7,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
L129:
	CMPI	#97,D5
	BLT.S	L130
	CMPI	#122,D5
	BGT.S	L130
	SUB	#32,D5
L130:
	CMPI	#65,D5
	BLT.S	L133
	CMPI	#90,D5
	BLE.S	L132
L133:
	CMPI	#46,D5
	BEQ.S	L132
	CMPI	#44,D5
	BEQ.S	L132
	CMPI	#59,D5
	BEQ.S	L132
	CMPI	#58,D5
	BEQ.S	L132
	CMPI	#32,D5
	BNE.S	L131
L132:
	CMPI	#32,D5
	BNE.S	L134
	CMPI	#0,D7
	BNE.S	L134
	BRA.S	L135
L134:
	MOVE	D4,D0
	BNE.S	L136
	MOVE	D5,D0
	MOVE.B	D0,G052_ac_Gr(A4)
	JSR	F077_aA39_(PC)
	PEA	G052_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
	MOVE	D5,D0
	MOVE	D7,D1
	ADDQ	#1,D7
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
	ADDQ	#6,-2(A6)
	CMPI	#1,D6
	BNE.S	L137
	CMPI	#7,D7
	BNE.S	L137
	BRA.S	L3T281_033_
L137:
L136:
L135:
	BRA	L138(PC)
L131:
	CMPI	#13,D5
	BNE.S	L139
	CMPI	#1,D6
	BNE.S	L140
	CMPI	#0,D7
	BLS.S	L140
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L3T281_033_:
	MOVE	#2,D6
	LEA	8(A3),A0
	MOVE.L	A0,A2
	MOVE	#105,-2(A6)
	MOVE	#109,-4(A6)
	CLR	D7
L140:
	BRA	L141(PC)
L139:
	CMPI	#8,D5
	BNE	L142(PC)
	CMPI	#1,D6
	BNE.S	L143
	CMPI	#0,D7
	BNE.S	L143
	BRA.S	L99
L143:
	MOVE	D4,D0
	BNE.S	L144
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L144:
	CMPI	#0,D7
	BNE.S	L145
	LEA	(A3),A0
	MOVE.L	A0,A2
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	SUBQ	#1,D0
	MOVE	D0,D7
	MOVE	#1,D6
	MOVE	#177,D0
	MOVE	D7,D1
	MULU	#6,D1
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	#91,-4(A6)
	BRA.S	L146
L145:
	SUBQ	#1,D7
	SUBQ	#6,-2(A6)
L146:
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
L142:
L141:
L138:
L99:
	BRA	L98(PC)
L100:
L97:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$96:	.EQU	#-40
F282_xzzz_:/* global */
	LINK	A6,L$147
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#162,8(A6)
	BNE	L149(PC)
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	CLR	G299_ui_Ca(A4)
	CMPI	#1,G305_ui_Pa(A4)
	BNE.S	L150
	MOVE	#-1,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L150:
	SUBQ	#1,G305_ui_Pa(A4)
	CLR	-8(A6)
	MOVE	#28,-6(A6)
	MOVE	D7,D0
	MULU	#69,D0
	MOVE	D0,-12(A6)
	ADD	#66,D0
	MOVE	D0,-10(A6)
	CLR	G578_B_Use(A4)
	JSR	F077_aA39_(PC)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	-12(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	MOVE.B	29(A3),D0
	AND	#255,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	JSR	F457_AA08_(PC)
	JSR	F078_xzzz_(PC)
	BRA	L151(PC)
L149:
	CLR	G299_ui_Ca(A4)
	MOVE	G306_i_Par(A4),-2(A6)
	MOVE	G307_i_Par(A4),-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	CLR	D6
	BRA.S	L152
L153:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#-1,D0
	BEQ.S	L156
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L156:
L154:
	ADDQ	#1,D6
L152:
	CMPI	#30,D6
	BCS.S	L153
L155:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L157:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L160
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	ANDI	#-128,2(A2)
	BRA.S	L159
L160:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L158:
	BRA.S	L157
L159:
	CMPI	#161,8(A6)
	BNE.S	L161
	MOVE.L	A3,-(A7)
	JSR	F281_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#120,-(A7)
	LEA	92(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	D6
	BRA.S	L162
L163:
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#7,D0
	SWAP	D0
	MOVE	D0,D5
	MOVE	D5,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	ADDQ.B	#1,(A0)
	MOVE	D5,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	ADDQ.B	#1,(A0)
L164:
	ADDQ	#1,D6
L162:
	CMPI	#12,D6
	BCS.S	L163
L165:
L161:
	CMPI	#1,G305_ui_Pa(A4)
	BNE.S	L166
	MOVE.L	G313_ul_Ga(A4),G362_l_Las(A4)
	CLR	-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L167
L166:
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
L167:
	JSR	F051_AA19_(PC)
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 5A 55 4D 20 4C 45 42 45 4E 20 45 52 57 45 43 4B 54 2E 00 20 52 45 49 4E 4B 41 52 4E 49 45 52 54 2E 00 00 
CODE SEG "player"
	CMPI	#160,8(A6)
	BNE.S	L168
	LEA	s!+60(A4),A0
	MOVE.L	A0,D0
	BRA.S	L169
L168:
	LEA	s!+80(A4),A0
	MOVE.L	A0,D0
L169:
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	JSR	F457_AA08_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L170
	MOVE	#0,D0
	BRA.S	L171
L170:
	MOVE	#1,D0
L171:
	MOVE	D0,-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
L151:
L148:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$147:	.EQU	#-12
F283_azzz_:/* global */
	LINK	A6,L$172
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	29(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L174
	CLR	D7
	BRA.S	L175
L176:
L177:
	ADDQ	#1,D7
L175:
	MOVE	D7,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BNE.S	L176
L178:
	MOVE	D7,D0
	MOVE.B	D0,29(A3)
L174:
	MOVE	54(A3),D7
	MOVE	D7,D0
	MOVE	D7,D1
	LSR	#6,D1
	SUB	D1,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#25,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,54(A3)
	ASR	#1,D0
	MOVE	D0,52(A3)
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	ORI	#-27648,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L173:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$172:	.EQU	#0
F284_czzz_:/* global */
	LINK	A6,L$179
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G308_i_Par(A4),D0
	BNE.S	L181
	BRA.S	L180
L181:
	MOVE	D7,D0
	SUB	G308_i_Par(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L182
	ADDQ	#4,D5
L182:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D6
	BRA.S	L183
L184:
	MOVE.B	29(A3),D0
	AND	#255,D0
	ADD	D5,D0
	AND	#3,D0
	MOVE.B	D0,29(A3)
	MOVE.B	28(A3),D0
	AND	#255,D0
	ADD	D5,D0
	AND	#3,D0
	MOVE.B	D0,28(A3)
	ADDA	#800,A3
L185:
	ADDQ	#1,D6
L183:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L184
L186:
	MOVE	D7,G308_i_Par(A4)
	JSR	F296_aizz_(PC)
L180:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$179:	.EQU	#0
F285_szzz_:/* global */
	LINK	A6,L$187
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#0,D0
	MOVE	D0,D6
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L189
L190:
	MOVE.B	29(A3),D0
	AND	#255,D0
	CMP	D7,D0
	BNE.S	L193
	MOVE	52(A3),D0
	BEQ.S	L193
	MOVE	D6,D0
	BRA.S	L188
L193:
L191:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	A3,D0
	ADDA	#800,A3
L189:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L190
L192:
	MOVE	#-1,D0
L188:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$187:	.EQU	#0
F286_hzzz_:/* global */
	LINK	A6,L$194
	MOVEM.L	D7-D6,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BEQ	L196(PC)
	MOVE	8(A6),D0
	MOVE	G306_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	10(A6),D0
	MOVE	G307_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	CMPI	#1,D0
	BGT.S	L196
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	PEA	-4(A6)
	JSR	F229_hzzz_(PC)
	ADDA	#14,A7
	CLR	D7
	BRA.S	L197
L198:
	MOVE	D7,D0
	LEA	-4(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#0,D0
	BLT.S	L201
	MOVE	D6,D0
	BRA.S	L195
L201:
L199:
	ADDQ	#1,D7
L197:
	CMPI	#4,D7
	BCS.S	L198
L200:
L196:
	MOVE	#-1,D0
L195:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$194:	.EQU	#-4
F287_xxxx_:/* global */
	LINK	A6,L$202
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	D6
	CMPI	#0,52(A3)
	BLE.S	L204
	MOVE	52(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	54(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L205
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L206
L205:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L206:
	BRA.S	L207
L204:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L207:
	CMPI	#0,56(A3)
	BLE.S	L208
	MOVE	56(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	58(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L209
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L210
L209:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L210:
	BRA.S	L211
L208:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L211:
	CMPI	#0,60(A3)
	BLE.S	L212
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BLE.S	L213
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	MOVE	#25,(A0)
	BRA.S	L214
L213:
	MOVE	60(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	62(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L215
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L216
L215:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L216:
L214:
	BRA.S	L217
L212:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L217:
	JSR	F077_aA39_(PC)
	MOVE.L	G348_pl_Bi(A4),A0
	LEA	320(A0),A0
	MOVE	8(A6),D1
	EXT.L	D1
	CMP	#3,D1
	BCS.S	L9T287_014
	MOVE.L	#-./,),(-*,(,D6
	MOVE.L	D6,D7
	ADDQ.L	#1,D7
	BRA.S	L9T287_017
L9T287_014:
	CMP	#2,D1
	BCS.S	L9T287_015
	MOVEQ	#0,D6
	MOVE.L	#-./,),(-*,(,D7
	BRA.S	L9T287_017
L9T287_015:
	CMP	#1,D1
	BCS.S	L9T287_016
	MOVE.L	#-2147483647,D6
	MOVE.L	D6,D7
	SUBQ.L	#1,D7
	BRA.S	L9T287_017
L9T287_016:
	MOVE.L	#-2147483647,D6
	MOVEQ	#1,D7
L9T287_017:
	ADD	D1,D1
	MOVE	D1,D2
	ADD	D1,D1
	ADD	D2,D1
	MOVE	D1,-8(A6)
	ADDQ	#4,-8(A6)
	LEA	-6(A6),A3
L9T287_018_:
	MOVE.L	A0,A2
	LEA	G056_aaui_(A4),A1
	ADDA	0(A1,D1),A2
	LSL	#1,D1
	LEA	G055_aaaui(A4),A1
	MOVE	0(A1,D1),D2
	MOVE	2(A1,D1),D3
	MOVE	D2,D4
	NOT	D4
	MOVE	D3,D5
	NOT	D5
	LSR	#1,D1
	MOVE	(A3)+,D0
	JSR	S287_xxxx_(PC)
	CMP	-8(A6),D1
	BEQ	L9T287_030(PC)
	ADDQ	#2,D1
	BRA.S	L9T287_018_
S287_xxxx_:/* global */
	MOVE	D1,-(A7)
	MOVE	#24,D1
L9T287_020_:
	CMP	D1,D0
	BHI.S	L9T287_021
	AND	D4,(A2)
	AND	D5,8(A2)
	AND	D4,2(A2)
	AND	D5,10(A2)
	OR	D2,4(A2)
	OR	D3,12(A2)
	OR	D2,6(A2)
	OR	D3,14(A2)
	BRA.S	L9T287_029
L9T287_021:
	TST	D6
	BEQ.S	L9T287_022
	OR	D2,(A2)
	OR	D3,8(A2)
	BRA.S	L9T287_023
L9T287_022:
	AND	D4,(A2)
	AND	D5,8(A2)
L9T287_023:
	TST.L	D6
	BGE.S	L9T287_024
	OR	D2,2(A2)
	OR	D3,10(A2)
	BRA.S	L9T287_025
L9T287_024:
	AND	D4,2(A2)
	AND	D5,10(A2)
L9T287_025:
	TST	D7
	BEQ.S	L9T287_026
	OR	D2,4(A2)
	OR	D3,12(A2)
	BRA.S	L9T287_027
L9T287_026:
	AND	D4,4(A2)
	AND	D5,12(A2)
L9T287_027:
	TST.L	D7
	BGE.S	L9T287_028
	OR	D2,6(A2)
	OR	D3,14(A2)
	BRA.S	L9T287_029
L9T287_028:
	AND	D4,6(A2)
	AND	D5,14(A2)
L9T287_029:
	LEA	160(A2),A2
	DBF	D1,L9T287_020_
	MOVE	(A7)+,D1
	RTS
L9T287_030:
	JSR	F078_xzzz_(PC)
L203:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$202:	.EQU	#-8
F288_xxxx_:/* global */
	LINK	A6,L$218
BSS SEG "bss"
11G419_ac_:
	.WORD	#6
CODE SEG "player"
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D6,D0
	BEQ.S	L220
	MOVE	#1,-(A7)
	MOVE	#32,-(A7)
	MOVE	#4,-(A7)
	PEA	11G419_ac_(A4)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
L220:
	LEA	11G419_ac_+4(A4),A0
	MOVE.L	A0,A3
	CLR.B	(A3)
	MOVE	D7,D0
	BNE.S	L221
	MOVE.B	#48,-(A3)
	BRA.S	L222
L221:
	BRA.S	L223
L224:
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,D7
	MULU	#10,D0
	MOVE	D0,-10(A6)
	MOVE	#48,D0
	ADD	D5,D0
	SUB	-10(A6),D0
	MOVE.B	D0,-(A3)
L223:
	MOVE	D7,D5
	BNE.S	L224
L225:
L222:
	MOVE	D6,D0
	BEQ.S	L226
	MOVE	#4,D0
	SUB	12(A6),D0
	LEA	11G419_ac_(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	BRA.S	L219
L226:
	MOVE.L	A3,D0
L219:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$218:	.EQU	#-10
F289_xxxx_:/* global */
	LINK	A6,L$227
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	10(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#55,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+96(A4)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#73,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#79,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
L228:
	UNLK	A6
	RTS
L$227:	.EQU	#0
F290_xxxx_:/* global */
	LINK	A6,L$229
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE	54(A3),-(A7)
	MOVE	52(A3),-(A7)
	MOVE	#116,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	58(A3),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-(A7)
	MOVE	56(A3),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-(A7)
	MOVE	#124,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	62(A3),-(A7)
	MOVE	60(A3),-(A7)
	MOVE	#132,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
L230:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$229:	.EQU	#0
F291_xxxx_:/* global */
	LINK	A6,L$231
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	10(A6),D7
	MOVE	#-1,-20(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G423_i_Inv(A4),D5
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	D5,D0
	BNE.S	L233
	CMPI	#1,D7
	BHI.S	L235
	MOVE	G299_ui_Ca(A4),D0
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L234
L235:
	BRA	L232(PC)
L234:
	MOVE	8(A6),D0
	ASL	#1,D0
	ADD	D7,D0
	MOVE	D0,-2(A6)
	BRA.S	L236
L233:
	MOVE	#8,D0
	ADD	D7,D0
	MOVE	D0,-2(A6)
L236:
	CMPI	#30,D7
	BCS.S	L237
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	BRA.S	L238
L237:
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	212(A3),A0
	ADDA	D6,A0
	MOVE	(A0),D6
L238:
	MOVE	-2(A6),D0
	MULS	#6,D0
	LEA	G030_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	(A2),D0
	SUBQ	#1,D0
	MOVE	D0,-18(A6)
	ADD	#17,D0
	MOVE	D0,-16(A6)
	MOVE	2(A2),D0
	SUBQ	#1,D0
	MOVE	D0,-14(A6)
	ADD	#17,D0
	MOVE	D0,-12(A6)
	MOVE	D5,D0
	BEQ.S	L239
	MOVE.L	G296_puc_B(A4),-24(A6)
	MOVE	#112,-26(A6)
	BRA.S	L240
L239:
	MOVE.L	G348_pl_Bi(A4),D0
	MOVE.L	D0,-24(A6)
	MOVE	#160,-26(A6)
	JSR	F077_aA39_(PC)
L240:
	CMPI	#-1,D6
	BNE.S	L241
	CMPI	#5,D7
	BHI.S	L242
	MOVE	#212,D4
	MOVE	D7,D1
	ASL	#1,D1
	ADD	D1,D4
	MOVE	50(A3),D0
	MOVE	#1,D1
	ASL	D7,D1
	AND	D1,D0
	BEQ.S	L243
	ADDQ	#1,D4
	MOVE	#34,-20(A6)
	BRA.S	L244
L243:
	MOVE	#33,-20(A6)
L244:
	BRA.S	L245
L242:
	CMPI	#10,D7
	BCS.S	L246
	CMPI	#13,D7
	BHI.S	L246
	MOVE	#208,D4
	MOVE	D7,D1
	SUB	#10,D1
	ADD	D1,D4
	BRA.S	L247
L246:
	MOVE	#204,D4
L247:
L245:
	BRA.S	L248
L241:
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	MOVE	D5,D0
	BEQ.S	L249
	CMPI	#1,D7
	BNE.S	L249
	CMPI	#144,D4
	BEQ.S	L250
	CMPI	#30,D4
	BNE.S	L249
L250:
	ADDQ	#1,D4
L249:
	CMPI	#5,D7
	BHI.S	L251
	MOVE	50(A3),D0
	MOVE	#1,D1
	ASL	D7,D1
	AND	D1,D0
	BEQ.S	L252
	MOVE	#34,-20(A6)
	BRA.S	L253
L252:
	MOVE	#33,-20(A6)
L253:
L251:
L248:
	CMPI	#1,D7
	BNE.S	L254
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G506_i_Act(A4),D0
	BNE.S	L254
	MOVE	#35,-20(A6)
L254:
	CMPI	#-1,-20(A6)
	BEQ.S	L255
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#12,-(A7)
	MOVE	-26(A6),-(A7)
	MOVE	#16,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	-18(A6)
	MOVE.L	-24(A6),-(A7)
	MOVE	-20(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L255:
	MOVE	D4,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	D5,D0
	BNE.S	L256
	JSR	F078_xzzz_(PC)
L256:
L232:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$231:	.EQU	#-26
F292_arzz_:/* global */
	LINK	A6,L$257
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULU	#69,D0
	MOVE	D0,-4(A6)
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	48(A3),D6
	MOVE	D6,D0
	AND	#-128,D0
	BNE.S	L259
	BRA	L258(PC)
L259:
	MOVE	D7,D5
	ADDQ	#1,D5
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	CLR	G578_B_Use(A4)
	JSR	F077_aA39_(PC)
	MOVE	D6,D0
	AND	#4096,D0
	BEQ	L260(PC)
	CLR	-12(A6)
	MOVE	#28,-10(A6)
	MOVE	-4(A6),D0
	MOVE	D0,-16(A6)
	ADD	#66,D0
	MOVE	D0,-14(A6)
	MOVE	52(A3),D0
	BEQ	L261(PC)
	MOVE	#160,-(A7)
	MOVE	#12,-(A7)
	PEA	-16(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#6,-(A7)
	PEA	-22(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	D4
	CMPI	#0,G407_s_Par+3206(A4)
	BLE.S	L262
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#38,(A0)
L262:
	CMPI	#0,G407_s_Par+3208(A4)
	BLE.S	L263
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#39,(A0)
L263:
	CMPI	#0,G407_s_Par+3204(A4)
	BGT.S	L265
	MOVE	274(A3),D0
	BEQ.S	L264
L265:
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#37,(A0)
L264:
	BRA.S	L266
L267:
	MOVE	#10,-(A7)
	MOVE	#40,-(A7)
	PEA	-16(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
L266:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L267
L268:
	MOVE	D5,D0
	BEQ.S	L269
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	OR	#256,D6
	BRA.S	L270
L269:
	OR	#-24192,D6
L270:
	BRA.S	L271
L261:
	MOVE	#-1,-(A7)
	MOVE	#40,-(A7)
	PEA	-16(A6)
	MOVE	#8,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#1,-(A7)
	MOVE	#13,-(A7)
	MOVE	#5,-(A7)
	MOVE	-4(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	D7,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
	BRA	L15T292_042(PC)
L271:
L260:
	MOVE	52(A3),D0
	BNE.S	L272
	BRA	L15T292_042(PC)
L272:
	MOVE	D6,D0
	AND	#128,D0
	BEQ	L273(PC)
	MOVE	D7,D4
	MOVE	G411_i_Lea(A4),D1
	CMP	D1,D4
	BNE.S	L274
	MOVE	#9,D4
	BRA.S	L275
L274:
	MOVE	#13,D4
L275:
	MOVE	D5,D0
	BEQ	L276(PC)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	#3,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-32(A6)
	MOVE	#6,D0
	MULS	-32(A6),D0
	ADDQ	#3,D0
	MOVE	D0,-6(A6)
	MOVE.B	8(A3),-1(A6)
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#44,D0
	BEQ.S	L277
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#59,D0
	BEQ.S	L277
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#45,D0
	BEQ.S	L277
	ADDQ	#6,-6(A6)
L277:
	LEA	8(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	OR	#16384,D6
	BRA.S	L278
L276:
	CLR	-12(A6)
	MOVE	#6,-10(A6)
	MOVE	-4(A6),D0
	MOVE	D0,-16(A6)
	ADD	#42,D0
	MOVE	D0,-14(A6)
	MOVE	#160,-(A7)
	MOVE	#1,-(A7)
	PEA	-16(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	MOVE	#5,-(A7)
	MOVE	-4(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L278:
L273:
	MOVE	D6,D0
	AND	#256,D0
	BEQ	L279(PC)
	MOVE	D7,-(A7)
	JSR	F287_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
	BEQ	L280(PC)
	MOVE.L	A3,-(A7)
	JSR	F290_xxxx_(PC)
	ADDQ.L	#4,A7
	CMPI	#0,66(A3)
	BLT.S	L282
	CMPI	#0,68(A3)
	BLT.S	L282
	MOVE.B	42(A3),D0
	BEQ.S	L281
L282:
	MOVE	#34,-8(A6)
	BRA.S	L283
L281:
	MOVE	#33,-8(A6)
L283:
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G048_s_Gra(A4)
	MOVE	-8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#33,-8(A6)
	MOVE	#1,D4
	BRA.S	L284
L285:
	MOVE	D4,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D4,D1
	MULS	#3,D1
	LEA	70(A3),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGE.S	L288
	MOVE	#34,-8(A6)
	BRA.S	L287
L288:
L286:
	ADDQ	#1,D4
L284:
	CMPI	#6,D4
	BLE.S	L285
L287:
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G049_s_Gra(A4)
	MOVE	-8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	OR	#16384,D6
L280:
L279:
	MOVE	D6,D0
	AND	#8192,D0
	BEQ.S	L289
	MOVE	D5,D4
	BEQ.S	L294
	MOVE	#5,D4
	BRA.S	L295
L294:
	MOVE	#1,D4
L295:
	BRA.S	L290
L291:
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
L292:
	SUBQ	#1,D4
L290:
	CMPI	#0,D4
	BGE.S	L291
L293:
	MOVE	D5,D0
	BEQ.S	L296
	OR	#16384,D6
L296:
L289:
	MOVE	D6,D0
	AND	#512,D0
	BEQ	L297(PC)
	MOVE	D5,D0
	BEQ	L297(PC)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	MOVE	D0,-42(A6)
	MOVE	272(A3),D0
	CMP	-42(A6),D0
	BLS.S	L298
	MOVE	#8,-8(A6)
	BRA.S	L299
L298:
	MOVE	272(A3),D0
	AND.L	#65535,D0
	ASL.L	#3,D0
	MOVE	D4,D1
	EXT.L	D1
	MOVE.L	D1,-(A7)
	MOVE.L	#5,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	CMP.L	D1,D0
	BLE.S	L300
	MOVE	#11,-8(A6)
	BRA.S	L301
L300:
	MOVE	#13,-8(A6)
L301:
L299:
DATA SEG "s!"
	DATA 4C 41 53 54 20 00 
CODE SEG "player"
	PEA	s!+98(A4)
	MOVE	-8(A6),-(A7)
	MOVE	#132,-(A7)
	MOVE	#104,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	272(A3),D4
	AND.L	#65535,D4
	DIVU	#10,D4
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2C 00 
CODE SEG "player"
	PEA	s!+104(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	272(A3),D0
	MOVE	D4,D1
	MULS	#10,D1
	SUB	D1,D0
	MOVE	D0,D4
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+106(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	ADDQ	#5,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,D4
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 4B 47 00 
CODE SEG "player"
	PEA	s!+108(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	-8(A6),-(A7)
	MOVE	#132,-(A7)
	MOVE	#148,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	OR	#16384,D6
L297:
	MOVE.B	29(A3),D4
	AND	#255,D4
	ADDQ	#4,D4
	SUB	G308_i_Par(A4),D4
	AND	#3,D4
	MOVE	D6,D0
	AND	#1024,D0
	BEQ	L302(PC)
	MOVE	G599_ui_Us(A4),D0
	MOVE	D4,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BEQ	L302(PC)
	MOVE	#160,-(A7)
	MOVE	D7,D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#160,-(A7)
	MOVE	#40,-(A7)
	CLR	-(A7)
	MOVE.B	28(A3),D0
	AND	#255,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	MULS	#19,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE	#28,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L302:
	MOVE	D6,D0
	AND	#2048,D0
	BEQ.S	L303
	MOVE	D5,D0
	BEQ.S	L303
	MOVE	G333_B_Pre(A4),D0
	BEQ.S	L304
	JSR	F345_xxxx_(PC)
	BRA.S	L305
L304:
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L306
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L307
	JSR	F351_xxxx_(PC)
L307:
	BRA.S	L308
L306:
	JSR	F347_xxxx_(PC)
L308:
L305:
	OR	#16384,D6
L303:
	MOVE	D6,D0
	AND	#-32768,D0
	BEQ.S	L309
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
	BEQ.S	L310
	OR	#16384,D6
L310:
L309:
	MOVE	D6,D0
	AND	#16384,D0
	BEQ.S	L311
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
L311:
L15T292_042:
	ANDI	#127,48(A3)
	JSR	F078_xzzz_(PC)
L258:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$257:	.EQU	#-42
F293_ahzz_:/* global */
	LINK	A6,L$312
	MOVE	D7,-(A7)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D7
	BRA.S	L314
L315:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L316:
	ADDQ	#1,D7
L314:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L315
L317:
L313:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$312:	.EQU	#0
F294_aozz_:/* global */
	LINK	A6,L$318
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	10(A6),D7
	ASL.L	#1,D7
	LEA	212(A3),A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BEQ.S	L320
	MOVE	#0,D0
	BRA	L319(PC)
L320:
	MOVE	D7,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#16,D0
	BLT.S	L321
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#31,D0
	BGT.S	L321
	MOVE	#10,D6
	BRA.S	L322
L321:
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#32,D0
	BLT.S	L323
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#47,D0
	BGT.S	L323
	MOVE	#11,D6
	BRA.S	L324
L323:
	MOVE	#0,D0
	BRA.S	L319
L324:
L322:
	MOVE	12(A6),D7
	ASL.L	#1,D7
	LEA	212(A3),A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D7,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L325
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	D6,D0
	SEQ	D0
	TST.B	D0
L325:
	AND	#1,D0
L319:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$318:	.EQU	#0
F295_xxxx_:/* global */
	LINK	A6,L$326
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,-(A7)
	JSR	F039_aaaL_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#32,D6
	BGE.S	L330
	CMPI	#0,D6
	BGE.S	L329
L330:
	CMPI	#148,D6
	BLT.S	L331
	CMPI	#163,D6
	BLE.S	L329
L331:
	CMPI	#195,D6
	BNE.S	L328
L329:
	MOVE	10(A6),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	D5,D0
	CMP	D6,D0
	BEQ.S	L332
	CMPI	#8,D7
	BGE.S	L333
	MOVE	G420_B_Mou(A4),D0
	BNE.S	L333
	MOVE	#1,G420_B_Mou(A4)
	JSR	F077_aA39_(PC)
L333:
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
	BRA.S	L327
L332:
L328:
	MOVE	#0,D0
L327:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$326:	.EQU	#0
F296_aizz_:/* global */
	LINK	A6,L$334
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G423_i_Inv(A4),D6
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L336
	MOVE	D6,D0
	BNE.S	L336
	BRA	L335(PC)
L336:
	CLR	G420_B_Mou(A4)
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#32,D0
	BGE.S	L339
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L338
L339:
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#148,D0
	BLT.S	L340
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#163,D0
	BLE.S	L338
L340:
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#195,D0
	BNE.S	L337
L338:
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	-2(A6),D0
	CMP	D5,D0
	BEQ.S	L341
	MOVE	#1,G420_B_Mou(A4)
	JSR	F077_aA39_(PC)
	MOVE.L	G412_puc_B(A4),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE.L	G412_puc_B(A4),-(A7)
	JSR	F068_aagz_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),G413_i_Lea(A4)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L341:
L337:
	CLR	D7
	BRA.S	L342
L343:
	MOVE	D7,D4
	LSR	#1,D4
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L346
	BRA.S	L344
L346:
	MOVE	D7,D0
	AND	#1,D0
	MOVE	D4,D1
	MULS	#800,D1
	LEA	G407_s_Par+212(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D0
	LEA	(A0),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L347
	MOVE	D7,D0
	AND	#1,D0
	CMPI	#1,D0
	BNE.S	L347
	MOVE	D4,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L347:
L344:
	ADDQ	#1,D7
L342:
	MOVE	D7,D0
	MOVE	G305_ui_Pa(A4),D1
	ASL	#1,D1
	CMP	D1,D0
	BCS.S	L343
L345:
	MOVE	D6,D0
	BEQ	L348(PC)
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	#0,D0
	MOVE	D0,D7
	ASL.L	#1,D0
	LEA	212(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	D5
	BRA.S	L349
L350:
	MOVE	(A3),-(A7)
	MOVE	D7,D0
	ADDQ	#8,D0
	MOVE	D0,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	OR	D0,D5
	MOVE	-4(A6),D0
	BEQ.S	L353
	CMPI	#1,D7
	BNE.S	L353
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L353:
L351:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#2,A3
L349:
	CMPI	#30,D7
	BCS.S	L350
L352:
	CMPI	#4,G424_i_Pan(A4)
	BNE.S	L354
	LEA	G425_aT_Ch(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L355
L356:
	MOVE	(A3),-(A7)
	MOVE	D7,D0
	ADD	#38,D0
	MOVE	D0,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	OR	D0,D5
L357:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#2,A3
L355:
	CMPI	#8,D7
	BCS.S	L356
L358:
L354:
	MOVE	D5,D0
	BEQ.S	L359
	ORI	#16384,48(A2)
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L359:
L348:
	MOVE	G420_B_Mou(A4),D0
	BEQ.S	L360
	JSR	F078_xzzz_(PC)
L360:
L335:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$334:	.EQU	#-4
F297_atzz_:/* global */
	LINK	A6,L$361
	CMPI	#-1,8(A6)
	BNE.S	L363
	BRA	L362(PC)
L363:
	CLR	G415_B_Lea(A4)
	MOVE.L	G412_puc_B(A4),-(A7)
	MOVE	8(A6),D0
	MOVE	D0,G414_T_Lea(A4)
	MOVE	D0,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,G413_i_Lea(A4)
	MOVE	D0,-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	JSR	F077_aA39_(PC)
	MOVE	8(A6),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
	MOVE	10(A6),D0
	BEQ.S	L364
	MOVE	#1,G325_B_Set(A4)
	BRA.S	L365
L364:
	MOVE.L	G412_puc_B(A4),-(A7)
	JSR	F068_aagz_(PC)
	ADDQ.L	#4,A7
L365:
	JSR	F078_xzzz_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L366
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L366:
L362:
	UNLK	A6
	RTS
L$361:	.EQU	#0
F298_aqzz_:/* global */
	LINK	A6,L$367
	MOVE	D7,-(A7)
	MOVE	#1,G415_B_Lea(A4)
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L369
	MOVE	#-1,G414_T_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	JSR	F077_aA39_(PC)
	JSR	F035_aaaw_(PC)
	JSR	F069_aaaL_(PC)
	JSR	F078_xzzz_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L370
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L370:
L369:
	MOVE	D7,D0
L368:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$367:	.EQU	#0
F299_xxxx_:/* global */
	LINK	A6,L$371
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CLR	D4
	MOVE	18(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D5
	CMPI	#5,D0
	BEQ.S	L374
	CMPI	#6,D5
	BNE.S	L373
L374:
	CMPI	#0,D7
	BCS.S	L373
	CMPI	#12,D7
	BHI.S	L373
	MOVE	18(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#5,D5
	BNE.S	L377
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#256,D0
	LSR	#8,D0
	BNE.S	L376
L377:
	CMPI	#6,D5
	BNE.S	L375
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#256,D0
	LSR	#8,D0
	BEQ.S	L375
L376:
	CLR	D5
	MOVE	#-3,D4
	BRA	L22T299_044(PC)
L375:
L373:
	CMPI	#137,D6
	BNE.S	L378
	CLR	D5
	MOVE	#10,D4
	BRA	L379(PC)
L378:
	CMPI	#1,D7
	BNE	L380(PC)
	CMPI	#45,D6
	BNE.S	L381
	MOVE	#1,D5
	MOVE	#5,D4
	BRA	L382(PC)
L381:
	MOVE	#8,D5
	CMPI	#20,D6
	BCS.S	L383
	CMPI	#22,D6
	BHI.S	L383
	MOVE	#4,D4
	BRA	L384(PC)
L383:
	CMPI	#58,D6
	BCS	L385(PC)
	CMPI	#66,D6
	BHI	L385(PC)
	MOVE	D6,D0
L386:
	CMP	#58,D0
	BEQ.S	L387
	BRA.S	L389
L387:
	MOVE	#2,D4
	BRA	L388(PC)
	BRA.S	L390
L389:
	CMP	#59,D0
	BEQ.S	L390
	BRA.S	L391
L390:
	MOVE	#1,D4
	BRA.S	L388
	BRA.S	L392
L391:
	CMP	#60,D0
	BEQ.S	L392
	BRA.S	L393
L392:
	MOVE	#6,D4
	BRA.S	L388
	BRA.S	L394
L393:
	CMP	#61,D0
	BEQ.S	L394
	BRA.S	L395
L394:
	MOVE	#4,D4
	BRA.S	L388
	BRA.S	L396
L395:
	CMP	#62,D0
	BEQ.S	L396
	BRA.S	L397
L396:
	MOVE	#10,D4
	BRA.S	L388
	BRA.S	L398
L397:
	CMP	#63,D0
	BEQ.S	L398
	BRA.S	L399
L398:
	MOVE	#8,D4
	BRA.S	L388
	BRA.S	L400
L399:
	CMP	#64,D0
	BEQ.S	L400
	BRA.S	L401
L400:
	MOVE	#16,D4
	BRA.S	L388
	BRA.S	L402
L401:
	CMP	#65,D0
	BEQ.S	L402
	BRA.S	L403
L402:
	MOVE	#7,D4
	BRA.S	L388
	BRA.S	L404
L403:
	CMP	#66,D0
	BEQ.S	L404
	BRA.S	L405
L404:
	MOVE	#5,D4
L405:
L406:
L388:
	BRA.S	L407
L385:
	MOVE	D6,D0
L408:
	CMP	#38,D0
	BEQ.S	L409
	BRA.S	L411
L409:
	MOVE	#1,D4
	BRA.S	L410
	BRA.S	L412
L411:
	CMP	#41,D0
	BEQ.S	L412
	BRA.S	L413
L412:
	MOVE	#2,D4
	BRA.S	L410
	BRA.S	L414
L413:
	CMP	#40,D0
	BEQ.S	L414
	BRA.S	L415
L414:
	MOVE	#4,D4
L415:
L416:
L410:
L407:
L384:
L382:
	BRA	L417(PC)
L380:
	CMPI	#4,D7
	BNE.S	L418
	CMPI	#142,D6
	BNE.S	L419
	MOVE	#1,D5
	MOVE	#10,D4
L419:
	BRA	L420(PC)
L418:
	CMPI	#2,D7
	BNE.S	L421
	CMPI	#104,D6
	BNE.S	L422
	MOVE	#3,D5
	MOVE	#10,D4
	BRA.S	L423
L422:
	CMPI	#140,D6
	BNE.S	L424
	MOVE	#2,D5
	MOVE	#10,D4
L424:
L423:
	BRA.S	L425
L421:
	CMPI	#3,D7
	BNE.S	L426
	CMPI	#141,D6
	BNE.S	L427
	MOVE	#6,D5
	MOVE	#12,D4
	BRA.S	L428
L427:
	CMPI	#81,D6
	BNE.S	L429
	MOVE	#2,D5
	MOVE	#8,D4
L429:
L428:
	BRA.S	L430
L426:
	CMPI	#10,D7
	BNE.S	L431
	CMPI	#10,D6
	BCS.S	L432
	CMPI	#11,D6
	BHI.S	L432
	MOVE	#5,D5
	MOVE	#15,D4
	BRA.S	L433
L432:
	CMPI	#81,D6
	BNE.S	L434
	MOVE	#2,D5
	MOVE	#8,D4
	BRA.S	L435
L434:
	CMPI	#122,D6
	BNE.S	L436
	MOVE	#8,D5
	MOVE	#3,D4
L436:
L435:
L433:
L431:
L430:
L425:
L420:
L417:
L379:
L22T299_044:
	MOVE	D4,D0
	BEQ.S	L437
	MOVE	D4,D0
	MULS	16(A6),D0
	MOVE	D0,D4
	CMPI	#8,D5
	BNE.S	L438
	MOVE	D4,D0
	ADD	D0,62(A3)
	BRA.S	L439
L438:
	CMPI	#7,D5
	BGE.S	L440
	CLR	D7
	BRA.S	L441
L442:
	MOVE	D5,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADD.L	A0,D0
	MOVE.L	D0,-14(A6)
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	-14(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D4,D0
	MOVE.B	D0,(A0)
L441:
	CMPI	#2,D7
	BLS.S	L442
L443:
L440:
L439:
	ORI	#2304,48(A3)
L437:
L372:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$371:	.EQU	#-14
F300_aozz_:/* global */
	LINK	A6,L$444
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	10(A6),D7
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#30,D7
	BCS.S	L446
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L447
L446:
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	212(A3),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L447:
	CMPI	#-1,D6
	BNE.S	L448
	MOVE	#-1,D0
	BRA	L445(PC)
L448:
	MOVE	8(A6),D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	D6,-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F299_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#10,D7
	BNE.S	L449
	CMPI	#12,D5
	BLT.S	L450
	CMPI	#13,D5
	BGT.S	L450
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	MOVE	G039_ai_Gr+4(A4),D0
	SUB	D0,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	BRA.S	L451
L450:
	CMPI	#10,D5
	BLT.S	L452
	CMPI	#11,D5
	BGT.S	L452
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
L452:
L451:
L449:
	MOVE	D7,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),D0
	BEQ.S	L453
	ORI	#16384,48(A3)
L453:
	CMPI	#2,D7
	BCC	L454(PC)
	CMPI	#1,D7
	BNE.S	L455
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L456
	JSR	F388_rzzz_(PC)
L456:
	CMPI	#30,D5
	BLT.S	L457
	CMPI	#31,D5
	BGT.S	L457
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,2(A0)
	OR	D3,2(A0)
	JSR	F296_aizz_(PC)
L457:
L455:
	CMPI	#4,D5
	BLT.S	L458
	CMPI	#7,D5
	BGT.S	L458
	MOVE	#0,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ASL	#8,D3
	ANDI	#32767,2(A2)
	OR	D3,2(A2)
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
L458:
	MOVE	-2(A6),D0
	BEQ.S	L459
	CMPI	#1,D7
	BNE.S	L459
	CMPI	#144,D5
	BNE.S	L460
	JSR	F334_akzz_(PC)
	ORI	#2048,48(A3)
	BRA.S	L461
L460:
	CMPI	#30,D5
	BLT.S	L462
	CMPI	#31,D5
	BGT.S	L462
	ORI	#2048,48(A3)
L462:
L461:
L459:
L454:
	MOVE	D6,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	SUB	D0,272(A3)
	ORI	#512,48(A3)
	MOVE	D6,D0
L445:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$444:	.EQU	#-2
F301_apzz_:/* global */
	LINK	A6,L$463
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	CMPI	#-1,D6
	BNE.S	L465
	BRA	L464(PC)
L465:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#30,D5
	BCS.S	L466
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	BRA.S	L467
L466:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L467:
	MOVE	D6,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	ADD	D0,272(A3)
	ORI	#512,48(A3)
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE	D6,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F299_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#2,D5
	BCC	L468(PC)
	CMPI	#1,D5
	BNE.S	L469
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	MOVE	D7,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L470
	JSR	F388_rzzz_(PC)
L470:
	CMPI	#30,D4
	BLT.S	L471
	CMPI	#31,D4
	BGT.S	L471
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,2(A0)
	OR	D3,2(A0)
	JSR	F296_aizz_(PC)
L471:
L469:
	CMPI	#4,D4
	BNE.S	L472
	MOVE	#1,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ASL	#8,D3
	ANDI	#32767,2(A2)
	OR	D3,2(A2)
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
	BRA.S	L473
L472:
	MOVE	-2(A6),D0
	BEQ.S	L474
	CMPI	#1,D5
	BNE.S	L474
	CMPI	#144,D4
	BEQ.S	L475
	CMPI	#30,D4
	BLT.S	L474
	CMPI	#31,D4
	BGT.S	L474
L475:
	ORI	#2048,48(A3)
L474:
L473:
	BRA.S	L476
L468:
	CMPI	#10,D5
	BNE.S	L477
	CMPI	#12,D4
	BLT.S	L478
	CMPI	#13,D4
	BGT.S	L478
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	MOVE	G039_ai_Gr+4(A4),D0
	ADD	D0,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	ADDQ	#1,D4
	BRA.S	L479
L478:
	CMPI	#10,D4
	BLT.S	L480
	CMPI	#11,D4
	BGT.S	L480
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	ADDQ	#1,D4
L480:
L479:
L477:
L476:
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),D0
	BEQ.S	L481
	ORI	#16384,48(A3)
L481:
L464:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$463:	.EQU	#-2
F302_mzzz_:/* global */
	LINK	A6,L$482
	MOVEM.L	D7-D4,-(A7)
	CMPI	#8,8(A6)
	BCC.S	L484
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L485
	BRA	L483(PC)
L485:
	MOVE	8(A6),D7
	LSR	#1,D7
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L487
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BEQ.S	L487
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L486
L487:
	BRA	L483(PC)
L486:
	MOVE	8(A6),D6
	AND	#1,D6
	BRA.S	L488
L484:
	MOVE	G423_i_Inv(A4),D7
	SUBQ	#1,D7
	MOVE	8(A6),D6
	SUBQ	#8,D6
L488:
	MOVE	G414_T_Lea(A4),D5
	CMPI	#30,D6
	BCS.S	L489
	MOVE	D6,D4
	ASL.L	#1,D4
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	BRA.S	L490
L489:
	MOVE	D6,D4
	MOVE	D7,D1
	MULS	#800,D1
	LEA	G407_s_Par+212(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D4
	LEA	(A0),A0
	ADDA	D4,A0
	MOVE	(A0),D4
L490:
	CMPI	#-1,D4
	BNE.S	L491
	CMPI	#-1,D5
	BNE.S	L491
	BRA.S	L483
L491:
	CMPI	#-1,D5
	BEQ.S	L492
	MOVE	D5,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G038_ai_Gr(A4),A0
	ADDA	D1,A0
	AND	(A0),D0
	BNE.S	L492
	BRA.S	L483
L492:
	JSR	F077_aA39_(PC)
	CMPI	#-1,D5
	BEQ.S	L493
	JSR	F298_aqzz_(PC)
L493:
	CMPI	#-1,D4
	BEQ.S	L494
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L494:
	CMPI	#-1,D5
	BEQ.S	L495
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
L495:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L483:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$482:	.EQU	#0
F303_AA09_:/* global */
	LINK	A6,L$496
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L498
	MOVE	#1,D0
	BRA	L497(PC)
L498:
	MOVE	10(A6),D0
	AND	#-32768,D0
	MOVE	D0,-2(A6)
	MOVE	10(A6),D0
	AND	#16384,D0
	MOVE	D0,-4(A6)
	ANDI	#16383,10(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	10(A6),D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	2(A3),D7
	MOVE	-2(A6),D0
	BNE.S	L499
	MOVE	(A3),D0
	EXT.L	D0
	ADD.L	D0,D7
L499:
	CMPI	#3,10(A6)
	BLS.S	L500
	MOVE	10(A6),D0
	SUBQ	#4,D0
	LSR	#2,D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	ADD.L	2(A3),D7
	MOVE	-2(A6),D0
	BNE.S	L501
	MOVE	(A3),D0
	EXT.L	D0
	ADD.L	D0,D7
L501:
	MOVE.L	D7,D0
	ASR.L	#1,D0
	MOVE.L	D0,D7
L500:
	MOVE	#1,D6
	BRA.S	L502
L503:
	MOVE.L	D7,D0
	ASR.L	#1,D0
	MOVE.L	D0,D7
	ADDQ	#1,D6
L502:
	CMPI.L	#500,D7
	BGE.S	L503
L504:
	MOVE	-4(A6),D0
	BNE	L505(PC)
	MOVE	214(A2),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#27,D0
	BNE.S	L506
	ADDQ	#1,D6
	BRA.S	L507
L506:
	CMPI	#28,D4
	BNE.S	L508
	ADDQ	#2,D6
L508:
L507:
	MOVE	232(A2),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	10(A6),D0
L509:
	CMP	#3,D0
	BEQ.S	L510
	BRA.S	L512
L510:
	CMPI	#124,D5
	BNE.S	L514
	ADDQ	#1,D6
L514:
	BRA.S	L511
	BRA.S	L513
L512:
	CMP	#15,D0
	BEQ.S	L513
	BRA.S	L515
L513:
	CMPI	#121,D5
	BNE.S	L517
	ADDQ	#1,D6
L517:
	BRA.S	L511
	BRA.S	L516
L515:
	CMP	#13,D0
	BEQ.S	L516
	BRA.S	L518
L516:
	CMPI	#120,D5
	BEQ.S	L521
	CMPI	#66,D4
	BNE.S	L520
L521:
	ADDQ	#1,D6
L520:
	BRA.S	L511
	BRA.S	L519
L518:
	CMP	#14,D0
	BEQ.S	L519
	BRA.S	L522
L519:
	CMPI	#122,D5
	BNE.S	L524
	ADDQ	#1,D6
L524:
L522:
L523:
L511:
L505:
	MOVE	D6,D0
L497:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$496:	.EQU	#-4
F304_apzz_:/* global */
	LINK	A6,L$525
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	12(A6),D7
	CMPI	#4,10(A6)
	BCS.S	L527
	CMPI	#11,10(A6)
	BHI.S	L527
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#150,D1
	CMP.L	D1,D0
	BGE.S	L527
	MOVE	D7,D0
	LSR	#1,D0
	MOVE	D0,D7
L527:
	MOVE	D7,D0
	BEQ	L528(PC)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D6
	AND	#-4096,D6
	LSR	#4,D6
	LSR	#8,D6
	BEQ.S	L529
	MOVE	D7,D0
	MULU	D6,D0
	MOVE	D0,D7
L529:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#4,10(A6)
	BCS.S	L530
	MOVE	10(A6),D5
	SUBQ	#4,D5
	LSR	#2,D5
	BRA.S	L531
L530:
	MOVE	10(A6),D5
L531:
	MOVE.L	2(A3),D4
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	CMPI	#4,10(A6)
	BCS.S	L532
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#25,D1
	CMP.L	D1,D0
	BLE.S	L532
	MOVE	D7,D0
	ASL	#1,D0
	MOVE	D0,D7
L532:
	MOVE	10(A6),D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D7,D0
	AND.L	#65535,D0
	ADD.L	D0,2(A3)
	CMPI	#32000,(A3)
	BGE.S	L533
	MOVE	#100,-(A7)
	MOVE	D7,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	ADD	D0,(A3)
L533:
	MOVE	D5,D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#4,10(A6)
	BCS.S	L534
	MOVE	D7,D0
	AND.L	#65535,D0
	ADD.L	D0,2(A3)
L534:
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	D7,D0
	CMP	D6,D0
	BLS	L535(PC)
	MOVE	D7,-6(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,-2(A6)
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	MOVE	#1,D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,D6
	CMPI	#2,D5
	BEQ.S	L536
	AND	D7,D6
L536:
	MOVE	D6,D0
	ADD.B	D0,82(A2)
	MOVE	58(A2),D6
	JSR	F028_a000_(PC)
	MOVE	D7,D1
	NOT	D1
	AND	D1,D0
	ADD.B	D0,88(A2)
	MOVE	D5,D0
L537:
	CMP	#0,D0
	BEQ.S	L538
	BRA.S	L540
L538:
	MOVE	D6,D0
	LSR	#4,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MULU	#3,D0
	MOVE	D0,D7
	MOVE	-4(A6),D0
	ADD.B	D0,73(A2)
	MOVE	-2(A6),D0
	ADD.B	D0,76(A2)
	BRA	L539(PC)
	BRA.S	L541
L540:
	CMP	#1,D0
	BEQ.S	L541
	BRA.S	L542
L541:
	MOVE	D6,D0
	AND.L	#65535,D0
	DIVU	#21,D0
	MOVE	D0,D6
	MOVE	D7,D0
	ASL	#1,D0
	MOVE	D0,D7
	MOVE	-2(A6),D0
	ADD.B	D0,73(A2)
	MOVE	-4(A6),D0
	ADD.B	D0,76(A2)
	BRA	L539(PC)
	BRA.S	L543
L542:
	CMP	#3,D0
	BEQ.S	L543
	BRA.S	L544
L543:
	MOVE	D6,D0
	LSR	#5,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MOVE	D7,D1
	LSR	#1,D1
	ADD	D1,D0
	ADD	D0,62(A2)
	MOVE	-4(A6),D0
	ADD.B	D0,79(A2)
	BRA.S	L27T304_016
	BRA.S	L545
L544:
	CMP	#2,D0
	BEQ.S	L545
	BRA.S	L546
L545:
	MOVE	D6,D0
	AND.L	#65535,D0
	DIVU	#25,D0
	MOVE	D0,D6
	MOVE	D7,D0
	ADD	D0,62(A2)
	MOVE	D7,D0
	ADDQ	#1,D0
	LSR	#1,D0
	ADD	D0,D7
	MOVE	-2(A6),D0
	ADD.B	D0,79(A2)
L27T304_016:
	MOVE	-6(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	62(A2),D0
	ADD	D1,D0
	MOVE	D0,62(A2)
	CMPI	#900,D0
	BLE.S	L548
	MOVE	#900,62(A2)
L548:
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	ADD.B	D0,85(A2)
L546:
L547:
L539:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE	D7,D0
	LSR	#1,D0
	ADDQ	#1,D0
	AND.L	#65535,D1
	DIVU	D0,D1
	SWAP	D1
	MOVE	D1,-16(A6)
	MOVE	D7,D1
	ADD	-16(A6),D1
	MOVE	54(A2),D0
	ADD	D1,D0
	MOVE	D0,54(A2)
	CMP	#999,D0
	BLE.S	L549
	MOVE	#999,54(A2)
L549:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE	D6,D0
	LSR	#1,D0
	ADDQ	#1,D0
	AND.L	#65535,D1
	DIVU	D0,D1
	SWAP	D1
	MOVE	D1,-26(A6)
	MOVE	D6,D1
	ADD	-26(A6),D1
	MOVE	58(A2),D0
	ADD	D1,D0
	MOVE	D0,58(A2)
	CMP	#9999,D0
	BLE.S	L550
	MOVE	#9999,58(A2)
L550:
	ORI	#256,48(A2)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F051_AA19_(PC)
	LEA	(A2),A0
	MOVE.L	A0,-(A7)
	MOVE	8(A6),D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 48 41 54 20 53 4F 45 42 45 4E 20 00 00 
CODE SEG "player"
	PEA	s!+112(A4)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 53 54 55 46 45 20 45 52 52 45 49 43 48 54 21 00 00 
CODE SEG "player"
	PEA	s!+126(A4)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L535:
L528:
L526:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$525:	.EQU	#-26
F305_xxxx_:/* global */
	LINK	A6,L$551
	MOVEM.L	D7-D6,-(A7)
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	LSR	#1,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	BRA.S	L553
L554:
	MOVE	D7,D0
	ASR	#1,D0
	ADD	D0,D6
L553:
	MOVE	D7,D0
	SUB	#10,D0
	MOVE	D0,D7
	CMPI	#0,D0
	BGT.S	L554
L555:
	MOVE	D6,D0
L552:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$551:	.EQU	#0
F306_xxxx_:/* global */
	LINK	A6,L$556
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	56(A3),D0
	MOVE	D0,D7
	MOVE	58(A3),D1
	ASR	#1,D1
	MOVE	D1,D6
	CMP	D1,D0
	BGE.S	L558
	MOVE	12(A6),D0
	ASR	#1,D0
	MOVE	D0,12(A6)
	MOVE	12(A6),D1
	EXT.L	D1
	MOVE	D7,D2
	EXT.L	D2
	MOVE.L	D1,-(A7)
	MOVE.L	D2,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	MOVE.L	D1,-(A7)
	MOVE	D6,D1
	EXT.L	D1
	MOVE.L	D1,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D1
	ADDQ.L	#4,A7
	ADD	D1,D0
	BRA.S	L557
L558:
	MOVE	12(A6),D0
L557:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$556:	.EQU	#0
F307_fzzz_:/* global */
	LINK	A6,L$559
	MOVE	D7,-(A7)
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MULS	#3,D0
	LEA	71(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D0,-10(A6)
	MOVE	#170,D0
	MOVE.B	-10(A6),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,D7
	CMPI	#16,D0
	BGE.S	L561
	MOVE	14(A6),D0
	LSR	#3,D0
	BRA.S	L560
L561:
	MOVE	D7,-(A7)
	MOVE	#7,-(A7)
	MOVE	14(A6),-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
L560:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$559:	.EQU	#-10
F308_vzzz_:/* global */
	LINK	A6,L$562
	MOVEM.L	A3/D7,-(A7)
	MOVE	12(A6),D7
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L564
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#100,D0
	SWAP	D0
	CMP	D7,D0
	BLS.S	L564
	MOVE	#1,D0
	BRA.S	L563
L564:
	MOVE.L	8(A6),A0
	LEA	70(A0),A0
	MOVE.L	A0,A3
	JSR	F027_AA59_(PC)
	MOVE.B	1(A3),D1
	AND	#255,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	CMP	D7,D0
	SHI	D0
	AND	#1,D0
	MOVE	D0,D7
	MOVE.B	(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	MOVE	D7,D1
	BEQ.S	L565
	MOVE	#-2,D1
	BRA.S	L566
L565:
	MOVE	#2,D1
L566:
	AND	#255,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,1(A3)
	MOVE	D7,D0
L563:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$562:	.EQU	#0
F309_awzz_:/* global */
	LINK	A6,L$567
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	74(A3),D7
	AND	#255,D7
	ASL	#3,D7
	ADD	#100,D7
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F306_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	50(A3),D6
	BEQ.S	L569
	MOVE	D7,D0
	MOVE	D6,D1
	AND	#16,D1
	BEQ.S	L570
	MOVE	#2,D1
	BRA.S	L571
L570:
	MOVE	#3,D1
L571:
	LSR	D1,D0
	SUB	D0,D7
L569:
	MOVE	222(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#119,D0
	BNE.S	L572
	MOVE	D7,D0
	LSR	#4,D0
	ADD	D0,D7
L572:
	ADD	#9,D7
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	SUB	D0,D7
	MOVE	D7,D0
L568:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$567:	.EQU	#0
F310_AA08_:/* global */
	LINK	A6,L$573
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	MOVE	272(A3),D1
	MOVE	D1,D7
	CMP	D1,D0
	BLS.S	L575
	MOVE	#2,D5
	MOVE	D7,D0
	AND.L	#65535,D0
	ASL.L	#3,D0
	MOVE	D6,D1
	AND.L	#65535,D1
	MOVE.L	D1,-(A7)
	MOVE.L	#5,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	CMP.L	D1,D0
	BLE.S	L576
	ADDQ	#1,D5
L576:
	MOVE	#1,D7
	BRA.S	L577
L575:
	MOVE	#4,D5
	MOVE	D7,D1
	SUB	D6,D1
	ASL	#2,D1
	AND.L	#65535,D1
	DIVU	D6,D1
	ADD	D1,D5
	MOVE	#2,D7
L577:
	MOVE	50(A3),D0
	AND	#32,D0
	BEQ.S	L578
	ADD	D7,D5
L578:
	MOVE	222(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#194,D0
	BNE.S	L579
	SUBQ	#1,D5
L579:
	MOVE	D5,D0
L574:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$573:	.EQU	#0
F311_wzzz_:/* global */
	LINK	A6,L$580
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	JSR	F027_AA59_(PC)
	AND	#7,D0
	MOVE.B	77(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	D7,D0
	ASR	#1,D0
	EXT.L	D0
	MOVE	272(A3),D1
	AND.L	#65535,D1
	MOVE.L	D0,-(A7)
	MOVE.L	D1,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE	D1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D0
	ADDQ.L	#4,A7
	SUB	D0,D7
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L582
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L582:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	#100,D0
	SUB	D1,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	#1,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L581:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$580:	.EQU	#0
F312_xzzz_:/* global */
	LINK	A6,L$583
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE.B	74(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	10(A6),D4
	ASL.L	#1,D4
	LEA	212(A3),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	D4,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	LSR	#4,D1
	MOVE	D1,D5
	CMP	D1,D0
	BHI.S	L585
	MOVE	D6,D0
	SUB	#12,D0
	ADD	D0,D7
	BRA.S	L586
L585:
	MOVE	D5,D0
	MOVE	D5,D1
	SUB	#12,D1
	LSR	#1,D1
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D0,-12(A6)
	MOVE	D6,D0
	CMP	-12(A6),D0
	BHI.S	L587
	MOVE	D6,D0
	SUB	D5,D0
	LSR	#1,D0
	ADD	D0,D7
	BRA.S	L588
L587:
	MOVE	D6,D0
	SUB	-2(A6),D0
	ASL	#1,D0
	SUB	D0,D7
L588:
L586:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L589
	MOVE	D4,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	2(A2),D0
	AND	#255,D0
	ADD	D0,D7
	CLR	D6
	MOVE.B	1(A2),D5
	AND	#255,D5
	CMPI	#0,D5
	BEQ.S	L591
	CMPI	#2,D5
	BNE.S	L590
L591:
	MOVE	#4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
L590:
	CMPI	#0,D5
	BEQ.S	L592
	CMPI	#16,D5
	BCC.S	L592
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D6
L592:
	CMPI	#16,D5
	BCS.S	L593
	CMPI	#112,D5
	BCC.S	L593
	MOVE	#11,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D6
L593:
	MOVE	D6,D0
	ASL	#1,D0
	ADD	D0,D7
L589:
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F306_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	50(A3),D0
	CMPI	#0,10(A6)
	BNE.S	L595
	MOVE	#1,D1
	BRA.S	L596
L595:
	MOVE	#2,D1
L596:
	AND	D1,D0
	BEQ.S	L594
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L594:
	MOVE	#100,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L584:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$583:	.EQU	#-12
F313_xxxx_:/* global */
	LINK	A6,L$597
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	10(A6),D5
	AND	#-32768,D5
	BEQ.S	L599
	ANDI	#32767,10(A6)
L599:
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE	#0,D0
	MOVE	D0,D7
	BRA	L600(PC)
L601:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#6,D0
	BNE.S	L604
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	ASL.L	#2,D0
	LEA	G239_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	2(A2),D0
	AND	#255,D0
	AND	#128,D0
	BEQ.S	L605
	MOVE	D7,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F143_mzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	10(A6),D1
	LEA	G050_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULU	D1,D0
	MOVE	D7,D1
	CMP	10(A6),D1
	BNE.S	L606
	MOVE	#4,D1
	BRA.S	L607
L606:
	MOVE	#5,D1
L607:
	LSR	D1,D0
	ADD	D0,D6
L605:
L604:
L602:
	ADDQ	#1,D7
L600:
	CMPI	#1,D7
	BLE	L601(PC)
L603:
	JSR	F027_AA59_(PC)
	MOVE.B	83(A3),D1
	AND	#255,D1
	ASR	#3,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D7
	MOVE	D5,D0
	BEQ.S	L608
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L608:
	MOVE	64(A3),D0
	ADD	274(A3),D0
	ADD	G407_s_Par+3204(A4),D0
	ADD	D6,D0
	ADD	D0,D7
	CMPI	#1,10(A6)
	BLS.S	L609
	MOVE	10(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#6,D0
	BNE.S	L609
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	D5,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	ASL.L	#2,D0
	LEA	G239_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F143_mzzz_(PC)
	ADDQ.L	#6,A7
	ADD	D0,D7
L609:
	MOVE	50(A3),D0
	MOVE	#1,D1
	MOVE	10(A6),D3
	ASL	D3,D1
	AND	D1,D0
	BEQ.S	L610
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE	#8,D0
	ADD	D1,D0
	SUB	D0,D7
L610:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L611
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L611:
	MOVE	#100,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L598:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$597:	.EQU	#0
F314_gzzz_:/* global */
	LINK	A6,L$612
	MOVE	#1,G321_B_Sto(A4)
	CLR	G300_B_Par(A4)
	MOVE	#10,G318_i_Wai(A4)
	JSR	F098_rzzz_(PC)
	LEA	G447_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	LEA	G448_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	LEA	G458_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	LEA	G459_as_Gr(A4),A0
	MOVE.L	A0,G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	JSR	F457_AA08_(PC)
L613:
	UNLK	A6
	RTS
L$612:	.EQU	#-2
F315_arzz_:/* global */
	LINK	A6,L$614
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	BEQ.S	L616
	MOVE	8(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-2(A6)
	OR	D3,-2(A6)
	MOVE	10(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-2(A6)
	OR	D3,-2(A6)
	MOVE	G272_i_Cur(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-2(A6)
	OR	D3,-2(A6)
	MOVE	-2(A6),D7
	MOVE	D6,D0
	SUBQ	#1,D6
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
L617:
	MOVE	-(A3),D0
	CMP	D7,D0
	BNE.S	L620
	MOVE	D6,D0
	ADDQ	#1,D0
	BRA.S	L615
L620:
L618:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L617
L619:
L616:
	MOVE	#0,D0
L615:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$614:	.EQU	#-2
F316_aizz_:/* global */
	LINK	A6,L$621
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	AND	#255,D6
	SUBQ.B	#1,G407_s_Par+3210(A4)
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	SUB	D7,D6
	BEQ.S	L623
	MOVE	D6,D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3216(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D6,-(A7)
	MOVE	D7,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	LEA	G407_s_Par+3263(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L623:
	MOVE	D7,D0
	MOVE.B	G407_s_Par+3212(A4),D1
	AND	#255,D1
	CMP	D1,D0
	BCC.S	L624
	SUBQ.B	#1,G407_s_Par+3212(A4)
L624:
	MOVE	D7,D0
	MOVE.B	G407_s_Par+3213(A4),D1
	AND	#255,D1
	CMP	D1,D0
	BCC.S	L625
	SUBQ.B	#1,G407_s_Par+3213(A4)
L625:
L622:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$621:	.EQU	#0
F317_adzz_:/* global */
	LINK	A6,L$626
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	12(A6),D7
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	BEQ	L628(PC)
	MOVE	D7,D5
	AND	#-32768,D5
	BEQ.S	L629
	AND	#32767,D7
L629:
	MOVE	8(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-2(A6)
	OR	D3,-2(A6)
	MOVE	10(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-2(A6)
	OR	D3,-2(A6)
	MOVE	G272_i_Cur(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-2(A6)
	OR	D3,-2(A6)
	LEA	G407_s_Par+3214(A4),A0
	MOVE.L	A0,A3
	CLR	D4
	BRA.S	L630
L631:
	MOVE.L	A3,A0
	ADDQ.L	#2,A3
	LEA	(A0),A1
	LEA	-2(A6),A0
	MOVEQ	#0,D0
	JSR	_blockcmp(PC)
	MOVE	D4,D0
	BNE.S	L633
	MOVE	#1,D4
	MOVE	D5,D0
	BEQ.S	L634
	MOVE	D7,-(A7)
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L635
L634:
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D7,D0
	MOVE	D0,-(A7)
	MOVE	#80,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
L635:
L633:
	MOVE	D7,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	D0,(A0)
L630:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L631
L632:
L628:
L627:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$626:	.EQU	#-2
F318_xxxx_:/* global */
	LINK	A6,L$636
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D6
	MULS	#800,D6
	LEA	G407_s_Par+29(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	CLR	D4
	BRA.S	L638
L639:
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G057_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	CMPI	#-1,D0
	BEQ.S	L642
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,D0
	AND	#16383,D0
	MOVE	D6,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L642:
L640:
	ADDQ	#1,D4
L638:
	CMPI	#30,D4
	BCS.S	L639
L641:
L637:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$636:	.EQU	#0
F319_xxxx_:/* global */
	LINK	A6,L$643
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	52(A3)
	ORI	#4096,48(A3)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L645
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L646
	CLR	G331_B_Pre(A4)
	CLR	G597_B_Ign(A4)
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L647
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L647:
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
	BRA.S	L648
L646:
	MOVE	G333_B_Pre(A4),D0
	BEQ.S	L649
	CLR	G333_B_Pre(A4)
	CLR	G597_B_Ign(A4)
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
L649:
L648:
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L645:
	MOVE	D7,-(A7)
	JSR	F318_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32758,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#-1,D4
	BNE.S	L650
	BRA.S	L651
L650:
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#5,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A2)
	OR	D3,2(A2)
	MOVE	#1,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ANDI	#-129,2(A2)
	OR	D3,2(A2)
	MOVE	D7,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A2)
	OR	D3,2(A2)
	MOVE.B	29(A3),D6
	AND	#255,D6
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	D6,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L651:
	CLR.B	33(A3)
	CLR.B	34(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR.B	41(A3)
	MOVE	D6,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE	D0,D6
	MOVE	D6,D0
	ADDQ	#1,D0
	CMP	G599_ui_Us(A4),D0
	BNE.S	L652
	MOVE	#1,G598_B_Mou(A4)
	CLR	G599_ui_Us(A4)
	MOVE	#1,G592_B_Bui(A4)
L652:
	MOVE.B	42(A3),D0
	BEQ.S	L653
	MOVE	D7,-(A7)
	JSR	F323_xxxx_(PC)
	ADDQ.L	#2,A7
L653:
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	MOVE	D6,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#0,D0
	MOVE	D0,D5
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L654
L655:
	MOVE	52(A3),D0
	BEQ.S	L658
	BRA.S	L657
L658:
L656:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE.L	A3,D0
	ADDA	#800,A3
L654:
	MOVE	D5,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L655
L657:
	MOVE	D5,D0
	CMP	G305_ui_Pa(A4),D0
	BNE.S	L659
	MOVE	#1,G303_B_Par(A4)
	BRA.S	L644
L659:
	MOVE	D7,D0
	MOVE	G411_i_Lea(A4),D1
	CMP	D1,D0
	BNE.S	L660
	MOVE	D5,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L660:
	MOVE	D7,D0
	MOVE	G514_i_Mag(A4),D1
	CMP	D1,D0
	BNE.S	L661
	MOVE	D5,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L644
L661:
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
L644:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$643:	.EQU	#0
F320_akzz_:/* global */
	LINK	A6,L$662
	MOVEM.L	A3-A2/D7-D4,-(A7)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA	L664(PC)
L665:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	OR	D0,50(A3)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	BNE.S	L668
	BRA	L666(PC)
L668:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE	52(A3),D0
	MOVE	D0,D5
	BNE.S	L669
	BRA	L666(PC)
L669:
	MOVE	D5,D0
	SUB	D6,D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGT.S	L670
	MOVE	D7,-(A7)
	JSR	F319_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L671(PC)
L670:
	MOVE	D5,52(A3)
	ORI	#256,48(A3)
	MOVE	D4,D0
	BEQ.S	L672
	ORI	#8192,48(A3)
L672:
	MOVE	D7,D5
	MULU	#69,D5
	CLR	-16(A6)
	JSR	F077_aA39_(PC)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L673
	MOVE	#28,-14(A6)
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,-20(A6)
	ADD	#31,D0
	MOVE	D0,-18(A6)
	MOVE	#10,-(A7)
	MOVE	#16,-(A7)
	PEA	-20(A6)
	MOVE	#16,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	CMPI	#10,D6
	BCC.S	L674
	ADD	#21,D5
	BRA.S	L675
L674:
	CMPI	#100,D6
	BCC.S	L676
	ADD	#18,D5
	BRA.S	L677
L676:
	ADD	#15,D5
L677:
L675:
	MOVE	#16,-2(A6)
	BRA.S	L678
L673:
	MOVE	#6,-14(A6)
	MOVE	D5,D0
	MOVE	D0,-20(A6)
	ADD	#47,D0
	MOVE	D0,-18(A6)
	MOVE	#10,-(A7)
	MOVE	#24,-(A7)
	PEA	-20(A6)
	MOVE	#15,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	CMPI	#10,D6
	BCC.S	L679
	ADD	#19,D5
	BRA.S	L680
L679:
	CMPI	#100,D6
	BCC.S	L681
	ADD	#16,D5
	BRA.S	L682
L681:
	ADD	#13,D5
L682:
L680:
	MOVE	#5,-2(A6)
L678:
	MOVE	#3,-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#8,-(A7)
	MOVE	#15,-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D5,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	46(A3),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L683
	MOVE.B	#12,-8(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#5,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-12(A6)
	MOVE	D7,D0
	MOVE.B	D0,-7(A6)
	PEA	-12(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,46(A3)
	BRA.S	L684
L683:
	MOVE	D5,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#5,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	MOVE	D5,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L684:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L671:
L666:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L664:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L665(PC)
L667:
L663:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$662:	.EQU	#-20
F321_AA29_:/* global */
	LINK	A6,L$685
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	10(A6),D7
	CMPI	#-1,8(A6)
	BEQ.S	L688
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ.S	L689
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L687
L689:
L688:
	BRA	L686(PC)
L687:
	CMPI	#0,D7
	BGT.S	L690
	MOVE	#0,D0
	BRA	L686(PC)
L690:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BNE.S	L691
L44T321_004:
	MOVE	#0,D0
	BRA	L686(PC)
L691:
	CMPI	#0,14(A6)
	BEQ	L692(PC)
	MOVE	#0,D0
	MOVE	D0,D4
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE	#0,D0
	MOVE	D0,D5
	BRA.S	L693
L694:
	MOVE	12(A6),D0
	MOVE	#1,D1
	ASL	D6,D1
	AND	D1,D0
	BEQ.S	L697
	ADDQ	#1,D4
	MOVE	D6,D0
	CMPI	#4,14(A6)
	BNE.S	L698
	MOVE	#-32768,D1
	BRA.S	L699
L698:
	MOVE	#0,D1
L699:
	OR	D1,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F313_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D5
L697:
L695:
	ADDQ	#1,D6
L693:
	CMPI	#5,D6
	BLE.S	L694
L696:
	MOVE	D4,D0
	BEQ.S	L700
	MOVE	D5,D0
	AND.L	#65535,D0
	DIVU	D4,D0
	MOVE	D0,D5
L700:
	MOVE	14(A6),D0
L701:
	CMP	#6,D0
	BEQ.S	L702
	BRA.S	L704
L702:
	MOVE	#115,D0
	MOVE.B	80(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BGT.S	L706
	CLR	D7
	BRA.S	L707
L706:
	MOVE	D6,-(A7)
	MOVE	#6,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L707:
	BRA	L44T321_024(PC)
	BRA.S	L705
L704:
	CMP	#5,D0
	BEQ.S	L705
	BRA.S	L708
L705:
	MOVE	D7,-(A7)
	MOVE	#5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	SUB	G407_s_Par+3208(A4),D7
	BRA.S	L44T321_024
	BRA.S	L709
L708:
	CMP	#1,D0
	BEQ.S	L709
	BRA.S	L710
L709:
	MOVE	D7,-(A7)
	MOVE	#6,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	SUB	G407_s_Par+3206(A4),D7
	BRA.S	L703
	BRA.S	L711
L710:
	CMP	#2,D0
	BEQ.S	L711
	BRA.S	L712
L711:
	MOVE	D5,D0
	LSR	#1,D0
	MOVE	D0,D5
	BRA.S	L713
L712:
	CMP	#3,D0
	BEQ.S	L713
L714:
	CMP	#4,D0
	BEQ.S	L713
L715:
	CMP	#7,D0
L716:
L713:
L703:
	CMPI	#0,D7
	BGT.S	L717
	BRA	L44T321_004(PC)
L717:
	MOVE	#130,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#6,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L44T321_024:
	CMPI	#0,D7
	BGT.S	L718
	BRA	L44T321_004(PC)
L718:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	ADD	#10,D0
	MOVE	D0,-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D6
	MOVE	D0,-10(A6)
	MOVE	D7,D0
	CMP	-10(A6),D0
	BLE.S	L719
L720:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	D1,-20(A6)
	MOVE	#1,D1
	MOVE	-20(A6),D3
	ASL	D3,D1
	AND	12(A6),D1
	MOVE	8(A6),D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	OR	D1,D0
	MOVE	D0,(A0)
L721:
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
	MOVE	D0,-30(A6)
	MOVE	D7,D0
	CMP	-30(A6),D0
	BLE.S	L723
	MOVE	D6,D0
	BNE.S	L720
L723:
L722:
L719:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L724
	JSR	F314_gzzz_(PC)
L724:
L692:
	CMPI	#0,D7
	BGT.S	L725
	CLR	D7
L725:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D7,D0
	MOVE	D0,(A0)
	MOVE	D7,D0
L686:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$685:	.EQU	#-30
F322_lzzz_:/* global */
	LINK	A6,L$726
	CMPI	#-1,8(A6)
	BEQ.S	L729
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BNE.S	L728
L729:
	BRA	L727(PC)
L728:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-14(A6)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	10(A6),D0
	LSR	#6,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE.L	-14(A6),A0
	ORI	#256,48(A0)
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G423_i_Inv(A4),D0
	BNE.S	L730
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L730
	MOVE.L	-14(A6),A0
	ORI	#2048,48(A0)
L730:
	SUBQ	#1,10(A6)
	BEQ.S	L731
	MOVE.L	-14(A6),A0
	ADDQ.B	#1,42(A0)
	MOVE.B	#75,-6(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-5(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#36,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE	10(A6),-4(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L731:
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L727:
	UNLK	A6
	RTS
L$726:	.EQU	#-14
F323_xxxx_:/* global */
	LINK	A6,L$732
	MOVEM.L	A3/D7,-(A7)
	CMPI	#-1,8(A6)
	BNE.S	L734
	BRA.S	L733
L734:
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L735
L736:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#75,D0
	BNE.S	L739
	MOVE.B	5(A3),D0
	AND	#255,D0
	CMP	8(A6),D0
	BNE.S	L739
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L739:
L737:
	MOVE.L	A3,D0
	ADDA	#10,A3
	MOVE	D7,D0
	ADDQ	#1,D7
L735:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L736
L738:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	CLR.B	(A0)
L733:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$732:	.EQU	#0
F324_aezz_:/* global */
	LINK	A6,L$740
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	BNE.S	L742
	BRA.S	L741
L742:
	MOVE	D7,D0
	LSR	#3,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	SUB	D0,D7
	MOVE	D5,D0
	ASL	#1,D0
	MOVE	D0,D5
	MOVE	#0,D0
	MOVE	D0,D4
	MOVE	#0,D0
	MOVE	D0,D6
	BRA.S	L743
L744:
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND.L	#65535,D1
	DIVU	D5,D1
	SWAP	D1
	MOVE	D7,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L747
	ADDQ	#1,D4
L747:
L745:
	ADDQ	#1,D6
L743:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L744
L746:
	MOVE	D4,D0
L741:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$740:	.EQU	#0
F325_bzzz_:/* global */
	LINK	A6,L$748
	MOVEM.L	A3/D7,-(A7)
	CMPI	#-1,8(A6)
	BNE.S	L750
	BRA.S	L749
L750:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	56(A3),D0
	SUB	10(A6),D0
	MOVE	D0,56(A3)
	MOVE	D0,D7
	CMPI	#0,D0
	BGT.S	L751
	CLR	56(A3)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	NEG	D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	BRA.S	L752
L751:
	MOVE	D7,D0
	CMP	58(A3),D0
	BLE.S	L753
	MOVE	58(A3),56(A3)
L753:
L752:
	ORI	#768,48(A3)
L749:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$748:	.EQU	#0
F326_ozzz_:/* global */
	LINK	A6,L$754
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	28(A3),D7
	AND	#255,D7
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE.B	29(A3),D0
	AND	#255,D0
	SUB	D7,D0
	ADDQ	#1,D0
	AND	#2,D0
	LSR	#1,D0
	ADD	D7,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L755:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$754:	.EQU	#0
F327_kzzz_:/* global */
	LINK	A6,L$756
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	12(A6),D7
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	60(A3),D0
	CMP	14(A6),D0
	BCC.S	L758
	MOVE	#0,D0
	BRA.S	L757
L758:
	MOVE	14(A6),D0
	SUB	D0,60(A3)
	ORI	#256,48(A3)
	MOVE	62(A3),D0
	ASR	#3,D0
	MOVE	D0,-(A7)
	MOVE	#8,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	#10,D0
	SUB	D1,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MOVE	D6,D1
	ASL	#2,D1
	CMP	D1,D0
	BGE.S	L759
	ADDQ	#3,D7
	SUBQ	#1,D6
L759:
	MOVE	D6,-(A7)
	MOVE	#90,-(A7)
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F326_ozzz_(PC)
	ADDA	#12,A7
L757:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$756:	.EQU	#0
F328_nzzz_:/* global */
	LINK	A6,L$760
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-4(A6)
	CMPI	#0,10(A6)
	BGE.S	L762
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L763
	MOVE	#0,D0
	BRA	L761(PC)
L763:
	JSR	F298_aqzz_(PC)
	MOVE	D0,D4
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	214(A3),-2(A6)
	MOVE	D4,214(A3)
	MOVE	#1,10(A6)
	MOVE	#1,-4(A6)
L762:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	-4(A6),D0
	BEQ.S	L764
	MOVE	10(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	-2(A6),(A0)
	BRA.S	L765
L764:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-1,D0
	BNE.S	L766
	MOVE	#0,D0
	BRA	L761(PC)
L766:
L765:
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,-(A7)
	JSR	F305_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F330_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#8,D6
	MOVE	#1,D5
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L767
	ADDQ	#4,D6
	MOVE	D4,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#12,D0
	BGT.S	L768
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,D5
	ASR	#2,D0
	ADD	D0,D6
L768:
L767:
	MOVE	D6,-(A7)
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	ADD	D5,D7
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE	D7,D1
	ASR	#1,D1
	ADD	D1,D0
	ADD	D5,D0
	ADD	D0,D7
	MOVE	#200,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#31,D1
	MOVE	D5,D0
	ASL	#3,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#40,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	MOVE	#11,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),D0
	ADD	12(A6),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	D4,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	#4,G311_i_Pro(A4)
	MOVE	G308_i_Par(A4),G312_i_Las(A4)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D0
L761:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$760:	.EQU	#-4
F329_hzzz_:/* global */
	LINK	A6,L$769
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L771
	MOVE	#0,D0
	BRA.S	L770
L771:
	MOVE	8(A6),-(A7)
	MOVE	#-1,-(A7)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F328_nzzz_(PC)
	ADDQ.L	#6,A7
L770:
	UNLK	A6
	RTS
L$769:	.EQU	#0
F330_szzz_:/* global */
	LINK	A6,L$772
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	G313_ul_Ga(A4),D7
	MOVE	10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D7
	MOVE.B	#11,-6(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-5(A6)
	CLR.B	-4(A6)
	MOVE	44(A3),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BLT.S	L774
	MOVE	D5,D6
	MULS	#10,D6
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D6,A0
	MOVE.L	(A0),D6
	AND.L	#16777215,D6
	MOVE.L	D7,D0
	CMP.L	D6,D0
	BLT.S	L775
	MOVE.L	D6,D0
	SUB.L	G313_ul_Ga(A4),D0
	ASR.L	#1,D0
	ADD.L	D0,D7
	BRA.S	L776
L775:
	MOVE.L	D6,D7
	MOVE	10(A6),D1
	LSR	#1,D1
	AND.L	#65535,D1
	ADD.L	D1,D7
L776:
	MOVE	D5,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L777
L774:
	ORI	#-32760,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L777:
	MOVE.L	D7,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,44(A3)
L773:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$772:	.EQU	#-10
F331_auzz_:/* global */
	LINK	A6,L$778
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BNE.S	L780
	BRA	L779(PC)
L780:
	MOVE	G306_i_Par(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-6(A6)
	OR	D3,-6(A6)
	MOVE	G307_i_Par(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-6(A6)
	OR	D3,-6(A6)
	MOVE	G309_i_Par(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-6(A6)
	OR	D3,-6(A6)
	CLR	D6
	BRA.S	L781
L782:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-6(A6),A0
	MOVEQ	#0,D0
	JSR	_blockcmp(PC)
	MOVE	D6,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	BNE.S	L784
	MOVE	D6,D0
	BNE.S	L784
	CLR	-(A7)
	JSR	F316_aizz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L781
L784:
	ADDQ	#1,D6
L781:
	MOVE	D6,D0
	MOVE.B	G407_s_Par+3210(A4),D1
	AND	#255,D1
	SUBQ	#1,D1
	CMP	D1,D0
	BLT.S	L782
L783:
	MOVE.L	G313_ul_Ga(A4),D7
	MOVE	D7,D0
	AND	#128,D0
	MOVE	D7,D1
	AND	#256,D1
	LSR	#2,D1
	ADD	D1,D0
	MOVE	D7,D1
	AND	#64,D1
	ASL	#2,D1
	ADD	D1,D0
	LSR	#2,D0
	MOVE	D0,-2(A6)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA	L785(PC)
L786:
	MOVE	52(A3),D0
	BEQ	L789(PC)
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ	L789(PC)
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BGE	L790(PC)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	D0,D5
	MOVE	D0,-16(A6)
	MOVE.B	80(A3),D0
	AND	#255,D0
	ADD	-16(A6),D0
	MOVE	D0,-16(A6)
	MOVE	-2(A6),D0
	CMP	-16(A6),D0
	BCC.S	L790
	MOVE	62(A3),D6
	EXT.L	D6
	DIVS	#40,D6
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L791
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
L791:
	ADDQ	#1,D6
	MOVE	#16,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#7,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	D6,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	62(A3),D0
	SUB	60(A3),D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,60(A3)
	BRA.S	L792
L790:
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BLE.S	L793
	SUBQ	#1,60(A3)
L793:
L792:
	MOVE	#19,D4
	BRA.S	L794
L795:
	MOVE	D4,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	CMPI	#0,(A0)
	BLE.S	L798
	MOVE	D4,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	SUBQ	#1,(A0)
L798:
L796:
	SUBQ	#1,D4
L794:
	CMPI	#0,D4
	BGE.S	L795
L797:
	MOVE	#4,D6
	MOVE	58(A3),D4
	BRA.S	L799
L800:
	ADDQ	#2,D6
L799:
	MOVE	D4,D0
	ASR	#1,D0
	MOVE	D0,D4
	MOVE	D0,-26(A6)
	MOVE	56(A3),D0
	CMP	-26(A6),D0
	BLT.S	L800
L801:
	CLR	D4
	MOVE	#6,-(A7)
	MOVE	58(A3),D0
	ASR	#8,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-4(A6)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L802
	MOVE	-4(A6),D0
	ASL	#1,D0
	MOVE	D0,-4(A6)
L802:
	MOVE.L	G313_ul_Ga(A4),D0
	SUB.L	G362_l_Las(A4),D0
	MOVE	D0,D5
	CMPI	#80,D0
	BLS.S	L803
	ADDQ	#1,-4(A6)
	CMPI	#250,D5
	BLS.S	L804
	ADDQ	#1,-4(A6)
L804:
L803:
L805:
	CMPI	#4,D6
	SLS	D5
	AND	#1,D5
	CMPI	#-512,66(A3)
	BGE.S	L808
	MOVE	D5,D0
	BEQ.S	L809
	ADD	-4(A6),D4
	SUBQ	#2,66(A3)
L809:
	BRA.S	L810
L808:
	CMPI	#0,66(A3)
	BLT.S	L811
	SUB	-4(A6),D4
L811:
	MOVE	D5,D0
	BEQ.S	L812
	MOVE	#2,D0
	BRA.S	L813
L812:
	MOVE	D6,D0
	LSR	#1,D0
L813:
	SUB	D0,66(A3)
L810:
	CMPI	#-512,68(A3)
	BGE.S	L814
	MOVE	D5,D0
	BEQ.S	L815
	ADD	-4(A6),D4
	SUBQ	#1,68(A3)
L815:
	BRA.S	L816
L814:
	CMPI	#0,68(A3)
	BLT.S	L817
	SUB	-4(A6),D4
L817:
	MOVE	D5,D0
	BEQ.S	L818
	MOVE	#1,D0
	BRA.S	L819
L818:
	MOVE	D6,D0
	LSR	#2,D0
L819:
	SUB	D0,68(A3)
L816:
	SUBQ	#1,D6
L806:
	MOVE	D6,D0
	BEQ.S	L820
	MOVE	56(A3),D0
	SUB	D4,D0
	CMP	58(A3),D0
	BLT	L805(PC)
L820:
L807:
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-1024,66(A3)
	BGE.S	L821
	MOVE	#-1024,66(A3)
L821:
	CMPI	#-1024,68(A3)
	BGE.S	L822
	MOVE	#-1024,68(A3)
L822:
	MOVE	52(A3),D0
	CMP	54(A3),D0
	BGE.S	L823
	MOVE	56(A3),D0
	MOVE	58(A3),D1
	ASR	#2,D1
	CMP	D1,D0
	BLT.S	L823
	MOVE	-2(A6),D0
	MOVE.B	83(A3),D1
	AND	#255,D1
	ADD	#12,D1
	CMP	D1,D0
	BCC.S	L823
	MOVE	54(A3),D0
	ASR	#7,D0
	ADDQ	#1,D0
	MOVE	D0,-4(A6)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L824
	MOVE	-4(A6),D0
	ASL	#1,D0
	MOVE	D0,-4(A6)
L824:
	MOVE	232(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#121,D0
	BNE.S	L825
	MOVE	-4(A6),D0
	ASR	#1,D0
	ADDQ	#1,D0
	ADD	D0,-4(A6)
L825:
	MOVE	54(A3),D0
	SUB	52(A3),D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,52(A3)
L823:
	MOVE	G328_i_Tim(A4),D0
	BEQ.S	L826
	SUBQ	#1,G328_i_Tim(A4)
	MOVE	G328_i_Tim(A4),D0
	BNE.S	L826
	CLR	G524_B_Res(A4)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#4096,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
L826:
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	G300_B_Par(A4),D1
	BEQ.S	L828
	MOVE	#63,D1
	BRA.S	L829
L828:
	MOVE	#255,D1
L829:
	AND	D1,D0
	BNE.S	L827
	CLR	D6
	BRA.S	L830
L831:
	MOVE	D6,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D5
	AND	#255,D5
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	D5,D0
	BCC.S	L833
	ADDQ.B	#1,1(A2)
	BRA.S	L834
L833:
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	D5,D0
	BLS.S	L835
	MOVE.B	1(A2),D0
	AND	#255,D0
	AND.L	#65535,D0
	DIVU	D5,D0
	SUB.B	D0,1(A2)
L835:
L834:
	ADDQ	#1,D6
L830:
	CMPI	#6,D6
	BLS.S	L831
L832:
L827:
	MOVE	G300_B_Par(A4),D0
	BNE.S	L836
	MOVE.B	28(A3),D0
	AND	#255,D0
	CMP	G308_i_Par(A4),D0
	BEQ.S	L836
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#60,D1
	CMP.L	D1,D0
	BGE.S	L836
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR.B	41(A3)
	ORI	#1024,48(A3)
L836:
	ORI	#256,48(A3)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L837
	MOVE	G333_B_Pre(A4),D0
	BNE.S	L839
	MOVE	G331_B_Pre(A4),D0
	BNE.S	L839
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L838
L839:
	ORI	#2048,48(A3)
L838:
L837:
L789:
L787:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L785:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L786(PC)
L788:
	JSR	F293_ahzz_(PC)
L779:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$778:	.EQU	#-26
