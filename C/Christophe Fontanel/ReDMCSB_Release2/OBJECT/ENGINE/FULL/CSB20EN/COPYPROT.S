CODE SEG "init!"
	MOVE	#0,G624_B_Flo(A4)
BSS SEG "bss"
G624_B_Flo:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#0,G625_i_Flo(A4)
BSS SEG "bss"
G625_i_Flo:/* global */
	.WORD	#2
G626_pfV_S:/* global */
	.WORD	#4
G627_pfV_S:/* global */
	.WORD	#4
CODE SEG "main"
F079_a002_:/* global */
	LINK	A6,L$0
	MOVE.L	8(A6),A0
	CMPI	#20217,(A0)
	BNE.S	L0T079_001
	MOVE.L	2(A0),A0
L0T079_001:
	MOVEQ	#100,D0
	MOVE.L	#1314803317,D1
L0T079_002_:
	ADD	(A0)+,D0
	CMP.L	(A0),D1
	BNE.S	L0T079_002_
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#0
S080_aaat_:/* global */
	LEA	G625_i_Flo(A4),A1
	CMPI	#259,(A1)
	BEQ.S	L0T080_001
	BTST	#5,64001.W
	BEQ.S	L0T080_002
	MOVEQ	#254,D0
L0T080_001:
	SUBQ	#1,(A1)
	BEQ.S	L0T080_005
	RTS
L0T080_002:
	MOVE	#-31226,A0
	MOVE	#144,(A0)
	MOVEQ	#1,D0
	AND	(A0),D0
	BEQ.S	L0T080_004
	MOVE	#128,(A0)
	MOVEQ	#44,D0
L0T080_003_:
	SUBQ	#1,D0
	BNE.S	L0T080_003_
	MOVEQ	#16,D0
	AND	-2(A0),D0
	BEQ.S	L0T080_005
	MOVEQ	#249,D0
L0T080_004:
	SUBQ	#1,D0
L0T080_005:
	MOVE	D0,(A1)
	BNE.S	L0T080_006
	CLR	G314_i_Sec(A4)
L0T080_006:
	CLR	1086.W
	RTS
S081_aaao_:/* global */
	TST	1086.W
	BNE.S	L0T081_001
	MOVE	34308.W,D0
	BTST	#7,D0
	BNE.S	L0T081_001
	MOVE	#-30720,A0
	MOVEQ	#7,D0
	MOVE	SR,D1
	ORI	#1792,SR
	MOVE.B	#14,(A0)
	OR.B	(A0),D0
	MOVE.B	D0,2(A0)
	MOVE	D1,SR
	CLR	G624_B_Flo(A4)
L0T081_001:
	RTS
CODE SEG "show"
F137_pzzz_:/* global */
	LINK	A6,L$2
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
L4:
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	30(A6),D0
	SWAP	D0
	ASL.L	#2,D0
	MOVE.L	26(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE	60(A2),D0
L7:
L5:
	MOVE	60(A2),D0
	BNE.S	L4
L6:
	MOVE	#1,60(A2)
	MOVE	#42,-(A7)
	MOVE.L	A2,-(A7)
	PEA	R138_lzzz_(PC)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L1T137_002:
	CMPI	#20217,(A3)
	BNE.S	L1T137_003
	MOVE.L	2(A3),A3
	BRA.S	L1T137_002
L1T137_003:
	MOVE	#6,-(A7)
	LEA	62(A2),A0
	MOVE.L	A0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	A3,42(A2)
	MOVE.L	12(A6),46(A2)
	MOVE	16(A6),50(A2)
	MOVE.L	18(A6),52(A2)
	MOVE.L	22(A6),56(A2)
	MOVE	#20217,(A3)+
	MOVE.L	A2,(A3)
L3:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$2:	.EQU	#0
R138_lzzz_:/* global */
	LEA	L1V138_6_xx(PC),A0
	CLR	(A0)+
	MOVE.L	L1V138_1_xx(PC),A1
	MOVE.L	(A0)+,(A1)+
	MOVE	(A0),(A1)
	MOVE.L	L1V138_2_xx(PC),A0
	MOVE	L1V138_3_xx(PC),-(A7)
	JSR	(A0)
	MOVE.L	D0,A0
	MOVE.L	L1V138_5_xx(PC),-(A7)
	MOVE.L	L1V138_4_xx(PC),-(A7)
	JSR	(A0)
	LEA	10(A7),A7
	JMP	*** absolute address expected ***

L1V138_1_xx:
	ORI.B	#0,D0
L1V138_2_xx:
	ORI.B	#0,D0
L1V138_3_xx:
	ORI.B	*** Immediate value expected ***,D0
L1V138_4_xx:
	ORI.B	#0,D0
L1V138_5_xx:
	ORI.B	#0,D0
L1V138_6_xx:
	ORI.B	#0,D0
	ORI.B	#0,D0
CODE SEG "dunman"
F210_uzzz_:/* global */
	LINK	A6,L$8
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#7,D0
	BNE.S	L11
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#80,D0
	BNE.S	L11
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#65,D0
	BNE.S	L11
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#67,D0
	BNE.S	L11
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#69,D0
	BNE.S	L11
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#47,D0
	BNE.S	L11
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#70,D0
	BNE.S	L11
	MOVE.B	(A3),D0
	AND	#255,D0
	CMP	#66,D0
	BNE.S	L11
	MOVE.B	503(A3),D0
	AND	#255,D0
	CMP	#70,D0
	BNE.S	L11
	MOVE.B	504(A3),D0
	AND	#255,D0
	CMP	#66,D0
	BEQ.S	L10
L11:
	MOVE	#0,D0
	BRA.S	L9
L10:
	ADDQ	#4,G240_i_Gra(A4)
	MOVE	#4,D0
L9:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$8:	.EQU	#0
F211_vzzz_:/* global */
	LINK	A6,L$12
	MOVE.L	8(A6),A0
	CMPI	#20217,(A0)
	BNE.S	L3T211_001
	MOVE.L	2(A0),A0
L3T211_001:
	MOVE.L	A0,D0
L13:
	UNLK	A6
	RTS
L$12:	.EQU	#0
CODE SEG "timeline"
F277_jzzz_:/* global */
	LINK	A6,L$14
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	CLR	D5
	CLR	-2(A6)
	CLR	D6
	CLR	D4
	MOVE	#512,G068_i_Che(A4)
	MOVE	#20,D7
	BRA.S	L16
L17:
	MOVE	D4,D0
	ASL	#1,D0
	MOVE.L	A3,A0
	ADDA	D7,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	ASR	#7,D1
	AND	#1,D1
	OR	D1,D0
	MOVE	D0,D4
	MOVE	D5,D0
	ADDQ	#1,D5
	CMPI	#16,D0
	BEQ.S	L21
	CMPI	#508,D7
	BNE.S	L20
L21:
	CLR	D5
	MOVE	D4,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G293_ai_Fu(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L22
	ADDQ	#1,-2(A6)
L22:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	G293_ai_Fu(A4),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
	CLR	D4
L20:
L18:
	ADDQ	#1,D7
L16:
	CMPI	#509,D7
	BLT.S	L17
L19:
	MOVE	-2(A6),D0
	BNE.S	L23
	CLR.L	G418_l_Las(A4)
L23:
	MOVE	#136,G031_i_Gra(A4)
	MOVE	-2(A6),D0
L15:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$14:	.EQU	#-2
CODE SEG "player"
F356_ozzz_:/* global */
	LINK	A6,L$24
BSS SEG "bss"
6G628_i_La:
	.WORD	#2
7G629_i_Co:
	.WORD	#2
CODE SEG "player"
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	CLR	D5
	MOVE	#20,D7
	MOVE	D7,D0
	EXT.L	D0
	ADDA.L	D0,A3
	BRA.S	L26
L27:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	MOVE	D0,D6
	AND	#127,D0
	CMPI	#104,D0
	BEQ.S	L29
L5T356_002:
	MOVE	#-384,G189_i_Gra(A4)
	MOVE	#0,D0
	BRA.S	L25
L29:
	CMPI	#232,D6
	BNE.S	L30
	ADDQ	#1,D5
L30:
L26:
	MOVE	D7,D0
	ADDQ	#1,D7
	CMPI	#509,D0
	BLT.S	L27
L28:
	MOVE	D5,D0
	CMP	6G628_i_La(A4),D0
	BNE.S	L31
	ADDQ	#1,7G629_i_Co(A4)
	MOVE	7G629_i_Co(A4),D0
	CMPI	#3,D0
	BLE.S	L32
	BRA.S	L5T356_002
L32:
L31:
	CLR	7G629_i_Co(A4)
	MOVE	D5,6G628_i_La(A4)
	MOVE	#12777,G488_i_Gra(A4)
	MOVE	#1,D0
L25:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$24:	.EQU	#0
CODE SEG "user"
F413_AA08_:/* global */
	LINK	A6,L$33
	MOVEQ	#10,D1
	MOVE.L	8(A6),A0
	MOVE.L	#1314803317,D2
	CMPI	#20217,(A0)
	BNE.S	L8T413_001
	MOVE.L	2(A0),A0
L8T413_001:
	MOVEQ	#0,D0
L8T413_002_:
	ADD	(A0)+,D1
	EOR	D1,D0
	CMP.L	(A0),D2
	BNE.S	L8T413_002_
L34:
	UNLK	A6
	RTS
L$33:	.EQU	#0
CODE SEG "start"
F464_AA07_:/* global */
	LINK	A6,L$35
	MOVEQ	#27,D0
	MOVE.L	8(A6),A1
	MOVE.L	#1314803317,D2
	MOVEQ	#0,D1
	CMPI	#20217,(A1)
	BNE.S	L9T464_001_
	MOVE.L	2(A1),A1
L9T464_001_:
	SUB	(A1)+,D0
	ADDQ	#1,D1
	ADD	D1,D0
	CMP.L	(A1),D2
	BNE.S	L9T464_001_
L36:
	UNLK	A6
	RTS
L$35:	.EQU	#0
S465_qzzz_:/* global */
L9S465Loop:
	TST	G625_i_Flo(A4)
	BNE.S	L9S465Loop
	MOVEQ	#4,D0
	OR	D0,G314_i_Sec(A4)
	MOVE.L	A2,D3
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	TRAP	#1
	MOVE.L	D0,2(A7)
	TST	1086.W
	BNE.S	L9T465_001
	MOVE	#1,1086.W
	MOVE	#259,G625_i_Flo(A4)
	MOVE	#1,G624_B_Flo(A4)
	MOVE	#-30720,A1
	MOVEQ	#248,D2
	MOVE	SR,D0
	ORI	#1792,SR
	MOVE.B	#14,(A1)
	AND.B	(A1),D2
	ORI.B	#5,D2
	MOVE.B	D2,2(A1)
	MOVE	#-31226,A1
	MOVE	#132,(A1)
	MOVEQ	#247,D1
	BSR.S	L9T465_002_
	MOVE.B	13(A7),-/./'.L
	MOVE.B	12(A7),-/../.L
	MOVE.B	11(A7),-/..-.L
	MOVE	#144,(A1)
	MOVE	#400,(A1)
	MOVE	#144,(A1)
	MOVE	#1,-2(A1)
	MOVE	#128,D1
	MOVE	D1,(A1)
	BSR.S	L9T465_002_
	MOVE	D0,SR
L9T465_001:
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.L	D3,A2
	RTS
L9T465_002_:
	BSR.S	L9T465_003_
	MOVE	D1,-2(A1)
L9T465_003_:
	MOVEQ	#46,D2
L9T465_004_:
	SUBQ	#1,D2
	BNE.S	L9T465_004_
	RTS
