BSS SEG "bss"
G369_ui_Ev:/* global */
	.WORD	#2
G370_ps_Ev:/* global */
	.WORD	#4
G371_pi_Ti:/* global */
	.WORD	#4
G372_ui_Ev:/* global */
	.WORD	#2
G373_ui_Fi:/* global */
	.WORD	#2
G374_l_Wat:/* global */
	.WORD	#4
CODE SEG "timeline"
F233_wzzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3/D7,-(A7)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G370_ps_Ev(A4)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G371_pi_Ti(A4)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L2
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L3
L4:
	CLR.B	4(A3)
L5:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#10,A3
L3:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L4
L6:
	CLR	G372_ui_Ev(A4)
	CLR	G373_ui_Fi(A4)
	JSR	F256_xxxx_(PC)
L2:
L1:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F234_xxxx_:/* global */
	LINK	A6,L$7
	MOVE.L	8(A6),A0
	MOVE.L	12(A6),A1
	MOVEQ	#1,D0
	MOVE.L	#16777215,D1
	MOVE.L	(A0)+,D2
	AND.L	D1,D2
	AND.L	(A1)+,D1
	CMP.L	D1,D2
	BLT.S	L1T234_005_
	BNE.S	L1T234_001
	CMPM	(A1)+,(A0)+
	BHI.S	L1T234_005_
	BNE.S	L1T234_001
	CMPA.L	A0,A1
	BCC.S	L1T234_005_
L1T234_001:
	MOVEQ	#0,D0
L1T234_005_:
L8:
	UNLK	A6
	RTS
L$7:	.EQU	#0
F235_bzzz_:/* global */
	LINK	A6,L$9
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	G369_ui_Ev(A4),D1
	MOVE	8(A6),D2
	MOVEQ	#0,D0
L2T235_001_:
	CMP	(A0)+,D2
	BEQ.S	L2T235_005_
	ADDQ	#1,D0
	CMP	D1,D0
	BCS.S	L2T235_001_
	MOVEQ	#0,D0
L2T235_005_:
L10:
	UNLK	A6
	RTS
L$9:	.EQU	#0
F236_pzzz_:/* global */
	LINK	A6,L$11
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D4
	CMPI	#1,D0
	BNE.S	L13
	BRA	L12(PC)
L13:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	-2(A6)
	BRA.S	L14
L15:
	MOVE	D7,D6
	SUBQ	#1,D6
	LSR	#1,D6
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L17
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	MOVE	#1,-2(A6)
	BRA.S	L14
L17:
	BRA.S	L16
L14:
	CMPI	#0,D7
	BHI.S	L15
L16:
	MOVE	-2(A6),D0
	BEQ.S	L18
	BRA	L3T236_011(PC)
L18:
	MOVE	D4,D0
	SUBQ	#1,D0
	SUBQ	#1,D0
	LSR	#1,D0
	MOVE	D0,D4
	BRA	L19(PC)
L20:
	MOVE	D7,D6
	ASL	#1,D6
	ADDQ	#1,D6
	MOVE	D6,D0
	ADDQ	#1,D0
	CMP	G372_ui_Ev(A4),D0
	BCC.S	L22
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L22
	ADDQ	#1,D6
L22:
	MOVE.L	A3,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L23
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	BRA.S	L19
L23:
	BRA.S	L21
L19:
	MOVE	D7,D0
	CMP	D4,D0
	BLS	L20(PC)
L21:
L3T236_011:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
L12:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$11:	.EQU	#-2
F237_rzzz_:/* global */
	LINK	A6,L$24
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	CLR.B	4(A0)
	MOVE	D7,D0
	CMP	G373_ui_Fi(A4),D0
	BCC.S	L26
	MOVE	D7,G373_ui_Fi(A4)
L26:
	SUBQ	#1,G372_ui_Ev(A4)
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L27
	BRA.S	L25
L27:
	MOVE	D7,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	D6,D0
	CMP	D5,D0
	BNE.S	L28
	BRA.S	L25
L28:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L25:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$24:	.EQU	#0
F238_pzzz_:/* global */
	LINK	A6,L$29
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	G372_ui_Ev(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L31
	MOVE	#45,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L31:
	CMPI	#3217,G189_i_Gra(A4)
	BNE.S	L33
	CMPI.L	#0,G418_l_Las(A4)
	BNE.S	L32
L33:
	MOVE	#0,D0
	BRA	L30(PC)
L32:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#5,D0
	BLT	L34(PC)
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#10,D0
	BGT	L34(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA	L35(PC)
L36:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#5,D0
	BLT.S	L39
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BGT.S	L39
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L40
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L40
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#6,D0
	BNE.S	L41
	MOVE.B	8(A2),D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BNE.S	L40
L41:
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L30(PC)
L40:
	BRA.S	L37
	BRA.S	L42
L39:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L43
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L43
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L43
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L44
	MOVE	#1,D0
	MOVE.B	9(A2),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A3)
L44:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L38
L43:
L42:
L37:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L35:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS	L36(PC)
L38:
	BRA	L45(PC)
L34:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#1,D0
	BNE	L46(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L47
L48:
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L51
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L51
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L52
	MOVE.B	9(A2),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L53
	MOVE	#1,D0
	MOVE.B	9(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A2)
L53:
	MOVE	D7,D0
	BRA	L30(PC)
L52:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L54
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L30(PC)
L54:
L51:
L49:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L47:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L48
L50:
	BRA.S	L55
L46:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L56
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L57
L58:
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L61
	MOVE.L	(A3),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE.L	(A2),D1
	MOVE.L	#24,D3
	ASR.L	D3,D1
	CMP	D1,D0
	BNE.S	L61
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BEQ.S	L63
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L62
L63:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L62:
L61:
L59:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L57:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L58
L60:
L56:
L55:
L45:
	LEA	(A3),A1
	MOVE	G373_ui_Fi(A4),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
L64:
	MOVE	G373_ui_Fi(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L67
	BRA.S	L66
L67:
	ADDQ	#1,G373_ui_Fi(A4)
L65:
	MOVE	G373_ui_Fi(A4),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L64
L66:
	MOVE	G372_ui_Ev(A4),D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	G372_ui_Ev(A4),D0
	ADDQ	#1,G372_ui_Ev(A4)
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
L30:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$29:	.EQU	#0
F239_xxxx_:/* global */
	LINK	A6,L$68
	MOVE	D7,-(A7)
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MOVE	D0,D7
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	MOVE.L	8(A6),A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L69:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$68:	.EQU	#0
F240_xxxx_:/* global */
	LINK	A6,L$70
	MOVE	G372_ui_Ev(A4),D0
	BEQ.S	L73
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	AND.L	#16777215,D0
	MOVE.L	G313_ul_Ga(A4),D1
	CMP.L	D1,D0
	SLE	D0
	TST.B	D0
L73:
	SNE	D0
	TST.B	D0
	BEQ.S	L72
	CMPI	#2,G330_i_Sto(A4)
	SLT	D0
	TST.B	D0
L72:
	AND	#1,D0
L71:
	UNLK	A6
	RTS
L$70:	.EQU	#0
F241_xxxx_:/* global */
	LINK	A6,L$74
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D4
	CMPI	#5,D0
	BNE.S	L76
	BRA	L75(PC)
L76:
	ADDQ.L	#1,(A3)
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#1,D5
	BNE	L77(PC)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#32,D0
	LSR	#5,D0
	MOVE	D0,-10(A6)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE	L78(PC)
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L78
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L78
	CMPI	#0,D4
	BEQ.S	L78
	CMPI	#0,G305_ui_Pa(A4)
	BLS.S	L79
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#0,D0
	MOVE.B	D0,(A2)
	MOVE	#2,-(A7)
	MOVE	#8,D0
	OR	-10(A6),D0
	BEQ.S	L81
	MOVE	#4,D0
	BRA.S	L82
L81:
	MOVE	#3,D0
L82:
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L80
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#18,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L80:
L79:
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L75(PC)
L78:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-6(A6)
	CMPI	#-2,D0
	BEQ	L83(PC)
	MOVE	-6(A6),-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-8(A6)
	AND	#64,D0
	BNE	L83(PC)
	MOVE	D4,D0
	MOVE	-10(A6),D1
	BEQ.S	L85
	MOVE	-8(A6),D1
	LSR	#7,D1
	AND	#3,D1
	BRA.S	L86
L85:
	MOVE	#1,D1
L86:
	CMP	D1,D0
	BCS.S	L84
	MOVE	#1,-(A7)
	MOVE	#5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	CMPI	#2,D0
	BEQ.S	L87
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L87:
	CMPI	#0,D4
	BNE.S	L88
	MOVE	#0,D0
	BRA.S	L89
L88:
	MOVE	D4,D0
	SUBQ	#1,D0
L89:
	MOVE	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#4,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L75
L84:
L83:
L77:
	CMPI	#0,D5
	BNE.S	L92
	CMPI	#0,D4
	BEQ.S	L91
L92:
	CMPI	#1,D5
	BNE.S	L90
	CMPI	#4,D4
	BNE.S	L90
L91:
	BRA.S	L75
L90:
	CMPI	#0,D5
	BNE.S	L93
	MOVE	#-1,D0
	BRA.S	L94
L93:
	MOVE	#1,D0
L94:
	ADD	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#2,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	CMPI	#0,D5
	BNE.S	L95
	CMPI	#0,D4
	BNE.S	L96
	BRA.S	L75
L96:
	BRA.S	L97
L95:
	CMPI	#4,D4
	BNE.S	L98
	BRA.S	L75
L98:
L97:
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L75:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$74:	.EQU	#-10
F242_xxxx_:/* global */
	LINK	A6,L$99
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#2,D5
	BNE.S	L101
	MOVE.B	(A2),D5
	AND	#255,D5
	AND	#4,D5
	BEQ.S	L102
	MOVE	#1,D5
	BRA.S	L103
L102:
	MOVE	#0,D5
L103:
L101:
	CMPI	#1,D5
	BNE.S	L104
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L105
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L105
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L105
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L106
L105:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L107
	MOVE	D4,-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#64,D0
	BNE.S	L107
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L108
L107:
	ANDI.B	#-5,(A2)
L108:
L106:
	BRA.S	L109
L104:
	ORI.B	#4,(A2)
L109:
L100:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$99:	.EQU	#0
F243_xxxx_:/* global */
	LINK	A6,L$110
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#5,D0
	MOVE.B	D0,(A2)
L111:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$110:	.EQU	#0
F244_xxxx_:/* global */
	LINK	A6,L$112
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D7
	CMPI	#5,D0
	BNE.S	L114
	BRA.S	L113
L114:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L115
	CMPI	#0,D7
	BNE.S	L116
	MOVE	#1,D0
	BRA.S	L117
L116:
	MOVE	#0,D0
L117:
	MOVE.B	D0,9(A3)
	BRA.S	L118
L115:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L119
	CMPI	#0,D7
	BNE.S	L120
	BRA.S	L113
L120:
	BRA.S	L121
L119:
	CMPI	#4,D7
	BNE.S	L122
	BRA.S	L113
L122:
L121:
L118:
	MOVE.B	#1,4(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L113:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$112:	.EQU	#0
F245_xxxx_:/* global */
	LINK	A6,L$123
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L125(PC)
L126:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D7
	CMPI	#2,D0
	BNE	L129(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D6
	AND	#1,D6
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L130
	MOVE	D6,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L131
L130:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L131:
	MOVE	D6,D0
	BNE.S	L132
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	BEQ.S	L132
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L132
	MOVE	-6(A6),D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L132
	MOVE	-8(A6),D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L132
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	PEA	G353_ac_St(A4)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L132:
	BRA	L133(PC)
L129:
	CMPI	#3,D7
	BNE	L134(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#6,D0
	BNE	L135(PC)
	MOVE	4(A2),D5
	AND	#1920,D5
	LSR	#7,D5
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L136
	JSR	F027_AA59_(PC)
	MOVE	D5,D1
	AND	#7,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D5
	BRA.S	L137
L136:
	SUBQ	#1,D5
L137:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BNE.S	L138
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-10(A6)
L138:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	2(A2),D0
	LSR	#7,D0
	MOVE	D0,-(A7)
	JSR	F185_auzz_(PC)
	ADDA	#12,A7
	MOVE	4(A2),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L139
	MOVE	#1,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L139:
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L140
	ANDI	#-128,2(A2)
	BRA.S	L141
L140:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#4,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BEQ.S	L142
	ANDI	#-128,2(A2)
	CMPI	#127,-10(A6)
	BLS.S	L143
	MOVE	-10(A6),D0
	SUB	#126,D0
	ASL	#6,D0
	MOVE	D0,-10(A6)
L143:
	MOVE.B	#65,-16(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	CLR.B	-15(A6)
	MOVE	-6(A6),D0
	MOVE.B	D0,-14(A6)
	MOVE	-8(A6),D0
	MOVE.B	D0,-13(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L142:
L141:
L135:
L134:
L133:
L127:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L125:
	CMPI	#-2,D4
	BNE	L126(PC)
L128:
L124:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$123:	.EQU	#-20
F246_xxxx_:/* global */
	LINK	A6,L$144
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L146
L147:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L150
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#0,D0
	BNE.S	L151
	ORI	#6,2(A2)
	BRA.S	L145
L151:
L150:
L148:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L146:
	CMPI	#-1,D7
	BNE.S	L147
L149:
L145:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$144:	.EQU	#0
F247_xxxx_:/* global */
	LINK	A6,L$152
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	MOVE.B	8(A2),D5
	AND	#255,D5
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-6(A6)
	MOVE	2(A3),D4
	AND	#127,D4
	MOVE	2(A3),D0
	LSR	#7,D0
	MOVE	D0,-8(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-12(A6)
	CMPI	#7,D4
	SEQ	D0
	TST.B	D0
	BNE.S	L155
	CMPI	#8,D4
	SEQ	D0
	TST.B	D0
L155:
	TST.B	D0
	BNE.S	L154
	CMPI	#14,D4
	SEQ	D0
	TST.B	D0
L154:
	AND	#1,D0
	MOVE	D0,-14(A6)
	CMPI	#8,D4
	BEQ.S	L157
	CMPI	#10,D4
	BNE.S	L156
L157:
	MOVE	-8(A6),D7
	ADD	#-128,D7
	MOVE	D7,D6
	BRA	L158(PC)
L156:
	CMPI	#14,D4
	BEQ.S	L160
	CMPI	#15,D4
	BNE	L159(PC)
L160:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L161
L162:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L165
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L166
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L165
L166:
	BRA.S	L164
L165:
L163:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L161:
	CMPI	#-1,D7
	BNE.S	L162
L164:
	CMPI	#-1,D7
	BNE.S	L167
	BRA	L153(PC)
L167:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-14(A6),D0
	BNE.S	L168
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA.S	L169
L170:
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L173
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L174
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L173
L174:
	BRA.S	L172
L173:
L171:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L169:
	CMPI	#-1,D6
	BNE.S	L170
L172:
	CMPI	#-1,D6
	BNE.S	L175
	MOVE	#1,-14(A6)
	BRA.S	L176
L175:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L176:
L168:
	BRA.S	L177
L159:
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L178
	BRA	L153(PC)
L178:
	MOVE	-14(A6),D0
	BNE.S	L179
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L179
	MOVE	#1,-14(A6)
L179:
L177:
L158:
	MOVE	-14(A6),D0
	BEQ.S	L180
	JSR	F028_a000_(PC)
	MOVE	D0,-26(A6)
	MOVE	-6(A6),D0
	ADD	-26(A6),D0
	AND	#3,D0
	MOVE	D0,-6(A6)
L180:
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	#1,G365_B_Cre(A4)
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	-14(A6),D0
	BNE.S	L181
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L181:
	CLR	G365_B_Cre(A4)
L153:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$152:	.EQU	#-26
F248_xxxx_:/* global */
	LINK	A6,L$182
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE.B	8(A3),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	BRA	L184(PC)
L185:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#2,D0
	BNE	L187(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L187
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L188
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L189
L188:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L189:
	BRA	L190(PC)
L187:
	CMPI	#3,D6
	BNE	L191(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D0,-6(A6)
	MOVE	2(A2),D4
	LSR	#7,D4
	CMPI	#6,-6(A6)
	BNE	L192(PC)
	CMPI	#0,D4
	BLS	L193(PC)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L194
	CMPI	#511,D4
	BCC.S	L195
	ADDQ	#1,D4
L195:
	BRA.S	L196
L194:
	SUBQ	#1,D4
L196:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L197
	CMPI	#0,D4
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L198
	MOVE	#0,D0
	BRA.S	L199
L198:
	MOVE	#1,D0
L199:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L200
L197:
	CMPI	#0,D4
	BNE.S	L201
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L201:
L200:
L193:
	BRA	L202(PC)
L192:
	CMPI	#5,-6(A6)
	BNE	L203(PC)
	MOVE	#1,D5
	MOVE.B	8(A3),D3
	ASL	D3,D5
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L204
	MOVE	D4,D0
	AND	D5,D0
	BEQ.S	L205
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L206
L205:
	OR	D5,D4
L206:
	BRA.S	L207
L204:
	MOVE.B	9(A3),D0
	BEQ.S	L208
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L209
L208:
	OR	D5,D4
L209:
L207:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	D4,D5
	AND	#15,D5
	MOVE	D4,D1
	AND	#240,D1
	LSR	#4,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L210
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L211
	MOVE	#0,D0
	BRA.S	L212
L211:
	MOVE	#1,D0
L212:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L213
L210:
	MOVE	D5,D0
	BEQ.S	L214
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L214:
L213:
	BRA.S	L215
L203:
	CMPI	#7,-6(A6)
	BCS.S	L218
	CMPI	#10,-6(A6)
	BLS.S	L217
L218:
	CMPI	#14,-6(A6)
	BEQ.S	L217
	CMPI	#15,-6(A6)
	BNE.S	L216
L217:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L216
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F247_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L219
	ANDI	#-128,2(A2)
L219:
	BRA.S	L220
L216:
	CMPI	#18,-6(A6)
	BNE.S	L221
	CLR	G524_B_Res(A4)
	MOVE	#1,G302_B_Gam(A4)
	MOVE	#1,-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L221:
L220:
L215:
L202:
L191:
L190:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L184:
	CMPI	#-2,D7
	BNE	L185(PC)
L186:
	JSR	F271_xxxx_(PC)
L183:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$182:	.EQU	#-12
F249_xxxx_:/* global */
	LINK	A6,L$222
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L224
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L224
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L224
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	JSR	F296_aizz_(PC)
L224:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L225
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L225:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	MOVE	D4,-2(A6)
	CLR	-4(A6)
	BRA.S	L226
L227:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#4,D0
	BLS.S	L229
	ADDQ	#1,-4(A6)
L229:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L226:
	CMPI	#-2,D4
	BNE.S	L227
L228:
	MOVE	-2(A6),D4
	BRA	L230(PC)
L231:
	SUBQ	#1,-4(A6)
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	D4,D5
	AND	#15360,D5
	LSR	#2,D5
	LSR	#8,D5
	CMPI	#4,D5
	BLS.S	L233
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L233:
	CMPI	#14,D5
	BNE	L234(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	6(A3),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	G397_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,8(A2)
	OR	D3,8(A2)
	MOVE	G398_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,8(A2)
	OR	D3,8(A2)
	MOVE	G400_i_Mov(A4),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-3073,8(A2)
	OR	D3,8(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,6(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	BRA	L235(PC)
L234:
	CMPI	#15,D5
	BNE.S	L236
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L237
L238:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#25,D0
	BNE.S	L241
	MOVE	8(A2),D0
	CMP	D4,D0
	BNE.S	L241
	MOVE	G397_i_Mov(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G398_i_Mov(A4),D0
	MOVE.B	D0,7(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,8(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
L241:
L239:
	MOVE.L	A2,D0
	ADDA	#10,A2
	MOVE	D5,D0
	ADDQ	#1,D5
L237:
	MOVE	D5,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L238
L240:
L236:
L235:
	MOVE	-2(A6),D4
L230:
	CMPI	#-2,D4
	BEQ.S	L242
	MOVE	-4(A6),D0
	BNE	L231(PC)
L242:
L232:
L223:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$222:	.EQU	#-4
F250_xxxx_:/* global */
	LINK	A6,L$243
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L245
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L246
	MOVE	#1,D0
	BRA.S	L247
L246:
	MOVE	#0,D0
L247:
	MOVE.B	D0,9(A3)
L245:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L248
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L249
L248:
	ANDI.B	#-9,(A2)
L249:
L244:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$243:	.EQU	#0
F251_xxxx_:/* global */
	LINK	A6,L$250
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L252
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L253
	MOVE	#1,D0
	BRA.S	L254
L253:
	MOVE	#0,D0
L254:
	MOVE.B	D0,9(A3)
L252:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L255
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L256
L255:
	ANDI.B	#-9,(A2)
L256:
L251:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$250:	.EQU	#0
F252_xxxx_:/* global */
	LINK	A6,L$257
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	CLR	-2(A6)
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
L19T252_001:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L260
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L260
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L259
L260:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BNE.S	L259
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#61,D0
	BNE.S	L261
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L261:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	8(A3),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	BRA	L258(PC)
L259:
	MOVE	-2(A6),D0
	BNE.S	L262
	MOVE	#1,-2(A6)
	MOVE	8(A3),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#23,D0
	BNE.S	L263
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L263
	JSR	F029_AA19_(PC)
L264:
	CMP	#0,D0
	BEQ.S	L265
	BRA.S	L267
L265:
	SUBQ	#1,D7
	BRA.S	L266
	BRA.S	L268
L267:
	CMP	#1,D0
	BEQ.S	L268
	BRA.S	L269
L268:
	ADDQ	#1,D7
	BRA.S	L266
	BRA.S	L270
L269:
	CMP	#2,D0
	BEQ.S	L270
	BRA.S	L271
L270:
	SUBQ	#1,D6
	BRA.S	L266
	BRA.S	L272
L271:
	CMP	#3,D0
	BEQ.S	L272
	BRA.S	L273
L272:
	ADDQ	#1,D6
L273:
L274:
L266:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F223_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L275
	BRA	L19T252_001(PC)
L275:
L263:
L262:
	ADDQ.L	#5,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L258:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$257:	.EQU	#-2
F253_xxxx_:/* global */
	LINK	A6,L$276
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,44(A3)
	ANDI	#-9,48(A3)
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BEQ.S	L278
	MOVE.B	32(A3),D0
	AND	#255,D0
	LEA	G495_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	SUB	D0,64(A3)
L278:
	MOVE	52(A3),D0
	BEQ.S	L279
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#32,D0
	BNE.S	L280
	CMPI	#-1,212(A3)
	BNE.S	L280
	MOVE	#12,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L281
L20T253_002:
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L282
L281:
	CLR	D5
	BRA.S	L283
L284:
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L287
	BRA.S	L20T253_002
L287:
L285:
	ADDQ	#1,D5
L283:
	CMPI	#3,D5
	BLT.S	L284
L286:
L282:
L280:
	ORI	#-32768,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L279:
	MOVE.B	#-1,32(A3)
L277:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$276:	.EQU	#0
F254_xxxx_:/* global */
	LINK	A6,L$288
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,46(A3)
	MOVE	52(A3),D0
	BNE.S	L290
	BRA.S	L289
L290:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L291
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	BRA.S	L292
L291:
	ORI	#128,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L292:
L289:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$288:	.EQU	#0
F255_xxxx_:/* global */
	LINK	A6,L$293
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
	MOVE.B	8(A3),D5
	AND	#255,D5
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
L295:
	CMP	#2,D0
	BEQ.S	L296
	BRA.S	L298
L296:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-28,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	ADDQ.L	#5,(A3)
L22T255_002:
	SUBQ	#1,-4(A6)
	MOVE	-4(A6),D0
	MOVE.B	D0,9(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L297(PC)
	BRA.S	L299
L298:
	CMP	#1,D0
	BEQ.S	L299
	BRA	L300(PC)
L299:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L302
L303:
	MOVE	D4,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	D5,D0
	BNE.S	L306
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#10,D0
	BNE.S	L306
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#147,-2(A6)
	BNE.S	L307
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-6(A6),D0
	BNE.S	L308
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	BRA	L22T255_002(PC)
L308:
L307:
L306:
L304:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L302:
	CMPI	#-2,D4
	BNE.S	L303
L305:
	BRA.S	L297
	BRA.S	L301
L300:
	CMP	#0,D0
	BEQ.S	L301
	BRA.S	L309
L301:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F283_azzz_(PC)
	ADDQ.L	#2,A7
L309:
L310:
L297:
L294:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$293:	.EQU	#-6
F256_xxxx_:/* global */
	LINK	A6,L$311
	MOVE.B	#53,-6(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#300,D0
	MOVE.L	D0,G374_l_Wat(A4)
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L312:
	UNLK	A6
	RTS
L$311:	.EQU	#-10
F257_xxxx_:/* global */
	LINK	A6,L$313
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	6(A3),D0
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L315
	BRA.S	L314
L315:
	CMPI	#0,D6
	SLT	D5
	AND	#1,D5
	BEQ.S	L316
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
L316:
	MOVE	D6,D7
	SUBQ	#1,D7
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G039_ai_Gr(A4),A0
	ADDA	D1,A0
	SUB	(A0),D0
	MOVE	D0,D6
	MOVE	D5,D0
	BEQ.S	L317
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
	MOVE	D7,D0
	NEG	D0
	MOVE	D0,D7
L317:
	MOVE	D6,D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	D7,D0
	BEQ.S	L318
	MOVE.B	#70,-6(A6)
	MOVE	D7,-4(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#4,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	CLR.B	-5(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L318:
L314:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$313:	.EQU	#-10
F258_xxxx_:/* global */
	LINK	A6,L$319
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L321
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	BRA.S	L320
L321:
	MOVE	#0,D0
L320:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$319:	.EQU	#0
F259_xxxx_:/* global */
	LINK	A6,L$322
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L324
	BRA.S	L323
L324:
	MOVE	D6,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L325
	BRA.S	L323
L325:
	MOVE	#7,D5
	BRA.S	L326
L327:
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L330
	BRA.S	L323
L330:
L328:
	ADDQ	#1,D5
L326:
	CMPI	#9,D5
	BLS.S	L327
L329:
L323:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$322:	.EQU	#0
F260_pzzz_:/* global */
	LINK	A6,L$331
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L333
L334:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L335:
	ADDQ	#1,D7
L333:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L334
L336:
	JSR	F293_ahzz_(PC)
L332:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$331:	.EQU	#0
F261_hzzz_:/* global */
	LINK	A6,L$337
	MOVEM.L	A3/D7,-(A7)
	BRA	L339(PC)
L340:
	LEA	-10(A6),A0
	MOVE.L	A0,A3
	MOVE.L	A3,-(A7)
	JSR	F239_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	-10(A6),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	G319_ul_Lo(A4),D0
	CMP.L	G313_ul_Ga(A4),D0
	BHI.S	L342
	MOVE.B	-6(A6),D7
	AND	#255,D7
L342:
	CMPI	#28,D7
	BLS.S	L343
	CMPI	#42,D7
	BCC.S	L343
	MOVE.B	-2(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
	BRA	L344(PC)
L343:
	MOVE	D7,D0
L345:
	CMP	#48,D0
	BEQ.S	L346
L348:
	CMP	#49,D0
	BEQ.S	L346
	BRA.S	L349
L346:
	MOVE.L	A3,-(A7)
	JSR	F219_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L350
L349:
	CMP	#1,D0
	BEQ.S	L350
	BRA.S	L351
L350:
	MOVE.L	A3,-(A7)
	JSR	F241_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L352
L351:
	CMP	#25,D0
	BEQ.S	L352
	BRA.S	L353
L352:
	MOVE.L	A3,-(A7)
	JSR	F220_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L354
L353:
	CMP	#7,D0
	BEQ.S	L354
	BRA.S	L355
L354:
	MOVE.L	A3,-(A7)
	JSR	F242_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L356
L355:
	CMP	#2,D0
	BEQ.S	L356
	BRA.S	L357
L356:
	MOVE.L	A3,-(A7)
	JSR	F243_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L358
L357:
	CMP	#10,D0
	BEQ.S	L358
	BRA.S	L359
L358:
	MOVE.L	A3,-(A7)
	JSR	F244_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L360
L359:
	CMP	#9,D0
	BEQ.S	L360
	BRA.S	L361
L360:
	MOVE.L	A3,-(A7)
	JSR	F251_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L362
L361:
	CMP	#8,D0
	BEQ.S	L362
	BRA.S	L363
L362:
	MOVE.L	A3,-(A7)
	JSR	F250_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L364
L363:
	CMP	#6,D0
	BEQ.S	L364
	BRA.S	L365
L364:
	MOVE.L	A3,-(A7)
	JSR	F248_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L366
L365:
	CMP	#5,D0
	BEQ.S	L366
	BRA.S	L367
L366:
	MOVE.L	A3,-(A7)
	JSR	F245_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L368
L367:
	CMP	#60,D0
	BEQ.S	L368
L369:
	CMP	#61,D0
	BEQ.S	L368
	BRA.S	L370
L368:
	MOVE.L	A3,-(A7)
	JSR	F252_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L371
L370:
	CMP	#65,D0
	BEQ.S	L371
	BRA.S	L372
L371:
	MOVE.L	A3,-(A7)
	JSR	F246_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L373
L372:
	CMP	#20,D0
	BEQ.S	L373
	BRA.S	L374
L373:
	MOVE	#1,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L347(PC)
	BRA.S	L375
L374:
	CMP	#24,D0
	BEQ.S	L375
	BRA.S	L376
L375:
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L378
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
L378:
	BRA	L347(PC)
	BRA.S	L377
L376:
	CMP	#22,D0
	BEQ.S	L377
	BRA.S	L379
L377:
	PEA	G295_ac_Se(A4)
	JSR	F210_uzzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L381
	MOVE	#136,G022_i_Gra(A4)
L381:
	BRA	L347(PC)
	BRA.S	L380
L379:
	CMP	#11,D0
	BEQ.S	L380
	BRA.S	L382
L380:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F253_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.B	-4(A6),D0
	BEQ.S	L384
	MOVE.B	-4(A6),D0
	EXT	D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F259_xxxx_(PC)
	ADDQ.L	#4,A7
L384:
	BRA	L28T261_048(PC)
	BRA.S	L383
L382:
	CMP	#12,D0
	BEQ.S	L383
	BRA.S	L385
L383:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F254_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L347(PC)
	BRA.S	L386
L385:
	CMP	#53,D0
	BEQ.S	L386
	BRA.S	L387
L386:
	MOVE.L	A3,-(A7)
	JSR	F256_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L347(PC)
	BRA.S	L388
L387:
	CMP	#70,D0
	BEQ.S	L388
	BRA.S	L389
L388:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F257_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F337_akzz_(PC)
	BRA	L347(PC)
	BRA.S	L390
L389:
	CMP	#71,D0
	BEQ.S	L390
	BRA.S	L391
L390:
	SUBQ.B	#1,G407_s_Par+3286(A4)
	BRA	L347(PC)
	BRA.S	L392
L391:
	CMP	#72,D0
	BEQ.S	L392
	BRA.S	L393
L392:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+274(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	-4(A6),D0
	MOVE	D0,(A0)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L28T261_048:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	BRA	L347(PC)
	BRA.S	L394
L393:
	CMP	#73,D0
	BEQ.S	L394
	BRA.S	L395
L394:
	SUBQ.B	#1,G407_s_Par+3202(A4)
	BRA	L347(PC)
	BRA.S	L396
L395:
	CMP	#74,D0
	BEQ.S	L396
	BRA.S	L397
L396:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3204(A4)
L28T261_053:
	JSR	F260_pzzz_(PC)
	BRA.S	L347
	BRA.S	L398
L397:
	CMP	#77,D0
	BEQ.S	L398
	BRA.S	L399
L398:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3208(A4)
	BRA.S	L28T261_053
	BRA.S	L400
L399:
	CMP	#78,D0
	BEQ.S	L400
	BRA.S	L401
L400:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3206(A4)
	BRA.S	L28T261_053
	BRA.S	L402
L401:
	CMP	#75,D0
	BEQ.S	L402
	BRA.S	L403
L402:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	SUBQ.B	#1,(A0)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L347
	BRA.S	L404
L403:
	CMP	#13,D0
	BEQ.S	L404
	BRA.S	L405
L404:
	MOVE.L	A3,-(A7)
	JSR	F255_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L347
	BRA.S	L406
L405:
	CMP	#79,D0
	BEQ.S	L406
	BRA.S	L407
L406:
	SUBQ.B	#1,G407_s_Par+3203(A4)
L407:
L408:
L347:
L344:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L339:
	JSR	F240_xxxx_(PC)
	TST	D0
	BNE	L340(PC)
L341:
L338:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$337:	.EQU	#-10
