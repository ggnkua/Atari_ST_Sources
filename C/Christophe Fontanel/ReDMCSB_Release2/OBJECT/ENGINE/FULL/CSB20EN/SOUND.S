CODE SEG "init!"
	MOVE	#0,G578_B_Use(A4)
BSS SEG "bss"
G578_B_Use:/* global */
	.WORD	#2
G579_i_Unr:/* global */
	.WORD	#2
G580_ui_PS:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE.L	#1156,G581_pc_co(A4)
BSS SEG "bss"
G581_pc_co:/* global */
	.WORD	#4
G582_c_con:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G583_i_Pen(A4)
BSS SEG "bss"
G583_i_Pen:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#0,G584_ui_Pe(A4)
BSS SEG "bss"
G584_ui_Pe:/* global */
	.WORD	#2
G585_ac_Co:/* global */
	.WORD	#68
CODE SEG "main"
F060_AA29_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D5,-(A7)
	MOVE	12(A6),D7
	MOVE.L	8(A6),D6
	MOVE.L	D6,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE.L	#2,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,D6
	MOVE.L	8(A6),A0
	MOVE.B	(A0),D5
	AND	#255,D5
	AND	#255,D5
	ASL	#8,D5
	MOVE.L	8(A6),A0
	MOVE.B	1(A0),D1
	AND	#255,D1
	AND	#255,D1
	OR	D1,D5
	MOVE	#139,-(A7)
	CLR	-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	MOVE	#140,-(A7)
	CLR	-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	MOVE	#7,-(A7)
	CLR	-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	EXT	D0
	MOVE	D0,-2(A6)
	MOVE	#135,-(A7)
	MOVE	-2(A6),D0
	OR	#63,D0
	MOVE	D0,-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	CMPI	#10,D7
	BLE.S	L2
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-6(A6)
	LEA	/+0+.L,A0
	MOVE.B	D7,(A0)
	MOVE.L	-6(A6),-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L2:
	LEA	V061_3_aav(PC),A0
	MOVE.L	D6,(A0)
	LEA	V061_1_HHH(PC),A0
	MOVE	D5,(A0)
	LEA	V061_2_A79(PC),A0
	CLR	(A0)
	CMPI	#0,14(A6)
	BNE.S	L3
	LEA	V061_6_dzz(PC),A0
	LEA	V061_4_GFF(PC),A1
	MOVE.L	A0,(A1)
	BRA.S	L4
L3:
	LEA	V061_5_xxx(PC),A0
	LEA	V061_4_GFF(PC),A1
	MOVE.L	A0,(A1)
L4:
	MOVE	#13,-(A7)
	MOVE	#27,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#4,A7
L1:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$0:	.EQU	#-6
F061_xxxx_:/* global */
	LINK	A6,L$5
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D6
	AND	#15,D7
	ADD.B	D7,D7
	ADD.B	D7,D7
	MOVE	#-30720,A1
	LEA	V061_5_xxx(PC),A0
	MOVE.L	-64(A0,D7),(A1)
	MOVE.L	0(A0,D7),(A1)
	MOVE.L	64(A0,D7),(A1)
	BRA	L1T061_017(PC)
E061_aAA6_:/* global */
	MOVEM.L	A1-D7,-(A7)
	LEA	V061_1_HHH(PC),A0
	TST	(A0)
	BEQ.S	L1T061_005
	SUBQ	#1,(A0)+
	TST	(A0)+
	BEQ.S	L1T061_002
	SUBQ	#1,-(A0)
	BRA.S	L1T061_003
L1T061_002:
	MOVE.L	(A0),D7
	ADDQ.L	#1,(A0)+
	LSR.L	#1,D7
	BCS.S	L1T061_004
	MOVE.L	D7,A1
	MOVE.B	(A1),D7
	LSR.B	#2,D7
	ANDI	#60,D7
	BEQ.S	L1T061_006
	MOVE	#-30720,A1
	MOVE.L	(A0),A0
	MOVE.L	-64(A0,D7),(A1)
	MOVE.L	0(A0,D7),(A1)
	MOVE.L	64(A0,D7),(A1)
L1T061_003:
	BCLR	#5,/+./.L
	MOVEM.L	(A7)+,D7-A1
	RTE
L1T061_004:
	MOVE.L	D7,A1
	MOVE.B	(A1),D7
	ANDI	#15,D7
	BEQ.S	L1T061_006
	ADD.B	D7,D7
	ADD.B	D7,D7
	MOVE	#-30720,A1
	MOVE.L	(A0),A0
	MOVE.L	-64(A0,D7),(A1)
	MOVE.L	0(A0,D7),(A1)
	MOVE.L	64(A0,D7),(A1)
	BCLR	#5,/+./.L
	MOVEM.L	(A7)+,D7-A1
	RTE
L1T061_005:
	BCLR	#5,/+.'.L
	BCLR	#5,/+./.L
	MOVEM.L	(A7)+,D7-A1
	RTE
L1T061_006:
	MOVE.L	D6,-(A7)
	CLR	D6
L1T061_007:
	LEA	V061_3_aav(PC),A0
	MOVE.L	(A0),D7
	ADDQ.L	#1,(A0)
	LSR.L	#1,D7
	BCS.S	L1T061_008
	MOVE.L	D7,A1
	MOVE.B	(A1),D7
	LSR.B	#4,D7
	BRA.S	L1T061_009
L1T061_008:
	MOVE.L	D7,A1
	MOVE.B	(A1),D7
L1T061_009:
	BTST	#3,D7
	BEQ.S	L1T061_010
	AND	#7,D7
	LSL	#3,D6
	ADD	D7,D6
	BRA.S	L1T061_007
L1T061_010:
	LSL	#3,D6
	AND	#7,D7
	ADD	D7,D6
	ADDQ	#2,D6
	LEA	V061_2_A79(PC),A0
	MOVE	D6,(A0)
	BCLR	#5,/+./.L
	MOVE.L	(A7)+,D6
	MOVEM.L	(A7)+,D7-A1
	RTE
V061_1_HHH:/* global */
	ORI.B	*** Immediate value expected ***,D0
V061_2_A79:/* global */
	ORI.B	*** Immediate value expected ***,D0
V061_3_aav:/* global */
	ORI.B	#0,D0
V061_4_GFF:/* global */
	ORI.B	#0,D0
	BTST	#0,D0
	BTST	#2048,D0
	BTST	#2560,D0
	BTST	#2816,D0
	BTST	#3072,D0
	BTST	#3328,D0
	BTST	#3328,D0
	BTST	#3328,D0
	BTST	#3584,D0
	BTST	#3584,D0
	BTST	#3584,D0
	BTST	#3584,D0
	BTST	#3840,D0
	BTST	#3584,D0
	BTST	#3584,D0
	BTST	#3584,D0
V061_5_xxx:/* global */
	BTST	D4,D0
	ORI.B	#2304,D0
	BTST	D2,D0
	BTST	D4,D0
	BTST	D3,D0
	BTST	D4,D0
	BTST	D4,D0
	BTST	D4,D0
	BTST	D4,D0
	BTST	D4,D0
	BTST	D2,D0
	BTST	D4,D0
	EORI.B	#2304,D0
	CMPI.B	#2304,D0
	BTST	#2304,D0
	EORI.B	#2304,D0
	CMPI.B	#2304,D0
	BTST	D6,D0
	BTST	D4,D0
	BTST	D5,D0
	BTST	D4,D0
	BTST	#2304,D0
	BTST	#2304,D0
	BTST	#2560,D0
	ORI.B	#2560,D0
	ORI.B	#2560,D0
	ORI.B	#2560,D0
	ORI.B	#2560,D0
	ORI.B	#2560,D0
	ORI.B	#2560,D0
	ADDI.B	#2560,D0
	ORI.B	#2560,D0
	ORI.B	#2560,D0
	EORI.B	#2560,D0
	EORI.B	#2560,D0
	EORI.B	#2560,D0
	ORI.B	#2560,D0
	BTST	D5,D0
	EORI.B	#3328,D0
	EORI.B	#3584,D0
	BTST	#0,D0
	BTST	#1280,D0
	BTST	#1792,D0
	BTST	#2048,D0
	BTST	#2304,D0
	BTST	#2304,D0
	BTST	#2560,D0
	BTST	#2560,D0
	BTST	#2816,D0
	BTST	#2816,D0
	BTST	#2816,D0
	BTST	#2816,D0
	BTST	#3072,D0
	BTST	#3072,D0
	BTST	#3072,D0
	BTST	#3072,D0
V061_6_dzz:/* global */
	BTST	D4,D0
	ORI.B	#2304,D0
	ORI.B	#2304,D0
	BTST	D0,D0
	BTST	D4,D0
	ANDI.B	#2304,D0
	ANDI.B	#2304,D0
	BTST	D2,D0
	BTST	D4,D0
	ANDI.B	#2304,D0
	ADDI.B	#2304,D0
	BTST	D1,D0
	BTST	D4,D0
	ADDI.B	#2304,D0
	BTST	D3,D0
	BTST	D4,D0
	BTST	#2304,D0
	SUBI.B	#2304,D0
	ADDI.B	#2304,D0
	BTST	#2304,D0
	BTST	D4,D0
	EORI.B	#0,D0
	EORI.B	#0,D0
	EORI.B	#0,D0
	EORI.B	#0,D0
	EORI.B	#0,D0
	EORI.B	#512,D0
	EORI.B	#512,D0
	EORI.B	#256,D0
	EORI.B	#256,D0
	EORI.B	#512,D0
	EORI.B	#1024,D0
	EORI.B	#1280,D0
	EORI.B	#256,D0
	EORI.B	#512,D0
	EORI.B	#0,D0
	EORI.B	#0,D0
L1T061_017:
	MOVE.L	D6,-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L6:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$5:	.EQU	#0
F062_aalz_:/* global */
	LINK	A6,L$7
	JSR	F063_aA05_(PC)
	MOVE	#139,-(A7)
	CLR	-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	MOVE	#140,-(A7)
	CLR	-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	MOVE	#7,-(A7)
	CLR	-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	AND	#255,D0
	MOVE	D0,G580_ui_PS(A4)
	MOVE	#135,-(A7)
	MOVE	G580_ui_PS(A4),D0
	OR	#63,D0
	MOVE	D0,-(A7)
	MOVE	#28,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#6,A7
	MOVE	#8,-(A7)
	JSR	F061_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#13,-(A7)
	MOVE	#26,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#4,A7
	LEA	E061_aAA6_(PC),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-(A7)
	MOVE	#112,-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	#31,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#13,-(A7)
	MOVE	#26,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#4,A7
L8:
	UNLK	A6
	RTS
L$7:	.EQU	#0
F063_aA05_:/* global */
	LINK	A6,L$9
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	G581_pc_co(A4),A0
	MOVE.B	(A0),G582_c_con(A4)
	MOVE.L	G581_pc_co(A4),A0
	ANDI.B	#254,(A0)
	MOVE.L	-4(A6),-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L10:
	UNLK	A6
	RTS
L$9:	.EQU	#-4
F064_aadz_:/* global */
	LINK	A6,L$11
BSS SEG "bss"
5G586_i_Im:
	.WORD	#2
CODE SEG "main"
	MOVEM.L	A3/D7,-(A7)
	MOVE	14(A6),D0
	BEQ.S	L13
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BEQ.S	L13
	BRA	L12(PC)
L13:
	MOVE	8(A6),D0
	ASL.L	#3,D0
	LEA	G060_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#1,14(A6)
	BLS.S	L14
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	14(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	SUBQ.L	#1,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	#20,-6(A6)
	MOVE.B	4(A3),-5(A6)
	MOVE	8(A6),-2(A6)
	MOVE	10(A6),D0
	MOVE.B	D0,-4(A6)
	MOVE	12(A6),D0
	MOVE.B	D0,-3(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L15(PC)
L14:
	MOVE	10(A6),D0
	SUB	G306_i_Par(A4),D0
	MOVE	D0,D7
	CMPI	#0,D0
	BGE.S	L16
	MOVE	D7,D0
	NEG	D0
	BRA.S	L17
L16:
	MOVE	D7,D0
L17:
	MOVE	12(A6),D1
	SUB	G307_i_Par(A4),D1
	MOVE	D1,D7
	CMPI	#0,D1
	BGE.S	L18
	MOVE	D7,D1
	NEG	D1
	BRA.S	L19
L18:
	MOVE	D7,D1
L19:
	ADD	D1,D0
	MOVE	D0,D7
	MOVE	D7,D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BGE.S	L20
	MOVE	#1,-12(A6)
	BRA.S	L21
L20:
	MOVE	D7,D0
	MOVE.B	7(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BGE.S	L22
	CLR	-12(A6)
	BRA.S	L23
L22:
	BRA	L12(PC)
L23:
L21:
	ADDQ	#1,5G586_i_Im(A4)
	MOVE	5G586_i_Im(A4),D0
	CMPI	#88,D0
	BCS.S	L24
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L24
	CLR	5G586_i_Im(A4)
	ADDQ	#3,G240_i_Gra(A4)
	ORI	#2,G644_i_Flo(A4)
	MOVE.L	G643_puc_F(A4),D0
	ADD.L	#512,D0
	MOVE.L	D0,-(A7)
	JSR	S465_qzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	G240_i_Gra(A4),D0
	ASL	#2,D0
	MOVE	D0,G058_i_Gra(A4)
	AND	D0,G329_i_Use(A4)
L24:
	MOVE	14(A6),D0
	BNE.S	L25
	MOVE	-12(A6),-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	(A3),D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
	BRA.S	L26
L25:
	CMPI	#-1,G583_i_Pen(A4)
	BEQ.S	L28
	MOVE	-12(A6),D0
	CMP	G584_ui_Pe(A4),D0
	BHI.S	L28
	MOVE	-12(A6),D0
	CMP	G584_ui_Pe(A4),D0
	BNE.S	L27
	MOVE.B	4(A3),D0
	MOVE	G583_i_Pen(A4),D1
	ASL.L	#3,D1
	LEA	G060_as_Gr+4(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BLE.S	L27
L28:
	MOVE	8(A6),G583_i_Pen(A4)
	MOVE	-12(A6),G584_ui_Pe(A4)
L27:
L26:
L15:
L12:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$11:	.EQU	#-12
F065_aanz_:/* global */
	LINK	A6,L$29
	MOVE.L	A3,-(A7)
	CMPI	#-1,G583_i_Pen(A4)
	BEQ.S	L31
	MOVE	G583_i_Pen(A4),D0
	ASL.L	#3,D0
	LEA	G060_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G584_ui_Pe(A4),-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	(A3),D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	G240_i_Gra(A4),D0
	AND	#1,D0
	BEQ.S	L32
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L32
	MOVE	G316_i_Sec(A4),D0
	AND	#4,D0
	BEQ.S	L33
	ANDI	#-5,G316_i_Sec(A4)
	ANDI	#-5,G315_i_Sec(A4)
L33:
	ADDQ	#1,G240_i_Gra(A4)
L32:
	MOVE	#-1,G583_i_Pen(A4)
	CLR	G584_ui_Pe(A4)
L31:
L30:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$29:	.EQU	#0
