BSS SEG "bss"
G630_i_Gra:/* global */
	.WORD	#2
G631_i_Gra:/* global */
	.WORD	#2
G632_ui_Gr:/* global */
	.WORD	#2
G633_l_Gra:/* global */
	.WORD	#4
G634_pui_G:/* global */
	.WORD	#4
G635_pui_G:/* global */
	.WORD	#4
G636_ppuc_:/* global */
	.WORD	#4
G637_pi_Na:/* global */
	.WORD	#4
G638_pi_De:/* global */
	.WORD	#4
G639_pi_De:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#-1,G640_i_Flo(A4)
BSS SEG "bss"
G640_i_Flo:/* global */
	.WORD	#2
G641_puc_C:/* global */
	.WORD	#4
G642_puc_G:/* global */
	.WORD	#4
G643_puc_F:/* global */
	.WORD	#4
G644_i_Flo:/* global */
	.WORD	#2
G645_puc_H:/* global */
	.WORD	#4
G646_puc_A:/* global */
	.WORD	#4
G647_l_Unr:/* global */
	.WORD	#4
G648_l_Ava:/* global */
	.WORD	#4
G649_puc_G:/* global */
	.WORD	#4
G650_puc_G:/* global */
	.WORD	#4
G651_puc_C:/* global */
	.WORD	#4
G652_puc_A:/* global */
	.WORD	#4
G653_l_Ava:/* global */
	.WORD	#4
G654_B_Gra:/* global */
	.WORD	#2
G655_ppuc_:/* global */
	.WORD	#4
G656_l_Ava:/* global */
	.WORD	#4
G657_puc_F:/* global */
	.WORD	#4
G658_puc_F:/* global */
	.WORD	#4
G659_puc_L:/* global */
	.WORD	#4
G660_puc_F:/* global */
	.WORD	#4
G661_B_Lar:/* global */
	.WORD	#2
G662_l_Las:/* global */
	.WORD	#4
CODE SEG "memory"
F467_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	#2,D6
	MOVE	G632_ui_Gr(A4),D1
	ASL	#2,D1
	ADD	D1,D6
	AND.L	#65535,D6
	CLR	D5
	BRA.S	L2
L3:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	ADD.L	D0,D6
L4:
	ADDQ	#1,D5
L2:
	MOVE	D5,D0
	CMP	D7,D0
	BCS.S	L3
L5:
	MOVE.L	D6,D0
L1:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F468_ozzz_:/* global */
	LINK	A6,L$6
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L8
	ADDQ.L	#1,D7
L8:
	CMPI	#1,12(A6)
	BNE.S	L9
	MOVE.L	G653_l_Ava(A4),D0
	CMP.L	D7,D0
	BLT.S	L9
	MOVE.L	D7,D0
	SUB.L	D0,G653_l_Ava(A4)
	MOVE.L	G652_puc_A(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G652_puc_A(A4)
	BRA.S	L10
L9:
	MOVE.L	D7,D0
	CMP.L	G648_l_Ava(A4),D0
	BLE.S	L11
	MOVE	#40,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L11:
	CMPI	#2,12(A6)
	BNE.S	L12
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	G648_l_Ava(A4),D0
	MOVE.L	D0,A3
	BRA.S	L13
L12:
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	D7,D0
	MOVE.L	D0,G646_puc_A(A4)
	MOVE.L	D0,A3
L13:
	MOVE.L	D7,D0
	SUB.L	D0,G648_l_Ava(A4)
L10:
	MOVE.L	A3,D0
L7:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$6:	.EQU	#0
F469_rzzz_:/* global */
	LINK	A6,L$14
	MOVE.L	D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L16
	ADDQ.L	#1,D7
L16:
	MOVE.L	D7,D0
	ADD.L	D0,G648_l_Ava(A4)
	MOVE.L	D7,D0
	ADD.L	D0,G646_puc_A(A4)
L15:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$14:	.EQU	#0
F470_xzzz_:/* global */
	LINK	A6,L$17
	MOVE.L	D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L19
	ADDQ.L	#1,D7
L19:
	MOVE.L	D7,D0
	ADD.L	D0,G648_l_Ava(A4)
L18:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$17:	.EQU	#0
F471_xxxx_:/* global */
	LINK	A6,L$20
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),-4(A6)
	CMPA.L	#0,A2
	BNE.S	L22
	CMPI.L	#0,-4(A6)
	BNE.S	L23
	CLR.L	G657_puc_F(A4)
	BRA.S	L24
L23:
	MOVE.L	-4(A6),G657_puc_F(A4)
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L24:
	BRA.S	L25
L22:
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	-4(A6),(A0)
	CMPI.L	#0,-4(A6)
	BEQ.S	L26
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
L26:
L25:
L21:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$20:	.EQU	#-4
F472_xxxx_:/* global */
	LINK	A6,L$27
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A2
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L29
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	#0,D0
	MOVE.L	A2,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	BRA	L30(PC)
L29:
	MOVE.L	G657_puc_F(A4),A3
	MOVE.L	A2,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	MOVE.L	D7,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L31
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	BRA.S	L32
L31:
	CLR	D6
	BRA.S	L33
L34:
	MOVE.L	D7,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L36
	MOVE.L	8(A6),D0
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	MOVE	#1,D6
	BRA.S	L35
L36:
	MOVE.L	A2,A3
L33:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	TST.L	D0
	BNE.S	L34
L35:
	MOVE	D6,D0
	BNE.S	L37
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	8(A6),(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L37:
L32:
L30:
L28:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$27:	.EQU	#-4
F473_xxxx_:/* global */
	LINK	A6,L$38
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	CLR	-4(A6)
	MOVE	12(A6),-2(A6)
	BRA.S	L40
L41:
	ADDQ	#1,-4(A6)
L40:
	MOVE	-2(A6),D0
	ASR	#1,D0
	MOVE	D0,-2(A6)
	BNE.S	L41
L42:
	MOVE	-4(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-2(A6)
	BRA	L43(PC)
L44:
	MOVE	#1,D0
	MOVE	-2(A6),D3
	ASL	D3,D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	ASL	#1,D0
	MOVE	D0,-8(A6)
	MOVE	-6(A6),D6
	BRA.S	L47
L48:
	MOVE	D6,D4
	MOVE	D4,D7
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
L51:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	CMP	12(A6),D0
	BCS.S	L54
	BRA.S	L53
L54:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	12(A6),D0
	BCC.S	L55
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L55
	ADDQ	#1,D5
L55:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L56
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L57
L56:
	BRA.S	L53
L57:
L52:
	BRA.S	L51
L53:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L49:
	ADDQ	#1,D6
L47:
	MOVE	D6,D0
	CMP	-8(A6),D0
	BLS.S	L48
L50:
L45:
	SUBQ	#1,-2(A6)
L43:
	CMPI	#0,-2(A6)
	BGE	L44(PC)
L46:
	MOVE	12(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	BRA	L58(PC)
L59:
	MOVE	-6(A6),D4
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	#0,D0
	MOVE	D0,D7
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	-6(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L62:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	MOVE	-6(A6),D1
	SUBQ	#1,D1
	CMP	D1,D0
	BLS.S	L65
	BRA.S	L64
L65:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	-6(A6),D0
	BCC.S	L66
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L66
	ADDQ	#1,D5
L66:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L67
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L68
L67:
	BRA.S	L64
L68:
L63:
	BRA.S	L62
L64:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L60:
	SUBQ	#1,-6(A6)
L58:
	CMPI	#1,-6(A6)
	BCC	L59(PC)
L61:
L39:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$38:	.EQU	#-8
F474_xxxx_:/* global */
	LINK	A6,L$69
	MOVEM.L	D7-D4,-(A7)
L72:
L71:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L72
L73:
	MOVE	8(A6),-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D7
	MOVE	8(A6),D5
	ASL.L	#1,D5
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE.L	D7,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D0,-2(A6)
	MOVE	-2(A6),D6
	EXT.L	D6
	ASL.L	#2,D6
	ASL.L	#8,D6
	BRA	L74(PC)
L75:
	MOVE	-2(A6),D0
	CMP	G640_i_Flo(A4),D0
	BNE.S	L78
	MOVE	G644_i_Flo(A4),D0
	BEQ.S	L77
L78:
	MOVE	-2(A6),G640_i_Flo(A4)
	MOVE.L	G633_l_Gra(A4),D0
	SUB.L	D6,D0
	MOVE.L	D0,-8(A6)
	CMPI.L	#1024,D0
	BLE.S	L79
	MOVE.L	#1024,-8(A6)
L79:
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE.L	D6,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	G643_puc_F(A4),-(A7)
	MOVE.L	-8(A6),D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	-8(A6),D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
	CLR	G644_i_Flo(A4)
L77:
	MOVE.L	D7,D4
	SUB.L	D6,D4
	MOVE	#1024,D0
	SUB	D4,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	-4(A6),-(A7)
	MOVE.L	10(A6),-(A7)
	MOVE.L	G643_puc_F(A4),D0
	EXT.L	D4
	ADD.L	D4,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	SUB	-4(A6),D5
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,D7
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,10(A6)
	ADDQ	#1,-2(A6)
	ADD.L	#1024,D6
L74:
	CMPI	#0,D5
	BGT	L75(PC)
L76:
L70:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$69:	.EQU	#-8
F475_ozzz_:/* global */
	LINK	A6,L$80
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),D7
	MOVE.L	A3,D0
	MOVE.L	D0,G651_puc_C(A4)
	MOVE.L	D0,G641_puc_C(A4)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,G645_puc_H(A4)
	MOVE.L	D0,G646_puc_A(A4)
	MOVE.L	D7,G648_l_Ava(A4)
	MOVE.L	16(A6),G652_puc_A(A4)
	MOVE.L	20(A6),G653_l_Ava(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1024,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G643_puc_F(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5100,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G655_ppuc_(A4)
	MOVE	#5100,-(A7)
	MOVE.L	G655_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G638_pi_De(A4)
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#730,-(A7)
	MOVE.L	G638_pi_De(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G639_pi_De(A4)
	MOVE.L	#0,D0
	MOVE.L	D0,G657_puc_F(A4)
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G659_puc_L(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	#-1,G662_l_Las(A4)
L81:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$80:	.EQU	#0
F476_mzzz_:/* global */
	LINK	A6,L$82
	MOVE.L	G646_puc_A(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	CMPI.L	#370000,D0
	SGT	D0
	AND	#1,D0
	MOVE	D0,G661_B_Lar(A4)
	BEQ.S	L84
	JSR	F461_AA08_(PC)
L84:
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	#10000,D0
	MOVE.L	D0,G642_puc_G(A4)
	MOVE	#1,G654_B_Gra(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	D0,G650_puc_G(A4)
	MOVE.L	D0,G649_puc_G(A4)
	MOVE.L	#10000,G648_l_Ava(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,G656_l_Ava(A4)
L83:
	UNLK	A6
	RTS
L$82:	.EQU	#0
F477_izzz_:/* global */
	LINK	A6,L$85
L88:
L87:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L88
L89:
	MOVE	G631_i_Gra(A4),D0
	ADDQ	#1,G631_i_Gra(A4)
	TST	D0
	BEQ.S	L90
	BRA.S	L86
L90:
DATA SEG "s!"
s!:
	DATA 41 3A 5C 47 52 41 50 48 49 43 53 2E 44 41 54 00 
CODE SEG "memory"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G630_i_Gra(A4)
	CMPI	#0,G630_i_Gra(A4)
	BGE.S	L91
	MOVE	#41,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L91:
L86:
	UNLK	A6
	RTS
L$85:	.EQU	#0
F478_gzzz_:/* global */
	LINK	A6,L$92
	SUBQ	#1,G631_i_Gra(A4)
	BEQ.S	L94
	BRA.S	L93
L94:
L96:
L95:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L96
L97:
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
L93:
	UNLK	A6
	RTS
L$92:	.EQU	#0
F479_izzz_:/* global */
	LINK	A6,L$98
	MOVEM.L	D7-D6,-(A7)
	CLR	G631_i_Gra(A4)
	JSR	F477_izzz_(PC)
	PEA	G632_ui_Gr(A4)
	MOVE.L	#2,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CMPI.L	#2,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L106
	MOVE	G632_ui_Gr(A4),D0
	ASL	#1,D0
	MOVE	D0,D6
L106:
	SNE	D0
	TST.B	D0
	BEQ.S	L105
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G634_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L105:
	TST.B	D0
	BEQ.S	L104
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G635_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L104:
	TST.B	D0
	BEQ.S	L103
	MOVE.L	G634_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L103:
	TST.B	D0
	BEQ.S	L102
	MOVE.L	G635_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L102:
	TST.B	D0
	BEQ.S	L101
	MOVE	#1,-(A7)
	MOVE	D6,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G636_ppuc_(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L101:
	TST.B	D0
	BEQ.S	L100
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G637_pi_Na(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L100:
	AND	#1,D0
	MOVE	D0,D7
	MOVE	D7,D0
	BNE.S	L107
	BRA	L108(PC)
L107:
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	G636_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE.L	G637_pi_Na(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	SUBQ	#1,D6
	MOVE	D6,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,G633_l_Gra(A4)
	MOVE	#1,-(A7)
	MOVE.L	G635_pui_G(A4),A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G343_puc_G(A4)
	CMPI.L	#0,D0
	BNE.S	L109
	BRA.S	L110
L109:
	MOVE.L	G343_puc_G(A4),-(A7)
	CLR	-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L99
L110:
L108:
	MOVE	#42,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L99:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$98:	.EQU	#0
F480_AA07_:/* global */
	LINK	A6,L$111
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CMPI	#0,8(A6)
	BLT.S	L113
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L114
	BRA	L112(PC)
L114:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L115
L113:
	ANDI	#32767,8(A6)
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L116
	BRA	L112(PC)
L116:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L115:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	NEG.L	D7
	MOVE.L	D7,D0
	ADD.L	D0,G656_l_Ava(A4)
	MOVE.L	A3,D5
	ADDQ.L	#6,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	MOVE.L	A3,D4
	ADDQ.L	#8,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#-1,D5
	BNE.S	L117
	CMPI	#-1,D4
	BNE.S	L118
	CLR.L	G658_puc_F(A4)
	CLR.L	G659_puc_L(A4)
	CLR.L	G660_puc_F(A4)
	BRA.S	L119
L118:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),G658_puc_F(A4)
	MOVE.L	G658_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L120
	MOVE.L	G658_puc_F(A4),G660_puc_F(A4)
L120:
L119:
	BRA.S	L121
L117:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D4,(A0)
	CMPI	#-1,D4
	BNE.S	L122
	MOVE.L	A2,G659_puc_L(A4)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L123
	CLR.L	G660_puc_F(A4)
L123:
	BRA.S	L124
L122:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L125
	MOVE.L	A2,G660_puc_F(A4)
L125:
L124:
L121:
	MOVE.L	A3,D0
	CMP.L	G641_puc_C(A4),D0
	BEQ.S	L126
	MOVE.L	A3,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L126
	SUBA.L	D6,A3
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L126:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	CMP.L	G651_puc_C(A4),D0
	BNE.S	L127
	MOVE.L	A3,G651_puc_C(A4)
	BRA.S	L112
L127:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L128
	MOVE.L	A2,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L128:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
L112:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$111:	.EQU	#0
F481_xxxx_:/* global */
	LINK	A6,L$129
	BRA.S	L131
L132:
	CMPI.L	#0,G658_puc_F(A4)
	BNE.S	L134
	MOVE	#43,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L134:
	MOVE.L	G658_puc_F(A4),D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	(A0),-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L131:
	MOVE.L	G656_l_Ava(A4),D0
	CMP.L	8(A6),D0
	BLT.S	L132
L133:
L130:
	UNLK	A6
	RTS
L$129:	.EQU	#0
F482_xxxx_:/* global */
	LINK	A6,L$135
	MOVEM.L	A3-A2/D7-D5,-(A7)
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L137
	BRA	L136(PC)
L137:
	MOVE.L	G641_puc_C(A4),D0
	MOVE.L	D0,A2
	MOVE.L	D0,A3
L138:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D7
	CMPI.L	#0,D0
	BLE.S	L141
	ADDA.L	D7,A2
	BRA	L142(PC)
L141:
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	D0,D7
	MOVE.L	A2,D0
	CMP.L	A3,D0
	BEQ.S	L143
	MOVE.L	A2,D6
	ADD.L	#10,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	CMPI	#0,D6
	BLT.S	L144
	MOVE	D6,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L145
L144:
	MOVE	D6,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L145:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	D7,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G658_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L146
	MOVE.L	A3,G658_puc_F(A4)
L146:
	MOVE.L	G659_puc_L(A4),D0
	CMP.L	A2,D0
	BNE.S	L147
	MOVE.L	A3,G659_puc_L(A4)
L147:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L148
	MOVE.L	A3,G660_puc_F(A4)
L148:
L143:
	ADDA.L	D7,A2
	ADDA.L	D7,A3
L142:
L139:
	MOVE.L	A2,D0
	CMP.L	G651_puc_C(A4),D0
	BNE	L138(PC)
L140:
	MOVE.L	A3,G651_puc_C(A4)
	CLR.L	G657_puc_F(A4)
L136:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$135:	.EQU	#0
F483_xxxx_:/* global */
	LINK	A6,L$149
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G651_puc_C(A4),D1
	SUB.L	D1,D0
	CMP.L	D7,D0
	BLT.S	L151
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L152(PC)
L151:
	MOVE.L	G657_puc_F(A4),D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BGE.S	L153
	JSR	F482_xxxx_(PC)
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L154(PC)
L153:
	MOVE.L	G657_puc_F(A4),A3
	CLR	D6
L155:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BNE.S	L158
	MOVE	#1,D6
	BRA.S	L159
L158:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BLT.S	L161
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	CMPI.L	#0,D0
	BNE.S	L160
L161:
	MOVE.L	G657_puc_F(A4),A3
	MOVE	#1,D6
	BRA.S	L162
L160:
	MOVE.L	A2,A3
L162:
L159:
L156:
	MOVE	D6,D0
	BEQ.S	L155
L157:
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.L	(A0),D5
	SUB.L	D7,D5
	CMPI.L	#24,D5
	BLT.S	L163
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D5,D0
	MOVE.L	A2,D1
	ADD.L	D5,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L164
L163:
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
L164:
L154:
L152:
	MOVE.L	D7,D0
	SUB.L	D0,G656_l_Ava(A4)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D7,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D0
L150:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$149:	.EQU	#0
F484_gzzz_:/* global */
	LINK	A6,L$165
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-14(A6)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F473_xxxx_(PC)
	ADDQ.L	#6,A7
	CLR.L	-4(A6)
	CLR	D7
	BRA	L167(PC)
L168:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L171
L172:
	MOVE	12(A6),D0
	SUBQ	#1,12(A6)
	SUB	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L171:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,D6
	CMP	12(A6),D0
	BGE.S	L174
	MOVE	D5,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L172
L174:
L173:
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L175
	ADDQ.L	#1,D4
L175:
	MOVE.L	D4,D0
	ADD.L	D0,-4(A6)
L169:
	ADDQ	#1,D7
L167:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L168(PC)
L170:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L176
	MOVE.L	G649_puc_G(A4),D0
	SUB.L	-4(A6),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
	BRA.S	L177
L176:
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
L177:
	MOVE.L	G348_pl_Bi(A4),A0
	MOVE.L	-8(A6),32000(A0)
	MOVE.L	#19576,D0
	CMP.L	-8(A6),D0
	BLE.S	L178
	MOVE	#44,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L178:
	CLR	D7
	BRA.S	L179
L180:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L183
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L183:
L181:
	ADDQ	#1,D7
L179:
	CMPI	#730,D7
	BLT.S	L180
L182:
	MOVE	#0,D6
	MOVE	D6,D7
L184:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L187
L188:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	TST.L	D0
	BEQ.S	L190
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L191
	ADDQ.L	#1,D4
L191:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L190:
	ADDQ	#1,D6
L187:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L188
L189:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BEQ.S	L192
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L192:
L185:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L184(PC)
L186:
	BRA.S	L193
L194:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BEQ.S	L196
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L197
	ADDQ.L	#1,D4
L197:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L196:
	ADDQ	#1,D6
L193:
	MOVE	D6,D0
	CMP	G632_ui_Gr(A4),D0
	BCS.S	L194
L195:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L198
	MOVE.L	G650_puc_G(A4),D4
	MOVE.L	G649_puc_G(A4),D1
	SUB.L	-4(A6),D1
	SUB.L	D1,D4
	CMPI.L	#0,D4
	BLE.S	L199
	MOVE.L	D4,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
L199:
	JSR	F482_xxxx_(PC)
	MOVE.L	D4,D0
	SUB.L	D0,G656_l_Ava(A4)
L198:
	MOVE.L	G649_puc_G(A4),D0
	MOVE.L	D0,A2
	SUBQ.L	#2,D0
	MOVE.L	D0,A3
	BRA.S	L200
L201:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L203
	MOVE	D5,D0
	SUBQ	#2,D0
	EXT.L	D0
	ADDA.L	D0,A3
	BRA.S	L204
L203:
	MOVE.L	A3,D4
	MOVE	D5,D1
	ASL.L	#2,D1
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),D1
	SUB.L	D1,D4
	MOVE.L	D4,-24(A6)
	MOVE.L	#2,D4
	ADD.L	-24(A6),D4
	SUBA.L	D4,A2
	SUBA.L	D4,A3
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	CMP.L	A2,D0
	BEQ.S	L205
	MOVE.L	D4,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L205:
L204:
L200:
	MOVE.L	A3,D0
	CMP.L	G650_puc_G(A4),D0
	BGT.S	L201
L202:
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-12(A6)
L207:
L206:
	MOVE	G625_i_Flo(A4),D0
	BNE.S	L207
L208:
	CLR	D7
	BRA	L209(PC)
L210:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L213
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA	L214(PC)
L213:
	MOVE.L	A2,D0
	SUBQ.L	#2,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L215
	ADDQ.L	#1,D4
L215:
	SUBA.L	D4,A2
	MOVE	-14(A6),D0
	BNE.S	L216
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE	#1,-14(A6)
L216:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L217
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D5,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	-12(A6),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	BRA.S	L218
L217:
	MOVE.L	A2,-(A7)
	MOVE	D5,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L218:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L214:
L211:
	ADDQ	#1,D7
L209:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L210(PC)
L212:
	MOVE	-14(A6),D0
	BEQ.S	L219
	JSR	F478_gzzz_(PC)
L219:
	MOVE.L	A2,G650_puc_G(A4)
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L220
	MOVE.L	G650_puc_G(A4),G642_puc_G(A4)
L220:
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#7,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	PEA	G295_ac_Se(A4)
	MOVE	#8,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L166:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$165:	.EQU	#-24
F485_xxxx_:/* global */
	LINK	A6,L$221
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	G313_ul_Ga(A4),G662_l_Las(A4)
	CLR.L	G660_puc_F(A4)
	MOVE.L	G659_puc_L(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L223
	BRA.S	L222
L223:
	BRA.S	L224
L225:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR	(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L227
	BRA.S	L222
L227:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
L224:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CMPI	#0,(A0)
	BNE.S	L225
L226:
L222:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$221:	.EQU	#0
F486_xxxx_:/* global */
	LINK	A6,L$228
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	CMPI.L	#0,G660_puc_F(A4)
	BNE.S	L230
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	CMPI.L	#0,G659_puc_L(A4)
	BNE.S	L231
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	A3,G658_puc_F(A4)
	BRA.S	L232
L231:
	MOVE.L	G659_puc_L(A4),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	G659_puc_L(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L233
	MOVE	D4,D6
	ASL.L	#1,D6
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	BRA.S	L234
L233:
	MOVE	D4,D6
	AND	#32767,D6
	ASL.L	#1,D6
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
L234:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L232:
	MOVE.L	A3,G659_puc_L(A4)
	BRA	L235(PC)
L230:
	MOVE.L	G660_puc_F(A4),D6
	ADDQ.L	#6,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	MOVE.L	G660_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	CMPI	#-1,D6
	BEQ.S	L236
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	BRA.S	L237
L236:
	MOVE.L	G660_puc_F(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L238
	MOVE	D4,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L239
L238:
	MOVE	D4,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L239:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A3,G658_puc_F(A4)
L237:
L235:
	MOVE.L	A3,G660_puc_F(A4)
L229:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$228:	.EQU	#0
F487_xxxx_:/* global */
	LINK	A6,L$240
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE.L	D0,-4(A6)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#0,D0
	BNE.S	L242
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L243
	MOVE.L	A3,G660_puc_F(A4)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	MOVE.L	A3,D0
	BRA	L241(PC)
L243:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L244
	MOVE.L	A2,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L245
L244:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L245:
	MOVE	D7,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	-4(A6),D0
	BRA	L241(PC)
L242:
	MOVE	D4,D0
	ADDQ	#1,D0
	MOVE	D0,D4
	MOVE.L	A3,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A3,D0
	CMP.L	G659_puc_L(A4),D0
	BNE.S	L246
	MOVE.L	A3,D0
	BRA	L241(PC)
L246:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L247
	MOVE.L	A3,D0
	BRA	L241(PC)
L247:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L248
	MOVE.L	A2,D0
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L249
L248:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L250
	MOVE.L	A2,G660_puc_F(A4)
L250:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L249:
L251:
	MOVE.L	A2,A3
	MOVE	D5,D6
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L254
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	-4(A6),D0
	MOVE.L	D0,G659_puc_L(A4)
	BRA.S	L241
L254:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L255
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	BRA.S	L241
L255:
L252:
	MOVE	#1,D0
	BNE	L251(PC)
L253:
L241:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$240:	.EQU	#-4
F488_bzzz_:/* global */
	LINK	A6,L$256
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	10(A6),A3
	MOVE	8(A6),D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
L257:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$256:	.EQU	#0
F489_ayzz_:/* global */
	LINK	A6,L$258
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#-32768,D0
	BEQ.S	L260
	MOVE	D7,D0
	AND	#32767,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	BRA	L259(PC)
L260:
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L261
	JSR	F485_xxxx_(PC)
L261:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L262
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	ADD.L	#12,D0
	BRA	L259(PC)
L262:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	ASR	#1,D5
	MOVE.L	A2,D1
	ADDQ.L	#2,D1
	MOVE.L	D1,A0
	MULS	(A0),D5
	MOVE	D5,-10(A6)
	MOVE	#16,D5
	ADD	-10(A6),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L264:
L263:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L264
L265:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE	D6,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	ADDA.L	#12,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	A3,D0
L259:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$258:	.EQU	#-10
F490_lzzz_:/* global */
	LINK	A6,L$266
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	JSR	F477_izzz_(PC)
	MOVE	D7,D6
	AND	#-32768,D6
	AND	#32767,D7
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ	L268(PC)
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D7,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L269
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L269:
	BRA.S	L270
L268:
	MOVE	D6,D0
	BEQ.S	L271
	MOVE.L	A3,D0
	BRA.S	L272
L271:
	MOVE.L	G296_puc_B(A4),D0
L272:
	MOVE.L	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L270:
	MOVE	D6,D0
	BNE.S	L273
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE	#1,G297_B_Dra(A4)
L273:
	JSR	F478_gzzz_(PC)
L267:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$266:	.EQU	#0
F491_xzzz_:/* global */
	LINK	A6,L$274
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L276
	JSR	F485_xxxx_(PC)
L276:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L277
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D0
	BRA.S	L275
L277:
	MOVE	#16,D5
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	ADD	(A0),D5
	AND.L	#65535,D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L279:
L278:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L279
L280:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE.L	A3,D1
	ADD.L	#10,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE	#0,D0
L275:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$274:	.EQU	#0
F492_mzzz_:/* global */
	LINK	A6,L$281
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	ADD.L	#12,D0
L282:
	UNLK	A6
	RTS
L$281:	.EQU	#0
F493_hzzz_:/* global */
	LINK	A6,L$283
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
L284:
	UNLK	A6
	RTS
L$283:	.EQU	#0
F494_ozzz_:/* global */
	LINK	A6,L$285
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L286:
	UNLK	A6
	RTS
L$285:	.EQU	#0
