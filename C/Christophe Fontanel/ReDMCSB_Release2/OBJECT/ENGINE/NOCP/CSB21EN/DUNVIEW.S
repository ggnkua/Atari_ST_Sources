BSS SEG "bss"
G000_s_Gra:/* global */
	.WORD	#8
G001_s_Gra:/* global */
	.WORD	#8
G002_s_Gra:/* global */
	.WORD	#8
G003_s_Gra:/* global */
	.WORD	#8
G004_s_Gra:/* global */
	.WORD	#8
G005_s_Gra:/* global */
	.WORD	#8
G006_s_Gra:/* global */
	.WORD	#8
G007_s_Gra:/* global */
	.WORD	#8
G008_s_Gra:/* global */
	.WORD	#8
G009_s_Gra:/* global */
	.WORD	#8
G010_s_Gra:/* global */
	.WORD	#8
G011_s_Gra:/* global */
	.WORD	#8
G012_s_Gra:/* global */
	.WORD	#8
G013_s_Gra:/* global */
	.WORD	#8
G014_s_Gra:/* global */
	.WORD	#8
G015_s_Gra:/* global */
	.WORD	#8
G016_s_Gra:/* global */
	.WORD	#8
G017_auc_G:/* global */
	.WORD	#16
G018_ai_Gr:/* global */
	.WORD	#140
G019_aui_G:/* global */
	.WORD	#32
G020_aui_G:/* global */
	.WORD	#32
G021_aaui_:/* global */
	.WORD	#192
G022_i_Gra:/* global */
	.WORD	#2
G023_aac_G:/* global */
	.WORD	#32
G024_ac_Gr:/* global */
	.WORD	#4
G025_ac_Gr:/* global */
	.WORD	#8
G026_ai_Gr:/* global */
	.WORD	#14
G027_ac_Gr:/* global */
	.WORD	#4
G028_s_Gra:/* global */
	.WORD	#8
G029_auc_G:/* global */
	.WORD	#16
G030_as_Gr:/* global */
	.WORD	#276
G031_i_Gra:/* global */
	.WORD	#2
G032_s_Gra:/* global */
	.WORD	#8
G033_s_Gra:/* global */
	.WORD	#8
G034_s_Gra:/* global */
	.WORD	#8
G035_s_Gra:/* global */
	.WORD	#8
G036_s_Gra:/* global */
	.WORD	#8
G037_s_Gra:/* global */
	.WORD	#8
G038_ai_Gr:/* global */
	.WORD	#76
G039_ai_Gr:/* global */
	.WORD	#32
G040_ai_Gr:/* global */
	.WORD	#12
G041_s_Gra:/* global */
	.WORD	#8
G042_auc_G:/* global */
	.WORD	#128
G043_auc_G:/* global */
	.WORD	#128
G044_auc_G:/* global */
	.WORD	#16
G045_auc_G:/* global */
	.WORD	#16
G046_auc_G:/* global */
	.WORD	#4
G047_s_Gra:/* global */
	.WORD	#4
G048_s_Gra:/* global */
	.WORD	#8
G049_s_Gra:/* global */
	.WORD	#8
G050_auc_G:/* global */
	.WORD	#6
G051_ac_Gr:/* global */
	.WORD	#2
G052_ac_Gr:/* global */
	.WORD	#2
G053_ac_Gr:/* global */
	.WORD	#6
G054_ai_Gr:/* global */
	.WORD	#32
G055_aaaui:/* global */
	.WORD	#48
G056_aaui_:/* global */
	.WORD	#24
G057_ai_Gr:/* global */
	.WORD	#60
G058_i_Gra:/* global */
	.WORD	#2
G059_auc_G:/* global */
	.WORD	#8
G060_as_Gr:/* global */
	.WORD	#176
G061_s_Gra:/* global */
	.WORD	#8
G062_s_Gra:/* global */
	.WORD	#8
G063_s_Gra:/* global */
	.WORD	#8
G064_al_Gr:/* global */
	.WORD	#16
G065_al_Gr:/* global */
	.WORD	#16
G066_ac_Gr:/* global */
	.WORD	#2
G067_i_Gra:/* global */
	.WORD	#2
G074_puc_B:/* global */
	.WORD	#4
G075_apuc_:/* global */
	.WORD	#16
G076_B_Use:/* global */
	.WORD	#2
G077_B_DoN:/* global */
	.WORD	#2
G079_ai_St:/* global */
	.WORD	#36
G080_aai_D:/* global */
	.WORD	#12
G084_puc_B:/* global */
	.WORD	#4
G085_puc_B:/* global */
	.WORD	#4
G086_puc_B:/* global */
	.WORD	#4
G087_puc_B:/* global */
	.WORD	#4
G088_apuc_:/* global */
	.WORD	#60
G090_puc_B:/* global */
	.WORD	#4
G091_puc_B:/* global */
	.WORD	#4
G092_puc_B:/* global */
	.WORD	#4
G093_puc_B:/* global */
	.WORD	#4
G094_puc_B:/* global */
	.WORD	#4
G095_puc_B:/* global */
	.WORD	#4
G096_puc_B:/* global */
	.WORD	#4
G097_puc_B:/* global */
	.WORD	#4
G098_puc_B:/* global */
	.WORD	#4
G099_puc_B:/* global */
	.WORD	#4
G101_aai_C:/* global */
	.WORD	#64
G102_aai_C:/* global */
	.WORD	#64
G103_aai_C:/* global */
	.WORD	#68
G105_s_Gra:/* global */
	.WORD	#4
G106_s_Gra:/* global */
	.WORD	#4
G107_s_Gra:/* global */
	.WORD	#4
G108_s_Gra:/* global */
	.WORD	#4
G109_s_Gra:/* global */
	.WORD	#4
G110_s_Gra:/* global */
	.WORD	#8
G111_s_Gra:/* global */
	.WORD	#8
G112_s_Gra:/* global */
	.WORD	#8
G113_s_Gra:/* global */
	.WORD	#8
G114_s_Gra:/* global */
	.WORD	#8
G115_s_Gra:/* global */
	.WORD	#8
G116_s_Gra:/* global */
	.WORD	#8
G117_s_Gra:/* global */
	.WORD	#8
G118_s_Gra:/* global */
	.WORD	#8
G119_s_Gra:/* global */
	.WORD	#8
G120_s_Gra:/* global */
	.WORD	#8
G121_s_Gra:/* global */
	.WORD	#8
G122_s_Gra:/* global */
	.WORD	#8
G123_s_Gra:/* global */
	.WORD	#8
G124_s_Gra:/* global */
	.WORD	#8
G125_s_Gra:/* global */
	.WORD	#8
G126_s_Gra:/* global */
	.WORD	#8
G127_s_Gra:/* global */
	.WORD	#8
G128_s_Gra:/* global */
	.WORD	#8
G129_s_Gra:/* global */
	.WORD	#8
G130_s_Gra:/* global */
	.WORD	#8
G131_s_Gra:/* global */
	.WORD	#8
G132_s_Gra:/* global */
	.WORD	#8
G133_s_Gra:/* global */
	.WORD	#8
G134_s_Gra:/* global */
	.WORD	#8
G135_s_Gra:/* global */
	.WORD	#8
G136_s_Gra:/* global */
	.WORD	#8
G137_s_Gra:/* global */
	.WORD	#8
G138_s_Gra:/* global */
	.WORD	#8
G139_s_Gra:/* global */
	.WORD	#8
G140_s_Gra:/* global */
	.WORD	#8
G141_s_Gra:/* global */
	.WORD	#8
G142_s_Gra:/* global */
	.WORD	#8
G143_s_Gra:/* global */
	.WORD	#8
G144_s_Gra:/* global */
	.WORD	#8
G145_s_Gra:/* global */
	.WORD	#8
G146_s_Gra:/* global */
	.WORD	#8
G147_s_Gra:/* global */
	.WORD	#8
G148_s_Gra:/* global */
	.WORD	#8
G149_s_Gra:/* global */
	.WORD	#8
G150_s_Gra:/* global */
	.WORD	#8
G151_s_Gra:/* global */
	.WORD	#8
G152_s_Gra:/* global */
	.WORD	#8
G153_s_Gra:/* global */
	.WORD	#8
G154_s_Gra:/* global */
	.WORD	#8
G155_s_Gra:/* global */
	.WORD	#8
G156_s_Gra:/* global */
	.WORD	#8
G157_s_Gra:/* global */
	.WORD	#8
G158_s_Gra:/* global */
	.WORD	#8
G159_s_Gra:/* global */
	.WORD	#8
G160_s_Gra:/* global */
	.WORD	#8
G161_s_Gra:/* global */
	.WORD	#4
G162_s_Gra:/* global */
	.WORD	#4
G163_as_Gr:/* global */
	.WORD	#112
G164_s_Gra:/* global */
	.WORD	#8
G165_s_Gra:/* global */
	.WORD	#8
G166_s_Gra:/* global */
	.WORD	#8
G167_s_Gra:/* global */
	.WORD	#8
G168_s_Gra:/* global */
	.WORD	#8
G169_s_Gra:/* global */
	.WORD	#8
G170_s_Gra:/* global */
	.WORD	#8
G171_s_Gra:/* global */
	.WORD	#8
G172_s_Gra:/* global */
	.WORD	#8
G173_s_Gra:/* global */
	.WORD	#8
G174_s_Gra:/* global */
	.WORD	#8
G175_s_Gra:/* global */
	.WORD	#8
G176_s_Gra:/* global */
	.WORD	#8
G177_s_Gra:/* global */
	.WORD	#8
G178_s_Gra:/* global */
	.WORD	#8
G179_s_Gra:/* global */
	.WORD	#80
G180_s_Gra:/* global */
	.WORD	#80
G181_s_Gra:/* global */
	.WORD	#80
G182_s_Gra:/* global */
	.WORD	#80
G183_s_Gra:/* global */
	.WORD	#80
G184_s_Gra:/* global */
	.WORD	#80
G185_s_Gra:/* global */
	.WORD	#80
G186_s_Gra:/* global */
	.WORD	#80
G187_s_Gra:/* global */
	.WORD	#80
G188_as_Gr:/* global */
	.WORD	#96
G189_i_Gra:/* global */
	.WORD	#2
G190_auc_G:/* global */
	.WORD	#12
G191_auc_G:/* global */
	.WORD	#10
G192_auc_G:/* global */
	.WORD	#4
G193_ai_Gr:/* global */
	.WORD	#2
G194_auc_G:/* global */
	.WORD	#60
G195_auc_G:/* global */
	.WORD	#10
G196_auc_G:/* global */
	.WORD	#12
G197_auc_G:/* global */
	.WORD	#2
G198_auc_G:/* global */
	.WORD	#16
G199_auc_G:/* global */
	.WORD	#16
G200_auc_G:/* global */
	.WORD	#16
G201_auc_G:/* global */
	.WORD	#16
G202_ac_Gr:/* global */
	.WORD	#4
G203_ac_Gr:/* global */
	.WORD	#4
G204_ac_Gr:/* global */
	.WORD	#16
G205_aaauc:/* global */
	.WORD	#624
G206_aaauc:/* global */
	.WORD	#162
G207_aaauc:/* global */
	.WORD	#72
G208_aaauc:/* global */
	.WORD	#24
G209_as_Gr:/* global */
	.WORD	#510
G210_as_Gr:/* global */
	.WORD	#84
G211_as_Gr:/* global */
	.WORD	#8
G212_auc_G:/* global */
	.WORD	#16
G213_auc_G:/* global */
	.WORD	#16
G214_auc_G:/* global */
	.WORD	#16
G215_auc_G:/* global */
	.WORD	#8
G216_auc_G:/* global */
	.WORD	#6
G217_aauc_:/* global */
	.WORD	#32
G218_aaaau:/* global */
	.WORD	#300
G219_as_Gr:/* global */
	.WORD	#324
G220_as_Gr:/* global */
	.WORD	#182
G221_auc_G:/* global */
	.WORD	#16
G222_auc_G:/* global */
	.WORD	#16
G223_aac_G:/* global */
	.WORD	#24
G224_aaaau:/* global */
	.WORD	#330
G225_aai_G:/* global */
	.WORD	#60
G226_aaai_:/* global */
	.WORD	#120
G227_aai_G:/* global */
	.WORD	#42
G228_aai_G:/* global */
	.WORD	#42
G229_i_Gra:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G230_i_Cur(A4)
BSS SEG "bss"
G230_i_Cur:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G231_i_Cur(A4)
BSS SEG "bss"
G231_i_Cur:/* global */
	.WORD	#2
CODE SEG "show"
F093_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CLR	D5
	BRA.S	L2
L3:
	MOVE	D5,D0
	MOVE	D6,D1
	MULS	#14,D1
	LEA	G220_as_Gr(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D0
	LEA	(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	MOVE	D5,D2
	MULS	#32,D2
	LEA	G021_aaui_(A4),A0
	ADD.L	A0,D2
	ASL.L	#1,D1
	MOVE.L	D2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L4:
	ADDQ	#1,D5
L2:
	CMPI	#6,D5
	BLT.S	L3
L5:
	MOVE	D6,D0
	MULS	#14,D0
	LEA	G220_as_Gr+12(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	LEA	G222_auc_G(A4),A0
	ADDA	D7,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
	MOVE	D6,D0
	MULS	#14,D0
	LEA	G220_as_Gr+13(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	LEA	G221_auc_G(A4),A0
	ADDA	D7,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
L1:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F094_mzzz_:/* global */
	LINK	A6,L$6
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE	G230_i_Cur(A4),D0
	CMP	D7,D0
	BEQ.S	L8
	MOVE	D7,G230_i_Cur(A4)
	MOVE	D7,D0
	MULS	#2,D0
	ADD	#75,D0
	MOVE	D0,D7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G084_puc_B(A4),-(A7)
	MOVE	D7,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G085_puc_B(A4),-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L8:
L7:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$6:	.EQU	#0
F095_izzz_:/* global */
	LINK	A6,L$9
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	G231_i_Cur(A4),D0
	CMP	D7,D0
	BNE.S	L12
	MOVE	G523_B_Res(A4),D0
	BEQ	L11(PC)
L12:
	MOVE	D7,G231_i_Cur(A4)
	MOVE	D7,D0
	MULS	#13,D0
	ADD	#77,D0
	MOVE	D0,D7
	LEA	G088_apuc_+4(A4),A0
	MOVE.L	A0,A3
	MOVE	D7,D6
	ADD	#13,D6
	BRA.S	L13
L14:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	(A3)+,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L13:
	MOVE	D7,D0
	CMP	D6,D0
	BLT.S	L14
L15:
	MOVE.B	G171_s_Gra+5(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G171_s_Gra+4(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G088_apuc_(A4),-(A7)
	MOVE.L	G088_apuc_+8(A4),-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.B	G163_as_Gr+101(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+100(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G088_apuc_+56(A4),-(A7)
	MOVE.L	G088_apuc_+52(A4),-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
L11:
L10:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$9:	.EQU	#0
F096_qzzz_:/* global */
	LINK	A6,L$16
CODE SEG "init!"
	MOVE	#1,4G232_B_Fi(A4)
BSS SEG "bss"
4G232_B_Fi:
	.WORD	#2
CODE SEG "show"
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	4G232_B_Fi(A4),D0
	BNE.S	L18
	MOVE	G661_B_Lar(A4),D0
	SEQ	D0
	TST.B	D0
L18:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-10(A6)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D5
	AND	#15,D5
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D6
	AND	#240,D6
	LSR	#4,D6
	MOVE	-10(A6),D0
	BNE.S	L21
	MOVE	D5,D0
	MOVE	G230_i_Cur(A4),D1
	CMP	D1,D0
	SNE	D0
	TST.B	D0
L21:
	SNE	D0
	TST.B	D0
	BNE.S	L20
	MOVE	D6,D0
	CMP	G231_i_Cur(A4),D0
	SNE	D0
	TST.B	D0
L20:
	AND	#1,D0
	MOVE	D0,-22(A6)
	BEQ.S	L19
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
L19:
	CLR	-(A7)
	MOVE.L	#1126,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	MOVE	#140,-(A7)
	MOVE.L	A2,-(A7)
	PEA	G018_ai_Gr(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#70,D4
	MOVE	D5,-(A7)
	JSR	F094_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,-(A7)
	JSR	F095_izzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G661_B_Lar(A4),D0
	BEQ	L22(PC)
	CLR	-(A7)
	MOVE.L	#5112,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G074_puc_B(A4)
	MOVE	#1,G578_B_Use(A4)
	MOVE.B	G163_as_Gr+5(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+4(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+48(A4),D0
	MOVE.L	D0,G095_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#408,-(A7)
	MOVE	#10,-(A7)
	MOVE.L	G090_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	#11,-(A7)
	PEA	G161_s_Gra(A4)
	MOVE.L	G090_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE.B	G163_as_Gr+29(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+28(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+44(A4),D0
	MOVE.L	D0,G096_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#639,-(A7)
	MOVE	#10,-(A7)
	MOVE.L	G091_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-(A7)
	MOVE	#72,-(A7)
	MOVE	#72,-(A7)
	CLR	-(A7)
	MOVE	#8,-(A7)
	PEA	G162_s_Gra(A4)
	MOVE.L	G091_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE.L	#5112,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	G163_as_Gr+53(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+52(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G092_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+40(A4),D0
	MOVE.L	D0,G097_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.B	G163_as_Gr+85(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+84(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G094_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+36(A4),D0
	MOVE.L	D0,G098_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.B	G163_as_Gr+85(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+84(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G093_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+32(A4),D0
	MOVE.L	D0,G099_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
L22:
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#240,D0
	LSR	#4,D0
	BEQ.S	L24
	MOVE	G661_B_Lar(A4),D0
	BEQ.S	L23
L24:
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	#40,(A0)
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	#26,(A0)
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	#27,(A0)
L23:
	LEA	G079_ai_St+34(A4),A0
	MOVE.L	A0,-4(A6)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D6
	AND	#240,D6
	LSR	#4,D6
	MULU	#18,D6
	ADD	#90,D6
	MOVE	D6,D7
	ADD	#18,D7
	BRA.S	L25
L26:
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L28
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L28:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	-4(A6),A0
	SUBQ.L	#2,-4(A6)
	MOVE	D0,(A0)
L25:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L26
L27:
	MOVE	#556,D7
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L29
	SUBQ	#6,D7
L29:
	MOVE	#533,D6
	BRA.S	L30
L31:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L30:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L31
L32:
	CLR	D6
	BRA.S	L33
L34:
	MOVE	#360,D5
	MOVE	D6,D1
	MULS	#6,D1
	LEA	G209_as_Gr(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G209_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L37
	MOVE	D5,D0
	ADDQ	#1,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L37:
L35:
	ADDQ	#1,D6
L33:
	CMPI	#85,D6
	BLT.S	L34
L36:
	CLR	D6
	BRA.S	L38
L39:
	MOVE	#316,D5
	MOVE	D6,D1
	MULS	#6,D1
	LEA	G210_as_Gr(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G210_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#3,D0
	MOVE	D0,D7
	CMPI	#3,D0
	BEQ.S	L42
	MOVE	D5,D0
	ADDQ	#1,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	CMPI	#2,D7
	BEQ.S	L43
	MOVE	D5,D0
	ADDQ	#2,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L43:
L42:
L40:
	ADDQ	#1,D6
L38:
	CMPI	#14,D6
	BLT.S	L39
L41:
	MOVE	#348,D6
	BRA.S	L44
L45:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L44:
	CMPI	#360,D6
	BLT.S	L45
L46:
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#3840,D0
	LSR	#8,D0
	MOVE.B	D0,-6(A6)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE.B	D0,-5(A6)
	CLR	D5
	BRA.S	L47
L48:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G080_aai_D+8(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
	MOVE	#108,D6
	MOVE	D5,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULS	#3,D1
	ADD	D1,D6
	MOVE	D6,D7
	ADDQ	#3,D7
	BRA.S	L51
L52:
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L54
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L54:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	-4(A6),A0
	MOVE	D0,(A0)
	SUBQ.L	#4,-4(A6)
L51:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L52
L53:
L49:
	ADDQ	#1,D5
L47:
	CMPI	#1,D5
	BLS.S	L48
L50:
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#3,-(A7)
	PEA	G267_ai_Cu(A4)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#1,-(A7)
	PEA	G268_ai_Cu(A4)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	CLR	-18(A6)
	CLR	-20(A6)
	MOVE	#-1,G266_i_Cur(A4)
	CLR	D5
	BRA	L55(PC)
L56:
	MOVE	#121,D6
	MOVE	D5,D1
	LEA	G261_auc_C(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D7
	MULS	#2,D1
	ADD	D1,D6
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G101_aai_C(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	CLR	-16(A6)
	BRA.S	L59
L60:
	MOVE	D7,D0
	LEA	G192_auc_G(A4),A0
	ADDA	-16(A6),A0
	MOVE.B	(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L63
	MOVE	-18(A6),D0
	ADDQ	#1,-18(A6)
	ASL.L	#1,D0
	LEA	G267_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	CMPI	#2,D7
	BNE.S	L64
	MOVE	D5,G266_i_Cur(A4)
L64:
L63:
L61:
	ADDQ	#1,-16(A6)
L59:
	CMPI	#3,-16(A6)
	BLT.S	L60
L62:
	CLR	-16(A6)
	BRA.S	L65
L66:
	MOVE	D7,D0
	MOVE	-16(A6),D1
	ASL.L	#1,D1
	LEA	G193_ai_Gr(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BNE.S	L69
	MOVE	-20(A6),D0
	ADDQ	#1,-20(A6)
	ASL.L	#1,D0
	LEA	G268_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
L69:
L67:
	ADDQ	#1,-16(A6)
L65:
	CMPI	#1,-16(A6)
	BLT.S	L66
L68:
	LEA	G194_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	ASL.L	#2,D1
	LEA	G101_aai_C+2(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE	D0,(A0)
	MULS	#78,D0
	LEA	G205_aaauc(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L70
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L70:
	MOVE	#4,D7
	MOVE	D5,D1
	MULU	#4,D1
	ADD	D1,D7
	MOVE	D7,D6
	ADDQ	#4,D7
	BRA.S	L71
L72:
	MOVE	D6,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	SUB	D6,D0
	CMPI	#2,D0
	BNE.S	L74
	MOVE	#18,D0
	BRA.S	L75
L74:
	MOVE	#12,D0
L75:
	EXT.L	D0
	ADDA.L	D0,A3
L71:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L72
L73:
L57:
	ADDQ	#1,D5
L55:
	MOVE	D5,D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D1
	AND	#15,D1
	CMP	D1,D0
	BLS	L56(PC)
L58:
	CLR	D5
	BRA.S	L76
L77:
	MOVE	#247,D6
	MOVE	D5,D1
	LEA	G262_auc_C(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D7
	MULS	#6,D1
	ADD	D1,D6
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G102_aai_C(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	LEA	G195_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	ASL.L	#2,D1
	LEA	G102_aai_C+2(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE	D0,(A0)
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L80
	MOVE	D6,D7
	ADDQ	#6,D7
	BRA.S	L81
L82:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L81:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L82
L83:
L80:
L78:
	ADDQ	#1,D5
L76:
	MOVE	D5,D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D1
	AND	#3840,D1
	LSR	#8,D1
	CMP	D1,D0
	BCS.S	L77
L79:
	CLR	D5
	BRA	L84(PC)
L85:
	MOVE	#303,D6
	MOVE	D5,D1
	LEA	G263_auc_C(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D7
	ADD	D1,D6
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G103_aai_C(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L88
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L88:
	LEA	G196_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	ASL.L	#2,D1
	LEA	G103_aai_C+2(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE	D0,(A0)
	MULS	#18,D0
	LEA	G207_aaauc(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#68,D7
	MOVE	D5,D1
	MULU	#2,D1
	ADD	D1,D7
	MOVE	D7,D6
	ADDQ	#2,D7
	BRA.S	L89
L90:
	MOVE	D6,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ.L	#6,A3
L89:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L90
L91:
L86:
	ADDQ	#1,D5
L84:
	MOVE	D5,D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D1
	AND	#15,D1
	CMP	D1,D0
	BCS	L85(PC)
L87:
	MOVE	#102,D0
	MOVE	D0,D7
	MOVE	#0,D0
	MOVE	D0,D6
	BRA.S	L92
L93:
	MOVE	D6,D0
	ADD	#315,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	LEA	G197_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#24,D0
	LEA	G208_aaauc+6(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D7,D1
	ADDQ	#1,D7
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ.L	#6,A3
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D7,D1
	ADDQ	#1,D7
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L94:
	ADDQ	#1,D6
L92:
	CMPI	#1,D6
	BLT.S	L93
L95:
	MOVE	#8,-(A7)
	MOVE	#9,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#12,-(A7)
	MOVE	#10,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-8(A6)
	BRA	L96(PC)
L97:
	MOVE.L	G264_puc_C(A4),A0
	ADDA	-8(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#12,D0
	LEA	G219_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.B	11(A0),D5
	AND	#255,D5
	AND	#15,D5
	BEQ.S	L100
	MOVE	D5,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#9,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
L100:
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.B	11(A0),D5
	AND	#255,D5
	ASR	#4,D5
	AND	#15,D5
	BEQ.S	L101
	MOVE	D5,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#10,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
L101:
	MOVE	G661_B_Lar(A4),D0
	BNE	L102(PC)
	MOVE	D7,D0
	MULS	#26,D0
	LEA	G243_as_Gr+1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	BEQ.S	L103
	CMPI	#6,D5
	BHI.S	L103
	MOVE	D5,D0
	ADD	#549,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L103:
	MOVE	#446,D6
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	ADD	(A0),D6
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	MOVE	D7,D5
	MULS	#26,D5
	LEA	G243_as_Gr+4(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L104
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L104:
	MOVE	D5,D0
	AND	#16,D0
	BEQ.S	L105
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L105:
	MOVE	D5,D0
	AND	#32,D0
	BEQ.S	L106
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L106:
	MOVE	D5,D0
	AND	#3,D0
	MOVE	D0,-14(A6)
	BEQ.S	L107
L108:
	MOVE	D5,D0
	AND	#4,D0
	BNE.S	L111
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L111:
L109:
	SUBQ	#1,-14(A6)
	BNE.S	L108
L110:
L107:
L102:
L98:
	ADDQ	#1,-8(A6)
L96:
	MOVE	-8(A6),D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D1
	AND	#240,D1
	LSR	#4,D1
	CMP	D1,D0
	BCS	L97(PC)
L99:
	MOVE	-10(A6),D0
	BEQ	L112(PC)
	MOVE	G661_B_Lar(A4),D0
	BEQ	L113(PC)
	MOVE	#90,D5
	BRA.S	L114
L115:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L114:
	CMPI	#108,D5
	BCS.S	L115
L116:
	MOVE	#108,D5
	BRA.S	L117
L118:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L117:
	CMPI	#120,D5
	BCS.S	L118
L119:
	MOVE	#121,D5
	BRA.S	L120
L121:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L120:
	CMPI	#247,D5
	BCS.S	L121
L122:
	MOVE	#247,D5
	BRA.S	L123
L124:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L123:
	CMPI	#301,D5
	BCS.S	L124
L125:
	MOVE	#303,D5
	BRA.S	L126
L127:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L126:
	CMPI	#316,D5
	BCS.S	L127
L128:
	MOVE	#446,D5
	BRA.S	L129
L130:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L129:
	CMPI	#533,D5
	BCS.S	L130
L131:
L113:
	MOVE	D4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F484_gzzz_(PC)
	ADDQ.L	#6,A7
L112:
	MOVE	-22(A6),D0
	BEQ.S	L132
	JSR	F478_gzzz_(PC)
L132:
	MOVE.L	#1126,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,G297_B_Dra(A4)
	MOVE	#1,G342_B_Ref(A4)
	CLR	4G232_B_Fi(A4)
L17:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$16:	.EQU	#-22
F097_lzzz_:/* global */
	LINK	A6,L$133
	CMPI	#2,8(A6)
	BNE.S	L135
	MOVE	G322_B_Pal(A4),G323_B_Ena(A4)
	BRA.S	L136
L135:
	MOVE	8(A6),G323_B_Ena(A4)
L136:
	MOVE	#1,G324_B_Dra(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L134:
	UNLK	A6
	RTS
L$133:	.EQU	#0
F098_rzzz_:/* global */
	LINK	A6,L$137
	MOVE	#4144,-(A7)
	MOVE.L	G086_puc_B(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#3248,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G085_puc_B(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#7840,-(A7)
	MOVE.L	G087_puc_B(A4),-(A7)
	MOVE.L	G084_puc_B(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	G297_B_Dra(A4)
L138:
	UNLK	A6
	RTS
L$137:	.EQU	#0
F099_xxxx_:/* global */
	LINK	A6,L$139
	MOVE	16(A6),D0
	MULU	18(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE.L	12(A6),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L140:
	UNLK	A6
	RTS
L$139:	.EQU	#0
F100_xxxx_:/* global */
	LINK	A6,L$141
	MOVE.L	A3,-(A7)
	MOVE.L	12(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L143
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L143:
L142:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$141:	.EQU	#0
F101_xxxx_:/* global */
	LINK	A6,L$144
	MOVE.L	A3,-(A7)
	MOVE.L	12(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L146
	MOVE	#-1,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L146:
L145:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$144:	.EQU	#0
F102_xxxx_:/* global */
	LINK	A6,L$147
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L149
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L149:
L148:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$147:	.EQU	#0
F103_xxxx_:/* global */
	LINK	A6,L$150
	MOVE.L	A3,-(A7)
	MOVE.L	12(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L152
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L152:
L151:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$150:	.EQU	#0
F104_xxxx_:/* global */
	LINK	A6,L$153
	MOVE.L	A3,-(A7)
	MOVE.L	10(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L155
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L155:
L154:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$153:	.EQU	#0
F105_xxxx_:/* global */
	LINK	A6,L$156
	MOVE.L	A3,-(A7)
	MOVE.L	10(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L158
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L158:
L157:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$156:	.EQU	#0
F107_xxxx_:/* global */
	LINK	A6,L$159
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L161(PC)
	SUBQ	#1,D7
	MOVE	D7,D5
	ASL.L	#2,D5
	LEA	G101_aai_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G101_aai_C+2(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D1,D4
	MULS	#78,D1
	LEA	G205_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D7,-(A7)
	JSR	F149_aawz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
	MOVE	D7,D0
	CMP	G265_i_Cur(A4),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-10(A6)
	BEQ.S	L162
	CLR	-(A7)
	MOVE	G290_T_Dun(A4),-(A7)
	PEA	-92(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
L162:
	CMPI	#10,D6
	BLT	L163(PC)
	CMPI	#12,D6
	BNE	L164(PC)
	MOVE	-10(A6),D0
	BEQ	L165(PC)
	MOVE	#-1,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	G163_as_Gr+52(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	#28,-(A7)
	MOVE	#94,-(A7)
	PEA	G202_ac_Gr(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	LEA	-92(A6),A0
	MOVE.L	A0,A3
	MOVE	#120,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CLR	-14(A6)
L166:
	CLR	D7
	MOVE.L	A3,A2
	BRA.S	L169
L170:
	ADDQ	#1,D7
L169:
	MOVE.B	(A2)+,D0
	AND	#255,D0
	CMP	#128,D0
	BLT.S	L170
L171:
	MOVE	#112,D0
	MOVE	D7,D1
	ASL	#2,D1
	SUB	D1,D0
	MOVE.B	D0,-22(A6)
	AND	#255,D0
	ADDQ	#7,D0
	MOVE.B	D0,-21(A6)
	MOVE	-14(A6),D0
	ADDQ	#1,-14(A6)
	LEA	G203_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE.B	D0,-19(A6)
	AND	#255,D0
	SUBQ	#7,D0
	MOVE.B	D0,-20(A6)
	BRA.S	L172
L173:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	#144,-(A7)
	CLR	-(A7)
	MOVE.B	(A3)+,D0
	AND	#255,D0
	ASL	#3,D0
	MOVE	D0,-(A7)
	PEA	-22(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADDQ.B	#8,-22(A6)
	ADDQ.B	#8,-21(A6)
L172:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L173
L174:
L167:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#129,D0
	BNE	L166(PC)
L168:
	BRA	L14T107_031(PC)
L165:
	ADDQ	#1,D5
	MOVE	#4,-(A7)
	PEA	G291_aauc_+20(A4)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	-12(A6),G286_B_Fac(A4)
	MOVE	D7,D0
	CMP	G266_i_Cur(A4),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,G287_B_Fac(A4)
	CLR	G288_B_Fac(A4)
	CLR	D4
	BRA.S	L175
L176:
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G268_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	CMP	D7,D0
	BNE.S	L179
	MOVE	#1,G288_B_Fac(A4)
	BRA.S	L178
L179:
L177:
	ADDQ	#1,D4
L175:
	CMPI	#1,D4
	BLT.S	L176
L178:
L164:
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#11,D6
	BNE.S	L180
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A2
L180:
	CLR	D4
	BRA	L181(PC)
L163:
	CLR	-6(A6)
	CMPI	#6,D6
	SEQ	D0
	TST.B	D0
	BNE.S	L183
	CMPI	#1,D6
	SEQ	D0
	TST.B	D0
L183:
	AND	#1,D0
	MOVE	D0,-8(A6)
	BEQ.S	L182
	MOVE	D4,D0
	MULS	#78,D0
	LEA	G205_aaauc+66(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	BRA.S	L184
L182:
	CMPI	#5,D6
	BEQ.S	L186
	CMPI	#0,D6
	BNE.S	L185
L186:
	MOVE	D4,D0
	MULS	#78,D0
	LEA	G205_aaauc+60(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	BRA.S	L187
L185:
	ADDQ	#1,D5
	MOVE	D4,D0
	MULS	#78,D0
	LEA	G205_aaauc+72(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#7,D6
	BNE.S	L188
	MOVE	#6,-6(A6)
	BRA.S	L189
L188:
	CMPI	#9,D6
	BNE.S	L190
	MOVE	#-6,-6(A6)
L190:
L189:
L187:
L184:
	MOVE.L	A3,D4
	MOVE	-6(A6),D3
	EXT.L	D3
	ADD.L	D3,D4
	MOVE.L	D4,A0
	MOVE.B	1(A0),D4
	MOVE.L	A3,D1
	MOVE	-6(A6),D3
	EXT.L	D3
	ADD.L	D3,D1
	MOVE.L	D1,A0
	AND	#255,D4
	MOVE.B	(A0),D3
	AND	#255,D3
	SUB	D3,D4
	MOVE	#4,D0
	MOVE	D7,D1
	ASL	#2,D1
	ADD	D1,D0
	LEA	G190_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE.S	L191
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#4,D6
	BGT.S	L192
	LEA	G198_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L193
L192:
	LEA	G199_auc_G(A4),A0
	MOVE.L	A0,D0
L193:
	MOVE.L	D0,-(A7)
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L191:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	-8(A6),D0
	BEQ.S	L194
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A2
	MOVE	#15,D0
	MOVE	D4,D1
	AND	#15,D1
	SUB	D1,D0
	MOVE	D0,D4
	BRA.S	L195
L194:
	CMPI	#7,D6
	BNE.S	L196
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	SUB	D3,D0
	SUB	D0,D4
	BRA.S	L197
L196:
	CLR	D4
L197:
L195:
L181:
	MOVE	-10(A6),D0
	BEQ.S	L198
	MOVE.L	A3,-4(A6)
	LEA	-92(A6),A0
	MOVE.L	A0,A3
	CLR	D5
L199:
	BRA.S	L202
L203:
	ADDQ.L	#1,A3
L202:
	MOVE.B	(A3),D0
	AND	#255,D0
	CMP	#128,D0
	BLT.S	L203
L204:
	ADDQ	#1,D5
L200:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#129,D0
	BNE.S	L199
L201:
	MOVE.L	-4(A6),A3
	CMPI	#4,D5
	BGE.S	L205
	MOVE	#8,-(A7)
	PEA	-22(A6)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	LEA	-22(A6),A0
	MOVE.L	A0,A3
	LEA	G190_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#3,D0
	ADD	D5,D0
	LEA	G204_ac_Gr+-1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),3(A3)
L205:
L198:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	CMPI	#12,D6
	BNE.S	L206
	MOVE	G289_i_Dun(A4),D0
	SUBQ	#1,G289_i_Dun(A4)
	TST	D0
	BEQ.S	L206
	MOVE	#1,-(A7)
	MOVE	#112,-(A7)
	MOVE	#128,-(A7)
	MOVE	G289_i_Dun(A4),D0
	ASR	#3,D0
	MULS	#29,D0
	MOVE	D0,-(A7)
	MOVE	G289_i_Dun(A4),D0
	AND	#7,D0
	ASL	#5,D0
	MOVE	D0,-(A7)
	PEA	G109_s_Gra(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	#26,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L206:
L14T107_031:
	MOVE	-12(A6),D0
	BRA.S	L160
L161:
	MOVE	#0,D0
L160:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$159:	.EQU	#-92
F108_xxxx_:/* global */
	LINK	A6,L$207
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L209(PC)
	MOVE	D7,D4
	AND	#-32768,D4
	BEQ.S	L210
	MOVE	D7,D0
	AND	#32767,D0
	MOVE	D0,D7
	BNE.S	L211
	BRA	L15T108_005(PC)
L211:
L210:
	SUBQ	#1,D7
	MOVE	D7,D5
	ASL.L	#2,D5
	LEA	G102_aai_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D6,D1
	LEA	G191_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G102_aai_C+2(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	#54,D1
	LEA	G206_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#8,D6
	BEQ.S	L213
	CMPI	#5,D6
	BEQ.S	L213
	CMPI	#2,D6
	BEQ.S	L213
	CMPI	#15,D7
	BNE.S	L212
	MOVE	G076_B_Use(A4),D0
	BEQ.S	L212
	CMPI	#7,D6
	BEQ.S	L214
	CMPI	#4,D6
	BEQ.S	L214
	CMPI	#1,D6
	BNE.S	L212
L214:
L213:
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L215
L212:
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
L215:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L15T108_005:
	MOVE	D4,D0
	BEQ.S	L216
	MOVE	D6,-(A7)
	MOVE	#16,-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L216:
L209:
L208:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$207:	.EQU	#0
F109_xxxx_:/* global */
	LINK	A6,L$217
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L219(PC)
	SUBQ	#1,D7
	MOVE	D7,D5
	ASL.L	#2,D5
	LEA	G103_aai_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G103_aai_C+2(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D1,D4
	MULS	#18,D1
	LEA	G207_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#2,D6
	BNE.S	L220
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#48,D6
	BRA	L221(PC)
L220:
	MOVE	#68,D0
	MOVE	D7,D1
	MULS	#2,D1
	ADD	D1,D0
	ADD	D6,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE	L222(PC)
	MOVE	D4,D0
	MULS	#18,D0
	LEA	G207_aaauc+12(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#0,D6
	BNE.S	L223
	LEA	G200_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L224
L223:
	LEA	G201_auc_G(A4),A0
	MOVE.L	A0,D0
L224:
	MOVE.L	D0,-(A7)
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	SUB	D3,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L222:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#0,D6
	BNE.S	L225
	MOVE	#24,D6
	BRA.S	L226
L225:
	MOVE	#32,D6
L226:
L221:
	MOVE	#9,-(A7)
	MOVE	D6,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L219:
L218:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$217:	.EQU	#-4
F110_xxxx_:/* global */
	LINK	A6,L$227
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L229(PC)
	SUBQ	#1,D7
	MOVE	D7,D5
	ADD	#315,D5
	MOVE	D6,D0
	LEA	G197_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D4
	MULS	#24,D1
	LEA	G208_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#3,D6
	BNE.S	L230
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#4,-(A7)
	PEA	G291_aauc_+20(A4)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	BRA	L231(PC)
L230:
	MOVE	#102,D0
	MOVE	D7,D1
	MULS	#2,D1
	ADD	D1,D0
	MOVE	D6,D1
	BNE.S	L233
	MOVE	#0,D1
	BRA.S	L234
L233:
	MOVE	D6,D1
	SUBQ	#1,D1
L234:
	ADD	D1,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE	L232(PC)
	MOVE	D4,D0
	MULS	#24,D0
	LEA	G208_aaauc+18(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#2,D6
	BNE.S	L235
	LEA	G199_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L236
L235:
	LEA	G198_auc_G(A4),A0
	MOVE.L	A0,D0
L236:
	MOVE.L	D0,-(A7)
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	SUB	D3,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L232:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
L231:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L229:
L228:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$227:	.EQU	#-4
F111_xxxx_:/* global */
	LINK	A6,L$237
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	10(A6),D7
	MOVE.L	20(A6),A3
	CMPI	#0,D7
	BEQ	L239(PC)
	MOVE.L	G284_apuc_(A4),D0
	MOVE	8(A6),D1
	AND.L	#65535,D1
	ASL.L	#2,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
	MOVE	16(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE	2(A2),D0
	AND	#1,D0
	MOVE	D0,D6
	ASL.L	#1,D0
	MOVE.L	12(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	18(A6),-(A7)
	MOVE	2(A2),D0
	AND	#30,D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	JSR	F109_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G275_as_Cu(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#4,D0
	BEQ.S	L240
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L241
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L241:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L242
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F131_xxxx_(PC)
	ADDQ.L	#8,A7
L242:
L240:
	MOVE.L	A3,D0
	LEA	G186_s_Gra(A4),A0
	CMP.L	A0,D0
	BNE.S	L243
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ.S	L243
	MOVE	#2,-(A7)
	MOVE	#17,-(A7)
	JSR	F109_xxxx_(PC)
	ADDQ.L	#4,A7
L243:
	CMPI	#4,D7
	BNE.S	L244
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L238
L244:
	CMPI	#5,D7
	BNE.S	L245
	MOVE	18(A6),-(A7)
	MOVE	#16,-(A7)
	JSR	F109_xxxx_(PC)
	ADDQ.L	#4,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L238
L245:
	SUBQ	#1,D7
	MOVE	2(A2),D0
	AND	#32,D0
	LSR	#5,D0
	BEQ.S	L246
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	8(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L247
L246:
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	32(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	56(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
L247:
L239:
L238:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$237:	.EQU	#0
F112_xxxx_:/* global */
	LINK	A6,L$248
	MOVE	D7,-(A7)
	PEA	16(A6)
	PEA	14(A6)
	MOVE	#-1,-(A7)
	MOVE	G272_i_Cur(A4),-(A7)
	JSR	F154_afzz_(PC)
	ADDA	#12,A7
	MOVE	D0,D7
	CMPI	#0,D0
	BLT.S	L250
	MOVE	14(A6),D0
	MOVE	D7,D1
	ASL.L	#2,D1
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D1,A0
	ASL.L	#2,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	16(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	ASR	#5,D0
	CMPI	#2,D0
	BNE.S	L250
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L250
	MOVE	18(A6),D0
	BEQ.S	L251
	MOVE.L	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L252
L251:
	MOVE.L	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L252:
L250:
L249:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$248:	.EQU	#0
F113_xxxx_:/* global */
	LINK	A6,L$253
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	3(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L255
	MOVE.L	#0,A2
	BRA.S	L256
L255:
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	MOVE	#69,D0
	MOVE.B	3(A3),D1
	AND	#255,D1
	AND	#127,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.B	3(A3),D0
	AND	#255,D0
	AND	#128,D0
	BEQ.S	L257
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L257:
L256:
	CLR	-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#73,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CLR	-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	#112,-(A7)
	JSR	F027_AA59_(PC)
	AND	#31,D0
	MOVE	D0,-(A7)
	JSR	F028_a000_(PC)
	MOVE.B	1(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	MOVE.L	12(A6),-(A7)
	CLR	-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F133_xxxx_(PC)
	ADDA	#32,A7
	CLR	-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32768,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L254:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$253:	.EQU	#-4
F114_xxxx_:/* global */
	LINK	A6,L$258
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G211_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#32,10(A6)
	BLS.S	L260
	MOVE	#32,10(A6)
L260:
	MOVE.B	(A2),D6
	AND	#255,D6
	MULU	10(A6),D6
	MOVE	10(A6),D1
	LSR	#1,D1
	ADD	D1,D6
	LSR	#5,D6
	MOVE.B	1(A2),D5
	AND	#255,D5
	MULU	10(A6),D5
	MOVE	10(A6),D1
	LSR	#1,D1
	ADD	D1,D5
	LSR	#5,D5
	CMPI	#32,10(A6)
	BNE.S	L261
	CMPI	#3,D7
	BEQ.S	L261
	MOVE	D7,D0
	ADD	#348,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA	L262(PC)
L261:
	MOVE	D7,D0
	MULU	#14,D0
	MOVE	10(A6),D1
	LSR	#1,D1
	ADD	D1,D0
	ADD	#436,D0
	MOVE	D0,D4
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L263
	MOVE	D4,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L264
L263:
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	#348,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#3,D7
	BNE.S	L265
	LEA	G212_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L266
L265:
	LEA	G017_auc_G(A4),A0
	MOVE.L	A0,D0
L266:
	MOVE.L	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D4,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L264:
L262:
	MOVE.L	12(A6),A0
	MOVE	D6,(A0)
	MOVE.L	16(A6),A0
	MOVE	D5,(A0)
	MOVE.L	A3,D0
L259:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$258:	.EQU	#-4
F115_xxxx_:/* global */
	LINK	A6,L$267
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	16(A6),D6
	CMPI	#-2,D7
	BNE.S	L269
	BRA	L268(PC)
L269:
	CLR.L	-58(A6)
	MOVE	#-1,-54(A6)
	MOVE	#0,D0
	MOVE	D0,-158(A6)
	MOVE	D0,-134(A6)
	MOVE	D0,-108(A6)
	CLR	-48(A6)
	MOVE	D7,-44(A6)
	MOVE	18(A6),D0
	AND	#8,D0
	BEQ.S	L270
	MOVE	18(A6),D0
	AND	#1,D0
	ADDQ	#1,D0
	MOVE	D0,-110(A6)
	MOVE	18(A6),D0
	LSR	#4,D0
	MOVE	D0,18(A6)
	BRA.S	L271
L270:
	CLR	-110(A6)
L271:
	MOVE	18(A6),D0
	AND.L	#65535,D0
	MOVE.L	D0,-4(A6)
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-20(A6)
	MOVE	D6,-46(A6)
	MOVE	D6,D0
	ADDQ	#3,D0
	EXT.L	D0
	DIVS	#3,D0
	SWAP	D0
	MOVE	D0,-26(A6)
L272:
	MOVE	-20(A6),D0
	BEQ.S	L275
	MOVE	#4,D5
	MOVE	10(A6),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-28(A6)
	MOVE	#2,-50(A6)
	BRA.S	L276
L275:
	MOVE.L	-4(A6),D5
	AND	#15,D5
	SUBQ	#1,D5
	MOVE	D5,-136(A6)
	MOVE.L	-4(A6),D0
	LSR.L	#4,D0
	MOVE.L	D0,-4(A6)
	ADDQ	#1,-48(A6)
	MOVE	D5,D0
	ADD	10(A6),D0
	AND	#3,D0
	MOVE	D0,-28(A6)
	MOVE	-44(A6),D7
	MOVE	-46(A6),D6
	CLR	-50(A6)
L276:
	MOVE	-28(A6),D0
	AND	#1,D0
	ASL	#3,D0
	ADD	D0,-50(A6)
	CLR	-132(A6)
L277:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D4
	CMPI	#4,D0
	BNE.S	L280
	MOVE	D7,-54(A6)
	BRA	L278(PC)
L280:
	CMPI	#14,D4
	BNE.S	L281
	MOVE	#1,-134(A6)
	BRA	L278(PC)
L281:
	CMPI	#15,D4
	BNE.S	L282
	MOVE	#1,-158(A6)
	BRA	L278(PC)
L282:
	CMPI	#0,D6
	BLT	L283(PC)
	CMPI	#9,D6
	BGT	L283(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	-28(A6),D1
	CMP	D1,D0
	BNE	L283(PC)
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#6,D0
	LEA	G209_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	#360,D4
	MOVE.B	(A2),D3
	AND	#255,D3
	ADD	D3,D4
	MOVE	-20(A6),D0
	BEQ.S	L286
	MOVE.B	4(A2),D0
	AND	#255,D0
	AND	#16,D0
L286:
	SNE	D0
	TST.B	D0
	BEQ.S	L285
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
L285:
	AND	#1,D0
	MOVE	D0,-34(A6)
	BEQ.S	L284
	ADDQ	#1,D4
L284:
	MOVE	D6,D1
	MOVE.B	5(A2),D0
	AND	#255,D0
	MULS	#100,D0
	LEA	G218_aaaau(A4),A0
	ADD.L	A0,D0
	MULS	#10,D1
	ADD.L	D0,D1
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-16(A6)
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),D0
	BNE.S	L287
	BRA	L278(PC)
L287:
L22T115_015:
	MOVE.B	4(A2),D0
	AND	#255,D0
	AND	#1,D0
	BEQ.S	L289
	MOVE	-34(A6),D0
	SEQ	D0
	TST.B	D0
L289:
	SNE	D0
	TST.B	D0
	BEQ.S	L288
	CMPI	#2,-26(A6)
	SEQ	D0
	TST.B	D0
	BNE.S	L290
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L291
	CMPI	#1,D5
	SEQ	D0
	TST.B	D0
	BNE.S	L292
	CMPI	#2,D5
	SEQ	D0
	TST.B	D0
L292:
	TST.B	D0
L291:
	TST.B	D0
L290:
	TST.B	D0
L288:
	AND	#1,D0
	MOVE	D0,-36(A6)
	CLR	-30(A6)
	CMPI	#9,D6
	BEQ.S	L294
	CMPI	#6,D6
	BLT.S	L293
	CMPI	#2,D5
	BLT.S	L293
L294:
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L295
	MOVE	-132(A6),D0
	SEQ	D0
	TST.B	D0
L295:
	AND	#1,D0
	MOVE	D0,-38(A6)
	CLR	-52(A6)
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.B	2(A2),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	-36(A6),D0
	BEQ.S	L296
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A3
L296:
	BRA	L297(PC)
L293:
	CLR	-38(A6)
	MOVE	#104,D0
	MOVE.B	1(A2),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-18(A6)
	CMPI	#6,D6
	BGE.S	L299
	CMPI	#3,D6
	BLT.S	L298
	CMPI	#2,D5
	BLT.S	L298
L299:
	ADDQ	#1,-18(A6)
	MOVE	#1,-52(A6)
	MOVE.B	2(A2),D0
	AND	#255,D0
	MULS	#20,D0
	ADD	#10,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MULS	#20,D0
	ADD	#10,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	LEA	G214_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
	BRA.S	L300
L298:
	MOVE	#2,-52(A6)
	MOVE.B	2(A2),D0
	AND	#255,D0
	MULS	#16,D0
	ADDQ	#8,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MULS	#16,D0
	ADDQ	#8,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	LEA	G213_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
L300:
	MOVE	-36(A6),D0
	BEQ.S	L301
	ADDQ	#2,-18(A6)
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-30(A6)
	BRA.S	L302
L301:
	MOVE	-34(A6),D0
	BEQ.S	L303
	ADDQ	#4,-18(A6)
L303:
L302:
	MOVE	-18(A6),-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L304
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L305
L304:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE.L	-8(A6),-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	-36(A6),D0
	BEQ.S	L306
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L306:
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L305:
L297:
	MOVE.L	-16(A6),A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),-39(A6)
	MOVE	-132(A6),D0
	BNE.S	L307
	MOVE	-50(A6),D0
	ASL.L	#1,D0
	LEA	G217_aauc_(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	AND	#255,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,D4
	MOVE	-50(A6),D0
	ASL.L	#1,D0
	LEA	G217_aauc_+1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	AND	#255,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	ADD.B	D0,-39(A6)
	ADDQ	#1,-50(A6)
	MOVE	-20(A6),D0
	BEQ.S	L308
	CMPI	#14,-50(A6)
	BCS.S	L309
	MOVE	#2,-50(A6)
L309:
	BRA.S	L310
L308:
	ANDI	#15,-50(A6)
L310:
L307:
	MOVE.B	-39(A6),D0
	MOVE	-24(A6),D1
	SUBQ	#1,D1
	AND	#255,D0
	SUB	D1,D0
	MOVE.B	D0,-40(A6)
	MOVE.B	-39(A6),D0
	AND	#255,D0
	CMP	#135,D0
	BLE.S	L311
	MOVE.B	#-121,-39(A6)
L311:
	MOVE	D4,D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	MOVE	#223,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-41(A6)
	MOVE	D4,D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L312
	MOVE	-36(A6),D0
	BEQ.S	L313
	MOVE	-30(A6),D4
	BRA.S	L314
L313:
	CLR	D4
L314:
	BRA.S	L315
L312:
	MOVE	-22(A6),D0
	SUB	D4,D0
	SUBQ	#1,D0
	MOVE	D0,D4
L315:
	MOVE	-38(A6),D0
	BEQ	L316(PC)
	MOVE.L	A3,-12(A6)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G291_aauc_(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L317
	MOVE	#4,-(A7)
	MOVE.L	A3,-(A7)
	PEA	-42(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE.B	2(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,-32(A6)
	CMPI	#14,D0
	BGE.S	L318
	MOVE	-32(A6),D0
	ASR	#1,D0
	MOVE	D0,-32(A6)
	MOVE	-32(A6),D0
	SUBQ	#7,D0
	ADD.B	D0,2(A3)
	CMPI	#4,-32(A6)
	BGE.S	L319
	MOVE	-32(A6),D0
	SUBQ	#3,D0
	SUB.B	D0,3(A3)
L319:
L318:
	BRA.S	L320
L317:
	MOVE.B	-42(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,(A3)
	MOVE.B	-41(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,1(A3)
	MOVE.B	-40(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,2(A3)
	MOVE.B	-39(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,3(A3)
L320:
	MOVE.L	-12(A6),A3
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G292_aT_Pi(A4),A0
	ADDA	D0,A0
	MOVE	D7,(A0)
L316:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	-132(A6),D0
	BEQ.S	L321
	BRA	L22T115_171(PC)
L321:
L283:
L278:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE	L277(PC)
L279:
	CMPI	#4,D5
	BNE.S	L322
	BRA	L274(PC)
L322:
	CMPI	#0,D6
	BGE.S	L323
	BRA	L274(PC)
L323:
	CMPI	#1,D5
	SLE	D0
	TST.B	D0
	BNE.S	L325
	CMPI	#1,-48(A6)
	SEQ	D0
	TST.B	D0
L325:
	TST.B	D0
	BEQ.S	L324
	MOVE.L	-4(A6),D0
	SEQ	D0
	TST.B	D0
	BNE.S	L326
	MOVE.L	-4(A6),D0
	AND.L	#15,D0
	CMPI.L	#3,D0
	SCC	D0
	TST.B	D0
L326:
	TST.B	D0
L324:
	AND	#1,D0
	MOVE	D0,-96(A6)
	CMPI	#-1,-54(A6)
	BEQ.S	L328
	MOVE	-108(A6),D0
	BEQ.S	L327
L328:
	BRA	L22T115_129(PC)
L327:
	CMPI.L	#0,-58(A6)
	BNE.S	L329
	MOVE	-54(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-58(A6)
	MOVE.L	-58(A6),A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-62(A6)
	MOVE.L	-58(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-66(A6)
	MOVE.L	-66(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#12,D0
	LEA	G219_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-70(A6)
	MOVE.L	-66(A6),A0
	MOVE	2(A0),D0
	AND	#3,D0
	MOVE	D0,-72(A6)
	MOVE.L	-66(A6),A0
	MOVE	4(A0),-76(A6)
L329:
	MOVE.L	-70(A6),D0
	MOVE.L	D0,A2
	MOVE	-28(A6),-(A7)
	MOVE.L	-58(A6),-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	BEQ.S	L330
	SUBQ	#1,D7
	MOVE	D7,D0
	MOVE	D0,-82(A6)
	BRA.S	L331
L330:
	CMPI	#1,-72(A6)
	BNE.S	L332
	CLR	D7
	MOVE	#-1,-82(A6)
	BRA.S	L333
L332:
	BRA	L22T115_129(PC)
L333:
L331:
	MOVE.L	-62(A6),A0
	MOVE.B	2(A0),D0
	MOVE	D7,D1
	ASL	#1,D1
	AND	#255,D0
	ASR	D1,D0
	AND	#3,D0
	MOVE	D0,-180(A6)
	MOVE	10(A6),D0
	SUB	-180(A6),D0
	AND	#3,D0
	MOVE	D0,-74(A6)
	CLR	-94(A6)
	MOVE.L	-62(A6),A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	CMPI	#255,D0
	BNE.S	L334
	MOVE.L	-4(A6),D0
	BNE.S	L336
	CMPI	#1,-110(A6)
	BNE.S	L335
L336:
	BRA	L22T115_129(PC)
L335:
	MOVE	#1,-108(A6)
	CMPI	#1,-72(A6)
	BNE.S	L337
	MOVE	-74(A6),D0
	AND	#1,D0
	BEQ.S	L337
	MOVE	#3,D5
	BRA.S	L338
L337:
	MOVE	#4,D5
L338:
	BRA	L339(PC)
L334:
	CMPI	#1,-72(A6)
	BNE	L340(PC)
	MOVE	-96(A6),D0
	BNE.S	L341
	MOVE.L	-4(A6),D0
	BEQ.S	L341
	CMPI	#0,-82(A6)
	BGE	L340(PC)
L341:
	MOVE	-96(A6),D0
	BEQ.S	L342
	CMPI	#2,-110(A6)
	BEQ.S	L342
	CMPI	#0,-82(A6)
	BLT.S	L343
	MOVE	-74(A6),D0
	AND	#1,D0
	BEQ.S	L343
	MOVE	#2,D5
	BRA.S	L344
L343:
	BRA	L22T115_129(PC)
L344:
	BRA	L345(PC)
L342:
	CMPI	#1,-110(A6)
	BEQ.S	L346
	MOVE.L	-4(A6),D0
	BNE.S	L346
	MOVE	-74(A6),D0
	AND	#1,D0
	BEQ.S	L347
	CMPI	#0,-82(A6)
	BLT.S	L348
	MOVE	#4,D5
	BRA.S	L349
L348:
	BRA	L22T115_129(PC)
L349:
	BRA.S	L350
L347:
	MOVE	#1,-108(A6)
	CMPI	#0,-82(A6)
	BGE.S	L351
	CLR	-82(A6)
L351:
	MOVE.L	-58(A6),A0
	MOVE	14(A0),D0
	AND	#96,D0
	LSR	#5,D0
	MOVE	D0,-94(A6)
	MOVE	D4,D0
	MOVE	D7,D1
	ASL	#1,D1
	ASR	D1,D0
	AND	#3,D0
	MOVE	D0,D4
	CMP	10(A6),D0
	BEQ.S	L353
	MOVE	D4,D0
	MOVE	10(A6),D1
	SUBQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L352
L353:
	CLR	D5
	BRA.S	L354
L352:
	MOVE	#1,D5
L354:
L350:
	BRA.S	L355
L346:
	BRA	L22T115_129(PC)
L355:
L345:
	BRA.S	L356
L340:
	CMPI	#0,-72(A6)
	BEQ.S	L357
	BRA	L22T115_129(PC)
L357:
L356:
L339:
	MOVE.L	-62(A6),A0
	LEA	12(A0),A0
	ADDA	-82(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-78(A6)
	CMPI	#9,D6
	BLE.S	L358
	SUBQ	#1,D6
L358:
L22T115_077:
	MOVE	D6,D1
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	10(A0),D0
	AND	#255,D0
	ASR	#4,D0
	AND	#15,D0
	MULS	#110,D0
	LEA	G224_aaaau(A4),A0
	ADD.L	A0,D0
	MULS	#10,D1
	ADD.L	D0,D1
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-16(A6)
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),D0
	BNE.S	L359
	BRA	L22T115_126(PC)
L359:
	MOVE	-76(A6),D7
	MOVE	#446,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	ADD	(A0),D4
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),-18(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L361
	MOVE	-74(A6),D0
	AND	#1,D0
L361:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-98(A6)
	BEQ.S	L360
	MOVE	#0,D0
	MOVE	D0,-100(A6)
	MOVE	D0,-106(A6)
	MOVE	D0,-104(A6)
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	6(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE	D0,-86(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	7(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	D0,-88(A6)
	BRA	L362(PC)
L360:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L363
	CMPI	#0,-74(A6)
	SEQ	D0
	TST.B	D0
L363:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-100(A6)
	MOVE	-100(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L366
	MOVE	-78(A6),D0
	AND	#128,D0
L366:
	SNE	D0
	TST.B	D0
	BEQ.S	L365
	MOVE	D7,D0
	AND	#32,D0
L365:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-104(A6)
	BEQ.S	L364
	CLR	-106(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	8(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE	D0,-86(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	9(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	D0,-88(A6)
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L367
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
L367:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L368
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
L368:
	BRA	L369(PC)
L364:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE	D0,-86(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	D0,-88(A6)
	MOVE	-100(A6),D0
	BEQ.S	L370
	CLR	-106(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L371
	ADDQ	#2,D4
	ADDQ	#4,-18(A6)
	BRA.S	L372
L371:
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
L372:
	BRA.S	L373
L370:
	MOVE	D7,D0
	AND	#4,D0
	BEQ.S	L375
	MOVE	-78(A6),D0
	AND	#64,D0
L375:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-106(A6)
	BEQ.S	L374
	ADDQ	#2,-18(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L376
	ADDQ	#2,-18(A6)
L376:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L377
	ADDQ	#2,-18(A6)
L377:
	MOVE	D7,D0
	AND	#32,D0
	BEQ.S	L378
	ADDQ	#2,-18(A6)
L378:
L374:
L373:
L369:
L362:
	CMPI	#6,D6
	BLT	L379(PC)
	CLR	-90(A6)
	CLR	-52(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	10(A0),D0
	AND	#255,D0
	AND	#15,D0
	MOVE	D0,-84(A6)
	MOVE	-98(A6),D0
	BEQ.S	L380
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CMPI	#1,-74(A6)
	BNE.S	L381
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A3
L381:
	BRA	L382(PC)
L380:
	MOVE	-100(A6),D0
	BNE.S	L384
	MOVE	-106(A6),D0
	BNE.S	L383
L384:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	-104(A6),D0
	BEQ.S	L385
	MOVE	-78(A6),D0
	AND	#64,D0
	BEQ.S	L385
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A3
L385:
	BRA.S	L386
L383:
	MOVE	-18(A6),-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L387
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L388
L387:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE	D7,D0
	AND	#4,D0
	BEQ.S	L389
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
L389:
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L388:
L386:
L382:
	BRA	L390(PC)
L379:
	MOVE	-106(A6),D0
	BEQ.S	L391
	ADDQ	#1,-18(A6)
L391:
	CMPI	#3,D6
	BLT.S	L392
	ADDQ	#1,-18(A6)
	MOVE	#1,-52(A6)
	MOVE	D7,D0
	AND	#128,D0
	BEQ.S	L395
	MOVE	-98(A6),D0
	SEQ	D0
	TST.B	D0
L395:
	SNE	D0
	TST.B	D0
	BEQ.S	L394
	MOVE	-100(A6),D0
	SEQ	D0
	TST.B	D0
L394:
	TST.B	D0
	BEQ.S	L393
	MOVE	-104(A6),D0
	SEQ	D0
	TST.B	D0
L393:
	AND	#1,D0
	MOVE	D0,-102(A6)
	LEA	G222_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
	MOVE	#20,-112(A6)
	BRA.S	L396
L392:
	MOVE	#2,-52(A6)
	CLR	-102(A6)
	LEA	G221_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
	MOVE	#16,-112(A6)
L396:
	MOVE	-86(A6),D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE	-88(A6),D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	10(A0),D0
	AND	#255,D0
	AND	#15,D0
	MOVE.L	-8(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-84(A6)
	MOVE	-18(A6),-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-114(A6)
	BEQ.S	L397
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L398
L397:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE.L	-8(A6),-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	-88(A6),-(A7)
	MOVE	-86(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L398:
	MOVE	-98(A6),D0
	BEQ.S	L401
	CMPI	#1,-74(A6)
	BEQ.S	L400
L401:
	MOVE	-104(A6),D0
	BEQ.S	L402
	MOVE	-78(A6),D0
	AND	#64,D0
	BNE.S	L400
L402:
	MOVE	-102(A6),D0
	BEQ.S	L403
	MOVE	D7,D0
	AND	#256,D0
	BNE.S	L400
L403:
	MOVE	-106(A6),D0
	BEQ.S	L399
	MOVE	D7,D0
	AND	#4,D0
	BEQ.S	L399
L400:
	MOVE	-106(A6),D0
	BEQ.S	L405
	MOVE	-114(A6),D0
	BNE.S	L404
L405:
	MOVE	-22(A6),D4
	ADDQ	#7,D4
	AND	#-8,D4
	MOVE	-106(A6),D0
	BNE.S	L406
	MOVE	D4,D0
	MULS	-24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G074_puc_B(A4),A3
L406:
	MOVE	-24(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L404:
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-90(A6)
	BRA.S	L407
L399:
	CLR	-90(A6)
L407:
L390:
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),D4
	AND	#255,D4
	MOVE	-78(A6),D0
	ASR	#3,D0
	AND	#7,D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,D4
	MOVE	#135,-(A7)
	MOVE	D4,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-39(A6)
	MOVE	D4,D0
	MOVE	-24(A6),D1
	SUBQ	#1,D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-40(A6)
	MOVE.L	-16(A6),A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE	-78(A6),D0
	AND	#7,D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,D4
	CMPI	#1,-26(A6)
	BNE.S	L408
	SUB	#100,D4
	BRA.S	L409
L408:
	MOVE	-26(A6),D0
	BEQ.S	L410
	ADD	#100,D4
L410:
L409:
	MOVE	#223,-(A7)
	MOVE	D4,D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,-41(A6)
	BNE.S	L411
	BRA.S	L22T115_126
L411:
	MOVE	#223,-(A7)
	MOVE	D4,D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L412
	MOVE.B	-42(A6),D0
	AND	#255,D0
	CMP	#223,D0
	BNE.S	L413
	BRA.S	L22T115_126
L413:
	MOVE	-90(A6),D7
	BRA.S	L414
L412:
	MOVE	-90(A6),D7
	MOVE	-22(A6),D1
	SUB	D4,D1
	SUBQ	#1,D1
	ADD	D1,D7
L414:
	MOVE	-84(A6),-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L22T115_126:
	MOVE	-94(A6),D0
	BEQ.S	L415
	CLR	-94(A6)
	MOVE	-82(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-62(A6),A0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-78(A6)
	CMPI	#1,D5
	BNE.S	L416
	CLR	D5
	BRA.S	L417
L416:
	MOVE	#1,D5
L417:
	BRA	L22T115_077(PC)
L415:
L22T115_129:
	MOVE	-134(A6),D0
	BEQ.S	L419
	MOVE	-46(A6),D0
	MOVE	D0,D6
	CMPI	#9,D0
	BGT.S	L419
	MOVE	-136(A6),D0
	MOVE	D0,D5
	MOVE	D6,D1
	MULS	#10,D1
	LEA	G218_aaaau(A4),A0
	ADD.L	A0,D1
	ASL.L	#1,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-122(A6)
	BNE.S	L418
L419:
	BRA	L273(PC)
L418:
	MOVE	-44(A6),D7
L420:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#14,D0
	BNE	L423(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	-28(A6),D1
	CMP	D1,D0
	BNE	L423(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-118(A6)
	MOVE.L	-118(A6),A0
	MOVE	2(A0),-(A7)
	JSR	F142_aqzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#0,D0
	BGE	L424(PC)
	MOVE	D4,D0
	NEG	D0
	MULS	#6,D0
	LEA	G210_as_Gr+-6(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	A2,D4
	MOVE.L	D4,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	ADD	#316,D4
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	4(A0),D0
	AND	#3,D0
	MOVE	D0,-126(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	4(A0),D0
	AND	#256,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-130(A6)
	BNE.S	L426
	MOVE.L	-118(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L425
L426:
	CMPI	#9,D6
	BNE.S	L425
	CLR	-112(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	BRA	L427(PC)
L425:
	MOVE	D6,D0
	EXT.L	D0
	DIVS	#3,D0
	ASL	#1,D0
	MOVE	D5,D1
	ASR	#1,D1
	ADD	D1,D0
	MOVE	D0,-52(A6)
	MOVE	-52(A6),D0
	LEA	G215_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-112(A6)
	MOVE	-130(A6),D0
	BNE.S	L428
	MOVE.L	-118(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#96,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-190(A6)
	MOVE	-112(A6),D0
	MULS	-190(A6),D0
	ASR	#8,D0
	MOVE	D0,-112(A6)
L428:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
L427:
	CMPI	#0,-126(A6)
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-140(A6)
	BEQ.S	L429
	MOVE	12(A6),D0
	ADD	14(A6),D0
	AND	#1,D0
	MOVE	D0,-138(A6)
L429:
	CMPI	#3,-126(A6)
	BNE.S	L430
	CLR	-128(A6)
	MOVE	#0,D0
	MOVE	D0,-36(A6)
	MOVE	D0,-142(A6)
	BRA	L431(PC)
L430:
	MOVE.L	-118(A6),A0
	MOVE	6(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#3072,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-124(A6)
	AND	#1,D0
	MOVE	10(A6),D1
	AND	#1,D1
	CMP	D1,D0
	BEQ.S	L432
	CMPI	#2,-126(A6)
	BNE.S	L433
	MOVE	#1,-128(A6)
	BRA.S	L434
L433:
	MOVE	#2,-128(A6)
L434:
	MOVE	-140(A6),D0
	BEQ.S	L435
	MOVE	D5,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L436
	CMPI	#3,D5
	SEQ	D0
	TST.B	D0
L436:
	AND	#1,D0
	MOVE	D0,-36(A6)
	MOVE	-138(A6),D0
	MOVE	D0,-142(A6)
	BNE.S	L437
	MOVE	-36(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-36(A6)
L437:
	BRA.S	L438
L435:
	CLR	-142(A6)
	MOVE	10(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	CMP	-124(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-36(A6)
L438:
	BRA	L439(PC)
L432:
	CMPI	#2,-126(A6)
	BGE.S	L441
	CMPI	#1,-126(A6)
	BNE.S	L442
	MOVE	-124(A6),D0
	CMP	10(A6),D0
	BNE.S	L441
L442:
	MOVE	-140(A6),D0
	BEQ.S	L440
	MOVE	-138(A6),D0
	BEQ.S	L440
L441:
	CLR	-128(A6)
	BRA.S	L443
L440:
	MOVE	#1,-128(A6)
L443:
	MOVE	-140(A6),D0
	BEQ.S	L444
	CMPI	#2,D5
	SLT	D0
	TST.B	D0
L444:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-142(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	4(A0),D0
	AND	#16,D0
	BEQ.S	L445
	CMPI	#2,-26(A6)
	SEQ	D0
	TST.B	D0
	BNE.S	L446
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L447
	CMPI	#1,D5
	SEQ	D0
	TST.B	D0
	BNE.S	L448
	CMPI	#2,D5
	SEQ	D0
	TST.B	D0
L448:
	TST.B	D0
L447:
	TST.B	D0
L446:
	TST.B	D0
	SEQ	D0
	TST.B	D0
L445:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-36(A6)
L439:
L431:
	ADD	-128(A6),D4
	CLR	-30(A6)
	MOVE	-112(A6),D0
	BNE.S	L449
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA	L450(PC)
L449:
	MOVE	-36(A6),D0
	BEQ.S	L451
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-30(A6)
L451:
	MOVE	-130(A6),D0
	BEQ.S	L452
	MOVE	#282,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE.B	1(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	-128(A6),D1
	MULS	#6,D1
	ADD	D1,D0
	ADD	-52(A6),D0
	MOVE	D0,-18(A6)
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L452
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L453
L452:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE	-130(A6),D0
	BEQ.S	L454
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L455
L454:
	MOVE.L	G074_puc_B(A4),A3
L455:
	MOVE	-52(A6),D0
	LSR	#1,D0
	ASL.L	#2,D0
	LEA	G075_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	-130(A6),D0
	BEQ.S	L456
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L456:
L453:
L450:
	MOVE	-36(A6),D0
	BNE.S	L458
	MOVE	-142(A6),D0
	BEQ.S	L457
L458:
	MOVE	-22(A6),D4
	ADDQ	#7,D4
	AND	#-8,D4
	MOVE.L	A3,D0
	CMP.L	G074_puc_B(A4),D0
	BEQ.S	L459
	MOVE	D4,D0
	MULS	-24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G074_puc_B(A4),A3
L459:
	MOVE	-142(A6),D0
	BEQ.S	L460
	MOVE	-24(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F131_xxxx_(PC)
	ADDQ.L	#8,A7
L460:
	MOVE	-36(A6),D0
	BEQ.S	L461
	MOVE	-24(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L461:
L457:
	MOVE	-24(A6),D0
	ASR	#1,D0
	ADD	#47,D0
	MOVE.B	D0,-39(A6)
	MOVE	#47,D0
	MOVE	-24(A6),D1
	ASR	#1,D1
	SUB	D1,D0
	MOVE	-24(A6),D1
	AND	#1,D1
	SEQ	D1
	AND	#1,D1
	ADD	D1,D0
	MOVE.B	D0,-40(A6)
	MOVE	-122(A6),D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	MOVE	#223,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-41(A6)
	MOVE	-122(A6),D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L462
	MOVE	-36(A6),D0
	BEQ.S	L463
	MOVE	-30(A6),D4
	BRA.S	L464
L463:
	CLR	D4
L464:
	BRA.S	L465
L462:
	MOVE	-22(A6),D0
	SUB	-122(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	-30(A6),-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L465:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	BRA.S	L466
L424:
	CLR	-34(A6)
	MOVE	-122(A6),D0
	MOVE.B	D0,-120(A6)
	MOVE.B	#47,-119(A6)
	LEA	-120(A6),A0
	MOVE.L	A0,-16(A6)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	G209_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D4
	AND	#255,D4
	ADD	#360,D4
	MOVE	#1,-132(A6)
	BRA	L22T115_015(PC)
L466:
L423:
L22T115_171:
L421:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE	L420(PC)
L422:
L273:
	MOVE.L	-4(A6),D0
	BNE	L272(PC)
L274:
	MOVE	-158(A6),D0
	BNE.S	L467
	BRA	L268(PC)
L467:
	CLR.L	-150(A6)
	MOVE	-46(A6),D6
	ADDQ	#3,D6
	MOVE	D6,D0
	EXT.L	D0
	DIVS	#3,D0
	MOVE	D0,-46(A6)
	MOVE	-44(A6),D7
L468:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE	L471(PC)
	MOVE	D7,D5
	LSR	#6,D5
	LSR	#8,D5
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-146(A6)
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D0
	AND	#127,D0
	MOVE	D0,D4
	CMPI	#100,D0
	SGE	D0
	AND	#1,D0
	MOVE	D0,-160(A6)
	BEQ.S	L472
	CMPI	#3,D6
	BLT.S	L473
	CMPI	#9,D6
	BGT.S	L473
	MOVE	D5,D0
	CMP	-28(A6),D0
	BEQ.S	L472
L473:
	BRA	L469(PC)
L472:
	CLR	-162(A6)
	CMPI	#0,D4
	BEQ.S	L475
	CMPI	#2,D4
	BEQ.S	L475
	CMPI	#101,D4
	BNE.S	L474
L475:
	CLR	D4
	BRA	L476(PC)
L474:
	CMPI	#6,D4
	BEQ.S	L478
	CMPI	#7,D4
	BNE.S	L477
L478:
	MOVE	#2,D4
	BRA	L479(PC)
L477:
	CMPI	#40,D4
	BNE.S	L480
	MOVE	#1,-162(A6)
	MOVE	#3,D4
	BRA	L481(PC)
L480:
	CMPI	#100,D4
	BNE	L482(PC)
	MOVE	#-126,-(A7)
	JSR	F142_aqzz_(PC)
	ADDQ.L	#2,A7
	NEG	D0
	MULS	#6,D0
	LEA	G210_as_Gr+-6(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	#317,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G228_aai_G+-18(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	MOVE.L	-154(A6),A0
	AND	#255,D0
	MULS	4(A0),D0
	MOVE.L	-154(A6),A0
	MOVE	4(A0),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	MOVE.L	-154(A6),A0
	AND	#255,D0
	MULS	4(A0),D0
	MOVE.L	-154(A6),A0
	MOVE	4(A0),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	CMPI	#9,D6
	BEQ.S	L483
	PEA	G017_auc_G(A4)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE.L	G074_puc_B(A4),A3
L483:
	BRA	L22T115_200(PC)
L482:
	CMPI	#50,D4
	BNE.S	L484
	CMPI	#4,D6
	BLT.S	L485
	MOVE.L	-146(A6),-150(A6)
L485:
	BRA	L469(PC)
L484:
	MOVE	#1,D4
L481:
L479:
L476:
	CMPI	#12,D6
	BNE	L486(PC)
	MOVE	-162(A6),D0
	BEQ.S	L487
	SUBQ	#1,D4
L487:
	MOVE	D4,D0
	MULS	#3,D0
	MOVE	D0,D4
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D5
	AND	#-256,D5
	LSR	#8,D5
	LSR	#5,D5
	BEQ.S	L488
	ADDQ	#1,D4
	CMPI	#3,D5
	BLE.S	L489
	ADDQ	#1,D4
L489:
L488:
	CLR	-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D4,D0
	ADD	#351,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	-162(A6),D0
	BEQ.S	L490
	PEA	G212_auc_G(A4)
	MOVE	#32,-(A7)
	MOVE	#48,-(A7)
	MOVE	#32,-(A7)
	MOVE	#48,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE.L	G074_puc_B(A4),A3
L490:
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#138,-(A7)
	MOVE	#112,-(A7)
	JSR	F027_AA59_(PC)
	AND	#63,D0
	MOVE	D0,-(A7)
	JSR	F029_AA19_(PC)
	ADD	#87,D0
	MOVE	D0,-(A7)
	PEA	G105_s_Gra(A4)
	CLR	-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	CLR.L	-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F133_xxxx_(PC)
	ADDA	#32,A7
	CLR	-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32768,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	BRA	L491(PC)
L486:
	MOVE	-160(A6),D0
	BEQ.S	L492
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G227_aai_G+-18(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
	MOVE.L	-154(A6),A0
	MOVE	4(A0),-156(A6)
	BRA	L493(PC)
L492:
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L494
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G225_aai_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
	BRA.S	L495
L494:
	MOVE	D5,D0
	CMP	10(A6),D0
	BEQ.S	L497
	MOVE	D5,D0
	MOVE	10(A6),D1
	SUBQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L496
L497:
	CLR	D5
	BRA.S	L498
L496:
	MOVE	#1,D5
L498:
	MOVE	D5,D0
	MOVE	D6,D1
	EXT.L	D1
	ASL.L	#3,D1
	LEA	G226_aaai_(A4),A0
	ADD.L	A0,D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
L495:
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D0
	AND	#-256,D0
	LSR	#8,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#48,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	-46(A6),D1
	LEA	G216_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULS	D1,D0
	ASR	#8,D0
	MOVE	D0,-(A7)
	MOVE	#4,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	AND	#-2,D0
	MOVE	D0,-156(A6)
L493:
	PEA	-24(A6)
	PEA	-22(A6)
	MOVE	-156(A6),-(A7)
	MOVE	D4,-(A7)
	JSR	F114_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	D0,A3
L22T115_200:
	JSR	F028_a000_(PC)
	MOVE	D0,-142(A6)
	CLR	-30(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,-36(A6)
	BEQ.S	L499
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-30(A6)
L499:
	MOVE.L	-154(A6),A0
	MOVE	2(A0),D0
	MOVE	-24(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#135,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-39(A6)
	MOVE.L	-154(A6),A0
	MOVE	2(A0),D0
	MOVE	-24(A6),D1
	ASR	#1,D1
	SUB	D1,D0
	MOVE	-24(A6),D1
	AND	#1,D1
	SEQ	D1
	AND	#1,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#136,D4
	BLT.S	L500
	BRA	L469(PC)
L500:
	MOVE	D4,D0
	MOVE.B	D0,-40(A6)
	MOVE.L	-154(A6),A0
	MOVE	(A0),D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	MOVE	#223,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#0,D0
	BGE.S	L501
	BRA	L469(PC)
L501:
	MOVE	D4,D0
	MOVE.B	D0,-41(A6)
	MOVE.L	-154(A6),A0
	MOVE	(A0),D4
	MOVE	#223,-(A7)
	MOVE	D4,D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L502
	MOVE	-30(A6),D4
	BRA.S	L503
L502:
	MOVE	-22(A6),D0
	SUB	D4,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	-30(A6),-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L503:
	MOVE.B	-41(A6),D0
	MOVE.B	-42(A6),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGT.S	L504
	BRA	L469(PC)
L504:
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-22(A6)
	MOVE	-36(A6),D0
	BNE.S	L506
	MOVE	-142(A6),D0
	BEQ.S	L505
L506:
	MOVE	-22(A6),D0
	MULS	-24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G074_puc_B(A4),A3
L505:
	MOVE	-36(A6),D0
	BEQ.S	L507
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L507:
	MOVE	-142(A6),D0
	BEQ.S	L508
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F131_xxxx_(PC)
	ADDQ.L	#8,A7
L508:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L491:
L471:
L469:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE	L468(PC)
L470:
	CMPI.L	#0,-150(A6)
	BEQ.S	L509
	CMPI	#1,-110(A6)
	BEQ.S	L509
	MOVE	G077_B_DoN(A4),D0
	BNE.S	L509
	SUBQ	#3,D6
	MOVE	#8,-(A7)
	PEA	-170(A6)
	MOVE	D6,D0
	ASL.L	#3,D0
	LEA	G188_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	ADDQ.B	#1,-170(A6)
	MOVE	D6,D0
	ASL.L	#3,D0
	LEA	G163_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	PEA	-170(A6)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L509:
L268:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$267:	.EQU	#-190
F116_xxxx_:/* global */
	LINK	A6,L$510
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L512:
	CMP	#19,D0
	BEQ.S	L513
	BRA.S	L515
L513:
	MOVE	-6(A6),D0
	BEQ.S	L517
	PEA	G110_s_Gra(A4)
	MOVE	G079_ai_St+34(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L518
L517:
	PEA	G121_s_Gra(A4)
	MOVE	G079_ai_St+20(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L518:
	BRA	L23T116_015(PC)
	BRA.S	L516
L515:
	CMP	#0,D0
	BEQ.S	L516
	BRA.S	L519
L516:
	PEA	G163_as_Gr+8(A4)
	MOVE.L	G088_apuc_+48(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	CLR	-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#2,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L521
	CLR	D4
	BRA	L23T116_017(PC)
L521:
	BRA	L511(PC)
	BRA.S	L520
L519:
	CMP	#16,D0
	BEQ.S	L520
L522:
	CMP	#18,D0
	BEQ.S	L520
	BRA.S	L523
L520:
	MOVE	#801,D4
	BRA	L23T116_016(PC)
	BRA.S	L524
L523:
	CMP	#17,D0
	BEQ.S	L524
	BRA.S	L525
L524:
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G164_s_Gra(A4)
	MOVE.L	G088_apuc_+20(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G179_s_Gra(A4)
	CLR	-(A7)
	MOVE	#984,-(A7)
	PEA	G080_aai_D+8(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L23T116_017
	BRA.S	L526
L525:
	CMP	#2,D0
	BEQ.S	L526
	BRA.S	L527
L526:
	MOVE	-6(A6),D0
	BNE.S	L529
	PEA	G140_s_Gra(A4)
	MOVE	#49,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L529:
	BRA.S	L528
L527:
	CMP	#5,D0
	BEQ.S	L528
L530:
	CMP	#1,D0
	BEQ.S	L528
	BRA.S	L531
L528:
L23T116_015:
	MOVE	#13345,D4
L23T116_016:
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L23T116_017:
	MOVE	D4,-(A7)
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L531:
L532:
L514:
	CMPI	#5,-10(A6)
	BNE.S	L533
	MOVE	-6(A6),D0
	BEQ.S	L533
	PEA	G163_as_Gr+8(A4)
	PEA	G188_as_Gr+8(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L533:
L511:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$510:	.EQU	#-10
F117_xxxx_:/* global */
	LINK	A6,L$534
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L536:
	CMP	#19,D0
	BEQ.S	L537
	BRA.S	L539
L537:
	MOVE	-6(A6),D0
	BEQ.S	L541
	PEA	G112_s_Gra(A4)
	MOVE	G079_ai_St+34(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L542
L541:
	PEA	G123_s_Gra(A4)
	MOVE	G079_ai_St+20(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L542:
	BRA	L24T117_016(PC)
	BRA.S	L540
L539:
	CMP	#0,D0
	BEQ.S	L540
	BRA.S	L543
L540:
	PEA	G163_as_Gr+16(A4)
	MOVE.L	G088_apuc_+48(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#4,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L545
	CLR	D4
	BRA	L24T117_018(PC)
L545:
	BRA	L535(PC)
	BRA.S	L544
L543:
	CMP	#16,D0
	BEQ.S	L544
L546:
	CMP	#18,D0
	BEQ.S	L544
	BRA.S	L547
L544:
	MOVE	#1042,D4
	BRA	L24T117_017(PC)
	BRA.S	L548
L547:
	CMP	#17,D0
	BEQ.S	L548
	BRA	L549(PC)
L548:
	MOVE	#2,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#296,-(A7)
	MOVE	#2,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#704,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+20(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	PEA	G165_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F103_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L551
	CLR	-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L551:
	PEA	G181_s_Gra(A4)
	CLR	-(A7)
	MOVE	#984,-(A7)
	PEA	G080_aai_D+8(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#1081,D4
	BRA.S	L24T117_018
	BRA.S	L550
L549:
	CMP	#2,D0
	BEQ.S	L550
	BRA.S	L552
L550:
	MOVE	-6(A6),D0
	BNE.S	L554
	PEA	G142_s_Gra(A4)
	MOVE	#49,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L554:
	BRA.S	L553
L552:
	CMP	#5,D0
	BEQ.S	L553
L555:
	CMP	#1,D0
	BEQ.S	L553
	BRA.S	L556
L553:
L24T117_016:
	MOVE	#17170,D4
L24T117_017:
	MOVE	#2,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L24T117_018:
	MOVE	D4,-(A7)
	MOVE	#2,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L556:
L557:
L538:
	CMPI	#5,-10(A6)
	BNE.S	L558
	MOVE	-6(A6),D0
	BEQ.S	L558
	PEA	G163_as_Gr+16(A4)
	PEA	G188_as_Gr+16(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L558:
L535:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$534:	.EQU	#-10
F118_xxxx_:/* global */
	LINK	A6,L$559
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L561:
	CMP	#19,D0
	BEQ.S	L562
	BRA.S	L564
L562:
	MOVE	-6(A6),D0
	BEQ.S	L566
	PEA	G111_s_Gra(A4)
	MOVE	G079_ai_St+32(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L567
L566:
	PEA	G122_s_Gra(A4)
	MOVE	G079_ai_St+18(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L567:
	BRA	L25T118_027(PC)
	BRA.S	L565
L564:
	CMP	#0,D0
	BEQ.S	L565
	BRA.S	L568
L565:
	PEA	G163_as_Gr(A4)
	MOVE.L	G088_apuc_+48(A4),-(A7)
	JSR	F101_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#3,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L570
	CLR	D4
	BRA	L25T118_028(PC)
L570:
	BRA	L560(PC)
	BRA.S	L569
L568:
	CMP	#17,D0
	BEQ.S	L569
	BRA	L571(PC)
L569:
	MOVE	#1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G166_s_Gra(A4)
	MOVE.L	G088_apuc_+16(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#704,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+16(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	PEA	G167_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F103_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L573
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L573:
	PEA	G180_s_Gra(A4)
	CLR	-(A7)
	MOVE	#984,-(A7)
	PEA	G080_aai_D+8(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L25T118_028
	BRA.S	L572
L571:
	CMP	#2,D0
	BEQ.S	L572
	BRA.S	L574
L572:
	MOVE	-6(A6),D0
	BNE.S	L576
	PEA	G141_s_Gra(A4)
	MOVE	#50,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L576:
	BRA.S	L575
L574:
	CMP	#1,D0
	BEQ.S	L575
	BRA.S	L577
L575:
L25T118_027:
	MOVE	#13345,D4
	MOVE	#1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L25T118_028:
	MOVE	D4,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L577:
L578:
L563:
	CMPI	#5,-10(A6)
	BNE.S	L579
	MOVE	-6(A6),D0
	BEQ.S	L579
	PEA	G163_as_Gr(A4)
	PEA	G188_as_Gr(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L579:
L560:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$559:	.EQU	#-10
F119_xxxx_:/* global */
	LINK	A6,L$580
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L582:
	CMP	#19,D0
	BEQ.S	L583
	BRA.S	L585
L583:
	MOVE	-6(A6),D0
	BEQ.S	L587
	PEA	G113_s_Gra(A4)
	MOVE	G079_ai_St+30(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L588
L587:
	PEA	G124_s_Gra(A4)
	MOVE	G079_ai_St+16(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L588:
	BRA	L26T119_018(PC)
	BRA.S	L586
L585:
	CMP	#0,D0
	BEQ.S	L586
	BRA.S	L589
L586:
	PEA	G163_as_Gr+32(A4)
	MOVE.L	G088_apuc_+44(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#5,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#7,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L591
	CLR	D4
	BRA	L26T119_020(PC)
L591:
	BRA	L581(PC)
	BRA.S	L590
L589:
	CMP	#18,D0
	BEQ.S	L590
	BRA.S	L592
L590:
	PEA	G132_s_Gra(A4)
	MOVE	G079_ai_St+6(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L593
L592:
	CMP	#16,D0
	BEQ.S	L593
	BRA.S	L594
L593:
	MOVE	#834,D4
	BRA	L26T119_019(PC)
	BRA.S	L595
L594:
	CMP	#17,D0
	BEQ.S	L595
	BRA.S	L596
L595:
	MOVE	#3,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G173_s_Gra(A4)
	MOVE.L	G088_apuc_+28(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G182_s_Gra(A4)
	MOVE	#1,-(A7)
	MOVE	#1952,-(A7)
	PEA	G080_aai_D+4(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L26T119_020
	BRA.S	L597
L596:
	CMP	#2,D0
	BEQ.S	L597
	BRA.S	L598
L597:
	PEA	G143_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L600
	MOVE	#57,D0
	BRA.S	L601
L600:
	MOVE	#51,D0
L601:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L599
L598:
	CMP	#5,D0
	BEQ.S	L599
L602:
	CMP	#1,D0
	BEQ.S	L599
	BRA.S	L603
L599:
L26T119_018:
	MOVE	#13345,D4
L26T119_019:
	MOVE	#3,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L26T119_020:
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G152_s_Gra(A4)
	MOVE	#63,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D4,-(A7)
	MOVE	#4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L603:
L604:
L584:
	CMPI	#5,-10(A6)
	BNE.S	L605
	MOVE	-6(A6),D0
	BEQ.S	L605
	PEA	G163_as_Gr+32(A4)
	PEA	G188_as_Gr+32(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L605:
L581:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$580:	.EQU	#-10
F120_xxxx_:/* global */
	LINK	A6,L$606
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L608:
	CMP	#19,D0
	BEQ.S	L609
	BRA.S	L611
L609:
	MOVE	-6(A6),D0
	BEQ.S	L613
	PEA	G115_s_Gra(A4)
	MOVE	G079_ai_St+30(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L614
L613:
	PEA	G126_s_Gra(A4)
	MOVE	G079_ai_St+16(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L614:
	BRA	L27T120_027(PC)
	BRA.S	L612
L611:
	CMP	#0,D0
	BEQ.S	L612
	BRA.S	L615
L612:
	PEA	G163_as_Gr+40(A4)
	MOVE.L	G088_apuc_+44(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#6,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#9,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L617
	CLR	D4
	BRA	L27T120_029(PC)
L617:
	BRA	L607(PC)
	BRA.S	L616
L615:
	CMP	#18,D0
	BEQ.S	L616
	BRA.S	L618
L616:
	PEA	G133_s_Gra(A4)
	MOVE	G079_ai_St+6(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L619
L618:
	CMP	#16,D0
	BEQ.S	L619
	BRA.S	L620
L619:
	MOVE	#1073,D4
	BRA	L27T120_028(PC)
	BRA.S	L621
L620:
	CMP	#17,D0
	BEQ.S	L621
	BRA.S	L622
L621:
	MOVE	#5,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#296,-(A7)
	MOVE	#5,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G175_s_Gra(A4)
	MOVE.L	G088_apuc_+28(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G184_s_Gra(A4)
	MOVE	#1,-(A7)
	MOVE	#1952,-(A7)
	PEA	G080_aai_D+4(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#1081,D4
	BRA.S	L27T120_029
	BRA.S	L623
L622:
	CMP	#2,D0
	BEQ.S	L623
	BRA.S	L624
L623:
	PEA	G145_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L626
	MOVE	#57,D0
	BRA.S	L627
L626:
	MOVE	#51,D0
L627:
	MOVE	D0,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L625
L624:
	CMP	#5,D0
	BEQ.S	L625
L628:
	CMP	#1,D0
	BEQ.S	L625
	BRA.S	L629
L625:
L27T120_027:
	MOVE	#17170,D4
L27T120_028:
	MOVE	#5,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G154_s_Gra(A4)
	MOVE	#63,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L27T120_029:
	MOVE	D4,-(A7)
	MOVE	#5,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L629:
L630:
L610:
	CMPI	#5,-10(A6)
	BNE.S	L631
	MOVE	-6(A6),D0
	BEQ.S	L631
	PEA	G163_as_Gr+40(A4)
	PEA	G188_as_Gr+40(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L631:
L607:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$606:	.EQU	#-10
F121_xxxx_:/* global */
	LINK	A6,L$632
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L634:
	CMP	#19,D0
	BEQ.S	L635
	BRA.S	L637
L635:
	MOVE	-6(A6),D0
	BEQ.S	L639
	PEA	G114_s_Gra(A4)
	MOVE	G079_ai_St+28(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L640
L639:
	PEA	G125_s_Gra(A4)
	MOVE	G079_ai_St+14(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L640:
	BRA	L28T121_015(PC)
	BRA.S	L638
L637:
	CMP	#0,D0
	BEQ.S	L638
	BRA.S	L641
L638:
	PEA	G163_as_Gr+24(A4)
	MOVE.L	G088_apuc_+44(A4),-(A7)
	JSR	F101_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#8,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L643
	CLR	D4
	BRA	L28T121_016(PC)
L643:
	BRA	L633(PC)
	BRA.S	L642
L641:
	CMP	#17,D0
	BEQ.S	L642
	BRA	L644(PC)
L642:
	MOVE	#4,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#3,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G174_s_Gra(A4)
	MOVE.L	G088_apuc_+28(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G168_s_Gra(A4)
	MOVE.L	G088_apuc_+12(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#1560,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+12(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	PEA	G169_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F103_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L646
	MOVE	#2,-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L646:
	PEA	G183_s_Gra(A4)
	MOVE	#1,-(A7)
	MOVE	#1952,-(A7)
	PEA	G080_aai_D+4(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L28T121_016
	BRA.S	L645
L644:
	CMP	#2,D0
	BEQ.S	L645
	BRA.S	L647
L645:
	PEA	G144_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L649
	MOVE	#58,D0
	BRA.S	L650
L649:
	MOVE	#52,D0
L650:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L648
L647:
	CMP	#5,D0
	BEQ.S	L648
L651:
	CMP	#1,D0
	BEQ.S	L648
	BRA.S	L652
L648:
L28T121_015:
	MOVE	#13345,D4
	MOVE	#4,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G153_s_Gra(A4)
	MOVE	#64,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L28T121_016:
	MOVE	D4,-(A7)
	MOVE	#3,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L652:
L653:
L636:
	CMPI	#5,-10(A6)
	BNE.S	L654
	MOVE	-6(A6),D0
	BEQ.S	L654
	PEA	-10(A6)
	PEA	G163_as_Gr+24(A4)
	PEA	G188_as_Gr+24(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L654:
L633:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$632:	.EQU	#-10
F122_xxxx_:/* global */
	LINK	A6,L$655
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L657:
	CMP	#19,D0
	BEQ.S	L658
	BRA.S	L660
L658:
	MOVE	-6(A6),D0
	BEQ.S	L662
	PEA	G116_s_Gra(A4)
	MOVE	G079_ai_St+26(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L663
L662:
	PEA	G127_s_Gra(A4)
	MOVE	G079_ai_St+12(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L663:
	BRA	L29T122_019(PC)
	BRA.S	L661
L660:
	CMP	#0,D0
	BEQ.S	L661
	BRA.S	L664
L661:
	PEA	G163_as_Gr+56(A4)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#10,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L656(PC)
	BRA.S	L665
L664:
	CMP	#18,D0
	BEQ.S	L665
	BRA.S	L666
L665:
	MOVE	-6(A6),D0
	BEQ.S	L668
	PEA	G134_s_Gra(A4)
	MOVE	G079_ai_St+4(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L669
L668:
	PEA	G136_s_Gra(A4)
	MOVE	G079_ai_St+2(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L669:
	BRA.S	L667
L666:
	CMP	#16,D0
	BEQ.S	L667
	BRA.S	L670
L667:
	MOVE	#50,D4
	BRA	L29T122_020(PC)
	BRA.S	L671
L670:
	CMP	#17,D0
	BEQ.S	L671
	BRA.S	L672
L671:
	MOVE	#6,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#40,-(A7)
	MOVE	#7,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G176_s_Gra(A4)
	MOVE.L	G088_apuc_+24(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G185_s_Gra(A4)
	MOVE	#2,-(A7)
	MOVE	#4224,-(A7)
	PEA	G080_aai_D(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#57,D4
	BRA.S	L29T122_021
	BRA.S	L673
L672:
	CMP	#2,D0
	BEQ.S	L673
	BRA.S	L674
L673:
	PEA	G146_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L676
	MOVE	#59,D0
	BRA.S	L677
L676:
	MOVE	#53,D0
L677:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L675
L674:
	CMP	#5,D0
	BEQ.S	L675
L678:
	CMP	#1,D0
	BEQ.S	L675
	BRA.S	L679
L675:
L29T122_019:
	MOVE	#50,D4
L29T122_020:
	MOVE	#6,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G155_s_Gra(A4)
	MOVE	#65,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L29T122_021:
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L679:
L680:
L659:
	CMPI	#5,-10(A6)
	BNE.S	L681
	MOVE	-6(A6),D0
	BEQ.S	L681
	PEA	-10(A6)
	PEA	G163_as_Gr+56(A4)
	PEA	G188_as_Gr+56(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L681:
L656:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$655:	.EQU	#-10
F123_xxxx_:/* global */
	LINK	A6,L$682
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L684:
	CMP	#19,D0
	BEQ.S	L685
	BRA.S	L687
L685:
	MOVE	-6(A6),D0
	BEQ.S	L689
	PEA	G118_s_Gra(A4)
	MOVE	G079_ai_St+26(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L690
L689:
	PEA	G129_s_Gra(A4)
	MOVE	G079_ai_St+12(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L690:
	BRA	L30T123_019(PC)
	BRA.S	L688
L687:
	CMP	#0,D0
	BEQ.S	L688
	BRA.S	L691
L688:
	PEA	G163_as_Gr+64(A4)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#11,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L683(PC)
	BRA.S	L692
L691:
	CMP	#18,D0
	BEQ.S	L692
	BRA.S	L693
L692:
	MOVE	-6(A6),D0
	BEQ.S	L695
	PEA	G135_s_Gra(A4)
	MOVE	G079_ai_St+4(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L696
L695:
	PEA	G137_s_Gra(A4)
	MOVE	G079_ai_St+2(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L696:
	BRA.S	L694
L693:
	CMP	#16,D0
	BEQ.S	L694
	BRA.S	L697
L694:
	MOVE	#65,D4
	BRA	L30T123_020(PC)
	BRA.S	L698
L697:
	CMP	#17,D0
	BEQ.S	L698
	BRA.S	L699
L698:
	MOVE	#8,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#24,-(A7)
	MOVE	#8,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G178_s_Gra(A4)
	MOVE.L	G088_apuc_+24(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G187_s_Gra(A4)
	MOVE	#2,-(A7)
	MOVE	#4224,-(A7)
	PEA	G080_aai_D(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#73,D4
	BRA.S	L30T123_021
	BRA.S	L700
L699:
	CMP	#2,D0
	BEQ.S	L700
	BRA.S	L701
L700:
	PEA	G148_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L703
	MOVE	#59,D0
	BRA.S	L704
L703:
	MOVE	#53,D0
L704:
	MOVE	D0,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L702
L701:
	CMP	#5,D0
	BEQ.S	L702
L705:
	CMP	#1,D0
	BEQ.S	L702
	BRA.S	L706
L702:
L30T123_019:
	MOVE	#65,D4
L30T123_020:
	MOVE	#8,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G157_s_Gra(A4)
	MOVE	#65,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L30T123_021:
	MOVE	D4,-(A7)
	MOVE	#8,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L706:
L707:
L686:
	CMPI	#5,-10(A6)
	BNE.S	L708
	MOVE	-6(A6),D0
	BEQ.S	L708
	PEA	-10(A6)
	PEA	G163_as_Gr+64(A4)
	PEA	G188_as_Gr+64(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L708:
L683:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$682:	.EQU	#-10
F124_xxxx_:/* global */
	LINK	A6,L$709
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
	MOVE	D0,G285_i_Squ(A4)
L711:
	CMP	#19,D0
	BEQ.S	L712
	BRA.S	L714
L712:
	MOVE	-6(A6),D0
	BEQ.S	L716
	PEA	G117_s_Gra(A4)
	MOVE	G079_ai_St+24(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L717
L716:
	PEA	G128_s_Gra(A4)
	MOVE	G079_ai_St+10(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L717:
	BRA	L31T124_017(PC)
	BRA.S	L715
L714:
	CMP	#0,D0
	BEQ.S	L715
	BRA	L718(PC)
L715:
	CLR	G286_B_Fac(A4)
	CLR	G287_B_Fac(A4)
	CLR	G288_B_Fac(A4)
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ	L720(PC)
	MOVE	#1,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	G106_s_Gra+2(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G106_s_Gra(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	PEA	G107_s_Gra(A4)
	MOVE	#1,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#41,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-14(A6)
	MOVE	#10,-(A7)
	MOVE	#48,-(A7)
	MOVE	#48,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G107_s_Gra(A4)
	MOVE	#1,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-14(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L720:
	PEA	G163_as_Gr+48(A4)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F101_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#12,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L721
	CLR	-(A7)
	MOVE	#6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L721:
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ.S	L722
	MOVE	#9,-(A7)
	MOVE	#112,-(A7)
	MOVE	#48,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G106_s_Gra(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	#1,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#1,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32767,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L722:
	BRA	L710(PC)
	BRA.S	L719
L718:
	CMP	#17,D0
	BEQ.S	L719
	BRA	L723(PC)
L719:
	MOVE	#7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G177_s_Gra(A4)
	MOVE.L	G088_apuc_+24(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G170_s_Gra(A4)
	MOVE.L	G088_apuc_+8(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G171_s_Gra(A4)
	MOVE.L	G088_apuc_(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L725
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L725:
	PEA	G186_s_Gra(A4)
	MOVE	#2,-(A7)
	MOVE	#4224,-(A7)
	PEA	G080_aai_D(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L31T124_018
	BRA.S	L724
L723:
	CMP	#2,D0
	BEQ.S	L724
	BRA.S	L726
L724:
	PEA	G147_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L728
	MOVE	#60,D0
	BRA.S	L729
L728:
	MOVE	#54,D0
L729:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L727
L726:
	CMP	#5,D0
	BEQ.S	L727
L730:
	CMP	#1,D0
	BEQ.S	L727
	BRA.S	L731
L727:
L31T124_017:
	MOVE	#13345,D4
	MOVE	#7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G156_s_Gra(A4)
	MOVE	#66,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L31T124_018:
	MOVE	D4,-(A7)
	MOVE	#6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L731:
L732:
L713:
	CMPI	#5,-10(A6)
	BNE.S	L733
	MOVE	-6(A6),D0
	BEQ.S	L733
	PEA	-10(A6)
	PEA	G163_as_Gr+48(A4)
	PEA	G188_as_Gr+48(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L733:
L710:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$709:	.EQU	#-14
F125_xxxx_:/* global */
	LINK	A6,L$734
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L736:
	CMP	#18,D0
	BEQ.S	L737
	BRA.S	L739
L737:
	PEA	G138_s_Gra(A4)
	MOVE	G079_ai_St(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA	L735(PC)
	BRA.S	L740
L739:
	CMP	#2,D0
	BEQ.S	L740
	BRA.S	L741
L740:
	PEA	G149_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L743
	MOVE	#61,D0
	BRA.S	L744
L743:
	MOVE	#55,D0
L744:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L742
L741:
	CMP	#1,D0
	BEQ.S	L742
L745:
	CMP	#16,D0
	BEQ.S	L742
L746:
	CMP	#5,D0
	BEQ.S	L742
	BRA.S	L747
L742:
	MOVE	#2,-(A7)
	MOVE	#10,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L738
	BRA.S	L748
L747:
	CMP	#0,D0
	BEQ.S	L748
	BRA.S	L749
L748:
	PEA	G163_as_Gr+80(A4)
	MOVE.L	G088_apuc_+36(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L735
L749:
L750:
L738:
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G158_s_Gra(A4)
	MOVE	#67,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	CMPI	#5,-10(A6)
	BNE.S	L751
	MOVE	-6(A6),D0
	BEQ.S	L751
	PEA	G163_as_Gr+80(A4)
	PEA	G188_as_Gr+80(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L751:
L735:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$734:	.EQU	#-10
F126_xxxx_:/* global */
	LINK	A6,L$752
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L754:
	CMP	#18,D0
	BEQ.S	L755
	BRA.S	L757
L755:
	PEA	G139_s_Gra(A4)
	MOVE	G079_ai_St(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA	L753(PC)
	BRA.S	L758
L757:
	CMP	#2,D0
	BEQ.S	L758
	BRA.S	L759
L758:
	PEA	G151_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L761
	MOVE	#61,D0
	BRA.S	L762
L761:
	MOVE	#55,D0
L762:
	MOVE	D0,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L760
L759:
	CMP	#1,D0
	BEQ.S	L760
L763:
	CMP	#16,D0
	BEQ.S	L760
L764:
	CMP	#5,D0
	BEQ.S	L760
	BRA.S	L765
L760:
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G160_s_Gra(A4)
	MOVE	#67,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#1,-(A7)
	MOVE	#11,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L756
	BRA.S	L766
L765:
	CMP	#0,D0
	BEQ.S	L766
	BRA.S	L767
L766:
	PEA	G163_as_Gr+88(A4)
	MOVE.L	G088_apuc_+32(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L753
L767:
L768:
L756:
	CMPI	#5,-10(A6)
	BNE.S	L769
	MOVE	-6(A6),D0
	BEQ.S	L769
	PEA	G163_as_Gr+88(A4)
	PEA	G188_as_Gr+88(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L769:
L753:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$752:	.EQU	#-10
F127_xxxx_:/* global */
	LINK	A6,L$770
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L772:
	CMP	#16,D0
	BEQ.S	L773
	BRA.S	L775
L773:
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ.S	L777
	MOVE	#1968,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+4(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#9,-(A7)
	MOVE	#16,-(A7)
	MOVE	#48,-(A7)
	CLR	-(A7)
	MOVE.B	G172_s_Gra(A4),D0
	AND	#255,D0
	MOVE.B	G106_s_Gra(A4),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,-(A7)
	PEA	G108_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE	#41,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	PEA	G172_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L778
L777:
	PEA	G172_s_Gra(A4)
	MOVE.L	G088_apuc_+4(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
L778:
	BRA.S	L774
	BRA.S	L776
L775:
	CMP	#19,D0
	BEQ.S	L776
	BRA.S	L779
L776:
	MOVE	-6(A6),D0
	BEQ.S	L781
	PEA	G119_s_Gra(A4)
	MOVE	G079_ai_St+22(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	PEA	G120_s_Gra(A4)
	MOVE	G079_ai_St+22(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L782
L781:
	PEA	G130_s_Gra(A4)
	MOVE	G079_ai_St+8(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	PEA	G131_s_Gra(A4)
	MOVE	G079_ai_St+8(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L782:
	BRA.S	L774
	BRA.S	L780
L779:
	CMP	#2,D0
	BEQ.S	L780
	BRA.S	L783
L780:
	PEA	G150_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L785
	MOVE	#62,D0
	BRA.S	L786
L785:
	MOVE	#56,D0
L786:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L783:
L784:
L774:
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G159_s_Gra(A4)
	MOVE	#68,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#33,-(A7)
	MOVE	#9,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	CMPI	#5,-10(A6)
	BNE.S	L787
	MOVE	-6(A6),D0
	BEQ.S	L787
	PEA	G163_as_Gr+72(A4)
	PEA	G188_as_Gr+72(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L787:
L771:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$770:	.EQU	#-10
F128_rzzz_:/* global */
	LINK	A6,L$788
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	CLR	D4
	MOVE	G297_B_Dra(A4),D0
	BEQ.S	L790
	JSR	F098_rzzz_(PC)
L790:
	MOVE	#1,G578_B_Use(A4)
	MOVE	#24,-(A7)
	PEA	G291_aauc_(A4)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#4,-(A7)
	MOVE	#255,-(A7)
	MOVE	#6,-(A7)
	PEA	G291_aauc_(A4)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	MOVE.L	#8880,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G074_puc_B(A4)
	MOVE	D6,D0
	ADD	D5,D0
	ADD	D7,D0
	AND	#1,D0
	MOVE	D0,G076_B_Use(A4)
	BEQ.S	L791
	MOVE	#70,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G087_puc_B(A4),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	G661_B_Lar(A4),D4
	BEQ.S	L792
	MOVE.L	G090_puc_B(A4),G088_apuc_+48(A4)
	MOVE.L	G091_puc_B(A4),G088_apuc_+44(A4)
	MOVE.L	G092_puc_B(A4),G088_apuc_+40(A4)
	MOVE.L	G093_puc_B(A4),G088_apuc_+36(A4)
	MOVE.L	G094_puc_B(A4),G088_apuc_+32(A4)
L792:
	BRA.S	L793
L791:
	MOVE	#29,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L793:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	#-2,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F153_yzzz_(PC)
	ADDA	#10,A7
	CMPI	#0,D0
	BNE.S	L794
	PEA	G163_as_Gr+104(A4)
	MOVE.L	G088_apuc_+52(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
L794:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	#2,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F153_yzzz_(PC)
	ADDA	#10,A7
	CMPI	#0,D0
	BNE.S	L795
	PEA	G163_as_Gr+96(A4)
	MOVE.L	G088_apuc_+56(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
L795:
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#4,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	MOVE	#-2,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#4,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	MOVE	#-1,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	MOVE	#-3,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F116_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F117_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F118_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F119_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F120_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F121_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F122_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F123_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F124_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F125_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F126_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F127_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D4,D0
	BEQ.S	L796
	MOVE.L	G095_puc_B(A4),G088_apuc_+48(A4)
	MOVE.L	G096_puc_B(A4),G088_apuc_+44(A4)
	MOVE.L	G097_puc_B(A4),G088_apuc_+40(A4)
	MOVE.L	G098_puc_B(A4),G088_apuc_+36(A4)
	MOVE.L	G099_puc_B(A4),G088_apuc_+32(A4)
L796:
	MOVE.L	#8880,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#255,G309_i_Par(A4)
	SNE	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#255,G309_i_Par(A4)
	BEQ.S	L797
	JSR	F098_rzzz_(PC)
L797:
L789:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$788:	.EQU	#-4
