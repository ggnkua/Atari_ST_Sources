BSS SEG "bss"
G521_i_Gam:/* global */
	.WORD	#2
G522_l_Unr:/* global */
	.WORD	#4
G523_B_Res:/* global */
	.WORD	#2
G524_B_Res:/* global */
	.WORD	#2
G525_l_Gam:/* global */
	.WORD	#4
G526_ui_Du:/* global */
	.WORD	#2
G527_i_Pla:/* global */
	.WORD	#2
G528_i_For:/* global */
	.WORD	#2
G529_i_Use:/* global */
	.WORD	#2
G530_B_Loa:/* global */
	.WORD	#2
G531_puc_D:/* global */
	.WORD	#4
G532_l_Dec:/* global */
	.WORD	#4
G534_ac_Sa:/* global */
	.WORD	#132
CODE SEG "start"
F414_xxxx_:/* global */
	LINK	A6,L$0
	MOVE.L	8(A6),A0
	CLR.B	(A0)
	MOVE	#126,-(A7)
	MOVE.L	12(A6),-(A7)
	JSR	index(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-4(A6)
	CMPI.L	#0,D0
	BEQ.S	L2
	MOVE.L	-4(A6),D0
	SUB.L	12(A6),D0
	MOVE	D0,-6(A6)
	MOVE	D0,-(A7)
	MOVE.L	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	strncpy(PC)
	ADDA	#10,A7
	MOVE	-6(A6),D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE	G567_B_Sin(A4),D0
	BNE.S	L4
	CMPI	#1,16(A6)
	BNE.S	L3
L4:
	MOVE.L	G571_pc_D1(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	BRA.S	L5
L3:
	MOVE.L	G572_pc_D1(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
L5:
	MOVE.L	-4(A6),D0
	ADDQ.L	#1,D0
	MOVE.L	D0,-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
L2:
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#-6
F415_xxxx_:/* global */
	LINK	A6,L$6
	MOVE.L	D7,-(A7)
	MOVE	12(A6),D0
	AND.L	#65535,D0
	MOVE.L	D0,D7
	CMPI.L	#0,D0
	BNE.S	L8
	MOVE	#1,D0
	BRA.S	L7
L8:
	MOVE	G530_B_Loa(A4),D0
	BEQ.S	L9
	MOVE.L	D7,D0
	CMP.L	G532_l_Dec(A4),D0
	BLE.S	L10
	MOVE	#0,D0
	BRA.S	L7
L10:
	MOVE.L	D7,D0
	MOVE	D0,-(A7)
	MOVE.L	8(A6),-(A7)
	MOVE.L	G531_puc_D(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	D7,D0
	ADD.L	D0,G531_puc_D(A4)
	MOVE.L	D7,D0
	SUB.L	D0,G532_l_Dec(A4)
	MOVE	#1,D0
	BRA.S	L7
L9:
	MOVE.L	8(A6),-(A7)
	MOVE.L	D7,D0
	MOVE.L	D0,-(A7)
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	D7,D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
L7:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$6:	.EQU	#0
F416_xxxx_:/* global */
	LINK	A6,L$11
	MOVE.L	D7,-(A7)
	MOVE	12(A6),D0
	AND.L	#65535,D0
	MOVE.L	D0,D7
	CMPI.L	#0,D0
	BNE.S	L13
	MOVE	#1,D0
	BRA.S	L12
L13:
	MOVE.L	8(A6),-(A7)
	MOVE.L	D7,D0
	MOVE.L	D0,-(A7)
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#64,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	D7,D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
L12:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$11:	.EQU	#0
F417_xxxx_:/* global */
	LINK	A6,L$14
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	D7,D5
L16:
	ADD	(A3),D5
	MOVE	D7,D0
	EOR	D0,(A3)
	ADD	(A3)+,D5
	ADD	D6,D7
L17:
	SUBQ	#1,D6
	BNE.S	L16
L18:
	MOVE	D5,D0
L15:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$14:	.EQU	#0
F418_xxxx_:/* global */
	LINK	A6,L$19
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	D7,D5
L21:
	ADD	(A3),D5
	MOVE	(A3)+,D0
	EOR	D7,D0
	ADD	D0,D5
	ADD	D6,D7
L22:
	SUBQ	#1,D6
	BNE.S	L21
L23:
	MOVE	D5,D0
L20:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$19:	.EQU	#0
F419_xxxx_:/* global */
	LINK	A6,L$24
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L26
	MOVE	12(A6),D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	MOVE	14(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F417_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-10(A6)
	MOVE	16(A6),D0
	CMP	-10(A6),D0
	SEQ	D0
	TST.B	D0
L26:
	SNE	D0
	AND	#1,D0
L25:
	UNLK	A6
	RTS
L$24:	.EQU	#-10
F420_xxxx_:/* global */
	LINK	A6,L$27
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D0
	LSR	#1,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	14(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F417_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	16(A6),A0
	MOVE	D0,(A0)
	MOVE	12(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	D6,-(A7)
	MOVE	14(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F417_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
L28:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$27:	.EQU	#0
F421_xxxx_:/* global */
	LINK	A6,L$29
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE	16(A6),D7
	CLR	D6
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L31
	MOVE	#0,D0
	BRA.S	L30
L31:
	BRA.S	L32
L33:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	ADD	D0,D6
L32:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L33
L34:
	MOVE	D6,D0
	ADD	D0,(A2)
	MOVE	#1,D0
L30:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$29:	.EQU	#0
F422_xxxx_:/* global */
	LINK	A6,L$35
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE	16(A6),D7
	CLR	D6
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L37
	MOVE	#0,D0
	BRA.S	L36
L37:
	BRA.S	L38
L39:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	ADD	D0,D6
L38:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L39
L40:
	MOVE	D6,D0
	ADD	D0,(A2)
	MOVE	#1,D0
L36:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$35:	.EQU	#0
F423_xxxx_:/* global */
	LINK	A6,L$41
CODE SEG "init!"
	LEA	10G535_auc(A4),A1
	MOVE.B	#1,(A1)+
	MOVE.B	#2,(A1)+
	MOVE.B	#4,(A1)+
	MOVE.B	#8,(A1)+
	MOVE.B	#16,(A1)+
	MOVE.B	#32,(A1)+
	MOVE.B	#64,(A1)+
	MOVE.B	#-128,(A1)+
BSS SEG "bss"
10G535_auc:
	.WORD	#8
CODE SEG "start"
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-(A7)
	MOVE.L	#2048,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A3
	MOVE	#2048,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	D7
	BRA.S	L43
L44:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BEQ.S	L47
L48:
	MOVE	D5,D6
	AND	#1023,D6
	MOVE	D5,D4
	AND	#15360,D4
	LSR	#2,D4
	LSR	#8,D4
	ASL	#7,D4
	MOVE	D6,D1
	ASR	#3,D1
	ADD	D1,D4
	MOVE	D6,D0
	AND	#7,D0
	LEA	10G535_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	D6,D0
	BEQ.S	L51
	BRA.S	L49
L51:
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	OR	D6,D0
	MOVE.B	D0,(A0)
L49:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE.S	L48
L50:
L47:
L45:
	ADDQ	#1,D7
L43:
	MOVE	D7,D0
	MOVE.L	G278_ps_Du(A4),A0
	CMP	10(A0),D0
	BCS.S	L44
L46:
	MOVE.L	G284_apuc_+16(A4),D0
	MOVE.L	D0,A2
	CLR	D7
	BRA.S	L52
L53:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L55
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	MOVE	D0,D5
	CMPI	#-2,D0
	BEQ.S	L55
L56:
	MOVE	D5,D6
	AND	#1023,D6
	MOVE	D5,D4
	AND	#15360,D4
	LSR	#2,D4
	LSR	#8,D4
	ASL	#7,D4
	MOVE	D6,D1
	ASR	#3,D1
	ADD	D1,D4
	MOVE	D6,D0
	AND	#7,D0
	LEA	10G535_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	D6,D0
	BEQ.S	L59
	BRA.S	L57
L59:
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	OR	D6,D0
	MOVE.B	D0,(A0)
L57:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE.S	L56
L58:
L55:
	ADDA.L	#16,A2
	ADDQ	#1,D7
L52:
	MOVE	D7,D0
	MOVE.L	G278_ps_Du(A4),A0
	CMP	20(A0),D0
	BCS	L53(PC)
L54:
	MOVE.L	G284_apuc_+36(A4),D0
	MOVE.L	D0,A2
	CLR	D7
	BRA	L60(PC)
L61:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	CMPI	#-1,(A0)
	BEQ	L63(PC)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	MOVE	D0,D5
	CMPI	#-2,D0
	BEQ	L63(PC)
	MOVE	#-1,-8(A6)
L64:
	MOVE	D5,D6
	AND	#1023,D6
	MOVE	D5,D4
	AND	#15360,D4
	LSR	#2,D4
	LSR	#8,D4
	ASL	#7,D4
	MOVE	D6,D1
	ASR	#3,D1
	ADD	D1,D4
	MOVE	D6,D0
	AND	#7,D0
	LEA	10G535_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	D6,D0
	BEQ.S	L67
	CMPI	#-1,-8(A6)
	BNE.S	L68
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	#-2,2(A0)
	BRA.S	L69
L68:
	MOVE	-8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE.L	-12(A6),A0
	MOVE	#-2,(A0)
L69:
	BRA.S	L66
L67:
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	OR	D6,D0
	MOVE.B	D0,(A0)
	MOVE	D5,-8(A6)
L65:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE	L64(PC)
L66:
L63:
	ADDQ.L	#8,A2
	ADDQ	#1,D7
L60:
	MOVE	D7,D0
	MOVE.L	G278_ps_Du(A4),A0
	CMP	30(A0),D0
	BCS	L61(PC)
L62:
	MOVE.L	G284_apuc_+28(A4),D0
	MOVE.L	D0,A2
	CLR	D7
	BRA.S	L70
L71:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L73
	MOVE.L	A2,D6
	MOVE.L	D6,A0
	MOVE	2(A0),D6
	AND	#1023,D6
	MOVE	#256,D4
	MOVE	D6,D1
	ASR	#3,D1
	ADD	D1,D4
	MOVE	D6,D0
	AND	#7,D0
	LEA	10G535_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	D6,D0
	BEQ.S	L74
	BRA.S	L9T423_022
L74:
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	OR	D6,D0
	MOVE.B	D0,(A0)
L73:
L9T423_022:
	ADDQ.L	#4,A2
	ADDQ	#1,D7
L70:
	MOVE	D7,D0
	MOVE.L	G278_ps_Du(A4),A0
	CMP	26(A0),D0
	BCS.S	L71
L72:
	MOVE.L	G284_apuc_+56(A4),D0
	MOVE.L	D0,A2
	CLR	D7
	BRA	L75(PC)
L76:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L78
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE.S	L79
	BRA.S	L9T423_028
L79:
	CMPI	#-1,D5
	BNE.S	L80
	BRA.S	L9T423_028
L80:
	MOVE	D5,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BEQ.S	L81
	MOVE	D5,D6
	AND	#1023,D6
	MOVE	D5,D4
	AND	#15360,D4
	LSR	#2,D4
	LSR	#8,D4
	ASL	#7,D4
	MOVE	D6,D1
	ASR	#3,D1
	ADD	D1,D4
	MOVE	D6,D0
	AND	#7,D0
	LEA	10G535_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	D6,D0
	BEQ.S	L82
	BRA.S	L9T423_028
L82:
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	OR	D6,D0
	MOVE.B	D0,(A0)
L81:
L78:
L9T423_028:
	ADDQ.L	#8,A2
	ADDQ	#1,D7
L75:
	MOVE	D7,D0
	MOVE.L	G278_ps_Du(A4),A0
	CMP	40(A0),D0
	BCS	L76(PC)
L77:
	CLR	D6
	BRA	L83(PC)
L84:
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+212(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	CLR	D7
	BRA.S	L87
L88:
	MOVE	D7,D5
	MOVE.L	A2,D1
	ASL.L	#1,D5
	MOVE.L	D1,A0
	ADDA	D5,A0
	MOVE	(A0),D5
	CMPI	#-1,D5
	BEQ.S	L91
	MOVE	D5,D4
	AND	#1023,D4
	MOVE	D5,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	ASL	#7,D0
	MOVE	D4,D1
	ASR	#3,D1
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D4,D0
	AND	#7,D0
	LEA	10G535_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	MOVE.L	A3,A0
	ADDA	-2(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	D4,D0
	BEQ.S	L92
	MOVE	D7,D0
	MOVE.L	A2,D1
	ASL.L	#1,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L89
L92:
	MOVE.L	A3,A0
	ADDA	-2(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	OR	D4,D0
	MOVE.B	D0,(A0)
L91:
L89:
	ADDQ	#1,D7
L87:
	CMPI	#30,D7
	BLT.S	L88
L90:
L85:
	ADDQ	#1,D6
L83:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L84(PC)
L86:
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BEQ.S	L93
	MOVE	D5,D7
	AND	#1023,D7
	MOVE	D5,D6
	AND	#15360,D6
	LSR	#2,D6
	LSR	#8,D6
	ASL	#7,D6
	MOVE	D7,D1
	ASR	#3,D1
	ADD	D1,D6
	MOVE	D7,D0
	AND	#7,D0
	LEA	10G535_auc(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	MOVE.L	A3,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	D7,D0
	BEQ.S	L94
	MOVE	#-1,G414_T_Lea(A4)
	BRA.S	L95
L94:
	MOVE.L	A3,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	OR	D7,D0
	MOVE.B	D0,(A0)
L95:
L93:
	MOVE.L	#2048,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L42:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$41:	.EQU	#-12
