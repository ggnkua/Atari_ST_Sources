BSS SEG "bss"
G630_i_Gra:/* global */
	.WORD	#2
G631_i_Gra:/* global */
	.WORD	#2
G632_ui_Gr:/* global */
	.WORD	#2
G633_l_Gra:/* global */
	.WORD	#4
G634_pui_G:/* global */
	.WORD	#4
G635_pui_G:/* global */
	.WORD	#4
G636_ppuc_:/* global */
	.WORD	#4
G637_pi_Na:/* global */
	.WORD	#4
G638_pi_De:/* global */
	.WORD	#4
G639_pi_De:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#-1,G640_i_Flo(A4)
BSS SEG "bss"
G640_i_Flo:/* global */
	.WORD	#2
G641_puc_C:/* global */
	.WORD	#4
G642_puc_G:/* global */
	.WORD	#4
G643_puc_F:/* global */
	.WORD	#4
G645_puc_H:/* global */
	.WORD	#4
G646_puc_A:/* global */
	.WORD	#4
G647_l_Unr:/* global */
	.WORD	#4
G648_l_Ava:/* global */
	.WORD	#4
G649_puc_G:/* global */
	.WORD	#4
G650_puc_G:/* global */
	.WORD	#4
G651_puc_C:/* global */
	.WORD	#4
G652_puc_A:/* global */
	.WORD	#4
G653_l_Ava:/* global */
	.WORD	#4
G654_B_Gra:/* global */
	.WORD	#2
G655_ppuc_:/* global */
	.WORD	#4
G656_l_Ava:/* global */
	.WORD	#4
G657_puc_F:/* global */
	.WORD	#4
G658_puc_F:/* global */
	.WORD	#4
G659_puc_L:/* global */
	.WORD	#4
G660_puc_F:/* global */
	.WORD	#4
G661_B_Lar:/* global */
	.WORD	#2
G662_l_Las:/* global */
	.WORD	#4
CODE SEG "memory"
F467_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	#2,D6
	MOVE	G632_ui_Gr(A4),D1
	ASL	#2,D1
	ADD	D1,D6
	AND.L	#65535,D6
	CLR	D5
	BRA.S	L2
L3:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	ADD.L	D0,D6
L4:
	ADDQ	#1,D5
L2:
	MOVE	D5,D0
	CMP	D7,D0
	BCS.S	L3
L5:
	MOVE.L	D6,D0
L1:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F468_ozzz_:/* global */
	LINK	A6,L$6
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L8
	ADDQ.L	#1,D7
L8:
	CMPI	#1,12(A6)
	BNE.S	L9
	MOVE.L	G653_l_Ava(A4),D0
	CMP.L	D7,D0
	BLT.S	L9
	MOVE.L	D7,D0
	SUB.L	D0,G653_l_Ava(A4)
	MOVE.L	G652_puc_A(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G652_puc_A(A4)
	BRA.S	L10
L9:
	MOVE.L	D7,D0
	CMP.L	G648_l_Ava(A4),D0
	BLE.S	L11
	MOVE	#40,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L11:
	CMPI	#2,12(A6)
	BNE.S	L12
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	G648_l_Ava(A4),D0
	MOVE.L	D0,A3
	BRA.S	L13
L12:
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	D7,D0
	MOVE.L	D0,G646_puc_A(A4)
	MOVE.L	D0,A3
L13:
	MOVE.L	D7,D0
	SUB.L	D0,G648_l_Ava(A4)
L10:
	MOVE.L	A3,D0
L7:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$6:	.EQU	#0
F469_rzzz_:/* global */
	LINK	A6,L$14
	MOVE.L	D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L16
	ADDQ.L	#1,D7
L16:
	MOVE.L	D7,D0
	ADD.L	D0,G648_l_Ava(A4)
	MOVE.L	D7,D0
	ADD.L	D0,G646_puc_A(A4)
L15:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$14:	.EQU	#0
F470_xzzz_:/* global */
	LINK	A6,L$17
	MOVE.L	D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L19
	ADDQ.L	#1,D7
L19:
	MOVE.L	D7,D0
	ADD.L	D0,G648_l_Ava(A4)
L18:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$17:	.EQU	#0
F471_xxxx_:/* global */
	LINK	A6,L$20
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),-4(A6)
	CMPA.L	#0,A2
	BNE.S	L22
	CMPI.L	#0,-4(A6)
	BNE.S	L23
	CLR.L	G657_puc_F(A4)
	BRA.S	L24
L23:
	MOVE.L	-4(A6),G657_puc_F(A4)
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L24:
	BRA.S	L25
L22:
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	-4(A6),(A0)
	CMPI.L	#0,-4(A6)
	BEQ.S	L26
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
L26:
L25:
L21:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$20:	.EQU	#-4
F472_xxxx_:/* global */
	LINK	A6,L$27
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A2
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L29
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	#0,D0
	MOVE.L	A2,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	BRA	L30(PC)
L29:
	MOVE.L	G657_puc_F(A4),A3
	MOVE.L	A2,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	MOVE.L	D7,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L31
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	BRA.S	L32
L31:
	CLR	D6
	BRA.S	L33
L34:
	MOVE.L	D7,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L36
	MOVE.L	8(A6),D0
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	MOVE	#1,D6
	BRA.S	L35
L36:
	MOVE.L	A2,A3
L33:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	TST.L	D0
	BNE.S	L34
L35:
	MOVE	D6,D0
	BNE.S	L37
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	8(A6),(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L37:
L32:
L30:
L28:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$27:	.EQU	#-4
F473_xxxx_:/* global */
	LINK	A6,L$38
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	CLR	-4(A6)
	MOVE	12(A6),-2(A6)
	BRA.S	L40
L41:
	ADDQ	#1,-4(A6)
L40:
	MOVE	-2(A6),D0
	ASR	#1,D0
	MOVE	D0,-2(A6)
	BNE.S	L41
L42:
	MOVE	-4(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-2(A6)
	BRA	L43(PC)
L44:
	MOVE	#1,D0
	MOVE	-2(A6),D3
	ASL	D3,D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	ASL	#1,D0
	MOVE	D0,-8(A6)
	MOVE	-6(A6),D6
	BRA.S	L47
L48:
	MOVE	D6,D4
	MOVE	D4,D7
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
L51:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	CMP	12(A6),D0
	BCS.S	L54
	BRA.S	L53
L54:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	12(A6),D0
	BCC.S	L55
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L55
	ADDQ	#1,D5
L55:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L56
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L57
L56:
	BRA.S	L53
L57:
L52:
	BRA.S	L51
L53:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L49:
	ADDQ	#1,D6
L47:
	MOVE	D6,D0
	CMP	-8(A6),D0
	BLS.S	L48
L50:
L45:
	SUBQ	#1,-2(A6)
L43:
	CMPI	#0,-2(A6)
	BGE	L44(PC)
L46:
	MOVE	12(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	BRA	L58(PC)
L59:
	MOVE	-6(A6),D4
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	#0,D0
	MOVE	D0,D7
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	-6(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L62:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	MOVE	-6(A6),D1
	SUBQ	#1,D1
	CMP	D1,D0
	BLS.S	L65
	BRA.S	L64
L65:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	-6(A6),D0
	BCC.S	L66
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L66
	ADDQ	#1,D5
L66:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L67
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L68
L67:
	BRA.S	L64
L68:
L63:
	BRA.S	L62
L64:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L60:
	SUBQ	#1,-6(A6)
L58:
	CMPI	#1,-6(A6)
	BCC	L59(PC)
L61:
L39:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$38:	.EQU	#-8
F474_xxxx_:/* global */
	LINK	A6,L$69
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D7
	MOVE	8(A6),D5
	ASL.L	#1,D5
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE.L	D7,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D0,-2(A6)
	MOVE	-2(A6),D6
	EXT.L	D6
	ASL.L	#2,D6
	ASL.L	#8,D6
	BRA	L71(PC)
L72:
	MOVE	-2(A6),D0
	CMP	G640_i_Flo(A4),D0
	BEQ.S	L74
	MOVE	-2(A6),G640_i_Flo(A4)
	MOVE.L	G633_l_Gra(A4),D0
	SUB.L	D6,D0
	MOVE.L	D0,-8(A6)
	CMPI.L	#1024,D0
	BLE.S	L75
	MOVE.L	#1024,-8(A6)
L75:
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE.L	D6,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	G643_puc_F(A4),-(A7)
	MOVE.L	-8(A6),D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	-8(A6),D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
L74:
	MOVE.L	D7,D4
	SUB.L	D6,D4
	MOVE	#1024,D0
	SUB	D4,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	-4(A6),-(A7)
	MOVE.L	10(A6),-(A7)
	MOVE.L	G643_puc_F(A4),D0
	EXT.L	D4
	ADD.L	D4,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	SUB	-4(A6),D5
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,D7
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,10(A6)
	ADDQ	#1,-2(A6)
	ADD.L	#1024,D6
L71:
	CMPI	#0,D5
	BGT	L72(PC)
L73:
L70:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$69:	.EQU	#-8
F475_ozzz_:/* global */
	LINK	A6,L$76
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),D7
	MOVE.L	A3,D0
	MOVE.L	D0,G651_puc_C(A4)
	MOVE.L	D0,G641_puc_C(A4)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,G645_puc_H(A4)
	MOVE.L	D0,G646_puc_A(A4)
	MOVE.L	D7,G648_l_Ava(A4)
	MOVE.L	16(A6),G652_puc_A(A4)
	MOVE.L	20(A6),G653_l_Ava(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1024,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G643_puc_F(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5100,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G655_ppuc_(A4)
	MOVE	#5100,-(A7)
	MOVE.L	G655_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G638_pi_De(A4)
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#730,-(A7)
	MOVE.L	G638_pi_De(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G639_pi_De(A4)
	MOVE.L	#0,D0
	MOVE.L	D0,G657_puc_F(A4)
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G659_puc_L(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	#-1,G662_l_Las(A4)
L77:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$76:	.EQU	#0
F476_mzzz_:/* global */
	LINK	A6,L$78
	MOVE.L	G646_puc_A(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	CMPI.L	#370000,D0
	SGT	D0
	AND	#1,D0
	MOVE	D0,G661_B_Lar(A4)
	BEQ.S	L80
	JSR	F461_AA08_(PC)
L80:
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	#10000,D0
	MOVE.L	D0,G642_puc_G(A4)
	MOVE	#1,G654_B_Gra(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	D0,G650_puc_G(A4)
	MOVE.L	D0,G649_puc_G(A4)
	MOVE.L	#10000,G648_l_Ava(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,G656_l_Ava(A4)
L79:
	UNLK	A6
	RTS
L$78:	.EQU	#0
F477_izzz_:/* global */
	LINK	A6,L$81
	MOVE	G631_i_Gra(A4),D0
	ADDQ	#1,G631_i_Gra(A4)
	TST	D0
	BEQ.S	L83
	BRA.S	L82
L83:
DATA SEG "s!"
s!:
	DATA 41 3A 5C 47 52 41 50 48 49 43 53 2E 44 41 54 00 
CODE SEG "memory"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G630_i_Gra(A4)
	CMPI	#0,G630_i_Gra(A4)
	BGE.S	L84
	MOVE	#41,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L84:
L82:
	UNLK	A6
	RTS
L$81:	.EQU	#0
F478_gzzz_:/* global */
	LINK	A6,L$85
	SUBQ	#1,G631_i_Gra(A4)
	BEQ.S	L87
	BRA.S	L86
L87:
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
L86:
	UNLK	A6
	RTS
L$85:	.EQU	#0
F479_izzz_:/* global */
	LINK	A6,L$88
	MOVEM.L	D7-D6,-(A7)
	CLR	G631_i_Gra(A4)
	JSR	F477_izzz_(PC)
	PEA	G632_ui_Gr(A4)
	MOVE.L	#2,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CMPI.L	#2,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L96
	MOVE	G632_ui_Gr(A4),D0
	ASL	#1,D0
	MOVE	D0,D6
L96:
	SNE	D0
	TST.B	D0
	BEQ.S	L95
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G634_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L95:
	TST.B	D0
	BEQ.S	L94
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G635_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L94:
	TST.B	D0
	BEQ.S	L93
	MOVE.L	G634_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L93:
	TST.B	D0
	BEQ.S	L92
	MOVE.L	G635_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L92:
	TST.B	D0
	BEQ.S	L91
	MOVE	#1,-(A7)
	MOVE	D6,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G636_ppuc_(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L91:
	TST.B	D0
	BEQ.S	L90
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G637_pi_Na(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L90:
	AND	#1,D0
	MOVE	D0,D7
	MOVE	D7,D0
	BNE.S	L97
	BRA	L98(PC)
L97:
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	G636_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE.L	G637_pi_Na(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	SUBQ	#1,D6
	MOVE	D6,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,G633_l_Gra(A4)
	MOVE	#1,-(A7)
	MOVE.L	G635_pui_G(A4),A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G343_puc_G(A4)
	CMPI.L	#0,D0
	BNE.S	L99
	BRA.S	L100
L99:
	MOVE.L	G343_puc_G(A4),-(A7)
	CLR	-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L89
L100:
L98:
	MOVE	#42,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L89:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$88:	.EQU	#0
F480_AA07_:/* global */
	LINK	A6,L$101
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CMPI	#0,8(A6)
	BLT.S	L103
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L104
	BRA	L102(PC)
L104:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L105
L103:
	ANDI	#32767,8(A6)
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L106
	BRA	L102(PC)
L106:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L105:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	NEG.L	D7
	MOVE.L	D7,D0
	ADD.L	D0,G656_l_Ava(A4)
	MOVE.L	A3,D5
	ADDQ.L	#6,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	MOVE.L	A3,D4
	ADDQ.L	#8,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#-1,D5
	BNE.S	L107
	CMPI	#-1,D4
	BNE.S	L108
	CLR.L	G658_puc_F(A4)
	CLR.L	G659_puc_L(A4)
	CLR.L	G660_puc_F(A4)
	BRA.S	L109
L108:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),G658_puc_F(A4)
	MOVE.L	G658_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L110
	MOVE.L	G658_puc_F(A4),G660_puc_F(A4)
L110:
L109:
	BRA.S	L111
L107:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D4,(A0)
	CMPI	#-1,D4
	BNE.S	L112
	MOVE.L	A2,G659_puc_L(A4)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L113
	CLR.L	G660_puc_F(A4)
L113:
	BRA.S	L114
L112:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L115
	MOVE.L	A2,G660_puc_F(A4)
L115:
L114:
L111:
	MOVE.L	A3,D0
	CMP.L	G641_puc_C(A4),D0
	BEQ.S	L116
	MOVE.L	A3,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L116
	SUBA.L	D6,A3
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L116:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	CMP.L	G651_puc_C(A4),D0
	BNE.S	L117
	MOVE.L	A3,G651_puc_C(A4)
	BRA.S	L102
L117:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L118
	MOVE.L	A2,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L118:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
L102:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$101:	.EQU	#0
F481_xxxx_:/* global */
	LINK	A6,L$119
	BRA.S	L121
L122:
	CMPI.L	#0,G658_puc_F(A4)
	BNE.S	L124
	MOVE	#43,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L124:
	MOVE.L	G658_puc_F(A4),D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	(A0),-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L121:
	MOVE.L	G656_l_Ava(A4),D0
	CMP.L	8(A6),D0
	BLT.S	L122
L123:
L120:
	UNLK	A6
	RTS
L$119:	.EQU	#0
F482_xxxx_:/* global */
	LINK	A6,L$125
	MOVEM.L	A3-A2/D7-D5,-(A7)
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L127
	BRA	L126(PC)
L127:
	MOVE.L	G641_puc_C(A4),D0
	MOVE.L	D0,A2
	MOVE.L	D0,A3
L128:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D7
	CMPI.L	#0,D0
	BLE.S	L131
	ADDA.L	D7,A2
	BRA	L132(PC)
L131:
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	D0,D7
	MOVE.L	A2,D0
	CMP.L	A3,D0
	BEQ.S	L133
	MOVE.L	A2,D6
	ADD.L	#10,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	CMPI	#0,D6
	BLT.S	L134
	MOVE	D6,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L135
L134:
	MOVE	D6,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L135:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	D7,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G658_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L136
	MOVE.L	A3,G658_puc_F(A4)
L136:
	MOVE.L	G659_puc_L(A4),D0
	CMP.L	A2,D0
	BNE.S	L137
	MOVE.L	A3,G659_puc_L(A4)
L137:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L138
	MOVE.L	A3,G660_puc_F(A4)
L138:
L133:
	ADDA.L	D7,A2
	ADDA.L	D7,A3
L132:
L129:
	MOVE.L	A2,D0
	CMP.L	G651_puc_C(A4),D0
	BNE	L128(PC)
L130:
	MOVE.L	A3,G651_puc_C(A4)
	CLR.L	G657_puc_F(A4)
L126:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$125:	.EQU	#0
F483_xxxx_:/* global */
	LINK	A6,L$139
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G651_puc_C(A4),D1
	SUB.L	D1,D0
	CMP.L	D7,D0
	BLT.S	L141
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L142(PC)
L141:
	MOVE.L	G657_puc_F(A4),D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BGE.S	L143
	JSR	F482_xxxx_(PC)
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L144(PC)
L143:
	MOVE.L	G657_puc_F(A4),A3
	CLR	D6
L145:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BNE.S	L148
	MOVE	#1,D6
	BRA.S	L149
L148:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BLT.S	L151
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	CMPI.L	#0,D0
	BNE.S	L150
L151:
	MOVE.L	G657_puc_F(A4),A3
	MOVE	#1,D6
	BRA.S	L152
L150:
	MOVE.L	A2,A3
L152:
L149:
L146:
	MOVE	D6,D0
	BEQ.S	L145
L147:
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.L	(A0),D5
	SUB.L	D7,D5
	CMPI.L	#24,D5
	BLT.S	L153
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D5,D0
	MOVE.L	A2,D1
	ADD.L	D5,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L154
L153:
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
L154:
L144:
L142:
	MOVE.L	D7,D0
	SUB.L	D0,G656_l_Ava(A4)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D7,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D0
L140:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$139:	.EQU	#0
F484_gzzz_:/* global */
	LINK	A6,L$155
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-14(A6)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F473_xxxx_(PC)
	ADDQ.L	#6,A7
	CLR.L	-4(A6)
	CLR	D7
	BRA	L157(PC)
L158:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L161
L162:
	MOVE	12(A6),D0
	SUBQ	#1,12(A6)
	SUB	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L161:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,D6
	CMP	12(A6),D0
	BGE.S	L164
	MOVE	D5,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L162
L164:
L163:
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L165
	ADDQ.L	#1,D4
L165:
	MOVE.L	D4,D0
	ADD.L	D0,-4(A6)
L159:
	ADDQ	#1,D7
L157:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L158(PC)
L160:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L166
	MOVE.L	G649_puc_G(A4),D0
	SUB.L	-4(A6),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
	BRA.S	L167
L166:
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
L167:
	MOVE.L	G348_pl_Bi(A4),A0
	MOVE.L	-8(A6),32000(A0)
	MOVE.L	#19576,D0
	CMP.L	-8(A6),D0
	BLE.S	L168
	MOVE	#44,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L168:
	CLR	D7
	BRA.S	L169
L170:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L173
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L173:
L171:
	ADDQ	#1,D7
L169:
	CMPI	#730,D7
	BLT.S	L170
L172:
	MOVE	#0,D6
	MOVE	D6,D7
L174:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L177
L178:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	TST.L	D0
	BEQ.S	L180
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L181
	ADDQ.L	#1,D4
L181:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L180:
	ADDQ	#1,D6
L177:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L178
L179:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BEQ.S	L182
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L182:
L175:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L174(PC)
L176:
	BRA.S	L183
L184:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BEQ.S	L186
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L187
	ADDQ.L	#1,D4
L187:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L186:
	ADDQ	#1,D6
L183:
	MOVE	D6,D0
	CMP	G632_ui_Gr(A4),D0
	BCS.S	L184
L185:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L188
	MOVE.L	G650_puc_G(A4),D4
	MOVE.L	G649_puc_G(A4),D1
	SUB.L	-4(A6),D1
	SUB.L	D1,D4
	CMPI.L	#0,D4
	BLE.S	L189
	MOVE.L	D4,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
L189:
	JSR	F482_xxxx_(PC)
	MOVE.L	D4,D0
	SUB.L	D0,G656_l_Ava(A4)
L188:
	MOVE.L	G649_puc_G(A4),D0
	MOVE.L	D0,A2
	SUBQ.L	#2,D0
	MOVE.L	D0,A3
	BRA.S	L190
L191:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L193
	MOVE	D5,D0
	SUBQ	#2,D0
	EXT.L	D0
	ADDA.L	D0,A3
	BRA.S	L194
L193:
	MOVE.L	A3,D4
	MOVE	D5,D1
	ASL.L	#2,D1
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),D1
	SUB.L	D1,D4
	MOVE.L	D4,-24(A6)
	MOVE.L	#2,D4
	ADD.L	-24(A6),D4
	SUBA.L	D4,A2
	SUBA.L	D4,A3
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	CMP.L	A2,D0
	BEQ.S	L195
	MOVE.L	D4,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L195:
L194:
L190:
	MOVE.L	A3,D0
	CMP.L	G650_puc_G(A4),D0
	BGT.S	L191
L192:
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-12(A6)
	CLR	D7
	BRA	L196(PC)
L197:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L200
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA	L201(PC)
L200:
	MOVE.L	A2,D0
	SUBQ.L	#2,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L202
	ADDQ.L	#1,D4
L202:
	SUBA.L	D4,A2
	MOVE	-14(A6),D0
	BNE.S	L203
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE	#1,-14(A6)
L203:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L204
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D5,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	-12(A6),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	BRA.S	L205
L204:
	MOVE.L	A2,-(A7)
	MOVE	D5,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L205:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L201:
L198:
	ADDQ	#1,D7
L196:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L197(PC)
L199:
	MOVE	-14(A6),D0
	BEQ.S	L206
	JSR	F478_gzzz_(PC)
L206:
	MOVE.L	A2,G650_puc_G(A4)
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L207
	MOVE.L	G650_puc_G(A4),G642_puc_G(A4)
L207:
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L156:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$155:	.EQU	#-24
F485_xxxx_:/* global */
	LINK	A6,L$208
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	G313_ul_Ga(A4),G662_l_Las(A4)
	CLR.L	G660_puc_F(A4)
	MOVE.L	G659_puc_L(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L210
	BRA.S	L209
L210:
	BRA.S	L211
L212:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR	(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L214
	BRA.S	L209
L214:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
L211:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CMPI	#0,(A0)
	BNE.S	L212
L213:
L209:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$208:	.EQU	#0
F486_xxxx_:/* global */
	LINK	A6,L$215
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	CMPI.L	#0,G660_puc_F(A4)
	BNE.S	L217
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	CMPI.L	#0,G659_puc_L(A4)
	BNE.S	L218
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	A3,G658_puc_F(A4)
	BRA.S	L219
L218:
	MOVE.L	G659_puc_L(A4),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	G659_puc_L(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L220
	MOVE	D4,D6
	ASL.L	#1,D6
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	BRA.S	L221
L220:
	MOVE	D4,D6
	AND	#32767,D6
	ASL.L	#1,D6
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
L221:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L219:
	MOVE.L	A3,G659_puc_L(A4)
	BRA	L222(PC)
L217:
	MOVE.L	G660_puc_F(A4),D6
	ADDQ.L	#6,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	MOVE.L	G660_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	CMPI	#-1,D6
	BEQ.S	L223
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	BRA.S	L224
L223:
	MOVE.L	G660_puc_F(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L225
	MOVE	D4,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L226
L225:
	MOVE	D4,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L226:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A3,G658_puc_F(A4)
L224:
L222:
	MOVE.L	A3,G660_puc_F(A4)
L216:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$215:	.EQU	#0
F487_xxxx_:/* global */
	LINK	A6,L$227
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE.L	D0,-4(A6)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#0,D0
	BNE.S	L229
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L230
	MOVE.L	A3,G660_puc_F(A4)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	MOVE.L	A3,D0
	BRA	L228(PC)
L230:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L231
	MOVE.L	A2,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L232
L231:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L232:
	MOVE	D7,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	-4(A6),D0
	BRA	L228(PC)
L229:
	MOVE	D4,D0
	ADDQ	#1,D0
	MOVE	D0,D4
	MOVE.L	A3,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A3,D0
	CMP.L	G659_puc_L(A4),D0
	BNE.S	L233
	MOVE.L	A3,D0
	BRA	L228(PC)
L233:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L234
	MOVE.L	A3,D0
	BRA	L228(PC)
L234:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L235
	MOVE.L	A2,D0
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L236
L235:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L237
	MOVE.L	A2,G660_puc_F(A4)
L237:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L236:
L238:
	MOVE.L	A2,A3
	MOVE	D5,D6
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L241
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	-4(A6),D0
	MOVE.L	D0,G659_puc_L(A4)
	BRA.S	L228
L241:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L242
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	BRA.S	L228
L242:
L239:
	MOVE	#1,D0
	BNE	L238(PC)
L240:
L228:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$227:	.EQU	#-4
F488_bzzz_:/* global */
	LINK	A6,L$243
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	10(A6),A3
	MOVE	8(A6),D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
L244:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$243:	.EQU	#0
F489_ayzz_:/* global */
	LINK	A6,L$245
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#-32768,D0
	BEQ.S	L247
	MOVE	D7,D0
	AND	#32767,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	BRA	L246(PC)
L247:
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L248
	JSR	F485_xxxx_(PC)
L248:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L249
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	ADD.L	#12,D0
	BRA	L246(PC)
L249:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	ASR	#1,D5
	MOVE.L	A2,D1
	ADDQ.L	#2,D1
	MOVE.L	D1,A0
	MULS	(A0),D5
	MOVE	D5,-10(A6)
	MOVE	#16,D5
	ADD	-10(A6),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L251:
L250:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L251
L252:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE	D6,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	ADDA.L	#12,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	A3,D0
L246:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$245:	.EQU	#-10
F490_lzzz_:/* global */
	LINK	A6,L$253
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	JSR	F477_izzz_(PC)
	MOVE	D7,D6
	AND	#-32768,D6
	AND	#32767,D7
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ	L255(PC)
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D7,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L256
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L256:
	BRA.S	L257
L255:
	MOVE	D6,D0
	BEQ.S	L258
	MOVE.L	A3,D0
	BRA.S	L259
L258:
	MOVE.L	G296_puc_B(A4),D0
L259:
	MOVE.L	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L257:
	MOVE	D6,D0
	BNE.S	L260
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE	#1,G297_B_Dra(A4)
L260:
	JSR	F478_gzzz_(PC)
L254:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$253:	.EQU	#0
F491_xzzz_:/* global */
	LINK	A6,L$261
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L263
	JSR	F485_xxxx_(PC)
L263:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L264
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D0
	BRA.S	L262
L264:
	MOVE	#16,D5
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	ADD	(A0),D5
	AND.L	#65535,D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L266:
L265:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L266
L267:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE.L	A3,D1
	ADD.L	#10,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE	#0,D0
L262:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$261:	.EQU	#0
F492_mzzz_:/* global */
	LINK	A6,L$268
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	ADD.L	#12,D0
L269:
	UNLK	A6
	RTS
L$268:	.EQU	#0
F493_hzzz_:/* global */
	LINK	A6,L$270
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
L271:
	UNLK	A6
	RTS
L$270:	.EQU	#0
F494_ozzz_:/* global */
	LINK	A6,L$272
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L273:
	UNLK	A6
	RTS
L$272:	.EQU	#0
