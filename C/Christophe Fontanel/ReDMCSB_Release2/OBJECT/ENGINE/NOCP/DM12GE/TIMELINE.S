BSS SEG "bss"
G369_ui_Ev:/* global */
	.WORD	#2
G370_ps_Ev:/* global */
	.WORD	#4
G371_pi_Ti:/* global */
	.WORD	#4
G372_ui_Ev:/* global */
	.WORD	#2
G373_ui_Fi:/* global */
	.WORD	#2
G374_l_Wat:/* global */
	.WORD	#4
CODE SEG "timeline"
F233_wzzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3/D7,-(A7)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G370_ps_Ev(A4)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G371_pi_Ti(A4)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L2
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L3
L4:
	CLR.B	4(A3)
L5:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#10,A3
L3:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L4
L6:
	CLR	G372_ui_Ev(A4)
	CLR	G373_ui_Fi(A4)
	JSR	F256_xxxx_(PC)
L2:
L1:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F234_xxxx_:/* global */
	LINK	A6,L$7
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVEQ	#1,D0
	MOVE.L	#16777215,D1
	MOVE.L	(A3)+,D2
	AND.L	D1,D2
	AND.L	(A2)+,D1
	CMP.L	D1,D2
	BLT.S	L1T234_005_
	BNE.S	L1T234_001
	MOVE	(A3),D2
	CMP	(A2),D2
	BHI.S	L1T234_005_
	BNE.S	L1T234_001
	CMPA.L	A3,A2
	BCC.S	L1T234_005_
L1T234_001:
	MOVEQ	#0,D0
L1T234_005_:
L8:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$7:	.EQU	#0
F235_bzzz_:/* global */
	LINK	A6,L$9
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,A3
	BRA.S	L11
L12:
	MOVE	(A3)+,D0
	CMP	D7,D0
	BNE.S	L15
	BRA.S	L14
L15:
L13:
	ADDQ	#1,D6
L11:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L12
L14:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L16
	CLR	D6
L16:
	MOVE	D6,D0
L10:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$9:	.EQU	#0
F236_pzzz_:/* global */
	LINK	A6,L$17
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D4
	CMPI	#1,D0
	BNE.S	L19
	BRA	L18(PC)
L19:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	-2(A6)
	BRA.S	L20
L21:
	MOVE	D7,D6
	SUBQ	#1,D6
	LSR	#1,D6
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L23
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	MOVE	#1,-2(A6)
	BRA.S	L20
L23:
	BRA.S	L22
L20:
	CMPI	#0,D7
	BHI.S	L21
L22:
	MOVE	-2(A6),D0
	BEQ.S	L24
	BRA	L3T236_011(PC)
L24:
	MOVE	D4,D0
	SUBQ	#1,D0
	SUBQ	#1,D0
	LSR	#1,D0
	MOVE	D0,D4
	BRA	L25(PC)
L26:
	MOVE	D7,D6
	ASL	#1,D6
	ADDQ	#1,D6
	MOVE	D6,D0
	ADDQ	#1,D0
	CMP	G372_ui_Ev(A4),D0
	BCC.S	L28
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L28
	ADDQ	#1,D6
L28:
	MOVE.L	A3,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L29
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	BRA.S	L25
L29:
	BRA.S	L27
L25:
	MOVE	D7,D0
	CMP	D4,D0
	BLS	L26(PC)
L27:
L3T236_011:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
L18:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$17:	.EQU	#-2
F237_rzzz_:/* global */
	LINK	A6,L$30
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	CLR.B	4(A0)
	MOVE	D7,D0
	CMP	G373_ui_Fi(A4),D0
	BCC.S	L32
	MOVE	D7,G373_ui_Fi(A4)
L32:
	SUBQ	#1,G372_ui_Ev(A4)
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L33
	BRA.S	L31
L33:
	MOVE	D7,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	D6,D0
	CMP	D5,D0
	BNE.S	L34
	BRA.S	L31
L34:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L31:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$30:	.EQU	#0
F238_pzzz_:/* global */
	LINK	A6,L$35
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	G372_ui_Ev(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L37
	MOVE	#45,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L37:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#5,D0
	BLT	L38(PC)
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#10,D0
	BGT	L38(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA	L39(PC)
L40:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#5,D0
	BLT.S	L43
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BGT.S	L43
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L44
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L44
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#6,D0
	BNE.S	L45
	MOVE.B	8(A2),D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BNE.S	L44
L45:
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L36(PC)
L44:
	BRA.S	L41
	BRA.S	L46
L43:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L47
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L47
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L47
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L48
	MOVE	#1,D0
	MOVE.B	9(A2),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A3)
L48:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L42
L47:
L46:
L41:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L39:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS	L40(PC)
L42:
	BRA	L49(PC)
L38:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#1,D0
	BNE	L50(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L51
L52:
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L55
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L55
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L56
	MOVE.B	9(A2),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L57
	MOVE	#1,D0
	MOVE.B	9(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A2)
L57:
	MOVE	D7,D0
	BRA	L36(PC)
L56:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L58
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L36(PC)
L58:
L55:
L53:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L51:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L52
L54:
	BRA.S	L59
L50:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L60
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L61
L62:
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L65
	MOVE.L	(A3),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE.L	(A2),D1
	MOVE.L	#24,D3
	ASR.L	D3,D1
	CMP	D1,D0
	BNE.S	L65
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BEQ.S	L67
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L66
L67:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L66:
L65:
L63:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L61:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L62
L64:
L60:
L59:
L49:
	LEA	(A3),A1
	MOVE	G373_ui_Fi(A4),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
L68:
	MOVE	G373_ui_Fi(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L71
	BRA.S	L70
L71:
	ADDQ	#1,G373_ui_Fi(A4)
L69:
	MOVE	G373_ui_Fi(A4),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L68
L70:
	MOVE	G372_ui_Ev(A4),D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	G372_ui_Ev(A4),D0
	ADDQ	#1,G372_ui_Ev(A4)
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
L36:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$35:	.EQU	#0
F239_xxxx_:/* global */
	LINK	A6,L$72
	MOVE	D7,-(A7)
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MOVE	D0,D7
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	MOVE.L	8(A6),A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L73:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$72:	.EQU	#0
F240_xxxx_:/* global */
	LINK	A6,L$74
	MOVE	G372_ui_Ev(A4),D0
	BEQ.S	L76
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	AND.L	#16777215,D0
	MOVE.L	G313_ul_Ga(A4),D1
	CMP.L	D1,D0
	SLE	D0
	TST.B	D0
L76:
	SNE	D0
	AND	#1,D0
L75:
	UNLK	A6
	RTS
L$74:	.EQU	#0
F241_xxxx_:/* global */
	LINK	A6,L$77
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D4
	CMPI	#5,D0
	BNE.S	L79
	BRA	L78(PC)
L79:
	ADDQ.L	#1,(A3)
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#1,D5
	BNE	L80(PC)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#32,D0
	LSR	#5,D0
	MOVE	D0,-10(A6)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE	L81(PC)
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L81
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L81
	CMPI	#0,D4
	BEQ.S	L81
	CMPI	#0,G305_ui_Pa(A4)
	BLS.S	L82
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#0,D0
	MOVE.B	D0,(A2)
	MOVE	#2,-(A7)
	MOVE	#8,D0
	OR	-10(A6),D0
	BEQ.S	L84
	MOVE	#4,D0
	BRA.S	L85
L84:
	MOVE	#3,D0
L85:
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L83
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#18,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L83:
L82:
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L78(PC)
L81:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-6(A6)
	CMPI	#-2,D0
	BEQ	L86(PC)
	MOVE	-6(A6),-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-8(A6)
	AND	#64,D0
	BNE	L86(PC)
	MOVE	D4,D0
	MOVE	-10(A6),D1
	BEQ.S	L88
	MOVE	-8(A6),D1
	LSR	#7,D1
	AND	#3,D1
	BRA.S	L89
L88:
	MOVE	#1,D1
L89:
	CMP	D1,D0
	BCS.S	L87
	MOVE	#1,-(A7)
	MOVE	#5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	CMPI	#2,D0
	BEQ.S	L90
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L90:
	CMPI	#0,D4
	BNE.S	L91
	MOVE	#0,D0
	BRA.S	L92
L91:
	MOVE	D4,D0
	SUBQ	#1,D0
L92:
	MOVE	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#4,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L78
L87:
L86:
L80:
	CMPI	#0,D5
	BNE.S	L95
	CMPI	#0,D4
	BEQ.S	L94
L95:
	CMPI	#1,D5
	BNE.S	L93
	CMPI	#4,D4
	BNE.S	L93
L94:
	BRA.S	L78
L93:
	CMPI	#0,D5
	BNE.S	L96
	MOVE	#-1,D0
	BRA.S	L97
L96:
	MOVE	#1,D0
L97:
	ADD	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#2,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	CMPI	#0,D5
	BNE.S	L98
	CMPI	#0,D4
	BNE.S	L99
	BRA.S	L78
L99:
	BRA.S	L100
L98:
	CMPI	#4,D4
	BNE.S	L101
	BRA.S	L78
L101:
L100:
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L78:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$77:	.EQU	#-10
F242_xxxx_:/* global */
	LINK	A6,L$102
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#2,D5
	BNE.S	L104
	MOVE.B	(A2),D5
	AND	#255,D5
	AND	#4,D5
	BEQ.S	L105
	MOVE	#1,D5
	BRA.S	L106
L105:
	MOVE	#0,D5
L106:
L104:
	CMPI	#1,D5
	BNE.S	L107
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L108
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L108
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L108
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L109
L108:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L110
	MOVE	D4,-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#64,D0
	BNE.S	L110
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L111
L110:
	ANDI.B	#-5,(A2)
L111:
L109:
	BRA.S	L112
L107:
	ORI.B	#4,(A2)
L112:
L103:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$102:	.EQU	#0
F243_xxxx_:/* global */
	LINK	A6,L$113
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#5,D0
	MOVE.B	D0,(A2)
L114:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$113:	.EQU	#0
F244_xxxx_:/* global */
	LINK	A6,L$115
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D7
	CMPI	#5,D0
	BNE.S	L117
	BRA.S	L116
L117:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L118
	CMPI	#0,D7
	BNE.S	L119
	MOVE	#1,D0
	BRA.S	L120
L119:
	MOVE	#0,D0
L120:
	MOVE.B	D0,9(A3)
	BRA.S	L121
L118:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L122
	CMPI	#0,D7
	BNE.S	L123
	BRA.S	L116
L123:
	BRA.S	L124
L122:
	CMPI	#4,D7
	BNE.S	L125
	BRA.S	L116
L125:
L124:
L121:
	MOVE.B	#1,4(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L116:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$115:	.EQU	#0
F245_xxxx_:/* global */
	LINK	A6,L$126
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L128(PC)
L129:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D7
	CMPI	#2,D0
	BNE	L132(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D6
	AND	#1,D6
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L133
	MOVE	D6,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L134
L133:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L134:
	MOVE	D6,D0
	BNE.S	L135
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	BEQ.S	L135
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L135
	MOVE	-6(A6),D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L135
	MOVE	-8(A6),D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L135
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	PEA	G353_ac_St(A4)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L135:
	BRA	L136(PC)
L132:
	CMPI	#3,D7
	BNE	L137(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#6,D0
	BNE	L138(PC)
	MOVE	4(A2),D5
	AND	#1920,D5
	LSR	#7,D5
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L139
	JSR	F027_AA59_(PC)
	MOVE	D5,D1
	AND	#7,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D5
	BRA.S	L140
L139:
	SUBQ	#1,D5
L140:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BNE.S	L141
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-10(A6)
L141:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	2(A2),D0
	LSR	#7,D0
	MOVE	D0,-(A7)
	JSR	F185_auzz_(PC)
	ADDA	#12,A7
	MOVE	4(A2),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L142
	MOVE	#1,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L142:
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L143
	ANDI	#-128,2(A2)
	BRA.S	L144
L143:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#4,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BEQ.S	L145
	ANDI	#-128,2(A2)
	CMPI	#127,-10(A6)
	BLS.S	L146
	MOVE	-10(A6),D0
	SUB	#126,D0
	ASL	#6,D0
	MOVE	D0,-10(A6)
L146:
	MOVE.B	#65,-16(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	CLR.B	-15(A6)
	MOVE	-6(A6),D0
	MOVE.B	D0,-14(A6)
	MOVE	-8(A6),D0
	MOVE.B	D0,-13(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L145:
L144:
L138:
L137:
L136:
L130:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L128:
	CMPI	#-2,D4
	BNE	L129(PC)
L131:
L127:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$126:	.EQU	#-20
F246_xxxx_:/* global */
	LINK	A6,L$147
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L149
L150:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L153
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#0,D0
	BNE.S	L154
	ORI	#6,2(A2)
	BRA.S	L148
L154:
L153:
L151:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L149:
	CMPI	#-1,D7
	BNE.S	L150
L152:
L148:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$147:	.EQU	#0
F247_xxxx_:/* global */
	LINK	A6,L$155
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	MOVE.B	8(A2),D5
	AND	#255,D5
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-6(A6)
	MOVE	2(A3),D4
	AND	#127,D4
	MOVE	2(A3),D0
	LSR	#7,D0
	MOVE	D0,-8(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-12(A6)
	CMPI	#7,D4
	SEQ	D0
	TST.B	D0
	BNE.S	L158
	CMPI	#8,D4
	SEQ	D0
	TST.B	D0
L158:
	TST.B	D0
	BNE.S	L157
	CMPI	#14,D4
	SEQ	D0
	TST.B	D0
L157:
	AND	#1,D0
	MOVE	D0,-14(A6)
	CMPI	#8,D4
	BEQ.S	L160
	CMPI	#10,D4
	BNE.S	L159
L160:
	MOVE	-8(A6),D7
	ADD	#-128,D7
	MOVE	D7,D6
	BRA	L161(PC)
L159:
	CMPI	#14,D4
	BEQ.S	L163
	CMPI	#15,D4
	BNE	L162(PC)
L163:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L164
L165:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L168
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L169
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L168
L169:
	BRA.S	L167
L168:
L166:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L164:
	CMPI	#-1,D7
	BNE.S	L165
L167:
	CMPI	#-1,D7
	BNE.S	L170
	BRA	L156(PC)
L170:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-14(A6),D0
	BNE.S	L171
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA.S	L172
L173:
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L176
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L177
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L176
L177:
	BRA.S	L175
L176:
L174:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L172:
	CMPI	#-1,D6
	BNE.S	L173
L175:
	CMPI	#-1,D6
	BNE.S	L178
	MOVE	#1,-14(A6)
	BRA.S	L179
L178:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L179:
L171:
	BRA.S	L180
L162:
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L181
	BRA	L156(PC)
L181:
	MOVE	-14(A6),D0
	BNE.S	L182
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L182
	MOVE	#1,-14(A6)
L182:
L180:
L161:
	MOVE	-14(A6),D0
	BEQ.S	L183
	JSR	F028_a000_(PC)
	MOVE	D0,-26(A6)
	MOVE	-6(A6),D0
	ADD	-26(A6),D0
	AND	#3,D0
	MOVE	D0,-6(A6)
L183:
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	#1,G365_B_Cre(A4)
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	-14(A6),D0
	BNE.S	L184
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L184:
	CLR	G365_B_Cre(A4)
L156:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$155:	.EQU	#-26
F248_xxxx_:/* global */
	LINK	A6,L$185
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE.B	8(A3),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	BRA	L187(PC)
L188:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#2,D0
	BNE	L190(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L190
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L191
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L192
L191:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L192:
	BRA	L193(PC)
L190:
	CMPI	#3,D6
	BNE	L194(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D0,-6(A6)
	MOVE	2(A2),D4
	LSR	#7,D4
	CMPI	#6,-6(A6)
	BNE	L195(PC)
	CMPI	#0,D4
	BLS	L196(PC)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L197
	CMPI	#511,D4
	BCC.S	L198
	ADDQ	#1,D4
L198:
	BRA.S	L199
L197:
	SUBQ	#1,D4
L199:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L200
	CMPI	#0,D4
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L201
	MOVE	#0,D0
	BRA.S	L202
L201:
	MOVE	#1,D0
L202:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L203
L200:
	CMPI	#0,D4
	BNE.S	L204
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L204:
L203:
L196:
	BRA	L205(PC)
L195:
	CMPI	#5,-6(A6)
	BNE	L206(PC)
	MOVE	#1,D5
	MOVE.B	8(A3),D3
	ASL	D3,D5
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L207
	MOVE	D4,D0
	AND	D5,D0
	BEQ.S	L208
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L209
L208:
	OR	D5,D4
L209:
	BRA.S	L210
L207:
	MOVE.B	9(A3),D0
	BEQ.S	L211
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L212
L211:
	OR	D5,D4
L212:
L210:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	D4,D5
	AND	#15,D5
	MOVE	D4,D1
	AND	#240,D1
	LSR	#4,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L213
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L214
	MOVE	#0,D0
	BRA.S	L215
L214:
	MOVE	#1,D0
L215:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L216
L213:
	MOVE	D5,D0
	BEQ.S	L217
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L217:
L216:
	BRA.S	L218
L206:
	CMPI	#7,-6(A6)
	BCS.S	L221
	CMPI	#10,-6(A6)
	BLS.S	L220
L221:
	CMPI	#14,-6(A6)
	BEQ.S	L220
	CMPI	#15,-6(A6)
	BNE.S	L219
L220:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L219
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F247_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L222
	ANDI	#-128,2(A2)
L222:
L219:
L218:
L205:
L194:
L193:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L187:
	CMPI	#-2,D7
	BNE	L188(PC)
L189:
	JSR	F271_xxxx_(PC)
L186:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$185:	.EQU	#-12
F249_xxxx_:/* global */
	LINK	A6,L$223
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L225
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L225
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L225
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	JSR	F296_aizz_(PC)
L225:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L226(PC)
L227:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	D4,D5
	AND	#15360,D5
	LSR	#2,D5
	LSR	#8,D5
	CMPI	#4,D5
	BCS.S	L229
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L229:
	CMPI	#14,D5
	BNE	L230(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	6(A3),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	G397_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,8(A2)
	OR	D3,8(A2)
	MOVE	G398_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,8(A2)
	OR	D3,8(A2)
	MOVE	G400_i_Mov(A4),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-3073,8(A2)
	OR	D3,8(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,6(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	BRA	L231(PC)
L230:
	CMPI	#15,D5
	BNE.S	L232
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L233
L234:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#25,D0
	BNE.S	L237
	MOVE	8(A2),D0
	CMP	D4,D0
	BNE.S	L237
	MOVE	G397_i_Mov(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G398_i_Mov(A4),D0
	MOVE.B	D0,7(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,8(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
L237:
L235:
	MOVE.L	A2,D0
	ADDA	#10,A2
	MOVE	D5,D0
	ADDQ	#1,D5
L233:
	MOVE	D5,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L234
L236:
L232:
L231:
	MOVE	-2(A6),D4
L226:
	CMPI	#-2,D4
	BNE	L227(PC)
L228:
L224:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$223:	.EQU	#-2
F250_xxxx_:/* global */
	LINK	A6,L$238
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L240
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L241
	MOVE	#1,D0
	BRA.S	L242
L241:
	MOVE	#0,D0
L242:
	MOVE.B	D0,9(A3)
L240:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L243
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L244
L243:
	ANDI.B	#-9,(A2)
L244:
L239:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$238:	.EQU	#0
F251_xxxx_:/* global */
	LINK	A6,L$245
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L247
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L248
	MOVE	#1,D0
	BRA.S	L249
L248:
	MOVE	#0,D0
L249:
	MOVE.B	D0,9(A3)
L247:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L250
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L251
L250:
	ANDI.B	#-9,(A2)
L251:
L246:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$245:	.EQU	#0
F252_xxxx_:/* global */
	LINK	A6,L$252
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	CLR	-2(A6)
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
L19T252_001:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L255
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L255
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L254
L255:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BNE.S	L254
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#61,D0
	BNE.S	L256
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L256:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	8(A3),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	BRA	L253(PC)
L254:
	MOVE	-2(A6),D0
	BNE.S	L257
	MOVE	#1,-2(A6)
	MOVE	8(A3),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#23,D0
	BNE.S	L258
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L258
	JSR	F029_AA19_(PC)
L259:
	CMP	#0,D0
	BEQ.S	L260
	BRA.S	L262
L260:
	SUBQ	#1,D7
	BRA.S	L261
	BRA.S	L263
L262:
	CMP	#1,D0
	BEQ.S	L263
	BRA.S	L264
L263:
	ADDQ	#1,D7
	BRA.S	L261
	BRA.S	L265
L264:
	CMP	#2,D0
	BEQ.S	L265
	BRA.S	L266
L265:
	SUBQ	#1,D6
	BRA.S	L261
	BRA.S	L267
L266:
	CMP	#3,D0
	BEQ.S	L267
	BRA.S	L268
L267:
	ADDQ	#1,D6
L268:
L269:
L261:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F223_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L270
	BRA	L19T252_001(PC)
L270:
L258:
L257:
	ADDQ.L	#5,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L253:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$252:	.EQU	#-2
F253_xxxx_:/* global */
	LINK	A6,L$271
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,44(A3)
	ANDI	#-9,48(A3)
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BEQ.S	L273
	MOVE.B	32(A3),D0
	AND	#255,D0
	LEA	G495_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	SUB	D0,64(A3)
L273:
	MOVE	52(A3),D0
	BEQ.S	L274
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#32,D0
	BNE.S	L275
	CMPI	#-1,212(A3)
	BNE.S	L275
	MOVE	#12,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L276
L20T253_002:
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L277
L276:
	CLR	D5
	BRA.S	L278
L279:
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L282
	BRA.S	L20T253_002
L282:
L280:
	ADDQ	#1,D5
L278:
	CMPI	#3,D5
	BLT.S	L279
L281:
L277:
L275:
	ORI	#-32768,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L274:
	MOVE.B	#-1,32(A3)
L272:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$271:	.EQU	#0
F254_xxxx_:/* global */
	LINK	A6,L$283
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,46(A3)
	MOVE	52(A3),D0
	BNE.S	L285
	BRA.S	L284
L285:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L286
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	BRA.S	L287
L286:
	ORI	#128,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L287:
L284:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$283:	.EQU	#0
F255_xxxx_:/* global */
	LINK	A6,L$288
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
	MOVE.B	8(A3),D5
	AND	#255,D5
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
L290:
	CMP	#2,D0
	BEQ.S	L291
	BRA.S	L293
L291:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-28,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	ADDQ.L	#5,(A3)
L22T255_002:
	SUBQ	#1,-4(A6)
	MOVE	-4(A6),D0
	MOVE.B	D0,9(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L292(PC)
	BRA.S	L294
L293:
	CMP	#1,D0
	BEQ.S	L294
	BRA	L295(PC)
L294:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L297
L298:
	MOVE	D4,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	D5,D0
	BNE.S	L301
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#10,D0
	BNE.S	L301
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#147,-2(A6)
	BNE.S	L302
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-6(A6),D0
	BNE.S	L303
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	BRA	L22T255_002(PC)
L303:
L302:
L301:
L299:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L297:
	CMPI	#-2,D4
	BNE.S	L298
L300:
	BRA.S	L292
	BRA.S	L296
L295:
	CMP	#0,D0
	BEQ.S	L296
	BRA.S	L304
L296:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F283_azzz_(PC)
	ADDQ.L	#2,A7
L304:
L305:
L292:
L289:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$288:	.EQU	#-6
F256_xxxx_:/* global */
	LINK	A6,L$306
	MOVE.B	#53,-6(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#300,D0
	MOVE.L	D0,G374_l_Wat(A4)
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L307:
	UNLK	A6
	RTS
L$306:	.EQU	#-10
F257_xxxx_:/* global */
	LINK	A6,L$308
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	6(A3),D0
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L310
	BRA.S	L309
L310:
	CMPI	#0,D6
	SLT	D5
	AND	#1,D5
	BEQ.S	L311
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
L311:
	MOVE	D6,D7
	SUBQ	#1,D7
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G039_ai_Gr(A4),A0
	ADDA	D1,A0
	SUB	(A0),D0
	MOVE	D0,D6
	MOVE	D5,D0
	BEQ.S	L312
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
	MOVE	D7,D0
	NEG	D0
	MOVE	D0,D7
L312:
	MOVE	D6,D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	D7,D0
	BEQ.S	L313
	MOVE.B	#70,-6(A6)
	MOVE	D7,-4(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#4,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	CLR.B	-5(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L313:
L309:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$308:	.EQU	#-10
F258_xxxx_:/* global */
	LINK	A6,L$314
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L316
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	BRA.S	L315
L316:
	MOVE	#0,D0
L315:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$314:	.EQU	#0
F259_xxxx_:/* global */
	LINK	A6,L$317
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L319
	BRA.S	L318
L319:
	MOVE	D6,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L320
	BRA.S	L318
L320:
	MOVE	#7,D5
	BRA.S	L321
L322:
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L325
	BRA.S	L318
L325:
L323:
	ADDQ	#1,D5
L321:
	CMPI	#9,D5
	BLS.S	L322
L324:
L318:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$317:	.EQU	#0
F260_pzzz_:/* global */
	LINK	A6,L$326
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L328
L329:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L330:
	ADDQ	#1,D7
L328:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L329
L331:
	JSR	F293_ahzz_(PC)
L327:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$326:	.EQU	#0
F261_hzzz_:/* global */
	LINK	A6,L$332
	MOVEM.L	A3/D7,-(A7)
	BRA	L334(PC)
L335:
	LEA	-10(A6),A0
	MOVE.L	A0,A3
	MOVE.L	A3,-(A7)
	JSR	F239_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	-10(A6),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.B	-6(A6),D7
	AND	#255,D7
	CMPI	#28,D7
	BLS.S	L337
	CMPI	#42,D7
	BCC.S	L337
	MOVE.B	-2(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
	BRA	L338(PC)
L337:
	MOVE	D7,D0
L339:
	CMP	#48,D0
	BEQ.S	L340
L342:
	CMP	#49,D0
	BEQ.S	L340
	BRA.S	L343
L340:
	MOVE.L	A3,-(A7)
	JSR	F219_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L344
L343:
	CMP	#1,D0
	BEQ.S	L344
	BRA.S	L345
L344:
	MOVE.L	A3,-(A7)
	JSR	F241_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L346
L345:
	CMP	#25,D0
	BEQ.S	L346
	BRA.S	L347
L346:
	MOVE.L	A3,-(A7)
	JSR	F220_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L348
L347:
	CMP	#7,D0
	BEQ.S	L348
	BRA.S	L349
L348:
	MOVE.L	A3,-(A7)
	JSR	F242_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L350
L349:
	CMP	#2,D0
	BEQ.S	L350
	BRA.S	L351
L350:
	MOVE.L	A3,-(A7)
	JSR	F243_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L352
L351:
	CMP	#10,D0
	BEQ.S	L352
	BRA.S	L353
L352:
	MOVE.L	A3,-(A7)
	JSR	F244_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L354
L353:
	CMP	#9,D0
	BEQ.S	L354
	BRA.S	L355
L354:
	MOVE.L	A3,-(A7)
	JSR	F251_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L356
L355:
	CMP	#8,D0
	BEQ.S	L356
	BRA.S	L357
L356:
	MOVE.L	A3,-(A7)
	JSR	F250_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L358
L357:
	CMP	#6,D0
	BEQ.S	L358
	BRA.S	L359
L358:
	MOVE.L	A3,-(A7)
	JSR	F248_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L360
L359:
	CMP	#5,D0
	BEQ.S	L360
	BRA.S	L361
L360:
	MOVE.L	A3,-(A7)
	JSR	F245_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L362
L361:
	CMP	#60,D0
	BEQ.S	L362
L363:
	CMP	#61,D0
	BEQ.S	L362
	BRA.S	L364
L362:
	MOVE.L	A3,-(A7)
	JSR	F252_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L365
L364:
	CMP	#65,D0
	BEQ.S	L365
	BRA.S	L366
L365:
	MOVE.L	A3,-(A7)
	JSR	F246_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L367
L366:
	CMP	#20,D0
	BEQ.S	L367
	BRA.S	L368
L367:
	MOVE	#1,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L341(PC)
	BRA.S	L369
L368:
	CMP	#24,D0
	BEQ.S	L369
	BRA.S	L370
L369:
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L372
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
L372:
	BRA	L341(PC)
	BRA.S	L371
L370:
	CMP	#11,D0
	BEQ.S	L371
	BRA.S	L373
L371:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F253_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.B	-4(A6),D0
	BEQ.S	L375
	MOVE.B	-4(A6),D0
	EXT	D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F259_xxxx_(PC)
	ADDQ.L	#4,A7
L375:
	BRA	L28T261_048(PC)
	BRA.S	L374
L373:
	CMP	#12,D0
	BEQ.S	L374
	BRA.S	L376
L374:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F254_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L341(PC)
	BRA.S	L377
L376:
	CMP	#53,D0
	BEQ.S	L377
	BRA.S	L378
L377:
	MOVE.L	A3,-(A7)
	JSR	F256_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L341(PC)
	BRA.S	L379
L378:
	CMP	#70,D0
	BEQ.S	L379
	BRA.S	L380
L379:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F257_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F337_akzz_(PC)
	BRA	L341(PC)
	BRA.S	L381
L380:
	CMP	#71,D0
	BEQ.S	L381
	BRA.S	L382
L381:
	SUBQ.B	#1,G407_s_Par+3286(A4)
	BRA	L341(PC)
	BRA.S	L383
L382:
	CMP	#72,D0
	BEQ.S	L383
	BRA.S	L384
L383:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+274(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	-4(A6),D0
	MOVE	D0,(A0)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L28T261_048:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	BRA	L341(PC)
	BRA.S	L385
L384:
	CMP	#73,D0
	BEQ.S	L385
	BRA.S	L386
L385:
	SUBQ.B	#1,G407_s_Par+3202(A4)
	BRA	L341(PC)
	BRA.S	L387
L386:
	CMP	#74,D0
	BEQ.S	L387
	BRA.S	L388
L387:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3204(A4)
L28T261_053:
	JSR	F260_pzzz_(PC)
	BRA.S	L341
	BRA.S	L389
L388:
	CMP	#77,D0
	BEQ.S	L389
	BRA.S	L390
L389:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3208(A4)
	BRA.S	L28T261_053
	BRA.S	L391
L390:
	CMP	#78,D0
	BEQ.S	L391
	BRA.S	L392
L391:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3206(A4)
	BRA.S	L28T261_053
	BRA.S	L393
L392:
	CMP	#75,D0
	BEQ.S	L393
	BRA.S	L394
L393:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	SUBQ.B	#1,(A0)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L341
	BRA.S	L395
L394:
	CMP	#13,D0
	BEQ.S	L395
	BRA.S	L396
L395:
	MOVE.L	A3,-(A7)
	JSR	F255_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L341
	BRA.S	L397
L396:
	CMP	#79,D0
	BEQ.S	L397
	BRA.S	L398
L397:
	SUBQ.B	#1,G407_s_Par+3203(A4)
L398:
L399:
L341:
L338:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L334:
	JSR	F240_xxxx_(PC)
	TST	D0
	BNE	L335(PC)
L336:
L333:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$332:	.EQU	#-10
