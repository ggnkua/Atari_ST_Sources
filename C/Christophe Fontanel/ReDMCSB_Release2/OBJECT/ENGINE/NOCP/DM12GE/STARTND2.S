BSS SEG "bss"
G562_apuc_:/* global */
	.WORD	#40
G563_puc_G:/* global */
	.WORD	#4
G564_puc_G:/* global */
	.WORD	#4
G565_puc_G:/* global */
	.WORD	#4
G566_puc_G:/* global */
	.WORD	#4
CODE SEG "start"
F432_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D5
	MOVE.L	#0,A3
L2:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	MOVE.L	G550_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	JSR	F077_aA39_(PC)
	CMPI	#2,D7
	BNE.S	L5
	MOVE	#0,D0
	BRA	L1(PC)
L5:
	JSR	F452_xxxx_(PC)
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L6
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L7
L6:
	CMPI	#2,D6
	BNE.S	L8
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L9
L8:
	MOVE	#1,D5
L9:
L7:
L3:
	MOVE	D5,D0
	BEQ.S	L2
L4:
	MOVE.L	G648_l_Ava(A4),-4(A6)
	CLR	-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	CLR	D4
	BRA.S	L10
L11:
	CMPI	#1,D4
	BGT.S	L14
	MOVE	#0,D0
	BRA.S	L15
L14:
	MOVE	#-6683,D0
L15:
	MOVE	D0,-(A7)
	MOVE.L	#-2023406815,-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	MOVE	#9,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#10,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#26,A7
L12:
	ADDQ	#1,D4
L10:
	CMPI	#80,D4
	BLT.S	L11
L13:
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE.L	#16777217,-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#18,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#9,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	MOVE.L	-4(A6),-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
L1:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-4
F433_AA39_:/* global */
	LINK	A6,L$16
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D7
	JSR	F456_vzzz_(PC)
	CLR	D7
	JSR	F077_aA39_(PC)
	MOVE.L	#0,A3
	CLR	-(A7)
	MOVE.L	#512,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
L18:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	MOVE.L	G558_pc_D1(A4),-(A7)
	MOVE.L	G557_pc_D1(A4),-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#4,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	JSR	F077_aA39_(PC)
	CMPI	#3,D4
	BNE.S	L21
	JSR	F432_xxxx_(PC)
	TST	D0
	BNE.S	L22
	BRA	L1T433_060(PC)
L22:
	BRA.S	L19
L21:
	CMPI	#4,D4
	BNE.S	L23
	BRA	L1T433_060(PC)
L23:
	CMPI	#1,D4
	SEQ	D6
	AND	#1,D6
	JSR	F452_xxxx_(PC)
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L24
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L19
L24:
	CMPI	#2,D5
	BNE.S	L25
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L19
L25:
	CMPI	#3,D5
	BNE.S	L26
	MOVE.L	G545_pc_D0(A4),A3
	BRA.S	L19
L26:
	MOVE	#1,D7
L19:
	MOVE	D7,D0
	BEQ	L18(PC)
L20:
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE	#65,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE	#60,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L27
	BRA	L1T433_059(PC)
L27:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L28
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D1,-4(A6)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
L28:
	MOVE.L	G313_ul_Ga(A4),-134(A6)
	MOVE.L	G349_ul_La(A4),-130(A6)
	MOVE	G305_ui_Pa(A4),-124(A6)
	MOVE	G306_i_Par(A4),-122(A6)
	MOVE	G307_i_Par(A4),-120(A6)
	MOVE	G308_i_Par(A4),-118(A6)
	MOVE	G309_i_Par(A4),-116(A6)
	MOVE	G411_i_Lea(A4),-114(A6)
	MOVE	G514_i_Mag(A4),-112(A6)
	MOVE	G372_ui_Ev(A4),-110(A6)
	MOVE	G373_ui_Fi(A4),-108(A6)
	MOVE	G369_ui_Ev(A4),-106(A6)
	MOVE	G377_ui_Cu(A4),-104(A6)
	MOVE.L	G361_l_Las(A4),-102(A6)
	MOVE.L	G362_l_Las(A4),-98(A6)
	MOVE	G310_i_Dis(A4),-94(A6)
	MOVE	G311_i_Pro(A4),-92(A6)
	MOVE	G312_i_Las(A4),-90(A6)
	MOVE	G414_T_Lea(A4),-126(A6)
	MOVE	G376_ui_Ma(A4),-88(A6)
	MOVE	#80,-(A7)
	PEA	-86(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#96,-(A7)
	PEA	-230(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	LEA	-134(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-230(A6)
	MOVE	#128,-226(A6)
	MOVE.L	G375_ps_Ac(A4),D0
	MOVE.L	D0,-224(A6)
	MOVE	G376_ui_Ma(A4),D0
	MULU	#16,D0
	MOVE	D0,-220(A6)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-218(A6)
	MOVE	#3328,-214(A6)
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,-212(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	MOVE	D0,-208(A6)
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,-206(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	MOVE	D0,-202(A6)
	MOVE	D6,304(A2)
	MOVE.L	G525_l_Gam(A4),306(A2)
	MOVE.B	#1,299(A2)
	MOVE.B	#1,298(A2)
	CLR	D4
	BRA.S	L29
L30:
	JSR	F027_AA59_(PC)
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	LEA	310(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L29:
	CMPI	#16,D4
	BLT.S	L30
L31:
	CLR	D4
	BRA.S	L32
L33:
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-226(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	310(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-230(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F418_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,D1
	ASL.L	#1,D1
	LEA	342(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L34:
	ADDQ	#1,D4
L32:
	CMPI	#5,D4
	BLT.S	L33
L35:
	MOVE.L	A2,-(A7)
	JSR	F430_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L36
	BRA	L1T433_059(PC)
L36:
	CLR	D4
	BRA.S	L37
L38:
	PEA	-2(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	310(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-226(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-230(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F420_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BNE.S	L41
	BRA	L1T433_059(PC)
L41:
L39:
	ADDQ	#1,D4
L37:
	CMPI	#5,D4
	BLT.S	L38
L40:
	LEA	-6(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	CLR	-6(A6)
	MOVE	#44,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L42
	BRA	L1T433_059(PC)
L42:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L43
	BRA	L1T433_059(PC)
L43:
	MOVE	G282_ui_Du(A4),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L44
	BRA	L1T433_059(PC)
L44:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L45
	BRA	L1T433_059(PC)
L45:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L46
	BRA	L1T433_059(PC)
L46:
	CLR	D4
	BRA.S	L47
L48:
	MOVE	D4,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	LEA	G235_auc_G(A4),A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE	D4,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L51
	BRA.S	L1T433_059
L51:
L49:
	ADDQ	#1,D4
L47:
	CMPI	#16,D4
	BLT.S	L48
L50:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F422_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L52
	BRA.S	L1T433_059
L52:
	MOVE	#2,-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L53
	BRA.S	L1T433_059
L53:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L54
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L54:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L55
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	-4(A6),D0
	MOVE	D0,(A0)
L55:
	MOVE	#1,G524_B_Res(A4)
	BRA.S	L1T433_060
L1T433_059:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	CLR.L	-(A7)
	MOVE.L	G540_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F077_aA39_(PC)
L1T433_060:
	MOVE.L	#512,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F457_AA08_(PC)
	JSR	F078_xzzz_(PC)
L17:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$16:	.EQU	#-230
F434_xxxx_:/* global */
	LINK	A6,L$56
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-8(A6)
	MOVE	G523_B_Res(A4),D0
	BNE.S	L58
	MOVE	#1,-(A7)
	MOVE.L	#44,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G278_ps_Du(A4)
L58:
	MOVE	#44,-(A7)
	PEA	-8(A6)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L59
	BRA	L2T434_043(PC)
L59:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L60
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	8(A0),D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G306_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G307_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	AND	#3,D0
	MOVE	D0,G308_i_Par(A4)
	CLR	G309_i_Par(A4)
L60:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D7
	AND	#255,D7
	MOVE	G523_B_Res(A4),D0
	BNE.S	L61
	MOVE	#1,-(A7)
	MOVE	#16,D0
	MULS	D7,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G277_ps_Du(A4)
L61:
	MOVE	D7,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L62
	BRA	L2T434_043(PC)
L62:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L63
	MOVE	#1,-(A7)
	MOVE	D7,D0
	ASL	#1,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G281_pi_Du(A4)
L63:
	MOVE	#0,D4
	MOVE	D4,D5
	BRA.S	L64
L65:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
	MOVE	D5,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	ADDQ	#1,D0
	ADD	D0,D4
	ADDQ	#1,D5
L64:
	MOVE	D5,D0
	CMP	D7,D0
	BLT.S	L65
L66:
	MOVE	D4,G282_ui_Du(A4)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L67
	MOVE.L	G278_ps_Du(A4),A0
	ADDI	#300,10(A0)
L67:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L68
	MOVE	#1,-(A7)
	MOVE	D4,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G280_pui_D(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G283_pT_Sq(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	AND.L	#65535,D0
	ASL.L	#1,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G260_pui_D(A4)
L68:
	MOVE	D4,D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L69
	BRA	L2T434_043(PC)
L69:
	MOVE	D5,D0
	MULS	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L70
	BRA	L2T434_043(PC)
L70:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L71
	CLR	D4
	BRA.S	L72
L73:
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L74:
	ADDQ	#1,D4
L72:
	CMPI	#300,D4
	BCS.S	L73
L75:
L71:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L76
	BRA	L2T434_043(PC)
L76:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L77
	MOVE	#100,G369_ui_Ev(A4)
L77:
	CLR	D6
	BRA	L78(PC)
L79:
	MOVE	D6,D5
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D5
	LEA	12(A0),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L82
	MOVE	D5,D0
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	CMPI	#15,D6
	BNE.S	L83
	MOVE	#768,D0
	BRA.S	L84
L83:
	MOVE	#1024,D0
L84:
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L82:
	LEA	G235_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE	G523_B_Res(A4),D0
	BNE.S	L85
	MOVE	#1,-(A7)
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULU	D4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,D1
	ASL.L	#2,D1
	LEA	G284_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L85:
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE	D4,D0
	MULU	D5,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L86
	BRA	L2T434_043(PC)
L86:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L87
	CMPI	#4,D6
	BEQ.S	L89
	CMPI	#14,D6
	BLT.S	L88
L89:
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D0,G369_ui_Ev(A4)
L88:
	MOVE	D4,D1
	LSR	#1,D1
	MOVE	D1,D4
	MOVE	D1,-18(A6)
	MOVE	D5,D1
	MULU	-18(A6),D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	BRA.S	L90
L91:
	MOVE	#-1,(A3)
L92:
	MOVE	D5,D0
	SUBQ	#1,D5
	MOVE	D4,D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
L90:
	MOVE	D5,D0
	BNE.S	L91
L93:
L87:
L80:
	ADDQ	#1,D6
L78:
	CMPI	#16,D6
	BLT	L79(PC)
L81:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L94
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G276_puc_D(A4)
L94:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	PEA	-8(A6)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F421_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L95
	BRA	L2T434_043(PC)
L95:
	MOVE	#2,-(A7)
	PEA	-6(A6)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L96
	MOVE	-6(A6),D0
	CMP	-8(A6),D0
	BEQ.S	L96
	BRA	L2T434_043(PC)
L96:
	MOVE	G523_B_Res(A4),D0
	BNE	L97(PC)
	MOVE	#1,-(A7)
	MOVE	G282_ui_Du(A4),D0
	ADD	D7,D0
	MULU	#4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G279_pppuc(A4)
	MOVE.L	G279_pppuc(A4),D0
	MOVE	D7,D1
	EXT.L	D1
	ASL.L	#2,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
	CLR	D5
	BRA	L98(PC)
L99:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
	MOVE.L	G276_puc_D(A4),D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
	MOVE	#1,D6
	BRA.S	L102
L103:
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	ADDQ	#1,D1
	MOVE.L	-4(A6),D0
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
L104:
	ADDQ	#1,D6
L102:
	MOVE	D6,D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#1984,D1
	LSR	#6,D1
	CMP	D1,D0
	BLS.S	L103
L105:
L100:
	ADDQ	#1,D5
L98:
	MOVE	D5,D0
	CMP	D7,D0
	BLT	L99(PC)
L101:
L97:
	MOVE	#1,D0
	BRA.S	L57
L2T434_043:
	MOVE	#0,D0
L57:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$56:	.EQU	#-18
F435_xxxx_:/* global */
	LINK	A6,L$106
	MOVEM.L	A3/D7-D4,-(A7)
	CLR	D4
	MOVE.L	#0,A3
	MOVE	G298_B_New(A4),D0
	BEQ.S	L108
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	TST	D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D4
DATA SEG "s!"
s!:
	DATA 5C 44 55 4E 47 45 4F 4E 2E 44 41 54 00 00 
CODE SEG "start"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,G521_i_Gam(A4)
	BGE.S	L109
	MOVE	#50,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L111:
L112:
	BRA.S	L111
L113:
L109:
L3T435_002:
	CLR	G524_B_Res(A4)
	CLR	G305_ui_Pa(A4)
	MOVE	#-1,G414_T_Lea(A4)
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE	D1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,G525_l_Gam(A4)
	BRA	L114(PC)
L108:
	MOVE.L	#0,A3
L3T435_004:
L115:
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G556_pc_D1(A4),-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	JSR	F077_aA39_(PC)
	CMPI	#2,D7
	BNE.S	L118
L3T435_008:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,D0
	BRA	L107(PC)
L118:
L3T435_009:
	JSR	F452_xxxx_(PC)
	MOVE	D0,D5
	CMPI	#1,D0
	BNE.S	L119
	CLR	D6
	CLR	-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L120
	CLR	-(A7)
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L121
	MOVE	#1,D6
	BRA.S	L122
L121:
DATA SEG "s!"
	DATA 41 3A 5C 44 55 4E 47 45 4F 4E 2E 46 54 4C 00 00 
CODE SEG "start"
	MOVE	G523_B_Res(A4),D0
	BNE.S	L123
	CLR	-(A7)
	PEA	s!+14(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L123
	MOVE	#1,D4
	MOVE	#1,G298_B_New(A4)
	BRA	L3T435_002(PC)
L123:
	MOVE.L	G539_pc_D0(A4),A3
	MOVE	#3,D5
L122:
L120:
	BRA.S	L124
L119:
	CMPI	#0,D5
	BNE.S	L125
	MOVE.L	G542_pc_D0(A4),A3
	BRA.S	L126
L125:
	CMPI	#3,D5
	BNE.S	L127
	MOVE.L	G545_pc_D0(A4),A3
	BRA.S	L128
L127:
	CMPI	#2,D5
	BNE.S	L129
	MOVE.L	G544_pc_D0(A4),A3
L129:
L128:
L126:
L124:
L116:
	CMPI	#1,D5
	BNE	L115(PC)
L117:
	PEA	-642(A6)
	JSR	F429_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L130
	BRA	L3T435_037(PC)
L130:
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L131
	MOVE.L	-336(A6),D0
	CMP.L	G525_l_Gam(A4),D0
	BEQ.S	L131
	MOVE.L	G546_pc_D0(A4),A3
	BRA	L3T435_004(PC)
L131:
	MOVE.L	-336(A6),G525_l_Gam(A4)
	MOVE	-300(A6),-(A7)
	MOVE	-332(A6),-(A7)
	MOVE	#128,-(A7)
	PEA	-130(A6)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L132
	BRA	L3T435_037(PC)
L132:
	MOVE.L	-130(A6),G313_ul_Ga(A4)
	MOVE.L	-126(A6),G349_ul_La(A4)
	MOVE	-120(A6),G305_ui_Pa(A4)
	MOVE	-118(A6),G306_i_Par(A4)
	MOVE	-116(A6),G307_i_Par(A4)
	MOVE	-114(A6),G308_i_Par(A4)
	MOVE	-112(A6),G309_i_Par(A4)
	MOVE	-110(A6),G411_i_Lea(A4)
	MOVE	-108(A6),G514_i_Mag(A4)
	MOVE	-106(A6),G372_ui_Ev(A4)
	MOVE	-104(A6),G373_ui_Fi(A4)
	MOVE	-102(A6),G369_ui_Ev(A4)
	MOVE	-100(A6),G377_ui_Cu(A4)
	MOVE.L	-98(A6),G361_l_Las(A4)
	MOVE.L	-94(A6),G362_l_Las(A4)
	MOVE	-90(A6),G310_i_Dis(A4)
	MOVE	-88(A6),G311_i_Pro(A4)
	MOVE	-86(A6),G312_i_Las(A4)
	MOVE	-122(A6),G414_T_Lea(A4)
	MOVE	-84(A6),G376_ui_Ma(A4)
	MOVE	G523_B_Res(A4),D0
	BNE.S	L133
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
L133:
	MOVE	-298(A6),-(A7)
	MOVE	-330(A6),-(A7)
	MOVE	#16,D0
	MULU	G376_ui_Ma(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G375_ps_Ac(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L134
	BRA	L3T435_037(PC)
L134:
	MOVE	-296(A6),-(A7)
	MOVE	-328(A6),-(A7)
	MOVE	#3328,-(A7)
	PEA	G407_s_Par(A4)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L135
	BRA	L3T435_037(PC)
L135:
	MOVE	-294(A6),-(A7)
	MOVE	-326(A6),-(A7)
	MOVE	#10,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G370_ps_Ev(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L136
	BRA	L3T435_037(PC)
L136:
	MOVE	-292(A6),-(A7)
	MOVE	-324(A6),-(A7)
	MOVE	#2,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G371_pi_Ti(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L137
	BRA	L3T435_037(PC)
L137:
L114:
	JSR	F434_xxxx_(PC)
	TST	D0
	BNE.S	L138
	BRA	L3T435_037(PC)
L138:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	G298_B_New(A4),D0
	BEQ.S	L139
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
	MOVE	D4,D0
	BEQ.S	L140
	MOVE	#32,-(A7)
	PEA	-674(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	-674(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L140:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	BRA.S	L141
L139:
	MOVE	#1,G524_B_Res(A4)
	MOVE	D6,D0
	BEQ.S	L142
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE.L	G520_pc_D0(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
L142:
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
L141:
	CLR	G303_B_Par(A4)
	MOVE	#1,D0
	BRA.S	L107
L3T435_037:
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L143
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	MOVE.L	G549_pc_D0(A4),-(A7)
	MOVE.L	G547_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F077_aA39_(PC)
	BRA	L3T435_008(PC)
L143:
	MOVE.L	G547_pc_D0(A4),-(A7)
	MOVE	#9,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L145:
L146:
	BRA.S	L145
L147:
L107:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$106:	.EQU	#-674
F436_xxxx_:/* global */
	LINK	A6,L$148
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	#-32192,A3
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-4(A6)
	CLR	D4
	BRA	L150(PC)
L151:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	BRA	L154(PC)
L155:
	MOVE	D5,D7
	ASL.L	#1,D7
	MOVE.L	A3,A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D5,D6
	ASL.L	#1,D6
	MOVE.L	8(A6),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BLS.S	L158
	SUBQ	#1,D7
L158:
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BCC.S	L159
	ADDQ	#1,D7
L159:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BLS.S	L160
	SUB	#16,D7
L160:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BCC.S	L161
	ADD	#16,D7
L161:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BLS.S	L162
	SUB	#256,D7
L162:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BCC.S	L163
	ADD	#256,D7
L163:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D7,(A0)
L156:
	ADDQ	#1,D5
L154:
	CMPI	#16,D5
	BLT	L155(PC)
L157:
L152:
	ADDQ	#1,D4
L150:
	CMPI	#8,D4
	BLT	L151(PC)
L153:
	MOVE.L	-4(A6),-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L149:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$148:	.EQU	#-4
F437_xxxx_:/* global */
	LINK	A6,L$164
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	G578_B_Use(A4)
	CMPI.L	#138060,G648_l_Ava(A4)
	BGE.S	L166
	BRA	L165(PC)
L166:
	CLR	-(A7)
	MOVE.L	#133056,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D4
	ADD.L	#256,D4
	AND.L	#-256,D4
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	D4,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	ADD.L	#32000,D4
	MOVE.L	G348_pl_Bi(A4),D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,A2
	MOVE.L	A3,D0
	MOVE.L	D0,-8(A6)
	MOVE.L	D0,-92(A6)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-340(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#137,-(A7)
	CLR	-(A7)
	PEA	G005_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#1911,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#80,-(A7)
	CLR	-(A7)
	PEA	G004_s_Gra(A4)
	MOVE.L	D4,D0
	MOVE.L	D0,-96(A6)
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADD.L	#9120,D4
	MOVE	#12,D6
	MOVE	#48,D5
	CLR	D7
	BRA	L167(PC)
L168:
	MOVE.L	D4,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-88(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	PEA	G017_auc_G(A4)
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	#80,-(A7)
	MOVE	#320,-(A7)
	MOVE.L	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	#320,D0
	SUB	D5,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-308(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D5,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-306(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#160,D0
	SUB	D6,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-304(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D6,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-302(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D0
	ADD	#15,D0
	EXT.L	D0
	DIVS	#16,D0
	MULS	#8,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-300(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MULU	D6,D0
	AND.L	#65535,D0
	ADD.L	D0,D4
	ADDQ	#4,D6
	ADD	#16,D5
L169:
	ADDQ	#1,D7
L167:
	CMPI	#18,D7
	BLT	L168(PC)
L170:
	MOVE	#2,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	-92(A6),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	-92(A6),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#1345,-334(A6)
	MOVE	#1057,-332(A6)
	MOVE	#1617,-330(A6)
	MOVE	#1329,-328(A6)
	MOVE	#1906,-324(A6)
	MOVE	#1792,-310(A6)
	MOVE	#2,-320(A6)
	MOVE	#2,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	D7
	BRA	L171(PC)
L172:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-300(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-308(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	-88(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
L173:
	ADDQ	#1,D7
L171:
	CMPI	#18,D7
	BLT	L172(PC)
L174:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G003_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-96(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	CLR	-320(A6)
	MOVE	#1792,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE.L	#133056,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L165:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$164:	.EQU	#-340
F438_xxxx_:/* global */
	LINK	A6,L$175
	MOVEM.L	A3/D7,-(A7)
	LEA	G562_apuc_(A4),A0
	MOVE.L	A0,A3
	MOVE.L	G348_pl_Bi(A4),D0
	ADD.L	#4800,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	36(A3),D0
	MOVE.L	D0,-8(A6)
	MOVE	#1,D7
L177:
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	CMPI	#1,D0
	BNE.S	L180
	MOVE	#1,-(A7)
	MOVE	#145,-(A7)
	MOVE.L	G565_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
L180:
	MOVE	#20608,-(A7)
	MOVE.L	36(A3),-(A7)
	MOVE.L	32(A3),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#112,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G006_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	G007_s_Gra+2(A4),D0
	CMPI	#0,D0
	BLT.S	L181
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#252,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G007_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,G007_s_Gra+2(A4)
L181:
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G008_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	#4,D0
	MOVE	D7,D1
	AND	#3,D1
	ADD	D1,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADDQ	#4,G008_s_Gra(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVEM.L	A6-A2/D7-D4,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.L	-8(A6),A1
	MOVE	#160,D0
L6T438_004:
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,(A0)
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,48(A0)
	MOVEM.L	(A1)+,D1-D4
	MOVEM.L	D1-D4,96(A0)
	MOVE.B	(A1),112(A0)
	MOVE.B	2(A1),114(A0)
	MOVE.B	4(A1),116(A0)
	MOVE.B	6(A1),118(A0)
	LEA	160(A0),A0
	LEA	16(A1),A1
	DBF	D0,L6T438_004
	MOVEM.L	(A7)+,D4-D7/A2-A6
L178:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMPI	#32,D0
	BNE	L177(PC)
L179:
L176:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$175:	.EQU	#-8
F439_xxxx_:/* global */
	LINK	A6,L$182
	MOVE	D7,-(A7)
	MOVE	#255,G309_i_Par(A4)
	MOVE	#1,G297_B_Dra(A4)
	MOVE	#5,G273_i_Cur(A4)
	MOVE	#5,G274_i_Cur(A4)
	LEA	-128(A6),A0
	MOVE.L	A0,G271_ppuc_(A4)
	LEA	-170(A6),A0
	MOVE.L	A0,G269_ps_Cu(A4)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	#25,-(A7)
	PEA	-154(A6)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
	CLR	D7
	BRA.S	L184
L185:
	MOVE	D7,D0
	MULU	#5,D0
	LEA	-154(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-128(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	MOVE	D7,D0
	LEA	-144(A6),A0
	ADDA	D0,A0
	MOVE.B	#32,(A0)
L186:
	ADDQ	#1,D7
L184:
	CMPI	#5,D7
	BCS.S	L185
L187:
	MOVE.B	#32,-147(A6)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G563_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	CLR	G324_B_Dra(A4)
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#160,-(A7)
	MOVE	#30,-(A7)
	CLR	-(A7)
	PEA	G009_s_Gra(A4)
	MOVE.L	G562_apuc_+32(A4),-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G010_s_Gra(A4)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G011_s_Gra(A4)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	PEA	G020_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L183:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$182:	.EQU	#-170
F440_xxxx_:/* global */
	LINK	A6,L$188
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	JSR	F494_ozzz_(PC)
	ADDQ.L	#2,A7
	AND.L	#65535,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	10(A6),A0
	MOVE.L	D0,(A0)
	MOVE.L	D0,-(A7)
	MOVE	8(A6),D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE.L	-4(A6),D0
L189:
	UNLK	A6
	RTS
L$188:	.EQU	#-4
F441_xxxx_:/* global */
	LINK	A6,L$190
	MOVEM.L	D7-D5,-(A7)
	LEA	G445_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	CLR	D7
	BRA.S	L192
L193:
	CLR	-(A7)
	MOVE.L	#10304,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G562_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L194:
	ADDQ	#1,D7
L192:
	CMPI	#8,D7
	BCS.S	L193
L195:
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+32(A4)
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+36(A4)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	MOVE	#3,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	MOVE	#2,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	PEA	G563_puc_G(A4)
	MOVE	#4,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D6
	PEA	G564_puc_G(A4)
	MOVE	#5,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G565_puc_G(A4)
	MOVE	#535,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G566_puc_G(A4)
	MOVE	#534,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	JSR	F478_gzzz_(PC)
	CLR	G578_B_Use(A4)
	CLR	-8(A6)
	MOVE	#100,-6(A6)
	CLR	-4(A6)
	MOVE	#160,-2(A6)
	MOVE	#1,D7
	BRA.S	L196
L197:
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,-6(A6)
L198:
	ADDQ	#1,D7
L196:
	CMPI	#4,D7
	BCS.S	L197
L199:
	MOVE	#127,-6(A6)
	MOVE	#5,D7
	BRA.S	L200
L201:
	ADDQ	#4,-8(A6)
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L202:
	ADDQ	#1,D7
L200:
	CMPI	#8,D7
	BCS.S	L201
L203:
L204:
	JSR	F439_xxxx_(PC)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	MOVE	#99,G298_B_New(A4)
L207:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	JSR	F380_xzzz_(PC)
L208:
	CMPI	#99,G298_B_New(A4)
	BEQ.S	L207
L209:
L205:
	CMPI	#202,G298_B_New(A4)
	BEQ.S	L204
L206:
	MOVE	#1,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G566_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	#20,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L210
	JSR	F438_xxxx_(PC)
L210:
	MOVE.L	D6,D0
	ADD.L	#82432,D0
	ADD.L	#41216,D0
	MOVE.L	D0,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L191:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$190:	.EQU	#-8
F442_AA08_:/* global */
	LINK	A6,L$211
	MOVE	#1800,-2(A6)
	JSR	F077_aA39_(PC)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G564_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L213:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L214:
	SUBQ	#1,-2(A6)
	MOVE	-2(A6),D0
	BEQ.S	L216
	MOVE	G588_i_Mou(A4),D0
	BNE.S	L216
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L213
L216:
L215:
	MOVE	#202,G298_B_New(A4)
L212:
	UNLK	A6
	RTS
L$211:	.EQU	#-2
F443_xxxx_:/* global */
	LINK	A6,L$217
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	14(A6),A3
	LEA	-50(A6),A0
	MOVE.L	A0,A2
	BRA.S	L219
L220:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#65,D0
	BLT.S	L223
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#90,D0
	BGT.S	L223
	SUBI.B	#64,(A2)
L223:
L221:
	ADDQ.L	#1,A2
L219:
	MOVE.B	(A3)+,(A2)
	BNE.S	L220
L222:
	PEA	-50(A6)
	MOVE	#12,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L218:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$217:	.EQU	#-50
F444_AA29_:/* global */
	LINK	A6,L$224
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	CLR.L	G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	MOVE	8(A6),D0
	BEQ.S	L226
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L226
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#6,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	#240,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
L226:
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE.L	G088_apuc_+40(A4),A3
	MOVE	8(A6),D0
	BEQ.S	L227
	MOVE.L	A3,A2
	ADDA.L	#560,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#6,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L228
	MOVE.L	A3,-14(A6)
	ADDA.L	#1376,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	-14(A6),-(A7)
	MOVE	#208,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L228:
L227:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-10(A6)
	MOVE.L	D0,-(A7)
	MOVE	#-32763,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	JSR	F478_gzzz_(PC)
	MOVE	G322_B_Pal(A4),D0
	BEQ	L229(PC)
	MOVE	#32,-(A7)
	PEA	-78(A6)
	PEA	G347_aui_P(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	D6
	BRA.S	L230
L231:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D7
	BRA.S	L234
L235:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G346_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G346_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G347_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G347_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L236:
	ADDQ	#1,D7
L234:
	CMPI	#16,D7
	BLT.S	L235
L237:
L232:
	ADDQ	#1,D6
L230:
	CMPI	#7,D6
	BLE.S	L231
L233:
	CLR	G322_B_Pal(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32,-(A7)
	PEA	G347_aui_P(A4)
	PEA	-78(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	BRA.S	L238
L229:
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L238:
	MOVE	8(A6),D0
	BEQ	L239(PC)
	MOVE	G302_B_Gam(A4),D0
	BEQ	L240(PC)
	MOVE	#4000,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	CLR	D7
	BRA	L241(PC)
L242:
	MOVE	D7,D6
	MULS	#48,D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-6(A6)
	MOVE	#10,-(A7)
	MOVE	#32,-(A7)
	PEA	G015_s_Gra(A4)
	MOVE.L	-14(A6),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#1,-(A7)
	MOVE	#16,-(A7)
	PEA	G016_s_Gra(A4)
	MOVE.L	-6(A6),A0
	LEA	336(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#87,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-140(A6)
	MOVE	#6,D0
	MULS	-140(A6),D0
	ADD	#87,D0
	MOVE	D0,D5
	MOVE.L	-6(A6),A0
	MOVE.B	8(A0),-1(A6)
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#44,D0
	BEQ.S	L245
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#59,D0
	BEQ.S	L245
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#45,D0
	BEQ.S	L245
	ADDQ	#6,D5
L245:
	MOVE.L	-6(A6),A0
	LEA	8(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	CLR	D5
	BRA	L246(PC)
L247:
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#16,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#1,D4
	BNE.S	L250
	BRA.S	L248
L250:
	MOVE	D4,D0
	ASL.L	#2,D0
	LEA	G428_apc_S+-8(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "start"
	PEA	s!+30(A4)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-130(A6)
	MOVE	#13,-(A7)
	MOVE	D6,D0
	ADDQ	#8,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#105,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
L248:
	ADDQ	#1,D5
L246:
	CMPI	#3,D5
	BLE	L247(PC)
L249:
	ADDI	#48,G015_s_Gra+4(A4)
	ADDI	#48,G015_s_Gra+6(A4)
	ADDI	#48,G016_s_Gra+4(A4)
	ADDI	#48,G016_s_Gra+6(A4)
L243:
	ADDQ	#1,D7
L241:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L242(PC)
L244:
	PEA	-78(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L252:
L253:
	BRA.S	L252
L254:
L240:
L12T444_017:
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#40,-(A7)
	PEA	G012_s_Gra(A4)
	MOVE.L	A2,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-110(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#32,-(A7)
	PEA	-46(A6)
	PEA	-110(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1911,-16(A6)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#300,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	MOVE	G524_B_Res(A4),D0
	BEQ	L255(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	MOVE	#1,-(A7)
	PEA	G013_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G014_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
DATA SEG "s!"
	DATA 44 49 45 53 45 53 20 53 50 49 45 4C 20 4E 45 55 20 53 54 41 52 54 45 4E 00 00 
CODE SEG "start"
	PEA	s!+32(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#154,-(A7)
	MOVE	#89,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	#1079,-44(A6)
	MOVE	#1911,-38(A6)
	LEA	G446_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	JSR	F357_qzzz_(PC)
	JSR	F078_xzzz_(PC)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#600,D7
	BRA.S	L256
L257:
	JSR	F380_xzzz_(PC)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L256:
	SUBQ	#1,D7
	MOVE	D7,D0
	BEQ.S	L259
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L257
L259:
L258:
	JSR	F077_aA39_(PC)
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L260
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G021_aaui_(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32,-(A7)
	PEA	G346_aui_P(A4)
	PEA	G021_aaui_(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	G298_B_New(A4)
	JSR	F435_xxxx_(PC)
	CMPI	#-1,D0
	BEQ.S	L261
	JSR	F462_xxxx_(PC)
	CLR	G523_B_Res(A4)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	BRA.S	L225
L261:
L260:
L255:
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L239:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-10(A6),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L263:
L264:
	BRA.S	L263
L265:
L225:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$224:	.EQU	#-140
F445_xxxx_:/* global */
	LINK	A6,L$266
	JSR	F261_hzzz_(PC)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F065_aanz_(PC)
	ADDQ.L	#1,G313_ul_Ga(A4)
L267:
	UNLK	A6
	RTS
L$266:	.EQU	#0
F446_zzzz_:/* global */
	LINK	A6,L$268
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,G302_B_Gam(A4)
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L270
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L270:
	JSR	F363_pzzz_(PC)
	MOVE	#200,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	MOVE	#100,D0
	MOVE	D0,G407_s_Par+3204(A4)
	MOVE	D0,G407_s_Par+3208(A4)
	MOVE	D0,G407_s_Par+3206(A4)
	JSR	F260_pzzz_(PC)
	JSR	F445_xxxx_(PC)
	MOVE	G306_i_Par(A4),-4(A6)
	MOVE	G307_i_Par(A4),-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#10000,6(A3)
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	#255,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F146_aczz_(PC)
	ADDQ.L	#8,A7
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F148_aayz_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,D7
	MOVE	G306_i_Par(A4),D6
	MOVE	G307_i_Par(A4),D5
L14T446_002:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L271
L272:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE.S	L275
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#50,D0
	BNE.S	L276
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,(A2)
	BRA.S	L14T446_002
L276:
L275:
L273:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L271:
	CMPI	#-2,D4
	BNE.S	L272
L274:
	MOVE	D7,D0
	BEQ.S	L277
	CLR	D7
	MOVE	-4(A6),D6
	MOVE	-6(A6),D5
	BRA.S	L14T446_002
L277:
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L278
L279:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L280:
	ADD	#40,D7
L278:
	CMPI	#255,D7
	BLE.S	L279
L281:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	#25,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L282
L283:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L284:
	ADD	#40,D7
L282:
	CMPI	#255,D7
	BLE.S	L283
L285:
	MOVE	#4,D6
	BRA.S	L286
L287:
	MOVE	#5,D7
	BRA.S	L289
L290:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
	AND	#1,D0
	BEQ.S	L292
	MOVE	#25,D0
	BRA.S	L293
L292:
	MOVE	#23,D0
L293:
	MOVE.B	D0,4(A3)
	MOVE	D6,D5
	BRA.S	L294
L295:
	JSR	F445_xxxx_(PC)
L294:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L295
L296:
L289:
	SUBQ	#1,D7
	BNE.S	L290
L291:
L286:
	SUBQ	#1,D6
	BNE.S	L287
L288:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
	MOVE.B	#26,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#1,G077_B_DoN(A4)
	JSR	F445_xxxx_(PC)
	CLR	D7
	BRA.S	L297
L298:
	CLR	D6
	BRA.S	L301
L302:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L305
	MOVE	D7,D0
	CMP	-4(A6),D0
	BNE.S	L306
	MOVE	D6,D0
	CMP	-6(A6),D0
	BEQ.S	L305
L306:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
L305:
L303:
	ADDQ	#1,D6
L301:
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BLT.S	L302
L304:
L299:
	ADDQ	#1,D7
L297:
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BLT.S	L298
L300:
	JSR	F445_xxxx_(PC)
	CLR	-(A7)
	CLR	-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CLR	D7
	BRA.S	L307
L308:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#2,D0
	BNE.S	L310
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L310:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L307:
	CMPI	#-2,D4
	BNE.S	L308
L309:
	MOVE.B	#65,-9(A6)
	MOVE	D7,D5
	BRA.S	L311
L312:
	CLR	D6
	BRA.S	L314
L315:
	MOVE	#-32767,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	PEA	-226(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	-225(A6),D0
	MOVE.B	-9(A6),D1
	EXT	D1
	EXT	D0
	CMP	D1,D0
	BNE.S	L318
	JSR	F043_aahz_(PC)
	MOVE.B	#10,-225(A6)
	PEA	-225(A6)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F445_xxxx_(PC)
	MOVE	#780,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	ADDQ.B	#1,-9(A6)
	BRA.S	L317
L318:
L316:
	ADDQ	#1,D6
L314:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L315
L317:
L311:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L312
L313:
	MOVE	#600,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	CLR	G524_B_Res(A4)
	MOVE	#1,-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L269:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$268:	.EQU	#-226
