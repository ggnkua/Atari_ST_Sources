BSS SEG "bss"
G407_s_Par:/* global */
	.WORD	#3328
G409_ai_Ch:/* global */
	.WORD	#8
G410_ai_Ch:/* global */
	.WORD	#8
CODE SEG "init!"
	MOVE	#-1,G411_i_Lea(A4)
BSS SEG "bss"
G411_i_Lea:/* global */
	.WORD	#2
G412_puc_B:/* global */
	.WORD	#4
G413_i_Lea:/* global */
	.WORD	#2
G414_T_Lea:/* global */
	.WORD	#2
G415_B_Lea:/* global */
	.WORD	#2
G416_i_Use:/* global */
	.WORD	#2
CODE SEG "init!"
	LEA	G417_apc_B(A4),A1
DATA SEG "s!"
s!:
	DATA 46 49 47 48 54 45 52 00 
CODE SEG "init!"
	LEA	s!(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4E 49 4E 4A 41 00 
CODE SEG "init!"
	LEA	s!+8(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 50 52 49 45 53 54 00 00 
CODE SEG "init!"
	LEA	s!+14(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 57 49 5A 41 52 44 00 00 
CODE SEG "init!"
	LEA	s!+22(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
G417_apc_B:/* global */
	.WORD	#16
CODE SEG "player"
F278_apzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	G298_B_New(A4),D0
	BNE	L2(PC)
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L3
	MOVE	#1,G415_B_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	JSR	F069_aaaL_(PC)
	BRA.S	L4
L3:
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L4:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L5
L6:
	ANDI	#127,48(A3)
	ORI	#-27648,48(A3)
L7:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L5:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L6
L8:
	JSR	F293_ahzz_(PC)
	MOVE	G411_i_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L9
	MOVE	#-1,G411_i_Lea(A4)
	MOVE	D7,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L9:
	MOVE	G514_i_Mag(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L10
	MOVE	#-1,G514_i_Mag(A4)
	MOVE	D7,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
L10:
	BRA.S	L11
L2:
	MOVE	#-1,G414_T_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	MOVE	#1,G415_B_Lea(A4)
L11:
L1:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-8
F279_xxxx_:/* global */
	LINK	A6,L$12
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	CLR	D5
	CLR	D6
	BRA.S	L14
L15:
	MOVE	D5,D0
	ASL	#4,D0
	MOVE.B	(A3)+,D1
	EXT	D1
	SUB	#65,D1
	ADD	D1,D0
	MOVE	D0,D5
L16:
	ADDQ	#1,D6
L14:
	MOVE	D6,D0
	CMP	D7,D0
	BCS.S	L15
L17:
	MOVE	D5,D0
L13:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$12:	.EQU	#0
F280_agzz_:/* global */
	LINK	A6,L$18
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L20
	BRA	L19(PC)
L20:
	CMPI	#4,G305_ui_Pa(A4)
	BNE.S	L21
	BRA	L19(PC)
L21:
	MOVE	G305_ui_Pa(A4),D0
	MOVE	D0,-2(A6)
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#800,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#-1,-(A7)
	MOVE	#16,-(A7)
	MOVE	#128,-(A7)
	MOVE	8(A6),D0
	LSR	#3,D0
	MULU	#29,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),D0
	AND	#7,D0
	ASL	#5,D0
	MOVE	D0,-(A7)
	PEA	G047_s_Gra(A4)
	LEA	336(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#26,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE.B	#1,30(A3)
	MOVE.B	#2,31(A3)
	MOVE.B	#-1,32(A3)
	MOVE	#-1,44(A3)
	MOVE	#-1,46(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR	D6
	BRA.S	L22
L23:
L24:
	ADDQ	#1,D6
L22:
	MOVE	D6,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BNE.S	L23
L25:
	MOVE	D6,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE.B	D0,29(A3)
	MOVE	#1024,48(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,40(A3)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#255,D1
	MOVE	#1500,D0
	ADD	D1,D0
	MOVE	D0,66(A3)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#255,D1
	MOVE	#1500,D0
	ADD	D1,D0
	MOVE	D0,68(A3)
	CLR	D6
	BRA.S	L26
L27:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L28:
	ADDQ	#1,D6
L26:
	CMPI	#30,D6
	BCS.S	L27
L29:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L30
L31:
L32:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L30:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#2,D0
	BNE.S	L31
L33:
	MOVE	#-32766,-(A7)
	MOVE	D7,-(A7)
	LEA	-96(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	CLR	D6
	BRA.S	L34
L35:
	MOVE	D4,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	LEA	(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L34:
	MOVE.B	(A2)+,D0
	AND	#255,D0
	MOVE	D0,D4
	CMPI	#10,D0
	BNE.S	L35
L36:
	MOVE	D6,D0
	LEA	(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	CLR	D6
	CLR	-4(A6)
L37:
	MOVE.B	(A2)+,D4
	AND	#255,D4
	CMPI	#10,D4
	BNE.S	L40
	MOVE	-4(A6),D0
	BEQ.S	L41
	BRA.S	L39
L41:
	MOVE	#1,-4(A6)
	BRA.S	L42
L40:
	MOVE	D4,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	LEA	8(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L42:
L38:
	BRA.S	L37
L39:
	MOVE	D6,D0
	LEA	8(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE.B	(A2)+,D0
	EXT	D0
	CMP	#77,D0
	BNE.S	L43
	ORI	#16,48(A3)
L43:
	ADDQ.L	#1,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,54(A3)
	MOVE	D0,52(A3)
	ADDQ.L	#4,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,58(A3)
	MOVE	D0,56(A3)
	ADDQ.L	#4,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,62(A3)
	MOVE	D0,60(A3)
	ADDQ.L	#4,A2
	ADDQ.L	#1,A2
	CLR	D6
	BRA.S	L44
L45:
	MOVE	D6,D0
	MULS	#3,D0
	LEA	72(A3),A0
	ADDA	D0,A0
	MOVE.B	#30,(A0)
	MOVE	#2,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,D1
	MULS	#3,D1
	LEA	70(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D6,D1
	MULS	#3,D1
	LEA	71(A3),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
	ADDQ.L	#2,A2
L46:
	ADDQ	#1,D6
L44:
	CMPI	#6,D6
	BLS.S	L45
L47:
	MOVE.B	#10,72(A3)
	ADDQ.L	#1,A2
	MOVE	#4,D6
	BRA.S	L48
L49:
	MOVE	D6,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE.B	(A2)+,D0
	EXT	D0
	SUB	#65,D0
	MOVE	D0,D4
	CMPI	#0,D0
	BNE.S	L52
	MOVE	D6,D0
	MULS	#6,D0
	LEA	94(A3),A0
	ADDA	D0,A0
	CLR.L	(A0)
	BRA.S	L53
L52:
	MOVE.L	#125,D0
	ASL.L	D4,D0
	MOVE	D6,D1
	MULS	#6,D1
	LEA	94(A3),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L53:
L50:
	ADDQ	#1,D6
L48:
	CMPI	#19,D6
	BLS.S	L49
L51:
	CLR	D6
	BRA.S	L54
L55:
	MOVE	D6,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	CLR	(A0)
	CLR.L	-18(A6)
	MOVE	D6,D5
	ADDQ	#1,D5
	ASL	#2,D5
	CLR	-4(A6)
	BRA.S	L58
L59:
	MOVE	D5,D0
	ADD	-4(A6),D0
	MULS	#6,D0
	LEA	94(A3),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	ADD.L	D0,-18(A6)
L60:
	ADDQ	#1,-4(A6)
L58:
	CMPI	#4,-4(A6)
	BCS.S	L59
L61:
	MOVE	D6,D0
	MULS	#6,D0
	LEA	94(A3),A0
	ADDA	D0,A0
	MOVE.L	-18(A6),(A0)
L56:
	ADDQ	#1,D6
L54:
	CMPI	#3,D6
	BLS.S	L55
L57:
	MOVE	-2(A6),D0
	ADDQ	#1,D0
	MOVE	D0,G299_ui_Ca(A4)
	ADDQ	#1,G305_ui_Pa(A4)
	MOVE	G305_ui_Pa(A4),D0
	CMPI	#1,D0
	BNE.S	L62
	CLR	-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,G508_B_Ref(A4)
	BRA.S	L63
L62:
	MOVE	G305_ui_Pa(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L63:
	MOVE	G306_i_Par(A4),-8(A6)
	MOVE	G307_i_Par(A4),-10(A6)
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-12(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-10(A6),D0
	ADD	D1,D0
	MOVE	D0,-10(A6)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	#13,D6
	BRA	L64(PC)
L65:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D4
	CMPI	#3,D0
	BLS	L67(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-12(A6),D0
	BNE	L67(PC)
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-14(A6)
	MOVE	D4,D0
L68:
	CMP	#6,D0
	BEQ.S	L69
	BRA.S	L71
L69:
	MOVE	#2,-6(A6)
	BRA.S	L73
L74:
	MOVE	-14(A6),D0
	MOVE	-6(A6),D1
	ASL.L	#1,D1
	LEA	G038_ai_Gr(A4),A0
	ADDA	D1,A0
	AND	(A0),D0
	BEQ.S	L77
	BRA	L2T280_048(PC)
L77:
L75:
	ADDQ	#1,-6(A6)
L73:
	CMPI	#5,-6(A6)
	BLS.S	L74
L76:
	MOVE	-14(A6),D0
	AND	G038_ai_Gr+20(A4),D0
	BEQ.S	L78
	CMPI	#-1,232(A3)
	BNE.S	L78
	MOVE	#10,-6(A6)
	BRA.S	L79
L78:
	BRA.S	L2T280_046
L79:
	BRA	L70(PC)
	BRA.S	L72
L71:
	CMP	#5,D0
	BEQ.S	L72
	BRA.S	L80
L72:
	CMPI	#-1,214(A3)
	BNE.S	L82
	MOVE	#1,-6(A6)
	BRA.S	L83
L82:
	BRA.S	L2T280_046
L83:
	BRA.S	L70
	BRA.S	L81
L80:
	CMP	#7,D0
	BEQ.S	L81
L84:
	CMP	#8,D0
	BEQ.S	L81
	BRA.S	L85
L81:
	CMPI	#-1,234(A3)
	BNE.S	L87
	MOVE	#11,-6(A6)
	BRA.S	L88
L87:
	CMPI	#-1,224(A3)
	BNE.S	L89
	MOVE	#6,-6(A6)
	BRA.S	L90
L89:
	BRA.S	L2T280_046
L90:
L88:
	BRA.S	L70
	BRA.S	L86
L85:
	CMP	#9,D0
	BEQ.S	L86
L91:
	CMP	#10,D0
	BEQ.S	L86
	BRA.S	L92
L86:
L2T280_046:
	MOVE	-14(A6),D0
	AND	G038_ai_Gr+20(A4),D0
	BEQ.S	L94
	CMPI	#-1,232(A3)
	BNE.S	L94
	MOVE	#10,-6(A6)
	BRA.S	L95
L94:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D0,-6(A6)
L95:
L92:
L93:
L70:
L2T280_048:
	MOVE	-6(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L96
	BRA.S	L2T280_046
L96:
	MOVE	-6(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
L67:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L64:
	CMPI	#-2,D7
	BNE	L65(PC)
L66:
	MOVE	-2(A6),-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	JSR	F456_vzzz_(PC)
L19:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$18:	.EQU	#-96
F281_xxxx_:/* global */
	LINK	A6,L$97
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	#3,-8(A6)
	MOVE	#8,-6(A6)
	MOVE	#3,D0
	MOVE	D0,-12(A6)
	ADD	#167,D0
	MOVE	D0,-10(A6)
	MOVE	#112,-(A7)
	MOVE	#12,-(A7)
	PEA	-12(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#4,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#27,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
DATA SEG "s!"
	DATA 5F 5F 5F 5F 5F 5F 5F 00 
CODE SEG "player"
	PEA	s!+30(A4)
	MOVE	#13,-(A7)
	MOVE	#58,-(A7)
	MOVE	#177,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 00 
CODE SEG "player"
	PEA	s!+38(A4)
	MOVE	#13,-(A7)
	MOVE	#76,-(A7)
	MOVE	#105,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	JSR	F077_aA39_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	CLR.B	8(A3)
	MOVE	#1,D6
	LEA	(A3),A0
	MOVE.L	A0,A2
	MOVE	#177,-2(A6)
	MOVE	#91,-4(A6)
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	MOVE	D0,-20(A6)
L99:
	CMPI	#2,D6
	SEQ	D0
	TST.B	D0
	BEQ.S	L103
	CMPI	#19,D7
	SEQ	D0
	TST.B	D0
L103:
	AND	#1,D0
	MOVE	D0,D4
	BNE.S	L102
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#9,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L102:
	BRA	L104(PC)
L105:
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	MOVE	D0,-18(A6)
	MOVE	-18(A6),D0
	BEQ	L107(PC)
	MOVE	-20(A6),D0
	BNE	L107(PC)
	MOVE	G589_i_Mou(A4),-14(A6)
	MOVE	G590_i_Mou(A4),-16(A6)
	CMPI	#2,D6
	BEQ.S	L109
	CMPI	#0,D7
	BLS	L108(PC)
L109:
	CMPI	#197,-14(A6)
	BCS	L108(PC)
	CMPI	#215,-14(A6)
	BHI	L108(PC)
	CMPI	#147,-16(A6)
	BCS	L108(PC)
	CMPI	#155,-16(A6)
	BHI	L108(PC)
	MOVE	D7,-22(A6)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	PEA	-30(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L110
L111:
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
L110:
	SUBQ	#1,D7
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#32,D0
	BEQ.S	L111
L112:
	CLR	D7
	BRA.S	L113
L114:
	MOVE.L	A2,-(A7)
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	strcmp(PC)
	ADDQ.L	#8,A7
	TST	D0
	BNE.S	L117
	BRA.S	L3T281_011_
L117:
L115:
	ADDQ	#1,D7
L113:
	MOVE	D7,D0
	MOVE	G305_ui_Pa(A4),D1
	SUBQ	#1,D1
	CMP	D1,D0
	BCS.S	L114
L116:
	BRA	L98(PC)
L3T281_011_:
	CMPI	#2,D6
	BNE.S	L118
	LEA	8(A3),A0
	MOVE.L	A0,A2
L118:
	PEA	-30(A6)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	-22(A6),D7
	BRA	L119(PC)
L108:
	CMPI	#107,-14(A6)
	BCS.S	L120
	CMPI	#175,-14(A6)
	BHI.S	L120
	CMPI	#147,-16(A6)
	BCS.S	L120
	CMPI	#155,-16(A6)
	BHI.S	L120
	MOVE	#8,D5
	BRA	L106(PC)
L120:
	CMPI	#107,-14(A6)
	BCS.S	L122
	CMPI	#215,-14(A6)
	BHI.S	L122
	CMPI	#116,-16(A6)
	BCS.S	L122
	CMPI	#144,-16(A6)
	BLS.S	L121
L122:
	BRA	L3T281_023(PC)
L121:
	MOVE	-14(A6),D0
	ADDQ	#4,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	TST	D0
	BEQ.S	L124
	MOVE	-16(A6),D0
	ADDQ	#5,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	TST	D0
	BNE.S	L123
	CMPI	#207,-14(A6)
	BCS.S	L125
	CMPI	#135,-16(A6)
	BEQ.S	L123
L125:
L124:
	BRA.S	L3T281_023
L123:
	MOVE	#11,D5
	MOVE	-16(A6),D1
	SUB	#116,D1
	AND.L	#65535,D1
	DIVU	#10,D1
	MULU	D1,D5
	MOVE	D5,-40(A6)
	MOVE	#65,D5
	ADD	-40(A6),D5
	MOVE	-14(A6),D1
	SUB	#107,D1
	AND.L	#65535,D1
	DIVU	#10,D1
	ADD	D1,D5
	CMPI	#86,D5
	BEQ.S	L127
	CMPI	#97,D5
	BNE.S	L126
L127:
	MOVE	#13,D5
	BRA.S	L106
L126:
	CMPI	#87,D5
	BLT.S	L128
	SUBQ	#1,D5
L128:
	CMPI	#90,D5
	BLE.S	L129
	MOVE	D5,D0
	SUB	#90,D0
	LEA	G053_ac_Gr+-1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	MOVE	D0,D5
L129:
	BRA.S	L106
L119:
L107:
L3T281_023:
	MOVE	-18(A6),-20(A6)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L104:
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ	L105(PC)
L106:
	MOVE	-18(A6),-20(A6)
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L130
	MOVE	#7,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
L130:
	CMPI	#97,D5
	BLT.S	L131
	CMPI	#122,D5
	BGT.S	L131
	SUB	#32,D5
L131:
	CMPI	#65,D5
	BLT.S	L134
	CMPI	#90,D5
	BLE.S	L133
L134:
	CMPI	#46,D5
	BEQ.S	L133
	CMPI	#44,D5
	BEQ.S	L133
	CMPI	#59,D5
	BEQ.S	L133
	CMPI	#58,D5
	BEQ.S	L133
	CMPI	#32,D5
	BNE.S	L132
L133:
	CMPI	#32,D5
	BNE.S	L135
	CMPI	#0,D7
	BNE.S	L135
	BRA.S	L136
L135:
	MOVE	D4,D0
	BNE.S	L137
	MOVE	D5,D0
	MOVE.B	D0,G052_ac_Gr(A4)
	JSR	F077_aA39_(PC)
	PEA	G052_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
	MOVE	D5,D0
	MOVE	D7,D1
	ADDQ	#1,D7
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
	ADDQ	#6,-2(A6)
	CMPI	#1,D6
	BNE.S	L138
	CMPI	#7,D7
	BNE.S	L138
	BRA.S	L3T281_033_
L138:
L137:
L136:
	BRA	L139(PC)
L132:
	CMPI	#13,D5
	BNE.S	L140
	CMPI	#1,D6
	BNE.S	L141
	CMPI	#0,D7
	BLS.S	L141
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L3T281_033_:
	MOVE	#2,D6
	LEA	8(A3),A0
	MOVE.L	A0,A2
	MOVE	#105,-2(A6)
	MOVE	#109,-4(A6)
	CLR	D7
L141:
	BRA	L142(PC)
L140:
	CMPI	#8,D5
	BNE	L143(PC)
	CMPI	#1,D6
	BNE.S	L144
	CMPI	#0,D7
	BNE.S	L144
	BRA.S	L100
L144:
	MOVE	D4,D0
	BNE.S	L145
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L145:
	CMPI	#0,D7
	BNE.S	L146
	LEA	(A3),A0
	MOVE.L	A0,A2
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	SUBQ	#1,D0
	MOVE	D0,D7
	MOVE	#1,D6
	MOVE	#177,D0
	MOVE	D7,D1
	MULU	#6,D1
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	#91,-4(A6)
	BRA.S	L147
L146:
	SUBQ	#1,D7
	SUBQ	#6,-2(A6)
L147:
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
L143:
L142:
L139:
L100:
	BRA	L99(PC)
L101:
L98:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$97:	.EQU	#-40
F282_xzzz_:/* global */
	LINK	A6,L$148
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#162,8(A6)
	BNE	L150(PC)
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	CLR	G299_ui_Ca(A4)
	CMPI	#1,G305_ui_Pa(A4)
	BNE.S	L151
	MOVE	#-1,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L151:
	SUBQ	#1,G305_ui_Pa(A4)
	CLR	-8(A6)
	MOVE	#28,-6(A6)
	MOVE	D7,D0
	MULU	#69,D0
	MOVE	D0,-12(A6)
	ADD	#66,D0
	MOVE	D0,-10(A6)
	CLR	G578_B_Use(A4)
	JSR	F077_aA39_(PC)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	-12(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	MOVE.B	29(A3),D0
	AND	#255,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	JSR	F457_AA08_(PC)
	JSR	F078_xzzz_(PC)
	BRA	L152(PC)
L150:
	CLR	G299_ui_Ca(A4)
	MOVE	G306_i_Par(A4),-2(A6)
	MOVE	G307_i_Par(A4),-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	CLR	D6
	BRA.S	L153
L154:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#-1,D0
	BEQ.S	L157
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L157:
L155:
	ADDQ	#1,D6
L153:
	CMPI	#30,D6
	BCS.S	L154
L156:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L158:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L161
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	ANDI	#-128,2(A2)
	BRA.S	L160
L161:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L159:
	BRA.S	L158
L160:
	CMPI	#161,8(A6)
	BNE.S	L162
	MOVE.L	A3,-(A7)
	JSR	F281_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#120,-(A7)
	LEA	92(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	D6
	BRA.S	L163
L164:
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#7,D0
	SWAP	D0
	MOVE	D0,D5
	MOVE	D5,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	ADDQ.B	#1,(A0)
	MOVE	D5,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	ADDQ.B	#1,(A0)
L165:
	ADDQ	#1,D6
L163:
	CMPI	#12,D6
	BCS.S	L164
L166:
L162:
	CMPI	#1,G305_ui_Pa(A4)
	BNE.S	L167
	MOVE.L	G313_ul_Ga(A4),G362_l_Las(A4)
	CLR	-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L168
L167:
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
L168:
	JSR	F051_AA19_(PC)
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 52 45 53 55 52 52 45 43 54 45 44 2E 00 20 52 45 49 4E 43 41 52 4E 41 54 45 44 2E 00 00 
CODE SEG "player"
	CMPI	#160,8(A6)
	BNE.S	L169
	LEA	s!+58(A4),A0
	MOVE.L	A0,D0
	BRA.S	L170
L169:
	LEA	s!+72(A4),A0
	MOVE.L	A0,D0
L170:
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	JSR	F457_AA08_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L171
	MOVE	#0,D0
	BRA.S	L172
L171:
	MOVE	#1,D0
L172:
	MOVE	D0,-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
L152:
L149:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$148:	.EQU	#-12
F283_azzz_:/* global */
	LINK	A6,L$173
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	29(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L175
	CLR	D7
	BRA.S	L176
L177:
L178:
	ADDQ	#1,D7
L176:
	MOVE	D7,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BNE.S	L177
L179:
	MOVE	D7,D0
	MOVE.B	D0,29(A3)
L175:
	MOVE	54(A3),D7
	MOVE	D7,D0
	MOVE	D7,D1
	LSR	#6,D1
	SUB	D1,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#25,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,54(A3)
	ASR	#1,D0
	MOVE	D0,52(A3)
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	ORI	#-27648,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L174:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$173:	.EQU	#0
F284_czzz_:/* global */
	LINK	A6,L$180
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G308_i_Par(A4),D0
	BNE.S	L182
	BRA.S	L181
L182:
	MOVE	D7,D0
	SUB	G308_i_Par(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L183
	ADDQ	#4,D5
L183:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D6
	BRA.S	L184
L185:
	MOVE.B	29(A3),D0
	AND	#255,D0
	ADD	D5,D0
	AND	#3,D0
	MOVE.B	D0,29(A3)
	MOVE.B	28(A3),D0
	AND	#255,D0
	ADD	D5,D0
	AND	#3,D0
	MOVE.B	D0,28(A3)
	ADDA	#800,A3
L186:
	ADDQ	#1,D6
L184:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L185
L187:
	MOVE	D7,G308_i_Par(A4)
	JSR	F296_aizz_(PC)
L181:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$180:	.EQU	#0
F285_szzz_:/* global */
	LINK	A6,L$188
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#0,D0
	MOVE	D0,D6
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L190
L191:
	MOVE.B	29(A3),D0
	AND	#255,D0
	CMP	D7,D0
	BNE.S	L194
	MOVE	52(A3),D0
	BEQ.S	L194
	MOVE	D6,D0
	BRA.S	L189
L194:
L192:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	A3,D0
	ADDA	#800,A3
L190:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L191
L193:
	MOVE	#-1,D0
L189:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$188:	.EQU	#0
F286_hzzz_:/* global */
	LINK	A6,L$195
	MOVEM.L	D7-D6,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BEQ	L197(PC)
	MOVE	8(A6),D0
	MOVE	G306_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	10(A6),D0
	MOVE	G307_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	CMPI	#1,D0
	BGT.S	L197
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	PEA	-4(A6)
	JSR	F229_hzzz_(PC)
	ADDA	#14,A7
	CLR	D7
	BRA.S	L198
L199:
	MOVE	D7,D0
	LEA	-4(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#0,D0
	BLT.S	L202
	MOVE	D6,D0
	BRA.S	L196
L202:
L200:
	ADDQ	#1,D7
L198:
	CMPI	#4,D7
	BCS.S	L199
L201:
L197:
	MOVE	#-1,D0
L196:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$195:	.EQU	#-4
F287_xxxx_:/* global */
	LINK	A6,L$203
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	D6
	CMPI	#0,52(A3)
	BLE.S	L205
	MOVE	52(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	54(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L206
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L207
L206:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L207:
	BRA.S	L208
L205:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L208:
	CMPI	#0,56(A3)
	BLE.S	L209
	MOVE	56(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	58(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L210
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L211
L210:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L211:
	BRA.S	L212
L209:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L212:
	CMPI	#0,60(A3)
	BLE.S	L213
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BLE.S	L214
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	MOVE	#25,(A0)
	BRA.S	L215
L214:
	MOVE	60(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	62(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L216
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L217
L216:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L217:
L215:
	BRA.S	L218
L213:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L218:
	JSR	F077_aA39_(PC)
	MOVE.L	G348_pl_Bi(A4),A0
	LEA	320(A0),A0
	MOVE	8(A6),D1
	EXT.L	D1
	CMP	#3,D1
	BCS.S	L9T287_014
	MOVE.L	#-./,),(-*,(,D6
	MOVE.L	D6,D7
	ADDQ.L	#1,D7
	BRA.S	L9T287_017
L9T287_014:
	CMP	#2,D1
	BCS.S	L9T287_015
	MOVEQ	#0,D6
	MOVE.L	#-./,),(-*,(,D7
	BRA.S	L9T287_017
L9T287_015:
	CMP	#1,D1
	BCS.S	L9T287_016
	MOVE.L	#-2147483647,D6
	MOVE.L	D6,D7
	SUBQ.L	#1,D7
	BRA.S	L9T287_017
L9T287_016:
	MOVE.L	#-2147483647,D6
	MOVEQ	#1,D7
L9T287_017:
	ADD	D1,D1
	MOVE	D1,D2
	ADD	D1,D1
	ADD	D2,D1
	MOVE	D1,-8(A6)
	ADDQ	#4,-8(A6)
	LEA	-6(A6),A3
L9T287_018_:
	MOVE.L	A0,A2
	LEA	G056_aaui_(A4),A1
	ADDA	0(A1,D1),A2
	LSL	#1,D1
	LEA	G055_aaaui(A4),A1
	MOVE	0(A1,D1),D2
	MOVE	2(A1,D1),D3
	MOVE	D2,D4
	NOT	D4
	MOVE	D3,D5
	NOT	D5
	LSR	#1,D1
	MOVE	(A3)+,D0
	JSR	S287_xxxx_(PC)
	CMP	-8(A6),D1
	BEQ	L9T287_030(PC)
	ADDQ	#2,D1
	BRA.S	L9T287_018_
S287_xxxx_:/* global */
	MOVE	D1,-(A7)
	MOVE	#24,D1
L9T287_020_:
	CMP	D1,D0
	BHI.S	L9T287_021
	AND	D4,(A2)
	AND	D5,8(A2)
	AND	D4,2(A2)
	AND	D5,10(A2)
	OR	D2,4(A2)
	OR	D3,12(A2)
	OR	D2,6(A2)
	OR	D3,14(A2)
	BRA.S	L9T287_029
L9T287_021:
	TST	D6
	BEQ.S	L9T287_022
	OR	D2,(A2)
	OR	D3,8(A2)
	BRA.S	L9T287_023
L9T287_022:
	AND	D4,(A2)
	AND	D5,8(A2)
L9T287_023:
	TST.L	D6
	BGE.S	L9T287_024
	OR	D2,2(A2)
	OR	D3,10(A2)
	BRA.S	L9T287_025
L9T287_024:
	AND	D4,2(A2)
	AND	D5,10(A2)
L9T287_025:
	TST	D7
	BEQ.S	L9T287_026
	OR	D2,4(A2)
	OR	D3,12(A2)
	BRA.S	L9T287_027
L9T287_026:
	AND	D4,4(A2)
	AND	D5,12(A2)
L9T287_027:
	TST.L	D7
	BGE.S	L9T287_028
	OR	D2,6(A2)
	OR	D3,14(A2)
	BRA.S	L9T287_029
L9T287_028:
	AND	D4,6(A2)
	AND	D5,14(A2)
L9T287_029:
	LEA	160(A2),A2
	DBF	D1,L9T287_020_
	MOVE	(A7)+,D1
	RTS
L9T287_030:
	JSR	F078_xzzz_(PC)
L204:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$203:	.EQU	#-8
F288_xxxx_:/* global */
	LINK	A6,L$219
BSS SEG "bss"
11G419_ac_:
	.WORD	#6
CODE SEG "player"
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D6,D0
	BEQ.S	L221
	MOVE	#1,-(A7)
	MOVE	#32,-(A7)
	MOVE	#4,-(A7)
	PEA	11G419_ac_(A4)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
L221:
	LEA	11G419_ac_+4(A4),A0
	MOVE.L	A0,A3
	CLR.B	(A3)
	MOVE	D7,D0
	BNE.S	L222
	MOVE.B	#48,-(A3)
	BRA.S	L223
L222:
	BRA.S	L224
L225:
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,D7
	MULU	#10,D0
	MOVE	D0,-10(A6)
	MOVE	#48,D0
	ADD	D5,D0
	SUB	-10(A6),D0
	MOVE.B	D0,-(A3)
L224:
	MOVE	D7,D5
	BNE.S	L225
L226:
L223:
	MOVE	D6,D0
	BEQ.S	L227
	MOVE	#4,D0
	SUB	12(A6),D0
	LEA	11G419_ac_(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	BRA.S	L220
L227:
	MOVE.L	A3,D0
L220:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$219:	.EQU	#-10
F289_xxxx_:/* global */
	LINK	A6,L$228
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	10(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#55,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+88(A4)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#73,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#79,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
L229:
	UNLK	A6
	RTS
L$228:	.EQU	#0
F290_xxxx_:/* global */
	LINK	A6,L$230
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE	54(A3),-(A7)
	MOVE	52(A3),-(A7)
	MOVE	#116,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	58(A3),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-(A7)
	MOVE	56(A3),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-(A7)
	MOVE	#124,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	62(A3),-(A7)
	MOVE	60(A3),-(A7)
	MOVE	#132,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
L231:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$230:	.EQU	#0
F291_xxxx_:/* global */
	LINK	A6,L$232
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	10(A6),D7
	MOVE	#-1,-20(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G423_i_Inv(A4),D5
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	D5,D0
	BNE.S	L234
	CMPI	#1,D7
	BHI.S	L236
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L235
L236:
	BRA	L233(PC)
L235:
	MOVE	8(A6),D0
	ASL	#1,D0
	ADD	D7,D0
	MOVE	D0,-2(A6)
	BRA.S	L237
L234:
	MOVE	#8,D0
	ADD	D7,D0
	MOVE	D0,-2(A6)
L237:
	CMPI	#30,D7
	BCS.S	L238
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	BRA.S	L239
L238:
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	212(A3),A0
	ADDA	D6,A0
	MOVE	(A0),D6
L239:
	MOVE	-2(A6),D0
	MULS	#6,D0
	LEA	G030_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	(A2),D0
	SUBQ	#1,D0
	MOVE	D0,-18(A6)
	ADD	#17,D0
	MOVE	D0,-16(A6)
	MOVE	2(A2),D0
	SUBQ	#1,D0
	MOVE	D0,-14(A6)
	ADD	#17,D0
	MOVE	D0,-12(A6)
	MOVE	D5,D0
	BEQ.S	L240
	MOVE.L	G296_puc_B(A4),-24(A6)
	MOVE	#112,-26(A6)
	BRA.S	L241
L240:
	MOVE.L	G348_pl_Bi(A4),D0
	MOVE.L	D0,-24(A6)
	MOVE	#160,-26(A6)
	JSR	F077_aA39_(PC)
L241:
	CMPI	#-1,D6
	BNE.S	L242
	CMPI	#5,D7
	BHI.S	L243
	MOVE	#212,D4
	MOVE	D7,D1
	ASL	#1,D1
	ADD	D1,D4
	MOVE	50(A3),D0
	MOVE	#1,D1
	ASL	D7,D1
	AND	D1,D0
	BEQ.S	L244
	ADDQ	#1,D4
	MOVE	#34,-20(A6)
	BRA.S	L245
L244:
	MOVE	#33,-20(A6)
L245:
	CMPI	#1,D7
	BNE.S	L246
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G506_i_Act(A4),D0
	BNE.S	L246
	MOVE	#35,-20(A6)
L246:
	BRA.S	L247
L243:
	CMPI	#10,D7
	BCS.S	L248
	CMPI	#13,D7
	BHI.S	L248
	MOVE	#208,D4
	MOVE	D7,D1
	SUB	#10,D1
	ADD	D1,D4
	BRA.S	L249
L248:
	MOVE	#204,D4
L249:
L247:
	BRA.S	L250
L242:
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#5,D7
	BHI.S	L251
	CMPI	#1,D7
	BNE.S	L252
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G506_i_Act(A4),D0
	BNE.S	L252
	MOVE	#35,-20(A6)
	BRA.S	L253
L252:
	MOVE	50(A3),D0
	MOVE	#1,D1
	ASL	D7,D1
	AND	D1,D0
	BEQ.S	L254
	MOVE	#34,-20(A6)
	BRA.S	L255
L254:
	MOVE	#33,-20(A6)
L255:
L253:
L251:
L250:
	CMPI	#-1,-20(A6)
	BEQ.S	L256
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#12,-(A7)
	MOVE	-26(A6),-(A7)
	MOVE	#16,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	-18(A6)
	MOVE.L	-24(A6),-(A7)
	MOVE	-20(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L256:
	MOVE	D4,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	D5,D0
	BNE.S	L257
	JSR	F078_xzzz_(PC)
L257:
L233:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$232:	.EQU	#-26
F292_arzz_:/* global */
	LINK	A6,L$258
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULU	#69,D0
	MOVE	D0,-4(A6)
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	48(A3),D6
	MOVE	D6,D0
	AND	#-128,D0
	BNE.S	L260
	BRA	L259(PC)
L260:
	MOVE	D7,D5
	ADDQ	#1,D5
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	CLR	G578_B_Use(A4)
	JSR	F077_aA39_(PC)
	MOVE	D6,D0
	AND	#4096,D0
	BEQ	L261(PC)
	CLR	-12(A6)
	MOVE	#28,-10(A6)
	MOVE	-4(A6),D0
	MOVE	D0,-16(A6)
	ADD	#66,D0
	MOVE	D0,-14(A6)
	MOVE	52(A3),D0
	BEQ	L262(PC)
	MOVE	#160,-(A7)
	MOVE	#12,-(A7)
	PEA	-16(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#6,-(A7)
	PEA	-22(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	D4
	CMPI	#0,G407_s_Par+3206(A4)
	BLE.S	L263
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#38,(A0)
L263:
	CMPI	#0,G407_s_Par+3208(A4)
	BLE.S	L264
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#39,(A0)
L264:
	CMPI	#0,G407_s_Par+3204(A4)
	BGT.S	L266
	MOVE	274(A3),D0
	BEQ.S	L265
L266:
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#37,(A0)
L265:
	BRA.S	L267
L268:
	MOVE	#10,-(A7)
	MOVE	#40,-(A7)
	PEA	-16(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
L267:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L268
L269:
	MOVE	D5,D0
	BEQ.S	L270
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	OR	#256,D6
	BRA.S	L271
L270:
	OR	#-24192,D6
L271:
	BRA	L272(PC)
L262:
	MOVE	#-1,-(A7)
	MOVE	#40,-(A7)
	PEA	-16(A6)
	MOVE	#8,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#1,-(A7)
	MOVE	#13,-(A7)
	MOVE	#5,-(A7)
	MOVE	#1,D0
	ADD	-4(A6),D0
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	MOVE.B	29(A3),D0
	AND	#255,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	D7,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
	BRA	L15T292_042(PC)
L272:
L261:
	MOVE	52(A3),D0
	BNE.S	L273
	BRA	L15T292_042(PC)
L273:
	MOVE	D6,D0
	AND	#128,D0
	BEQ	L274(PC)
	MOVE	D7,D4
	MOVE	G411_i_Lea(A4),D1
	CMP	D1,D4
	BNE.S	L275
	MOVE	#9,D4
	BRA.S	L276
L275:
	MOVE	#13,D4
L276:
	MOVE	D5,D0
	BEQ	L277(PC)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	#3,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-32(A6)
	MOVE	#6,D0
	MULS	-32(A6),D0
	ADDQ	#3,D0
	MOVE	D0,-6(A6)
	MOVE.B	8(A3),-1(A6)
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#44,D0
	BEQ.S	L278
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#59,D0
	BEQ.S	L278
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#45,D0
	BEQ.S	L278
	ADDQ	#6,-6(A6)
L278:
	LEA	8(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	OR	#16384,D6
	BRA.S	L279
L277:
	CLR	-12(A6)
	MOVE	#6,-10(A6)
	MOVE	-4(A6),D0
	MOVE	D0,-16(A6)
	ADD	#42,D0
	MOVE	D0,-14(A6)
	MOVE	#160,-(A7)
	MOVE	#1,-(A7)
	PEA	-16(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	MOVE	#5,-(A7)
	MOVE	-4(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L279:
L274:
	MOVE	D6,D0
	AND	#256,D0
	BEQ	L280(PC)
	MOVE	D7,-(A7)
	JSR	F287_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
	BEQ	L281(PC)
	MOVE.L	A3,-(A7)
	JSR	F290_xxxx_(PC)
	ADDQ.L	#4,A7
	CMPI	#0,66(A3)
	BLT.S	L283
	CMPI	#0,68(A3)
	BLT.S	L283
	MOVE.B	42(A3),D0
	BEQ.S	L282
L283:
	MOVE	#34,-8(A6)
	BRA.S	L284
L282:
	MOVE	#33,-8(A6)
L284:
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G048_s_Gra(A4)
	MOVE	-8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#33,-8(A6)
	MOVE	#1,D4
	BRA.S	L285
L286:
	MOVE	D4,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D4,D1
	MULS	#3,D1
	LEA	70(A3),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGE.S	L289
	MOVE	#34,-8(A6)
	BRA.S	L288
L289:
L287:
	ADDQ	#1,D4
L285:
	CMPI	#6,D4
	BLE.S	L286
L288:
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G049_s_Gra(A4)
	MOVE	-8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	OR	#16384,D6
L281:
L280:
	MOVE	D6,D0
	AND	#8192,D0
	BEQ.S	L290
	MOVE	D5,D4
	BEQ.S	L295
	MOVE	#5,D4
	BRA.S	L296
L295:
	MOVE	#1,D4
L296:
	BRA.S	L291
L292:
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
L293:
	SUBQ	#1,D4
L291:
	CMPI	#0,D4
	BGE.S	L292
L294:
	MOVE	D5,D0
	BEQ.S	L297
	OR	#16384,D6
L297:
L290:
	MOVE	D6,D0
	AND	#512,D0
	BEQ	L298(PC)
	MOVE	D5,D0
	BEQ	L298(PC)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	MOVE	D0,-42(A6)
	MOVE	272(A3),D0
	CMP	-42(A6),D0
	BLS.S	L299
	MOVE	#8,-8(A6)
	BRA.S	L300
L299:
	MOVE	272(A3),D0
	AND.L	#65535,D0
	ASL.L	#3,D0
	MOVE	D4,D1
	EXT.L	D1
	MOVE.L	D1,-(A7)
	MOVE.L	#5,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	CMP.L	D1,D0
	BLE.S	L301
	MOVE	#11,-8(A6)
	BRA.S	L302
L301:
	MOVE	#13,-8(A6)
L302:
L300:
DATA SEG "s!"
	DATA 4C 4F 41 44 00 00 
CODE SEG "player"
	PEA	s!+90(A4)
	MOVE	-8(A6),-(A7)
	MOVE	#132,-(A7)
	MOVE	#104,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	272(A3),D4
	AND.L	#65535,D4
	DIVU	#10,D4
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2E 00 
CODE SEG "player"
	PEA	s!+96(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	272(A3),D0
	MOVE	D4,D1
	MULS	#10,D1
	SUB	D1,D0
	MOVE	D0,D4
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+98(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	ADDQ	#5,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,D4
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 4B 47 00 
CODE SEG "player"
	PEA	s!+100(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	-8(A6),-(A7)
	MOVE	#132,-(A7)
	MOVE	#148,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	OR	#16384,D6
L298:
	MOVE.B	29(A3),D4
	AND	#255,D4
	ADDQ	#4,D4
	SUB	G308_i_Par(A4),D4
	AND	#3,D4
	MOVE	D6,D0
	AND	#1024,D0
	BEQ	L303(PC)
	MOVE	G599_ui_Us(A4),D0
	MOVE	D4,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BEQ	L303(PC)
	MOVE	#160,-(A7)
	MOVE	D7,D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#160,-(A7)
	MOVE	#40,-(A7)
	CLR	-(A7)
	MOVE.B	28(A3),D0
	AND	#255,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	MULS	#19,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE	#28,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L303:
	MOVE	D6,D0
	AND	#2048,D0
	BEQ.S	L304
	MOVE	D5,D0
	BEQ.S	L304
	MOVE	G333_B_Pre(A4),D0
	BEQ.S	L305
	JSR	F345_xxxx_(PC)
	BRA.S	L306
L305:
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L307
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L308
	JSR	F351_xxxx_(PC)
L308:
	BRA.S	L309
L307:
	JSR	F347_xxxx_(PC)
L309:
L306:
	OR	#16384,D6
L304:
	MOVE	D6,D0
	AND	#-32768,D0
	BEQ.S	L310
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
	BEQ.S	L311
	OR	#16384,D6
L311:
L310:
	MOVE	D6,D0
	AND	#16384,D0
	BEQ.S	L312
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
L312:
L15T292_042:
	ANDI	#127,48(A3)
	JSR	F078_xzzz_(PC)
L259:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$258:	.EQU	#-42
F293_ahzz_:/* global */
	LINK	A6,L$313
	MOVE	D7,-(A7)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D7
	BRA.S	L315
L316:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L317:
	ADDQ	#1,D7
L315:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L316
L318:
L314:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$313:	.EQU	#0
F294_aozz_:/* global */
	LINK	A6,L$319
	MOVEM.L	A3-A2,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
	MOVE	10(A6),D0
	MOVE.L	-4(A6),A0
	ASL.L	#1,D0
	LEA	212(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	(A2),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BEQ.S	L321
	MOVE	#0,D0
	BRA	L320(PC)
L321:
	MOVE	(A2),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+20(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	1(A3),D0
	AND	#255,D0
	CMP	#16,D0
	BLT.S	L322
	MOVE.B	1(A3),D0
	AND	#255,D0
	CMP	#31,D0
	BGT.S	L322
	MOVE	#10,-10(A6)
	BRA.S	L323
L322:
	MOVE.B	1(A3),D0
	AND	#255,D0
	CMP	#32,D0
	BLT.S	L324
	MOVE.B	1(A3),D0
	AND	#255,D0
	CMP	#47,D0
	BGT.S	L324
	MOVE	#11,-10(A6)
	BRA.S	L325
L324:
	MOVE	#0,D0
	BRA.S	L320
L325:
L323:
	MOVE	12(A6),D0
	MOVE.L	-4(A6),A0
	ASL.L	#1,D0
	LEA	212(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	(A2),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L326
	MOVE	(A2),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+20(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr+1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	CMP	-10(A6),D0
	SEQ	D0
	TST.B	D0
L326:
	AND	#1,D0
L320:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$319:	.EQU	#-10
F295_xxxx_:/* global */
	LINK	A6,L$327
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,-(A7)
	JSR	F039_aaaL_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#32,D6
	BGE.S	L331
	CMPI	#0,D6
	BGE.S	L330
L331:
	CMPI	#148,D6
	BLT.S	L332
	CMPI	#163,D6
	BLE.S	L330
L332:
	CMPI	#195,D6
	BNE.S	L329
L330:
	MOVE	10(A6),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	D5,D0
	CMP	D6,D0
	BEQ.S	L333
	CMPI	#8,D7
	BGE.S	L334
	MOVE	G420_B_Mou(A4),D0
	BNE.S	L334
	MOVE	#1,G420_B_Mou(A4)
	JSR	F077_aA39_(PC)
L334:
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
	BRA.S	L328
L333:
L329:
	MOVE	#0,D0
L328:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$327:	.EQU	#0
F296_aizz_:/* global */
	LINK	A6,L$335
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G423_i_Inv(A4),D6
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L337
	MOVE	D6,D0
	BNE.S	L337
	BRA	L336(PC)
L337:
	CLR	G420_B_Mou(A4)
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#32,D0
	BGE.S	L340
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L339
L340:
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#148,D0
	BLT.S	L341
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#163,D0
	BLE.S	L339
L341:
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#195,D0
	BNE.S	L338
L339:
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	-2(A6),D0
	CMP	D5,D0
	BEQ.S	L342
	MOVE	#1,G420_B_Mou(A4)
	JSR	F077_aA39_(PC)
	MOVE.L	G412_puc_B(A4),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE.L	G412_puc_B(A4),-(A7)
	JSR	F068_aagz_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),G413_i_Lea(A4)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L342:
L338:
	CLR	D7
	BRA.S	L343
L344:
	MOVE	D7,D4
	LSR	#1,D4
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L347
	BRA.S	L345
L347:
	MOVE	D7,D0
	AND	#1,D0
	MOVE	D4,D1
	MULS	#800,D1
	LEA	G407_s_Par+212(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D0
	LEA	(A0),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L348
	MOVE	D7,D0
	AND	#1,D0
	CMPI	#1,D0
	BNE.S	L348
	MOVE	D4,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L348:
L345:
	ADDQ	#1,D7
L343:
	MOVE	D7,D0
	MOVE	G305_ui_Pa(A4),D1
	ASL	#1,D1
	CMP	D1,D0
	BCS.S	L344
L346:
	MOVE	D6,D0
	BEQ	L349(PC)
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	#0,D0
	MOVE	D0,D7
	ASL.L	#1,D0
	LEA	212(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	D5
	BRA.S	L350
L351:
	MOVE	(A3),-(A7)
	MOVE	D7,D0
	ADDQ	#8,D0
	MOVE	D0,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	OR	D0,D5
	MOVE	-4(A6),D0
	BEQ.S	L354
	CMPI	#1,D7
	BNE.S	L354
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L354:
L352:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#2,A3
L350:
	CMPI	#30,D7
	BCS.S	L351
L353:
	CMPI	#4,G424_i_Pan(A4)
	BNE.S	L355
	LEA	G425_aT_Ch(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L356
L357:
	MOVE	(A3),-(A7)
	MOVE	D7,D0
	ADD	#38,D0
	MOVE	D0,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	OR	D0,D5
L358:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#2,A3
L356:
	CMPI	#8,D7
	BCS.S	L357
L359:
L355:
	MOVE	D5,D0
	BEQ.S	L360
	ORI	#16384,48(A2)
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L360:
L349:
	MOVE	G420_B_Mou(A4),D0
	BEQ.S	L361
	JSR	F078_xzzz_(PC)
L361:
L336:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$335:	.EQU	#-4
F297_atzz_:/* global */
	LINK	A6,L$362
	CMPI	#-1,8(A6)
	BNE.S	L364
	BRA	L363(PC)
L364:
	CLR	G415_B_Lea(A4)
	MOVE.L	G412_puc_B(A4),-(A7)
	MOVE	8(A6),D0
	MOVE	D0,G414_T_Lea(A4)
	MOVE	D0,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,G413_i_Lea(A4)
	MOVE	D0,-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	JSR	F077_aA39_(PC)
	MOVE	8(A6),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
	MOVE	10(A6),D0
	BEQ.S	L365
	MOVE	#1,G325_B_Set(A4)
	BRA.S	L366
L365:
	MOVE.L	G412_puc_B(A4),-(A7)
	JSR	F068_aagz_(PC)
	ADDQ.L	#4,A7
L366:
	JSR	F078_xzzz_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L367
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L367:
L363:
	UNLK	A6
	RTS
L$362:	.EQU	#0
F298_aqzz_:/* global */
	LINK	A6,L$368
	MOVE	D7,-(A7)
	MOVE	#1,G415_B_Lea(A4)
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L370
	MOVE	#-1,G414_T_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	JSR	F077_aA39_(PC)
	JSR	F035_aaaw_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L371
	MOVE	#0,D0
	BRA.S	L372
L371:
	MOVE	#1,D0
L372:
	MOVE	D0,-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L373
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L373:
L370:
	MOVE	D7,D0
L369:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$368:	.EQU	#0
F299_xxxx_:/* global */
	LINK	A6,L$374
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CLR	D4
	MOVE	18(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D5
	CMPI	#5,D0
	BEQ.S	L377
	CMPI	#6,D5
	BNE.S	L376
L377:
	CMPI	#0,D7
	BCS.S	L376
	CMPI	#12,D7
	BHI.S	L376
	MOVE	18(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#5,D5
	BNE.S	L380
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#256,D0
	LSR	#8,D0
	BNE.S	L379
L380:
	CMPI	#6,D5
	BNE.S	L378
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#256,D0
	LSR	#8,D0
	BEQ.S	L378
L379:
	CLR	D5
	MOVE	#-3,D4
	BRA	L22T299_044(PC)
L378:
L376:
	CMPI	#137,D6
	BNE.S	L381
	CLR	D5
	MOVE	#10,D4
	BRA	L382(PC)
L381:
	CMPI	#1,D7
	BNE	L383(PC)
	CMPI	#45,D6
	BNE.S	L384
	MOVE	#1,D5
	MOVE	#5,D4
	BRA	L385(PC)
L384:
	MOVE	#8,D5
	CMPI	#20,D6
	BCS.S	L386
	CMPI	#22,D6
	BHI.S	L386
	MOVE	#4,D4
	BRA	L387(PC)
L386:
	CMPI	#58,D6
	BCS	L388(PC)
	CMPI	#66,D6
	BHI	L388(PC)
	MOVE	D6,D0
L389:
	CMP	#58,D0
	BEQ.S	L390
	BRA.S	L392
L390:
	MOVE	#2,D4
	BRA	L391(PC)
	BRA.S	L393
L392:
	CMP	#59,D0
	BEQ.S	L393
	BRA.S	L394
L393:
	MOVE	#1,D4
	BRA.S	L391
	BRA.S	L395
L394:
	CMP	#60,D0
	BEQ.S	L395
	BRA.S	L396
L395:
	MOVE	#6,D4
	BRA.S	L391
	BRA.S	L397
L396:
	CMP	#61,D0
	BEQ.S	L397
	BRA.S	L398
L397:
	MOVE	#4,D4
	BRA.S	L391
	BRA.S	L399
L398:
	CMP	#62,D0
	BEQ.S	L399
	BRA.S	L400
L399:
	MOVE	#10,D4
	BRA.S	L391
	BRA.S	L401
L400:
	CMP	#63,D0
	BEQ.S	L401
	BRA.S	L402
L401:
	MOVE	#8,D4
	BRA.S	L391
	BRA.S	L403
L402:
	CMP	#64,D0
	BEQ.S	L403
	BRA.S	L404
L403:
	MOVE	#16,D4
	BRA.S	L391
	BRA.S	L405
L404:
	CMP	#65,D0
	BEQ.S	L405
	BRA.S	L406
L405:
	MOVE	#7,D4
	BRA.S	L391
	BRA.S	L407
L406:
	CMP	#66,D0
	BEQ.S	L407
	BRA.S	L408
L407:
	MOVE	#5,D4
L408:
L409:
L391:
	BRA.S	L410
L388:
	MOVE	D6,D0
L411:
	CMP	#38,D0
	BEQ.S	L412
	BRA.S	L414
L412:
	MOVE	#1,D4
	BRA.S	L413
	BRA.S	L415
L414:
	CMP	#41,D0
	BEQ.S	L415
	BRA.S	L416
L415:
	MOVE	#2,D4
	BRA.S	L413
	BRA.S	L417
L416:
	CMP	#40,D0
	BEQ.S	L417
	BRA.S	L418
L417:
	MOVE	#4,D4
L418:
L419:
L413:
L410:
L387:
L385:
	BRA	L420(PC)
L383:
	CMPI	#4,D7
	BNE.S	L421
	CMPI	#142,D6
	BNE.S	L422
	MOVE	#1,D5
	MOVE	#10,D4
L422:
	BRA	L423(PC)
L421:
	CMPI	#2,D7
	BNE.S	L424
	CMPI	#104,D6
	BNE.S	L425
	MOVE	#3,D5
	MOVE	#10,D4
	BRA.S	L426
L425:
	CMPI	#140,D6
	BNE.S	L427
	MOVE	#2,D5
	MOVE	#10,D4
L427:
L426:
	BRA.S	L428
L424:
	CMPI	#3,D7
	BNE.S	L429
	CMPI	#141,D6
	BNE.S	L430
	MOVE	#6,D5
	MOVE	#12,D4
	BRA.S	L431
L430:
	CMPI	#81,D6
	BNE.S	L432
	MOVE	#2,D5
	MOVE	#8,D4
L432:
L431:
	BRA.S	L433
L429:
	CMPI	#10,D7
	BNE.S	L434
	CMPI	#10,D6
	BCS.S	L435
	CMPI	#11,D6
	BHI.S	L435
	MOVE	#5,D5
	MOVE	#15,D4
	BRA.S	L436
L435:
	CMPI	#81,D6
	BNE.S	L437
	MOVE	#2,D5
	MOVE	#8,D4
	BRA.S	L438
L437:
	CMPI	#122,D6
	BNE.S	L439
	MOVE	#8,D5
	MOVE	#3,D4
L439:
L438:
L436:
L434:
L433:
L428:
L423:
L420:
L382:
L22T299_044:
	MOVE	D4,D0
	BEQ.S	L440
	MOVE	D4,D0
	MULS	16(A6),D0
	MOVE	D0,D4
	CMPI	#8,D5
	BNE.S	L441
	MOVE	D4,D0
	ADD	D0,62(A3)
	BRA.S	L442
L441:
	CMPI	#7,D5
	BGE.S	L443
	CLR	D7
	BRA.S	L444
L445:
	MOVE	D5,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADD.L	A0,D0
	MOVE.L	D0,-14(A6)
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	-14(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D4,D0
	MOVE.B	D0,(A0)
L444:
	CMPI	#2,D7
	BLS.S	L445
L446:
L443:
L442:
	ORI	#2304,48(A3)
L440:
L375:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$374:	.EQU	#-14
F300_aozz_:/* global */
	LINK	A6,L$447
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	10(A6),D7
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#30,D7
	BCS.S	L449
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L450
L449:
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	212(A3),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L450:
	CMPI	#-1,D6
	BNE.S	L451
	MOVE	#-1,D0
	BRA	L448(PC)
L451:
	MOVE	8(A6),D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	D6,-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F299_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#10,D7
	BNE.S	L452
	CMPI	#12,D5
	BLT.S	L453
	CMPI	#13,D5
	BGT.S	L453
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	MOVE	G039_ai_Gr+4(A4),D0
	SUB	D0,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	BRA.S	L454
L453:
	CMPI	#10,D5
	BLT.S	L455
	CMPI	#11,D5
	BGT.S	L455
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
L455:
L454:
L452:
	MOVE	D7,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),D0
	BEQ.S	L456
	ORI	#16384,48(A3)
L456:
	CMPI	#2,D7
	BCC	L457(PC)
	CMPI	#1,D7
	BNE.S	L458
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L459
	JSR	F388_rzzz_(PC)
L459:
	CMPI	#30,D5
	BLT.S	L460
	CMPI	#31,D5
	BGT.S	L460
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,2(A0)
	OR	D3,2(A0)
	JSR	F296_aizz_(PC)
L460:
L458:
	CMPI	#4,D5
	BLT.S	L461
	CMPI	#7,D5
	BGT.S	L461
	MOVE	#0,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ASL	#8,D3
	ANDI	#32767,2(A2)
	OR	D3,2(A2)
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
L461:
	MOVE	-2(A6),D0
	BEQ.S	L462
	CMPI	#1,D7
	BNE.S	L462
	CMPI	#144,D5
	BNE.S	L463
	JSR	F334_akzz_(PC)
	ORI	#2048,48(A3)
	BRA.S	L464
L463:
	CMPI	#30,D5
	BLT.S	L465
	CMPI	#31,D5
	BGT.S	L465
	ORI	#2048,48(A3)
L465:
L464:
L462:
L457:
	MOVE	D6,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	SUB	D0,272(A3)
	ORI	#512,48(A3)
	MOVE	D6,D0
L448:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$447:	.EQU	#-2
F301_apzz_:/* global */
	LINK	A6,L$466
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	CMPI	#-1,D6
	BNE.S	L468
	BRA	L467(PC)
L468:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#30,D5
	BCS.S	L469
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	BRA.S	L470
L469:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L470:
	MOVE	D6,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	ADD	D0,272(A3)
	ORI	#512,48(A3)
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE	D6,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F299_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#2,D5
	BCC	L471(PC)
	CMPI	#1,D5
	BNE.S	L472
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	MOVE	D7,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L473
	JSR	F388_rzzz_(PC)
L473:
	CMPI	#30,D4
	BLT.S	L474
	CMPI	#31,D4
	BGT.S	L474
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,2(A0)
	OR	D3,2(A0)
	JSR	F296_aizz_(PC)
L474:
L472:
	CMPI	#4,D4
	BNE.S	L475
	MOVE	#1,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ASL	#8,D3
	ANDI	#32767,2(A2)
	OR	D3,2(A2)
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
	BRA.S	L476
L475:
	MOVE	-2(A6),D0
	BEQ.S	L477
	CMPI	#1,D5
	BNE.S	L477
	CMPI	#144,D4
	BEQ.S	L478
	CMPI	#30,D4
	BLT.S	L477
	CMPI	#31,D4
	BGT.S	L477
L478:
	ORI	#2048,48(A3)
L477:
L476:
	BRA.S	L479
L471:
	CMPI	#10,D5
	BNE.S	L480
	CMPI	#12,D4
	BLT.S	L481
	CMPI	#13,D4
	BGT.S	L481
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	MOVE	G039_ai_Gr+4(A4),D0
	ADD	D0,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	ADDQ	#1,D4
	BRA.S	L482
L481:
	CMPI	#10,D4
	BLT.S	L483
	CMPI	#11,D4
	BGT.S	L483
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	ADDQ	#1,D4
L483:
L482:
L480:
L479:
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),D0
	BEQ.S	L484
	ORI	#16384,48(A3)
L484:
L467:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$466:	.EQU	#-2
F302_mzzz_:/* global */
	LINK	A6,L$485
	MOVEM.L	D7-D4,-(A7)
	CMPI	#8,8(A6)
	BCC.S	L487
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L488
	BRA	L486(PC)
L488:
	MOVE	8(A6),D7
	LSR	#1,D7
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L490
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BEQ.S	L490
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L489
L490:
	BRA	L486(PC)
L489:
	MOVE	8(A6),D6
	AND	#1,D6
	BRA.S	L491
L487:
	MOVE	G423_i_Inv(A4),D7
	SUBQ	#1,D7
	MOVE	8(A6),D6
	SUBQ	#8,D6
L491:
	MOVE	G414_T_Lea(A4),D5
	CMPI	#30,D6
	BCS.S	L492
	MOVE	D6,D4
	ASL.L	#1,D4
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	BRA.S	L493
L492:
	MOVE	D6,D4
	MOVE	D7,D1
	MULS	#800,D1
	LEA	G407_s_Par+212(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D4
	LEA	(A0),A0
	ADDA	D4,A0
	MOVE	(A0),D4
L493:
	CMPI	#-1,D4
	BNE.S	L494
	CMPI	#-1,D5
	BNE.S	L494
	BRA.S	L486
L494:
	CMPI	#-1,D5
	BEQ.S	L495
	MOVE	D5,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G038_ai_Gr(A4),A0
	ADDA	D1,A0
	AND	(A0),D0
	BNE.S	L495
	BRA.S	L486
L495:
	JSR	F077_aA39_(PC)
	CMPI	#-1,D5
	BEQ.S	L496
	JSR	F298_aqzz_(PC)
L496:
	CMPI	#-1,D4
	BEQ.S	L497
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L497:
	CMPI	#-1,D5
	BEQ.S	L498
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
L498:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L486:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$485:	.EQU	#0
F303_AA09_:/* global */
	LINK	A6,L$499
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L501
	MOVE	#1,D0
	BRA	L500(PC)
L501:
	MOVE	10(A6),D0
	AND	#-32768,D0
	MOVE	D0,-2(A6)
	MOVE	10(A6),D0
	AND	#16384,D0
	MOVE	D0,-4(A6)
	ANDI	#16383,10(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	10(A6),D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	2(A3),D7
	MOVE	-2(A6),D0
	BNE.S	L502
	MOVE	(A3),D0
	EXT.L	D0
	ADD.L	D0,D7
L502:
	CMPI	#3,10(A6)
	BLS.S	L503
	MOVE	10(A6),D0
	SUBQ	#4,D0
	LSR	#2,D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	ADD.L	2(A3),D7
	MOVE	-2(A6),D0
	BNE.S	L504
	MOVE	(A3),D0
	EXT.L	D0
	ADD.L	D0,D7
L504:
	MOVE.L	D7,D0
	ASR.L	#1,D0
	MOVE.L	D0,D7
L503:
	MOVE	#1,D6
	BRA.S	L505
L506:
	MOVE.L	D7,D0
	ASR.L	#1,D0
	MOVE.L	D0,D7
	ADDQ	#1,D6
L505:
	CMPI.L	#500,D7
	BGE.S	L506
L507:
	MOVE	-4(A6),D0
	BNE	L508(PC)
	MOVE	214(A2),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#27,D0
	BNE.S	L509
	ADDQ	#1,D6
	BRA.S	L510
L509:
	CMPI	#28,D4
	BNE.S	L511
	ADDQ	#2,D6
	BRA.S	L512
L511:
	MOVE	232(A2),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	10(A6),D0
L513:
	CMP	#3,D0
	BEQ.S	L514
	BRA.S	L516
L514:
	CMPI	#124,D5
	BNE.S	L518
	ADDQ	#1,D6
L518:
	BRA.S	L515
	BRA.S	L517
L516:
	CMP	#15,D0
	BEQ.S	L517
	BRA.S	L519
L517:
	CMPI	#121,D5
	BNE.S	L521
	ADDQ	#1,D6
L521:
	BRA.S	L515
	BRA.S	L520
L519:
	CMP	#13,D0
	BEQ.S	L520
	BRA.S	L522
L520:
	CMPI	#120,D5
	BEQ.S	L525
	CMPI	#66,D4
	BNE.S	L524
L525:
	ADDQ	#1,D6
L524:
	BRA.S	L515
	BRA.S	L523
L522:
	CMP	#14,D0
	BEQ.S	L523
	BRA.S	L526
L523:
	CMPI	#122,D5
	BNE.S	L528
	ADDQ	#1,D6
L528:
L526:
L527:
L515:
L512:
L510:
L508:
	MOVE	D6,D0
L500:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$499:	.EQU	#-4
F304_apzz_:/* global */
	LINK	A6,L$529
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	12(A6),D7
	CMPI	#4,10(A6)
	BCS.S	L531
	CMPI	#11,10(A6)
	BHI.S	L531
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#150,D1
	CMP.L	D1,D0
	BGE.S	L531
	MOVE	D7,D0
	LSR	#1,D0
	MOVE	D0,D7
L531:
	MOVE	D7,D0
	BEQ	L532(PC)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D6
	AND	#-4096,D6
	LSR	#4,D6
	LSR	#8,D6
	BEQ.S	L533
	MOVE	D7,D0
	MULU	D6,D0
	MOVE	D0,D7
L533:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#4,10(A6)
	BCS.S	L534
	MOVE	10(A6),D5
	SUBQ	#4,D5
	LSR	#2,D5
	BRA.S	L535
L534:
	MOVE	10(A6),D5
L535:
	MOVE.L	2(A3),D4
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	CMPI	#4,10(A6)
	BCS.S	L536
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#25,D1
	CMP.L	D1,D0
	BLE.S	L536
	MOVE	D7,D0
	ASL	#1,D0
	MOVE	D0,D7
L536:
	MOVE	10(A6),D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D7,D0
	AND.L	#65535,D0
	ADD.L	D0,2(A3)
	CMPI	#32000,(A3)
	BGE.S	L537
	MOVE	#100,-(A7)
	MOVE	D7,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	ADD	D0,(A3)
L537:
	MOVE	D5,D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#4,10(A6)
	BCS.S	L538
	MOVE	D7,D0
	AND.L	#65535,D0
	ADD.L	D0,2(A3)
L538:
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	D7,D0
	CMP	D6,D0
	BLS	L539(PC)
	MOVE	D7,-6(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,-2(A6)
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	MOVE	#1,D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,D6
	CMPI	#2,D5
	BEQ.S	L540
	AND	D7,D6
L540:
	MOVE	D6,D0
	ADD.B	D0,82(A2)
	MOVE	58(A2),D6
	JSR	F028_a000_(PC)
	MOVE	D7,D1
	NOT	D1
	AND	D1,D0
	ADD.B	D0,88(A2)
	MOVE	D5,D0
L541:
	CMP	#0,D0
	BEQ.S	L542
	BRA.S	L544
L542:
	MOVE	D6,D0
	LSR	#4,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MULU	#3,D0
	MOVE	D0,D7
	MOVE	-4(A6),D0
	ADD.B	D0,73(A2)
	MOVE	-2(A6),D0
	ADD.B	D0,76(A2)
	BRA	L543(PC)
	BRA.S	L545
L544:
	CMP	#1,D0
	BEQ.S	L545
	BRA.S	L546
L545:
	MOVE	D6,D0
	AND.L	#65535,D0
	DIVU	#21,D0
	MOVE	D0,D6
	MOVE	D7,D0
	ASL	#1,D0
	MOVE	D0,D7
	MOVE	-2(A6),D0
	ADD.B	D0,73(A2)
	MOVE	-4(A6),D0
	ADD.B	D0,76(A2)
	BRA	L543(PC)
	BRA.S	L547
L546:
	CMP	#3,D0
	BEQ.S	L547
	BRA.S	L548
L547:
	MOVE	D6,D0
	LSR	#5,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MOVE	D7,D1
	LSR	#1,D1
	ADD	D1,D0
	ADD	D0,62(A2)
	MOVE	-4(A6),D0
	ADD.B	D0,79(A2)
	BRA.S	L27T304_016
	BRA.S	L549
L548:
	CMP	#2,D0
	BEQ.S	L549
	BRA.S	L550
L549:
	MOVE	D6,D0
	AND.L	#65535,D0
	DIVU	#25,D0
	MOVE	D0,D6
	MOVE	D7,D0
	ADD	D0,62(A2)
	MOVE	D7,D0
	ADDQ	#1,D0
	LSR	#1,D0
	ADD	D0,D7
	MOVE	-2(A6),D0
	ADD.B	D0,79(A2)
L27T304_016:
	MOVE	-6(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	62(A2),D0
	ADD	D1,D0
	MOVE	D0,62(A2)
	CMPI	#900,D0
	BLE.S	L552
	MOVE	#900,62(A2)
L552:
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	ADD.B	D0,85(A2)
L550:
L551:
L543:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE	D7,D0
	LSR	#1,D0
	ADDQ	#1,D0
	AND.L	#65535,D1
	DIVU	D0,D1
	SWAP	D1
	MOVE	D1,-16(A6)
	MOVE	D7,D1
	ADD	-16(A6),D1
	MOVE	54(A2),D0
	ADD	D1,D0
	MOVE	D0,54(A2)
	CMP	#999,D0
	BLE.S	L553
	MOVE	#999,54(A2)
L553:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE	D6,D0
	LSR	#1,D0
	ADDQ	#1,D0
	AND.L	#65535,D1
	DIVU	D0,D1
	SWAP	D1
	MOVE	D1,-26(A6)
	MOVE	D6,D1
	ADD	-26(A6),D1
	MOVE	58(A2),D0
	ADD	D1,D0
	MOVE	D0,58(A2)
	CMP	#9999,D0
	BLE.S	L554
	MOVE	#9999,58(A2)
L554:
	ORI	#256,48(A2)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F051_AA19_(PC)
	LEA	(A2),A0
	MOVE.L	A0,-(A7)
	MOVE	8(A6),D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 4A 55 53 54 20 47 41 49 4E 45 44 20 41 20 00 
CODE SEG "player"
	PEA	s!+104(A4)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 4C 45 56 45 4C 21 00 
CODE SEG "player"
	PEA	s!+120(A4)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L539:
L532:
L530:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$529:	.EQU	#-26
F305_xxxx_:/* global */
	LINK	A6,L$555
	MOVEM.L	D7-D6,-(A7)
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	LSR	#1,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	BRA.S	L557
L558:
	MOVE	D7,D0
	ASR	#1,D0
	ADD	D0,D6
L557:
	MOVE	D7,D0
	SUB	#10,D0
	MOVE	D0,D7
	CMPI	#0,D0
	BGT.S	L558
L559:
	MOVE	D6,D0
L556:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$555:	.EQU	#0
F306_xxxx_:/* global */
	LINK	A6,L$560
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	56(A3),D0
	MOVE	D0,D7
	MOVE	58(A3),D1
	ASR	#1,D1
	MOVE	D1,D6
	CMP	D1,D0
	BGE.S	L562
	MOVE	12(A6),D0
	ASR	#1,D0
	MOVE	D0,12(A6)
	MOVE	12(A6),D1
	EXT.L	D1
	MOVE	D7,D2
	EXT.L	D2
	MOVE.L	D1,-(A7)
	MOVE.L	D2,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	MOVE.L	D1,-(A7)
	MOVE	D6,D1
	EXT.L	D1
	MOVE.L	D1,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D1
	ADDQ.L	#4,A7
	ADD	D1,D0
	BRA.S	L561
L562:
	MOVE	12(A6),D0
L561:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$560:	.EQU	#0
F307_fzzz_:/* global */
	LINK	A6,L$563
	MOVE	D7,-(A7)
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MULS	#3,D0
	LEA	71(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D0,-10(A6)
	MOVE	#170,D0
	MOVE.B	-10(A6),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,D7
	CMPI	#16,D0
	BGE.S	L565
	MOVE	14(A6),D0
	LSR	#3,D0
	BRA.S	L564
L565:
	MOVE	D7,-(A7)
	MOVE	#7,-(A7)
	MOVE	14(A6),-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
L564:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$563:	.EQU	#-10
F308_vzzz_:/* global */
	LINK	A6,L$566
	MOVEM.L	A3/D7,-(A7)
	MOVE	12(A6),D7
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L568
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#100,D0
	SWAP	D0
	CMP	D7,D0
	BLS.S	L568
	MOVE	#1,D0
	BRA.S	L567
L568:
	MOVE.L	8(A6),A0
	LEA	70(A0),A0
	MOVE.L	A0,A3
	JSR	F027_AA59_(PC)
	MOVE.B	1(A3),D1
	AND	#255,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	CMP	D7,D0
	SHI	D0
	AND	#1,D0
	MOVE	D0,D7
	MOVE.B	(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	MOVE	D7,D1
	BEQ.S	L569
	MOVE	#-2,D1
	BRA.S	L570
L569:
	MOVE	#2,D1
L570:
	AND	#255,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,1(A3)
	MOVE	D7,D0
L567:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$566:	.EQU	#0
F309_awzz_:/* global */
	LINK	A6,L$571
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	74(A3),D7
	AND	#255,D7
	ASL	#3,D7
	ADD	#100,D7
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F306_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	50(A3),D6
	BEQ.S	L573
	MOVE	D7,D0
	MOVE	D6,D1
	AND	#16,D1
	BEQ.S	L574
	MOVE	#2,D1
	BRA.S	L575
L574:
	MOVE	#3,D1
L575:
	LSR	D1,D0
	SUB	D0,D7
L573:
	MOVE	222(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#119,D0
	BNE.S	L576
	MOVE	D7,D0
	LSR	#4,D0
	ADD	D0,D7
L576:
	ADD	#9,D7
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	SUB	D0,D7
	MOVE	D7,D0
L572:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$571:	.EQU	#0
F310_AA08_:/* global */
	LINK	A6,L$577
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	MOVE	272(A3),D1
	MOVE	D1,D7
	CMP	D1,D0
	BLS.S	L579
	MOVE	#2,D5
	MOVE	D7,D0
	AND.L	#65535,D0
	ASL.L	#3,D0
	MOVE	D6,D1
	AND.L	#65535,D1
	MOVE.L	D1,-(A7)
	MOVE.L	#5,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	CMP.L	D1,D0
	BLE.S	L580
	ADDQ	#1,D5
L580:
	MOVE	#1,D7
	BRA.S	L581
L579:
	MOVE	#4,D5
	MOVE	D7,D1
	SUB	D6,D1
	ASL	#2,D1
	AND.L	#65535,D1
	DIVU	D6,D1
	ADD	D1,D5
	MOVE	#2,D7
L581:
	MOVE	50(A3),D0
	AND	#32,D0
	BEQ.S	L582
	ADD	D7,D5
L582:
	MOVE	222(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#194,D0
	BNE.S	L583
	SUBQ	#1,D5
L583:
	MOVE	D5,D0
L578:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$577:	.EQU	#0
F311_wzzz_:/* global */
	LINK	A6,L$584
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	JSR	F027_AA59_(PC)
	AND	#7,D0
	MOVE.B	77(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	D7,D0
	ASR	#1,D0
	EXT.L	D0
	MOVE	272(A3),D1
	AND.L	#65535,D1
	MOVE.L	D0,-(A7)
	MOVE.L	D1,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE	D1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D0
	ADDQ.L	#4,A7
	SUB	D0,D7
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L586
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L586:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	#100,D0
	SUB	D1,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	#1,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L585:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$584:	.EQU	#0
F312_xzzz_:/* global */
	LINK	A6,L$587
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE.B	74(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	10(A6),D4
	ASL.L	#1,D4
	LEA	212(A3),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	D4,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	LSR	#4,D1
	MOVE	D1,D5
	CMP	D1,D0
	BHI.S	L589
	MOVE	D6,D0
	SUB	#12,D0
	ADD	D0,D7
	BRA.S	L590
L589:
	MOVE	D5,D0
	MOVE	D5,D1
	SUB	#12,D1
	LSR	#1,D1
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D0,-12(A6)
	MOVE	D6,D0
	CMP	-12(A6),D0
	BHI.S	L591
	MOVE	D6,D0
	SUB	D5,D0
	LSR	#1,D0
	ADD	D0,D7
	BRA.S	L592
L591:
	MOVE	D6,D0
	SUB	-2(A6),D0
	ASL	#1,D0
	SUB	D0,D7
L592:
L590:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE	L593(PC)
	MOVE	D4,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+20(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	2(A2),D0
	AND	#255,D0
	ADD	D0,D7
	CLR	D6
	MOVE.B	1(A2),D5
	AND	#255,D5
	CMPI	#0,D5
	BEQ.S	L595
	CMPI	#2,D5
	BNE.S	L594
L595:
	MOVE	#4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
L594:
	CMPI	#0,D5
	BEQ.S	L596
	CMPI	#16,D5
	BCC.S	L596
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D6
L596:
	CMPI	#16,D5
	BCS.S	L597
	CMPI	#112,D5
	BCC.S	L597
	MOVE	#11,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D6
L597:
	MOVE	D6,D0
	ASL	#1,D0
	ADD	D0,D7
L593:
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F306_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	50(A3),D0
	CMPI	#0,10(A6)
	BNE.S	L599
	MOVE	#1,D1
	BRA.S	L600
L599:
	MOVE	#2,D1
L600:
	AND	D1,D0
	BEQ.S	L598
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L598:
	MOVE	#100,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L588:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$587:	.EQU	#-12
F313_xxxx_:/* global */
	LINK	A6,L$601
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	10(A6),D5
	AND	#-32768,D5
	BEQ.S	L603
	ANDI	#32767,10(A6)
L603:
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE	#0,D0
	MOVE	D0,D7
	BRA	L604(PC)
L605:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#6,D0
	BNE.S	L608
	MOVE	D4,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+24(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	ASL.L	#2,D0
	LEA	G239_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	2(A2),D0
	AND	#255,D0
	AND	#128,D0
	BEQ.S	L609
	MOVE	D7,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F143_mzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	10(A6),D1
	LEA	G050_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULU	D1,D0
	MOVE	D7,D1
	CMP	10(A6),D1
	BNE.S	L610
	MOVE	#4,D1
	BRA.S	L611
L610:
	MOVE	#5,D1
L611:
	LSR	D1,D0
	ADD	D0,D6
L609:
L608:
L606:
	ADDQ	#1,D7
L604:
	CMPI	#1,D7
	BLE	L605(PC)
L607:
	JSR	F027_AA59_(PC)
	MOVE.B	83(A3),D1
	AND	#255,D1
	ASR	#3,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D7
	MOVE	D5,D0
	BEQ.S	L612
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L612:
	MOVE	64(A3),D0
	ADD	274(A3),D0
	ADD	G407_s_Par+3204(A4),D0
	ADD	D6,D0
	ADD	D0,D7
	CMPI	#1,10(A6)
	BLS.S	L613
	MOVE	10(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#6,D0
	BNE.S	L613
	MOVE	D5,-(A7)
	MOVE	D4,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+24(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	ASL.L	#2,D0
	LEA	G239_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F143_mzzz_(PC)
	ADDQ.L	#6,A7
	ADD	D0,D7
L613:
	MOVE	50(A3),D0
	MOVE	#1,D1
	MOVE	10(A6),D3
	ASL	D3,D1
	AND	D1,D0
	BEQ.S	L614
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE	#8,D0
	ADD	D1,D0
	SUB	D0,D7
L614:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L615
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L615:
	MOVE	#100,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L602:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$601:	.EQU	#0
F314_gzzz_:/* global */
	LINK	A6,L$616
	MOVE	#1,G321_B_Sto(A4)
	CLR	G300_B_Par(A4)
	MOVE	#10,G318_i_Wai(A4)
	JSR	F098_rzzz_(PC)
	MOVE	G509_B_Act(A4),D0
	BNE.S	L618
	MOVE	G506_i_Act(A4),D0
	BNE.S	L618
	MOVE	#1,G509_B_Act(A4)
L618:
	LEA	G447_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	LEA	G448_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	LEA	G458_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	LEA	G459_as_Gr(A4),A0
	MOVE.L	A0,G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	JSR	F457_AA08_(PC)
L617:
	UNLK	A6
	RTS
L$616:	.EQU	#-2
F315_arzz_:/* global */
	LINK	A6,L$619
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	BEQ.S	L621
	MOVE	8(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-2(A6)
	OR	D3,-2(A6)
	MOVE	10(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-2(A6)
	OR	D3,-2(A6)
	MOVE	G272_i_Cur(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-2(A6)
	OR	D3,-2(A6)
	MOVE	-2(A6),D7
	MOVE	D6,D0
	SUBQ	#1,D6
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
L622:
	MOVE	-(A3),D0
	CMP	D7,D0
	BNE.S	L625
	MOVE	D6,D0
	ADDQ	#1,D0
	BRA.S	L620
L625:
L623:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L622
L624:
L621:
	MOVE	#0,D0
L620:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$619:	.EQU	#-2
F316_aizz_:/* global */
	LINK	A6,L$626
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	AND	#255,D6
	SUBQ.B	#1,G407_s_Par+3210(A4)
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	SUB	D7,D6
	BEQ.S	L628
	MOVE	D6,D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3216(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D6,-(A7)
	MOVE	D7,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	LEA	G407_s_Par+3263(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L628:
	MOVE	D7,D0
	MOVE.B	G407_s_Par+3212(A4),D1
	AND	#255,D1
	CMP	D1,D0
	BCC.S	L629
	SUBQ.B	#1,G407_s_Par+3212(A4)
L629:
	MOVE	D7,D0
	MOVE.B	G407_s_Par+3213(A4),D1
	AND	#255,D1
	CMP	D1,D0
	BCC.S	L630
	SUBQ.B	#1,G407_s_Par+3213(A4)
L630:
L627:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$626:	.EQU	#0
F317_adzz_:/* global */
	LINK	A6,L$631
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	12(A6),D7
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	BEQ	L633(PC)
	MOVE	D7,D5
	AND	#-32768,D5
	BEQ.S	L634
	AND	#32767,D7
L634:
	MOVE	8(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-2(A6)
	OR	D3,-2(A6)
	MOVE	10(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-2(A6)
	OR	D3,-2(A6)
	MOVE	G272_i_Cur(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-2(A6)
	OR	D3,-2(A6)
	LEA	G407_s_Par+3214(A4),A0
	MOVE.L	A0,A3
	CLR	D4
	BRA.S	L635
L636:
	MOVE.L	A3,A0
	ADDQ.L	#2,A3
	LEA	(A0),A1
	LEA	-2(A6),A0
	MOVEQ	#0,D0
	JSR	_blockcmp(PC)
	MOVE	D4,D0
	BNE.S	L638
	MOVE	#1,D4
	MOVE	D5,D0
	BEQ.S	L639
	MOVE	D7,-(A7)
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L640
L639:
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D7,D0
	MOVE	D0,-(A7)
	MOVE	#80,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
L640:
L638:
	MOVE	D7,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	D0,(A0)
L635:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L636
L637:
L633:
L632:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$631:	.EQU	#-2
F318_xxxx_:/* global */
	LINK	A6,L$641
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D6
	MULS	#800,D6
	LEA	G407_s_Par+29(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	CLR	D4
	BRA.S	L643
L644:
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G057_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	CMPI	#-1,D0
	BEQ.S	L647
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,D0
	AND	#16383,D0
	MOVE	D6,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L647:
L645:
	ADDQ	#1,D4
L643:
	CMPI	#30,D4
	BCS.S	L644
L646:
L642:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$641:	.EQU	#0
F319_xxxx_:/* global */
	LINK	A6,L$648
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	52(A3)
	ORI	#4096,48(A3)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L650
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L651
	CLR	G331_B_Pre(A4)
	CLR	G597_B_Ign(A4)
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L652
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L652:
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
	BRA.S	L653
L651:
	MOVE	G333_B_Pre(A4),D0
	BEQ.S	L654
	CLR	G333_B_Pre(A4)
	CLR	G597_B_Ign(A4)
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
L654:
L653:
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L650:
	MOVE	D7,-(A7)
	JSR	F318_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32758,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#-1,D4
	BNE.S	L655
	BRA.S	L656
L655:
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#5,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A2)
	OR	D3,2(A2)
	MOVE	#1,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ANDI	#-129,2(A2)
	OR	D3,2(A2)
	MOVE	D7,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A2)
	OR	D3,2(A2)
	MOVE.B	29(A3),D6
	AND	#255,D6
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	D6,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L656:
	CLR.B	33(A3)
	CLR.B	34(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR.B	41(A3)
	MOVE	D6,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	ADDQ	#1,D0
	CMP	G599_ui_Us(A4),D0
	BNE.S	L657
	MOVE	#1,G598_B_Mou(A4)
	CLR	G599_ui_Us(A4)
	MOVE	#1,G592_B_Bui(A4)
L657:
	MOVE.B	42(A3),D0
	BEQ.S	L658
	MOVE	D7,-(A7)
	JSR	F323_xxxx_(PC)
	ADDQ.L	#2,A7
L658:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#0,D0
	MOVE	D0,D5
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L659
L660:
	MOVE	52(A3),D0
	BEQ.S	L663
	BRA.S	L662
L663:
L661:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE.L	A3,D0
	ADDA	#800,A3
L659:
	MOVE	D5,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L660
L662:
	MOVE	D5,D0
	CMP	G305_ui_Pa(A4),D0
	BNE.S	L664
	MOVE	#1,G303_B_Par(A4)
	BRA.S	L649
L664:
	MOVE	D7,D0
	MOVE	G411_i_Lea(A4),D1
	CMP	D1,D0
	BNE.S	L665
	MOVE	D5,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L665:
	MOVE	D7,D0
	MOVE	G514_i_Mag(A4),D1
	CMP	D1,D0
	BNE.S	L666
	MOVE	D5,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L649
L666:
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
L649:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$648:	.EQU	#0
F320_akzz_:/* global */
	LINK	A6,L$667
	MOVEM.L	A3-A2/D7-D4,-(A7)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA	L669(PC)
L670:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	OR	D0,50(A3)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	BNE.S	L673
	BRA	L671(PC)
L673:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE	52(A3),D0
	MOVE	D0,D5
	BNE.S	L674
	BRA	L671(PC)
L674:
	MOVE	D5,D0
	SUB	D6,D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGT.S	L675
	MOVE	D7,-(A7)
	JSR	F319_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L676(PC)
L675:
	MOVE	D5,52(A3)
	ORI	#256,48(A3)
	MOVE	D4,D0
	BEQ.S	L677
	ORI	#8192,48(A3)
L677:
	MOVE	D7,D5
	MULU	#69,D5
	CLR	-16(A6)
	JSR	F077_aA39_(PC)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L678
	MOVE	#28,-14(A6)
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,-20(A6)
	ADD	#31,D0
	MOVE	D0,-18(A6)
	MOVE	#10,-(A7)
	MOVE	#16,-(A7)
	PEA	-20(A6)
	MOVE	#16,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	CMPI	#10,D6
	BCC.S	L679
	ADD	#21,D5
	BRA.S	L680
L679:
	CMPI	#100,D6
	BCC.S	L681
	ADD	#18,D5
	BRA.S	L682
L681:
	ADD	#15,D5
L682:
L680:
	MOVE	#16,-2(A6)
	BRA.S	L683
L678:
	MOVE	#6,-14(A6)
	MOVE	D5,D0
	MOVE	D0,-20(A6)
	ADD	#47,D0
	MOVE	D0,-18(A6)
	MOVE	#10,-(A7)
	MOVE	#24,-(A7)
	PEA	-20(A6)
	MOVE	#15,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	CMPI	#10,D6
	BCC.S	L684
	ADD	#19,D5
	BRA.S	L685
L684:
	CMPI	#100,D6
	BCC.S	L686
	ADD	#16,D5
	BRA.S	L687
L686:
	ADD	#13,D5
L687:
L685:
	MOVE	#5,-2(A6)
L683:
	MOVE	#3,-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#8,-(A7)
	MOVE	#15,-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D5,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	46(A3),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L688
	MOVE.B	#12,-8(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#5,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-12(A6)
	MOVE	D7,D0
	MOVE.B	D0,-7(A6)
	PEA	-12(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,46(A3)
	BRA.S	L689
L688:
	MOVE	D5,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#5,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	MOVE	D5,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L689:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L676:
L671:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L669:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L670(PC)
L672:
L668:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$667:	.EQU	#-20
F321_AA29_:/* global */
	LINK	A6,L$690
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	10(A6),D7
	CMPI	#-1,8(A6)
	BEQ.S	L693
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ.S	L694
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L692
L694:
L693:
	BRA	L691(PC)
L692:
	CMPI	#0,D7
	BGT.S	L695
	MOVE	#0,D0
	BRA	L691(PC)
L695:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BNE.S	L696
	MOVE	#0,D0
	BRA	L691(PC)
L696:
	CMPI	#0,14(A6)
	BEQ	L697(PC)
	MOVE	#0,D0
	MOVE	D0,D4
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE	#0,D0
	MOVE	D0,D5
	BRA.S	L698
L699:
	MOVE	12(A6),D0
	MOVE	#1,D1
	ASL	D6,D1
	AND	D1,D0
	BEQ.S	L702
	ADDQ	#1,D4
	MOVE	D6,D0
	CMPI	#4,14(A6)
	BNE.S	L703
	MOVE	#-32768,D1
	BRA.S	L704
L703:
	MOVE	#0,D1
L704:
	OR	D1,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F313_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D5
L702:
L700:
	ADDQ	#1,D6
L698:
	CMPI	#5,D6
	BLE.S	L699
L701:
	MOVE	D4,D0
	BEQ.S	L705
	MOVE	D5,D0
	AND.L	#65535,D0
	DIVU	D4,D0
	MOVE	D0,D5
L705:
	MOVE	14(A6),D0
L706:
	CMP	#6,D0
	BEQ.S	L707
	BRA.S	L709
L707:
	MOVE	#115,D0
	MOVE.B	80(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BGT.S	L711
	CLR	D7
	BRA.S	L712
L711:
	MOVE	D6,-(A7)
	MOVE	#6,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L712:
	BRA.S	L44T321_024
	BRA.S	L710
L709:
	CMP	#5,D0
	BEQ.S	L710
	BRA.S	L713
L710:
	MOVE	D7,-(A7)
	MOVE	#5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	SUB	G407_s_Par+3208(A4),D7
	BRA.S	L44T321_024
	BRA.S	L714
L713:
	CMP	#1,D0
	BEQ.S	L714
	BRA.S	L715
L714:
	MOVE	D7,-(A7)
	MOVE	#6,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	SUB	G407_s_Par+3206(A4),D7
	BRA.S	L708
	BRA.S	L716
L715:
	CMP	#2,D0
	BEQ.S	L716
	BRA.S	L717
L716:
	MOVE	D5,D0
	LSR	#1,D0
	MOVE	D0,D5
	BRA.S	L718
L717:
	CMP	#3,D0
	BEQ.S	L718
L719:
	CMP	#4,D0
	BEQ.S	L718
L720:
	CMP	#7,D0
L721:
L718:
L708:
	MOVE	#130,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#6,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L44T321_024:
	CMPI	#0,D7
	BGT.S	L722
	MOVE	#0,D0
	BRA	L691(PC)
L722:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	ADD	#10,D0
	MOVE	D0,-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D6
	MOVE	D0,-10(A6)
	MOVE	D7,D0
	CMP	-10(A6),D0
	BLE.S	L723
L724:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	D1,-20(A6)
	MOVE	#1,D1
	MOVE	-20(A6),D3
	ASL	D3,D1
	AND	12(A6),D1
	MOVE	8(A6),D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	OR	D1,D0
	MOVE	D0,(A0)
L725:
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
	MOVE	D0,-30(A6)
	MOVE	D7,D0
	CMP	-30(A6),D0
	BLE.S	L727
	MOVE	D6,D0
	BNE.S	L724
L727:
L726:
L723:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L728
	JSR	F314_gzzz_(PC)
L728:
L697:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D7,D0
	MOVE	D0,(A0)
	MOVE	D7,D0
L691:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$690:	.EQU	#-30
F322_lzzz_:/* global */
	LINK	A6,L$729
	CMPI	#-1,8(A6)
	BEQ.S	L732
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BNE.S	L731
L732:
	BRA	L730(PC)
L731:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-14(A6)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	10(A6),D0
	LSR	#6,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE.L	-14(A6),A0
	ORI	#256,48(A0)
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G423_i_Inv(A4),D0
	BNE.S	L733
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L733
	MOVE.L	-14(A6),A0
	ORI	#2048,48(A0)
L733:
	SUBQ	#1,10(A6)
	BEQ.S	L734
	MOVE.L	-14(A6),A0
	ADDQ.B	#1,42(A0)
	MOVE.B	#75,-6(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-5(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#36,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE	10(A6),-4(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L734:
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L730:
	UNLK	A6
	RTS
L$729:	.EQU	#-14
F323_xxxx_:/* global */
	LINK	A6,L$735
	MOVEM.L	A3/D7,-(A7)
	CMPI	#-1,8(A6)
	BNE.S	L737
	BRA.S	L736
L737:
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L738
L739:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#75,D0
	BNE.S	L742
	MOVE.B	5(A3),D0
	AND	#255,D0
	CMP	8(A6),D0
	BNE.S	L742
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L742:
L740:
	MOVE.L	A3,D0
	ADDA	#10,A3
	MOVE	D7,D0
	ADDQ	#1,D7
L738:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L739
L741:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	CLR.B	(A0)
L736:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$735:	.EQU	#0
F324_aezz_:/* global */
	LINK	A6,L$743
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	BNE.S	L745
	BRA.S	L744
L745:
	MOVE	D7,D0
	LSR	#3,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	SUB	D0,D7
	MOVE	D5,D0
	ASL	#1,D0
	MOVE	D0,D5
	MOVE	#0,D0
	MOVE	D0,D4
	MOVE	#0,D0
	MOVE	D0,D6
	BRA.S	L746
L747:
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND.L	#65535,D1
	DIVU	D5,D1
	SWAP	D1
	MOVE	D7,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L750
	ADDQ	#1,D4
L750:
L748:
	ADDQ	#1,D6
L746:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L747
L749:
	MOVE	D4,D0
L744:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$743:	.EQU	#0
F325_bzzz_:/* global */
	LINK	A6,L$751
	MOVEM.L	A3/D7,-(A7)
	CMPI	#-1,8(A6)
	BNE.S	L753
	BRA.S	L752
L753:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	56(A3),D0
	SUB	10(A6),D0
	MOVE	D0,56(A3)
	MOVE	D0,D7
	CMPI	#0,D0
	BGT.S	L754
	CLR	56(A3)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	NEG	D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	BRA.S	L755
L754:
	MOVE	D7,D0
	CMP	58(A3),D0
	BLE.S	L756
	MOVE	58(A3),56(A3)
L756:
L755:
	ORI	#768,48(A3)
L752:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$751:	.EQU	#0
F326_ozzz_:/* global */
	LINK	A6,L$757
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	28(A3),D7
	AND	#255,D7
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE.B	29(A3),D0
	AND	#255,D0
	SUB	D7,D0
	ADDQ	#1,D0
	AND	#2,D0
	LSR	#1,D0
	ADD	D7,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L758:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$757:	.EQU	#0
F327_kzzz_:/* global */
	LINK	A6,L$759
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	12(A6),D7
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	60(A3),D0
	CMP	14(A6),D0
	BCC.S	L761
	MOVE	#0,D0
	BRA.S	L760
L761:
	MOVE	14(A6),D0
	SUB	D0,60(A3)
	ORI	#256,48(A3)
	MOVE	62(A3),D0
	ASR	#3,D0
	MOVE	D0,-(A7)
	MOVE	#8,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	#10,D0
	SUB	D1,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MOVE	D6,D1
	ASL	#2,D1
	CMP	D1,D0
	BGE.S	L762
	ADDQ	#3,D7
	SUBQ	#1,D6
L762:
	MOVE	D6,-(A7)
	MOVE	#90,-(A7)
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F326_ozzz_(PC)
	ADDA	#12,A7
L760:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$759:	.EQU	#0
F328_nzzz_:/* global */
	LINK	A6,L$763
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-4(A6)
	CMPI	#0,10(A6)
	BGE.S	L765
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L766
	MOVE	#0,D0
	BRA	L764(PC)
L766:
	JSR	F298_aqzz_(PC)
	MOVE	D0,D4
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	214(A3),-2(A6)
	MOVE	D4,214(A3)
	MOVE	#1,10(A6)
	MOVE	#1,-4(A6)
L765:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	-4(A6),D0
	BEQ.S	L767
	MOVE	10(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	-2(A6),(A0)
	BRA.S	L768
L767:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-1,D0
	BNE.S	L769
	MOVE	#0,D0
	BRA	L764(PC)
L769:
L768:
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,-(A7)
	JSR	F305_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F330_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#8,D6
	MOVE	#1,D5
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L770
	ADDQ	#4,D6
	MOVE	D4,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+20(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#12,D0
	BGT.S	L771
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,D5
	ASR	#2,D0
	ADD	D0,D6
L771:
L770:
	MOVE	D6,-(A7)
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	ADD	D5,D7
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE	D7,D1
	ASR	#1,D1
	ADD	D1,D0
	ADD	D5,D0
	ADD	D0,D7
	MOVE	#200,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#31,D1
	MOVE	D5,D0
	ASL	#3,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#40,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	MOVE	#11,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),D0
	ADD	12(A6),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	D4,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	#4,G311_i_Pro(A4)
	MOVE	G308_i_Par(A4),G312_i_Las(A4)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D0
L764:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$763:	.EQU	#-4
F329_hzzz_:/* global */
	LINK	A6,L$772
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L774
	MOVE	#0,D0
	BRA.S	L773
L774:
	MOVE	8(A6),-(A7)
	MOVE	#-1,-(A7)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F328_nzzz_(PC)
	ADDQ.L	#6,A7
L773:
	UNLK	A6
	RTS
L$772:	.EQU	#0
F330_szzz_:/* global */
	LINK	A6,L$775
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	G313_ul_Ga(A4),D7
	MOVE	10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D7
	MOVE.B	#11,-6(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-5(A6)
	CLR.B	-4(A6)
	MOVE	44(A3),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BLT.S	L777
	MOVE	D5,D6
	MULS	#10,D6
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D6,A0
	MOVE.L	(A0),D6
	AND.L	#16777215,D6
	MOVE.L	D7,D0
	CMP.L	D6,D0
	BLT.S	L778
	MOVE.L	D6,D0
	SUB.L	G313_ul_Ga(A4),D0
	ASR.L	#1,D0
	ADD.L	D0,D7
	BRA.S	L779
L778:
	MOVE.L	D6,D7
	MOVE	10(A6),D1
	LSR	#1,D1
	AND.L	#65535,D1
	ADD.L	D1,D7
L779:
	MOVE	D5,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L780
L777:
	ORI	#-32760,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L780:
	MOVE.L	D7,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,44(A3)
L776:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$775:	.EQU	#-10
F331_auzz_:/* global */
	LINK	A6,L$781
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BNE.S	L783
	BRA	L782(PC)
L783:
	MOVE	G306_i_Par(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-6(A6)
	OR	D3,-6(A6)
	MOVE	G307_i_Par(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-6(A6)
	OR	D3,-6(A6)
	MOVE	G309_i_Par(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-6(A6)
	OR	D3,-6(A6)
	CLR	D6
	BRA.S	L784
L785:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-6(A6),A0
	MOVEQ	#0,D0
	JSR	_blockcmp(PC)
	MOVE	D6,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	BNE.S	L787
	MOVE	D6,D0
	BNE.S	L787
	CLR	-(A7)
	JSR	F316_aizz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L784
L787:
	ADDQ	#1,D6
L784:
	MOVE	D6,D0
	MOVE.B	G407_s_Par+3210(A4),D1
	AND	#255,D1
	SUBQ	#1,D1
	CMP	D1,D0
	BLT.S	L785
L786:
	MOVE.L	G313_ul_Ga(A4),D7
	MOVE	D7,D0
	AND	#128,D0
	MOVE	D7,D1
	AND	#256,D1
	LSR	#2,D1
	ADD	D1,D0
	MOVE	D7,D1
	AND	#64,D1
	ASL	#2,D1
	ADD	D1,D0
	LSR	#2,D0
	MOVE	D0,-2(A6)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA	L788(PC)
L789:
	MOVE	52(A3),D0
	BEQ	L792(PC)
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ	L792(PC)
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BGE.S	L793
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	D0,D5
	MOVE	D0,-16(A6)
	MOVE.B	80(A3),D0
	AND	#255,D0
	ADD	-16(A6),D0
	MOVE	D0,-16(A6)
	MOVE	-2(A6),D0
	CMP	-16(A6),D0
	BCC.S	L793
	MOVE	#16,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#7,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	62(A3),D0
	ASR	#6,D0
	ADDQ	#1,D0
	ADD	D0,60(A3)
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BLE.S	L794
	MOVE	62(A3),60(A3)
L794:
	BRA.S	L795
L793:
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BLE.S	L796
	SUBQ	#1,60(A3)
L796:
L795:
	MOVE	#19,D4
	BRA.S	L797
L798:
	MOVE	D4,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	CMPI	#0,(A0)
	BLE.S	L801
	MOVE	D4,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	SUBQ	#1,(A0)
L801:
L799:
	SUBQ	#1,D4
L797:
	CMPI	#0,D4
	BGE.S	L798
L800:
	MOVE	#4,D6
	MOVE	58(A3),D4
	BRA.S	L802
L803:
	ADDQ	#2,D6
L802:
	MOVE	D4,D0
	ASR	#1,D0
	MOVE	D0,D4
	MOVE	D0,-26(A6)
	MOVE	56(A3),D0
	CMP	-26(A6),D0
	BLT.S	L803
L804:
	CLR	D4
	MOVE	#6,-(A7)
	MOVE	58(A3),D0
	ASR	#8,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-4(A6)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L805
	MOVE	-4(A6),D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,-4(A6)
L805:
	MOVE.L	G313_ul_Ga(A4),D0
	SUB.L	G362_l_Las(A4),D0
	MOVE	D0,D5
	CMPI	#100,D0
	BLS.S	L806
	ADDQ	#1,-4(A6)
	CMPI	#500,D5
	BLS.S	L807
	ADDQ	#1,-4(A6)
L807:
L806:
L808:
	CMPI	#4,D6
	SLS	D5
	AND	#1,D5
	CMPI	#-512,66(A3)
	BGE.S	L811
	MOVE	D5,D0
	BEQ.S	L812
	ADD	-4(A6),D4
	SUBQ	#2,66(A3)
L812:
	BRA.S	L813
L811:
	CMPI	#0,66(A3)
	BLT.S	L814
	SUB	-4(A6),D4
L814:
	MOVE	D5,D0
	BEQ.S	L815
	MOVE	#2,D0
	BRA.S	L816
L815:
	MOVE	D6,D0
	LSR	#1,D0
L816:
	SUB	D0,66(A3)
L813:
	CMPI	#-512,68(A3)
	BGE.S	L817
	MOVE	D5,D0
	BEQ.S	L818
	ADD	-4(A6),D4
	SUBQ	#1,68(A3)
L818:
	BRA.S	L819
L817:
	CMPI	#0,68(A3)
	BLT.S	L820
	SUB	-4(A6),D4
L820:
	MOVE	D5,D0
	BEQ.S	L821
	MOVE	#1,D0
	BRA.S	L822
L821:
	MOVE	D6,D0
	LSR	#2,D0
L822:
	SUB	D0,68(A3)
L819:
	SUBQ	#1,D6
L809:
	MOVE	D6,D0
	BEQ.S	L823
	MOVE	56(A3),D0
	SUB	D4,D0
	CMP	58(A3),D0
	BLT	L808(PC)
L823:
L810:
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-1024,66(A3)
	BGE.S	L824
	MOVE	#-1024,66(A3)
L824:
	CMPI	#-1024,68(A3)
	BGE.S	L825
	MOVE	#-1024,68(A3)
L825:
	MOVE	52(A3),D0
	CMP	54(A3),D0
	BGE.S	L826
	MOVE	56(A3),D0
	MOVE	58(A3),D1
	ASR	#2,D1
	CMP	D1,D0
	BLT.S	L826
	MOVE	-2(A6),D0
	MOVE.B	83(A3),D1
	AND	#255,D1
	ADD	#12,D1
	CMP	D1,D0
	BCC.S	L826
	MOVE	54(A3),D0
	ASR	#7,D0
	ADDQ	#1,D0
	MOVE	D0,-4(A6)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L827
	MOVE	-4(A6),D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,-4(A6)
L827:
	MOVE	232(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#121,D0
	BNE.S	L828
	ADDQ	#1,-4(A6)
L828:
	MOVE	52(A3),D0
	ADD	-4(A6),D0
	MOVE	D0,52(A3)
	CMP	54(A3),D0
	BLE.S	L829
	MOVE	54(A3),52(A3)
L829:
L826:
	MOVE.L	G313_ul_Ga(A4),D0
	AND	#255,D0
	BNE.S	L830
	CLR	D6
	BRA.S	L831
L832:
	MOVE	D6,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	1(A2),D0
	MOVE.B	(A2),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGE.S	L834
	ADDQ.B	#1,1(A2)
	BRA.S	L835
L834:
	MOVE.B	1(A2),D0
	MOVE.B	(A2),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BLE.S	L836
	SUBQ.B	#1,1(A2)
L836:
L835:
	ADDQ	#1,D6
L831:
	CMPI	#6,D6
	BLS.S	L832
L833:
L830:
	MOVE	G300_B_Par(A4),D0
	BNE.S	L837
	MOVE.B	28(A3),D0
	AND	#255,D0
	CMP	G308_i_Par(A4),D0
	BEQ.S	L837
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#60,D1
	CMP.L	D1,D0
	BGE.S	L837
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR.B	41(A3)
	ORI	#1024,48(A3)
L837:
	ORI	#256,48(A3)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L838
	MOVE	G333_B_Pre(A4),D0
	BNE.S	L840
	MOVE	G331_B_Pre(A4),D0
	BNE.S	L840
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L839
L840:
	ORI	#2048,48(A3)
L839:
L838:
L792:
L790:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L788:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L789(PC)
L791:
	JSR	F293_ahzz_(PC)
L782:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$781:	.EQU	#-26
