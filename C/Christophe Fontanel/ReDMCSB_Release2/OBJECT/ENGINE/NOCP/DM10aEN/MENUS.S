BSS SEG "bss"
G485_aauc_:/* global */
	.WORD	#24
G486_auc_G:/* global */
	.WORD	#6
G487_as_Gr:/* global */
	.WORD	#200
G488_i_Gra:/* global */
	.WORD	#2
G489_as_Gr:/* global */
	.WORD	#352
G490_ac_Gr:/* global */
	.WORD	#300
G491_auc_G:/* global */
	.WORD	#44
G492_auc_G:/* global */
	.WORD	#44
G493_auc_G:/* global */
	.WORD	#44
G494_auc_G:/* global */
	.WORD	#44
G495_ac_Gr:/* global */
	.WORD	#44
G496_auc_G:/* global */
	.WORD	#44
G497_auc_G:/* global */
	.WORD	#44
G498_auc_G:/* global */
	.WORD	#16
G499_s_Gra:/* global */
	.WORD	#8
G500_s_Gra:/* global */
	.WORD	#8
G501_s_Gra:/* global */
	.WORD	#8
G502_s_Gra:/* global */
	.WORD	#8
G503_s_Gra:/* global */
	.WORD	#8
G504_s_Gra:/* global */
	.WORD	#8
G505_i_Gra:/* global */
	.WORD	#2
G506_i_Act:/* global */
	.WORD	#2
G507_ui_Ac:/* global */
	.WORD	#2
G508_B_Ref:/* global */
	.WORD	#2
G509_B_Act:/* global */
	.WORD	#2
G510_ac_Ac:/* global */
	.WORD	#4
G511_auc_A:/* global */
	.WORD	#4
G512_uc_Us:/* global */
	.WORD	#2
G513_i_Act:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G514_i_Mag(A4)
BSS SEG "bss"
G514_i_Mag:/* global */
	.WORD	#2
G515_aui_B:/* global */
	.WORD	#576
G516_aaui_:/* global */
	.WORD	#1728
G517_T_Act:/* global */
	.WORD	#2
CODE SEG "user"
F381_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	LEA	-132(A6),A0
	MOVE.L	A0,A2
	MOVE.B	#10,(A2)+
L2:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#64,D0
	BNE.S	L5
	ADDQ.L	#1,A3
	MOVE.L	A2,D0
	SUBQ.L	#1,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#10,D0
	BEQ.S	L6
	MOVE.B	#32,(A2)+
L6:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#112,D0
	BEQ.S	L7
	BRA.S	L8
L7:
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
L8:
	CLR.B	(A2)
	MOVE.L	-4(A6),-(A7)
	PEA	-132(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE.L	-4(A6),-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	EXT.L	D0
	ADDA.L	D0,A2
	MOVE.B	#32,(A2)+
	BRA.S	L9
L5:
	MOVE.B	(A3),(A2)+
L9:
L3:
	MOVE.B	(A3)+,D0
	BNE.S	L2
L4:
	CLR.B	(A2)
	MOVE.B	-131(A6),D0
	BEQ.S	L10
	PEA	-132(A6)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L10:
L1:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-132
F382_xxxx_:/* global */
	LINK	A6,L$11
	MOVEM.L	A3/D7,-(A7)
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-588(A4),A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L13:
	CMP	#5,D0
	BEQ.S	L14
	BRA.S	L16
L14:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	BRA.S	L12
	BRA.S	L17
L16:
	CMP	#6,D0
	BEQ.S	L17
	BRA.S	L18
L17:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#7680,D0
	LSR	#1,D0
	LSR	#8,D0
	BRA.S	L12
	BRA.S	L19
L18:
	CMP	#10,D0
	BEQ.S	L19
	BRA.S	L20
L19:
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	BRA.S	L12
L21:
	MOVE	#1,D0
	BRA.S	L12
	BRA.S	L22
L20:
	BRA.S	L21
L22:
L15:
L12:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$11:	.EQU	#0
F383_xxxx_:/* global */
	LINK	A6,L$23
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	(A3),G511_auc_A(A4)
	MOVE.B	#1,G510_ac_Ac(A4)
	MOVE	#1,D6
	MOVE	#1,D7
	BRA.S	L25
L26:
	MOVE	D7,D0
	LEA	(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	CMPI	#255,D0
	BNE.S	L29
	BRA.S	L27
L29:
	MOVE	D7,D0
	LEA	3(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	AND	#128,D0
	BEQ.S	L30
	JSR	F382_xxxx_(PC)
	TST	D0
	BNE.S	L30
	BRA.S	L27
L30:
	AND	#-129,D4
	MOVE	D5,D0
	LEA	G496_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	G506_i_Act(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	CMP	D4,D0
	BCS.S	L31
	MOVE	D5,D0
	MOVE	D6,D1
	LEA	G511_auc_A(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D4,D0
	MOVE	D6,D1
	LEA	G510_ac_Ac(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	ADDQ	#1,D6
L31:
L27:
	ADDQ	#1,D7
L25:
	CMPI	#3,D7
	BCS.S	L26
L28:
	MOVE	D6,G507_ui_Ac(A4)
	MOVE	D6,D7
	BRA.S	L32
L33:
	MOVE	D7,D0
	LEA	G511_auc_A(A4),A0
	ADDA	D0,A0
	MOVE.B	#-1,(A0)
L34:
	ADDQ	#1,D7
L32:
	CMPI	#3,D7
	BCS.S	L33
L35:
L24:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$23:	.EQU	#0
F384_xxxx_:/* global */
	LINK	A6,L$36
	MOVEM.L	A3/D7,-(A7)
	MOVE.B	9(A6),D7
	MOVE.B	D7,D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L38
DATA SEG "s!"
s!:
	DATA 00 00 
CODE SEG "user"
	LEA	s!(A4),A0
	MOVE.L	A0,D0
	BRA.S	L37
L38:
	LEA	G490_ac_Gr(A4),A0
	MOVE.L	A0,A3
	BRA.S	L39
L40:
L43:
L42:
	MOVE.B	(A3)+,D0
	BNE.S	L43
L44:
L39:
	MOVE.B	D7,D0
	AND	#255,D0
	SUBQ.B	#1,D7
	TST.B	D0
	BNE.S	L40
L41:
	MOVE.L	A3,D0
L37:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$36:	.EQU	#0
F385_xxxx_:/* global */
	LINK	A6,L$45
	MOVEM.L	A3-A2/D7-D5,-(A7)
	JSR	F077_aA39_(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G001_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	CMPI	#0,8(A6)
	BGE.S	L47
	CMPI	#-1,8(A6)
	BNE.S	L48
	MOVE	#242,D5
DATA SEG "s!"
	DATA 43 41 4E 27 54 20 52 45 41 43 48 00 
CODE SEG "user"
	LEA	s!+2(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	BRA.S	L49
L48:
	MOVE	#248,D5
DATA SEG "s!"
	DATA 4E 45 45 44 20 41 4D 4D 4F 00 
CODE SEG "user"
	LEA	s!+14(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
L49:
	MOVE.L	A2,-(A7)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#100,-(A7)
	MOVE	D5,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	BRA	L50(PC)
L47:
	CMPI	#40,8(A6)
	BLE.S	L51
	LEA	G499_s_Gra(A4),A0
	MOVE.L	A0,-10(A6)
	MOVE	#14,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#48,D6
	BRA	L52(PC)
L51:
	CMPI	#15,8(A6)
	BLE.S	L53
	MOVE	#2,D7
	MOVE	#64,D5
	MOVE	#32,D6
	LEA	G502_s_Gra(A4),A0
	MOVE.L	A0,-10(A6)
	BRA.S	L54
L53:
	MOVE	#3,D7
	MOVE	#42,D5
	MOVE	#24,D6
	LEA	G503_s_Gra(A4),A0
	MOVE.L	A0,-10(A6)
L54:
	MOVE	D7,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE.S	L55
	MOVE	#14,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	PEA	G017_auc_G(A4)
	MOVE	#37,-(A7)
	MOVE	D5,-(A7)
	MOVE	#45,-(A7)
	MOVE	#96,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L56
L55:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
L56:
L52:
	MOVE	#-1,-(A7)
	MOVE	D6,-(A7)
	MOVE.L	-10(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#5,D7
	MOVE	#274,D5
	CLR.B	-1(A6)
L57:
	MOVE	#48,D0
	MOVE	8(A6),D1
	EXT.L	D1
	DIVS	#10,D1
	SWAP	D1
	ADD	D1,D0
	SUBQ	#1,D7
	MOVE	D7,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	SUBQ	#3,D5
L58:
	MOVE	8(A6),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,8(A6)
	BNE.S	L57
L59:
	MOVE	D7,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#100,-(A7)
	MOVE	D5,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L50:
	JSR	F078_xzzz_(PC)
L46:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$45:	.EQU	#-10
F386_ezzz_:/* global */
	LINK	A6,L$60
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE	G509_B_Act(A4),D0
	BNE.S	L62
	BRA	L61(PC)
L62:
	MOVE	8(A6),D0
	MULU	#22,D0
	ADD	#233,D0
	MOVE	D0,-8(A6)
	ADD	#19,D0
	MOVE	D0,-6(A6)
	MOVE	#86,-4(A6)
	MOVE	#120,-2(A6)
	CLR	G578_B_Use(A4)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	52(A2),D0
	BNE.S	L63
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	BRA	L61(PC)
L63:
	CLR	-(A7)
	MOVE.L	#128,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A3
	MOVE	214(A2),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L64
	MOVE	#201,D7
	BRA.S	L65
L64:
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+3(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	BEQ.S	L66
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	BRA.S	L67
L66:
	MOVE	#16,-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	BRA.S	L5T386_006
L67:
L65:
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G498_auc_G(A4)
	MOVE	#16,-(A7)
	MOVE	#16,-(A7)
	MOVE	#16,-(A7)
	MOVE	#16,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
L5T386_006:
	MOVE	#160,-(A7)
	MOVE	#4,-(A7)
	PEA	-8(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	-8(A6),D0
	ADDQ	#2,D0
	MOVE	D0,-16(A6)
	MOVE	-6(A6),D0
	SUBQ	#2,D0
	MOVE	D0,-14(A6)
	MOVE	#95,-12(A6)
	MOVE	#110,-10(A6)
	MOVE	#-1,-(A7)
	MOVE	#8,-(A7)
	PEA	-16(A6)
	MOVE.L	A3,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	48(A2),D0
	AND	#8,D0
	BNE.S	L69
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L69
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L68
L69:
	CLR	-(A7)
	PEA	-8(A6)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
L68:
	MOVE.L	#128,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L61:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$60:	.EQU	#-16
F387_hzzz_:/* global */
	LINK	A6,L$70
	MOVEM.L	A3/D7,-(A7)
	JSR	F077_aA39_(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G001_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	G509_B_Act(A4),D0
	BEQ.S	L72
	CLR	D7
	BRA.S	L73
L74:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L73:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L74
L75:
	BRA	L76(PC)
L72:
	MOVE	G506_i_Act(A4),D0
	BEQ	L77(PC)
	LEA	G499_s_Gra(A4),A0
	MOVE.L	A0,A3
	MOVE.B	G511_auc_A+2(A4),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L78
	LEA	G500_s_Gra(A4),A0
	MOVE.L	A0,A3
L78:
	MOVE.B	G511_auc_A+1(A4),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L79
	LEA	G501_s_Gra(A4),A0
	MOVE.L	A0,A3
L79:
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	#10,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#7,-(A7)
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#83,-(A7)
	MOVE	#235,-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F041_aadZ_(PC)
	ADDA	#20,A7
	CLR	D7
	BRA.S	L80
L81:
	MOVE	#12,-(A7)
	MOVE	D7,D0
	LEA	G511_auc_A(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F384_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#93,D0
	MOVE	D7,D1
	MULU	#12,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#241,-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F041_aadZ_(PC)
	ADDA	#20,A7
L82:
	ADDQ	#1,D7
L80:
	CMPI	#3,D7
	BCS.S	L81
L83:
L77:
L76:
	JSR	F078_xzzz_(PC)
	CLR	G508_B_Ref(A4)
L71:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$70:	.EQU	#0
F388_rzzz_:/* global */
	LINK	A6,L$84
	MOVE	G506_i_Act(A4),D0
	BEQ.S	L86
	SUBQ	#1,G506_i_Act(A4)
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#-32768,(A0)
	MOVE	G506_i_Act(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	CLR	G506_i_Act(A4)
	MOVE	#1,G508_B_Ref(A4)
L86:
L85:
	UNLK	A6
	RTS
L$84:	.EQU	#0
F389_xxxx_:/* global */
	LINK	A6,L$87
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	48(A3),D0
	AND	#8,D0
	BNE.S	L90
	MOVE	52(A3),D0
	BNE.S	L89
L90:
	BRA.S	L88
L89:
	MOVE	214(A3),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L91
	MOVE	#2,D7
	BRA.S	L92
L91:
	MOVE	D6,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+3(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	CMPI	#0,D0
	BNE.S	L93
	BRA.S	L88
L93:
L92:
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	G489_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	8(A6),D0
	ADDQ	#1,D0
	MOVE	D0,G506_i_Act(A4)
	MOVE.B	6(A2),G512_uc_Us(A4)
	MOVE.L	A2,-(A7)
	JSR	F383_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	G509_B_Act(A4)
	ORI	#-32768,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F387_hzzz_(PC)
L88:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$87:	.EQU	#0
F390_rzzz_:/* global */
	LINK	A6,L$94
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BNE.S	L96
	BRA	L95(PC)
L96:
	MOVE	G300_B_Par(A4),D0
	BNE.S	L98
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L97
L98:
	MOVE	G506_i_Act(A4),D0
	BEQ.S	L99
	JSR	F388_rzzz_(PC)
	BRA	L95(PC)
L99:
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L100
	BRA	L95(PC)
L100:
	BRA.S	L101
L97:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
L102:
	MOVE	D7,D0
	CMP	G411_i_Lea(A4),D0
	BEQ.S	L105
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	G506_i_Act(A4),D0
	BEQ.S	L105
	MOVE.B	41(A3),D0
	BEQ.S	L105
	MOVE.B	28(A3),D0
	MOVE.B	40(A3),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BEQ.S	L105
	MOVE.B	40(A3),28(A3)
	ORI	#1024,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L105:
	CLR.B	41(A3)
	ADDA	#800,A3
	ADDQ	#1,D7
L103:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L102
L104:
L101:
	MOVE	G508_B_Ref(A4),D0
	BEQ.S	L106
	MOVE	G506_i_Act(A4),D0
	BNE.S	L107
	MOVE	G513_i_Act(A4),D0
	BEQ.S	L108
	MOVE	G513_i_Act(A4),-(A7)
	JSR	F385_xxxx_(PC)
	ADDQ.L	#2,A7
	CLR	G513_i_Act(A4)
	BRA.S	L109
L108:
	MOVE	#1,G509_B_Act(A4)
	JSR	F387_hzzz_(PC)
L109:
	BRA.S	L110
L107:
	CLR	G509_B_Act(A4)
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F387_hzzz_(PC)
L110:
L106:
L95:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$94:	.EQU	#0
F391_xxxx_:/* global */
	LINK	A6,L$111
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G506_i_Act(A4),D0
	BEQ.S	L114
	LEA	G511_auc_A(A4),A0
	ADDA	8(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L113
L114:
	MOVE	#0,D0
	BRA.S	L112
L113:
	MOVE	G506_i_Act(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#-1,8(A6)
	BNE.S	L115
	MOVE	#-1,D5
	BRA.S	L116
L115:
	LEA	G511_auc_A(A4),A0
	ADDA	8(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE	D6,D0
	LEA	G495_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,64(A3)
	ORI	#256,48(A3)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F407_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	MOVE	D6,D0
	MOVE.B	D0,32(A3)
L116:
	JSR	F388_rzzz_(PC)
	MOVE	D5,D0
L112:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$111:	.EQU	#0
F392_xxxx_:/* global */
	LINK	A6,L$117
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#2,8(A6)
	BNE.S	L119
	MOVE	#576,-(A7)
	PEA	G515_aui_B(A4)
	PEA	G516_aaui_+576(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1,D6
	MOVE	#6,D5
	MOVE.B	33(A3),D1
	AND	#255,D1
	MULS	D1,D5
	MOVE	D5,-12(A6)
	MOVE	#96,D5
	ADD	-12(A6),D5
	CLR.B	-1(A6)
	CLR	D7
	BRA.S	L120
L121:
	MOVE.B	D5,D0
	ADDQ.B	#1,D5
	MOVE.B	D0,-2(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#8,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#48,-(A7)
	PEA	G515_aui_B(A4)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L122:
	ADDQ	#1,D7
L120:
	CMPI	#6,D7
	BCS.S	L121
L123:
	BRA.S	L124
L119:
	CMPI	#3,8(A6)
	BNE.S	L125
	MOVE	#576,-(A7)
	PEA	G515_aui_B(A4)
	PEA	G516_aaui_+1152(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR.B	-1(A6)
	MOVE	#8,D6
	CLR	D7
	BRA.S	L126
L127:
	MOVE	D7,D0
	LEA	34(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE.B	D0,-2(A6)
	EXT	D0
	CMP	#0,D0
	BNE.S	L130
	BRA.S	L118
L130:
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#8,-(A7)
	MOVE	D6,D0
	ADD	#9,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#48,-(A7)
	PEA	G515_aui_B(A4)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L128:
	ADDQ	#1,D7
L126:
	CMPI	#4,D7
	BCS.S	L127
L129:
L125:
L124:
L118:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$117:	.EQU	#-12
F393_lzzz_:/* global */
	LINK	A6,L$131
	MOVE.L	A3,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	G578_B_Use(A4)
	MOVE	G407_s_Par+52(A4),-2(A6)
	MOVE	G407_s_Par+852(A4),-4(A6)
	MOVE	G407_s_Par+1652(A4),-6(A6)
	MOVE	G407_s_Par+2452(A4),-8(A6)
	JSR	F077_aA39_(PC)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G504_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	8(A6),D0
L133:
	CMP	#0,D0
	BEQ.S	L134
	BRA	L136(PC)
L134:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#277,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#235,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	CMPI	#1,G305_ui_Pa(A4)
	BLS.S	L138
	MOVE	-4(A6),D0
	BEQ.S	L139
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#291,-(A7)
	MOVE	#280,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L139:
L12T393_002:
	CMPI	#2,G305_ui_Pa(A4)
	BLS.S	L140
	MOVE	-6(A6),D0
	BEQ.S	L141
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#305,-(A7)
	MOVE	#294,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L141:
L12T393_003:
	CMPI	#3,G305_ui_Pa(A4)
	BLS.S	L142
	MOVE	-8(A6),D0
	BEQ.S	L143
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#319,-(A7)
	MOVE	#308,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L143:
L142:
L140:
L138:
	BRA	L135(PC)
	BRA.S	L137
L136:
	CMP	#1,D0
	BEQ.S	L137
	BRA.S	L144
L137:
	MOVE	-2(A6),D0
	BEQ.S	L146
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#244,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L146:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#291,-(A7)
	MOVE	#247,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#249,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	BRA	L12T393_002(PC)
	BRA.S	L145
L144:
	CMP	#2,D0
	BEQ.S	L145
	BRA.S	L147
L145:
	MOVE	-2(A6),D0
	BEQ.S	L149
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#244,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L149:
	MOVE	-4(A6),D0
	BEQ.S	L150
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#258,-(A7)
	MOVE	#247,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L150:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#305,-(A7)
	MOVE	#261,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#263,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	BRA	L12T393_003(PC)
	BRA.S	L148
L147:
	CMP	#3,D0
	BEQ.S	L148
	BRA	L151(PC)
L148:
	MOVE	-2(A6),D0
	BEQ.S	L153
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#244,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L153:
	MOVE	-4(A6),D0
	BEQ.S	L154
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#258,-(A7)
	MOVE	#247,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L154:
	MOVE	-6(A6),D0
	BEQ.S	L155
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#272,-(A7)
	MOVE	#261,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L155:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#319,-(A7)
	MOVE	#275,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#277,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L151:
L152:
L135:
	JSR	F078_xzzz_(PC)
L132:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$131:	.EQU	#-8
F394_ozzz_:/* global */
	LINK	A6,L$156
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G514_i_Mag(A4),D0
	BEQ.S	L159
	CMPI	#-1,D7
	BEQ.S	L158
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L158
L159:
	BRA	L157(PC)
L158:
	CMPI	#-1,G514_i_Mag(A4)
	BNE.S	L160
	JSR	F077_aA39_(PC)
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	PEA	G000_s_Gra(A4)
	MOVE	#9,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
L160:
	CMPI	#-1,D7
	BNE.S	L161
	MOVE	#-1,G514_i_Mag(A4)
	JSR	F077_aA39_(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G000_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
	BRA	L162(PC)
L161:
	MOVE	D7,D0
	MOVE	D0,G514_i_Mag(A4)
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#2,-(A7)
	JSR	F392_xxxx_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	MOVE.L	G348_pl_Bi(A4),D4
	ADD.L	#8112,D4
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D6
	BRA.S	L163
L164:
	MOVE	#48,-(A7)
	MOVE.L	D4,D0
	ADD.L	#160,D0
	MOVE.L	D0,D4
	MOVE.L	D0,-(A7)
	MOVE	D5,D0
	ADD	#24,D0
	MOVE	D0,D5
	ASL.L	#1,D0
	LEA	G515_aui_B(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L165:
	ADDQ	#1,D6
L163:
	CMPI	#12,D6
	BCS.S	L164
L166:
	MOVE	#3,-(A7)
	JSR	F392_xxxx_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	MOVE.L	G348_pl_Bi(A4),D4
	ADD.L	#10032,D4
	MOVE	#1,D6
	BRA.S	L167
L168:
	MOVE	#48,-(A7)
	MOVE.L	D4,D0
	ADD.L	#160,D0
	MOVE.L	D0,D4
	MOVE.L	D0,-(A7)
	MOVE	D5,D0
	ADD	#24,D0
	MOVE	D0,D5
	ASL.L	#1,D0
	LEA	G515_aui_B(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L169:
	ADDQ	#1,D6
L167:
	CMPI	#12,D6
	BCS.S	L168
L170:
	JSR	F078_xzzz_(PC)
L162:
L157:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$156:	.EQU	#0
F395_pzzz_:/* global */
	LINK	A6,L$171
	JSR	F077_aA39_(PC)
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	PEA	G002_s_Gra(A4)
	MOVE	#13,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
L172:
	UNLK	A6
	RTS
L$171:	.EQU	#0
F396_pzzz_:/* global */
	LINK	A6,L$173
	CLR	-(A7)
	CLR	-(A7)
	PEA	G516_aaui_(A4)
	MOVE	#11,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L174:
	UNLK	A6
	RTS
L$173:	.EQU	#0
F397_xxxx_:/* global */
	LINK	A6,L$175
	MOVEM.L	D7-D5,-(A7)
	CLR.B	-1(A6)
	MOVE	#96,D5
	MOVE	#6,D1
	MULU	8(A6),D1
	ADD	D1,D5
	MOVE	#225,D6
	CLR	D7
	BRA.S	L177
L178:
	MOVE.B	D5,D0
	ADDQ.B	#1,D5
	MOVE.B	D0,-2(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#58,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L179:
	ADDQ	#1,D7
L177:
	CMPI	#6,D7
	BCS.S	L178
L180:
L176:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$175:	.EQU	#-2
F398_xxxx_:/* global */
	LINK	A6,L$181
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	LEA	34(A3),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	MOVE	#232,D6
	CLR.B	-1(A6)
	CLR	D7
	BRA.S	L183
L184:
	MOVE	D7,D0
	CMP	D5,D0
	BCS.S	L187
	MOVE.B	#32,-2(A6)
	BRA.S	L188
L187:
	MOVE	D7,D0
	LEA	34(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),-2(A6)
L188:
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#70,-(A7)
	MOVE	D6,D0
	ADD	#9,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L185:
	ADDQ	#1,D7
L183:
	CMPI	#4,D7
	BCS.S	L184
L186:
L182:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$181:	.EQU	#-2
F399_xxxx_:/* global */
	LINK	A6,L$189
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	33(A3),D7
	AND	#255,D7
	MOVE	D7,D6
	MULS	#6,D6
	LEA	G485_aauc_(A4),A0
	ADD.L	A0,D6
	MOVE.L	D6,A0
	ADDA	8(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE	D7,D0
	BEQ.S	L191
	MOVE	D6,D0
	MOVE.B	34(A3),D1
	EXT	D1
	SUB	#96,D1
	MOVE	D1,D5
	LEA	G486_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULU	D1,D0
	LSR	#3,D0
	MOVE	D0,D6
L191:
	MOVE	D6,D0
	MOVE	60(A3),D1
	CMP	D1,D0
	BHI.S	L192
	MOVE	D6,D0
	SUB	D0,60(A3)
	ORI	#256,48(A3)
	MOVE	#96,D0
	MOVE	D7,D1
	MULU	#6,D1
	ADD	D1,D0
	ADD	8(A6),D0
	MOVE	D7,D1
	LEA	34(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D7,D0
	LEA	35(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE	D7,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,D7
	MOVE.B	D0,33(A3)
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F397_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F398_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L192:
L190:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$189:	.EQU	#0
F400_xxxx_:/* global */
	LINK	A6,L$193
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	LEA	34(A3),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L195
	BRA.S	L194
L195:
	MOVE.B	33(A3),D0
	AND	#255,D0
	ADDQ	#3,D0
	AND	#3,D0
	MOVE	D0,D7
	MOVE.B	D0,33(A3)
	MOVE	D7,D0
	LEA	34(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F397_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F398_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F078_xzzz_(PC)
L194:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$193:	.EQU	#0
F401_xxxx_:/* global */
	LINK	A6,L$196
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D4
	CMPI	#-2,G517_T_Act(A4)
	BNE.S	L198
	BRA	L199(PC)
L198:
	MOVE	10(A6),D0
L200:
	CMP	#8,D0
	BEQ.S	L201
	BRA.S	L203
L201:
	MOVE	#3,D7
	MOVE	#12,D5
	BRA.S	L202
	BRA.S	L204
L203:
	CMP	#37,D0
	BEQ.S	L204
	BRA.S	L205
L204:
	MOVE	#7,D7
	MOVE	#35,D5
	BRA.S	L202
	BRA.S	L206
L205:
	CMP	#41,D0
	BEQ.S	L206
	BRA.S	L207
L206:
	MOVE	#6,D7
	MOVE	#30,D5
	BRA.S	L202
	BRA.S	L208
L207:
	CMP	#4,D0
	BEQ.S	L208
	BRA.S	L209
L208:
	MOVE	#6,D7
	MOVE	#20,D5
	BRA.S	L202
	BRA.S	L210
L209:
	CMP	#22,D0
	BEQ.S	L210
	BRA.S	L211
L210:
	MOVE	#12,D7
	MOVE	#45,D5
L211:
L212:
L202:
	MOVE	#14,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D7
	MOVE	G517_T_Act(A4),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	MOVE	D0,-14(A6)
	MOVE	16(A2),D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,D6
	CMP	-14(A6),D0
	BHI.S	L214
	CMPI	#15,D6
	BNE.S	L213
L214:
	MOVE	D5,D0
	LSR	#1,D0
	MOVE	D0,D5
	BRA	L215(PC)
L213:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
	MOVE	14(A3),D0
	AND	#15,D0
	CMPI	#6,D0
	BNE.S	L216
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F182_aqzz_(PC)
	ADDQ.L	#8,A7
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F180_hzzz_(PC)
	ADDQ.L	#4,A7
L216:
	MOVE	#5,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	MOVE	#16,D0
	SUB	D6,D0
	ASL	#2,D0
	MOVE.B	6(A2),D1
	AND	#255,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	MOVE.L	-4(A6),A0
	MOVE.B	D0,5(A0)
	MOVE	#1,D4
L215:
	MOVE	D5,-(A7)
	MOVE	#14,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L199:
	MOVE	D4,D0
L197:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$196:	.EQU	#-14
F402_xxxx_:/* global */
	LINK	A6,L$217
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	10(A6),A3
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	CMPI	#-2,G517_T_Act(A4)
	BNE.S	L219
	BRA	L21T402_010(PC)
L219:
	MOVE.B	29(A3),D0
	AND	#255,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	JSR	F177_aszz_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	BEQ	L220(PC)
	MOVE.B	28(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	CMP	D7,D0
	BEQ.S	L221
	ADDQ	#1,D6
	MOVE	D6,D0
	AND	#3,D0
	CMP	D7,D0
	BEQ.S	L221
	ADDQ	#1,D6
	MOVE	D6,D0
	AND	#3,D0
	CMP	D7,D0
	BNE.S	L222
	MOVE	D7,D0
	ADDQ	#3,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L221
L222:
	MOVE	D7,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L223
	MOVE	#-1,G513_i_Act(A4)
	BRA	L21T402_010(PC)
L223:
L221:
	CMPI	#24,14(A6)
	BNE.S	L224
	MOVE	G517_T_Act(A4),-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#64,D0
	BNE.S	L224
	BRA	L225(PC)
L224:
	LEA	G493_auc_G(A4),A0
	ADDA	14(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	LEA	G492_auc_G(A4),A0
	ADDA	14(A6),A0
	MOVE.B	(A0),D7
	AND	#255,D7
	MOVE	214(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#40,D0
	BEQ.S	L227
	CMPI	#24,14(A6)
	BNE.S	L226
L227:
	OR	#-32768,D6
L226:
	MOVE	20(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	D5,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	G517_T_Act(A4),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	8(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F231_izzz_(PC)
	ADDA	#22,A7
	MOVE	D0,G513_i_Act(A4)
	MOVE	#1,D0
	BRA.S	L218
L225:
L220:
L21T402_010:
	MOVE	#0,D0
L218:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$217:	.EQU	#0
F403_xxxx_:/* global */
	LINK	A6,L$228
	MOVEM.L	D7-D6,-(A7)
	MOVE	14(A6),D7
	MOVE	#1,D6
	MOVE	16(A6),D0
	BEQ.S	L230
	MOVE.L	8(A6),A0
	CMPI	#0,60(A0)
	BNE.S	L231
	MOVE	#0,D0
	BRA	L229(PC)
L231:
	MOVE.L	8(A6),A0
	CMPI	#4,60(A0)
	BGE.S	L232
	MOVE	D7,D0
	LSR	#1,D0
	MOVE	D0,D7
	MOVE.L	8(A6),A0
	CLR	60(A0)
	CLR	D6
	BRA.S	L233
L232:
	MOVE.L	8(A6),A0
	SUBQ	#4,60(A0)
L233:
L230:
	MOVE	D7,D0
	LSR	#5,D0
	MOVE	D0,-4(A6)
	MOVE	12(A6),D0
	BEQ.S	L234
	MOVE.B	#77,-6(A6)
	CMPI	#50,G407_s_Par+3208(A4)
	BLE.S	L235
	MOVE	-4(A6),D0
	ASR	#2,D0
	MOVE	D0,-4(A6)
L235:
	MOVE	-4(A6),D0
	ADD	D0,G407_s_Par+3208(A4)
	BRA.S	L236
L234:
	MOVE.B	#78,-6(A6)
	CMPI	#50,G407_s_Par+3206(A4)
	BLE.S	L237
	MOVE	-4(A6),D0
	ASR	#2,D0
	MOVE	D0,-4(A6)
L237:
	MOVE	-4(A6),D0
	ADD	D0,G407_s_Par+3206(A4)
L236:
	CLR.B	-5(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	AND.L	#65535,D7
	ADD.L	D7,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	JSR	F260_pzzz_(PC)
	MOVE	D6,D0
L229:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$228:	.EQU	#-10
F404_xxxx_:/* global */
	LINK	A6,L$238
	MOVE.B	#70,-6(A6)
	MOVE	8(A6),-4(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	CLR.B	-5(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	JSR	F337_akzz_(PC)
L239:
	UNLK	A6
	RTS
L$238:	.EQU	#-10
F405_xxxx_:/* global */
	LINK	A6,L$240
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A0
	MOVE	214(A0),D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L242:
	CMP	#5,D0
	BEQ.S	L243
	BRA.S	L245
L243:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	BEQ.S	L247
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-15361,2(A0)
	OR	D3,2(A0)
L247:
	BRA	L244(PC)
	BRA.S	L246
L245:
	CMP	#6,D0
	BEQ.S	L246
	BRA.S	L248
L246:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#7680,D0
	LSR	#1,D0
	LSR	#8,D0
	BEQ.S	L250
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#7680,D0
	LSR	#1,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#1,D3
	ASL	#8,D3
	ANDI	#-7681,2(A0)
	OR	D3,2(A0)
L250:
	BRA.S	L244
	BRA.S	L249
L248:
	CMP	#10,D0
	BEQ.S	L249
	BRA.S	L251
L249:
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	BEQ.S	L253
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A3)
	OR	D3,2(A3)
L253:
L251:
L252:
L244:
	JSR	F296_aizz_(PC)
L241:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$240:	.EQU	#0
F406_xxxx_:/* global */
	LINK	A6,L$254
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	28(A3),D0
	AND	#255,D0
	CMP	G308_i_Par(A4),D0
	BEQ.S	L256
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	ORI	#1024,48(A3)
L256:
L255:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$254:	.EQU	#0
F407_xxxx_:/* global */
	LINK	A6,L$257
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L259
	MOVE	#0,D0
	BRA	L258(PC)
L259:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BNE.S	L260
	MOVE	#0,D0
	BRA	L258(PC)
L260:
	MOVE	G306_i_Par(A4),-6(A6)
	MOVE	G307_i_Par(A4),-8(A6)
	MOVE.B	28(A3),D1
	AND	#255,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE.B	28(A3),D1
	AND	#255,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,G517_T_Act(A4)
	LEA	G491_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	LEA	G496_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	LEA	G494_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D1,D0
	MOVE	D0,-10(A6)
	LEA	G497_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-14(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D6
	MOVE	#1,D5
	CMPI	#16,-12(A6)
	BLT.S	L263
	CMPI	#19,-12(A6)
	BLE.S	L262
L263:
	CMPI	#3,-12(A6)
	BNE.S	L261
L262:
	MOVE	-12(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#6,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	#7,D0
	SUB	D1,D0
	MOVE	D0,D4
L261:
	MOVE	10(A6),D0
L264:
	CMP	#23,D0
	BEQ.S	L265
	BRA.S	L267
L265:
	MOVE	#180,-4(A6)
	MOVE	#-126,D5
	BRA.S	L26T407_014
	BRA.S	L268
L267:
	CMP	#21,D0
	BEQ.S	L268
	BRA.S	L269
L268:
	MOVE	#150,-4(A6)
	MOVE	#-125,D5
	BRA.S	L26T407_014
	BRA.S	L270
L269:
	CMP	#20,D0
	BEQ.S	L270
	BRA.S	L271
L270:
	MOVE	#150,-4(A6)
	BRA.S	L26T407_013
	BRA.S	L272
L271:
	CMP	#40,D0
	BEQ.S	L272
	BRA.S	L273
L272:
	MOVE	#250,-4(A6)
L26T407_013:
	MOVE	#-128,D5
L26T407_014:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	60(A3),D0
	CMP	D4,D0
	BGE.S	L275
	MOVE	60(A3),D0
	MULS	-4(A6),D0
	EXT.L	D0
	DIVS	D4,D0
	MOVE	D0,-(A7)
	MOVE	#2,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	60(A3),D4
L275:
	MOVE	D4,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F327_kzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	BNE.S	L276
	MOVE	-14(A6),D0
	ASR	#1,D0
	MOVE	D0,-14(A6)
L276:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L266(PC)
	BRA.S	L274
L273:
	CMP	#30,D0
	BEQ.S	L274
L277:
	CMP	#18,D0
	BEQ.S	L274
L278:
	CMP	#19,D0
	BEQ.S	L274
L279:
	CMP	#7,D0
	BEQ.S	L274
L280:
	CMP	#13,D0
	BEQ.S	L274
L281:
	CMP	#2,D0
	BEQ.S	L274
	BRA.S	L282
L274:
	MOVE	D6,D0
	LSR	#5,D0
	CMPI	#4,D0
	BNE.S	L284
	MOVE	D6,D0
	AND	#7,D0
	CMPI	#4,D0
	BNE.S	L284
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	#6,-2(A6)
	MOVE	#2,-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F232_dzzz_(PC)
	ADDA	#10,A7
	MOVE	#2,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#4,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L266(PC)
L284:
	BRA.S	L283
L282:
	CMP	#24,D0
	BEQ.S	L283
L285:
	CMP	#16,D0
	BEQ.S	L283
L286:
	CMP	#17,D0
	BEQ.S	L283
L287:
	CMP	#14,D0
	BEQ.S	L283
L288:
	CMP	#9,D0
	BEQ.S	L283
L289:
	CMP	#31,D0
	BEQ.S	L283
L290:
	CMP	#15,D0
	BEQ.S	L283
L291:
	CMP	#25,D0
	BEQ.S	L283
L292:
	CMP	#28,D0
	BEQ.S	L283
L293:
	CMP	#29,D0
	BEQ.S	L283
L294:
	CMP	#6,D0
	BEQ.S	L283
	BRA.S	L295
L283:
	MOVE	-12(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F402_xxxx_(PC)
	ADDA	#14,A7
	MOVE	D0,D5
	BNE.S	L297
	MOVE	-14(A6),D0
	ASR	#1,D0
	MOVE	D0,-14(A6)
L297:
	BRA	L266(PC)
	BRA.S	L296
L295:
	CMP	#22,D0
	BEQ.S	L296
	BRA.S	L298
L296:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L299
L298:
	CMP	#8,D0
	BEQ.S	L299
L300:
	CMP	#37,D0
	BEQ.S	L299
L301:
	CMP	#41,D0
	BEQ.S	L299
L302:
	CMP	#4,D0
	BEQ.S	L299
	BRA.S	L303
L299:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F401_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	BRA	L266(PC)
	BRA.S	L304
L303:
	CMP	#32,D0
	BEQ.S	L304
	BRA	L305(PC)
L304:
	MOVE	212(A3),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BEQ.S	L307
	BRA	L26T407_032(PC)
L307:
	MOVE	214(A3),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+20(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-18(A6)
	MOVE	212(A3),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+20(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-22(A6)
	MOVE.L	-18(A6),A0
	MOVE.B	1(A0),D4
	AND	#255,D4
	MOVE.L	-22(A6),A0
	MOVE.B	1(A0),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	CMPI	#16,D4
	BLT.S	L308
	CMPI	#31,D4
	BGT.S	L308
	CMPI	#10,-4(A6)
	BEQ.S	L309
	BRA.S	L26T407_032
L309:
	SUB	#16,D4
	BRA.S	L310
L308:
	CMPI	#32,D4
	BLT.S	L311
	CMPI	#47,D4
	BGT.S	L311
	CMPI	#11,-4(A6)
	BEQ.S	L312
L26T407_032:
	MOVE	#-2,G513_i_Act(A4)
	CLR	-14(A6)
	CLR	D5
	BRA	L266(PC)
L312:
	SUB	#32,D4
L311:
L310:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,-(A7)
	MOVE	#11,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-42(A6)
	MOVE.L	-18(A6),A0
	MOVE	4(A0),D0
	AND	#255,D0
	ADD	-42(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	-18(A6),A0
	MOVE.B	3(A0),D0
	MOVE.L	-22(A6),A0
	AND	#255,D0
	MOVE.B	3(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F326_ozzz_(PC)
	ADDA	#12,A7
	BRA	L266(PC)
	BRA.S	L306
L305:
	CMP	#5,D0
	BEQ.S	L306
	BRA.S	L313
L306:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L315
DATA SEG "s!"
	DATA 49 54 20 43 4F 4D 45 53 20 55 50 20 48 45 41 44 53 2E 00 00 
CODE SEG "user"
	PEA	s!+24(A4)
	JSR	F381_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L316
L315:
DATA SEG "s!"
	DATA 49 54 20 43 4F 4D 45 53 20 55 50 20 54 41 49 4C 53 2E 00 00 
CODE SEG "user"
	PEA	s!+44(A4)
	JSR	F381_xxxx_(PC)
	ADDQ.L	#4,A7
L316:
	BRA	L266(PC)
	BRA.S	L314
L313:
	CMP	#33,D0
	BEQ.S	L314
L317:
	CMP	#34,D0
	BEQ.S	L314
	BRA.S	L318
L314:
	MOVE	#1,-(A7)
	MOVE	#280,-(A7)
	CMPI	#33,10(A6)
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F403_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L320
	MOVE	-14(A6),D0
	ASR	#2,D0
	MOVE	D0,-14(A6)
	MOVE	-2(A6),D0
	LSR	#1,D0
	MOVE	D0,-2(A6)
	BRA.S	L321
L320:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
L321:
	BRA	L266(PC)
	BRA.S	L319
L318:
	CMP	#27,D0
	BEQ.S	L319
	BRA.S	L322
L319:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	ADD	#100,D0
	MOVE	D0,-4(A6)
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#6,D0
	SWAP	D0
L324:
	CMP	#0,D0
	BEQ.S	L325
	BRA.S	L327
L325:
	MOVE	#-122,D5
	BRA	L26T407_014(PC)
	BRA.S	L328
L327:
	CMP	#1,D0
	BEQ.S	L328
	BRA.S	L329
L328:
	MOVE	#-121,D5
	BRA	L26T407_014(PC)
	BRA.S	L330
L329:
	CMP	#2,D0
	BEQ.S	L330
	BRA.S	L331
L330:
	MOVE	#-125,D5
	BRA	L26T407_014(PC)
L332:
	BRA	L26T407_013(PC)
	BRA.S	L333
L331:
	BRA.S	L332
L333:
L326:
	BRA.S	L323
L322:
	CMP	#35,D0
	BEQ.S	L323
	BRA.S	L334
L323:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F224_zzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L266(PC)
	BRA.S	L335
L334:
	CMP	#43,D0
	BEQ.S	L335
	BRA.S	L336
L335:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	G306_i_Par(A4),-6(A6)
	MOVE	G307_i_Par(A4),-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F225_dzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L266(PC)
	BRA.S	L337
L336:
	CMP	#36,D0
	BEQ.S	L337
	BRA	L338(PC)
L337:
	MOVE	#13,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#10,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	JSR	F027_AA59_(PC)
	MOVE	D4,D1
	ADDQ	#5,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,-(A7)
	MOVE	54(A3),D0
	SUB	52(A3),D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	#2,-14(A6)
	BRA.S	L340
L341:
	SUBQ	#1,-4(A6)
L340:
	MOVE	-4(A6),D0
	BEQ.S	L343
	MOVE	#16,D0
	SUB	D4,D0
	MULS	-4(A6),D0
	ASR	#2,D0
	MOVE	D0,D6
	MOVE	60(A3),D1
	CMP	D1,D0
	BHI.S	L341
L343:
L342:
	MOVE	-4(A6),D0
	BEQ.S	L344
	MOVE	-4(A6),D0
	ADD	D0,52(A3)
	MOVE	D6,D0
	SUB	D0,60(A3)
	ORI	#256,48(A3)
	MOVE	#1,D5
	MOVE	#20,-14(A6)
L344:
	BRA	L266(PC)
	BRA.S	L339
L338:
	CMP	#39,D0
	BEQ.S	L339
	BRA.S	L345
L339:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,-(A7)
	MOVE	-12(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADDQ	#8,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	ADDQ	#5,D0
	MOVE	D0,D4
	CLR.B	-27(A6)
	MOVE.B	#73,-28(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	AND.L	#65535,D4
	ADD.L	D4,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-32(A6)
	PEA	-32(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	ADDQ.B	#1,G407_s_Par+3202(A4)
	BRA	L26T407_076(PC)
	BRA.S	L346
L345:
	CMP	#10,D0
	BEQ.S	L346
	BRA	L347(PC)
L346:
	MOVE	G306_i_Par(A4),-6(A6)
	MOVE	G307_i_Par(A4),-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	CMPI	#2,D0
	BNE.S	L349
	MOVE	#1,G402_B_Use(A4)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	CLR	G402_B_Use(A4)
	BRA.S	L350
L349:
	CLR	-2(A6)
L350:
	BRA	L266(PC)
	BRA.S	L348
L347:
	CMP	#11,D0
	BEQ.S	L348
	BRA.S	L351
L348:
	MOVE	214(A3),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	CMPI	#42,D0
	BNE.S	L353
	MOVE	#30,D4
	BRA.S	L26T407_071
L353:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	CMPI	#43,D0
	BNE.S	L354
	MOVE	#125,D4
L26T407_071:
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L355
L354:
	MOVE	#70,D4
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
L355:
	MOVE.B	G407_s_Par+3211(A4),D0
	AND	#255,D0
	ADD	D4,D0
	MOVE	D0,-(A7)
	MOVE	#200,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,G407_s_Par+3211(A4)
	BRA	L266(PC)
	BRA.S	L352
L351:
	CMP	#38,D0
	BEQ.S	L352
	BRA.S	L356
L352:
	MOVE	G039_ai_Gr+4(A4),D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	#2500,-(A7)
	MOVE	#-2,-(A7)
	JSR	F404_xxxx_(PC)
	ADDQ.L	#4,A7
L26T407_076:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L266
	BRA.S	L357
L356:
	CMP	#42,D0
	BEQ.S	L357
	BRA.S	L358
L357:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.B	29(A3),D0
	MOVE	G308_i_Par(A4),D1
	ADDQ	#1,D1
	AND	#3,D1
	AND	#255,D0
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L361
	MOVE.B	29(A3),D0
	MOVE	G308_i_Par(A4),D1
	ADDQ	#2,D1
	AND	#3,D1
	AND	#255,D0
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
L361:
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F328_nzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	BEQ.S	L360
	MOVE	44(A3),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	#2,6(A0)
L360:
L358:
L359:
L266:
	MOVE	-2(A6),D0
	BEQ.S	L362
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F330_szzz_(PC)
	ADDQ.L	#4,A7
L362:
	MOVE	-10(A6),D0
	BEQ.S	L363
	MOVE	-10(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
L363:
	MOVE	-14(A6),D0
	BEQ.S	L364
	MOVE	-14(A6),-(A7)
	MOVE	-12(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L364:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
L258:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$257:	.EQU	#-42
F408_xxxx_:/* global */
	LINK	A6,L$365
	MOVEM.L	A3/D7,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	JSR	F077_aA39_(PC)
	JSR	F363_pzzz_(PC)
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F412_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#3,D0
	BEQ.S	L367
	CLR.B	34(A3)
	MOVE.B	#0,D0
	AND	#255,D0
	MOVE.B	D0,33(A3)
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F397_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F398_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L368
L367:
	CLR	D7
L368:
	JSR	F078_xzzz_(PC)
	MOVE	D7,D0
L366:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$365:	.EQU	#0
F409_xxxx_:/* global */
	LINK	A6,L$369
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,D0
	ADDQ.L	#1,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	BNE.S	L371
	MOVE.L	#0,D0
	BRA.S	L370
L371:
	MOVE	#24,D6
	CLR.L	D7
L372:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	EXT.L	D0
	ASL.L	D6,D0
	OR.L	D0,D7
L373:
	MOVE.B	(A3),D0
	BEQ.S	L375
	MOVE	D6,D0
	SUBQ	#8,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BGE.S	L372
L375:
L374:
	LEA	G487_as_Gr(A4),A0
	MOVE.L	A0,A2
	MOVE	#25,D6
	BRA.S	L376
L377:
	MOVE.L	(A2),D0
	AND.L	#-16777216,D0
	BEQ.S	L379
	MOVE.L	D7,D0
	CMP.L	(A2),D0
	BNE.S	L380
	MOVE.L	A2,D0
	BRA.S	L370
L380:
	BRA.S	L381
L379:
	MOVE.L	D7,D0
	AND.L	#16777215,D0
	CMP.L	(A2),D0
	BNE.S	L382
	MOVE.L	A2,D0
	BRA.S	L370
L382:
L381:
	ADDQ.L	#8,A2
L376:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L377
L378:
	MOVE.L	#0,D0
L370:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$369:	.EQU	#0
F410_xxxx_:/* global */
	LINK	A6,L$383
	MOVE.L	A3,-(A7)
	CMPI	#3,14(A6)
	BLS.S	L385
	MOVE	14(A6),D0
	SUBQ	#4,D0
	AND.L	#65535,D0
	DIVU	#4,D0
	MOVE	D0,14(A6)
L385:
	JSR	F051_AA19_(PC)
	MOVE.L	8(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	12(A6),D0
L386:
	CMP	#0,D0
	BEQ.S	L387
	BRA.S	L389
L387:
DATA SEG "s!"
	DATA 20 4E 45 45 44 53 20 4D 4F 52 45 20 50 52 41 43 54 49 43 45 20 57 49 54 48 20 54 48 49 53 20 00 
CODE SEG "user"
	LEA	s!+64(A4),A0
	MOVE.L	A0,A3
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	14(A6),D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 53 50 45 4C 4C 2E 00 
CODE SEG "user"
	LEA	s!+96(A4),A0
	MOVE.L	A0,A3
	BRA.S	L388
	BRA.S	L390
L389:
	CMP	#1,D0
	BEQ.S	L390
	BRA.S	L391
L390:
DATA SEG "s!"
	DATA 20 4D 55 4D 42 4C 45 53 20 41 20 4D 45 41 4E 49 4E 47 4C 45 53 53 20 53 50 45 4C 4C 2E 00 
CODE SEG "user"
	LEA	s!+104(A4),A0
	MOVE.L	A0,A3
	BRA.S	L388
	BRA.S	L392
L391:
	CMP	#10,D0
	BEQ.S	L392
	BRA.S	L393
L392:
DATA SEG "s!"
	DATA 20 4E 45 45 44 53 20 41 4E 20 45 4D 50 54 59 20 46 4C 41 53 4B 20 49 4E 20 48 41 4E 44 20 46 4F 52 20 50 4F 54 49 4F 4E 2E 00 
CODE SEG "user"
	LEA	s!+134(A4),A0
	MOVE.L	A0,A3
L393:
L394:
L388:
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L384:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$383:	.EQU	#0
F411_xxxx_:/* global */
	LINK	A6,L$395
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE	214(A3),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L397
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#195,D0
	BNE.S	L397
	MOVE	D7,(A2)
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+32(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	BRA.S	L396
L397:
	MOVE	212(A3),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L398
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#195,D0
	BNE.S	L398
	MOVE	D7,(A2)
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+32(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	BRA.S	L396
L398:
	MOVE.L	#0,D0
L396:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$395:	.EQU	#0
F412_xxxx_:/* global */
	LINK	A6,L$399
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L401
	MOVE	#0,D0
	BRA	L400(PC)
L401:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BNE.S	L402
	MOVE	#0,D0
	BRA	L400(PC)
L402:
	LEA	34(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F409_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A2
	CMPI.L	#0,D0
	BNE.S	L403
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F410_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#0,D0
	BRA	L400(PC)
L403:
	MOVE.B	34(A3),D4
	EXT	D4
	SUB	#95,D4
	JSR	F027_AA59_(PC)
	AND	#7,D0
	MOVE.B	4(A2),D1
	AND	#255,D1
	ADD	D4,D1
	MOVE	D1,D5
	ASL	#4,D1
	ADD	D1,D0
	MOVE	D4,D1
	SUBQ	#1,D1
	MOVE.B	4(A2),D2
	AND	#255,D2
	MULS	D2,D1
	ASL	#3,D1
	ADD	D1,D0
	MOVE	D5,D1
	MULU	D5,D1
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	MOVE	D6,D0
	CMP	D5,D0
	BCC.S	L404
	MOVE	D5,D0
	SUB	D6,D0
	MOVE	D0,-6(A6)
	BRA.S	L405
L406:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	MOVE.L	D0,-(A7)
	MOVE	#115,-(A7)
	MOVE.B	80(A3),D0
	AND	#255,D0
	ADD	#15,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	CMP	D1,D0
	BLS.S	L408
	MOVE	-4(A6),D0
	MOVE	D5,D1
	SUB	D6,D1
	LSR	D1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	JSR	F410_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#0,D0
	BRA	L400(PC)
L408:
L405:
	MOVE	-6(A6),D0
	SUBQ	#1,-6(A6)
	TST	D0
	BNE.S	L406
L407:
L404:
	MOVE	6(A2),D0
	AND	#15,D0
L409:
	CMP	#1,D0
	BEQ.S	L410
	BRA	L412(PC)
L410:
	PEA	-2(A6)
	MOVE.L	A3,-(A7)
	JSR	F411_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	D0,-10(A6)
	CMPI.L	#0,D0
	BNE.S	L414
	CLR	-(A7)
	MOVE	#10,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F410_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#3,D0
	BRA	L400(PC)
L414:
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
	MOVE.L	-10(A6),A0
	AND	#127,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-32513,2(A0)
	OR	D3,2(A0)
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE	D4,D1
	MULS	#40,D1
	ADD	D1,D0
	MOVE.L	-10(A6),A0
	AND	#255,D0
	MOVE	D0,D3
	ANDI	#-256,2(A0)
	OR	D3,2(A0)
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	SUB	D5,D0
	ADD	D0,272(A3)
	JSR	F296_aizz_(PC)
	MOVE	G423_i_Inv(A4),D0
	MOVE	D7,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L415
	ORI	#512,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L415:
	BRA	L411(PC)
	BRA.S	L413
L412:
	CMP	#2,D0
	BEQ.S	L413
	BRA.S	L416
L413:
	MOVE.B	28(A3),D0
	AND	#255,D0
	CMP	G308_i_Par(A4),D0
	BEQ.S	L418
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	ORI	#1024,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L418:
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
	CMPI	#4,D0
	BNE.S	L419
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
L419:
	CLR	-(A7)
	MOVE	#255,-(A7)
	MOVE	#4,D1
	MOVE	D6,D0
	ASL	#1,D0
	ADD	D0,D1
	MOVE	D4,D0
	ADDQ	#2,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE	#21,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-(A7)
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
	ADD	#-128,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F327_kzzz_(PC)
	ADDQ.L	#8,A7
	BRA	L411(PC)
	BRA.S	L417
L416:
	CMP	#3,D0
	BEQ.S	L417
	BRA	L420(PC)
L417:
	CLR.B	-15(A6)
	MOVE	D4,D6
	ADDQ	#1,D6
	ASL	#2,D6
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
L422:
	CMP	#0,D0
	BEQ.S	L423
	BRA.S	L425
L423:
	MOVE	#10000,D5
	MOVE	D6,D1
	SUBQ	#8,D1
	ASL	#1,D1
	ASL	#8,D1
	ADD	D1,D5
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	SUBQ	#1,D6
	BRA.S	L31T412_019
	BRA.S	L426
L425:
	CMP	#5,D0
	BEQ.S	L426
	BRA.S	L427
L426:
	MOVE	#2000,D5
	MOVE	D6,D1
	SUBQ	#3,D1
	ASL	#7,D1
	ADD	D1,D5
	MOVE	D6,D0
	LSR	#2,D0
	MOVE	D0,D6
	ADDQ	#1,D6
L31T412_019:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	D5,-(A7)
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,-(A7)
	JSR	F404_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L424(PC)
	BRA.S	L428
L427:
	CMP	#1,D0
	BEQ.S	L428
	BRA.S	L429
L428:
	MOVE	D6,D0
	LSR	#2,D0
	MOVE	D0,D6
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D0,G407_s_Par+3200(A4)
	MOVE	#98,-(A7)
	MOVE	D6,-(A7)
	JSR	F404_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L424(PC)
	BRA.S	L430
L429:
	CMP	#2,D0
	BEQ.S	L430
	BRA.S	L431
L430:
	MOVE.B	#73,-16(A6)
	ADDQ.B	#1,G407_s_Par+3202(A4)
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	BRA.S	L31T412_032
	BRA.S	L432
L431:
	CMP	#3,D0
	BEQ.S	L432
	BRA.S	L433
L432:
	MOVE.B	#71,-16(A6)
	ADDQ.B	#1,G407_s_Par+3286(A4)
	BRA.S	L31T412_033
	BRA.S	L434
L433:
	CMP	#4,D0
	BEQ.S	L434
	BRA.S	L435
L434:
	MOVE.B	#74,-16(A6)
	MOVE	D6,-14(A6)
	CMPI	#50,G407_s_Par+3204(A4)
	BLE.S	L437
	MOVE	-14(A6),D0
	ASR	#2,D0
	MOVE	D0,-14(A6)
L437:
	MOVE	-14(A6),D0
	ADD	D0,G407_s_Par+3204(A4)
	JSR	F260_pzzz_(PC)
	BRA.S	L31T412_032
	BRA.S	L436
L435:
	CMP	#6,D0
	BEQ.S	L436
	BRA.S	L438
L436:
	MOVE.B	#79,-16(A6)
	ADDQ.B	#1,G407_s_Par+3203(A4)
	MOVE.B	G407_s_Par+3210(A4),G407_s_Par+3212(A4)
	CMPI	#3,D4
	BGE.S	L440
	MOVE.B	G407_s_Par+3212(A4),G407_s_Par+3213(A4)
	BRA.S	L441
L440:
	CLR.B	G407_s_Par+3213(A4)
L441:
L31T412_032:
	MOVE	D6,D0
	MULU	D6,D0
	MOVE	D0,D6
L31T412_033:
	MOVE.L	G313_ul_Ga(A4),D0
	AND.L	#65535,D6
	ADD.L	D6,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L424(PC)
	BRA.S	L439
L438:
	CMP	#7,D0
	BEQ.S	L439
	BRA	L442(PC)
L439:
	MOVE	#10,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#-1,D0
	BNE.S	L444
	BRA	L424(PC)
L444:
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-24(A6)
	MOVE	#51,D0
	MOVE.L	-24(A6),A0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A0)
	OR	D3,2(A0)
	CMPI	#-1,212(A3)
	BNE.S	L445
	CLR	D6
	BRA.S	L446
L445:
	CMPI	#-1,214(A3)
	BNE.S	L447
	MOVE	#1,D6
	BRA.S	L448
L447:
	MOVE	#-1,D6
L448:
L446:
	CMPI	#0,D6
	BEQ.S	L450
	CMPI	#1,D6
	BNE.S	L449
L450:
	MOVE	D6,-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L451
L449:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L451:
	BRA.S	L424
	BRA.S	L443
L442:
	CMP	#8,D0
	BEQ.S	L443
	BRA.S	L452
L443:
	CLR	-(A7)
	MOVE	D6,D0
	MULU	D6,D0
	ADD	#100,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	JSR	F403_xxxx_(PC)
	ADDA	#10,A7
L452:
L453:
L424:
L420:
L421:
L411:
	MOVE	-4(A6),-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	6(A2),D0
	LSR	#2,D0
	LSR	#8,D0
	AND	#63,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F330_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
L400:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$399:	.EQU	#-24
