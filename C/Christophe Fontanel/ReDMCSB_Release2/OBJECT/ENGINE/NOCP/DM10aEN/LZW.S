BSS SEG "bss"
G663_B_LZW:/* global */
	.WORD	#2
G664_i_LZW:/* global */
	.WORD	#2
G665_i_LZW:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#4096,G666_i_LZW(A4)
BSS SEG "bss"
G666_i_LZW:/* global */
	.WORD	#2
G667_ac_LZ:/* global */
	.WORD	#12
G668_i_LZW:/* global */
	.WORD	#2
G669_B_LZW:/* global */
	.WORD	#2
CODE SEG "memory"
F495_xxxx_:/* global */
	LINK	A6,L$0
CODE SEG "init!"
	LEA	1G670_auc_(A4),A1
	MOVE.B	#-1,(A1)+
	MOVE.B	#-2,(A1)+
	MOVE.B	#-4,(A1)+
	MOVE.B	#-8,(A1)+
	MOVE.B	#-16,(A1)+
	MOVE.B	#-32,(A1)+
	MOVE.B	#-64,(A1)+
	MOVE.B	#-128,(A1)+
	MOVE.B	#0,(A1)+
BSS SEG "bss"
1G670_auc_:
	.WORD	#10
CODE SEG "init!"
	LEA	2G671_auc_(A4),A1
	MOVE.B	#0,(A1)+
	MOVE.B	#1,(A1)+
	MOVE.B	#3,(A1)+
	MOVE.B	#7,(A1)+
	MOVE.B	#15,(A1)+
	MOVE.B	#31,(A1)+
	MOVE.B	#63,(A1)+
	MOVE.B	#127,(A1)+
	MOVE.B	#-1,(A1)+
BSS SEG "bss"
2G671_auc_:
	.WORD	#10
CODE SEG "init!"
	MOVE	#0,3G672_i_LZ(A4)
BSS SEG "bss"
3G672_i_LZ:
	.WORD	#2
CODE SEG "init!"
	MOVE	#0,4G673_i_LZ(A4)
BSS SEG "bss"
4G673_i_LZ:
	.WORD	#2
CODE SEG "memory"
	MOVEM.L	A3/D7-D5,-(A7)
	LEA	G667_ac_LZ(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	CMPI	#0,G669_B_LZW(A4)
	BGT.S	L3
	MOVE	3G672_i_LZ(A4),D0
	CMP	4G673_i_LZ(A4),D0
	BGE.S	L3
	MOVE	G668_i_LZW(A4),D0
	CMP	G665_i_LZW(A4),D0
	BLE	L2(PC)
L3:
	MOVE	G668_i_LZW(A4),D0
	CMP	G665_i_LZW(A4),D0
	BLE.S	L4
	ADDQ	#1,G664_i_LZW(A4)
	CMPI	#12,G664_i_LZW(A4)
	BNE.S	L5
	MOVE	G666_i_LZW(A4),G665_i_LZW(A4)
	BRA.S	L6
L5:
	MOVE	#1,D0
	MOVE	G664_i_LZW(A4),D3
	ASL	D3,D0
	SUBQ	#1,D0
	MOVE	D0,G665_i_LZW(A4)
L6:
L4:
	CMPI	#0,G669_B_LZW(A4)
	BLE.S	L7
	MOVE	#1,D0
	MOVE	#9,D1
	MOVE	D1,G664_i_LZW(A4)
	ASL	D1,D0
	SUBQ	#1,D0
	MOVE	D0,G665_i_LZW(A4)
	CLR	G669_B_LZW(A4)
L7:
	MOVE.L	10(A6),A0
	MOVE.L	(A0),D0
	MOVE	G664_i_LZW(A4),D1
	EXT.L	D1
	CMP.L	D1,D0
	BLE.S	L8
	MOVE	G664_i_LZW(A4),4G673_i_LZ(A4)
	BRA.S	L9
L8:
	MOVE.L	10(A6),A0
	MOVE.L	(A0),D0
	MOVE	D0,4G673_i_LZ(A4)
L9:
	CMPI	#0,4G673_i_LZ(A4)
	BLE.S	L10
	PEA	G667_ac_LZ(A4)
	MOVE	4G673_i_LZ(A4),D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	4G673_i_LZ(A4),D1
	EXT.L	D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	4G673_i_LZ(A4),D1
	EXT.L	D1
	MOVE.L	10(A6),A0
	MOVE.L	(A0),D0
	SUB.L	D1,D0
	MOVE.L	D0,(A0)
	BRA.S	L11
L10:
	MOVE	#-1,D0
	BRA.S	L1
L11:
	CLR	3G672_i_LZ(A4)
	MOVE	4G673_i_LZ(A4),D0
	ASL	#3,D0
	MOVE	G664_i_LZW(A4),D1
	SUBQ	#1,D1
	SUB	D1,D0
	MOVE	D0,4G673_i_LZ(A4)
L2:
	MOVE	3G672_i_LZ(A4),D6
	MOVE	G664_i_LZW(A4),D5
	MOVE	D6,D0
	ASR	#3,D0
	EXT.L	D0
	ADDA.L	D0,A3
	AND	#7,D6
	MOVE.B	(A3)+,D7
	AND	#255,D7
	ASR	D6,D7
	MOVE	#8,D0
	SUB	D6,D0
	SUB	D0,D5
	MOVE	#8,D0
	SUB	D6,D0
	MOVE	D0,D6
	CMPI	#8,D5
	BLT.S	L12
	MOVE.B	(A3)+,D0
	AND	#255,D0
	ASL	D6,D0
	OR	D0,D7
	ADDQ	#8,D6
	SUBQ	#8,D5
L12:
	MOVE.B	(A3),D0
	LEA	2G671_auc_(A4),A0
	ADDA	D5,A0
	AND	#255,D0
	MOVE.B	(A0),D3
	AND	#255,D3
	AND	D3,D0
	ASL	D6,D0
	OR	D0,D7
	MOVE	G664_i_LZW(A4),D0
	ADD	D0,3G672_i_LZ(A4)
	MOVE	D7,D0
L1:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F496_xxxx_:/* global */
	LINK	A6,L$13
BSS SEG "bss"
6G674_i_LZ:
	.WORD	#2
CODE SEG "memory"
	MOVEM.L	A3/D7,-(A7)
	MOVE.B	9(A6),D7
	MOVE.L	10(A6),A0
	MOVE.L	(A0),A3
	MOVE	G663_B_LZW(A4),D0
L15:
	CMP	#0,D0
	BEQ.S	L16
	BRA.S	L18
L16:
	MOVE.B	D7,D0
	AND	#255,D0
	CMP	#144,D0
	BNE.S	L20
	MOVE	#1,G663_B_LZW(A4)
	BRA.S	L21
L20:
	MOVE.B	D7,D0
	AND	#255,D0
	MOVE	D0,6G674_i_LZ(A4)
	MOVE.B	D0,(A3)+
L21:
	MOVE.L	10(A6),A0
	MOVE.L	A3,(A0)
	BRA.S	L14
	BRA.S	L19
L18:
	CMP	#1,D0
	BEQ.S	L19
	BRA.S	L22
L19:
	MOVE.B	D7,D0
	BEQ.S	L24
	BRA.S	L25
L26:
	MOVE	6G674_i_LZ(A4),D0
	MOVE.B	D0,(A3)+
L25:
	SUBQ.B	#1,D7
	BNE.S	L26
L27:
	BRA.S	L28
L24:
	MOVE.B	#-112,(A3)+
L28:
	CLR	G663_B_LZW(A4)
	MOVE.L	10(A6),A0
	MOVE.L	A3,(A0)
	BRA.S	L14
L23:
L31:
L32:
	BRA.S	L31
L33:
	BRA.S	L29
L22:
	BRA.S	L23
L29:
L17:
L14:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$13:	.EQU	#0
F497_pzzz_:/* global */
	LINK	A6,L$34
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	18(A6),D0
	MOVE.L	D0,A3
	MOVE.L	18(A6),D0
	ADD.L	#10006,D0
	MOVE.L	D0,A2
	MOVE.L	22(A6),D0
	MOVE.L	D0,-8(A6)
	MOVE.L	D0,-4(A6)
	MOVE.L	14(A6),D0
	MOVE.L	D0,-12(A6)
	CLR	G663_B_LZW(A4)
	MOVE	#12,D6
	MOVE	#9,G664_i_LZW(A4)
	CLR	G669_B_LZW(A4)
	MOVE	#1,D0
	MOVE	#9,D1
	MOVE	D1,G664_i_LZW(A4)
	ASL	D1,D0
	SUBQ	#1,D0
	MOVE	D0,G665_i_LZW(A4)
	MOVE	#255,D6
	BRA.S	L36
L37:
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE	D6,D0
	MOVE.L	A2,A0
	ADDA	D6,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
L38:
	SUBQ	#1,D6
L36:
	CMPI	#0,D6
	BGE.S	L37
L39:
	MOVE	#257,G668_i_LZW(A4)
	PEA	10(A6)
	MOVE	8(A6),-(A7)
	JSR	F495_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	MOVE	D0,D7
	CMPI	#-1,D5
	BNE.S	L40
	MOVE.L	#-1,D0
	BRA	L35(PC)
L40:
	PEA	14(A6)
	MOVE	D7,D0
	EXT	D0
	MOVE	D0,-(A7)
	JSR	F496_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA	L41(PC)
L42:
	CMPI	#256,D6
	BNE.S	L44
	MOVE	#512,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,G669_B_LZW(A4)
	MOVE	#256,G668_i_LZW(A4)
	PEA	10(A6)
	MOVE	8(A6),-(A7)
	JSR	F495_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L45
	BRA	L43(PC)
L45:
L44:
	MOVE	D6,D4
	MOVE	D6,D0
	CMP	G668_i_LZW(A4),D0
	BLT.S	L46
	MOVE	D7,D0
	MOVE.L	-4(A6),A0
	ADDQ.L	#1,-4(A6)
	MOVE.B	D0,(A0)
	MOVE	D5,D6
L46:
	BRA.S	L47
L48:
	MOVE.L	A2,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	MOVE.L	-4(A6),A0
	ADDQ.L	#1,-4(A6)
	AND	#255,D0
	MOVE.B	D0,(A0)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D6
L47:
	CMPI	#256,D6
	BGE.S	L48
L49:
	MOVE.L	A2,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	MOVE.L	-4(A6),A0
	ADDQ.L	#1,-4(A6)
	MOVE.B	D0,(A0)
L50:
	PEA	14(A6)
	SUBQ.L	#1,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F496_xxxx_(PC)
	ADDQ.L	#6,A7
L51:
	MOVE.L	-4(A6),D0
	CMP.L	-8(A6),D0
	BGT.S	L50
L52:
	MOVE	G668_i_LZW(A4),D0
	MOVE	D0,D6
	CMP	G666_i_LZW(A4),D0
	BGE.S	L53
	MOVE	D5,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D6,A0
	MOVE.B	D0,(A0)
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,G668_i_LZW(A4)
L53:
	MOVE	D4,D5
L41:
	PEA	10(A6)
	MOVE	8(A6),-(A7)
	JSR	F495_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BGT	L42(PC)
L43:
	MOVE.L	14(A6),D0
	SUB.L	-12(A6),D0
L35:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$34:	.EQU	#-12
