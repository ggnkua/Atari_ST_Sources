BSS SEG "bss"
G630_i_Gra:/* global */
	.WORD	#2
G631_i_Gra:/* global */
	.WORD	#2
G632_ui_Gr:/* global */
	.WORD	#2
G633_l_Gra:/* global */
	.WORD	#4
G634_pui_G:/* global */
	.WORD	#4
G635_pui_G:/* global */
	.WORD	#4
G636_ppuc_:/* global */
	.WORD	#4
G637_pi_Na:/* global */
	.WORD	#4
G638_pi_De:/* global */
	.WORD	#4
G639_pi_De:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#-1,G640_i_Flo(A4)
BSS SEG "bss"
G640_i_Flo:/* global */
	.WORD	#2
G641_puc_C:/* global */
	.WORD	#4
G642_puc_G:/* global */
	.WORD	#4
G643_puc_F:/* global */
	.WORD	#4
G645_puc_H:/* global */
	.WORD	#4
G646_puc_A:/* global */
	.WORD	#4
G647_l_Unr:/* global */
	.WORD	#4
G648_l_Ava:/* global */
	.WORD	#4
G649_puc_G:/* global */
	.WORD	#4
G650_puc_G:/* global */
	.WORD	#4
G651_puc_C:/* global */
	.WORD	#4
G652_puc_A:/* global */
	.WORD	#4
G653_l_Ava:/* global */
	.WORD	#4
G654_B_Gra:/* global */
	.WORD	#2
G655_ppuc_:/* global */
	.WORD	#4
G656_l_Ava:/* global */
	.WORD	#4
G657_puc_F:/* global */
	.WORD	#4
G658_puc_F:/* global */
	.WORD	#4
G659_puc_L:/* global */
	.WORD	#4
G660_puc_F:/* global */
	.WORD	#4
G661_B_Lar:/* global */
	.WORD	#2
G662_l_Las:/* global */
	.WORD	#4
CODE SEG "memory"
F467_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	#2,D6
	MOVE	G632_ui_Gr(A4),D1
	ASL	#2,D1
	ADD	D1,D6
	AND.L	#65535,D6
	CLR	D5
	BRA.S	L2
L3:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	ADD.L	D0,D6
L4:
	ADDQ	#1,D5
L2:
	MOVE	D5,D0
	CMP	D7,D0
	BCS.S	L3
L5:
	MOVE.L	D6,D0
L1:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F468_ozzz_:/* global */
	LINK	A6,L$6
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L8
	ADDQ.L	#1,D7
L8:
	MOVE	12(A6),D0
	BEQ.S	L9
	MOVE.L	G653_l_Ava(A4),D0
	CMP.L	D7,D0
	BLT.S	L9
	MOVE.L	D7,D0
	SUB.L	D0,G653_l_Ava(A4)
	MOVE.L	G652_puc_A(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G652_puc_A(A4)
	MOVE.L	A3,D0
	BRA.S	L7
L9:
	MOVE.L	D7,D0
	CMP.L	G648_l_Ava(A4),D0
	BLE.S	L10
	MOVE	#40,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L10:
	MOVE.L	D7,D0
	SUB.L	D0,G648_l_Ava(A4)
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	D7,D0
	MOVE.L	D0,G646_puc_A(A4)
L7:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$6:	.EQU	#0
F469_rzzz_:/* global */
	LINK	A6,L$11
	MOVE.L	D7,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,D0
	AND.L	#1,D0
	BEQ.S	L13
	ADDQ.L	#1,D7
L13:
	MOVE.L	D7,D0
	ADD.L	D0,G648_l_Ava(A4)
	MOVE.L	D7,D0
	ADD.L	D0,G646_puc_A(A4)
L12:
	MOVE.L	(A7)+,D7
	UNLK	A6
	RTS
L$11:	.EQU	#0
F471_xxxx_:/* global */
	LINK	A6,L$14
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),-4(A6)
	CMPA.L	#0,A2
	BNE.S	L16
	CMPI.L	#0,-4(A6)
	BNE.S	L17
	CLR.L	G657_puc_F(A4)
	BRA.S	L18
L17:
	MOVE.L	-4(A6),G657_puc_F(A4)
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L18:
	BRA.S	L19
L16:
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	-4(A6),(A0)
	CMPI.L	#0,-4(A6)
	BEQ.S	L20
	MOVE.L	-4(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
L20:
L19:
L15:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$14:	.EQU	#-4
F472_xxxx_:/* global */
	LINK	A6,L$21
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A2
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L23
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	#0,D0
	MOVE.L	A2,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	BRA	L24(PC)
L23:
	MOVE.L	G657_puc_F(A4),A3
	MOVE.L	A2,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	MOVE.L	D7,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L25
	MOVE.L	A2,G657_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	BRA.S	L26
L25:
	CLR	D6
	BRA.S	L27
L28:
	MOVE.L	D7,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	CMP.L	(A0),D0
	BLT.S	L30
	MOVE.L	8(A6),D0
	MOVE.L	A2,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	A2,(A0)
	MOVE	#1,D6
	BRA.S	L29
L30:
	MOVE.L	A2,A3
L27:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	TST.L	D0
	BNE.S	L28
L29:
	MOVE	D6,D0
	BNE.S	L31
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	8(A6),(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	8(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	CLR.L	(A0)
L31:
L26:
L24:
L22:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$21:	.EQU	#-4
F473_xxxx_:/* global */
	LINK	A6,L$32
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	CLR	-4(A6)
	MOVE	12(A6),-2(A6)
	BRA.S	L34
L35:
	ADDQ	#1,-4(A6)
L34:
	MOVE	-2(A6),D0
	ASR	#1,D0
	MOVE	D0,-2(A6)
	BNE.S	L35
L36:
	MOVE	-4(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-2(A6)
	BRA	L37(PC)
L38:
	MOVE	#1,D0
	MOVE	-2(A6),D3
	ASL	D3,D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	ASL	#1,D0
	MOVE	D0,-8(A6)
	MOVE	-6(A6),D6
	BRA.S	L41
L42:
	MOVE	D6,D4
	MOVE	D4,D7
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
L45:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	CMP	12(A6),D0
	BCS.S	L48
	BRA.S	L47
L48:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	12(A6),D0
	BCC.S	L49
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L49
	ADDQ	#1,D5
L49:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L50
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L51
L50:
	BRA.S	L47
L51:
L46:
	BRA.S	L45
L47:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L43:
	ADDQ	#1,D6
L41:
	MOVE	D6,D0
	CMP	-8(A6),D0
	BLS.S	L42
L44:
L39:
	SUBQ	#1,-2(A6)
L37:
	CMPI	#0,-2(A6)
	BGE	L38(PC)
L40:
	MOVE	12(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-6(A6)
	BRA	L52(PC)
L53:
	MOVE	-6(A6),D4
	ASL.L	#1,D4
	MOVE.L	A3,A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	#0,D0
	MOVE	D0,D7
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	-6(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L56:
	MOVE	D7,D0
	ASL	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	MOVE	-6(A6),D1
	SUBQ	#1,D1
	CMP	D1,D0
	BLS.S	L59
	BRA.S	L58
L59:
	MOVE	D5,D0
	ADDQ	#1,D0
	CMP	-6(A6),D0
	BCC.S	L60
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCS.S	L60
	ADDQ	#1,D5
L60:
	MOVE	D4,D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	CMP	(A0),D0
	BCC.S	L61
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D7
	BRA.S	L62
L61:
	BRA.S	L58
L62:
L57:
	BRA.S	L56
L58:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L54:
	SUBQ	#1,-6(A6)
L52:
	CMPI	#1,-6(A6)
	BCC	L53(PC)
L55:
L33:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$32:	.EQU	#-8
F474_xxxx_:/* global */
	LINK	A6,L$63
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D7
	MOVE	8(A6),D5
	ASL.L	#1,D5
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE.L	D7,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D0,-2(A6)
	MOVE	-2(A6),D6
	EXT.L	D6
	ASL.L	#2,D6
	ASL.L	#8,D6
	BRA	L65(PC)
L66:
	MOVE	-2(A6),D0
	CMP	G640_i_Flo(A4),D0
	BEQ.S	L68
	MOVE	-2(A6),G640_i_Flo(A4)
	MOVE.L	G633_l_Gra(A4),D0
	SUB.L	D6,D0
	MOVE.L	D0,-8(A6)
	CMPI.L	#1024,D0
	BLE.S	L69
	MOVE.L	#1024,-8(A6)
L69:
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE.L	D6,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	G643_puc_F(A4),-(A7)
	MOVE.L	-8(A6),D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	-8(A6),D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
L68:
	MOVE.L	D7,D4
	SUB.L	D6,D4
	MOVE	#1024,D0
	SUB	D4,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	-4(A6),-(A7)
	MOVE.L	10(A6),-(A7)
	MOVE.L	G643_puc_F(A4),D0
	EXT.L	D4
	ADD.L	D4,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	SUB	-4(A6),D5
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,D7
	MOVE	-4(A6),D0
	EXT.L	D0
	ADD.L	D0,10(A6)
	ADDQ	#1,-2(A6)
	ADD.L	#1024,D6
L65:
	CMPI	#0,D5
	BGT	L66(PC)
L67:
L64:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$63:	.EQU	#-8
F475_ozzz_:/* global */
	LINK	A6,L$70
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),D7
	MOVE.L	A3,D0
	MOVE.L	D0,G651_puc_C(A4)
	MOVE.L	D0,G641_puc_C(A4)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,G645_puc_H(A4)
	MOVE.L	D0,G646_puc_A(A4)
	MOVE.L	D7,G648_l_Ava(A4)
	MOVE.L	16(A6),G652_puc_A(A4)
	MOVE.L	20(A6),G653_l_Ava(A4)
	MOVE	#1,-(A7)
	MOVE.L	#1024,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G643_puc_F(A4)
	MOVE	#1,-(A7)
	MOVE.L	#5100,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G655_ppuc_(A4)
	MOVE	#5100,-(A7)
	MOVE.L	G655_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G638_pi_De(A4)
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#730,-(A7)
	MOVE.L	G638_pi_De(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1,-(A7)
	MOVE.L	#1460,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G639_pi_De(A4)
	MOVE.L	#0,D0
	MOVE.L	D0,G657_puc_F(A4)
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G659_puc_L(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	#-1,G662_l_Las(A4)
L71:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$70:	.EQU	#0
F476_mzzz_:/* global */
	LINK	A6,L$72
	MOVE.L	G646_puc_A(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	CMPI.L	#370000,D0
	SGT	D0
	AND	#1,D0
	MOVE	D0,G661_B_Lar(A4)
	BEQ.S	L74
	JSR	F461_AA08_(PC)
L74:
	MOVE.L	G646_puc_A(A4),D0
	SUB.L	#10000,D0
	MOVE.L	D0,G642_puc_G(A4)
	MOVE	#1,G654_B_Gra(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	D0,G650_puc_G(A4)
	MOVE.L	D0,G649_puc_G(A4)
	MOVE.L	#10000,G648_l_Ava(A4)
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,G656_l_Ava(A4)
L73:
	UNLK	A6
	RTS
L$72:	.EQU	#0
F477_izzz_:/* global */
	LINK	A6,L$75
	MOVE	G631_i_Gra(A4),D0
	ADDQ	#1,G631_i_Gra(A4)
	TST	D0
	BEQ.S	L77
	BRA.S	L76
L77:
DATA SEG "s!"
s!:
	DATA 41 3A 5C 47 52 41 50 48 49 43 53 2E 44 41 54 00 
CODE SEG "memory"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G630_i_Gra(A4)
	CMPI	#0,G630_i_Gra(A4)
	BGE.S	L78
	MOVE	#41,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L78:
L76:
	UNLK	A6
	RTS
L$75:	.EQU	#0
F478_gzzz_:/* global */
	LINK	A6,L$79
	SUBQ	#1,G631_i_Gra(A4)
	BEQ.S	L81
	BRA.S	L80
L81:
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
L80:
	UNLK	A6
	RTS
L$79:	.EQU	#0
F479_izzz_:/* global */
	LINK	A6,L$82
	MOVEM.L	D7-D6,-(A7)
	CLR	G631_i_Gra(A4)
	JSR	F477_izzz_(PC)
	PEA	G632_ui_Gr(A4)
	MOVE.L	#2,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CMPI.L	#2,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L90
	MOVE	G632_ui_Gr(A4),D0
	ASL	#1,D0
	MOVE	D0,D6
L90:
	SNE	D0
	TST.B	D0
	BEQ.S	L89
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G634_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L89:
	TST.B	D0
	BEQ.S	L88
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G635_pui_G(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L88:
	TST.B	D0
	BEQ.S	L87
	MOVE.L	G634_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L87:
	TST.B	D0
	BEQ.S	L86
	MOVE.L	G635_pui_G(A4),-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	#63,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	MOVE	D6,D1
	AND.L	#65535,D1
	CMP.L	D1,D0
	SEQ	D0
	TST.B	D0
L86:
	TST.B	D0
	BEQ.S	L85
	MOVE	#1,-(A7)
	MOVE	D6,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G636_ppuc_(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L85:
	TST.B	D0
	BEQ.S	L84
	MOVE	#1,-(A7)
	MOVE	D6,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G637_pi_Na(A4)
	CMPI.L	#0,D0
	SNE	D0
	TST.B	D0
L84:
	AND	#1,D0
	MOVE	D0,D7
	MOVE	D7,D0
	BNE.S	L91
	BRA	L92(PC)
L91:
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	G636_ppuc_(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE.L	G637_pi_Na(A4),-(A7)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	SUBQ	#1,D6
	MOVE	D6,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,G633_l_Gra(A4)
	MOVE	#1,-(A7)
	MOVE.L	G635_pui_G(A4),A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G343_puc_G(A4)
	CMPI.L	#0,D0
	BNE.S	L93
	BRA.S	L94
L93:
	MOVE.L	G343_puc_G(A4),-(A7)
	CLR	-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L83
L94:
L92:
	MOVE	#42,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L83:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$82:	.EQU	#0
F480_AA07_:/* global */
	LINK	A6,L$95
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CMPI	#0,8(A6)
	BLT.S	L97
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L98
	BRA	L96(PC)
L98:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L99
L97:
	ANDI	#32767,8(A6)
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L100
	BRA	L96(PC)
L100:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L99:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
	NEG.L	D7
	MOVE.L	D7,D0
	ADD.L	D0,G656_l_Ava(A4)
	MOVE.L	A3,D5
	ADDQ.L	#6,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	MOVE.L	A3,D4
	ADDQ.L	#8,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#-1,D5
	BNE.S	L101
	CMPI	#-1,D4
	BNE.S	L102
	CLR.L	G658_puc_F(A4)
	CLR.L	G659_puc_L(A4)
	CLR.L	G660_puc_F(A4)
	BRA.S	L103
L102:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),G658_puc_F(A4)
	MOVE.L	G658_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L104
	MOVE.L	G658_puc_F(A4),G660_puc_F(A4)
L104:
L103:
	BRA.S	L105
L101:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D4,(A0)
	CMPI	#-1,D4
	BNE.S	L106
	MOVE.L	A2,G659_puc_L(A4)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L107
	CLR.L	G660_puc_F(A4)
L107:
	BRA.S	L108
L106:
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L109
	MOVE.L	A2,G660_puc_F(A4)
L109:
L108:
L105:
	MOVE.L	A3,D0
	CMP.L	G641_puc_C(A4),D0
	BEQ.S	L110
	MOVE.L	A3,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L110
	SUBA.L	D6,A3
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L110:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	CMP.L	G651_puc_C(A4),D0
	BNE.S	L111
	MOVE.L	A3,G651_puc_C(A4)
	BRA.S	L96
L111:
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D6
	CMPI.L	#0,D0
	BLE.S	L112
	MOVE.L	A2,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD.L	D6,D7
L112:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,D0
	ADD.L	D7,D0
	SUBQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE.L	D7,(A0)
	MOVE.L	A3,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
L96:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$95:	.EQU	#0
F481_xxxx_:/* global */
	LINK	A6,L$113
	BRA.S	L115
L116:
	CMPI.L	#0,G658_puc_F(A4)
	BNE.S	L118
	MOVE	#43,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L118:
	MOVE.L	G658_puc_F(A4),D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	(A0),-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L115:
	MOVE.L	G656_l_Ava(A4),D0
	CMP.L	8(A6),D0
	BLT.S	L116
L117:
L114:
	UNLK	A6
	RTS
L$113:	.EQU	#0
F482_xxxx_:/* global */
	LINK	A6,L$119
	MOVEM.L	A3-A2/D7-D5,-(A7)
	CMPI.L	#0,G657_puc_F(A4)
	BNE.S	L121
	BRA	L120(PC)
L121:
	MOVE.L	G641_puc_C(A4),D0
	MOVE.L	D0,A2
	MOVE.L	D0,A3
L122:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,D7
	CMPI.L	#0,D0
	BLE.S	L125
	ADDA.L	D7,A2
	BRA	L126(PC)
L125:
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	D0,D7
	MOVE.L	A2,D0
	CMP.L	A3,D0
	BEQ.S	L127
	MOVE.L	A2,D6
	ADD.L	#10,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	CMPI	#0,D6
	BLT.S	L128
	MOVE	D6,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L129
L128:
	MOVE	D6,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L129:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	D7,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G658_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L130
	MOVE.L	A3,G658_puc_F(A4)
L130:
	MOVE.L	G659_puc_L(A4),D0
	CMP.L	A2,D0
	BNE.S	L131
	MOVE.L	A3,G659_puc_L(A4)
L131:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A2,D0
	BNE.S	L132
	MOVE.L	A3,G660_puc_F(A4)
L132:
L127:
	ADDA.L	D7,A2
	ADDA.L	D7,A3
L126:
L123:
	MOVE.L	A2,D0
	CMP.L	G651_puc_C(A4),D0
	BNE	L122(PC)
L124:
	MOVE.L	A3,G651_puc_C(A4)
	CLR.L	G657_puc_F(A4)
L120:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$119:	.EQU	#0
F483_xxxx_:/* global */
	LINK	A6,L$133
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),D7
	MOVE.L	D7,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G651_puc_C(A4),D1
	SUB.L	D1,D0
	CMP.L	D7,D0
	BLT.S	L135
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L136(PC)
L135:
	MOVE.L	G657_puc_F(A4),D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BGE.S	L137
	JSR	F482_xxxx_(PC)
	MOVE.L	G651_puc_C(A4),A3
	MOVE.L	D7,D0
	ADD.L	D0,G651_puc_C(A4)
	BRA	L138(PC)
L137:
	MOVE.L	G657_puc_F(A4),A3
	CLR	D6
L139:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BNE.S	L142
	MOVE	#1,D6
	BRA.S	L143
L142:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	CMP.L	D7,D0
	BLT.S	L145
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A2
	CMPI.L	#0,D0
	BNE.S	L144
L145:
	MOVE.L	G657_puc_F(A4),A3
	MOVE	#1,D6
	BRA.S	L146
L144:
	MOVE.L	A2,A3
L146:
L143:
L140:
	MOVE	D6,D0
	BEQ.S	L139
L141:
	MOVE.L	A3,-(A7)
	JSR	F471_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.L	(A0),D5
	SUB.L	D7,D5
	CMPI.L	#24,D5
	BLT.S	L147
	MOVE.L	A3,D0
	ADD.L	D7,D0
	MOVE.L	D0,A2
	MOVE.L	D5,D0
	MOVE.L	A2,D1
	ADD.L	D5,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A2,-(A7)
	JSR	F472_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L148
L147:
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE.L	(A0),D7
L148:
L138:
L136:
	MOVE.L	D7,D0
	SUB.L	D0,G656_l_Ava(A4)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	D7,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D7,D1
	SUBQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE.L	D0,(A0)
	MOVE.L	A3,D0
L134:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$133:	.EQU	#0
F484_gzzz_:/* global */
	LINK	A6,L$149
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-14(A6)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F473_xxxx_(PC)
	ADDQ.L	#6,A7
	CLR.L	-4(A6)
	CLR	D7
	BRA	L151(PC)
L152:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L155
L156:
	MOVE	12(A6),D0
	SUBQ	#1,12(A6)
	SUB	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L155:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,D6
	CMP	12(A6),D0
	BGE.S	L158
	MOVE	D5,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L156
L158:
L157:
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L159
	ADDQ.L	#1,D4
L159:
	MOVE.L	D4,D0
	ADD.L	D0,-4(A6)
L153:
	ADDQ	#1,D7
L151:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L152(PC)
L154:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L160
	MOVE.L	G649_puc_G(A4),D0
	SUB.L	-4(A6),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
	BRA.S	L161
L160:
	MOVE.L	G642_puc_G(A4),D0
	MOVE.L	G641_puc_C(A4),D1
	SUB.L	D1,D0
	MOVE.L	D0,-8(A6)
L161:
	MOVE.L	G348_pl_Bi(A4),A0
	MOVE.L	-8(A6),32000(A0)
	MOVE.L	#19576,D0
	CMP.L	-8(A6),D0
	BLE.S	L162
	MOVE	#44,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L162:
	CLR	D7
	BRA.S	L163
L164:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L167
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L167:
L165:
	ADDQ	#1,D7
L163:
	CMPI	#730,D7
	BLT.S	L164
L166:
	MOVE	#0,D6
	MOVE	D6,D7
L168:
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	8(A6),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L171
L172:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	TST.L	D0
	BEQ.S	L174
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L175
	ADDQ.L	#1,D4
L175:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L174:
	ADDQ	#1,D6
L171:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L172
L173:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BEQ.S	L176
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L176:
L169:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L168(PC)
L170:
	BRA.S	L177
L178:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BEQ.S	L180
	MOVE	D6,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	CLR.L	(A0)
	MOVE	D6,D4
	ASL.L	#1,D4
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L181
	ADDQ.L	#1,D4
L181:
	MOVE.L	D4,D0
	NEG.L	D0
	MOVE.L	A3,D1
	ADD.L	D4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
L180:
	ADDQ	#1,D6
L177:
	MOVE	D6,D0
	CMP	G632_ui_Gr(A4),D0
	BCS.S	L178
L179:
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L182
	MOVE.L	G650_puc_G(A4),D4
	MOVE.L	G649_puc_G(A4),D1
	SUB.L	-4(A6),D1
	SUB.L	D1,D4
	CMPI.L	#0,D4
	BLE.S	L183
	MOVE.L	D4,-(A7)
	JSR	F481_xxxx_(PC)
	ADDQ.L	#4,A7
L183:
	JSR	F482_xxxx_(PC)
	MOVE.L	D4,D0
	SUB.L	D0,G656_l_Ava(A4)
L182:
	MOVE.L	G649_puc_G(A4),D0
	MOVE.L	D0,A2
	SUBQ.L	#2,D0
	MOVE.L	D0,A3
	BRA.S	L184
L185:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L187
	MOVE	D5,D0
	SUBQ	#2,D0
	EXT.L	D0
	ADDA.L	D0,A3
	BRA.S	L188
L187:
	MOVE.L	A3,D4
	MOVE	D5,D1
	ASL.L	#2,D1
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),D1
	SUB.L	D1,D4
	MOVE.L	D4,-24(A6)
	MOVE.L	#2,D4
	ADD.L	-24(A6),D4
	SUBA.L	D4,A2
	SUBA.L	D4,A3
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	CMP.L	A2,D0
	BEQ.S	L189
	MOVE.L	D4,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L189:
L188:
L184:
	MOVE.L	A3,D0
	CMP.L	G650_puc_G(A4),D0
	BGT.S	L185
L186:
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-12(A6)
	CLR	D7
	BRA	L190(PC)
L191:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L194
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	NOT	D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	8(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA	L195(PC)
L194:
	MOVE.L	A2,D0
	SUBQ.L	#2,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE	#2,D4
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	ADD	(A0),D4
	AND.L	#65535,D4
	MOVE.L	D4,D0
	AND.L	#1,D0
	BEQ.S	L196
	ADDQ.L	#1,D4
L196:
	SUBA.L	D4,A2
	MOVE	-14(A6),D0
	BNE.S	L197
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE	#1,-14(A6)
L197:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D5,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ.S	L198
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D5,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	-12(A6),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	BRA.S	L199
L198:
	MOVE.L	A2,-(A7)
	MOVE	D5,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L199:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
L195:
L192:
	ADDQ	#1,D7
L190:
	MOVE	D7,D0
	CMP	12(A6),D0
	BLT	L191(PC)
L193:
	MOVE	-14(A6),D0
	BEQ.S	L200
	JSR	F478_gzzz_(PC)
L200:
	MOVE.L	A2,G650_puc_G(A4)
	MOVE	G654_B_Gra(A4),D0
	BEQ.S	L201
	MOVE.L	G650_puc_G(A4),G642_puc_G(A4)
L201:
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L150:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$149:	.EQU	#-24
F485_xxxx_:/* global */
	LINK	A6,L$202
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	G313_ul_Ga(A4),G662_l_Las(A4)
	CLR.L	G660_puc_F(A4)
	MOVE.L	G659_puc_L(A4),D0
	MOVE.L	D0,A3
	CMPI.L	#0,D0
	BNE.S	L204
	BRA.S	L203
L204:
	BRA.S	L205
L206:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CLR	(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L208
	BRA.S	L203
L208:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
L205:
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	CMPI	#0,(A0)
	BNE.S	L206
L207:
L203:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$202:	.EQU	#0
F486_xxxx_:/* global */
	LINK	A6,L$209
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	CMPI.L	#0,G660_puc_F(A4)
	BNE.S	L211
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	CMPI.L	#0,G659_puc_L(A4)
	BNE.S	L212
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	A3,G658_puc_F(A4)
	BRA.S	L213
L212:
	MOVE.L	G659_puc_L(A4),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	G659_puc_L(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L214
	MOVE	D4,D6
	ASL.L	#1,D6
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	BRA.S	L215
L214:
	MOVE	D4,D6
	AND	#32767,D6
	ASL.L	#1,D6
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
L215:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L213:
	MOVE.L	A3,G659_puc_L(A4)
	BRA	L216(PC)
L211:
	MOVE.L	G660_puc_F(A4),D6
	ADDQ.L	#6,D6
	MOVE.L	D6,A0
	MOVE	(A0),D6
	MOVE.L	G660_puc_F(A4),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	CMPI	#-1,D6
	BEQ.S	L217
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE.L	A3,D1
	ADDQ.L	#8,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	BRA.S	L218
L217:
	MOVE.L	G660_puc_F(A4),D4
	ADD.L	#10,D4
	MOVE.L	D4,A0
	MOVE	(A0),D4
	CMPI	#0,D4
	BLT.S	L219
	MOVE	D4,D5
	ASL.L	#1,D5
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L220
L219:
	MOVE	D4,D5
	AND	#32767,D5
	ASL.L	#1,D5
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
L220:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A3,G658_puc_F(A4)
L218:
L216:
	MOVE.L	A3,G660_puc_F(A4)
L210:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$209:	.EQU	#0
F487_xxxx_:/* global */
	LINK	A6,L$221
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE.L	D0,-4(A6)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#0,D0
	BNE.S	L223
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L224
	MOVE.L	A3,G660_puc_F(A4)
	MOVE.L	A3,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	#1,(A0)
	MOVE.L	A3,D0
	BRA	L222(PC)
L224:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L225
	MOVE.L	A2,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L226
L225:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L226:
	MOVE	D7,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	-4(A6),D0
	BRA	L222(PC)
L223:
	MOVE	D4,D0
	ADDQ	#1,D0
	MOVE	D0,D4
	MOVE.L	A3,D1
	ADDQ.L	#4,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE.L	A3,D0
	CMP.L	G659_puc_L(A4),D0
	BNE.S	L227
	MOVE.L	A3,D0
	BRA	L222(PC)
L227:
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L228
	MOVE.L	A3,D0
	BRA	L222(PC)
L228:
	MOVE.L	A3,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L229
	MOVE.L	A2,D0
	MOVE.L	D0,G660_puc_F(A4)
	MOVE.L	D0,G658_puc_F(A4)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L230
L229:
	MOVE.L	G660_puc_F(A4),D0
	CMP.L	A3,D0
	BNE.S	L231
	MOVE.L	A2,G660_puc_F(A4)
L231:
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
L230:
L232:
	MOVE.L	A2,A3
	MOVE	D5,D6
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L235
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	-4(A6),D0
	MOVE.L	D0,G659_puc_L(A4)
	BRA.S	L222
L235:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	ADDQ.L	#4,D0
	MOVE.L	D0,A0
	MOVE	(A0),D0
	CMP	D4,D0
	BCS.S	L236
	MOVE.L	A3,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D6,(A0)
	MOVE.L	-4(A6),D0
	ADDQ.L	#8,D0
	MOVE.L	D0,A0
	MOVE	D5,(A0)
	MOVE.L	A2,D0
	ADDQ.L	#6,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE.L	-4(A6),D0
	BRA.S	L222
L236:
L233:
	MOVE	#1,D0
	BNE	L232(PC)
L234:
L222:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$221:	.EQU	#-4
F488_bzzz_:/* global */
	LINK	A6,L$237
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	10(A6),A3
	MOVE	8(A6),D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
L238:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$237:	.EQU	#0
F489_ayzz_:/* global */
	LINK	A6,L$239
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#-32768,D0
	BEQ.S	L241
	MOVE	D7,D0
	AND	#32767,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D0
	BRA	L240(PC)
L241:
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L242
	JSR	F485_xxxx_(PC)
L242:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L243
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	ADD.L	#12,D0
	BRA	L240(PC)
L243:
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G636_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A2
	MOVE.L	A2,D5
	MOVE.L	D5,A0
	MOVE	(A0),D5
	ASR	#1,D5
	MOVE.L	A2,D1
	ADDQ.L	#2,D1
	MOVE.L	D1,A0
	MULS	(A0),D5
	MOVE	D5,-10(A6)
	MOVE	#16,D5
	ADD	-10(A6),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L245:
L244:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L245
L246:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G637_pi_Na(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE.L	A3,D0
	ADD.L	#10,D0
	MOVE.L	D0,A0
	MOVE	D7,(A0)
	MOVE	D6,-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
	ADDA.L	#12,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE.L	A3,D0
L240:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$239:	.EQU	#-10
F490_lzzz_:/* global */
	LINK	A6,L$247
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	JSR	F477_izzz_(PC)
	MOVE	D7,D6
	AND	#-32768,D6
	AND	#32767,D7
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BEQ	L249(PC)
	CLR	-(A7)
	MOVE.L	#5004,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	CLR	-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	MOVE	D7,-(A7)
	JSR	F467_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	#66,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#10,A7
	CMPI.L	#0,D0
	SGE	D0
	AND	#1,D0
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G634_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	MOVE	G630_i_Gra(A4),-(A7)
	JSR	F497_pzzz_(PC)
	ADDA	#18,A7
	MOVE	#1,G297_B_Dra(A4)
	MOVE.L	#5004,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L250
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L250:
	BRA.S	L251
L249:
	MOVE	D6,D0
	BEQ.S	L252
	MOVE.L	A3,D0
	BRA.S	L253
L252:
	MOVE.L	G296_puc_B(A4),D0
L253:
	MOVE.L	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F474_xxxx_(PC)
	ADDQ.L	#6,A7
L251:
	MOVE	D6,D0
	BNE.S	L254
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	MOVE	#1,G297_B_Dra(A4)
L254:
	JSR	F478_gzzz_(PC)
L248:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$247:	.EQU	#0
F491_xzzz_:/* global */
	LINK	A6,L$255
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	G313_ul_Ga(A4),D0
	CMP.L	G662_l_Las(A4),D0
	BEQ.S	L257
	JSR	F485_xxxx_(PC)
L257:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BEQ.S	L258
	MOVE	D6,-(A7)
	JSR	F487_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D0
	BRA.S	L256
L258:
	MOVE	#16,D5
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	ADD	(A0),D5
	AND.L	#65535,D5
	MOVE.L	D5,-(A7)
	JSR	F483_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	CLR	D6
L260:
L259:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	CMPI.L	#0,(A0)
	BNE.S	L260
L261:
	SUBQ	#1,D6
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	A3,(A0)
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE.L	A3,D1
	ADD.L	#10,D1
	MOVE.L	D1,A0
	MOVE	D0,(A0)
	MOVE	#0,D0
L256:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$255:	.EQU	#0
F492_mzzz_:/* global */
	LINK	A6,L$262
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#2,D0
	MOVE.L	G655_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	ADD.L	#12,D0
L263:
	UNLK	A6
	RTS
L$262:	.EQU	#0
F493_hzzz_:/* global */
	LINK	A6,L$264
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G638_pi_De(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F486_xxxx_(PC)
	ADDQ.L	#2,A7
L265:
	UNLK	A6
	RTS
L$264:	.EQU	#0
F494_ozzz_:/* global */
	LINK	A6,L$266
	MOVE	8(A6),D0
	ASL.L	#1,D0
	MOVE.L	G635_pui_G(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L267:
	UNLK	A6
	RTS
L$266:	.EQU	#0
