BSS SEG "bss"
G397_i_Mov:/* global */
	.WORD	#2
G398_i_Mov:/* global */
	.WORD	#2
G399_ui_Mo:/* global */
	.WORD	#2
G400_i_Mov:/* global */
	.WORD	#2
G401_ui_Mo:/* global */
	.WORD	#2
G402_B_Use:/* global */
	.WORD	#2
CODE SEG "timeline"
F262_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	2(A3),D6
	AND	#3072,D6
	LSR	#2,D6
	LSR	#8,D6
	MOVE	14(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F147_aawz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	MOVE	2(A3),D0
	AND	#4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-6(A6)
	BEQ.S	L2
	MOVE	D6,D4
	BRA.S	L3
L2:
	MOVE	D5,D4
	ADD	D6,D4
	AND	#3,D4
L3:
	MOVE	14(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F145_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-2(A6)
	CMPI	#255,D0
	BEQ	L4(PC)
	MOVE	-2(A6),-8(A6)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#3,D0
	MOVE	D0,-10(A6)
	MOVE	#4,D0
	ADD	D4,D0
	SUB	D5,D0
	AND	#3,D0
	MOVE	D0,-12(A6)
	CLR	-4(A6)
	BRA.S	L5
L6:
	MOVE	-6(A6),D0
	BEQ.S	L9
	MOVE	D6,D0
	BRA.S	L10
L9:
	MOVE	D5,D0
	ADD	D6,D0
	AND	#3,D0
L10:
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D4,-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D4
	CMPI	#0,-10(A6)
	BNE.S	L11
	MOVE	-6(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-12(A6)
	BEQ.S	L11
	MOVE	D6,-12(A6)
L11:
	MOVE	-12(A6),D0
	BEQ.S	L12
	MOVE	-8(A6),D0
	ADD	-12(A6),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F178_aazz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-2(A6)
L12:
	MOVE	D5,D0
	LSR	#2,D0
	MOVE	D0,D5
	MOVE	-8(A6),D0
	LSR	#2,D0
	MOVE	D0,-8(A6)
L7:
	ADDQ	#1,-4(A6)
L5:
	MOVE	-4(A6),D0
	MOVE	14(A2),D1
	AND	#96,D1
	LSR	#5,D1
	CMP	D1,D0
	BLS	L6(PC)
L8:
L4:
	MOVE	14(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F148_aayz_(PC)
	ADDQ.L	#8,A7
	MOVE	14(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F146_aczz_(PC)
	ADDQ.L	#8,A7
	MOVE	14(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L13
	MOVE	14(A2),D0
	AND	#15,D0
	CMPI	#6,D0
	BNE.S	L13
	MOVE.B	5(A2),D0
	AND	#255,D0
	ADDQ	#2,D0
	BRA.S	L1
L13:
	MOVE	#1,D0
L1:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-12
F263_xxxx_:/* global */
	LINK	A6,L$14
	MOVEM.L	D7-D5,-(A7)
	MOVE	12(A6),D7
	MOVE	G400_i_Mov(A4),D6
	MOVE.L	8(A6),A0
	MOVE	2(A0),D5
	AND	#3072,D5
	LSR	#2,D5
	LSR	#8,D5
	MOVE.L	8(A6),A0
	MOVE	2(A0),D0
	AND	#4096,D0
	LSR	#4,D0
	LSR	#8,D0
	BEQ.S	L16
	MOVE	D5,D6
	BRA.S	L17
L16:
	MOVE	D6,D0
	ADD	D5,D0
	AND	#3,D0
	MOVE	D0,D6
	MOVE	D7,D0
	AND	#16383,D0
	MOVE	D7,D1
	LSR	#6,D1
	LSR	#8,D1
	ADD	D5,D1
	AND	#3,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,D7
L17:
	MOVE	D6,G400_i_Mov(A4)
	MOVE	D7,D0
L15:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$14:	.EQU	#0
F264_avzz_:/* global */
	LINK	A6,L$18
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#4,D0
	BNE.S	L20
	MOVE	D7,-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#32,D0
	BRA.S	L19
L20:
	CMPI	#14,D6
	BNE.S	L21
	MOVE	#1,D0
	BRA.S	L19
L21:
	MOVE	#0,D0
L19:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$18:	.EQU	#0
F265_xxxx_:/* global */
	LINK	A6,L$22
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#5,D0
	MOVE	14(A6),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE	16(A6),D0
	BEQ.S	L24
	MOVE	#61,D0
	BRA.S	L25
L24:
	MOVE	#60,D0
L25:
	MOVE.B	D0,-6(A6)
	CLR.B	-5(A6)
	MOVE	10(A6),D0
	MOVE.B	D0,-4(A6)
	MOVE	12(A6),D0
	MOVE.B	D0,-3(A6)
	MOVE	D7,-2(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L23:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$22:	.EQU	#-10
F266_xxxx_:/* global */
	LINK	A6,L$26
	MOVEM.L	A3/D7-D4,-(A7)
	CLR	-4(A6)
	MOVE	#4,-(A7)
	PEA	-16(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CMPI	#-1,16(A6)
	BNE.S	L28
	MOVE	#-2,-2(A6)
	CLR	D5
	BRA.S	L29
L30:
	MOVE	D5,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#0,D0
	BLT.S	L33
	MOVE	D5,D0
	ADDQ	#1,D0
	MOVE	D5,D1
	LEA	-16(A6),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L33:
L31:
	ADDQ	#1,D5
L29:
	CMPI	#4,D5
	BCS.S	L30
L32:
	BRA.S	L34
L28:
	MOVE	#-1,-2(A6)
	MOVE	16(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE	#0,D0
	MOVE	D0,D4
	BRA.S	L35
L36:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	6(A3),A0
	ADDA	D0,A0
	OR	(A0),D4
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L39
	MOVE	D5,D0
	ADDQ	#1,D0
	MOVE	D5,D1
	LEA	-16(A6),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L39:
L37:
	ADDQ	#1,D5
L35:
	CMPI	#4,D5
	BCS.S	L36
L38:
	MOVE	D4,D0
	BNE.S	L40
	MOVE	#0,D0
	BRA	L27(PC)
L40:
L34:
	CMPI	#0,12(A6)
	BLT	L41(PC)
	MOVE	8(A6),D0
	SUB	12(A6),D0
	MOVE	D0,D4
	CMPI	#0,D0
	BGE.S	L42
	MOVE	D4,D0
	NEG	D0
	BRA.S	L43
L42:
	MOVE	D4,D0
L43:
	MOVE	10(A6),D1
	SUB	14(A6),D1
	MOVE	D1,D4
	CMPI	#0,D1
	BGE.S	L44
	MOVE	D4,D1
	NEG	D1
	BRA.S	L45
L44:
	MOVE	D4,D1
L45:
	ADD	D1,D0
	CMPI	#1,D0
	BNE	L41(PC)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F228_uzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	MOVE	D5,D4
	ADDQ	#1,D4
	AND	#3,D4
	MOVE	#4,-(A7)
	PEA	-12(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	ADDQ	#3,D1
	AND	#3,D1
	LEA	-12(A6),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
	BEQ.S	L46
	MOVE	#1,-4(A6)
L46:
	LEA	-16(A6),A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	MOVE	D4,D1
	ADDQ	#1,D1
	AND	#3,D1
	LEA	-12(A6),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
	BEQ.S	L47
	MOVE	#1,-4(A6)
L47:
	MOVE	D5,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	BNE.S	L48
	MOVE	D5,D0
	ADDQ	#3,D0
	AND	#3,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	LEA	-16(A6),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
L48:
	LEA	-16(A6),A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	BNE.S	L49
	MOVE	D4,D0
	ADDQ	#1,D0
	AND	#3,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	LEA	-16(A6),A0
	ADDA	D4,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
L49:
L41:
	MOVE	8(A6),-6(A6)
	MOVE	10(A6),-8(A6)
L4T266_017_:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA	L50(PC)
L51:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#14,D0
	BNE.S	L54
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+56(A4),D1
	ASL.L	#3,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	6(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#48,D0
	BEQ.S	L54
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	BEQ.S	L54
	MOVE	D7,-(A7)
	MOVE	D5,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F217_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L54
	MOVE	D7,-(A7)
	JSR	F214_pzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#2,G364_i_Cre(A4)
	BNE.S	L55
	MOVE	#1,D0
	BRA.S	L27
L55:
	BRA	L4T266_017_(PC)
L54:
L52:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L50:
	CMPI	#-2,D7
	BNE	L51(PC)
L53:
	MOVE	-4(A6),D0
	BEQ.S	L56
	MOVE	12(A6),D0
	MOVE	D0,-6(A6)
	ADDQ	#1,D0
	ASL	#8,D0
	OR	D0,8(A6)
	MOVE	14(A6),D0
	MOVE	D0,-8(A6)
	ASL	#8,D0
	OR	D0,10(A6)
	MOVE	#4,-(A7)
	PEA	-16(A6)
	PEA	-12(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	-4(A6)
	BRA	L4T266_017_(PC)
L56:
	MOVE	#0,D0
L27:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$26:	.EQU	#-16
F267_dzzz_:/* global */
	LINK	A6,L$57
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	#-1,D4
	CLR	-2(A6)
	CLR	-14(A6)
	CLR	-16(A6)
	CLR	-18(A6)
	CLR	-20(A6)
	CLR	-22(A6)
	CLR	-24(A6)
	CLR	-26(A6)
	CMPI	#-1,D7
	BEQ.S	L59
	MOVE	D7,D4
	AND	#15360,D4
	LSR	#2,D4
	LSR	#8,D4
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-10(A6)
	MOVE	D7,-(A7)
	JSR	F264_avzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
L59:
	CMPI	#0,10(A6)
	BLT.S	L60
	CMPI	#-1,D7
	BEQ.S	L61
	CMPI	#4,D4
	BNE.S	L60
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L60
L61:
	MOVE	D7,-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F266_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L62
	MOVE	#1,D0
	BRA	L58(PC)
L62:
L60:
	CMPI	#0,14(A6)
	BLT	L63(PC)
	MOVE	G272_i_Cur(A4),D0
	MOVE	D0,-6(A6)
	MOVE	D0,-4(A6)
	MOVE	-4(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L64
	CMPI	#0,10(A6)
	SGE	D0
	TST.B	D0
L64:
	AND	#1,D0
	MOVE	D0,-16(A6)
	CMPI	#-1,D7
	BNE.S	L65
	MOVE	14(A6),G306_i_Par(A4)
	MOVE	16(A6),G307_i_Par(A4)
	MOVE	#2,-12(A6)
	MOVE	G423_i_Inv(A4),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-20(A6)
	MOVE	G308_i_Par(A4),-8(A6)
	BRA.S	L66
L65:
	CMPI	#4,D4
	BNE.S	L67
	MOVE	#1,-12(A6)
	BRA.S	L68
L67:
	MOVE	#3,-12(A6)
L68:
L66:
	CMPI	#14,D4
	BNE.S	L69
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+56(A4),D1
	ASL.L	#3,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	6(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#3072,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,G400_i_Mov(A4)
L69:
	MOVE	#1000,-30(A6)
	BRA	L70(PC)
L71:
	MOVE	14(A6),D6
	ASL.L	#2,D6
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D6,A0
	MOVE.L	(A0),A0
	ADDA	16(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE	D6,D0
	ASR	#5,D0
	MOVE	D0,D5
	CMPI	#5,D0
	BNE	L73(PC)
	MOVE	D6,D0
	AND	#8,D0
	BNE.S	L74
	BRA	L72(PC)
L74:
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#24576,D0
	LSR	#5,D0
	LSR	#8,D0
	CMPI	#1,D0
	BNE.S	L75
	CMPI	#4,D4
	BEQ.S	L75
	BRA	L72(PC)
L75:
	CMPI	#3,-12(A6)
	BEQ.S	L76
	MOVE	2(A2),D0
	AND	#24576,D0
	LSR	#5,D0
	LSR	#8,D0
	AND	-12(A6),D0
	BNE.S	L76
	BRA	L72(PC)
L76:
	MOVE	14(A6),D0
	MOVE	2(A2),D1
	AND	#31,D1
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L78
	MOVE	16(A6),D0
	MOVE	2(A2),D1
	AND	#992,D1
	LSR	#5,D1
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
L78:
	TST.B	D0
	BEQ.S	L77
	MOVE	-6(A6),D0
	MOVE	4(A2),D1
	AND	#-256,D1
	LSR	#8,D1
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
L77:
	AND	#1,D0
	MOVE	D0,-22(A6)
	MOVE	2(A2),D0
	AND	#31,D0
	MOVE	D0,14(A6)
	MOVE	2(A2),D0
	AND	#992,D0
	LSR	#5,D0
	MOVE	D0,16(A6)
	MOVE	2(A2),D0
	AND	#-32768,D0
	LSR	#7,D0
	LSR	#8,D0
	MOVE	D0,-26(A6)
	MOVE	4(A2),D0
	AND	#-256,D0
	LSR	#8,D0
	MOVE	D0,-6(A6)
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D7
	BNE.S	L79
	MOVE	14(A6),G306_i_Par(A4)
	MOVE	16(A6),G307_i_Par(A4)
	MOVE	2(A2),D0
	AND	#-32768,D0
	LSR	#7,D0
	LSR	#8,D0
	BEQ.S	L80
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L80:
	MOVE	G661_B_Lar(A4),D0
	AND	D0,-20(A6)
	MOVE	2(A2),D0
	AND	#4096,D0
	LSR	#4,D0
	LSR	#8,D0
	BEQ.S	L81
	MOVE	2(A2),D0
	AND	#3072,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-(A7)
	JSR	F284_czzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L82
L81:
	MOVE	G308_i_Par(A4),D0
	MOVE	2(A2),D1
	AND	#3072,D1
	LSR	#2,D1
	LSR	#8,D1
	ADD	D1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F284_czzz_(PC)
	ADDQ.L	#2,A7
L82:
	BRA	L83(PC)
L79:
	CMPI	#4,D4
	BNE.S	L84
	MOVE	2(A2),D0
	AND	#-32768,D0
	LSR	#7,D0
	LSR	#8,D0
	BEQ.S	L85
	MOVE	#1,-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L85:
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F262_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-14(A6)
	BRA.S	L86
L84:
	CMPI	#14,D4
	BNE.S	L87
	MOVE	D7,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F263_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	BRA.S	L88
L87:
	MOVE	2(A2),D0
	AND	#4096,D0
	LSR	#4,D0
	LSR	#8,D0
	BNE.S	L89
	CMPI	#-2,10(A6)
	BEQ.S	L89
	MOVE	D7,D1
	LSR	#6,D1
	LSR	#8,D1
	MOVE	2(A2),D0
	AND	#3072,D0
	LSR	#2,D0
	LSR	#8,D0
	ADD	D0,D1
	AND	#3,D1
	ASL	#6,D1
	ASL	#8,D1
	MOVE	D7,D0
	AND	#16383,D0
	OR	D1,D0
	MOVE	D0,D7
L89:
L88:
L86:
L83:
	MOVE	-22(A6),D0
	BEQ.S	L90
	BRA	L72(PC)
L90:
	BRA	L91(PC)
L73:
	CMPI	#2,D5
	BNE	L92(PC)
	MOVE	-2(A6),D0
	BNE	L92(PC)
	MOVE	D6,D0
	AND	#8,D0
	BEQ	L92(PC)
	MOVE	D6,D0
	AND	#1,D0
	BNE	L92(PC)
	MOVE	-20(A6),D0
	BEQ.S	L93
	MOVE	G402_B_Use(A4),D0
	BNE.S	L93
	MOVE	G661_B_Lar(A4),-20(A6)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
L93:
	PEA	16(A6)
	PEA	14(A6)
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F154_afzz_(PC)
	ADDA	#12,A7
	MOVE	D0,-6(A6)
	MOVE	-6(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D7
	BNE	L94(PC)
	MOVE	14(A6),G306_i_Par(A4)
	MOVE	16(A6),G307_i_Par(A4)
	CMPI	#0,G305_ui_Pa(A4)
	BLS	L95(PC)
	MOVE	G402_B_Use(A4),D0
	BEQ.S	L96
	MOVE	#0,D0
	MOVE	D0,D5
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L97
L98:
	MOVE	52(A3),D0
	BEQ.S	L101
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-40(A6)
	MOVE	272(A3),D0
	MULU	#25,D0
	AND.L	#65535,D0
	DIVU	-40(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
L101:
L99:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE.L	A3,D0
	ADDA	#800,A3
L97:
	MOVE	D5,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L98
L100:
	BRA.S	L102
L96:
	MOVE	#2,-(A7)
	MOVE	#48,-(A7)
	MOVE	#20,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L103
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#6,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L103:
L102:
L95:
	CLR	G402_B_Use(A4)
	BRA.S	L104
L94:
	CMPI	#4,D4
	BNE.S	L105
	MOVE	-4(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	MOVE	#20,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	MOVE	D0,-28(A6)
	MOVE	-6(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#2,-28(A6)
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-18(A6)
	BEQ.S	L106
	BRA	L72(PC)
L106:
	CMPI	#1,-28(A6)
	BNE.S	L107
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F187_czzz_(PC)
	ADDQ.L	#6,A7
L107:
L105:
L104:
	BRA	L108(PC)
L92:
	CMPI	#3,D5
	BNE	L109(PC)
	CMPI	#-1,D7
	BEQ	L109(PC)
	CMPI	#14,D4
	BEQ	L109(PC)
	MOVE	D6,D0
	AND	#4,D0
	BNE.S	L110
	PEA	16(A6)
	PEA	14(A6)
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F154_afzz_(PC)
	ADDA	#12,A7
	MOVE	D0,-6(A6)
	MOVE	-6(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L110:
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F155_ahzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-8(A6)
	MOVE	-8(A6),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	14(A6),D0
	ADD	D1,D0
	MOVE	D0,14(A6)
	MOVE	-8(A6),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	16(A6),D0
	ADD	D1,D0
	MOVE	D0,16(A6)
	MOVE	-8(A6),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-8(A6)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-28(A6)
	MOVE	-28(A6),D0
	SUB	-8(A6),D0
	ADDQ	#1,D0
	AND	#2,D0
	LSR	#1,D0
	ADD	-8(A6),D0
	AND	#3,D0
	MOVE	D0,-28(A6)
	MOVE	D7,D0
	AND	#16383,D0
	MOVE	-28(A6),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,D7
	BRA.S	L111
L109:
	BRA.S	L72
L111:
L108:
L91:
L70:
	SUBQ	#1,-30(A6)
	BNE	L71(PC)
L72:
	CMPI	#4,D4
	BNE.S	L112
	MOVE	-18(A6),D0
	BNE.S	L113
	MOVE	-6(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F139_aqzz_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L112
L113:
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F187_czzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F188_aozz_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#0,10(A6)
	BLT.S	L114
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
L114:
	MOVE	#1,D0
	BRA	L58(PC)
L112:
	MOVE	14(A6),G397_i_Mov(A4)
	MOVE	16(A6),G398_i_Mov(A4)
	MOVE	-6(A6),G399_ui_Mo(A4)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,G401_ui_Mo(A4)
	MOVE	-6(A6),D0
	CMP	-4(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L116
	MOVE	14(A6),D0
	CMP	10(A6),D0
	SEQ	D0
	TST.B	D0
L116:
	TST.B	D0
	BEQ.S	L115
	MOVE	16(A6),D0
	CMP	12(A6),D0
	SEQ	D0
	TST.B	D0
L115:
	AND	#1,D0
	MOVE	D0,-24(A6)
	MOVE	-24(A6),D0
	BEQ.S	L117
	CMPI	#-1,D7
	BNE.S	L118
	MOVE	G308_i_Par(A4),D0
	CMP	-8(A6),D0
	BNE.S	L119
	MOVE	#0,D0
	BRA	L58(PC)
L119:
	BRA.S	L120
L118:
	MOVE	G401_ui_Mo(A4),D0
	CMP	-10(A6),D0
	BNE.S	L121
	CMPI	#14,D4
	BEQ.S	L121
	MOVE	#0,D0
	BRA	L58(PC)
L121:
L120:
	BRA	L122(PC)
L117:
	CMPI	#-1,D7
	BNE	L123(PC)
	MOVE	G305_ui_Pa(A4),D0
	BEQ	L123(PC)
	MOVE	D6,-28(A6)
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	BRA.S	L124
L125:
	CLR	-(A7)
	JSR	F316_aizz_(PC)
	ADDQ.L	#2,A7
L126:
	SUBQ	#1,D6
L124:
	CMPI	#24,D6
	BGE.S	L125
L127:
	MOVE	D6,D0
	BEQ.S	L128
	MOVE.L	G313_ul_Ga(A4),D0
	SUB.L	G362_l_Las(A4),D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F317_adzz_(PC)
	ADDQ.L	#6,A7
L128:
	MOVE.L	G313_ul_Ga(A4),G362_l_Las(A4)
	ADDQ.B	#1,G407_s_Par+3210(A4)
	MOVE.B	G407_s_Par+3203(A4),D0
	BEQ.S	L129
	MOVE.B	G407_s_Par+3210(A4),G407_s_Par+3213(A4)
L129:
	MOVE	14(A6),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D1,A0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,(A0)
	OR	D3,(A0)
	MOVE	16(A6),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D1,A0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,(A0)
	OR	D3,(A0)
	MOVE	-6(A6),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D1,A0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,(A0)
	OR	D3,(A0)
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	CLR.B	(A0)
	MOVE	#-32744,-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F317_adzz_(PC)
	ADDQ.L	#6,A7
	MOVE	-28(A6),D6
L123:
	MOVE	-6(A6),D0
	CMP	-4(A6),D0
	BEQ.S	L130
	MOVE	-4(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L130:
L122:
L63:
	CMPI	#0,10(A6)
	BLT	L131(PC)
	CMPI	#-1,D7
	BNE.S	L132
	CLR	-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	#-1,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
	BRA.S	L133
L132:
	MOVE	-2(A6),D0
	BEQ.S	L134
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	BRA.S	L135
L134:
	CLR	-(A7)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L137
	MOVE	10(A6),D0
	CMP	G306_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
L137:
	TST.B	D0
	BEQ.S	L136
	MOVE	12(A6),D0
	CMP	G307_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
L136:
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
L135:
L133:
L131:
	CMPI	#0,14(A6)
	BLT	L138(PC)
	CMPI	#-1,D7
	BNE	L139(PC)
	MOVE	-6(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BEQ.S	L140
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F188_aozz_(PC)
	ADDQ.L	#8,A7
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
L140:
	MOVE	-6(A6),D0
	CMP	-4(A6),D0
	BNE.S	L141
	MOVE	#1,-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	#-1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
	BRA.S	L142
L141:
	MOVE	-4(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	-6(A6),G327_i_New(A4)
L142:
	BRA	L143(PC)
L139:
	CMPI	#4,D4
	BNE	L144(PC)
	MOVE	-6(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	-6(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L147
	MOVE	14(A6),D0
	CMP	G306_i_Par(A4),D0
	BNE.S	L147
	MOVE	16(A6),D0
	CMP	G307_i_Par(A4),D0
	BEQ.S	L146
L147:
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BEQ.S	L145
L146:
	MOVE	-4(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#0,10(A6)
	BLT.S	L148
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F181_czzz_(PC)
	ADDQ.L	#4,A7
L148:
	MOVE	-16(A6),D0
	BEQ.S	L149
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F184_ahzz_(PC)
	ADDQ.L	#2,A7
L149:
	MOVE	-26(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F265_xxxx_(PC)
	ADDA	#10,A7
	MOVE	#1,D0
	BRA	L58(PC)
L145:
	MOVE	-16(A6),D0
	BEQ.S	L150
	MOVE	-6(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L150
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F184_ahzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,-14(A6)
	BRA.S	L151
L150:
	MOVE	-6(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L152
	MOVE	-16(A6),D0
	BNE.S	L152
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F183_kzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,-14(A6)
L152:
L151:
	MOVE	-2(A6),D0
	BEQ.S	L153
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	BRA.S	L154
L153:
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
L154:
	MOVE	-14(A6),D0
	BNE.S	L156
	CMPI	#0,10(A6)
	BGE.S	L155
L156:
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F180_hzzz_(PC)
	ADDQ.L	#4,A7
L155:
	MOVE	-4(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#0,10(A6)
	BLT.S	L157
	CMPI	#1,-14(A6)
	BLS.S	L158
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	-14(A6),D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	-32(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F182_aqzz_(PC)
	ADDQ.L	#8,A7
	BRA.S	L159
L158:
	MOVE	-14(A6),D0
	BEQ.S	L160
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F181_czzz_(PC)
	ADDQ.L	#4,A7
L160:
L159:
L157:
	MOVE	-14(A6),D0
	BRA.S	L58
L144:
	MOVE	-6(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#14,D4
	BNE.S	L161
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	BRA.S	L162
L161:
	MOVE	#1,-(A7)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L164
	MOVE	14(A6),D0
	CMP	G306_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
L164:
	TST.B	D0
	BEQ.S	L163
	MOVE	16(A6),D0
	CMP	G307_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
L163:
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F276_qzzz_(PC)
	ADDA	#10,A7
L162:
	MOVE	-4(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L143:
L138:
L58:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$57:	.EQU	#-40
