BSS SEG "bss"
G369_ui_Ev:/* global */
	.WORD	#2
G370_ps_Ev:/* global */
	.WORD	#4
G371_pi_Ti:/* global */
	.WORD	#4
G372_ui_Ev:/* global */
	.WORD	#2
G373_ui_Fi:/* global */
	.WORD	#2
G374_l_Wat:/* global */
	.WORD	#4
CODE SEG "timeline"
F233_wzzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3/D7,-(A7)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G370_ps_Ev(A4)
	MOVE	#1,-(A7)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G371_pi_Ti(A4)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L2
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L3
L4:
	CLR.B	4(A3)
L5:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#10,A3
L3:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L4
L6:
	CLR	G372_ui_Ev(A4)
	CLR	G373_ui_Fi(A4)
	JSR	F256_xxxx_(PC)
L2:
L1:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F234_xxxx_:/* global */
	LINK	A6,L$7
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.L	(A3),D0
	AND.L	#16777215,D0
	MOVE.L	(A2),D1
	AND.L	#16777215,D1
	CMP.L	D1,D0
	SLT	D0
	TST.B	D0
	BNE.S	L10
	MOVE.L	(A3),D0
	AND.L	#16777215,D0
	MOVE.L	(A2),D1
	AND.L	#16777215,D1
	CMP.L	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D7
	BEQ.S	L11
	MOVE	4(A3),D0
	CMP	4(A2),D0
	SHI	D0
	TST.B	D0
L11:
	SNE	D0
	TST.B	D0
L10:
	TST.B	D0
	BNE.S	L9
	MOVE	D7,D0
	BEQ.S	L13
	MOVE	4(A3),D0
	CMP	4(A2),D0
	SEQ	D0
	TST.B	D0
L13:
	SNE	D0
	TST.B	D0
	BEQ.S	L12
	MOVE.L	A3,D0
	CMP.L	A2,D0
	SLE	D0
	TST.B	D0
L12:
	TST.B	D0
L9:
	AND	#1,D0
L8:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$7:	.EQU	#0
F235_bzzz_:/* global */
	LINK	A6,L$14
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,A3
	BRA.S	L16
L17:
	MOVE	(A3)+,D0
	CMP	D7,D0
	BNE.S	L20
	BRA.S	L19
L20:
L18:
	ADDQ	#1,D6
L16:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L17
L19:
	MOVE	D6,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L21
	CLR	D6
L21:
	MOVE	D6,D0
L15:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$14:	.EQU	#0
F236_pzzz_:/* global */
	LINK	A6,L$22
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D4
	CMPI	#1,D0
	BNE.S	L24
	BRA	L23(PC)
L24:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	-2(A6)
	BRA.S	L25
L26:
	MOVE	D7,D6
	SUBQ	#1,D6
	LSR	#1,D6
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L28
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	MOVE	#1,-2(A6)
	BRA.S	L25
L28:
	BRA.S	L27
L25:
	CMPI	#0,D7
	BHI.S	L26
L27:
	MOVE	-2(A6),D0
	BEQ.S	L29
	BRA	L3T236_011(PC)
L29:
	MOVE	D4,D0
	SUBQ	#1,D0
	SUBQ	#1,D0
	LSR	#1,D0
	MOVE	D0,D4
	BRA	L30(PC)
L31:
	MOVE	D7,D6
	ASL	#1,D6
	ADDQ	#1,D6
	MOVE	D6,D0
	ADDQ	#1,D0
	CMP	G372_ui_Ev(A4),D0
	BCC.S	L33
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L33
	ADDQ	#1,D6
L33:
	MOVE.L	A3,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F234_xxxx_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L34
	MOVE	D6,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D7
	BRA.S	L30
L34:
	BRA.S	L32
L30:
	MOVE	D7,D0
	CMP	D4,D0
	BLS	L31(PC)
L32:
L3T236_011:
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
L23:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$22:	.EQU	#-2
F237_rzzz_:/* global */
	LINK	A6,L$35
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	CLR.B	4(A0)
	MOVE	D7,D0
	CMP	G373_ui_Fi(A4),D0
	BCC.S	L37
	MOVE	D7,G373_ui_Fi(A4)
L37:
	SUBQ	#1,G372_ui_Ev(A4)
	MOVE	G372_ui_Ev(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L38
	BRA.S	L36
L38:
	MOVE	D7,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	D6,D0
	CMP	D5,D0
	BNE.S	L39
	BRA.S	L36
L39:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L36:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$35:	.EQU	#0
F238_pzzz_:/* global */
	LINK	A6,L$40
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	G372_ui_Ev(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L42
L5T238_001:
	MOVE	#0,D0
	BRA	L41(PC)
L42:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#5,D0
	BLT	L43(PC)
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#10,D0
	BGT	L43(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA	L44(PC)
L45:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#5,D0
	BLT.S	L48
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BGT.S	L48
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L49
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L49
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#6,D0
	BNE.S	L50
	MOVE.B	8(A2),D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BNE.S	L49
L50:
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L41(PC)
L49:
	BRA.S	L46
	BRA.S	L51
L48:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L52
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L52
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L52
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L53
	MOVE	#1,D0
	MOVE.B	9(A2),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A3)
L53:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L47
L52:
L51:
L46:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L44:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS	L45(PC)
L47:
	BRA	L54(PC)
L43:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#1,D0
	BNE	L55(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L56
L57:
	MOVE.L	(A3),D0
	CMP.L	(A2),D0
	BNE.S	L60
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L60
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L61
	MOVE.B	9(A2),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L62
	MOVE	#1,D0
	MOVE.B	9(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.B	D0,9(A2)
L62:
	MOVE	D7,D0
	BRA	L41(PC)
L61:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BNE.S	L63
	MOVE.B	9(A3),9(A2)
	MOVE	D7,D0
	BRA	L41(PC)
L63:
L60:
L58:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L56:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L57
L59:
	BRA.S	L64
L55:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L65
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L66
L67:
	MOVE	6(A3),D0
	CMP	6(A2),D0
	BNE.S	L70
	MOVE.L	(A3),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE.L	(A2),D1
	MOVE.L	#24,D3
	ASR.L	D3,D1
	CMP	D1,D0
	BNE.S	L70
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#1,D0
	BEQ.S	L72
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#10,D0
	BNE.S	L71
L72:
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L71:
L70:
L68:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A2,D0
	ADDA	#10,A2
L66:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L67
L69:
L65:
L64:
L54:
	LEA	(A3),A1
	MOVE	G373_ui_Fi(A4),D0
	MOVE	D0,D5
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
L73:
	MOVE	G373_ui_Fi(A4),D0
	CMP	G369_ui_Ev(A4),D0
	BNE.S	L76
	BRA.S	L75
L76:
	ADDQ	#1,G373_ui_Fi(A4)
L74:
	MOVE	G373_ui_Fi(A4),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L73
L75:
	MOVE	G372_ui_Ev(A4),D0
	ASL.L	#1,D0
	MOVE.L	G371_pi_Ti(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	G372_ui_Ev(A4),D0
	ADDQ	#1,G372_ui_Ev(A4)
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
L41:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$40:	.EQU	#0
F239_xxxx_:/* global */
	LINK	A6,L$77
	MOVE	D7,-(A7)
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MOVE	D0,D7
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	MOVE.L	8(A6),A0
	LEA	(A0),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L78:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$77:	.EQU	#0
F240_xxxx_:/* global */
	LINK	A6,L$79
	MOVE	G372_ui_Ev(A4),D0
	BEQ.S	L81
	MOVE.L	G371_pi_Ti(A4),A0
	MOVE	(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	AND.L	#16777215,D0
	MOVE.L	G313_ul_Ga(A4),D1
	CMP.L	D1,D0
	SLE	D0
	TST.B	D0
L81:
	SNE	D0
	AND	#1,D0
L80:
	UNLK	A6
	RTS
L$79:	.EQU	#0
F241_xxxx_:/* global */
	LINK	A6,L$82
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D4
	CMPI	#5,D0
	BNE.S	L84
	BRA	L83(PC)
L84:
	ADDQ.L	#1,(A3)
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#1,D5
	BNE	L85(PC)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#32,D0
	LSR	#5,D0
	MOVE	D0,-10(A6)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE	L86(PC)
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L86
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L86
	CMPI	#0,D4
	BEQ.S	L86
	CMPI	#0,G305_ui_Pa(A4)
	BLS.S	L87
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#0,D0
	MOVE.B	D0,(A2)
	MOVE	#2,-(A7)
	MOVE	#8,D0
	OR	-10(A6),D0
	BEQ.S	L89
	MOVE	#4,D0
	BRA.S	L90
L89:
	MOVE	#3,D0
L90:
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L88
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#18,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L88:
L87:
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L83(PC)
L86:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-6(A6)
	CMPI	#-2,D0
	BEQ	L91(PC)
	MOVE	-6(A6),-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-8(A6)
	AND	#64,D0
	BNE	L91(PC)
	MOVE	D4,D0
	MOVE	-10(A6),D1
	BEQ.S	L93
	MOVE	-8(A6),D1
	LSR	#7,D1
	AND	#3,D1
	BRA.S	L94
L93:
	MOVE	#1,D1
L94:
	CMP	D1,D0
	BCS.S	L92
	MOVE	#1,-(A7)
	MOVE	#5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	CMPI	#2,D0
	BEQ.S	L95
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L95:
	CMPI	#0,D4
	BNE.S	L96
	MOVE	#0,D0
	BRA.S	L97
L96:
	MOVE	D4,D0
	SUBQ	#1,D0
L97:
	MOVE	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#4,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L83
L92:
L91:
L85:
	CMPI	#0,D5
	BNE.S	L100
	CMPI	#0,D4
	BEQ.S	L99
L100:
	CMPI	#1,D5
	BNE.S	L98
	CMPI	#4,D4
	BNE.S	L98
L99:
	BRA.S	L83
L98:
	CMPI	#0,D5
	BNE.S	L101
	MOVE	#-1,D0
	BRA.S	L102
L101:
	MOVE	#1,D0
L102:
	ADD	D0,D4
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	D4,D0
	MOVE.B	D0,(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#2,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	CMPI	#0,D5
	BNE.S	L103
	CMPI	#0,D4
	BNE.S	L104
	BRA.S	L83
L104:
	BRA.S	L105
L103:
	CMPI	#4,D4
	BNE.S	L106
	BRA.S	L83
L106:
L105:
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L83:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$82:	.EQU	#-10
F242_xxxx_:/* global */
	LINK	A6,L$107
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D5
	AND	#255,D5
	CMPI	#2,D5
	BNE.S	L109
	MOVE.B	(A2),D5
	AND	#255,D5
	AND	#4,D5
	BEQ.S	L110
	MOVE	#1,D5
	BRA.S	L111
L110:
	MOVE	#0,D5
L111:
L109:
	CMPI	#1,D5
	BNE.S	L112
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L113
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L113
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L113
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L114
L113:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L115
	MOVE	D4,-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#64,D0
	BNE.S	L115
	ADDQ.L	#1,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L116
L115:
	ANDI.B	#-5,(A2)
L116:
L114:
	BRA.S	L117
L112:
	ORI.B	#4,(A2)
L117:
L108:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$107:	.EQU	#0
F243_xxxx_:/* global */
	LINK	A6,L$118
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#5,D0
	MOVE.B	D0,(A2)
L119:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$118:	.EQU	#0
F244_xxxx_:/* global */
	LINK	A6,L$120
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,D7
	CMPI	#5,D0
	BNE.S	L122
	BRA.S	L121
L122:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L123
	CMPI	#0,D7
	BNE.S	L124
	MOVE	#1,D0
	BRA.S	L125
L124:
	MOVE	#0,D0
L125:
	MOVE.B	D0,9(A3)
	BRA.S	L126
L123:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L127
	CMPI	#0,D7
	BNE.S	L128
	BRA.S	L121
L128:
	BRA.S	L129
L127:
	CMPI	#4,D7
	BNE.S	L130
	BRA.S	L121
L130:
L129:
L126:
	MOVE.B	#1,4(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L121:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$120:	.EQU	#0
F245_xxxx_:/* global */
	LINK	A6,L$131
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L133(PC)
L134:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D7
	CMPI	#2,D0
	BNE	L137(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D6
	AND	#1,D6
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L138
	MOVE	D6,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L139
L138:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L139:
	MOVE	D6,D0
	BNE.S	L140
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	BEQ.S	L140
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L140
	MOVE	-6(A6),D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L140
	MOVE	-8(A6),D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L140
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	PEA	G353_ac_St(A4)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L140:
	BRA	L141(PC)
L137:
	CMPI	#3,D7
	BNE	L142(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#6,D0
	BNE	L143(PC)
	MOVE	4(A2),D5
	AND	#1920,D5
	LSR	#7,D5
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L144
	JSR	F027_AA59_(PC)
	MOVE	D5,D1
	AND	#7,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D5
	BRA.S	L145
L144:
	SUBQ	#1,D5
L145:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BNE.S	L146
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-10(A6)
L146:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	2(A2),D0
	LSR	#7,D0
	MOVE	D0,-(A7)
	JSR	F185_auzz_(PC)
	ADDA	#12,A7
	MOVE	4(A2),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L147
	MOVE	#1,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L147:
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L148
	ANDI	#-128,2(A2)
	BRA.S	L149
L148:
	MOVE	6(A2),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#4,D0
	MOVE	D0,-10(A6)
	CMPI	#0,D0
	BEQ.S	L150
	ANDI	#-128,2(A2)
	CMPI	#127,-10(A6)
	BLS.S	L151
	MOVE	-10(A6),D0
	SUB	#126,D0
	ASL	#6,D0
	MOVE	D0,-10(A6)
L151:
	MOVE.B	#65,-16(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	CLR.B	-15(A6)
	MOVE	-6(A6),D0
	MOVE.B	D0,-14(A6)
	MOVE	-8(A6),D0
	MOVE.B	D0,-13(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L150:
L149:
L143:
L142:
L141:
L135:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L133:
	CMPI	#-2,D4
	BNE	L134(PC)
L136:
L132:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$131:	.EQU	#-20
F246_xxxx_:/* global */
	LINK	A6,L$152
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L154
L155:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L158
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#0,D0
	BNE.S	L159
	ORI	#6,2(A2)
	BRA.S	L153
L159:
L158:
L156:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L154:
	CMPI	#-1,D7
	BNE.S	L155
L157:
L153:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$152:	.EQU	#0
F247_xxxx_:/* global */
	LINK	A6,L$160
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.B	6(A2),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	MOVE.B	7(A2),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	MOVE.B	8(A2),D5
	AND	#255,D5
	MOVE	D5,D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-6(A6)
	MOVE	2(A3),D4
	AND	#127,D4
	MOVE	2(A3),D0
	LSR	#7,D0
	MOVE	D0,-8(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-12(A6)
	CMPI	#7,D4
	SEQ	D0
	TST.B	D0
	BNE.S	L163
	CMPI	#8,D4
	SEQ	D0
	TST.B	D0
L163:
	TST.B	D0
	BNE.S	L162
	CMPI	#14,D4
	SEQ	D0
	TST.B	D0
L162:
	AND	#1,D0
	MOVE	D0,-14(A6)
	CMPI	#8,D4
	BEQ.S	L165
	CMPI	#10,D4
	BNE.S	L164
L165:
	MOVE	-8(A6),D7
	ADD	#-128,D7
	MOVE	D7,D6
	BRA	L166(PC)
L164:
	CMPI	#14,D4
	BEQ.S	L168
	CMPI	#15,D4
	BNE	L167(PC)
L168:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L169
L170:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L173
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L174
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L173
L174:
	BRA.S	L172
L173:
L171:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L169:
	CMPI	#-1,D7
	BNE.S	L170
L172:
	CMPI	#-1,D7
	BNE.S	L175
	BRA	L161(PC)
L175:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-14(A6),D0
	BNE.S	L176
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA.S	L177
L178:
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-16(A6)
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L181
	MOVE	-16(A6),D0
	CMP	D5,D0
	BEQ.S	L182
	MOVE	-16(A6),D0
	MOVE	D5,D1
	ADDQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L181
L182:
	BRA.S	L180
L181:
L179:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L177:
	CMPI	#-1,D6
	BNE.S	L178
L180:
	CMPI	#-1,D6
	BNE.S	L183
	MOVE	#1,-14(A6)
	BRA.S	L184
L183:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L184:
L176:
	BRA.S	L185
L167:
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L186
	BRA	L161(PC)
L186:
	MOVE	-14(A6),D0
	BNE.S	L187
	MOVE	-8(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L187
	MOVE	#1,-14(A6)
L187:
L185:
L166:
	MOVE	-14(A6),D0
	BEQ.S	L188
	JSR	F028_a000_(PC)
	MOVE	D0,-26(A6)
	MOVE	-6(A6),D0
	ADD	-26(A6),D0
	AND	#3,D0
	MOVE	D0,-6(A6)
L188:
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	#1,G365_B_Cre(A4)
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	-14(A6),D0
	BNE.S	L189
	CLR	-(A7)
	MOVE	#100,-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	-6(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L189:
	CLR	G365_B_Cre(A4)
L161:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$160:	.EQU	#-26
F248_xxxx_:/* global */
	LINK	A6,L$190
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE.B	8(A3),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	BRA	L192(PC)
L193:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#2,D0
	BNE	L195(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L195
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L196
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
	BRA.S	L197
L196:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-4(A6),A0
	AND	#1,D0
	MOVE	D0,D3
	ANDI	#-2,2(A0)
	OR	D3,2(A0)
L197:
	BRA	L198(PC)
L195:
	CMPI	#3,D6
	BNE	L199(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D0,-6(A6)
	MOVE	2(A2),D4
	LSR	#7,D4
	CMPI	#6,-6(A6)
	BNE	L200(PC)
	CMPI	#0,D4
	BLS	L201(PC)
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L202
	CMPI	#511,D4
	BCC.S	L203
	ADDQ	#1,D4
L203:
	BRA.S	L204
L202:
	SUBQ	#1,D4
L204:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L205
	CMPI	#0,D4
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L206
	MOVE	#0,D0
	BRA.S	L207
L206:
	MOVE	#1,D0
L207:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L208
L205:
	CMPI	#0,D4
	BNE.S	L209
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L209:
L208:
L201:
	BRA	L210(PC)
L200:
	CMPI	#5,-6(A6)
	BNE	L211(PC)
	MOVE	#1,D5
	MOVE.B	8(A3),D3
	ASL	D3,D5
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L212
	MOVE	D4,D0
	AND	D5,D0
	BEQ.S	L213
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L214
L213:
	OR	D5,D4
L214:
	BRA.S	L215
L212:
	MOVE.B	9(A3),D0
	BEQ.S	L216
	MOVE	D5,D0
	NOT	D0
	AND	D0,D4
	BRA.S	L217
L216:
	OR	D5,D4
L217:
L215:
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D4,D1
	ASL	#7,D1
	OR	D1,D0
	MOVE	D0,2(A2)
	MOVE	D4,D5
	AND	#15,D5
	MOVE	D4,D1
	AND	#240,D1
	LSR	#4,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D5
	SNE	D5
	AND	#1,D5
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L218
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	D5,D0
	BEQ.S	L219
	MOVE	#0,D0
	BRA.S	L220
L219:
	MOVE	#1,D0
L220:
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L221
L218:
	MOVE	D5,D0
	BEQ.S	L222
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L222:
L221:
	BRA.S	L223
L211:
	CMPI	#7,-6(A6)
	BCS.S	L226
	CMPI	#10,-6(A6)
	BLS.S	L225
L226:
	CMPI	#14,-6(A6)
	BEQ.S	L225
	CMPI	#15,-6(A6)
	BNE.S	L224
L225:
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE.B	8(A3),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L224
	MOVE.L	A3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F247_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	4(A2),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L227
	ANDI	#-128,2(A2)
L227:
L224:
L223:
L210:
L199:
L198:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L192:
	CMPI	#-2,D7
	BNE	L193(PC)
L194:
	JSR	F271_xxxx_(PC)
L191:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$190:	.EQU	#-12
F249_xxxx_:/* global */
	LINK	A6,L$228
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L230
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L230
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L230
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	JSR	F296_aizz_(PC)
L230:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA	L231(PC)
L232:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	D4,D5
	AND	#15360,D5
	LSR	#2,D5
	LSR	#8,D5
	CMPI	#4,D5
	BCS.S	L234
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L234:
	CMPI	#14,D5
	BNE	L235(PC)
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	6(A3),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	G397_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,8(A2)
	OR	D3,8(A2)
	MOVE	G398_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,8(A2)
	OR	D3,8(A2)
	MOVE	G400_i_Mov(A4),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-3073,8(A2)
	OR	D3,8(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,6(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	BRA	L236(PC)
L235:
	CMPI	#15,D5
	BNE.S	L237
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A2
	BRA.S	L238
L239:
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#25,D0
	BNE.S	L242
	MOVE	8(A2),D0
	CMP	D4,D0
	BNE.S	L242
	MOVE	G397_i_Mov(A4),D0
	MOVE.B	D0,6(A2)
	MOVE	G398_i_Mov(A4),D0
	MOVE.B	D0,7(A2)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,8(A2)
	MOVE.L	(A2),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
L242:
L240:
	MOVE.L	A2,D0
	ADDA	#10,A2
	MOVE	D5,D0
	ADDQ	#1,D5
L238:
	MOVE	D5,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L239
L241:
L237:
L236:
	MOVE	-2(A6),D4
L231:
	CMPI	#-2,D4
	BNE	L232(PC)
L233:
L229:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$228:	.EQU	#-2
F250_xxxx_:/* global */
	LINK	A6,L$243
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L245
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L246
	MOVE	#1,D0
	BRA.S	L247
L246:
	MOVE	#0,D0
L247:
	MOVE.B	D0,9(A3)
L245:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L248
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L249
L248:
	ANDI.B	#-9,(A2)
L249:
L244:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$243:	.EQU	#0
F251_xxxx_:/* global */
	LINK	A6,L$250
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D7
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#2,D0
	BNE.S	L252
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L253
	MOVE	#1,D0
	BRA.S	L254
L253:
	MOVE	#0,D0
L254:
	MOVE.B	D0,9(A3)
L252:
	MOVE.B	9(A3),D0
	AND	#255,D0
	CMP	#0,D0
	BNE.S	L255
	ORI.B	#8,(A2)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F249_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L256
L255:
	ANDI.B	#-9,(A2)
L256:
L251:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$250:	.EQU	#0
F252_xxxx_:/* global */
	LINK	A6,L$257
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	CLR	-2(A6)
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
L19T252_001:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L260
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L260
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L259
L260:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BNE.S	L259
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#61,D0
	BNE.S	L261
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L261:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	8(A3),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	BRA	L258(PC)
L259:
	MOVE	-2(A6),D0
	BNE.S	L262
	MOVE	#1,-2(A6)
	MOVE	8(A3),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	4(A2),D0
	AND	#255,D0
	CMP	#23,D0
	BNE.S	L263
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L263
	JSR	F029_AA19_(PC)
L264:
	CMP	#0,D0
	BEQ.S	L265
	BRA.S	L267
L265:
	SUBQ	#1,D7
	BRA.S	L266
	BRA.S	L268
L267:
	CMP	#1,D0
	BEQ.S	L268
	BRA.S	L269
L268:
	ADDQ	#1,D7
	BRA.S	L266
	BRA.S	L270
L269:
	CMP	#2,D0
	BEQ.S	L270
	BRA.S	L271
L270:
	SUBQ	#1,D6
	BRA.S	L266
	BRA.S	L272
L271:
	CMP	#3,D0
	BEQ.S	L272
	BRA.S	L273
L272:
	ADDQ	#1,D6
L273:
L274:
L266:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F223_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L275
	BRA	L19T252_001(PC)
L275:
L263:
L262:
	ADDQ.L	#5,(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L258:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$257:	.EQU	#-2
F253_xxxx_:/* global */
	LINK	A6,L$276
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,44(A3)
	ANDI	#-9,48(A3)
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BEQ.S	L278
	MOVE.B	32(A3),D0
	AND	#255,D0
	LEA	G495_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	SUB	D0,64(A3)
L278:
	MOVE	52(A3),D0
	BEQ.S	L279
	MOVE.B	32(A3),D0
	AND	#255,D0
	CMP	#32,D0
	BNE.S	L280
	CMPI	#-1,212(A3)
	BNE.S	L280
	MOVE	#12,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L281
L20T253_002:
	CLR	-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L282
L281:
	CLR	D5
	BRA.S	L283
L284:
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F294_aozz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L287
	BRA.S	L20T253_002
L287:
L285:
	ADDQ	#1,D5
L283:
	CMPI	#3,D5
	BLT.S	L284
L286:
L282:
L280:
	ORI	#-32768,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L279:
	MOVE.B	#-1,32(A3)
L277:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$276:	.EQU	#0
F254_xxxx_:/* global */
	LINK	A6,L$288
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#-1,46(A3)
	MOVE	52(A3),D0
	BNE.S	L290
	BRA.S	L289
L290:
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L291
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	BRA.S	L292
L291:
	ORI	#128,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L292:
L289:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$288:	.EQU	#0
F255_xxxx_:/* global */
	LINK	A6,L$293
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
	MOVE.B	8(A3),D5
	AND	#255,D5
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-6(A6)
	MOVE.B	9(A3),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
L295:
	CMP	#2,D0
	BEQ.S	L296
	BRA.S	L298
L296:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	#-28,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	ADDQ.L	#5,(A3)
L22T255_002:
	SUBQ	#1,-4(A6)
	MOVE	-4(A6),D0
	MOVE.B	D0,9(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L297(PC)
	BRA.S	L299
L298:
	CMP	#1,D0
	BEQ.S	L299
	BRA	L300(PC)
L299:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L302
L303:
	MOVE	D4,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	D5,D0
	BNE.S	L306
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#10,D0
	BNE.S	L306
	MOVE	D4,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#147,-2(A6)
	BNE.S	L307
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-6(A6),D0
	BNE.S	L308
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	ADDQ.L	#1,(A3)
	BRA	L22T255_002(PC)
L308:
L307:
L306:
L304:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L302:
	CMPI	#-2,D4
	BNE.S	L303
L305:
	BRA.S	L297
	BRA.S	L301
L300:
	CMP	#0,D0
	BEQ.S	L301
	BRA.S	L309
L301:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F283_azzz_(PC)
	ADDQ.L	#2,A7
L309:
L310:
L297:
L294:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$293:	.EQU	#-6
F256_xxxx_:/* global */
	LINK	A6,L$311
	MOVE.B	#53,-6(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#300,D0
	MOVE.L	D0,G374_l_Wat(A4)
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L312:
	UNLK	A6
	RTS
L$311:	.EQU	#-10
F257_xxxx_:/* global */
	LINK	A6,L$313
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	6(A3),D0
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L315
	BRA.S	L314
L315:
	CMPI	#0,D6
	SLT	D5
	AND	#1,D5
	BEQ.S	L316
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
L316:
	MOVE	D6,D7
	SUBQ	#1,D7
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G039_ai_Gr(A4),A0
	ADDA	D1,A0
	SUB	(A0),D0
	MOVE	D0,D6
	MOVE	D5,D0
	BEQ.S	L317
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,D6
	MOVE	D7,D0
	NEG	D0
	MOVE	D0,D7
L317:
	MOVE	D6,D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	D7,D0
	BEQ.S	L318
	MOVE.B	#70,-6(A6)
	MOVE	D7,-4(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#4,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	CLR.B	-5(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L318:
L314:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$313:	.EQU	#-10
F258_xxxx_:/* global */
	LINK	A6,L$319
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L321
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	BRA.S	L320
L321:
	MOVE	#0,D0
L320:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$319:	.EQU	#0
F259_xxxx_:/* global */
	LINK	A6,L$322
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L324
	BRA.S	L323
L324:
	MOVE	D6,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L325
	BRA.S	L323
L325:
	MOVE	#7,D5
	BRA.S	L326
L327:
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F258_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L330
	BRA.S	L323
L330:
L328:
	ADDQ	#1,D5
L326:
	CMPI	#9,D5
	BLS.S	L327
L329:
L323:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$322:	.EQU	#0
F260_pzzz_:/* global */
	LINK	A6,L$331
	MOVE	D7,-(A7)
	CLR	D7
	BRA.S	L333
L334:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L335:
	ADDQ	#1,D7
L333:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L334
L336:
	JSR	F293_ahzz_(PC)
L332:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$331:	.EQU	#0
F261_hzzz_:/* global */
	LINK	A6,L$337
	MOVEM.L	A3/D7,-(A7)
	BRA	L339(PC)
L340:
	LEA	-10(A6),A0
	MOVE.L	A0,A3
	MOVE.L	A3,-(A7)
	JSR	F239_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	-10(A6),D0
	MOVE.L	#24,D3
	ASR.L	D3,D0
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.B	-6(A6),D7
	AND	#255,D7
	CMPI	#28,D7
	BLS.S	L342
	CMPI	#42,D7
	BCC.S	L342
	MOVE.B	-2(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
	BRA	L343(PC)
L342:
	MOVE	D7,D0
L344:
	CMP	#48,D0
	BEQ.S	L345
L347:
	CMP	#49,D0
	BEQ.S	L345
	BRA.S	L348
L345:
	MOVE.L	A3,-(A7)
	JSR	F219_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L349
L348:
	CMP	#1,D0
	BEQ.S	L349
	BRA.S	L350
L349:
	MOVE.L	A3,-(A7)
	JSR	F241_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L351
L350:
	CMP	#25,D0
	BEQ.S	L351
	BRA.S	L352
L351:
	MOVE.L	A3,-(A7)
	JSR	F220_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L353
L352:
	CMP	#7,D0
	BEQ.S	L353
	BRA.S	L354
L353:
	MOVE.L	A3,-(A7)
	JSR	F242_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L355
L354:
	CMP	#2,D0
	BEQ.S	L355
	BRA.S	L356
L355:
	MOVE.L	A3,-(A7)
	JSR	F243_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L357
L356:
	CMP	#10,D0
	BEQ.S	L357
	BRA.S	L358
L357:
	MOVE.L	A3,-(A7)
	JSR	F244_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L359
L358:
	CMP	#9,D0
	BEQ.S	L359
	BRA.S	L360
L359:
	MOVE.L	A3,-(A7)
	JSR	F251_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L361
L360:
	CMP	#8,D0
	BEQ.S	L361
	BRA.S	L362
L361:
	MOVE.L	A3,-(A7)
	JSR	F250_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L363
L362:
	CMP	#6,D0
	BEQ.S	L363
	BRA.S	L364
L363:
	MOVE.L	A3,-(A7)
	JSR	F248_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L365
L364:
	CMP	#5,D0
	BEQ.S	L365
	BRA.S	L366
L365:
	MOVE.L	A3,-(A7)
	JSR	F245_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L367
L366:
	CMP	#60,D0
	BEQ.S	L367
L368:
	CMP	#61,D0
	BEQ.S	L367
	BRA.S	L369
L367:
	MOVE.L	A3,-(A7)
	JSR	F252_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L370
L369:
	CMP	#65,D0
	BEQ.S	L370
	BRA.S	L371
L370:
	MOVE.L	A3,-(A7)
	JSR	F246_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L372
L371:
	CMP	#20,D0
	BEQ.S	L372
	BRA.S	L373
L372:
	MOVE	#1,-(A7)
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L346(PC)
	BRA.S	L374
L373:
	CMP	#24,D0
	BEQ.S	L374
	BRA.S	L375
L374:
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L377
	MOVE.B	-3(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-2(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+60(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L377:
	BRA	L346(PC)
	BRA.S	L376
L375:
	CMP	#11,D0
	BEQ.S	L376
	BRA.S	L378
L376:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F253_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.B	-4(A6),D0
	BEQ.S	L380
	MOVE.B	-4(A6),D0
	EXT	D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F259_xxxx_(PC)
	ADDQ.L	#4,A7
L380:
	BRA	L28T261_048(PC)
	BRA.S	L379
L378:
	CMP	#12,D0
	BEQ.S	L379
	BRA.S	L381
L379:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F254_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L346(PC)
	BRA.S	L382
L381:
	CMP	#53,D0
	BEQ.S	L382
	BRA.S	L383
L382:
	MOVE.L	A3,-(A7)
	JSR	F256_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L346(PC)
	BRA.S	L384
L383:
	CMP	#70,D0
	BEQ.S	L384
	BRA.S	L385
L384:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F257_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F337_akzz_(PC)
	BRA	L346(PC)
	BRA.S	L386
L385:
	CMP	#71,D0
	BEQ.S	L386
	BRA.S	L387
L386:
	SUBQ.B	#1,G407_s_Par+3286(A4)
	BRA	L346(PC)
	BRA.S	L388
L387:
	CMP	#72,D0
	BEQ.S	L388
	BRA.S	L389
L388:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+274(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	-4(A6),D0
	MOVE	D0,(A0)
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#4096,(A0)
L28T261_048:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	BRA	L346(PC)
	BRA.S	L390
L389:
	CMP	#73,D0
	BEQ.S	L390
	BRA.S	L391
L390:
	SUBQ.B	#1,G407_s_Par+3202(A4)
	BRA	L346(PC)
	BRA.S	L392
L391:
	CMP	#74,D0
	BEQ.S	L392
	BRA.S	L393
L392:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3204(A4)
L28T261_053:
	JSR	F260_pzzz_(PC)
	BRA.S	L346
	BRA.S	L394
L393:
	CMP	#77,D0
	BEQ.S	L394
	BRA.S	L395
L394:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3208(A4)
	BRA.S	L28T261_053
	BRA.S	L396
L395:
	CMP	#78,D0
	BEQ.S	L396
	BRA.S	L397
L396:
	MOVE	-4(A6),D0
	SUB	D0,G407_s_Par+3206(A4)
	BRA.S	L28T261_053
	BRA.S	L398
L397:
	CMP	#75,D0
	BEQ.S	L398
	BRA.S	L399
L398:
	MOVE.B	-5(A6),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	SUBQ.B	#1,(A0)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L346
	BRA.S	L400
L399:
	CMP	#13,D0
	BEQ.S	L400
	BRA.S	L401
L400:
	MOVE.L	A3,-(A7)
	JSR	F255_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L346
	BRA.S	L402
L401:
	CMP	#79,D0
	BEQ.S	L402
	BRA.S	L403
L402:
	SUBQ.B	#1,G407_s_Par+3203(A4)
L403:
L404:
L346:
L343:
	MOVE	G309_i_Par(A4),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
L339:
	JSR	F240_xxxx_(PC)
	TST	D0
	BNE	L340(PC)
L341:
L338:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$337:	.EQU	#-10
