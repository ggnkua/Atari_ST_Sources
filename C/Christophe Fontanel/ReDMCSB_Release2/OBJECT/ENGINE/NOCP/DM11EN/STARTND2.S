BSS SEG "bss"
G562_apuc_:/* global */
	.WORD	#40
G563_puc_G:/* global */
	.WORD	#4
G564_puc_G:/* global */
	.WORD	#4
G565_puc_G:/* global */
	.WORD	#4
G566_puc_G:/* global */
	.WORD	#4
CODE SEG "start"
F432_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D5
	MOVE.L	#0,A3
L2:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	MOVE.L	G550_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	JSR	F077_aA39_(PC)
	CMPI	#2,D7
	BNE.S	L5
	MOVE	#0,D0
	BRA	L1(PC)
L5:
	JSR	F452_xxxx_(PC)
	MOVE	D0,D6
	CMPI	#0,D0
	BNE.S	L6
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L7
L6:
	CMPI	#2,D6
	BNE.S	L8
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L9
L8:
	MOVE	#1,D5
L9:
L7:
L3:
	MOVE	D5,D0
	BEQ.S	L2
L4:
	MOVE.L	G648_l_Ava(A4),-4(A6)
	CLR	-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	CLR	D4
	BRA.S	L10
L11:
	CMPI	#1,D4
	BGT.S	L14
	MOVE	#0,D0
	BRA.S	L15
L14:
	MOVE	#-6683,D0
L15:
	MOVE	D0,-(A7)
	MOVE.L	#-2023406815,-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	MOVE	#9,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#10,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#26,A7
L12:
	ADDQ	#1,D4
L10:
	CMPI	#80,D4
	BLT.S	L11
L13:
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE.L	#16777217,-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#18,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#9,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	MOVE.L	-4(A6),-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
L1:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-4
F433_AA39_:/* global */
	LINK	A6,L$16
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D7
	JSR	F456_vzzz_(PC)
	CLR	D7
	JSR	F077_aA39_(PC)
	MOVE.L	#0,A3
	CLR	-(A7)
	MOVE.L	#512,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
L18:
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G559_pc_D1(A4),-(A7)
	MOVE.L	G558_pc_D1(A4),-(A7)
	MOVE.L	G557_pc_D1(A4),-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#4,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	JSR	F077_aA39_(PC)
	CMPI	#3,D4
	BNE.S	L21
	JSR	F432_xxxx_(PC)
	TST	D0
	BNE.S	L22
	BRA	L1T433_060(PC)
L22:
	BRA.S	L19
L21:
	CMPI	#4,D4
	BNE.S	L23
	BRA	L1T433_060(PC)
L23:
	CMPI	#1,D4
	SEQ	D6
	AND	#1,D6
	JSR	F452_xxxx_(PC)
	MOVE	D0,D5
	CMPI	#0,D0
	BNE.S	L24
	MOVE.L	G537_pc_D0(A4),A3
	BRA.S	L19
L24:
	CMPI	#2,D5
	BNE.S	L25
	MOVE.L	G544_pc_D0(A4),A3
	BRA.S	L19
L25:
	CMPI	#3,D5
	BNE.S	L26
	MOVE.L	G545_pc_D0(A4),A3
	BRA.S	L19
L26:
	MOVE	#1,D7
L19:
	MOVE	D7,D0
	BEQ	L18(PC)
L20:
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE	#65,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE	#60,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L27
	BRA	L1T433_059(PC)
L27:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L28
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	D1,-4(A6)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
L28:
	MOVE.L	G313_ul_Ga(A4),-132(A6)
	MOVE.L	G349_ul_La(A4),-128(A6)
	MOVE	G305_ui_Pa(A4),-122(A6)
	MOVE	G306_i_Par(A4),-120(A6)
	MOVE	G307_i_Par(A4),-118(A6)
	MOVE	G308_i_Par(A4),-116(A6)
	MOVE	G309_i_Par(A4),-114(A6)
	MOVE	G411_i_Lea(A4),-112(A6)
	MOVE	G514_i_Mag(A4),-110(A6)
	MOVE	G372_ui_Ev(A4),-108(A6)
	MOVE	G373_ui_Fi(A4),-106(A6)
	MOVE	G369_ui_Ev(A4),-104(A6)
	MOVE	G377_ui_Cu(A4),-102(A6)
	MOVE.L	G361_l_Las(A4),-100(A6)
	MOVE.L	G362_l_Las(A4),-96(A6)
	MOVE	G310_i_Dis(A4),-92(A6)
	MOVE	G311_i_Pro(A4),-90(A6)
	MOVE	G312_i_Las(A4),-88(A6)
	MOVE	G414_T_Lea(A4),-124(A6)
	MOVE	G376_ui_Ma(A4),-86(A6)
	MOVE	#80,-(A7)
	PEA	-84(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#96,-(A7)
	PEA	-228(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	LEA	-132(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-228(A6)
	MOVE	#128,-224(A6)
	MOVE.L	G375_ps_Ac(A4),D0
	MOVE.L	D0,-222(A6)
	MOVE	G376_ui_Ma(A4),D0
	MULU	#16,D0
	MOVE	D0,-218(A6)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,-216(A6)
	MOVE	#3328,-212(A6)
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,-210(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#10,D0
	MOVE	D0,-206(A6)
	MOVE.L	G371_pi_Ti(A4),D0
	MOVE.L	D0,-204(A6)
	MOVE	G369_ui_Ev(A4),D0
	MULU	#2,D0
	MOVE	D0,-200(A6)
	MOVE	D6,304(A2)
	MOVE.L	G525_l_Gam(A4),306(A2)
	MOVE.B	#1,299(A2)
	MOVE.B	#1,298(A2)
	CLR	D4
	BRA.S	L29
L30:
	JSR	F027_AA59_(PC)
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	LEA	310(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L29:
	CMPI	#16,D4
	BLT.S	L30
L31:
	CLR	D4
	BRA.S	L32
L33:
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-224(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	310(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-228(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F418_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,D1
	ASL.L	#1,D1
	LEA	342(A2),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L34:
	ADDQ	#1,D4
L32:
	CMPI	#5,D4
	BLT.S	L33
L35:
	MOVE.L	A2,-(A7)
	JSR	F430_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L36
	BRA	L1T433_059(PC)
L36:
	CLR	D4
	BRA.S	L37
L38:
	PEA	-2(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	310(A2),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-224(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	-228(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F420_xxxx_(PC)
	ADDA	#12,A7
	TST	D0
	BNE.S	L41
	BRA	L1T433_059(PC)
L41:
L39:
	ADDQ	#1,D4
L37:
	CMPI	#5,D4
	BLT.S	L38
L40:
	MOVE	#44,-(A7)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L42
	BRA	L1T433_059(PC)
L42:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L43
	BRA	L1T433_059(PC)
L43:
	MOVE	G282_ui_Du(A4),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L44
	BRA	L1T433_059(PC)
L44:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L45
	BRA	L1T433_059(PC)
L45:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L46
	BRA	L1T433_059(PC)
L46:
	CLR	D4
	BRA.S	L47
L48:
	MOVE	D4,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	LEA	G235_auc_G(A4),A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L51
	BRA.S	L1T433_059
L51:
L49:
	ADDQ	#1,D4
L47:
	CMPI	#16,D4
	BLT.S	L48
L50:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L52
	BRA.S	L1T433_059
L52:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	BNE.S	L53
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L53:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L54
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	-4(A6),D0
	MOVE	D0,(A0)
L54:
	MOVE	#1,G524_B_Res(A4)
	BRA.S	L1T433_060
L1T433_059:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G560_pc_D1(A4),-(A7)
	CLR.L	-(A7)
	MOVE.L	G540_pc_D0(A4),-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	CLR	-(A7)
	MOVE	#1,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F077_aA39_(PC)
L1T433_060:
	MOVE.L	#512,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F457_AA08_(PC)
	JSR	F078_xzzz_(PC)
L17:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$16:	.EQU	#-228
F434_xxxx_:/* global */
	LINK	A6,L$55
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G523_B_Res(A4),D0
	BNE.S	L57
	MOVE	#1,-(A7)
	MOVE.L	#44,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G278_ps_Du(A4)
L57:
	MOVE	#44,-(A7)
	MOVE.L	G278_ps_Du(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L58
	MOVE	#0,D0
	BRA	L56(PC)
L58:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L59
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	8(A0),D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G306_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	MOVE	D0,D6
	AND	#31,D0
	MOVE	D0,G307_i_Par(A4)
	MOVE	D6,D0
	ASR	#5,D0
	AND	#3,D0
	MOVE	D0,G308_i_Par(A4)
	CLR	G309_i_Par(A4)
L59:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D7
	AND	#255,D7
	MOVE	G523_B_Res(A4),D0
	BNE.S	L60
	MOVE	#1,-(A7)
	MOVE	#16,D0
	MULS	D7,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G277_ps_Du(A4)
L60:
	MOVE	D7,D0
	MULS	#16,D0
	MOVE	D0,-(A7)
	MOVE.L	G277_ps_Du(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L61
	MOVE	#0,D0
	BRA	L56(PC)
L61:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L62
	MOVE	#1,-(A7)
	MOVE	D7,D0
	ASL	#1,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G281_pi_Du(A4)
L62:
	MOVE	#0,D4
	MOVE	D4,D5
	BRA.S	L63
L64:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
	MOVE	D5,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	ADDQ	#1,D0
	ADD	D0,D4
	ADDQ	#1,D5
L63:
	MOVE	D5,D0
	CMP	D7,D0
	BLT.S	L64
L65:
	MOVE	D4,G282_ui_Du(A4)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L66
	MOVE.L	G278_ps_Du(A4),A0
	ADDI	#300,10(A0)
L66:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L67
	MOVE	#1,-(A7)
	MOVE	D4,D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G280_pui_D(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	ASL	#1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G283_pT_Sq(A4)
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	AND.L	#65535,D0
	ASL.L	#1,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G260_pui_D(A4)
L67:
	MOVE	D4,D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G280_pui_D(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L68
	MOVE	#0,D0
	BRA	L56(PC)
L68:
	MOVE	D5,D0
	MULS	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G283_pT_Sq(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L69
	MOVE	#0,D0
	BRA	L56(PC)
L69:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L70
	CLR	D4
	BRA.S	L71
L72:
	MOVE	D5,D0
	ADDQ	#1,D5
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L73:
	ADDQ	#1,D4
L71:
	CMPI	#300,D4
	BCS.S	L72
L74:
L70:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	6(A0),D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE.L	G260_pui_D(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L75
	MOVE	#0,D0
	BRA	L56(PC)
L75:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L76
	MOVE	#100,G369_ui_Ev(A4)
L76:
	CLR	D6
	BRA	L77(PC)
L78:
	MOVE	D6,D5
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D5
	LEA	12(A0),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	G298_B_New(A4),D0
	BEQ.S	L81
	MOVE	D5,D0
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	CMPI	#15,D6
	BNE.S	L82
	MOVE	#768,D0
	BRA.S	L83
L82:
	MOVE	#1024,D0
L83:
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D1
	LEA	12(A0),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L81:
	LEA	G235_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE	G523_B_Res(A4),D0
	BNE.S	L84
	MOVE	#1,-(A7)
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MULU	D4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,D1
	ASL.L	#2,D1
	LEA	G284_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L84:
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
	MOVE	D4,D0
	MULU	D5,D0
	MOVE	D0,-(A7)
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L85
	MOVE	#0,D0
	BRA	L56(PC)
L85:
	MOVE	G298_B_New(A4),D0
	BEQ.S	L86
	CMPI	#4,D6
	BEQ.S	L88
	CMPI	#14,D6
	BLT.S	L87
L88:
	MOVE	D6,D0
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D0,G369_ui_Ev(A4)
L87:
	MOVE	D4,D1
	LSR	#1,D1
	MOVE	D1,D4
	MOVE	D1,-14(A6)
	MOVE	D5,D1
	MULU	-14(A6),D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
	LEA	G236_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	BRA.S	L89
L90:
	MOVE	#-1,(A3)
L91:
	MOVE	D5,D0
	SUBQ	#1,D5
	MOVE	D4,D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	MOVE.L	A3,D0
	ADD.L	D1,D0
	MOVE.L	D0,A3
L89:
	MOVE	D5,D0
	BNE.S	L90
L92:
L86:
L79:
	ADDQ	#1,D6
L77:
	CMPI	#16,D6
	BLT	L78(PC)
L80:
	MOVE	G523_B_Res(A4),D0
	BNE.S	L93
	MOVE	#1,-(A7)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G276_puc_D(A4)
L93:
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	2(A0),-(A7)
	MOVE.L	G276_puc_D(A4),-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L94
	MOVE	#0,D0
	BRA	L56(PC)
L94:
	MOVE	G523_B_Res(A4),D0
	BNE	L95(PC)
	MOVE	#1,-(A7)
	MOVE	G282_ui_Du(A4),D0
	ADD	D7,D0
	MULU	#4,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G279_pppuc(A4)
	MOVE.L	G279_pppuc(A4),D0
	MOVE	D7,D1
	EXT.L	D1
	ASL.L	#2,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
	CLR	D5
	BRA	L96(PC)
L97:
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	A2,(A0)
	MOVE.L	G276_puc_D(A4),D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
	MOVE	#1,D6
	BRA.S	L100
L101:
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	ADDQ	#1,D1
	MOVE.L	-4(A6),D0
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,(A2)+
L102:
	ADDQ	#1,D6
L100:
	MOVE	D6,D0
	MOVE	D5,D1
	MULS	#16,D1
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D1,A0
	MOVE	8(A0),D1
	AND	#1984,D1
	LSR	#6,D1
	CMP	D1,D0
	BLS.S	L101
L103:
L98:
	ADDQ	#1,D5
L96:
	MOVE	D5,D0
	CMP	D7,D0
	BLT	L97(PC)
L99:
L95:
	MOVE	#1,D0
L56:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$55:	.EQU	#-14
F435_xxxx_:/* global */
	LINK	A6,L$104
	MOVEM.L	A3/D7-D4,-(A7)
	CLR	D4
	MOVE.L	#0,A3
	MOVE	G298_B_New(A4),D0
	BEQ.S	L106
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	TST	D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D4
DATA SEG "s!"
s!:
	DATA 5C 44 55 4E 47 45 4F 4E 2E 44 41 54 00 00 
CODE SEG "start"
	CLR	-(A7)
	PEA	s!(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,G521_i_Gam(A4)
	BGE.S	L107
	MOVE	#50,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L109:
L110:
	BRA.S	L109
L111:
L107:
L3T435_002:
	CLR	G524_B_Res(A4)
	CLR	G305_ui_Pa(A4)
	MOVE	#-1,G414_T_Lea(A4)
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE	D1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,G525_l_Gam(A4)
	BRA	L112(PC)
L106:
	MOVE.L	#0,A3
L3T435_004:
L113:
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	CLR.L	-(A7)
	CLR.L	-(A7)
	MOVE.L	G561_pc_D1(A4),-(A7)
	MOVE.L	G556_pc_D1(A4),-(A7)
	MOVE.L	G548_pc_D0(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F427_xxxx_(PC)
	ADDA	#30,A7
	JSR	F078_xzzz_(PC)
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	JSR	F424_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	JSR	F077_aA39_(PC)
	CMPI	#2,D7
	BNE.S	L116
L3T435_008:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,D0
	BRA	L105(PC)
L116:
L3T435_009:
	JSR	F452_xxxx_(PC)
	MOVE	D0,D5
	CMPI	#1,D0
	BNE.S	L117
	CLR	D6
	CLR	-(A7)
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BGE.S	L118
	CLR	-(A7)
	MOVE.L	G520_pc_D0(A4),-(A7)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L119
	MOVE	#1,D6
	BRA.S	L120
L119:
DATA SEG "s!"
	DATA 41 3A 5C 44 55 4E 47 45 4F 4E 2E 46 54 4C 00 00 
CODE SEG "start"
	MOVE	G523_B_Res(A4),D0
	BNE.S	L121
	CLR	-(A7)
	PEA	s!+14(A4)
	MOVE	#61,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,G521_i_Gam(A4)
	CMPI	#0,D0
	BLT.S	L121
	MOVE	#1,D4
	MOVE	#1,G298_B_New(A4)
	BRA	L3T435_002(PC)
L121:
	MOVE.L	G539_pc_D0(A4),A3
	MOVE	#3,D5
L120:
L118:
	BRA.S	L122
L117:
	CMPI	#0,D5
	BNE.S	L123
	MOVE.L	G542_pc_D0(A4),A3
	BRA.S	L124
L123:
	CMPI	#3,D5
	BNE.S	L125
	MOVE.L	G545_pc_D0(A4),A3
	BRA.S	L126
L125:
	CMPI	#2,D5
	BNE.S	L127
	MOVE.L	G544_pc_D0(A4),A3
L127:
L126:
L124:
L122:
L114:
	CMPI	#1,D5
	BNE	L113(PC)
L115:
	PEA	-642(A6)
	JSR	F429_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L128
	BRA	L3T435_037(PC)
L128:
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L129
	MOVE.L	-336(A6),D0
	CMP.L	G525_l_Gam(A4),D0
	BEQ.S	L129
	MOVE.L	G546_pc_D0(A4),A3
	BRA	L3T435_004(PC)
L129:
	MOVE.L	-336(A6),G525_l_Gam(A4)
	MOVE	-300(A6),-(A7)
	MOVE	-332(A6),-(A7)
	MOVE	#128,-(A7)
	PEA	-130(A6)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L130
	BRA	L3T435_037(PC)
L130:
	MOVE.L	-130(A6),G313_ul_Ga(A4)
	MOVE.L	-126(A6),G349_ul_La(A4)
	MOVE	-120(A6),G305_ui_Pa(A4)
	MOVE	-118(A6),G306_i_Par(A4)
	MOVE	-116(A6),G307_i_Par(A4)
	MOVE	-114(A6),G308_i_Par(A4)
	MOVE	-112(A6),G309_i_Par(A4)
	MOVE	-110(A6),G411_i_Lea(A4)
	MOVE	-108(A6),G514_i_Mag(A4)
	MOVE	-106(A6),G372_ui_Ev(A4)
	MOVE	-104(A6),G373_ui_Fi(A4)
	MOVE	-102(A6),G369_ui_Ev(A4)
	MOVE	-100(A6),G377_ui_Cu(A4)
	MOVE.L	-98(A6),G361_l_Las(A4)
	MOVE.L	-94(A6),G362_l_Las(A4)
	MOVE	-90(A6),G310_i_Dis(A4)
	MOVE	-88(A6),G311_i_Pro(A4)
	MOVE	-86(A6),G312_i_Las(A4)
	MOVE	-122(A6),G414_T_Lea(A4)
	MOVE	-84(A6),G376_ui_Ma(A4)
	MOVE	G523_B_Res(A4),D0
	BNE.S	L131
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
L131:
	MOVE	-298(A6),-(A7)
	MOVE	-330(A6),-(A7)
	MOVE	#16,D0
	MULU	G376_ui_Ma(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G375_ps_Ac(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L132
	BRA	L3T435_037(PC)
L132:
	MOVE	-296(A6),-(A7)
	MOVE	-328(A6),-(A7)
	MOVE	#3328,-(A7)
	PEA	G407_s_Par(A4)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L133
	BRA	L3T435_037(PC)
L133:
	MOVE	-294(A6),-(A7)
	MOVE	-326(A6),-(A7)
	MOVE	#10,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G370_ps_Ev(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L134
	BRA	L3T435_037(PC)
L134:
	MOVE	-292(A6),-(A7)
	MOVE	-324(A6),-(A7)
	MOVE	#2,D0
	MULU	G369_ui_Ev(A4),D0
	MOVE	D0,-(A7)
	MOVE.L	G371_pi_Ti(A4),-(A7)
	JSR	F419_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L135
	BRA	L3T435_037(PC)
L135:
L112:
	JSR	F434_xxxx_(PC)
	TST	D0
	BNE.S	L136
	BRA	L3T435_037(PC)
L136:
	MOVE	G521_i_Gam(A4),-(A7)
	MOVE	#62,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	G298_B_New(A4),D0
	BEQ.S	L137
	JSR	F233_wzzz_(PC)
	JSR	F196_aozz_(PC)
	MOVE	D4,D0
	BEQ.S	L138
	MOVE	#32,-(A7)
	PEA	-674(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	-674(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L138:
	MOVE	#1,-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	BRA.S	L139
L137:
	MOVE	#1,G524_B_Res(A4)
	MOVE	D6,D0
	BEQ.S	L140
	MOVE.L	G519_pc_D0(A4),-(A7)
	MOVE.L	G520_pc_D0(A4),-(A7)
	CLR	-(A7)
	MOVE	#86,-(A7)
	JSR	R057_rzzz_(PC)
	ADDA	#12,A7
L140:
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
L139:
	CLR	G303_B_Par(A4)
	MOVE	#1,D0
	BRA.S	L105
L3T435_037:
	PEA	G347_aui_P(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#52,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L141
	MOVE	#600,D7
	BRA.S	L142
L143:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L142:
	SUBQ	#1,D7
	BNE.S	L143
L144:
	MOVE	#-1,D0
	BRA.S	L105
L141:
L146:
L147:
	BRA.S	L146
L148:
L105:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$104:	.EQU	#-674
F436_xxxx_:/* global */
	LINK	A6,L$149
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	#-32192,A3
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-4(A6)
	CLR	D4
	BRA	L151(PC)
L152:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	BRA	L155(PC)
L156:
	MOVE	D5,D7
	ASL.L	#1,D7
	MOVE.L	A3,A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D5,D6
	ASL.L	#1,D6
	MOVE.L	8(A6),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BLS.S	L159
	SUBQ	#1,D7
L159:
	MOVE	D7,D0
	AND	#7,D0
	MOVE	D6,D1
	AND	#7,D1
	CMP	D1,D0
	BCC.S	L160
	ADDQ	#1,D7
L160:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BLS.S	L161
	SUB	#16,D7
L161:
	MOVE	D7,D0
	AND	#112,D0
	MOVE	D6,D1
	AND	#112,D1
	CMP	D1,D0
	BCC.S	L162
	ADD	#16,D7
L162:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BLS.S	L163
	SUB	#256,D7
L163:
	MOVE	D7,D0
	AND	#1792,D0
	MOVE	D6,D1
	AND	#1792,D1
	CMP	D1,D0
	BCC.S	L164
	ADD	#256,D7
L164:
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	D7,(A0)
L157:
	ADDQ	#1,D5
L155:
	CMPI	#16,D5
	BLT	L156(PC)
L158:
L153:
	ADDQ	#1,D4
L151:
	CMPI	#8,D4
	BLT	L152(PC)
L154:
	MOVE.L	-4(A6),-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
L150:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$149:	.EQU	#-4
F437_xxxx_:/* global */
	LINK	A6,L$165
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	G578_B_Use(A4)
	CMPI.L	#138060,G648_l_Ava(A4)
	BGE.S	L167
	BRA	L166(PC)
L167:
	CLR	-(A7)
	MOVE.L	#133056,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D4
	ADD.L	#256,D4
	AND.L	#-256,D4
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	D4,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	ADD.L	#32000,D4
	MOVE.L	G348_pl_Bi(A4),D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,A2
	MOVE.L	A3,D0
	MOVE.L	D0,-8(A6)
	MOVE.L	D0,-92(A6)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-340(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#137,-(A7)
	CLR	-(A7)
	PEA	G005_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#1911,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	MOVE	#80,-(A7)
	CLR	-(A7)
	PEA	G004_s_Gra(A4)
	MOVE.L	D4,D0
	MOVE.L	D0,-96(A6)
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADD.L	#9120,D4
	MOVE	#12,D6
	MOVE	#48,D5
	CLR	D7
	BRA	L168(PC)
L169:
	MOVE.L	D4,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-88(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	PEA	G017_auc_G(A4)
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	#80,-(A7)
	MOVE	#320,-(A7)
	MOVE.L	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	#320,D0
	SUB	D5,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-308(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D5,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-306(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	#160,D0
	SUB	D6,D0
	EXT.L	D0
	DIVS	#2,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-304(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADD	D6,D0
	SUBQ	#1,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-302(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D5,D0
	ADD	#15,D0
	EXT.L	D0
	DIVS	#16,D0
	MULS	#8,D0
	MOVE	D7,D1
	MULS	#10,D1
	LEA	-300(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MULU	D6,D0
	AND.L	#65535,D0
	ADD.L	D0,D4
	ADDQ	#4,D6
	ADD	#16,D5
L170:
	ADDQ	#1,D7
L168:
	CMPI	#18,D7
	BLT	L169(PC)
L171:
	MOVE	#2,-310(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	-92(A6),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	-92(A6),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#32000,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
	MOVE	#1345,-334(A6)
	MOVE	#1057,-332(A6)
	MOVE	#1617,-330(A6)
	MOVE	#1329,-328(A6)
	MOVE	#1906,-324(A6)
	MOVE	#1792,-310(A6)
	MOVE	#2,-320(A6)
	MOVE	#2,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	D7
	BRA	L172(PC)
L173:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#-1,-(A7)
	MOVE	#160,-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-300(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	MULS	#10,D0
	LEA	-308(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	-88(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	D7,D0
	AND	#1,D0
	ASL.L	#2,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	#-1,-(A7)
	MOVE	#5,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#12,A7
L174:
	ADDQ	#1,D7
L172:
	CMPI	#18,D7
	BLT	L173(PC)
L175:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	MOVE	#160,-(A7)
	MOVE	#160,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G003_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-96(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	CLR	-320(A6)
	MOVE	#1792,-316(A6)
	PEA	-340(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE.L	#133056,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L166:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$165:	.EQU	#-340
F438_xxxx_:/* global */
	LINK	A6,L$176
	MOVEM.L	A3/D7,-(A7)
	LEA	G562_apuc_(A4),A0
	MOVE.L	A0,A3
	MOVE.L	G348_pl_Bi(A4),D0
	ADD.L	#4800,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	36(A3),D0
	MOVE.L	D0,-8(A6)
	MOVE	#1,D7
L178:
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	CMPI	#1,D0
	BNE.S	L181
	MOVE	#1,-(A7)
	MOVE	#145,-(A7)
	MOVE.L	G565_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
L181:
	MOVE	#20608,-(A7)
	MOVE.L	36(A3),-(A7)
	MOVE.L	32(A3),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#112,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G006_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	G007_s_Gra+2(A4),D0
	CMPI	#0,D0
	BLT.S	L182
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#252,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G007_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,G007_s_Gra+2(A4)
L182:
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND	#3,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	G008_s_Gra(A4)
	MOVE.L	36(A3),-(A7)
	MOVE	#4,D0
	MOVE	D7,D1
	AND	#3,D1
	ADD	D1,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADDQ	#4,G008_s_Gra(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVEM.L	A6-A2/D7-D4,-(A7)
	MOVE.L	-4(A6),A0
	MOVE.L	-8(A6),A1
	MOVE	#160,D0
L6T438_004:
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,(A0)
	MOVEM.L	(A1)+,D1-D7/A2-A6
	MOVEM.L	D1-D7/A2-A6,48(A0)
	MOVEM.L	(A1)+,D1-D4
	MOVEM.L	D1-D4,96(A0)
	MOVE.B	(A1),112(A0)
	MOVE.B	2(A1),114(A0)
	MOVE.B	4(A1),116(A0)
	MOVE.B	6(A1),118(A0)
	LEA	160(A0),A0
	LEA	16(A1),A1
	DBF	D0,L6T438_004
	MOVEM.L	(A7)+,D4-D7/A2-A6
L179:
	ADDQ	#1,D7
	MOVE	D7,D0
	CMPI	#32,D0
	BNE	L178(PC)
L180:
L177:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$176:	.EQU	#-8
F439_xxxx_:/* global */
	LINK	A6,L$183
	MOVE	D7,-(A7)
	MOVE	#255,G309_i_Par(A4)
	MOVE	#1,G297_B_Dra(A4)
	MOVE	#5,G273_i_Cur(A4)
	MOVE	#5,G274_i_Cur(A4)
	LEA	-128(A6),A0
	MOVE.L	A0,G271_ppuc_(A4)
	LEA	-170(A6),A0
	MOVE.L	A0,G269_ps_Cu(A4)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	#25,-(A7)
	PEA	-154(A6)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
	CLR	D7
	BRA.S	L185
L186:
	MOVE	D7,D0
	MULU	#5,D0
	LEA	-154(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	-128(A6),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
	MOVE	D7,D0
	LEA	-144(A6),A0
	ADDA	D0,A0
	MOVE.B	#32,(A0)
L187:
	ADDQ	#1,D7
L185:
	CMPI	#5,D7
	BCS.S	L186
L188:
	MOVE.B	#32,-147(A6)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G563_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	CLR	G324_B_Dra(A4)
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#-1,-(A7)
	MOVE	#128,-(A7)
	MOVE	#160,-(A7)
	MOVE	#30,-(A7)
	CLR	-(A7)
	PEA	G009_s_Gra(A4)
	MOVE.L	G562_apuc_+32(A4),-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G010_s_Gra(A4)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	PEA	G011_s_Gra(A4)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	PEA	G020_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L184:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$183:	.EQU	#-170
F440_xxxx_:/* global */
	LINK	A6,L$189
	CLR	-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	JSR	F494_ozzz_(PC)
	ADDQ.L	#2,A7
	AND.L	#65535,D0
	MOVE.L	D0,-4(A6)
	MOVE.L	D0,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	10(A6),A0
	MOVE.L	D0,(A0)
	MOVE.L	D0,-(A7)
	MOVE	8(A6),D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE.L	-4(A6),D0
L190:
	UNLK	A6
	RTS
L$189:	.EQU	#-4
F441_xxxx_:/* global */
	LINK	A6,L$191
	MOVEM.L	D7-D5,-(A7)
	LEA	G445_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	CLR	D7
	BRA.S	L193
L194:
	CLR	-(A7)
	MOVE.L	#10304,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G562_apuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L195:
	ADDQ	#1,D7
L193:
	CMPI	#8,D7
	BCS.S	L194
L196:
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+32(A4)
	CLR	-(A7)
	MOVE.L	#20608,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G562_apuc_+36(A4)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	MOVE	#3,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	MOVE	#2,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	PEA	G563_puc_G(A4)
	MOVE	#4,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D6
	PEA	G564_puc_G(A4)
	MOVE	#5,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G565_puc_G(A4)
	MOVE	#535,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	PEA	G566_puc_G(A4)
	MOVE	#534,-(A7)
	JSR	F440_xxxx_(PC)
	ADDQ.L	#6,A7
	ADD.L	D0,D6
	JSR	F478_gzzz_(PC)
	CLR	G578_B_Use(A4)
	CLR	-8(A6)
	MOVE	#100,-6(A6)
	CLR	-4(A6)
	MOVE	#160,-2(A6)
	MOVE	#1,D7
	BRA.S	L197
L198:
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	ASL	#2,D0
	MOVE	D0,-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	SUBQ	#4,-6(A6)
L199:
	ADDQ	#1,D7
L197:
	CMPI	#4,D7
	BCS.S	L198
L200:
	MOVE	#127,-6(A6)
	MOVE	#5,D7
	BRA.S	L201
L202:
	ADDQ	#4,-8(A6)
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G562_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	G562_apuc_+16(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L203:
	ADDQ	#1,D7
L201:
	CMPI	#8,D7
	BCS.S	L202
L204:
L205:
	JSR	F439_xxxx_(PC)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	MOVE	#99,G298_B_New(A4)
L208:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	JSR	F380_xzzz_(PC)
L209:
	CMPI	#99,G298_B_New(A4)
	BEQ.S	L208
L210:
L206:
	CMPI	#202,G298_B_New(A4)
	BEQ.S	L205
L207:
	MOVE	#1,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G566_puc_G(A4),-(A7)
	JSR	F060_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	#20,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	MOVE	G298_B_New(A4),D0
	BEQ.S	L211
	JSR	F438_xxxx_(PC)
L211:
	MOVE.L	D6,D0
	ADD.L	#82432,D0
	ADD.L	#41216,D0
	MOVE.L	D0,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L192:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$191:	.EQU	#-8
F442_AA08_:/* global */
	LINK	A6,L$212
	MOVE	#1800,-2(A6)
	JSR	F077_aA39_(PC)
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	G564_puc_G(A4),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L214:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L215:
	SUBQ	#1,-2(A6)
	MOVE	-2(A6),D0
	BEQ.S	L217
	MOVE	G588_i_Mou(A4),D0
	BNE.S	L217
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L214
L217:
L216:
	MOVE	#202,G298_B_New(A4)
L213:
	UNLK	A6
	RTS
L$212:	.EQU	#-2
F443_xxxx_:/* global */
	LINK	A6,L$218
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	14(A6),A3
	LEA	-50(A6),A0
	MOVE.L	A0,A2
	BRA.S	L220
L221:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#65,D0
	BLT.S	L224
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#90,D0
	BGT.S	L224
	SUBI.B	#64,(A2)
L224:
L222:
	ADDQ.L	#1,A2
L220:
	MOVE.B	(A3)+,(A2)
	BNE.S	L221
L223:
	PEA	-50(A6)
	MOVE	#12,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L219:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$218:	.EQU	#-50
F444_AA29_:/* global */
	LINK	A6,L$225
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F077_aA39_(PC)
	CLR.L	G441_ps_Pr(A4)
	CLR.L	G442_ps_Se(A4)
	CLR.L	G443_ps_Pr(A4)
	CLR.L	G444_ps_Se(A4)
	MOVE	8(A6),D0
	BEQ.S	L227
	MOVE	G302_B_Gam(A4),D0
	BNE.S	L227
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#6,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	#240,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
L227:
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
	MOVE.L	G088_apuc_+40(A4),A3
	MOVE	8(A6),D0
	BEQ.S	L228
	MOVE.L	A3,A2
	ADDA.L	#560,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A2,-(A7)
	MOVE	#6,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L229
	MOVE.L	A3,-14(A6)
	ADDA.L	#1376,A3
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	-14(A6),-(A7)
	MOVE	#208,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L229:
L228:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,D0
	MOVE.L	D0,-10(A6)
	MOVE.L	D0,-(A7)
	MOVE	#-32763,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	JSR	F478_gzzz_(PC)
	MOVE	G322_B_Pal(A4),D0
	BEQ	L230(PC)
	MOVE	#32,-(A7)
	PEA	-78(A6)
	PEA	G347_aui_P(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	D6
	BRA.S	L231
L232:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D7
	BRA.S	L235
L236:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G346_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G346_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G347_aui_P(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F431_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G347_aui_P(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L237:
	ADDQ	#1,D7
L235:
	CMPI	#16,D7
	BLT.S	L236
L238:
L233:
	ADDQ	#1,D6
L231:
	CMPI	#7,D6
	BLE.S	L232
L234:
	CLR	G322_B_Pal(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	#32,-(A7)
	PEA	G347_aui_P(A4)
	PEA	-78(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	BRA.S	L239
L230:
	PEA	G345_aui_B(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L239:
	MOVE	8(A6),D0
	BEQ	L240(PC)
	MOVE	G302_B_Gam(A4),D0
	BEQ	L241(PC)
	MOVE	#4000,-(A7)
	MOVE	#12,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	CLR	D7
	BRA	L242(PC)
L243:
	MOVE	D7,D6
	MULS	#48,D6
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-6(A6)
	MOVE	#10,-(A7)
	MOVE	#32,-(A7)
	PEA	G015_s_Gra(A4)
	MOVE.L	-14(A6),-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#1,-(A7)
	MOVE	#16,-(A7)
	PEA	G016_s_Gra(A4)
	MOVE.L	-6(A6),A0
	LEA	336(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#87,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	MOVE.L	-6(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-140(A6)
	MOVE	#6,D0
	MULS	-140(A6),D0
	ADD	#87,D0
	MOVE	D0,D5
	MOVE.L	-6(A6),A0
	MOVE.B	8(A0),-1(A6)
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#44,D0
	BEQ.S	L246
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#59,D0
	BEQ.S	L246
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#45,D0
	BEQ.S	L246
	ADDQ	#6,D5
L246:
	MOVE.L	-6(A6),A0
	LEA	8(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#9,-(A7)
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
	CLR	D5
	BRA	L247(PC)
L248:
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#16,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#1,D4
	BNE.S	L251
	BRA.S	L249
L251:
	MOVE	D4,D0
	ASL.L	#2,D0
	LEA	G428_apc_S+-8(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "start"
	PEA	s!+30(A4)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-130(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-130(A6)
	MOVE	#13,-(A7)
	MOVE	D6,D0
	ADDQ	#8,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#105,-(A7)
	JSR	F443_xxxx_(PC)
	ADDA	#10,A7
L249:
	ADDQ	#1,D5
L247:
	CMPI	#3,D5
	BLE	L248(PC)
L250:
	ADDI	#48,G015_s_Gra+4(A4)
	ADDI	#48,G015_s_Gra+6(A4)
	ADDI	#48,G016_s_Gra+4(A4)
	ADDI	#48,G016_s_Gra+6(A4)
L244:
	ADDQ	#1,D7
L242:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L243(PC)
L245:
	PEA	-78(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L253:
L254:
	BRA.S	L253
L255:
L241:
L12T444_017:
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#40,-(A7)
	PEA	G012_s_Gra(A4)
	MOVE.L	A2,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#2,-(A7)
	MOVE	#2,-(A7)
	MOVE	#16,-(A7)
	PEA	-110(A6)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#32,-(A7)
	PEA	-46(A6)
	PEA	-110(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1911,-16(A6)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#300,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	MOVE	G524_B_Res(A4),D0
	BEQ	L256(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	MOVE	#1,-(A7)
	PEA	G013_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G014_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
DATA SEG "s!"
	DATA 52 45 53 54 41 52 54 20 54 48 49 53 20 47 41 4D 45 00 
CODE SEG "start"
	PEA	s!+32(A4)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#154,-(A7)
	MOVE	#110,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	#1079,-44(A6)
	MOVE	#1911,-38(A6)
	LEA	G446_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	JSR	F357_qzzz_(PC)
	JSR	F078_xzzz_(PC)
	PEA	-46(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#600,D7
	BRA.S	L257
L258:
	JSR	F380_xzzz_(PC)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L257:
	SUBQ	#1,D7
	MOVE	D7,D0
	BEQ.S	L260
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L258
L260:
L259:
	JSR	F077_aA39_(PC)
	MOVE	G523_B_Res(A4),D0
	BEQ.S	L261
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32000,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G021_aaui_(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#32,-(A7)
	PEA	G346_aui_P(A4)
	PEA	G021_aaui_(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	G298_B_New(A4)
	JSR	F435_xxxx_(PC)
	CMPI	#-1,D0
	BEQ.S	L262
	JSR	F462_xxxx_(PC)
	CLR	G523_B_Res(A4)
	JSR	F078_xzzz_(PC)
	JSR	F357_qzzz_(PC)
	BRA.S	L226
L262:
L261:
L256:
	PEA	-110(A6)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L240:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	-10(A6),-(A7)
	JSR	F466_rzzz_(PC)
	ADDA	#12,A7
	PEA	G019_aui_G(A4)
	JSR	F436_xxxx_(PC)
	ADDQ.L	#4,A7
L264:
L265:
	BRA.S	L264
L266:
L226:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$225:	.EQU	#-140
F445_xxxx_:/* global */
	LINK	A6,L$267
	JSR	F261_hzzz_(PC)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F065_aanz_(PC)
	ADDQ.L	#1,G313_ul_Ga(A4)
L268:
	UNLK	A6
	RTS
L$267:	.EQU	#0
F446_zzzz_:/* global */
	LINK	A6,L$269
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,G302_B_Gam(A4)
	MOVE	G423_i_Inv(A4),D0
	BEQ.S	L271
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L271:
	JSR	F363_pzzz_(PC)
	MOVE	#200,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	MOVE	#100,D0
	MOVE	D0,G407_s_Par+3204(A4)
	MOVE	D0,G407_s_Par+3208(A4)
	MOVE	D0,G407_s_Par+3206(A4)
	JSR	F260_pzzz_(PC)
	JSR	F445_xxxx_(PC)
	MOVE	G306_i_Par(A4),-4(A6)
	MOVE	G307_i_Par(A4),-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-8(A6)
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#10000,6(A3)
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	#255,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F146_aczz_(PC)
	ADDQ.L	#8,A7
	MOVE	G309_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F148_aayz_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,D7
	MOVE	G306_i_Par(A4),D6
	MOVE	G307_i_Par(A4),D5
L14T446_002:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L272
L273:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE.S	L276
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#50,D0
	BNE.S	L277
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,(A2)
	BRA.S	L14T446_002
L277:
L276:
L274:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L272:
	CMPI	#-2,D4
	BNE.S	L273
L275:
	MOVE	D7,D0
	BEQ.S	L278
	CLR	D7
	MOVE	-4(A6),D6
	MOVE	-6(A6),D5
	BRA.S	L14T446_002
L278:
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L279
L280:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L281:
	ADD	#40,D7
L279:
	CMPI	#255,D7
	BLE.S	L280
L282:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	#25,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#55,D7
	BRA.S	L283
L284:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
L285:
	ADD	#40,D7
L283:
	CMPI	#255,D7
	BLE.S	L284
L286:
	MOVE	#4,D6
	BRA.S	L287
L288:
	MOVE	#5,D7
	BRA.S	L290
L291:
	MOVE	#1,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#17,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
	AND	#1,D0
	BEQ.S	L293
	MOVE	#25,D0
	BRA.S	L294
L293:
	MOVE	#23,D0
L294:
	MOVE.B	D0,4(A3)
	MOVE	D6,D5
	BRA.S	L295
L296:
	JSR	F445_xxxx_(PC)
L295:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L296
L297:
L290:
	SUBQ	#1,D7
	BNE.S	L291
L292:
L287:
	SUBQ	#1,D6
	BNE.S	L288
L289:
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-128,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	MOVE	#255,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	#255,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	JSR	F445_xxxx_(PC)
	MOVE.B	#26,4(A3)
	JSR	F445_xxxx_(PC)
	MOVE	#1,G077_B_DoN(A4)
	JSR	F445_xxxx_(PC)
	CLR	D7
	BRA.S	L298
L299:
	CLR	D6
	BRA.S	L302
L303:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-2,D0
	BEQ.S	L306
	MOVE	D7,D0
	CMP	-4(A6),D0
	BNE.S	L307
	MOVE	D6,D0
	CMP	-6(A6),D0
	BEQ.S	L306
L307:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
L306:
L304:
	ADDQ	#1,D6
L302:
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BLT.S	L303
L305:
L300:
	ADDQ	#1,D7
L298:
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BLT.S	L299
L301:
	JSR	F445_xxxx_(PC)
	CLR	-(A7)
	CLR	-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CLR	D7
	BRA.S	L308
L309:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#2,D0
	BNE.S	L311
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	D4,(A0)
L311:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L308:
	CMPI	#-2,D4
	BNE.S	L309
L310:
	MOVE.B	#65,-9(A6)
	MOVE	D7,D5
	BRA.S	L312
L313:
	CLR	D6
	BRA.S	L315
L316:
	MOVE	#-32767,-(A7)
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-26(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	PEA	-226(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	-225(A6),D0
	MOVE.B	-9(A6),D1
	EXT	D1
	EXT	D0
	CMP	D1,D0
	BNE.S	L319
	JSR	F043_aahz_(PC)
	MOVE.B	#10,-225(A6)
	PEA	-225(A6)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	JSR	F445_xxxx_(PC)
	MOVE	#780,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	ADDQ.B	#1,-9(A6)
	BRA.S	L318
L319:
L317:
	ADDQ	#1,D6
L315:
	MOVE	D6,D0
	CMP	D5,D0
	BLT.S	L316
L318:
L312:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L313
L314:
	MOVE	#600,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	CLR	G524_B_Res(A4)
	MOVE	#1,-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L270:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$269:	.EQU	#-226
