BSS SEG "bss"
G233_ai_Gr:/* global */
	.WORD	#8
G234_ai_Gr:/* global */
	.WORD	#8
G235_auc_G:/* global */
	.WORD	#16
G236_auc_G:/* global */
	.WORD	#16
G237_as_Gr:/* global */
	.WORD	#1080
G238_as_Gr:/* global */
	.WORD	#276
G239_as_Gr:/* global */
	.WORD	#232
G240_i_Gra:/* global */
	.WORD	#2
G241_ac_Gr:/* global */
	.WORD	#54
G242_ai_Gr:/* global */
	.WORD	#16
G243_as_Gr:/* global */
	.WORD	#702
G244_auc_G:/* global */
	.WORD	#8
G245_aui_G:/* global */
	.WORD	#6
G246_aui_G:/* global */
	.WORD	#4
G247_aui_G:/* global */
	.WORD	#4
G248_aui_G:/* global */
	.WORD	#14
G249_aui_G:/* global */
	.WORD	#10
G250_aui_G:/* global */
	.WORD	#6
G251_aui_G:/* global */
	.WORD	#6
G252_aui_G:/* global */
	.WORD	#8
G253_aui_G:/* global */
	.WORD	#22
G254_as_Gr:/* global */
	.WORD	#8
G255_aac_G:/* global */
	.WORD	#256
G256_aac_G:/* global */
	.WORD	#64
G257_aac_G:/* global */
	.WORD	#256
G258_auc_G:/* global */
	.WORD	#4
G259_i_Gra:/* global */
	.WORD	#2
G260_pui_D:/* global */
	.WORD	#4
G261_auc_C:/* global */
	.WORD	#16
G262_auc_C:/* global */
	.WORD	#16
G263_auc_C:/* global */
	.WORD	#18
G264_puc_C:/* global */
	.WORD	#4
G265_i_Cur:/* global */
	.WORD	#2
G266_i_Cur:/* global */
	.WORD	#2
G267_ai_Cu:/* global */
	.WORD	#6
G268_ai_Cu:/* global */
	.WORD	#2
G269_ps_Cu:/* global */
	.WORD	#4
G270_pui_C:/* global */
	.WORD	#4
G271_ppuc_:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#-1,G272_i_Cur(A4)
BSS SEG "bss"
G272_i_Cur:/* global */
	.WORD	#2
G273_i_Cur:/* global */
	.WORD	#2
G274_i_Cur:/* global */
	.WORD	#2
G275_as_Cu:/* global */
	.WORD	#4
G276_puc_D:/* global */
	.WORD	#4
G277_ps_Du:/* global */
	.WORD	#4
G278_ps_Du:/* global */
	.WORD	#4
G279_pppuc:/* global */
	.WORD	#4
G280_pui_D:/* global */
	.WORD	#4
G281_pi_Du:/* global */
	.WORD	#4
G282_ui_Du:/* global */
	.WORD	#2
G283_pT_Sq:/* global */
	.WORD	#4
G284_apuc_:/* global */
	.WORD	#64
CODE SEG "dunman"
F139_aqzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	A3,D6
	MOVE.L	D6,A0
	MOVE.B	4(A0),D6
	AND	#255,D6
	MOVE	10(A6),D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	8(A2),D0
	AND	#1984,D0
	LSR	#6,D0
	MOVE	10(A6),D1
	ASL.L	#2,D1
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D1,A0
	ASL.L	#2,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE	8(A2),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	AND.L	#65535,D1
	ADD.L	D1,D0
	ADDQ.L	#1,D0
	MOVE.L	D0,A3
	MOVE	12(A2),D7
	AND	#240,D7
	LSR	#4,D7
	BRA.S	L2
L3:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	D6,D0
	BNE.S	L6
	MOVE	#1,D0
	BRA.S	L1
L6:
L4:
	SUBQ	#1,D7
L2:
	CMPI	#0,D7
	BGT.S	L3
L5:
	MOVE	#0,D0
L1:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F140_yzzz_:/* global */
	LINK	A6,L$7
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	CMPI	#-1,D7
	BNE.S	L9
	MOVE	#0,D0
	BRA	L8(PC)
L9:
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L10:
	CMP	#5,D0
	BEQ.S	L11
	BRA.S	L13
L11:
	MOVE.L	A3,D6
	MOVE.L	D6,A0
	MOVE	2(A0),D6
	AND	#127,D6
	MULS	#6,D6
	LEA	G238_as_Gr(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	BRA	L12(PC)
	BRA.S	L14
L13:
	CMP	#6,D0
	BEQ.S	L14
	BRA.S	L15
L14:
	MOVE.L	A3,D6
	MOVE.L	D6,A0
	MOVE	2(A0),D6
	AND	#127,D6
	ASL.L	#2,D6
	LEA	G239_as_Gr(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	BRA	L12(PC)
	BRA.S	L16
L15:
	CMP	#10,D0
	BEQ.S	L16
	BRA.S	L17
L16:
	MOVE	2(A3),D6
	AND	#127,D6
	LEA	G241_ac_Gr(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE	2(A3),D0
	AND	#127,D0
	CMPI	#1,D0
	BNE.S	L19
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	ASL	#1,D0
	ADD	D0,D6
L19:
	BRA.S	L12
	BRA.S	L18
L17:
	CMP	#9,D0
	BEQ.S	L18
	BRA.S	L20
L18:
	MOVE	#50,D6
	MOVE.L	A3,D7
	MOVE.L	D7,A0
	MOVE	2(A0),D7
	BRA.S	L22
L23:
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	ADD	D0,D6
L24:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L22:
	CMPI	#-2,D7
	BNE.S	L23
L25:
	BRA.S	L12
	BRA.S	L21
L20:
	CMP	#8,D0
	BEQ.S	L21
	BRA.S	L26
L21:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#32512,D0
	LSR	#8,D0
	CMPI	#20,D0
	BNE.S	L28
	MOVE	#1,D6
	BRA.S	L29
L28:
	MOVE	#3,D6
L29:
	BRA.S	L12
	BRA.S	L27
L26:
	CMP	#7,D0
	BEQ.S	L27
	BRA.S	L30
L27:
	MOVE	#1,D6
L30:
L31:
L12:
	MOVE	D6,D0
L8:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$7:	.EQU	#0
F141_anzz_:/* global */
	LINK	A6,L$32
	MOVE.L	A3,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	8(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L34:
	CMP	#7,D0
	BEQ.S	L35
	BRA.S	L37
L35:
	MOVE	#0,D0
	BRA	L33(PC)
	BRA.S	L38
L37:
	CMP	#9,D0
	BEQ.S	L38
	BRA.S	L39
L38:
	MOVE	#1,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	4(A0),D1
	AND	#6,D1
	LSR	#1,D1
	ADD	D1,D0
	BRA	L33(PC)
	BRA.S	L40
L39:
	CMP	#10,D0
	BEQ.S	L40
	BRA.S	L41
L40:
	MOVE	#127,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#127,D1
	ADD	D1,D0
	BRA.S	L33
	BRA.S	L42
L41:
	CMP	#5,D0
	BEQ.S	L42
	BRA.S	L43
L42:
	MOVE	#23,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#127,D1
	ADD	D1,D0
	BRA.S	L33
	BRA.S	L44
L43:
	CMP	#6,D0
	BEQ.S	L44
	BRA.S	L45
L44:
	MOVE	#69,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#127,D1
	ADD	D1,D0
	BRA.S	L33
	BRA.S	L46
L45:
	CMP	#8,D0
	BEQ.S	L46
	BRA.S	L47
L46:
	MOVE	#2,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#32512,D1
	LSR	#8,D1
	ADD	D1,D0
	BRA.S	L33
L48:
	MOVE	#-1,D0
	BRA.S	L33
	BRA.S	L49
L47:
	BRA.S	L48
L49:
L36:
L33:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$32:	.EQU	#0
F142_aqzz_:/* global */
	LINK	A6,L$50
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#15,D0
	BNE.S	L52
	CMPI	#-128,D7
	BNE.S	L53
	MOVE	#-11,D0
	BRA.S	L51
L53:
	CMPI	#-127,D7
	BNE.S	L54
	MOVE	#-13,D0
	BRA.S	L51
L54:
	CMPI	#-126,D7
	BNE.S	L55
	MOVE	#-4,D0
	BRA.S	L51
L55:
	CMPI	#-122,D7
	BEQ.S	L57
	CMPI	#-121,D7
	BNE.S	L56
L57:
	MOVE	#-14,D0
	BRA.S	L51
L56:
	MOVE	#-12,D0
	BRA.S	L51
	BRA.S	L58
L52:
	CMPI	#5,D6
	BNE.S	L59
	MOVE	D7,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	4(A3),D5
	LSR	#8,D5
	AND	#31,D5
	BEQ.S	L60
	MOVE	D5,D0
	NEG	D0
	BRA.S	L51
L60:
L59:
L58:
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
L51:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$50:	.EQU	#0
F143_mzzz_:/* global */
	LINK	A6,L$61
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	1(A3),D7
	AND	#255,D7
	MOVE	12(A6),D0
	BEQ.S	L63
	MOVE.B	2(A3),D0
	AND	#255,D0
	AND	#7,D0
	ADDQ	#4,D0
	MOVE	D0,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L63:
	MOVE	D7,D0
L62:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$61:	.EQU	#0
F144_amzz_:/* global */
	LINK	A6,L$64
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L65:
	UNLK	A6
	RTS
L$64:	.EQU	#-4
F145_rzzz_:/* global */
	LINK	A6,L$66
	MOVE	D7,-(A7)
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D7
	AND	#255,D7
	MOVE	12(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L68
	MOVE.B	D7,D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	MOVE.B	3(A0),D7
L68:
	MOVE.B	D7,D0
	AND	#255,D0
L67:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$66:	.EQU	#0
F146_aczz_:/* global */
	LINK	A6,L$69
	MOVE	14(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L71
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D1
	AND	#255,D1
	MULS	#16,D1
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,3(A0)
	BRA.S	L72
L71:
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MOVE.B	D0,5(A0)
L72:
L70:
	UNLK	A6
	RTS
L$69:	.EQU	#0
F147_aawz_:/* global */
	LINK	A6,L$73
	MOVE	12(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L75
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	BRA.S	L74
L75:
	MOVE.L	8(A6),A0
	MOVE	14(A0),D0
	AND	#768,D0
	LSR	#8,D0
	LEA	G258_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
L74:
	UNLK	A6
	RTS
L$73:	.EQU	#0
F148_aayz_:/* global */
	LINK	A6,L$76
	MOVE	14(A6),D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L78
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MOVE.B	5(A0),D1
	AND	#255,D1
	MULS	#16,D1
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,2(A0)
	BRA.S	L79
L78:
	MOVE	12(A6),D0
	AND	#3,D0
	MOVE.L	8(A6),A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-769,14(A0)
	OR	D3,14(A0)
L79:
L77:
	UNLK	A6
	RTS
L$76:	.EQU	#0
F149_aawz_:/* global */
	LINK	A6,L$80
	MOVE	D7,-(A7)
	CMPI	#0,8(A6)
	BLT.S	L82
	CLR	D7
	BRA.S	L83
L84:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G267_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	CMP	8(A6),D0
	BNE.S	L87
	MOVE	#1,D0
	BRA.S	L81
L87:
L85:
	ADDQ	#1,D7
L83:
	CMPI	#3,D7
	BLT.S	L84
L86:
L82:
	MOVE	#0,D0
L81:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$80:	.EQU	#0
F150_wzzz_:/* global */
	LINK	A6,L$88
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE.L	14(A6),A3
	MOVE.L	18(A6),A2
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D6,D1
	MOVE	(A3),D0
	ADD	D1,D0
	MOVE	D0,(A3)
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D6,D1
	MOVE	(A2),D0
	ADD	D1,D0
	MOVE	D0,(A2)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,D7
	MOVE	D7,D0
	AND	#3,D0
	MOVE	D0,D7
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D5,D1
	MOVE	(A3),D0
	ADD	D1,D0
	MOVE	D0,(A3)
	MOVE	D7,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	D5,D1
	MOVE	(A2),D0
	ADD	D1,D0
	MOVE	D0,(A2)
L89:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$88:	.EQU	#0
F151_rzzz_:/* global */
	LINK	A6,L$90
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CMPI	#0,D6
	SGE	D4
	TST.B	D4
	BEQ.S	L92
	MOVE	D6,D4
	CMP	G274_i_Cur(A4),D4
	SLT	D4
	TST.B	D4
L92:
	AND	#1,D4
	CMPI	#0,D7
	SGE	D0
	TST.B	D0
	BEQ.S	L94
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	SLT	D0
	TST.B	D0
L94:
	AND	#1,D0
	MOVE	D0,D5
	BEQ.S	L93
	MOVE	D4,D0
	BEQ.S	L93
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	BRA	L91(PC)
L93:
	MOVE	D4,D0
	BEQ.S	L95
	CMPI	#-1,D7
	BNE.S	L98
	MOVE.L	G271_ppuc_(A4),A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D4
	CMPI	#1,D0
	BEQ.S	L97
L98:
	CMPI	#2,D4
	BNE.S	L96
L97:
	MOVE	#4,D0
	BRA	L91(PC)
L96:
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BNE.S	L101
	MOVE	G273_i_Cur(A4),D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	-4(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D4
	CMPI	#1,D0
	BEQ.S	L100
L101:
	CMPI	#2,D4
	BNE.S	L99
L100:
	MOVE	#1,D0
	BRA.S	L91
L99:
	BRA.S	L102
L95:
	MOVE	D5,D0
	BEQ.S	L103
	CMPI	#-1,D6
	BNE.S	L106
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D5
	CMPI	#1,D0
	BEQ.S	L105
L106:
	CMPI	#2,D5
	BNE.S	L104
L105:
	MOVE	#2,D0
	BRA.S	L91
L104:
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BNE.S	L109
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	G274_i_Cur(A4),A0
	MOVE.B	-1(A0),D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D5
	CMPI	#1,D0
	BEQ.S	L108
L109:
	CMPI	#2,D5
	BNE.S	L107
L108:
	MOVE	#8,D0
	BRA.S	L91
L107:
L103:
L102:
	MOVE	#0,D0
L91:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$90:	.EQU	#0
F152_xxxx_:/* global */
	LINK	A6,L$110
	PEA	16(A6)
	PEA	14(A6)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
L111:
	UNLK	A6
	RTS
L$110:	.EQU	#0
F153_yzzz_:/* global */
	LINK	A6,L$112
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F152_xxxx_(PC)
	ADDA	#10,A7
	AND	#255,D0
	ASR	#5,D0
L113:
	UNLK	A6
	RTS
L$112:	.EQU	#0
F154_afzz_:/* global */
	LINK	A6,L$114
	MOVEM.L	A3/D7-D4,-(A7)
	CMPI	#255,G309_i_Par(A4)
	BNE.S	L116
	MOVE	#-1,D0
	BRA	L115(PC)
L116:
	MOVE.L	G277_ps_Du(A4),D0
	MOVE	8(A6),D1
	MULS	#16,D1
	ADD.L	D1,D0
	MOVE.L	D0,A3
	MOVE.B	6(A3),D7
	MOVE.L	12(A6),A0
	AND	#255,D7
	ADD	(A0),D7
	MOVE.B	7(A3),D6
	MOVE.L	16(A6),A0
	AND	#255,D6
	ADD	(A0),D6
	MOVE	8(A3),D5
	AND	#63,D5
	ADD	10(A6),D5
	MOVE	#0,D0
	MOVE	D0,-2(A6)
	MOVE.L	G277_ps_Du(A4),D0
	MOVE.L	D0,A3
	BRA	L117(PC)
L118:
	MOVE	8(A3),D0
	AND	#63,D0
	MOVE	D5,D1
	CMP	D1,D0
	BNE.S	L120
	MOVE	D7,D0
	MOVE.B	6(A3),D1
	AND	#255,D1
	MOVE	D1,D4
	CMP	D1,D0
	BLT.S	L120
	MOVE	D4,D0
	MOVE	8(A3),D1
	AND	#1984,D1
	LSR	#6,D1
	ADD	D1,D0
	MOVE	D0,-12(A6)
	MOVE	D7,D0
	CMP	-12(A6),D0
	BHI.S	L120
	MOVE	D6,D0
	MOVE.B	7(A3),D1
	AND	#255,D1
	MOVE	D1,D4
	CMP	D1,D0
	BLT.S	L120
	MOVE	D4,D0
	MOVE	8(A3),D1
	AND	#-2048,D1
	LSR	#3,D1
	LSR	#8,D1
	ADD	D1,D0
	MOVE	D0,-12(A6)
	MOVE	D6,D0
	CMP	-12(A6),D0
	BHI.S	L120
	MOVE	D6,D0
	SUB	D4,D0
	MOVE.L	16(A6),A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	MOVE.B	6(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE.L	12(A6),A0
	MOVE	D0,(A0)
	MOVE	-2(A6),D0
	BRA.S	L115
L120:
	MOVE	-2(A6),D0
	ADDQ	#1,-2(A6)
	MOVE.L	A3,D0
	ADDA	#16,A3
L117:
	MOVE	-2(A6),D0
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BLT	L118(PC)
L119:
	MOVE	#-1,D0
L115:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$114:	.EQU	#-12
F155_ahzz_:/* global */
	LINK	A6,L$121
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	AND	#8,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D4
	BEQ.S	L123
	MOVE	D7,D0
	ADD	G233_ai_Gr+2(A4),D0
	MOVE	D0,D7
	MOVE	D6,D0
	ADD	G234_ai_Gr+2(A4),D0
	MOVE	D0,D6
	BRA.S	L124
L123:
	MOVE	D7,D0
	ADD	G233_ai_Gr(A4),D0
	MOVE	D0,D7
	MOVE	D6,D0
	ADD	G234_ai_Gr(A4),D0
	MOVE	D0,D6
L124:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D5
	CMPI	#0,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L125
	CMPI	#3,D5
	SEQ	D0
	TST.B	D0
L125:
	AND	#1,D0
	ASL	#1,D0
	ADD	D4,D0
L122:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$121:	.EQU	#0
F156_afzz_:/* global */
	LINK	A6,L$126
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#1023,D0
	MOVE	D7,D1
	AND	#15360,D1
	LSR	#2,D1
	LSR	#8,D1
	LEA	G235_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULU	D1,D0
	MOVE	D0,-10(A6)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE	-10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
L127:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$126:	.EQU	#-10
F157_rzzz_:/* global */
	LINK	A6,L$128
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
L129:
	UNLK	A6
	RTS
L$128:	.EQU	#0
F158_ayzz_:/* global */
	LINK	A6,L$130
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
L131:
	UNLK	A6
	RTS
L$130:	.EQU	#-4
F159_rzzz_:/* global */
	LINK	A6,L$132
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	(A0),D0
L133:
	UNLK	A6
	RTS
L$132:	.EQU	#-4
F160_xxxx_:/* global */
	LINK	A6,L$134
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A3
	CMPI	#0,D7
	BLT.S	L137
	MOVE	D7,D0
	CMP	G273_i_Cur(A4),D0
	BGE.S	L137
	CMPI	#0,D6
	BLT.S	L137
	MOVE	D6,D0
	CMP	G274_i_Cur(A4),D0
	BGE.S	L137
	MOVE.L	A3,A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#16,D0
	BNE.S	L136
L137:
	MOVE	#-1,D0
	BRA.S	L135
L136:
	CLR	D4
	MOVE	D7,D5
	ASL.L	#1,D5
	MOVE.L	G270_pui_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	BRA.S	L138
L139:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L141
	ADDQ	#1,D5
L141:
L138:
	MOVE	D4,D0
	ADDQ	#1,D4
	CMP	D6,D0
	BNE.S	L139
L140:
	MOVE	D5,D0
L135:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$134:	.EQU	#0
F161_szzz_:/* global */
	LINK	A6,L$142
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F160_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-2(A6)
	CMPI	#-1,D0
	BNE.S	L144
	MOVE	#-2,D0
	BRA.S	L143
L144:
	MOVE	-2(A6),D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
L143:
	UNLK	A6
	RTS
L$142:	.EQU	#-2
F162_afzz_:/* global */
	LINK	A6,L$145
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L147
L148:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L147:
	CMPI	#-2,D7
	BEQ.S	L150
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#4,D0
	BCS.S	L148
L150:
L149:
	MOVE	D7,D0
L146:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$145:	.EQU	#0
F163_amzz_:/* global */
	LINK	A6,L$151
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CMPI	#-2,8(A6)
	BNE.S	L153
	BRA	L152(PC)
L153:
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	#-2,(A0)
	CMPI	#0,D7
	BLT	L154(PC)
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L155
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,10(A6)
	BRA	L156(PC)
L155:
	ORI.B	#16,(A2)
	MOVE.L	G270_pui_C(A4),D0
	MOVE	D7,D1
	EXT.L	D1
	ASL.L	#1,D1
	ADD.L	D1,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,A3
	MOVE	G282_ui_Du(A4),D4
	MOVE	G272_i_Cur(A4),D1
	ASL.L	#1,D1
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	ADD	D7,D1
	SUB	D1,D4
	SUBQ	#1,D4
	BRA.S	L157
L158:
	ADDQ	#1,(A3)+
L157:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L158
L159:
	CLR	-6(A6)
	MOVE	D6,D0
	EXT.L	D0
	SUBA.L	D0,A2
	MOVE	D7,D4
	ASL.L	#1,D4
	MOVE.L	G270_pui_C(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	BRA.S	L160
L161:
	MOVE.B	(A2)+,D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L163
	ADDQ	#1,D4
L163:
L160:
	MOVE	-6(A6),D0
	ADDQ	#1,-6(A6)
	MOVE	D6,D1
	CMP	D1,D0
	BNE.S	L161
L162:
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	SUB	D4,D0
	SUBQ	#1,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	8(A6),(A3)
	BRA.S	L152
L156:
L154:
	MOVE	10(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	BRA.S	L164
L165:
L166:
	MOVE	D5,D0
	MOVE	D0,10(A6)
	MOVE	D0,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
L164:
	CMPI	#-2,D5
	BNE.S	L165
L167:
	MOVE	10(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	8(A6),(A0)
L152:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$151:	.EQU	#-6
F164_dzzz_:/* global */
	LINK	A6,L$168
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	CMPI	#-2,D7
	BNE.S	L170
	BRA	L169(PC)
L170:
	AND	#16383,D7
	CMPI	#0,12(A6)
	BLT	L171(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F160_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#-2,(A3)
	BNE	L172(PC)
	MOVE	(A2),D0
	AND	#16383,D0
	CMP	D7,D0
	BNE	L172(PC)
	MOVE	12(A6),D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	14(A6),A0
	ANDI.B	#-17,(A0)
	MOVE.L	G278_ps_Du(A4),A0
	MOVE	10(A0),D0
	SUBQ	#1,D0
	MOVE	D0,D5
	SUB	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	A2,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	MOVE.L	G270_pui_C(A4),D0
	MOVE	12(A6),D1
	EXT.L	D1
	ASL.L	#1,D1
	ADD.L	D1,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,A2
	MOVE	G282_ui_Du(A4),D5
	MOVE	G272_i_Cur(A4),D1
	ASL.L	#1,D1
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	ADD	12(A6),D1
	SUB	D1,D5
	SUBQ	#1,D5
	BRA.S	L173
L174:
	SUBQ	#1,(A2)+
L173:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L174
L175:
	BRA.S	L25T164_011
L172:
	MOVE	(A2),D0
	AND	#16383,D0
	CMP	D7,D0
	BNE.S	L176
	MOVE	(A3),(A2)
	BRA.S	L25T164_011
L176:
	MOVE	(A2),10(A6)
L171:
	MOVE	10(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	BRA.S	L177
L178:
	CMPI	#-2,D4
	BEQ.S	L182
	CMPI	#-1,D4
	BNE.S	L181
L182:
	BRA.S	L25T164_011
L181:
L179:
	MOVE	D4,D0
	MOVE	D0,10(A6)
	MOVE	D0,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L177:
	MOVE	D4,D0
	AND	#16383,D0
	CMP	D7,D0
	BNE.S	L178
L180:
	MOVE	10(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,(A3)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
L25T164_011:
	MOVE	#-2,(A3)
L169:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$168:	.EQU	#0
F165_xxxx_:/* global */
	LINK	A6,L$183
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CMPI	#15,8(A6)
	BNE.S	L185
	MOVE	#-1,D0
	BRA	L184(PC)
L185:
	MOVE	G272_i_Cur(A4),-8(A6)
	MOVE	8(A6),D0
	LEA	G294_auc_L(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L186
	ADDQ	#1,D4
	MOVE	D4,D0
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BCS.S	L186
	CLR	D4
L186:
	MOVE	D4,-6(A6)
L187:
	MOVE	D4,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	MOVE	D0,-10(A6)
	MOVE	D4,D0
	MULS	#16,D0
	MOVE.L	G277_ps_Du(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#-2048,D0
	LSR	#3,D0
	LSR	#8,D0
	MOVE	D0,-12(A6)
	MOVE	D4,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	MOVE.L	(A0),A3
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#1,D0
	MOVE.L	G280_pui_D(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#1,D0
	MOVE.L	G283_pT_Sq(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CLR	D7
	BRA	L190(PC)
L191:
	CLR	D6
	BRA	L194(PC)
L195:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	AND	#16,D0
	BEQ	L198(PC)
	MOVE	(A2)+,D5
	MOVE	D4,D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L199
	MOVE	D7,D0
	SUB	G306_i_Par(A4),D0
	ADDQ	#5,D0
	CMPI	#10,D0
	BHI.S	L199
	MOVE	D6,D0
	SUB	G307_i_Par(A4),D0
	ADDQ	#5,D0
	CMPI	#10,D0
	BHI.S	L199
	BRA	L200(PC)
L199:
L201:
	MOVE	D5,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMP	8(A6),D0
	BNE	L204(PC)
	MOVE	D5,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE	8(A6),D0
L205:
	CMP	#4,D0
	BEQ.S	L206
	BRA.S	L208
L206:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	14(A0),D0
	AND	#1024,D0
	LSR	#2,D0
	LSR	#8,D0
	BEQ.S	L210
	BRA	L202(PC)
L210:
	BRA.S	L209
L208:
	CMP	#14,D0
	BEQ.S	L209
	BRA.S	L211
L209:
	MOVE	D4,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#4,8(A6)
	BNE.S	L213
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F188_aozz_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F189_awzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L214
L213:
	MOVE	D5,-(A7)
	JSR	F214_pzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR.L	-(A7)
	MOVE	D5,-(A7)
	JSR	F215_lzzz_(PC)
	ADDA	#10,A7
L214:
	BRA	L207(PC)
	BRA.S	L212
L211:
	CMP	#6,D0
	BEQ.S	L212
	BRA.S	L215
L212:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L217
	BRA	L202(PC)
L217:
	BRA.S	L26T165_026
	BRA.S	L216
L215:
	CMP	#5,D0
	BEQ.S	L216
	BRA.S	L218
L216:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L220
	BRA	L202(PC)
L220:
	BRA.S	L26T165_026
	BRA.S	L219
L218:
	CMP	#10,D0
	BEQ.S	L219
	BRA.S	L221
L219:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L223
	BRA.S	L202
L223:
	BRA.S	L26T165_026
	BRA.S	L222
L221:
	CMP	#8,D0
	BEQ.S	L222
	BRA.S	L224
L222:
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#-32768,D0
	LSR	#7,D0
	LSR	#8,D0
	BEQ.S	L226
	BRA.S	L202
L226:
L26T165_026:
	MOVE	D4,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L224:
L225:
L207:
	MOVE	-8(A6),-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D4,D0
	MOVE	8(A6),D1
	LEA	G294_auc_L(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D5,D0
	AND	#16383,D0
	BRA	L184(PC)
L204:
L202:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-2,D0
	BNE	L201(PC)
L203:
L200:
L198:
L196:
	ADDQ	#1,D6
L194:
	MOVE	D6,D0
	CMP	-12(A6),D0
	BLS	L195(PC)
L197:
L192:
	ADDQ	#1,D7
L190:
	MOVE	D7,D0
	CMP	-10(A6),D0
	BLS	L191(PC)
L193:
	MOVE	D4,D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L228
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#1,D0
	BGT.S	L227
L228:
	MOVE	D4,D0
	MOVE	8(A6),D1
	LEA	G294_auc_L(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	#-1,D0
	BRA.S	L184
L227:
L229:
	ADDQ	#1,D4
	MOVE	D4,D0
	MOVE.L	G278_ps_Du(A4),A0
	MOVE.B	4(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BCS.S	L232
	CLR	D4
L232:
L230:
	MOVE	D4,D0
	MOVE	G309_i_Par(A4),D1
	CMP	D1,D0
	BEQ.S	L229
L231:
	MOVE	D4,D0
	CMP	-6(A6),D0
	BNE.S	L233
	MOVE	G309_i_Par(A4),D4
L233:
L188:
	BRA	L187(PC)
L189:
L184:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$183:	.EQU	#-12
F166_szzz_:/* global */
	LINK	A6,L$234
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D4
	MOVE.L	G278_ps_Du(A4),A0
	ASL.L	#1,D4
	LEA	12(A0),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	CMPI	#-32758,D7
	BNE.S	L236
	MOVE	#10,D7
	BRA.S	L237
L236:
	CMPI	#10,D7
	BNE.S	L238
	SUBQ	#3,D4
L238:
L237:
	MOVE	D4,D6
	MOVE	D7,D5
	LEA	G235_auc_G(A4),A0
	ADDA	D5,A0
	MOVE.B	(A0),D5
	AND	#255,D5
	ASR	#1,D5
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G284_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
L239:
	CMPI	#-1,(A3)
	BNE.S	L242
	MOVE	D7,D0
	ASL	#2,D0
	ASL	#8,D0
	MOVE	D4,D1
	SUB	D6,D1
	OR	D1,D0
	MOVE	D0,-2(A6)
	BRA.S	L241
L242:
	SUBQ	#1,D6
	BEQ.S	L243
	MOVE	D5,D0
	EXT.L	D0
	ASL.L	#1,D0
	ADDA.L	D0,A3
	BRA.S	L244
L243:
	MOVE	D7,-(A7)
	JSR	F165_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#-1,D0
	BNE.S	L245
	MOVE	#-1,D0
	BRA.S	L235
L245:
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L241
L244:
L240:
	BRA.S	L239
L241:
	MOVE	D5,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-2,(A3)
	MOVE	-2(A6),D0
L235:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$234:	.EQU	#-2
F167_aozz_:/* global */
	LINK	A6,L$246
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	#5,D5
	CMPI	#4,D7
	BCS.S	L248
	CMPI	#7,D7
	BHI.S	L248
	MOVE	#4,D7
L248:
	MOVE	D7,D0
L249:
	CMP	#54,D0
	BEQ.S	L250
	BRA.S	L252
L250:
	MOVE	#30,D6
	BRA	L251(PC)
	BRA.S	L253
L252:
	CMP	#128,D0
	BEQ.S	L253
	BRA.S	L254
L253:
	MOVE	#25,D6
	MOVE	#10,D5
	BRA.S	L251
	BRA.S	L255
L254:
	CMP	#51,D0
	BEQ.S	L255
	BRA.S	L256
L255:
	MOVE	#27,D6
	BRA.S	L251
	BRA.S	L257
L256:
	CMP	#52,D0
	BEQ.S	L257
	BRA.S	L258
L257:
	MOVE	#28,D6
	BRA.S	L251
	BRA.S	L259
L258:
	CMP	#55,D0
	BEQ.S	L259
	BRA.S	L260
L259:
	MOVE	#31,D6
	BRA.S	L251
	BRA.S	L261
L260:
	CMP	#56,D0
	BEQ.S	L261
	BRA.S	L262
L261:
	MOVE	#32,D6
	BRA.S	L251
	BRA.S	L263
L262:
	CMP	#32,D0
	BEQ.S	L263
	BRA.S	L264
L263:
	MOVE	#8,D6
	BRA.S	L251
	BRA.S	L265
L264:
	CMP	#4,D0
	BEQ.S	L265
	BRA.S	L266
L265:
	MOVE	#2,D6
	BRA.S	L251
L267:
	MOVE	#-1,D0
	BRA.S	L247
	BRA.S	L268
L266:
	BRA.S	L267
L268:
L251:
	MOVE	D5,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#-1,D0
	BNE.S	L269
	MOVE	#-1,D0
	BRA.S	L247
L269:
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D6,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A3)
	OR	D3,2(A3)
	CMPI	#4,D7
	BNE.S	L270
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#-32768,D0
	LSR	#7,D0
	LSR	#8,D0
	BEQ.S	L270
	MOVE	#15,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-15361,2(A0)
	OR	D3,2(A0)
L270:
	MOVE	D4,D0
L247:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$246:	.EQU	#0
F168_ajzz_:/* global */
	LINK	A6,L$271
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	14(A6),D7
	MOVE	12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+8(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-12(A6),A0
	MOVEQ	#1,D0
	JSR	_blockmv(PC)
	MOVE	-10(A6),D0
	AND	#1,D0
	BNE.S	L274
	MOVE	D7,D0
	AND	#-32768,D0
	BEQ	L273(PC)
L274:
	AND	#32767,D7
	CMPI	#1,D7
	BNE.S	L275
	MOVE.B	#10,(A3)+
	MOVE.B	#32,-1(A6)
	BRA.S	L276
L275:
	CMPI	#0,D7
	BNE.S	L277
	MOVE.B	#-128,-1(A6)
	BRA.S	L278
L277:
	MOVE.B	#10,-1(A6)
L278:
L276:
	CLR	D5
	CLR	-4(A6)
	MOVE.L	G260_pui_D(A4),D0
	MOVE	-10(A6),D1
	AND	#-8,D1
	LSR	#3,D1
	AND.L	#65535,D1
	ASL.L	#1,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
L279:
	MOVE	D5,D0
	BNE.S	L282
	MOVE	(A2)+,D6
	MOVE	D6,D4
	LSR	#2,D4
	LSR	#8,D4
	AND	#31,D4
	BRA.S	L283
L282:
	CMPI	#1,D5
	BNE.S	L284
	MOVE	D6,D4
	LSR	#5,D4
	AND	#31,D4
	BRA.S	L285
L284:
	MOVE	D6,D4
	AND	#31,D4
L285:
L283:
	ADDQ	#1,D5
	MOVE	D5,D0
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	MOVE	D0,D5
	MOVE	-4(A6),D0
	BEQ.S	L286
	CLR.B	(A3)
	CMPI	#30,-4(A6)
	BNE.S	L287
	CMPI	#0,D7
	BEQ.S	L288
	MOVE	D4,D0
	ASL.L	#3,D0
	LEA	G255_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
	BRA.S	L289
L288:
	MOVE	D4,D0
	ASL.L	#3,D0
	LEA	G257_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
L289:
	BRA.S	L290
L287:
	CMPI	#0,D7
	BEQ.S	L291
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G256_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
	BRA.S	L292
L291:
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G256_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
L292:
L290:
	MOVE.L	-8(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE.L	-8(A6),-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	EXT.L	D0
	ADDA.L	D0,A3
	CLR	-4(A6)
	BRA.S	L293
L286:
	CMPI	#28,D4
	BCC.S	L294
	CMPI	#0,D7
	BEQ.S	L295
	CMPI	#26,D4
	BNE.S	L296
	MOVE	#32,D4
	BRA.S	L297
L296:
	CMPI	#27,D4
	BNE.S	L298
	MOVE	#46,D4
	BRA.S	L299
L298:
	ADD	#65,D4
L299:
L297:
L295:
	MOVE	D4,D0
	MOVE.B	D0,(A3)+
	BRA.S	L300
L294:
	CMPI	#28,D4
	BNE.S	L301
	MOVE.B	-1(A6),(A3)+
	BRA.S	L302
L301:
	CMPI	#30,D4
	BHI.S	L303
	MOVE	D4,-4(A6)
	BRA.S	L304
L303:
	BRA.S	L281
L304:
L302:
L300:
L293:
L280:
	BRA	L279(PC)
L281:
L273:
	CMPI	#0,D7
	BNE.S	L305
	MOVE.B	#-127,(A3)
	BRA.S	L306
L305:
	CLR.B	(A3)
L306:
L272:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$271:	.EQU	#-12
F169_xxxx_:/* global */
	LINK	A6,L$307
	MOVE	8(A6),D0
	MULU	#31417,D0
	LSR	#1,D0
	MOVE	10(A6),D1
	MULU	#11,D1
	ADD	D1,D0
	MOVE.L	G278_ps_Du(A4),A0
	ADD	(A0),D0
	LSR	#2,D0
	AND.L	#65535,D0
	DIVU	12(A6),D0
	SWAP	D0
L308:
	UNLK	A6
	RTS
L$307:	.EQU	#0
F170_xxxx_:/* global */
	LINK	A6,L$309
	MOVE	8(A6),D0
	BEQ.S	L311
	MOVE	16(A6),-(A7)
	MOVE	#3000,D0
	MOVE	G272_i_Cur(A4),D1
	ASL	#6,D1
	ADD	D1,D0
	ADD	G273_i_Cur(A4),D0
	ADD	G274_i_Cur(A4),D0
	MOVE	D0,-(A7)
	MOVE	#2000,D0
	MOVE	12(A6),D1
	ASL	#5,D1
	ADD	D1,D0
	ADD	14(A6),D0
	MOVE	D0,-(A7)
	JSR	F169_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-2(A6)
	CMP	10(A6),D0
	BGE.S	L311
	MOVE	-2(A6),D0
	ADDQ	#1,D0
	BRA.S	L310
L311:
	MOVE	#0,D0
L310:
	UNLK	A6
	RTS
L$309:	.EQU	#-2
F171_xxxx_:/* global */
	LINK	A6,L$312
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	18(A6),D7
	MOVE	20(A6),D6
	MOVE	22(A6),D5
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D4
	AND	#240,D4
	LSR	#4,D4
	MOVE	#30,-(A7)
	ADDQ	#1,D5
	MOVE	D5,D0
	ADDQ	#1,D7
	MOVE	D7,D1
	AND	#3,D1
	ADDQ	#1,D1
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,4(A3)
	MOVE	#30,-(A7)
	MOVE	D5,D0
	ADDQ	#1,D7
	MOVE	D7,D1
	AND	#3,D1
	ADDQ	#1,D1
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	MOVE	14(A6),-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,6(A3)
	MOVE	#30,-(A7)
	MOVE	D5,D0
	SUBQ	#1,D5
	ADDQ	#1,D7
	MOVE	D7,D1
	AND	#3,D1
	ADDQ	#1,D1
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D4,-(A7)
	MOVE	16(A6),-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,8(A3)
	MOVE	24(A6),D0
	BNE.S	L315
	CMPI	#0,D6
	BLT.S	L315
	MOVE	D6,D0
	CMP	G273_i_Cur(A4),D0
	BGE.S	L315
	CMPI	#0,D5
	BLT.S	L315
	MOVE	D5,D0
	CMP	G274_i_Cur(A4),D0
	BLT.S	L314
L315:
	MOVE	#2,D4
	BRA.S	L316
L317:
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F149_aawz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L320
	MOVE	D4,D0
	ASL.L	#1,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	CLR	(A0)
L320:
L318:
	ADDQ	#1,D4
L316:
	CMPI	#4,D4
	BLE.S	L317
L319:
L314:
L313:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$312:	.EQU	#0
F172_awzz_:/* global */
	LINK	A6,L$321
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	MOVE	#10,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-12(A6)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,D4
	MOVE.B	D4,D0
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,(A3)
L323:
	CMP	#0,D0
	BEQ.S	L324
	BRA	L326(PC)
L324:
	MOVE	D7,D0
L328:
	CMP	#0,D0
	BEQ.S	L329
	BRA.S	L331
L329:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#2,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#1,D0
	MOVE	D0,-6(A6)
	BRA	L330(PC)
	BRA.S	L332
L331:
	CMP	#1,D0
	BEQ.S	L332
	BRA.S	L333
L332:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#2,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#1,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-6(A6)
	BRA.S	L330
	BRA.S	L334
L333:
	CMP	#2,D0
	BEQ.S	L334
	BRA.S	L335
L334:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,-6(A6)
	BRA.S	L330
	BRA.S	L336
L335:
	CMP	#3,D0
	BEQ.S	L336
	BRA.S	L337
L336:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-2(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,-4(A6)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#2,D0
	MOVE	D0,-6(A6)
L337:
L338:
L330:
	CLR	G289_i_Dun(A4)
	CLR	-10(A6)
L33T172_010:
	MOVE	-10(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F171_xxxx_(PC)
	ADDA	#18,A7
	BRA	L339(PC)
L340:
	MOVE	-12(A6),D0
	LSR	#6,D0
	LSR	#8,D0
	SUB	D7,D0
	AND	#3,D0
	MOVE	D0,-4(A6)
	BEQ	L342(PC)
	CMPI	#2,-8(A6)
	BNE.S	L343
	MOVE	-12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+8(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#1,D0
	BEQ.S	L344
	MOVE	G265_i_Cur(A4),D0
	ADDQ	#1,D0
	MOVE	-4(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,2(A0)
	MOVE	-12(A6),G290_T_Dun(A4)
L344:
	BRA.S	L345
L343:
	MOVE	-12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+12(A4),D1
	ASL.L	#3,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	4(A2),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	-4(A6),D1
	ASL.L	#1,D1
	MOVE.L	A3,A0
	ADDA	D1,A0
	MOVE	D0,2(A0)
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#127,D0
	BNE.S	L346
	MOVE	2(A2),D0
	LSR	#7,D0
	ADDQ	#1,D0
	MOVE	D0,G289_i_Dun(A4)
L346:
L345:
L342:
	MOVE	-12(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
L339:
	CMPI	#-2,-12(A6)
	BEQ.S	L347
	MOVE	-12(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-8(A6)
	CMPI	#3,D0
	BLE	L340(PC)
L347:
L341:
	MOVE	-10(A6),D0
	BEQ.S	L348
	MOVE	G306_i_Par(A4),D0
	CMP	D6,D0
	BEQ.S	L348
	MOVE	G307_i_Par(A4),D0
	CMP	D5,D0
	BEQ.S	L348
	MOVE	#-2,2(A3)
	BRA	L322(PC)
L348:
	BRA	L325(PC)
	BRA.S	L327
L326:
	CMP	#2,D0
	BEQ.S	L327
	BRA.S	L349
L327:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L351
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,4(A3)
	AND.B	#1,D4
	BRA.S	L352
L351:
	MOVE	#1,(A3)
	MOVE.B	#1,D4
L352:
	BRA	L33T172_030(PC)
	BRA.S	L350
L349:
	CMP	#6,D0
	BEQ.S	L350
	BRA.S	L353
L350:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	BNE.S	L355
	CLR	(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-4(A6)
	MOVE	D0,-6(A6)
	MOVE	D0,-2(A6)
	MOVE	#1,-10(A6)
	BRA	L33T172_010(PC)
L355:
	MOVE	#1,(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L356
	MOVE	#8,D0
	BRA.S	L357
L356:
	MOVE	#0,D0
L357:
	MOVE.B	D0,D4
	BRA.S	L354
L353:
	CMP	#1,D0
	BEQ.S	L354
	BRA	L358(PC)
L354:
	MOVE	#30,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,-(A7)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	MOVE	D0,-(A7)
	JSR	F170_xxxx_(PC)
	ADDA	#10,A7
	MOVE	D0,8(A3)
L33T172_029:
	MOVE.B	#1,D4
L33T172_030:
	BRA.S	L360
L361:
	CMPI	#3,D7
	BNE.S	L363
	MOVE	-12(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+12(A4),D1
	ASL.L	#3,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	4(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE	D0,8(A3)
L363:
	MOVE	-12(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
L360:
	CMPI	#-2,-12(A6)
	BEQ.S	L364
	MOVE	-12(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D7
	CMPI	#3,D0
	BLE.S	L361
L364:
L362:
	BRA	L33T172_049(PC)
	BRA.S	L359
L358:
	CMP	#5,D0
	BEQ.S	L359
	BRA.S	L365
L359:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	BEQ.S	L367
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
L367:
	SNE	D0
	AND	#1,D0
	MOVE	D0,4(A3)
	BRA	L33T172_029(PC)
	BRA.S	L366
L365:
	CMP	#3,D0
	BEQ.S	L366
	BRA.S	L368
L366:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	ASR	#3,D0
	MOVE	D7,D1
	AND	#1,D1
	CMP	D1,D0
	BNE.S	L370
	MOVE	#18,D0
	BRA.S	L371
L370:
	MOVE	#19,D0
L371:
	MOVE	D0,(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#4,D0
	MOVE	D0,4(A3)
	CLR.B	D4
	BRA.S	L33T172_046
	BRA.S	L369
L368:
	CMP	#4,D0
	BEQ.S	L369
	BRA	L372(PC)
L369:
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#8,D0
	ASR	#3,D0
	MOVE	D7,D1
	AND	#1,D1
	CMP	D1,D0
	BNE.S	L374
	MOVE	#16,(A3)
	BRA.S	L375
L374:
	MOVE	#17,(A3)
	MOVE.B	D4,D0
	AND	#255,D0
	AND	#7,D0
	MOVE	D0,4(A3)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	AND	#1023,D0
	MOVE	D0,6(A3)
L375:
	MOVE.B	#1,D4
L33T172_046:
	BRA.S	L376
L377:
	MOVE	-12(A6),-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
L376:
	CMPI	#-2,-12(A6)
	BEQ.S	L379
	MOVE	-12(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BLS.S	L377
L379:
L378:
L33T172_049:
	MOVE.B	D4,D0
	BEQ.S	L380
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F315_arzz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,D4
	BEQ.S	L380
	AND	#255,D0
	SUBQ.B	#1,D4
	MOVE.B	D4,D0
	MOVE.B	G407_s_Par+3212(A4),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BLT.S	L380
	MOVE.B	D4,D0
	MOVE.B	G407_s_Par+3213(A4),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGE.S	L380
	ORI	#-32768,8(A3)
L380:
L372:
L373:
L325:
	MOVE	-12(A6),2(A3)
L322:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$321:	.EQU	#-12
F173_gzzz_:/* global */
	LINK	A6,L$381
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE	G272_i_Cur(A4),D0
	CMP	D7,D0
	BNE.S	L383
	BRA	L382(PC)
L383:
	MOVE	D7,G272_i_Cur(A4)
	MOVE	D7,D0
	ASL.L	#2,D0
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),G271_ppuc_(A4)
	MOVE.L	G277_ps_Du(A4),D0
	MOVE	D7,D1
	MULU	#16,D1
	ADD.L	D1,D0
	MOVE.L	D0,G269_ps_Cu(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	8(A0),D0
	AND	#1984,D0
	LSR	#6,D0
	ADDQ	#1,D0
	MOVE	D0,G273_i_Cur(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	8(A0),D0
	AND	#-2048,D0
	LSR	#3,D0
	LSR	#8,D0
	ADDQ	#1,D0
	MOVE	D0,G274_i_Cur(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#3840,D0
	LSR	#8,D0
	ASL.L	#1,D0
	LEA	G254_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	G275_as_Cu(A4),A0
	MOVEQ	#0,D0
	JSR	_blockmv(PC)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	ASL.L	#1,D0
	LEA	G254_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	G275_as_Cu+2(A4),A0
	MOVEQ	#0,D0
	JSR	_blockmv(PC)
	MOVE	D7,D0
	ASL.L	#1,D0
	MOVE.L	G281_pi_Du(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL.L	#1,D0
	MOVE.L	G280_pui_D(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,G270_pui_C(A4)
L382:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$381:	.EQU	#0
F174_aozz_:/* global */
	LINK	A6,L$384
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MOVE	D0,G309_i_Par(A4)
	MOVE	D0,-(A7)
	JSR	F173_gzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G273_i_Cur(A4),D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	-4(A0),D0
	MOVE	G274_i_Cur(A4),D3
	EXT.L	D3
	ADD.L	D3,D0
	MOVE.L	D0,A3
	MOVE.L	A3,G264_puc_C(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D0
	AND	#15,D0
	MOVE	D0,G265_i_Cur(A4)
	MOVE	D0,-(A7)
	PEA	G261_auc_C(A4)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D1
	AND	#240,D1
	LSR	#4,D1
	MOVE.L	A3,D0
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D0
	AND	#3840,D0
	LSR	#8,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	PEA	G262_auc_C(A4)
	MOVE.L	A3,D0
	MOVE	G265_i_Cur(A4),D3
	EXT.L	D3
	ADD.L	D3,D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#15,D0
	MOVE	D0,-(A7)
	PEA	G263_auc_C(A4)
	MOVE.L	A3,D0
	EXT.L	D6
	ADD.L	D6,D0
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	LEA	G261_auc_C(A4),A0
	ADDA	G265_i_Cur(A4),A0
	CLR.B	(A0)
L385:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$384:	.EQU	#0
