CODE SEG "timeline"
F221_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D6,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BEQ.S	L3
	CMPI	#3,D6
	BNE.S	L2
L3:
	MOVE	#0,D0
	BRA.S	L1
L2:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L4
L5:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE.S	L8
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+60(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	CMPI	#50,D0
	BNE.S	L8
	MOVE	#1,D0
	BRA.S	L1
L8:
L6:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L4:
	CMPI	#-2,D7
	BNE.S	L5
L7:
	MOVE	#0,D0
L1:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F222_xxxx_:/* global */
	LINK	A6,L$9
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE.S	L11
	MOVE	#0,D0
	BRA.S	L10
L11:
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+16(A4),D1
	MULS	#16,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#23,D0
	BNE.S	L12
	MOVE	D7,D0
	BRA.S	L10
L12:
	MOVE	#0,D0
L10:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$9:	.EQU	#0
F224_zzzz_:/* global */
	LINK	A6,L$13
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D4
	CMPI	#0,D0
	BEQ.S	L16
	CMPI	#3,D4
	BNE.S	L15
L16:
	BRA	L14(PC)
L15:
	MOVE	#15,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L17
	BRA	L14(PC)
L17:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#50,D0
	MOVE	D5,D1
	AND	#1023,D1
	MOVE.L	G284_apuc_+60(A4),D2
	ASL.L	#2,D1
	MOVE.L	D2,A0
	ADDA	D1,A0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A0)
	OR	D3,2(A0)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#100,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	#24,-6(A6)
	CLR.B	-5(A6)
	MOVE	D5,-2(A6)
	MOVE	D7,D0
	MOVE.B	D0,-4(A6)
	MOVE	D6,D0
	MOVE.B	D0,-3(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L18
	SUBQ	#1,D6
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L2T224_005
L18:
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L19
	SUBQ	#1,D7
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L2T224_005:
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D4
	BRA.S	L20
L19:
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L21
	ADDQ	#1,D7
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L2T224_008
L21:
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L22
	ADDQ	#1,D6
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L2T224_008:
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D4
	BRA.S	L23
L22:
	CLR	D4
L23:
L20:
	CMPI	#2,D4
	BNE.S	L24
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L24:
L14:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$13:	.EQU	#-10
F225_dzzz_:/* global */
	LINK	A6,L$25
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	#255,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#255,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-18(A6)
	BEQ	L27(PC)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-16(A6)
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE	D1,-14(A6)
	ADD	D1,D0
	MOVE.L	D0,-(A7)
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE	D1,-12(A6)
	ADD	D1,D0
	MOVE.L	D0,-(A7)
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE	D1,-10(A6)
	ADD	D1,D0
	MOVE	D0,-4(A6)
	BRA	L28(PC)
L29:
	MOVE	D7,D5
	MOVE	D6,D4
	MOVE	#5,D0
	MOVE	D0,-8(A6)
	JSR	F029_AA19_(PC)
	MOVE	D0,-6(A6)
	BRA.S	L31
L32:
	MOVE	-6(A6),D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L34
	MOVE	-6(A6),D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	#1,(A0)
	MOVE	-6(A6),D0
L35:
	CMP	#0,D0
	BEQ.S	L36
	BRA.S	L38
L36:
	SUBQ	#1,D5
	BRA.S	L37
	BRA.S	L39
L38:
	CMP	#1,D0
	BEQ.S	L39
	BRA.S	L40
L39:
	ADDQ	#1,D5
	BRA.S	L37
	BRA.S	L41
L40:
	CMP	#2,D0
	BEQ.S	L41
	BRA.S	L42
L41:
	SUBQ	#1,D4
	BRA.S	L37
	BRA.S	L43
L42:
	CMP	#3,D0
	BEQ.S	L43
	BRA.S	L44
L43:
	ADDQ	#1,D4
L44:
L45:
L37:
	BRA.S	L33
L34:
	MOVE	-6(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-6(A6)
L31:
	SUBQ	#1,-8(A6)
	BNE.S	L32
L33:
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,-2(A6)
	CMPI	#1,D0
	BEQ.S	L47
	CMPI	#5,-2(A6)
	BEQ.S	L47
	CMPI	#2,-2(A6)
	BEQ.S	L47
	CMPI	#4,-2(A6)
	BNE.S	L46
L47:
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L48
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F180_hzzz_(PC)
	ADDQ.L	#4,A7
L48:
	BRA.S	L26
L46:
L28:
	MOVE	-4(A6),D0
	ADDQ	#1,-4(A6)
	CMPI	#4,D0
	BCS	L29(PC)
L30:
	JSR	F446_zzzz_(PC)
L27:
L26:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$25:	.EQU	#-18
F226_ozzz_:/* global */
	LINK	A6,L$49
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	SUB	12(A6),D0
	MOVE	D0,D7
	CMPI	#0,D0
	BGE.S	L51
	MOVE	D7,D0
	NEG	D0
	BRA.S	L52
L51:
	MOVE	D7,D0
L52:
	MOVE	D6,D1
	SUB	14(A6),D1
	MOVE	D1,D6
	CMPI	#0,D1
	BGE.S	L53
	MOVE	D6,D1
	NEG	D1
	BRA.S	L54
L53:
	MOVE	D6,D1
L54:
	ADD	D1,D0
L50:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$49:	.EQU	#0
F227_qzzz_:/* global */
	LINK	A6,L$55
	MOVEM.L	D7-D4,-(A7)
	MOVE	10(A6),D7
	MOVE	12(A6),D6
	MOVE	14(A6),D5
	MOVE	16(A6),D4
	MOVE	8(A6),D0
L57:
	CMP	#2,D0
	BEQ.S	L58
	BRA.S	L60
L58:
	EXG	D7,D4
	EXG	D5,D6
	BRA.S	L59
	BRA.S	L61
L60:
	CMP	#1,D0
	BEQ.S	L61
	BRA.S	L62
L61:
	EXG	D7,D5
	EXG	D6,D4
	BRA.S	L59
	BRA.S	L63
L62:
	CMP	#0,D0
	BEQ.S	L63
	BRA.S	L64
L63:
	EXG	D7,D6
	EXG	D5,D4
L64:
L65:
L59:
	MOVE	D5,D1
	SUBQ	#1,D1
	MOVE	D7,D0
	SUB	D1,D0
	MOVE	D0,D7
	CMPI	#0,D0
	SGT	D0
	TST.B	D0
	BEQ.S	L66
	MOVE	D6,D0
	SUB	D4,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BGE.S	L67
	MOVE	D6,D0
	NEG	D0
	BRA.S	L68
L67:
	MOVE	D6,D0
L68:
	CMP	D7,D0
	SLE	D0
	TST.B	D0
L66:
	AND	#1,D0
L56:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$55:	.EQU	#0
F228_uzzz_:/* global */
	LINK	A6,L$69
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D7,D0
	CMP	D5,D0
	BNE.S	L71
	JSR	F027_AA59_(PC)
	AND	#2,D0
	ADDQ	#1,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D6,D0
	CMP	14(A6),D0
	BLE.S	L72
	MOVE	#0,D0
	BRA	L70(PC)
L72:
	MOVE	#2,D0
	BRA	L70(PC)
L71:
	MOVE	D6,D0
	CMP	14(A6),D0
	BNE.S	L73
	JSR	F027_AA59_(PC)
	AND	#2,D0
	ADD	#0,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D7,D0
	CMP	D5,D0
	BLE.S	L74
	MOVE	#3,D0
	BRA	L70(PC)
L74:
	MOVE	#1,D0
	BRA	L70(PC)
L73:
	CLR	D4
L75:
	MOVE	14(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F227_qzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ	L78(PC)
	MOVE	14(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D0,-(A7)
	JSR	F227_qzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L79
	CMPI	#0,D4
	BNE.S	L81
	MOVE	14(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,D0
	ADDQ	#3,D0
	AND	#3,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D0,-(A7)
	JSR	F227_qzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L80
L81:
	JSR	F027_AA59_(PC)
	AND	#2,D0
	ADD	D4,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D4,D0
	BRA.S	L70
L80:
L79:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L82
	MOVE	G363_i_Sec(A4),D7
	MOVE	D4,G363_i_Sec(A4)
	MOVE	D7,D0
	BRA.S	L70
L82:
	MOVE	D4,D0
	BRA.S	L70
L78:
	ADDQ	#1,D4
L76:
	BRA	L75(PC)
L77:
L70:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$69:	.EQU	#0
F229_hzzz_:/* global */
	LINK	A6,L$83
	MOVE	D7,-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F228_uzzz_(PC)
	ADDQ.L	#8,A7
	ASL	#1,D0
	MOVE	D0,D7
	AND	#2,D0
	BNE.S	L85
	ADDQ	#1,20(A6)
L85:
	MOVE	20(A6),D0
	LSR	#1,D0
	AND	#1,D0
	ADD	D0,D7
	MOVE	#4,-(A7)
	MOVE.L	8(A6),-(A7)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G023_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L84:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$83:	.EQU	#0
F230_ezzz_:/* global */
	LINK	A6,L$86
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	12(A6),D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L88
	MOVE	#0,D0
	BRA	L87(PC)
L88:
	MOVE	52(A2),D0
	BNE.S	L89
	MOVE	#0,D0
	BRA	L87(PC)
L89:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L90
	JSR	F314_gzzz_(PC)
L90:
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	ASL	#1,D0
	MOVE	D0,-2(A6)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-28(A6),A0
	MOVEQ	#12,D0
	JSR	_blockmv(PC)
	MOVE	-12(A6),D0
	LSR	#8,D0
	AND	#15,D0
	MOVE	D0,-(A7)
	MOVE	#7,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	G300_B_Par(A4),D0
	BNE.S	L92
	MOVE.L	A2,-(A7)
	JSR	F311_wzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	AND	#31,D1
	MOVE.B	-16(A6),D3
	AND	#255,D3
	ADD	D3,D1
	ADD	-2(A6),D1
	SUB	#16,D1
	CMP	D1,D0
	BCS.S	L93
	JSR	F029_AA19_(PC)
	TST	D0
	BNE	L91(PC)
L93:
	MOVE	#60,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F308_vzzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE	L91(PC)
L92:
	JSR	F027_AA59_(PC)
	MOVE	D0,D6
	AND	#112,D0
	BEQ.S	L94
	AND	#15,D6
	MOVE	-6(A6),D5
	CLR	D4
	BRA.S	L95
L96:
	MOVE	D5,D0
	LSR	#4,D0
	MOVE	D0,D5
	MOVE	D4,D0
	ADDQ	#1,D4
L95:
	MOVE	D6,D0
	MOVE	D5,D1
	AND	#15,D1
	CMP	D1,D0
	BHI.S	L96
L97:
	MOVE	D4,D0
	LEA	G024_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	BRA.S	L98
L94:
	MOVE	D6,D4
	AND	#1,D4
L98:
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE.B	-18(A6),D3
	AND	#255,D3
	ADD	D3,D0
	ADD	-2(A6),D0
	MOVE.L	D0,-(A7)
	MOVE	#7,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ASL	#1,D1
	SUB	D1,D0
	MOVE	D0,D7
	CMPI	#1,D0
	BGT.S	L99
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L100
	BRA	L8T230_014(PC)
L100:
	JSR	F029_AA19_(PC)
	ADDQ	#2,D0
	MOVE	D0,D7
L99:
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	MOVE.L	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	ADD	D0,D7
	MOVE	D7,D0
	ASR	#2,D0
	MOVE	D0,D7
	JSR	F029_AA19_(PC)
	ADDQ	#1,D0
	ADD	D0,D7
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L101
	JSR	F027_AA59_(PC)
	MOVE	D7,D1
	ASR	#1,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	SUBQ	#1,D0
	SUB	D0,D7
L101:
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	BEQ.S	L102
	MOVE	#2,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#9,D0
	ADD	12(A6),D0
	MOVE	D0,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	-17(A6),D0
	AND	#255,D0
	MOVE	D0,D6
	BEQ.S	L103
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L103
	MOVE	D6,-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D6
	CMPI	#0,D0
	BCS.S	L103
	MOVE	D6,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
L103:
	MOVE	D7,D0
	BRA.S	L87
L102:
L91:
L8T230_014:
	MOVE	#0,D0
L87:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$86:	.EQU	#-28
F231_izzz_:/* global */
	LINK	A6,L$104
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	14(A6),A2
	MOVE	12(A6),D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L106
	MOVE	#0,D0
	BRA	L105(PC)
L106:
	MOVE	52(A3),D0
	BNE.S	L107
	MOVE	#0,D0
	BRA	L105(PC)
L107:
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D5
	AND	#-4096,D5
	LSR	#4,D5
	LSR	#8,D5
	ASL	#1,D5
	MOVE.B	4(A2),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-10(A6)
	MOVE	214(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-6(A6)
	MOVE	24(A6),D0
	AND	#-32768,D0
	MOVE	D0,-4(A6)
	BEQ.S	L108
	ANDI	#32767,24(A6)
L108:
	MOVE.L	-10(A6),A0
	MOVE	2(A0),D0
	AND	#64,D0
	BEQ.S	L110
	MOVE	-4(A6),D0
	BEQ	L109(PC)
L110:
	MOVE.L	A3,-(A7)
	JSR	F311_wzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	AND	#31,D1
	MOVE.L	-10(A6),A0
	MOVE.B	12(A0),D3
	AND	#255,D3
	ADD	D3,D1
	ADD	D5,D1
	SUB	#16,D1
	CMP	D1,D0
	BHI.S	L111
	JSR	F029_AA19_(PC)
	TST	D0
	BEQ.S	L111
	MOVE	#75,D0
	SUB	24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F308_vzzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ	L109(PC)
L111:
	MOVE	#1,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BNE.S	L112
	BRA	L9T231_009(PC)
L112:
	JSR	F027_AA59_(PC)
	MOVE	D7,D1
	ASR	#1,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	ADD	D0,D7
	MOVE	D7,D0
	EXT.L	D0
	MOVE	26(A6),D1
	AND.L	#65535,D1
	MOVE.L	D0,-(A7)
	MOVE.L	D1,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	ASR.L	#5,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND	#31,D0
	MOVE.L	-10(A6),A0
	MOVE.B	8(A0),D3
	AND	#255,D3
	ADD	D3,D0
	ADD	D5,D0
	MOVE	D0,D4
	CMPI	#39,-6(A6)
	BNE.S	L113
	MOVE	D4,D0
	ASR	#2,D0
	SUB	D0,D4
	BRA.S	L114
L113:
	CMPI	#43,-6(A6)
	BNE.S	L115
	MOVE	D4,D0
	ASR	#3,D0
	SUB	D0,D4
L115:
L114:
	JSR	F027_AA59_(PC)
	AND	#31,D0
	ADD	D7,D0
	SUB	D4,D0
	MOVE	D0,D7
	MOVE	D0,D6
	CMPI	#1,D0
	BGT.S	L116
L9T231_009:
	JSR	F029_AA19_(PC)
	MOVE	D0,D7
	BNE.S	L117
	BRA	L9T231_015(PC)
L117:
	ADDQ	#1,D7
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#15,D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,D6
	CMP	#0,D0
	BGT.S	L119
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L118
L119:
	JSR	F029_AA19_(PC)
	ADD	D0,D7
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L120
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#15,D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D7
L120:
L118:
L116:
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	MOVE.L	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	ADD	D0,D7
	MOVE	D7,D0
	ASR	#2,D0
	MOVE	D0,D7
	JSR	F029_AA19_(PC)
	ADDQ	#1,D0
	ADD	D0,D7
	CMPI	#40,-6(A6)
	BNE.S	L121
	MOVE.L	-10(A6),A0
	MOVE	2(A0),D0
	AND	#64,D0
	BNE.S	L121
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
	BNE.S	L121
	BRA	L9T231_015(PC)
L121:
	JSR	F027_AA59_(PC)
	AND	#63,D0
	MOVE.L	D0,-(A7)
	MOVE	28(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	CMP	D1,D0
	BCC.S	L122
	MOVE	D7,D0
	ADD	#10,D0
	ADD	D0,D7
L122:
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	MOVE	22(A6),-(A7)
	MOVE	20(A6),-(A7)
	MOVE	18(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F190_zzzz_(PC)
	ADDA	#14,A7
	MOVE	D0,-2(A6)
	MOVE	D7,D0
	MOVE.L	-10(A6),A0
	MOVE	16(A0),D1
	LSR	#8,D1
	AND	#15,D1
	MULU	D1,D0
	LSR	#4,D0
	ADDQ	#3,D0
	MOVE	D0,-(A7)
	MOVE	28(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	JSR	F029_AA19_(PC)
	ADDQ	#4,D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L9T231_016
L109:
L9T231_015:
	CLR	D7
	CLR	-2(A6)
	JSR	F028_a000_(PC)
	ADDQ	#2,D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
L9T231_016:
	MOVE	12(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#2,-2(A6)
	BEQ.S	L123
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	22(A6),-(A7)
	MOVE	20(A6),-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L123:
	MOVE	D7,D0
L105:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$104:	.EQU	#-10
F232_dzzz_:/* global */
	LINK	A6,L$124
	MOVEM.L	A3-A2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	AND	#1023,D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	14(A6),D0
	BEQ.S	L128
	MOVE	2(A3),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L127
L128:
	MOVE	14(A6),D0
	BNE.S	L126
	MOVE	2(A3),D0
	AND	#256,D0
	LSR	#8,D0
	BNE.S	L126
L127:
	MOVE	#0,D0
	BRA	L125(PC)
L126:
	MOVE	12(A6),D0
	MOVE	2(A3),D1
	AND	#1,D1
	ASL.L	#1,D1
	LEA	G275_as_Cu+1(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BLT	L129(PC)
	MOVE	10(A6),D0
	MOVE	8(A6),D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#7,D0
	CMPI	#4,D0
	BNE.S	L130
	MOVE	16(A6),D0
	BEQ.S	L131
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	16(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	#2,-6(A6)
	CLR.B	-5(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-4(A6)
	MOVE	10(A6),D0
	MOVE.B	D0,-3(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L132
L131:
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#5,D0
	MOVE.B	D0,(A2)
L132:
	MOVE	#1,D0
	BRA.S	L125
L130:
L129:
	MOVE	#0,D0
L125:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$124:	.EQU	#-10
