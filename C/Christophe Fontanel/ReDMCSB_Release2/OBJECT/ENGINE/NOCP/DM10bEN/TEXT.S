BSS SEG "bss"
G353_ac_St:/* global */
	.WORD	#128
CODE SEG "init!"
	MOVE	#-1,G354_i_Mes(A4)
BSS SEG "bss"
G354_i_Mes:/* global */
	.WORD	#2
G355_B_Scr:/* global */
	.WORD	#2
G356_puc_B:/* global */
	.WORD	#4
G357_puc_I:/* global */
	.WORD	#4
G358_i_Mes:/* global */
	.WORD	#2
G359_i_Mes:/* global */
	.WORD	#2
G360_al_Me:/* global */
	.WORD	#16
CODE SEG "main"
F040_aacZ_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	14(A6),D7
	MOVE	16(A6),D6
	MOVE	18(A6),D5
	MOVE	20(A6),D4
	MOVE.L	22(A6),A0
	MOVE.B	(A0),D0
	BNE.S	L0T040_001
	BRA	L0T040_043_(PC)
L0T040_001:
	MOVE	D6,D0
	SUBQ	#4,D0
	MULU	12(A6),D0
	ADDA	D0,A3
	MOVE	D7,D0
	ANDI	#-16,D0
	LSR	#1,D0
	ADDA	D0,A3
	MOVEQ	#15,D3
	AND	D7,D3
	MOVE	D5,D1
	ADD	D5,D5
	ADD	D1,D5
	ADD	D5,D5
	JMP	2(PC,D5)
L0T040_002:
	LEA	L0T040_025_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_010_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_011_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_012_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_013_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_014_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_015_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_016_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_017_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_018_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_019_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_020_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_021_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_022_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_023_(PC),A0
	BRA.S	L0T040_003_
	LEA	L0T040_024_(PC),A0
L0T040_003_:
	MOVE	D4,D1
	ADD	D4,D4
	ADD	D1,D4
	ADD	D4,D4
	JMP	2(PC,D4)
L0T040_004_:
	LEA	L0T040_041_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_026_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_027_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_028_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_029_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_030_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_031_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_032_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_033_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_034_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_035_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_036_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_037_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_038_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_039_(PC),A1
	BRA.S	L0T040_005_
	LEA	L0T040_040_(PC),A1
L0T040_005_:
	MOVEQ	#0,D2
	MOVE.L	22(A6),A2
	MOVE.B	(A2),D2
	BEQ	L0T040_043_(PC)
	ADDQ.L	#1,22(A6)
	MOVE.L	G357_puc_I(A4),A2
	LEA	0(A2,D2),A2
	CMP	#11,D3
	BHI.S	L0T040_006_
	MOVEQ	#6,D4
	MOVE.L	#134154239,D2
	ROR.L	D3,D2
	MOVEQ	#0,D5
	MOVE.L	A3,-(A7)
	BSR.S	L0T040_007_
	MOVE.L	(A7)+,A3
	ADDQ	#6,D3
	CMPI	#16,D3
	BCS.S	L0T040_005_
	ANDI	#1,D3
	ADDQ.L	#8,A3
	BRA.S	L0T040_005_
L0T040_006_:
	MOVEQ	#6,D4
	MOVE.L	A3,-(A7)
	ADDQ.L	#8,(A7)
	MOVE.L	A2,-(A7)
	LSL	#2,D3
	LEA	G064_al_Gr+-48(A4),A2
	MOVE.L	0(A2,D3),D2
	LEA	G065_al_Gr+-48(A4),A2
	MOVE.L	0(A2,D3),-(A7)
	LSR	#2,D3
	MOVE.L	4(A7),A2
	MOVEQ	#8,D5
	BSR.S	L0T040_007_
	MOVE.L	(A7)+,D2
	MOVE.L	(A7)+,A2
	MOVE.L	(A7),A3
	MOVEQ	#6,D4
	MOVEQ	#18,D5
	BSR.S	L0T040_007_
	MOVE.L	(A7)+,A3
	SUBI	#10,D3
	BRA.S	L0T040_005_
L0T040_007_:
	AND.L	D2,(A3)
	AND.L	D2,4(A3)
	MOVEQ	#0,D0
	MOVE.B	(A2),D0
	JMP	2(PC,D5)
L0T040_008:
	MOVEQ	#11,D1
	SUB	D3,D1
	LSL	D1,D0
	BRA.S	L0T040_009
	MOVE	D3,D1
	SUBI	#11,D1
	LSR	D1,D0
	BRA.S	L0T040_009
	MOVEQ	#27,D1
	SUB	D3,D1
	LSL	D1,D0
L0T040_009:
	MOVE	D0,D1
	SWAP	D1
	MOVE	D0,D1
	SWAP	D0
	MOVEQ	#0,D6
	MOVEQ	#0,D7
	JMP	(A0)
L0T040_010_:
	MOVE.L	D0,D6
	BRA.S	L0T040_025_
L0T040_011_:
	MOVE	D1,D6
	BRA.S	L0T040_025_
L0T040_012_:
	MOVE.L	D1,D6
	BRA.S	L0T040_025_
L0T040_013_:
	MOVE.L	D0,D7
	BRA.S	L0T040_025_
L0T040_014_:
	MOVE.L	D0,D6
	MOVE.L	D0,D7
	BRA.S	L0T040_025_
L0T040_015_:
	MOVE	D1,D6
	MOVE.L	D0,D7
	BRA.S	L0T040_025_
L0T040_016_:
	MOVE.L	D1,D6
	MOVE.L	D0,D7
	BRA.S	L0T040_025_
L0T040_017_:
	MOVE	D1,D7
	BRA.S	L0T040_025_
L0T040_018_:
	MOVE.L	D0,D6
	MOVE	D1,D7
	BRA.S	L0T040_025_
L0T040_019_:
	MOVE	D1,D6
	MOVE	D1,D7
	BRA.S	L0T040_025_
L0T040_020_:
	MOVE.L	D1,D6
	MOVE	D1,D7
	BRA.S	L0T040_025_
L0T040_021_:
	MOVE.L	D1,D7
	BRA.S	L0T040_025_
L0T040_022_:
	MOVE.L	D0,D6
	MOVE.L	D1,D7
	BRA.S	L0T040_025_
L0T040_023_:
	MOVE	D1,D6
	MOVE.L	D1,D7
	BRA.S	L0T040_025_
L0T040_024_:
	MOVE.L	D1,D6
	MOVE.L	D1,D7
L0T040_025_:
	OR.L	D2,D0
	NOT.L	D0
	CLR	D0
	OR.L	D2,D1
	NOT.L	D1
	JMP	(A1)
L0T040_026_:
	OR.L	D0,D6
	BRA.S	L0T040_041_
L0T040_027_:
	OR	D1,D6
	BRA.S	L0T040_041_
L0T040_028_:
	OR.L	D1,D6
	BRA.S	L0T040_041_
L0T040_029_:
	OR.L	D0,D7
	BRA.S	L0T040_041_
L0T040_030_:
	OR.L	D0,D6
	OR.L	D0,D7
	BRA.S	L0T040_041_
L0T040_031_:
	OR	D1,D6
	OR.L	D0,D7
	BRA.S	L0T040_041_
L0T040_032_:
	OR.L	D1,D6
	OR.L	D0,D7
	BRA.S	L0T040_041_
L0T040_033_:
	OR	D1,D7
	BRA.S	L0T040_041_
L0T040_034_:
	OR.L	D0,D6
	OR	D1,D7
	BRA.S	L0T040_041_
L0T040_035_:
	OR	D1,D6
	OR	D1,D7
	BRA.S	L0T040_041_
L0T040_036_:
	OR.L	D1,D6
	OR	D1,D7
	BRA.S	L0T040_041_
L0T040_037_:
	OR.L	D1,D7
	BRA.S	L0T040_041_
L0T040_038_:
	OR.L	D0,D6
	OR.L	D1,D7
	BRA.S	L0T040_041_
L0T040_039_:
	OR	D1,D6
	OR.L	D1,D7
	BRA.S	L0T040_041_
L0T040_040_:
	OR.L	D1,D6
	OR.L	D1,D7
L0T040_041_:
	OR.L	D6,(A3)
	OR.L	D7,4(A3)
	SUBQ	#1,D4
	BNE.S	L0T040_042
	RTS
L0T040_042:
	LEA	128(A2),A2
	ADDA	12(A6),A3
	BRA	L0T040_007_(PC)
L0T040_043_:
	MOVEM.L	(A7)+,D4-D7/A2-A3
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#0
F041_aadZ_:/* global */
	LINK	A6,L$2
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	22(A6),A3
	CLR	D7
	BRA.S	L4
L5:
	ADDQ	#1,D7
L4:
	LEA	-80(A6),A0
	ADDA	D7,A0
	MOVE.B	(A3)+,(A0)
	BNE.S	L5
L6:
	BRA.S	L7
L8:
	LEA	-80(A6),A0
	ADDA	D7,A0
	MOVE.B	#32,(A0)
	ADDQ	#1,D7
L7:
	MOVE	D7,D0
	CMP	26(A6),D0
	BLT.S	L8
L9:
	LEA	-80(A6),A0
	ADDA	D7,A0
	CLR.B	(A0)
	PEA	-80(A6)
	MOVE	20(A6),-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L3:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$2:	.EQU	#-80
F042_xxxx_:/* global */
	LINK	A6,L$10
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CMPI	#0,D7
	BGE.S	L12
	CLR	D7
	BRA.S	L13
L12:
	CMPI	#53,D7
	BLT.S	L14
	MOVE	#52,D7
L14:
L13:
	MOVE	D7,G359_i_Mes(A4)
	CMPI	#0,D6
	BGE.S	L15
	CLR	D6
	BRA.S	L16
L15:
	CMPI	#4,D6
	BLT.S	L17
	MOVE	#3,D6
L17:
L16:
	MOVE	D6,G358_i_Mes(A4)
L11:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$10:	.EQU	#0
F043_aahz_:/* global */
	LINK	A6,L$18
	MOVE	D7,-(A7)
	CLR	G578_B_Use(A4)
	CLR	-8(A6)
	MOVE	#319,-6(A6)
	MOVE	#169,-4(A6)
	MOVE	#199,-2(A6)
L21:
L20:
	CMPI	#0,G354_i_Mes(A4)
	BGE.S	L21
	MOVE	G355_B_Scr(A4),D0
	BNE.S	L21
L22:
	JSR	F077_aA39_(PC)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
	MOVE	#3,G358_i_Mes(A4)
	CLR	G359_i_Mes(A4)
	CLR	D7
	BRA.S	L23
L24:
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G360_al_Me(A4),A0
	ADDA	D0,A0
	MOVE.L	#-1,(A0)
L25:
	ADDQ	#1,D7
L23:
	CMPI	#4,D7
	BCS.S	L24
L26:
L19:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$18:	.EQU	#-8
F044_xxxx_:/* global */
	LINK	A6,L$27
	MOVEM.L	D7-D5,-(A7)
	CLR	G578_B_Use(A4)
	CLR	-8(A6)
	MOVE	#319,-6(A6)
	CLR	D6
	BRA.S	L29
L30:
	MOVE	D6,D5
	ASL.L	#2,D5
	LEA	G360_al_Me(A4),A0
	ADDA	D5,A0
	MOVE.L	(A0),D5
	CMPI.L	#-1,D5
	BEQ.S	L34
	MOVE.L	D5,D0
	MOVE.L	G313_ul_Ga(A4),D1
	CMP.L	D1,D0
	BLE.S	L33
L34:
	BRA.S	L31
L33:
	MOVE	#172,D0
	MOVE	D6,D1
	MULU	#7,D1
	ADD	D1,D0
	MOVE	D0,-4(A6)
	ADDQ	#6,D0
	MOVE	D0,-2(A6)
L36:
L35:
	CMPI	#0,G354_i_Mes(A4)
	BGE.S	L36
	MOVE	G355_B_Scr(A4),D0
	BNE.S	L36
L37:
	JSR	F077_aA39_(PC)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G360_al_Me(A4),A0
	ADDA	D0,A0
	MOVE.L	#-1,(A0)
L31:
	ADDQ	#1,D6
L29:
	CMPI	#4,D6
	BCS.S	L30
L32:
L28:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$27:	.EQU	#-8
F045_xxxx_:/* global */
	LINK	A6,L$38
	MOVE	D7,-(A7)
	CMPI	#3,G358_i_Mes(A4)
	BNE.S	L40
L42:
L41:
	CMPI	#0,G354_i_Mes(A4)
	BGE.S	L42
	MOVE	G355_B_Scr(A4),D0
	BNE.S	L42
L43:
	MOVE	#1120,-(A7)
	MOVE.L	G356_puc_B(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	G354_i_Mes(A4)
	CLR	D7
	BRA.S	L44
L45:
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G360_al_Me+4(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G360_al_Me(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L46:
	ADDQ	#1,D7
L44:
	CMPI	#3,D7
	BCS.S	L45
L47:
	MOVE.L	#-1,G360_al_Me+12(A4)
	BRA.S	L48
L40:
	ADDQ	#1,G358_i_Mes(A4)
L48:
L39:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$38:	.EQU	#0
F046_xxxx_:/* global */
	LINK	A6,L$49
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	10(A6),A3
	MOVE.L	A3,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	CMPI	#-1,G354_i_Mes(A4)
	BNE.S	L51
L53:
L52:
	MOVE	G355_B_Scr(A4),D0
	BNE.S	L53
L54:
	JSR	F077_aA39_(PC)
	MOVE.L	A3,-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	MOVE	G358_i_Mes(A4),D0
	MULS	#7,D0
	ADD	#177,D0
	MOVE	D0,-(A7)
	MOVE	G359_i_Mes(A4),D0
	MULS	#6,D0
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
	BRA.S	L55
L51:
	MOVE.L	A3,-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#5,-(A7)
	MOVE	G359_i_Mes(A4),D0
	MULS	#6,D0
	MOVE	D0,-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G356_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	CMPI	#-1,G354_i_Mes(A4)
	BNE.S	L56
	MOVE	#1,G355_B_Scr(A4)
L56:
L55:
	MOVE	D7,D0
	ADD	D0,G359_i_Mes(A4)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#70,D0
	MOVE	G358_i_Mes(A4),D1
	ASL.L	#2,D1
	LEA	G360_al_Me(A4),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L50:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$49:	.EQU	#0
F047_xzzz_:/* global */
	LINK	A6,L$57
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE.L	10(A6),A3
	BRA	L59(PC)
L60:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L62
	ADDQ.L	#1,A3
	CMPI	#0,G359_i_Mes(A4)
	BNE.S	L64
	CMPI	#0,G358_i_Mes(A4)
	BEQ.S	L63
L64:
	CLR	G359_i_Mes(A4)
	JSR	F045_xxxx_(PC)
L63:
	BRA.S	L59
L62:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#32,D0
	BNE.S	L65
	ADDQ.L	#1,A3
	CMPI	#53,G359_i_Mes(A4)
	BEQ.S	L66
	MOVE	#8192,-2(A6)
	PEA	-2(A6)
	MOVE	D7,-(A7)
	JSR	F046_xxxx_(PC)
	ADDQ.L	#6,A7
L66:
	BRA.S	L59
L65:
	CLR	D6
L67:
	MOVE	D6,D0
	ADDQ	#1,D6
	LEA	-56(A6),A0
	ADDA	D0,A0
	MOVE.B	(A3)+,(A0)
L68:
	MOVE.B	(A3),D0
	BEQ.S	L70
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#32,D0
	BEQ.S	L70
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L67
L70:
L69:
	MOVE	D6,D0
	LEA	-56(A6),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE	G359_i_Mes(A4),D0
	ADD	D6,D0
	CMPI	#53,D0
	BLS.S	L71
	MOVE	#2,G359_i_Mes(A4)
	JSR	F045_xxxx_(PC)
L71:
	PEA	-56(A6)
	MOVE	D7,-(A7)
	JSR	F046_xxxx_(PC)
	ADDQ.L	#6,A7
L59:
	MOVE.B	(A3),D0
	BNE	L60(PC)
L61:
L58:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$57:	.EQU	#-56
F048_xxxx_:/* global */
	LINK	A6,L$72
	MOVE.B	11(A6),-2(A6)
	CLR.B	-1(A6)
	PEA	-2(A6)
	MOVE	8(A6),-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L73:
	UNLK	A6
	RTS
L$72:	.EQU	#-2
F049_xxxx_:/* global */
	LINK	A6,L$74
	MOVEM.L	D7-D6,-(A7)
	MOVE	10(A6),D7
	MOVE	#7,D6
	CLR.B	-1(A6)
L76:
	MOVE	#48,D0
	MOVE	D7,D1
	AND.L	#65535,D1
	DIVU	#10,D1
	SWAP	D1
	ADD	D1,D0
	SUBQ	#1,D6
	MOVE	D6,D1
	LEA	-8(A6),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L77:
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,D7
	BNE.S	L76
L78:
	MOVE	D6,D0
	LEA	-8(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L75:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$74:	.EQU	#-8
F050_xxxx_:/* global */
	LINK	A6,L$79
DATA SEG "s!"
s!:
	DATA 20 00 
CODE SEG "main"
	PEA	s!(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L80:
	UNLK	A6
	RTS
L$79:	.EQU	#0
F051_AA19_:/* global */
	LINK	A6,L$81
	PEA	G066_ac_Gr(A4)
	CLR	-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L82:
	UNLK	A6
	RTS
L$81:	.EQU	#0
F052_aaoz_:/* global */
	LINK	A6,L$83
	MOVE.L	14(A6),-(A7)
	MOVE	#12,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L84:
	UNLK	A6
	RTS
L$83:	.EQU	#0
F053_aajz_:/* global */
	LINK	A6,L$85
	MOVE.L	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L86:
	UNLK	A6
	RTS
L$85:	.EQU	#0
F054_aAA1_:/* global */
	LINK	A6,L$87
	MOVE	D7,-(A7)
	MOVE	#3,-(A7)
	CLR	-(A7)
	JSR	F042_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE.L	#1120,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G356_puc_B(A4)
	MOVE	#1,-(A7)
	MOVE.L	#768,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G357_puc_I(A4)
	MOVE.L	G357_puc_I(A4),-(A7)
	MOVE	#-32211,-(A7)
	JSR	F490_lzzz_(PC)
	ADDQ.L	#6,A7
	CLR	D7
	BRA.S	L89
L90:
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G360_al_Me(A4),A0
	ADDA	D0,A0
	MOVE.L	#-1,(A0)
L91:
	ADDQ	#1,D7
L89:
	CMPI	#4,D7
	BCS.S	L90
L92:
L88:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$87:	.EQU	#0
