BSS SEG "bss"
G420_B_Mou:/* global */
	.WORD	#2
G421_i_Obj:/* global */
	.WORD	#2
G422_i_Obj:/* global */
	.WORD	#2
G423_i_Inv:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#0,G424_i_Pan(A4)
BSS SEG "bss"
G424_i_Pan:/* global */
	.WORD	#2
G425_aT_Ch:/* global */
	.WORD	#16
CODE SEG "init!"
	MOVE	#-1,G426_T_Ope(A4)
BSS SEG "bss"
G426_T_Ope:/* global */
	.WORD	#2
CODE SEG "init!"
	LEA	G428_apc_S(A4),A1
DATA SEG "s!"
s!:
	DATA 4E 45 4F 50 48 59 54 45 00 00 
CODE SEG "init!"
	LEA	s!(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4E 4F 56 49 43 45 00 00 
CODE SEG "init!"
	LEA	s!+10(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 50 50 52 45 4E 54 49 43 45 00 00 
CODE SEG "init!"
	LEA	s!+18(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4A 4F 55 52 4E 45 59 4D 41 4E 00 00 
CODE SEG "init!"
	LEA	s!+30(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 43 52 41 46 54 53 4D 41 4E 00 
CODE SEG "init!"
	LEA	s!+42(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 52 54 49 53 41 4E 00 
CODE SEG "init!"
	LEA	s!+52(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 44 45 50 54 00 
CODE SEG "init!"
	LEA	s!+60(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 45 58 50 45 52 54 00 00 
CODE SEG "init!"
	LEA	s!+66(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 60 20 4D 41 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+74(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 61 20 4D 41 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+84(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 62 20 4D 41 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+94(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 63 20 4D 41 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+104(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 64 20 4D 41 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+114(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 65 20 4D 41 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+124(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 52 43 48 4D 41 53 54 45 52 00 00 
CODE SEG "init!"
	LEA	s!+134(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
G428_apc_S:/* global */
	.WORD	#60
CODE SEG "player"
F332_xxxx_:/* global */
	LINK	A6,L$0
	CLR	-(A7)
	MOVE.L	#128,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-12(A6)
	MOVE	10(A6),D0
	MOVE	D0,-8(A6)
	ADD	#15,D0
	MOVE	D0,-6(A6)
	MOVE	12(A6),D0
	MOVE	D0,-4(A6)
	ADD	#15,D0
	MOVE	D0,-2(A6)
	MOVE.L	-12(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#-1,-(A7)
	MOVE	#8,-(A7)
	PEA	-8(A6)
	MOVE.L	-12(A6),-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE.L	#128,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#-12
F333_xxxx_:/* global */
	LINK	A6,L$2
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	10(A6),A3
	MOVE	8(A6),G426_T_Ope(A4)
	MOVE	14(A6),D0
	BNE.S	L4
	MOVE	#145,-(A7)
	MOVE	#9,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
L4:
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#25,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	CLR	D7
	MOVE	2(A3),D6
	BRA.S	L5
L6:
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ADD	#38,D0
	MOVE	D0,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	G425_aT_Ch(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L5:
	CMPI	#-2,D6
	BNE.S	L6
L7:
	BRA.S	L8
L9:
	MOVE	#-1,-(A7)
	MOVE	D7,D0
	ADD	#38,D0
	MOVE	D0,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,D0
	ADDQ	#1,D7
	ASL.L	#1,D0
	LEA	G425_aT_Ch(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L8:
	CMPI	#8,D7
	BLT.S	L9
L10:
L3:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$2:	.EQU	#-40
F334_akzz_:/* global */
	LINK	A6,L$11
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	#1,D4
	CMPI	#-1,G426_T_Ope(A4)
	BNE.S	L13
	BRA.S	L12
L13:
	MOVE	G426_T_Ope(A4),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#-1,G426_T_Ope(A4)
	MOVE	#-2,2(A3)
	CLR	D5
	BRA.S	L14
L15:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L18
	MOVE	D4,D0
	BEQ.S	L19
	CLR	D4
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#-2,(A2)
	MOVE	D7,D0
	MOVE	D0,D6
	MOVE	D0,2(A3)
	BRA.S	L20
L19:
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D6
L20:
L18:
L16:
	ADDQ	#1,D5
L14:
	CMPI	#8,D5
	BLT.S	L15
L17:
L12:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$11:	.EQU	#0
F335_xxxx_:/* global */
	LINK	A6,L$21
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#12,D0
	BNE.S	L23
	ADDQ.L	#1,8(A6)
	MOVE	#108,G421_i_Obj(A4)
	MOVE	#59,G422_i_Obj(A4)
L23:
	MOVE.L	8(A6),A0
	MOVE.B	(A0),D0
	BEQ.S	L24
	MOVE.L	8(A6),-(A7)
	PEA	-128(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	LEA	-128(A6),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L25
L26:
	MOVE.L	A3,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	CMPI	#18,D0
	BLE.S	L28
	LEA	17(A3),A0
	MOVE.L	A0,A2
	BRA.S	L29
L30:
	SUBQ.L	#1,A2
L29:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#32,D0
	BNE.S	L30
L31:
	CLR.B	(A2)
	MOVE	#1,D7
L28:
	MOVE.L	A3,-(A7)
	MOVE	#13,-(A7)
	MOVE	G422_i_Obj(A4),-(A7)
	MOVE	G421_i_Obj(A4),-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	ADDQ	#7,G422_i_Obj(A4)
	MOVE	D7,D0
	BEQ.S	L32
	CLR	D7
	ADDQ.L	#1,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A3
	BRA.S	L33
L32:
	CLR.B	(A3)
L33:
L25:
	MOVE.B	(A3),D0
	BNE.S	L26
L27:
L24:
L22:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$21:	.EQU	#-128
F336_xxxx_:/* global */
	LINK	A6,L$34
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE.L	12(A6),A3
	MOVE.L	16(A6),A2
	CLR	-2(A6)
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE	#1,D0
	MOVE	D0,D4
	BRA.S	L36
L37:
	MOVE	D4,D0
	AND	D7,D0
	AND	D6,D0
	BEQ.S	L40
	ADDQ	#1,-2(A6)
L40:
L38:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D0
	ASL	#1,D0
	MOVE	D0,D4
L36:
	CMPI	#16,D5
	BCS.S	L37
L39:
	CMPI	#0,-2(A6)
	BNE.S	L41
	CLR.B	(A2)
	BRA	L35(PC)
L41:
	MOVE.L	20(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	#0,D0
	MOVE	D0,D5
	MOVE	#1,D0
	MOVE	D0,D4
	BRA.S	L42
L43:
	MOVE	D4,D0
	AND	D7,D0
	AND	D6,D0
	BEQ.S	L46
	MOVE	D5,D0
	ASL.L	#2,D0
	MOVE.L	A3,A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	-2(A6),D0
	SUBQ	#1,-2(A6)
	CMPI	#2,D0
	BLS.S	L47
DATA SEG "s!"
	DATA 2C 20 00 00 
CODE SEG "player"
	PEA	s!+146(A4)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	BRA.S	L48
L47:
	CMPI	#1,-2(A6)
	BNE.S	L49
DATA SEG "s!"
	DATA 20 41 4E 44 20 00 
CODE SEG "player"
	PEA	s!+150(A4)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
L49:
L48:
L46:
L44:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D0
	ASL	#1,D0
	MOVE	D0,D4
L42:
	CMPI	#16,D5
	BCS.S	L43
L45:
	MOVE.L	24(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
L35:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$34:	.EQU	#-2
F337_akzz_:/* global */
	LINK	A6,L$50
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	CMPI	#0,D0
	BNE.S	L52
	CLR	G304_i_Dun(A4)
	BRA	L53(PC)
L52:
	MOVE	#4,D5
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,-8(A6)
	LEA	-26(A6),A0
	MOVE.L	A0,A3
	BRA	L54(PC)
L55:
	MOVE	#2,D4
	BRA.S	L57
L58:
	MOVE	D4,D0
	MOVE.L	-8(A6),A0
	ASL.L	#1,D0
	LEA	212(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMPI	#4,D0
	BLT.S	L60
	MOVE	D4,D0
	MOVE.L	-8(A6),A0
	ASL.L	#1,D0
	LEA	212(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,-10(A6)
	MOVE	D0,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMPI	#7,D0
	BGT.S	L60
	MOVE	-10(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,(A3)
	BRA.S	L61
L60:
	CLR	(A3)
L61:
	ADDQ.L	#2,A3
L57:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L58
L59:
	ADDI.L	#800,-8(A6)
L54:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE	L55(PC)
L56:
	LEA	-26(A6),A0
	MOVE.L	A0,A3
	CLR	D4
	BRA.S	L62
L63:
	MOVE	#7,D5
	SUB	D4,D5
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	-24(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	BRA.S	L66
L67:
	MOVE	(A2),D0
	CMP	(A3),D0
	BLE.S	L69
	MOVE	(A2),-10(A6)
	MOVE	(A3),(A2)
	MOVE	-10(A6),(A3)
L69:
	ADDQ.L	#2,A2
L66:
	MOVE	D5,D0
	SUBQ	#1,D5
	TST	D0
	BNE.S	L67
L68:
	ADDQ.L	#2,A3
L64:
	ADDQ	#1,D4
L62:
	CMPI	#4,D4
	BNE.S	L63
L65:
	MOVE	#6,D6
	MOVE	#5,D4
	CLR	D7
	LEA	-26(A6),A0
	MOVE.L	A0,A3
	BRA.S	L70
L71:
	MOVE	(A3),D0
	BEQ.S	L73
	MOVE	(A3),D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ASL	D6,D0
	LSR	#6,D0
	ADD	D0,D7
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
L73:
	ADDQ.L	#2,A3
L70:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L71
L72:
	ADD	G407_s_Par+3200(A4),D7
	LEA	G040_ai_Gr(A4),A0
	MOVE.L	A0,A3
	CMPI	#0,D7
	BLE.S	L74
	CLR	D4
	BRA.S	L75
L76:
	ADDQ	#1,D4
L75:
	MOVE	(A3)+,D0
	CMP	D7,D0
	BGT.S	L76
L77:
	BRA.S	L78
L74:
	MOVE	#5,D4
L78:
	MOVE	D4,G304_i_Dun(A4)
L53:
	MOVE	#1,G342_B_Ref(A4)
L51:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$50:	.EQU	#-26
F338_atzz_:/* global */
	LINK	A6,L$79
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D5
	MOVE	G305_ui_Pa(A4),D7
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L81
	SUBQ	#1,D7
L81:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	BRA	L82(PC)
L83:
	MOVE	#2,D6
	BRA	L85(PC)
L86:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#4,D4
	BLT.S	L88
	CMPI	#7,D4
	BGT.S	L88
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	BEQ.S	L89
	MOVE	2(A2),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-15361,2(A2)
	OR	D3,2(A2)
	MOVE	D0,D0
	CMPI	#0,D0
	BNE.S	L90
	MOVE	#0,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ANDI	#-129,2(A2)
	OR	D3,2(A2)
L90:
	MOVE	#1,D5
L89:
L88:
L85:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE	L86(PC)
L87:
	ADDA	#800,A3
L82:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE	L83(PC)
L84:
	MOVE	D5,D0
	BEQ.S	L91
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
L91:
L80:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$79:	.EQU	#0
F339_xxxx_:/* global */
	LINK	A6,L$92
	MOVE	#8,-(A7)
	MOVE	#8,-(A7)
	PEA	G033_s_Gra(A4)
	MOVE	8(A6),D0
	BEQ.S	L94
	MOVE	#19,D0
	BRA.S	L95
L94:
	MOVE	#18,D0
L95:
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
L93:
	UNLK	A6
	RTS
L$92:	.EQU	#0
F340_xxxx_:/* global */
	LINK	A6,L$96
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	10(A6),A3
	MOVE.L	A3,A2
	BRA.S	L98
L99:
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#65,D0
	BLT.S	L101
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#90,D0
	BGT.S	L101
	SUBI.B	#64,(A2)+
	BRA.S	L98
L101:
	ADDQ.L	#1,A2
L98:
	MOVE.B	(A2),D0
	BNE.S	L99
L100:
	MOVE.L	A3,-(A7)
	MOVE	#15,-(A7)
	CLR	-(A7)
	MOVE	8(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	D1,-10(A6)
	MOVE	#6,D1
	MULS	-10(A6),D1
	ASR	#1,D1
	MOVE	#162,D0
	SUB	D1,D0
	MOVE	D0,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L97:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$96:	.EQU	#-10
F341_xxxx_:/* global */
	LINK	A6,L$102
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE	#-32766,-(A7)
	MOVE.L	8(A6),A0
	MOVE	2(A0),D0
	AND	#1023,D0
	MOVE	D0,-(A7)
	PEA	-260(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	LEA	-260(A6),A0
	MOVE.L	A0,A2
	BRA.S	L104
L105:
	ADDQ.L	#1,A2
L104:
	MOVE.B	(A2),D0
	BEQ.S	L107
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L105
L107:
L106:
	CLR.B	(A2)
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#23,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#1,D7
	ADDQ.L	#1,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A3
	BRA.S	L108
L109:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L111
	ADDQ	#1,D7
L111:
	ADDQ.L	#1,A3
L108:
	MOVE.B	(A3),D0
	BNE.S	L109
L110:
	MOVE.L	A3,D0
	SUBQ.L	#1,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#10,D0
	BEQ.S	L112
	ADDQ	#1,D7
	BRA.S	L113
L112:
	MOVE.L	A3,D0
	SUBQ.L	#2,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L114
	SUBQ	#1,D7
L114:
L113:
	MOVE	#92,D0
	MOVE	#7,D1
	MULS	D7,D1
	EXT.L	D1
	DIVS	#2,D1
	SUB	D1,D0
	MOVE	D0,D7
	PEA	-260(A6)
	MOVE	D7,-(A7)
	JSR	F340_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	A2,A3
	BRA.S	L115
L116:
	ADDQ	#7,D7
	BRA.S	L118
L119:
	ADDQ.L	#1,A2
L118:
	MOVE.B	(A2),D0
	BEQ.S	L121
	MOVE.B	(A2),D0
	EXT	D0
	CMP	#10,D0
	BNE.S	L119
L121:
L120:
	MOVE.B	(A2),D0
	BNE.S	L122
	CLR.B	1(A2)
L122:
	CLR.B	(A2)+
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F340_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	A2,A3
L115:
	MOVE.B	(A3),D0
	BNE.S	L116
L117:
L103:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$102:	.EQU	#-260
F342_xxxx_:/* global */
	LINK	A6,L$123
DATA SEG "s!"
	DATA 29 00 28 00 
CODE SEG "init!"
	LEA	11G430_apc(A4),A1
DATA SEG "s!"
	DATA 4E 4F 52 54 48 00 
CODE SEG "init!"
	LEA	s!+160(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 45 41 53 54 00 00 
CODE SEG "init!"
	LEA	s!+166(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 53 4F 55 54 48 00 
CODE SEG "init!"
	LEA	s!+172(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 57 45 53 54 00 00 
CODE SEG "init!"
	LEA	s!+178(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
11G430_apc:
	.WORD	#16
CODE SEG "player"
	MOVEM.L	A3-A2/D7-D4,-(A7)
	LEA	s!+156(A4),A0
	MOVE.L	A0,-68(A6)
	LEA	s!+158(A4),A0
	MOVE.L	A0,-72(A6)
	JSR	F334_akzz_(PC)
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
DATA SEG "s!"
	DATA 0C 00 
CODE SEG "player"
	PEA	s!+184(A4)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	8(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-74(A6)
	CMPI	#7,-74(A6)
	BNE.S	L125
	MOVE.L	A2,-(A7)
	JSR	F341_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L126(PC)
L125:
	CMPI	#9,-74(A6)
	BNE.S	L127
	MOVE	10(A6),-(A7)
	MOVE.L	A2,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F333_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L128(PC)
L127:
	MOVE	8(A6),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#20,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G034_s_Gra(A4)
	MOVE	#29,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	CMPI	#147,D6
	BNE.S	L129
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	PEA	-114(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "player"
	PEA	s!+186(A4)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G352_apc_O(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	LEA	-114(A6),A0
	MOVE.L	A0,A3
	BRA.S	L130
L129:
	CMPI	#8,-74(A6)
	BNE.S	L131
	CMPI	#163,D6
	BEQ.S	L131
	MOVE	#2,-(A7)
	MOVE	G423_i_Inv(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	CMPI	#1,D0
	BLS.S	L131
	MOVE	#95,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#255,D1
	AND.L	#65535,D1
	DIVU	#40,D1
	ADD	D1,D0
	MOVE.B	D0,-114(A6)
	MOVE.B	#32,-113(A6)
	CLR.B	-112(A6)
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G352_apc_O(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	LEA	-114(A6),A0
	MOVE.L	A0,A3
	BRA.S	L132
L131:
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G352_apc_O(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	MOVE.L	D0,A3
L132:
L130:
	MOVE.L	A3,-(A7)
	MOVE	#13,-(A7)
	MOVE	#68,-(A7)
	MOVE	#134,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	#59,-(A7)
	MOVE	#111,-(A7)
	MOVE	D6,-(A7)
	JSR	F332_xxxx_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 43 4F 4E 53 55 4D 41 42 4C 45 00 00 
CODE SEG "player"
	LEA	s!+188(A4),A0
	MOVE.L	A0,-64(A6)
DATA SEG "s!"
	DATA 50 4F 49 53 4F 4E 45 44 00 00 
CODE SEG "player"
	LEA	s!+200(A4),A0
	MOVE.L	A0,-60(A6)
DATA SEG "s!"
	DATA 42 52 4F 4B 45 4E 00 00 
CODE SEG "player"
	LEA	s!+210(A4),A0
	MOVE.L	A0,-56(A6)
DATA SEG "s!"
	DATA 43 55 52 53 45 44 00 00 
CODE SEG "player"
	LEA	s!+218(A4),A0
	MOVE.L	A0,-52(A6)
	MOVE	#87,G422_i_Obj(A4)
	MOVE	-74(A6),D0
L133:
	CMP	#5,D0
	BEQ.S	L134
	BRA.S	L136
L134:
	MOVE	#14,D5
	MOVE.L	A2,D4
	MOVE.L	D4,A0
	MOVE	2(A0),D4
	AND	#256,D4
	LSR	#8,D4
	ASL	#3,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#512,D1
	LSR	#1,D1
	LSR	#8,D1
	ASL	#1,D1
	OR	D1,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#16384,D1
	LSR	#6,D1
	LSR	#8,D1
	ASL	#2,D1
	OR	D1,D4
	CMPI	#4,D6
	BCS.S	L138
	CMPI	#7,D6
	BHI.S	L138
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#0,D0
	BNE.S	L138
DATA SEG "s!"
	DATA 28 42 55 52 4E 54 20 4F 55 54 29 00 
CODE SEG "player"
	PEA	s!+226(A4)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
L138:
	BRA	L135(PC)
	BRA.S	L137
L136:
	CMP	#6,D0
	BEQ.S	L137
	BRA.S	L139
L137:
	MOVE	#12,D5
	MOVE.L	A2,D4
	MOVE.L	D4,A0
	MOVE	2(A0),D4
	AND	#256,D4
	LSR	#8,D4
	ASL	#3,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#8192,D1
	LSR	#5,D1
	LSR	#8,D1
	ASL	#2,D1
	OR	D1,D4
	BRA	L135(PC)
	BRA.S	L140
L139:
	CMP	#8,D0
	BEQ.S	L140
	BRA.S	L141
L140:
	MOVE	#1,D5
	MOVE	#2,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE	2(A0),D1
	AND	#32512,D1
	LSR	#8,D1
	ADD	D1,D4
	MULS	#6,D4
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	BRA	L135(PC)
	BRA.S	L142
L141:
	CMP	#10,D0
	BEQ.S	L142
	BRA	L143(PC)
L142:
	CMPI	#8,D6
	BCS.S	L145
	CMPI	#9,D6
	BHI.S	L145
	CLR	D5
	MOVE	2(A2),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
L146:
	CMP	#0,D0
	BEQ.S	L147
	BRA.S	L149
L147:
DATA SEG "s!"
	DATA 28 45 4D 50 54 59 29 00 
CODE SEG "player"
	LEA	s!+238(A4),A0
	MOVE.L	A0,A3
	BRA.S	L148
	BRA.S	L150
L149:
	CMP	#1,D0
	BEQ.S	L150
	BRA.S	L151
L150:
DATA SEG "s!"
	DATA 28 41 4C 4D 4F 53 54 20 45 4D 50 54 59 29 00 00 
CODE SEG "player"
	LEA	s!+246(A4),A0
	MOVE.L	A0,A3
	BRA.S	L148
	BRA.S	L152
L151:
	CMP	#2,D0
	BEQ.S	L152
	BRA.S	L153
L152:
DATA SEG "s!"
	DATA 28 41 4C 4D 4F 53 54 20 46 55 4C 4C 29 00 
CODE SEG "player"
	LEA	s!+262(A4),A0
	MOVE.L	A0,A3
	BRA.S	L148
	BRA.S	L154
L153:
	CMP	#3,D0
	BEQ.S	L154
	BRA.S	L155
L154:
DATA SEG "s!"
	DATA 28 46 55 4C 4C 29 00 00 
CODE SEG "player"
	LEA	s!+276(A4),A0
	MOVE.L	A0,A3
L155:
L156:
L148:
	MOVE.L	A3,-(A7)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L157
L145:
	CMPI	#0,D6
	BCS.S	L158
	CMPI	#3,D6
	BHI.S	L158
	CLR	D5
DATA SEG "s!"
	DATA 50 41 52 54 59 20 46 41 43 49 4E 47 20 00 
CODE SEG "player"
	PEA	s!+284(A4)
	PEA	-114(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	11G430_apc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-114(A6)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L159
L158:
	MOVE	#1,D5
	MOVE	#127,D4
	MOVE	2(A2),D1
	AND	#127,D1
	ADD	D1,D4
	MULS	#6,D4
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
L159:
L157:
L143:
L144:
L135:
	MOVE	D5,D0
	BEQ.S	L160
	MOVE.L	-68(A6),-(A7)
	MOVE.L	-72(A6),-(A7)
	PEA	-114(A6)
	PEA	-64(A6)
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F336_xxxx_(PC)
	ADDA	#20,A7
	PEA	-114(A6)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
L160:
DATA SEG "s!"
	DATA 57 45 49 47 48 53 20 00 
CODE SEG "player"
	PEA	s!+298(A4)
	PEA	-114(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	MOVE	#3,-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2E 00 
CODE SEG "player"
	PEA	s!+306(A4)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MULU	#10,D0
	SUB	D0,D7
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 4B 47 2E 00 00 
CODE SEG "player"
	PEA	s!+308(A4)
	PEA	-114(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-114(A6)
	JSR	F335_xxxx_(PC)
	ADDQ.L	#4,A7
L128:
L126:
	MOVE	10(A6),-(A7)
	JSR	F339_xxxx_(PC)
	ADDQ.L	#2,A7
L124:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$123:	.EQU	#-114
F343_xxxx_:/* global */
	LINK	A6,L$161
	MOVE	8(A6),D0
	MOVE	D0,-8(A6)
	ADD	12(A6),D0
	MOVE	D0,-6(A6)
	MOVE	10(A6),D0
	MOVE	D0,-4(A6)
	ADDQ	#6,D0
	MOVE	D0,-2(A6)
	CLR	G578_B_Use(A4)
	MOVE	#112,-(A7)
	MOVE	14(A6),-(A7)
	PEA	-8(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
L162:
	UNLK	A6
	RTS
L$161:	.EQU	#-8
F344_xxxx_:/* global */
	LINK	A6,L$163
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	CMPI	#-512,D7
	BGE.S	L165
	MOVE	#8,D6
	BRA.S	L166
L165:
	CMPI	#0,D7
	BGE.S	L167
	MOVE	#11,D6
	BRA.S	L168
L167:
	MOVE	12(A6),D6
L168:
L166:
	MOVE	D7,D5
	ADD	#1024,D5
	CMPI	#3072,D5
	BNE.S	L169
	MOVE	#3071,D5
L169:
	MOVE	D5,D0
	ASR	#5,D0
	MOVE	D0,D5
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),D0
	ADDQ	#2,D0
	MOVE	D0,-(A7)
	MOVE	#115,-(A7)
	JSR	F343_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	#113,-(A7)
	JSR	F343_xxxx_(PC)
	ADDQ.L	#8,A7
L164:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$163:	.EQU	#0
F345_xxxx_:/* global */
	LINK	A6,L$170
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	G423_i_Inv(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	JSR	F334_akzz_(PC)
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#20,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#24,-(A7)
	PEA	G035_s_Gra(A4)
	MOVE	#30,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#24,-(A7)
	PEA	G036_s_Gra(A4)
	MOVE	#31,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE.B	42(A3),D0
	BEQ.S	L172
	MOVE	#12,-(A7)
	MOVE	#48,-(A7)
	PEA	G037_s_Gra(A4)
	MOVE	#32,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
L172:
	MOVE	#5,-(A7)
	MOVE	#69,-(A7)
	MOVE	66(A3),-(A7)
	JSR	F344_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	#14,-(A7)
	MOVE	#92,-(A7)
	MOVE	68(A3),-(A7)
	JSR	F344_xxxx_(PC)
	ADDQ.L	#6,A7
L171:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$170:	.EQU	#0
F346_xxxx_:/* global */
	LINK	A6,L$173
	MOVE	#5,G424_i_Pan(A4)
	MOVE	#6,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#40,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
L174:
	UNLK	A6
	RTS
L$173:	.EQU	#0
F347_xxxx_:/* global */
	LINK	A6,L$175
	MOVEM.L	A3/D7,-(A7)
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L177
	JSR	F346_xxxx_(PC)
	BRA.S	L176
L177:
	MOVE	G423_i_Inv(A4),D7
	MULS	#800,D7
	LEA	G407_s_Par+-588(A4),A0
	ADDA	D7,A0
	MOVE	2(A0),D7
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CLR	G424_i_Pan(A4)
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L178:
	CMP	#9,D0
	BEQ.S	L179
	BRA.S	L181
L179:
	MOVE	#4,G424_i_Pan(A4)
	BRA.S	L180
	BRA.S	L182
L181:
	CMP	#7,D0
	BEQ.S	L182
	BRA.S	L183
L182:
	MOVE	#2,G424_i_Pan(A4)
	BRA.S	L180
L184:
	MOVE	#-1,D7
	BRA.S	L185
L183:
	BRA.S	L184
L185:
L180:
	CMPI	#-1,D7
	BNE.S	L186
	JSR	F345_xxxx_(PC)
	BRA.S	L176
L186:
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F342_xxxx_(PC)
	ADDQ.L	#4,A7
L176:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$175:	.EQU	#0
F348_xxxx_:/* global */
	LINK	A6,L$187
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CMPI	#0,D6
	BLT.S	L189
	MOVE	D7,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	CMPI	#120,D0
	BLE.S	L190
	MOVE	D6,D0
	ASR	#1,D0
	MOVE	D0,D6
	CMPI	#150,D5
	BLE.S	L191
	MOVE	D6,D0
	ASR	#1,D0
	MOVE	D0,D6
L191:
	ADDQ	#1,D6
L190:
	MOVE	#170,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	BRA.S	L192
L189:
	MOVE	D7,D0
	MULS	#3,D0
	LEA	72(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D7,D1
	MULS	#3,D1
	LEA	71(A3),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	(A0),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
L192:
	MOVE	D7,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D5,D0
	MOVE.B	D0,(A0)
L188:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$187:	.EQU	#0
F349_dzzz_:/* global */
	LINK	A6,L$193
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L195
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L196
	BRA	L194(PC)
L196:
	MOVE	#1,G597_B_Ign(A4)
	MOVE	#1,G333_B_Pre(A4)
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	BNE.S	L197
	CLR	G597_B_Ign(A4)
	CLR	G333_B_Pre(A4)
	CLR	G334_B_Sto(A4)
	BRA.S	L198
L197:
	JSR	F077_aA39_(PC)
	MOVE	#1,G587_i_Hid(A4)
	JSR	F345_xxxx_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
L198:
	BRA	L199(PC)
L195:
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L200
	BRA	L194(PC)
L200:
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#1,D0
	BNE.S	L201
	BRA	L194(PC)
L201:
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-18(A6)
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-20(A6)
	MOVE	G423_i_Inv(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D5
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CMPI	#8,D6
	BCS.S	L202
	CMPI	#9,D6
	BHI.S	L202
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	BNE.S	L203
	BRA	L194(PC)
L203:
	MOVE	#2048,-(A7)
	MOVE	68(A2),D0
	ADD	#800,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,68(A2)
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A3)
	OR	D3,2(A3)
	CLR	D4
	BRA.S	L204
L202:
	CMPI	#8,-18(A6)
	BNE.S	L205
	CLR	D4
	BRA.S	L206
L205:
	MOVE	#-1,(A3)
	MOVE	#1,D4
L206:
L204:
	JSR	F077_aA39_(PC)
	MOVE	D4,D0
	BEQ.S	L207
	JSR	F298_aqzz_(PC)
L207:
	CMPI	#8,-18(A6)
	BNE	L208(PC)
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	MOVE	#32,D0
	MOVE	-12(A6),D1
	ADDQ	#1,D1
	AND.L	#65535,D1
	DIVU	#8,D1
	ADD	D1,D0
	MOVE	D0,-30(A6)
	MOVE	#511,D0
	SUB	-12(A6),D0
	AND.L	#65535,D0
	DIVU	-30(A6),D0
	LSR	#1,D0
	MOVE	D0,-14(A6)
	MOVE	-12(A6),D0
	AND.L	#65535,D0
	DIVU	#25,D0
	ADDQ	#8,D0
	MOVE	D0,-12(A6)
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#32512,D0
	LSR	#8,D0
L209:
	CMP	#6,D0
	BEQ.S	L210
	BRA.S	L212
L210:
	MOVE	-12(A6),-(A7)
	MOVE	#2,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L211(PC)
	BRA.S	L213
L212:
	CMP	#7,D0
	BEQ.S	L213
	BRA.S	L214
L213:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#255,D0
	AND.L	#65535,D0
	DIVU	#35,D0
	ADDQ	#5,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L211(PC)
	BRA.S	L215
L214:
	CMP	#8,D0
	BEQ.S	L215
	BRA.S	L216
L215:
	MOVE	-12(A6),-(A7)
	MOVE	#3,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L211(PC)
	BRA.S	L217
L216:
	CMP	#9,D0
	BEQ.S	L217
	BRA.S	L218
L217:
	MOVE	-12(A6),-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F348_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA	L211(PC)
	BRA.S	L219
L218:
	CMP	#10,D0
	BEQ.S	L219
	BRA.S	L220
L219:
	MOVE	D5,-(A7)
	JSR	F323_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L211(PC)
	BRA.S	L221
L220:
	CMP	#11,D0
	BEQ.S	L221
	BRA.S	L222
L221:
	MOVE	58(A2),D0
	AND.L	#65535,D0
	DIVU	-14(A6),D0
	MOVE	D0,-(A7)
	MOVE	58(A2),D0
	SUB	56(A2),D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,56(A2)
	BRA	L211(PC)
	BRA.S	L223
L222:
	CMP	#12,D0
	BEQ.S	L223
	BRA.S	L224
L223:
	MOVE	-12(A6),D0
	LSR	#1,D0
	ADD	D0,-12(A6)
	CMPI	#50,274(A2)
	BLE.S	L226
	MOVE	-12(A6),D0
	LSR	#2,D0
	MOVE	D0,-12(A6)
L226:
	MOVE	-12(A6),D0
	ADD	D0,274(A2)
	MOVE.B	#72,-6(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	-12(A6),D1
	MULU	-12(A6),D1
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE	D5,D0
	MOVE.B	D0,-5(A6)
	MOVE	-12(A6),-4(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	ORI	#4096,48(A2)
	BRA	L211(PC)
	BRA.S	L225
L224:
	CMP	#13,D0
	BEQ.S	L225
	BRA.S	L227
L225:
	MOVE	60(A2),D0
	ADD	-12(A6),D0
	MOVE	-12(A6),D1
	SUBQ	#8,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#900,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-18(A6)
	MOVE	-18(A6),D0
	MOVE	62(A2),D1
	CMP	D1,D0
	BLS.S	L229
	MOVE	62(A2),-(A7)
	MOVE	60(A2),-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-40(A6)
	MOVE	-18(A6),D0
	SUB	-40(A6),D0
	LSR	#1,D0
	SUB	D0,-18(A6)
L229:
	MOVE	-18(A6),60(A2)
	BRA	L211(PC)
	BRA.S	L228
L227:
	CMP	#14,D0
	BEQ.S	L228
	BRA	L230(PC)
L228:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#255,D0
	AND.L	#65535,D0
	DIVU	#42,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-18(A6)
	MOVE	54(A2),D0
	AND.L	#65535,D0
	DIVU	-14(A6),D0
	ADD	D0,52(A2)
	MOVE	50(A2),-16(A6)
	BEQ.S	L232
	MOVE	#10,-14(A6)
L233:
	CLR	-12(A6)
	BRA.S	L236
L237:
	JSR	F027_AA59_(PC)
	AND	D0,50(A2)
L238:
	ADDQ	#1,-12(A6)
L236:
	MOVE	-12(A6),D0
	CMP	-18(A6),D0
	BCS.S	L237
L239:
	MOVE	#1,-18(A6)
L234:
	MOVE	-16(A6),D0
	CMP	50(A2),D0
	BNE.S	L240
	SUBQ	#1,-14(A6)
	MOVE	-14(A6),D0
	BNE.S	L233
L240:
L235:
L232:
	ORI	#8704,48(A2)
	BRA.S	L211
	BRA.S	L231
L230:
	CMP	#15,D0
	BEQ.S	L231
	BRA.S	L241
L231:
	MOVE	#2048,-(A7)
	MOVE	68(A2),D0
	ADD	#1600,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,68(A2)
L241:
L242:
L211:
	MOVE	#20,D0
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	AND	#127,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-32513,2(A0)
	OR	D3,2(A0)
	BRA.S	L243
L208:
	CMPI	#168,D6
	BCS.S	L244
	CMPI	#176,D6
	BCC.S	L244
	MOVE	#2048,-(A7)
	MOVE	66(A2),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G242_ai_Gr+-336(A4),A0
	ADDA	D1,A0
	ADD	(A0),D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,66(A2)
L244:
L243:
	MOVE	56(A2),D0
	CMP	58(A2),D0
	BLE.S	L245
	MOVE	58(A2),56(A2)
L245:
	MOVE	52(A2),D0
	CMP	54(A2),D0
	BLE.S	L246
	MOVE	54(A2),52(A2)
L246:
	MOVE	D4,D0
	BEQ.S	L247
	MOVE	#5,-14(A6)
	BRA.S	L248
L249:
	MOVE	#46,-(A7)
	MOVE	#56,-(A7)
	MOVE	#205,D0
	MOVE	-14(A6),D1
	AND	#1,D1
	SEQ	D1
	AND	#1,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F037_aA29_(PC)
	ADDQ.L	#6,A7
	MOVE	#8,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
L248:
	SUBQ	#1,-14(A6)
	BNE.S	L249
L250:
	BRA.S	L251
L247:
	JSR	F296_aizz_(PC)
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	SUB	-20(A6),D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
L251:
	CLR	-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#8,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	ORI	#256,48(A2)
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L252
	ORI	#2048,48(A2)
L252:
	MOVE	D5,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L199:
L194:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$193:	.EQU	#-40
F350_aqzz_:/* global */
	LINK	A6,L$253
	JSR	F347_xxxx_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
L254:
	UNLK	A6
	RTS
L$253:	.EQU	#0
F351_xxxx_:/* global */
	LINK	A6,L$255
CODE SEG "init!"
	LEA	21G431_apc(A4),A1
DATA SEG "s!"
	DATA 4C 00 
CODE SEG "init!"
	LEA	s!+314(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 53 54 52 45 4E 47 54 48 00 00 
CODE SEG "init!"
	LEA	s!+316(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 44 45 58 54 45 52 49 54 59 00 
CODE SEG "init!"
	LEA	s!+326(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 57 49 53 44 4F 4D 00 00 
CODE SEG "init!"
	LEA	s!+336(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 56 49 54 41 4C 49 54 59 00 00 
CODE SEG "init!"
	LEA	s!+344(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 4E 54 49 2D 4D 41 47 49 43 00 00 
CODE SEG "init!"
	LEA	s!+354(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 41 4E 54 49 2D 46 49 52 45 00 
CODE SEG "init!"
	LEA	s!+366(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
21G431_apc:
	.WORD	#28
CODE SEG "player"
	MOVEM.L	A3/D7-D4,-(A7)
	JSR	F334_akzz_(PC)
	MOVE	G423_i_Inv(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D4
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#8,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#20,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#58,D6
	CLR	D7
	BRA.S	L257
L258:
	MOVE	D7,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#16,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	CMPI	#1,D5
	BNE.S	L261
	BRA.S	L259
L261:
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G428_apc_S+-8(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-24(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 00 
CODE SEG "player"
	PEA	s!+376(A4)
	PEA	-24(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	-24(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-24(A6)
	MOVE	#13,-(A7)
	MOVE	D6,-(A7)
	MOVE	#108,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	ADDQ	#7,D6
L259:
	ADDQ	#1,D7
L257:
	CMPI	#3,D7
	BLS.S	L258
L260:
	MOVE	#86,D6
	MOVE	#1,D7
	BRA	L262(PC)
L263:
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	21G431_apc(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	#13,-(A7)
	MOVE	D6,-(A7)
	MOVE	#108,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	D7,D5
	MULS	#3,D5
	LEA	71(A3),A0
	ADDA	D5,A0
	MOVE.B	(A0),D5
	AND	#255,D5
	MOVE	D7,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	MOVE	D5,D0
	CMP	-4(A6),D0
	BCC.S	L266
	MOVE	#8,-2(A6)
	BRA.S	L267
L266:
	MOVE	D5,D0
	CMP	-4(A6),D0
	BLS.S	L268
	MOVE	#7,-2(A6)
	BRA.S	L269
L268:
	MOVE	#13,-2(A6)
L269:
L267:
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	#174,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+378(A4)
	PEA	-24(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	-24(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	-24(A6)
	MOVE	#13,-(A7)
	MOVE	D6,-(A7)
	MOVE	#192,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	ADDQ	#7,D6
L264:
	ADDQ	#1,D7
L262:
	CMPI	#6,D7
	BLS	L263(PC)
L265:
L256:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$255:	.EQU	#-24
F352_aszz_:/* global */
	LINK	A6,L$270
	MOVEM.L	D7-D6,-(A7)
	MOVE	#1,G597_B_Ign(A4)
	MOVE	#1,G331_B_Pre(A4)
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	BNE.S	L272
	CLR	G597_B_Ign(A4)
	CLR	G331_B_Pre(A4)
	CLR	G332_B_Sto(A4)
	BRA.S	L271
L272:
	JSR	F357_qzzz_(PC)
	JSR	F077_aA39_(PC)
	MOVE	#8,-(A7)
	JSR	F022_aaaU_(PC)
	ADDQ.L	#2,A7
	MOVE	#13,-(A7)
	MOVE	#12,-(A7)
	MOVE	#203,-(A7)
	JSR	F332_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L273
	JSR	F351_xxxx_(PC)
	BRA.S	L274
L273:
	JSR	F035_aaaw_(PC)
	MOVE	#1,-(A7)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F342_xxxx_(PC)
	ADDQ.L	#4,A7
L274:
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
L271:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$270:	.EQU	#0
F353_auzz_:/* global */
	LINK	A6,L$275
	MOVE	D7,-(A7)
	MOVE	#13,-(A7)
	MOVE	#12,-(A7)
	MOVE	#202,-(A7)
	JSR	F332_xxxx_(PC)
	ADDQ.L	#6,A7
	JSR	F347_xxxx_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L277
	MOVE	D7,-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L277:
	JSR	F078_xzzz_(PC)
L276:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$275:	.EQU	#0
F354_szzz_:/* global */
	LINK	A6,L$278
	CLR	G578_B_Use(A4)
	CLR	-4(A6)
	MOVE	#28,-2(A6)
	MOVE	8(A6),D0
	MULS	#69,D0
	ADDQ	#7,D0
	MOVE	D0,-8(A6)
	ADD	#31,D0
	MOVE	D0,-6(A6)
	MOVE	#-1,-(A7)
	MOVE	#16,-(A7)
	PEA	-8(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par+336(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
L279:
	UNLK	A6
	RTS
L$278:	.EQU	#-8
F355_hzzz_:/* global */
	LINK	A6,L$280
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	CMPI	#4,D7
	BEQ.S	L282
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L282
	BRA	L281(PC)
L282:
	MOVE	G333_B_Pre(A4),D0
	BNE.S	L284
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L283
L284:
	BRA	L281(PC)
L283:
	MOVE	#1,G321_B_Sto(A4)
	MOVE	G423_i_Inv(A4),D6
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	D6,D0
	BNE.S	L285
	MOVE	#4,D7
L285:
	JSR	F077_aA39_(PC)
	MOVE	D6,D0
	BEQ.S	L286
	CLR	G423_i_Inv(A4)
	JSR	F334_akzz_(PC)
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BEQ.S	L287
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L287
	ORI	#4096,48(A3)
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L287:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L288
	JSR	F078_xzzz_(PC)
	BRA	L281(PC)
L288:
	CMPI	#4,D7
	BNE.S	L289
	MOVE	#1,G326_B_Ref(A4)
	JSR	F395_pzzz_(PC)
	JSR	F078_xzzz_(PC)
	LEA	G448_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	LEA	G459_as_Gr(A4),A0
	MOVE.L	A0,G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	JSR	F098_rzzz_(PC)
	BRA	L281(PC)
L289:
L286:
	CLR	G578_B_Use(A4)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,G423_i_Inv(A4)
	MOVE	D6,D0
	BNE.S	L290
	CLR	-(A7)
	PEA	G002_s_Gra(A4)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
L290:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	#17,-(A7)
	JSR	F488_bzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L291
	MOVE	#112,-(A7)
	MOVE	#12,-(A7)
	PEA	G041_s_Gra(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
L291:
DATA SEG "s!"
	DATA 48 45 41 4C 54 48 00 00 
CODE SEG "player"
	PEA	s!+380(A4)
	MOVE	#13,-(A7)
	MOVE	#116,-(A7)
	MOVE	#5,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 53 54 41 4D 49 4E 41 00 
CODE SEG "player"
	PEA	s!+388(A4)
	MOVE	#13,-(A7)
	MOVE	#124,-(A7)
	MOVE	#5,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 4D 41 4E 41 00 00 
CODE SEG "player"
	PEA	s!+396(A4)
	MOVE	#13,-(A7)
	MOVE	#132,-(A7)
	MOVE	#5,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	CLR	D6
	BRA.S	L292
L293:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
L294:
	ADDQ	#1,D6
L292:
	CMPI	#30,D6
	BCS.S	L293
L295:
	ORI	#23424,48(A3)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,G598_B_Mou(A4)
	JSR	F078_xzzz_(PC)
	LEA	G449_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	CLR.L	G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
L281:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$280:	.EQU	#0
