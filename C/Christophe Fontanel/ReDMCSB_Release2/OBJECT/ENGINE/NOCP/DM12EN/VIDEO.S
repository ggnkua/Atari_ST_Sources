CODE SEG "show"
F129_szzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A5-A2/D7-D4,-(A7)
	MOVE.L	24(A6),A5
	MOVE.L	8(A6),A0
	MOVE.L	12(A6),A1
	MOVEQ	#0,D1
	MOVE	16(A6),D1
	MOVEQ	#15,D0
	ADD	D1,D0
	AND	#-16,D0
	LSR	#1,D0
	MOVE	D0,-10(A6)
	MOVE	20(A6),D3
	MOVEQ	#10,D2
	LSL.L	D2,D1
	DIVU	D3,D1
	ANDI.L	#65535,D1
	LSL.L	#6,D1
	MOVE.L	D1,A2
	LSR.L	#1,D1
	ADDI.L	#32767,D1
	MOVE.L	D1,-8(A6)
	MOVEQ	#0,D1
	MOVE	18(A6),D1
	LSL.L	D2,D1
	DIVU	22(A6),D1
	ANDI.L	#65535,D1
	LSL.L	#6,D1
	MOVE.L	D1,-4(A6)
	LSR.L	#1,D1
	ADDI.L	#32767,D1
	MOVE.L	D1,A4
	SWAP	D1
	MULU	D1,D0
	ADDA	D0,A0
	MOVE	D3,-(A7)
L0T129_001_:
	MOVE	#-1,A3
	MOVE.L	-8(A6),D4
	MOVE.L	#-2147450880,D7
L0T129_002_:
	MOVEQ	#0,D2
	MOVEQ	#0,D3
L0T129_003_:
	SWAP	D4
	MOVEQ	#240,D6
	AND	D4,D6
	CMP	A3,D6
	BEQ.S	L0T129_004
	MOVE	D6,A3
	LSR	#1,D6
	MOVEM.L	0(A0,D6),D0-D1
L0T129_004:
	MOVEQ	#15,D6
	AND	D4,D6
	NEG	D6
	ADDI	#15,D6
	MOVEQ	#0,D5
	BTST	D6,D0
	BEQ.S	L0T129_005
	MOVEQ	#2,D5
L0T129_005:
	BTST	D6,D1
	BEQ.S	L0T129_006
	ADDQ	#8,D5
L0T129_006:
	ADDI	#16,D6
	BTST	D6,D0
	BEQ.S	L0T129_007
	ADDQ	#1,D5
L0T129_007:
	BTST	D6,D1
	BEQ.S	L0T129_008
	ADDQ	#4,D5
L0T129_008:
	MOVE.B	0(A5,D5),D5
	JMP	2(PC,D5)
L0T129_009:
	BRA	L0T129_010(PC)
	NOP
	NOP
	NOP
	SWAP	D2
	OR	D7,D2
	SWAP	D2
	BRA	L0T129_010(PC)
	OR	D7,D2
	BRA	L0T129_010(PC)
	NOP
	NOP
	OR.L	D7,D2
	BRA	L0T129_010(PC)
	NOP
	NOP
	SWAP	D3
	OR	D7,D3
	SWAP	D3
	BRA	L0T129_010(PC)
	MOVE	D7,D6
	SWAP	D6
	OR.L	D6,D2
	OR.L	D6,D3
	BRA.S	L0T129_010
	OR	D7,D2
	SWAP	D3
	OR	D7,D3
	SWAP	D3
	BRA.S	L0T129_010
	OR.L	D7,D2
	SWAP	D3
	OR	D7,D3
	SWAP	D3
	BRA.S	L0T129_010
	OR	D7,D3
	BRA.S	L0T129_010
	NOP
	NOP
	NOP
	OR	D7,D3
	SWAP	D2
	OR	D7,D2
	SWAP	D2
	BRA.S	L0T129_010
	OR	D7,D2
	OR	D7,D3
	BRA.S	L0T129_010
	NOP
	NOP
	OR.L	D7,D2
	OR	D7,D3
	BRA.S	L0T129_010
	NOP
	NOP
	OR.L	D7,D3
	BRA.S	L0T129_010
	NOP
	NOP
	NOP
	SWAP	D2
	OR	D7,D2
	SWAP	D2
	OR.L	D7,D3
	BRA.S	L0T129_010
	OR	D7,D2
	OR.L	D7,D3
	BRA.S	L0T129_010
	NOP
	NOP
	OR.L	D7,D2
	OR.L	D7,D3
L0T129_010:
	SUBQ	#1,(A7)
	BEQ.S	L0T129_011
	SWAP	D4
	ADD.L	A2,D4
	ROR.L	#1,D7
	BCC	L0T129_003_(PC)
	MOVE.L	D2,(A1)+
	MOVE.L	D3,(A1)+
	BRA	L0T129_002_(PC)
L0T129_011:
	MOVE.L	D2,(A1)+
	MOVE.L	D3,(A1)+
	SUBQ	#1,22(A6)
	BEQ.S	L0T129_012
	MOVE.L	A4,D2
	MOVE.L	D2,D3
	ADD.L	-4(A6),D3
	MOVE.L	D3,A4
	SWAP	D2
	SWAP	D3
	SUB	D2,D3
	MULU	-10(A6),D3
	ADDA	D3,A0
	MOVE	20(A6),(A7)
	BRA	L0T129_001_(PC)
L0T129_012:
	ADDQ	#2,A7
	MOVEM.L	(A7)+,D4-D7/A2-A5
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#-10
F130_xxxx_:/* global */
	LINK	A6,L$2
	MOVEM.L	D7-D6,-(A7)
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVEM.L	A4-A2,-(A7)
	MOVE.L	8(A6),A0
	LEA	L1V130_1_xx(PC),A2
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVE	D7,D3
	LSR	#3,D7
	MOVE.L	A0,A1
	ADDA	D3,A1
	SUBQ.L	#6,A1
	MOVE.L	A0,A3
	MOVE.L	A1,A4
L1T130_001_:
	MOVE	D7,D2
L1T130_002:
	SUBQ	#2,D2
	BMI.S	L1T130_003
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	ADDQ.L	#4,A1
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	ADDQ.L	#4,A1
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	ADDQ.L	#4,A1
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)+
	TST	D2
	BEQ.S	L1T130_004
	SUBA	#12,A1
	BRA.S	L1T130_002
L1T130_003:
	MOVE.B	(A0),D0
	MOVE.B	-(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)
	ADDQ.L	#2,A0
	ADDQ.L	#2,A1
	MOVE.B	(A0),D0
	MOVE.B	(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)
	ADDQ.L	#2,A0
	ADDQ.L	#2,A1
	MOVE.B	(A0),D0
	MOVE.B	(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)
	ADDQ.L	#2,A0
	ADDQ.L	#2,A1
	MOVE.B	(A0),D0
	MOVE.B	(A1),D1
	MOVE.B	0(A2,D0),(A1)
	MOVE.B	0(A2,D1),(A0)
L1T130_004:
	SUBQ	#1,D6
	BEQ	L1T130_006_(PC)
	ADDA	D3,A3
	MOVE.L	A3,A0
	ADDA	D3,A4
	MOVE.L	A4,A1
	BRA	L1T130_001_(PC)
L1V130_1_xx:
	ORI.L	#1086333088,D0
	BRA.S	-32(PC)
	MOVE.B	(A0),(A0)
	ST	(A0)
	MOVE	-16(A0,D7),(A0)
	BCLR	#18632,A0
	MOVE.L	26856(A0),(A4)
	MOVE.B	(A0)+,(A4)
	SVC	(A0)+
	MOVE	30968.W,(A4)
	SUBI.L	#1153705124,D4
	BCC.S	-28(PC)
	MOVE.B	(A4),(A2)
	SCC	(A4)
	MOVE	-12(A4,D7),(A2)
	CMPI.L	#1288449196,A4
	BGE.S	-20(PC)
	MOVE.B	(A4)+,(A6)
	SGE	(A4)+
	MOVE	#31996,(A6)
	ANDI.L	#1120019106,D2
	BHI.S	-30(PC)
	MOVE.B	(A2),(A1)
	SHI	(A2)
	MOVE	-14(A2,D7),(A1)
	EORI.L	#1254763178,A2
	BPL.S	-22(PC)
	MOVE.B	(A2)+,(A5)
	SPL	(A2)+
	MOVE	31482(PC),(A5)
	ADDI.L	#1187391142,D6
	BNE.S	-26(PC)
	MOVE.B	(A6),(A3)
	SNE	(A6)
	MOVE	-10(A6,D7),(A3)
	BCLR	#20174,A6
	MOVE.L	28398(A6),(A7)
	MOVE.B	(A6)+,(A7)
	SGT	(A6)+
	MOVE	*** Illegal Mode 111 ***,(A7)
	MOVEQ	#254,D7
	BCLR	D0,D1
	LEA	D1,A0
	MOVE.L	-(A1),-31(A0,D6)
	MOVE.B	(A1),-47(A0,D5)
	MOVE	-15(A1,D7),-119(A0,D0.L)
	LEA	A1,A4
	MOVE.L	27113(A1),-103(A4,D1.L)
	SVS	(A1)+
	MOVE	2046363013.L,-59(A4,D4)
	MOVE.L	-(A5),-27(A2,D6)
	MOVE.B	(A5),-43(A2,D5)
	MOVE	-11(A5,D7),-115(A2,D0.L)
	LEA	A5,A6
	MOVE.L	28141(A5),-99(A6,D1.L)
	SLT	(A5)+
	MOVE	*** Illegal Mode 111 ***,-3(A6,D7.L)
	BCLR	D1,D3
	LEA	D3,A1
	MOVE.L	-(A3),-29(A1,D6)
	MOVE.B	(A3),-45(A1,D5)
	MOVE	-13(A3,D7),-117(A1,D0.L)
	LEA	A3,A5
	MOVE.L	27627(A3),-101(A5,D1.L)
	SMI	(A3)+
	MOVE	-5(PC,D7.L),-121(A5,D0)
	LEA	D7,A3
	MOVE.L	-(A7),-25(A3,D6)
	MOVE.B	(A7),-41(A3,D5)
	MOVE	-9(A7,D7),-113(A3,D0.L)
	LEA	A7,A7
	MOVE.L	28655(A7),-97(A7,D1.L)
	SLE	(A7)+
	MOVE	*** Illegal Mode 111 ***,-1(A7,D7.L)
L1T130_006_:
	MOVEM.L	(A7)+,A2-A4
L3:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$2:	.EQU	#0
F131_xxxx_:/* global */
	LINK	A6,L$4
	MOVEM.L	A2/D7-D4,-(A7)
	MOVE	14(A6),D7
	MOVE	12(A6),D6
	MOVE.L	8(A6),A0
	MOVE.L	A0,A1
	MOVE	D7,D0
	SUBQ	#1,D0
	MULU	D6,D0
	ADDA	D0,A1
	MOVE	D6,A2
	ADDA	A2,A2
	LSR	#3,D6
L2T131_001_:
	SUBQ	#2,D7
	BMI	L2T131_006_(PC)
	SWAP	D7
	MOVE	D6,D7
L2T131_002_:
	SUBQ	#3,D7
	BMI.S	L2T131_003
	MOVEM.L	(A0),D0-D5
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVEM.L	D0-D5,-24(A1)
	TST	D7
	BNE.S	L2T131_002_
	BRA.S	L2T131_005
L2T131_003:
	ADDQ	#2,D7
L2T131_004:
	MOVE.L	(A0),D0
	MOVE.L	(A1),(A0)+
	MOVE.L	D0,(A1)+
	MOVE.L	(A0),D0
	MOVE.L	(A1),(A0)+
	MOVE.L	D0,(A1)+
	DBF	D7,L2T131_004
L2T131_005:
	SUBA	A2,A1
	SWAP	D7
	TST	D7
	BNE	L2T131_001_(PC)
L2T131_006_:
	MOVEM.L	(A7)+,D4-D7/A2
L5:
	UNLK	A6
	RTS
L$4:	.EQU	#0
F132_xzzz_:/* global */
	LINK	A6,L$6
	MOVEM.L	A5-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A0
	MOVE.L	12(A6),A1
	MOVE	28(A6),D0
	MOVE	26(A6),D1
	MOVE	24(A6),D2
	MOVE	22(A6),D3
	MOVE	20(A6),D4
	CMPA.L	#0,A1
	BNE.S	L3T132_001
	MOVEM.L	A0/D4-D0,-(A7)
	MOVE	#2,-(A7)
	TRAP	#14
	ADDQ.L	#2,A7
	MOVE.L	D0,A1
	MOVEM.L	(A7)+,D0-D4/A0
L3T132_001:
	MOVE.L	16(A6),A2
	LEA	L3V132_1_xx(PC),A5
	MOVEQ	#15,D5
	AND	D4,D5
	MULU	D2,D3
	ADDA.L	D3,A0
	SUB	D5,D4
	LSR	#1,D4
	ADDA	D4,A0
	MOVEQ	#0,D7
	MOVEQ	#0,D4
	TST	G578_B_Use(A4)
	BEQ.S	L3T132_002
	MOVE.B	(A2)+,D4
	MOVE.B	(A2)+,D7
	BRA.S	L3T132_003
L3T132_002:
	MOVE	(A2)+,D4
	MOVE	(A2)+,D7
L3T132_003:
	SUB	D4,D7
	ADDQ	#1,D7
	SWAP	D7
	MOVEQ	#0,D3
	TST	G578_B_Use(A4)
	BEQ.S	L3T132_004
	MOVE.B	(A2)+,D3
	MOVE.B	(A2),D7
	BRA.S	L3T132_005
L3T132_004:
	MOVE	(A2)+,D3
	MOVE	(A2),D7
L3T132_005:
	SUB	D3,D7
	SWAP	D7
	MOVEQ	#15,D6
	AND	D4,D6
	MULU	D1,D3
	ADDA.L	D3,A1
	SUB	D6,D4
	LSR	#1,D4
	ADDA	D4,A1
	MOVEQ	#15,D3
	ADD	D7,D3
	ADD	D5,D3
	ANDI	#-16,D3
	LSR	#1,D3
	MOVE	D2,D4
	SUB	D3,D4
	MOVE	D4,A3
	ADD	D6,D7
	MOVE	D7,-2(A6)
	MOVEQ	#15,D3
	ADD	D7,D3
	ANDI	#-16,D3
	LSR	#1,D3
	SUB	D3,D1
	MOVE	D1,A4
	MOVE	D5,D1
	NEG	D5
	ADD	D6,D5
	BPL.S	L3T132_006
	ADDI	#16,D5
L3T132_006:
	MOVE	D6,D3
	ADD	D3,D3
	MOVE	0(A5,D3),-4(A6)
	MOVE	D7,D3
	ADD	D7,D3
	CMPI	#32,D3
	BPL.S	L3T132_007
	MOVE	0(A5,D3),D3
	NOT	D3
	OR	D3,-4(A6)
	CMP	D5,D6
	BPL.S	L3T132_008
	ADD	D7,D1
	SUB	D6,D1
	CMPI	#17,D1
	BPL.S	L3T132_008
	SUBQ	#8,A3
	BRA.S	L3T132_008
L3T132_007:
	ANDI	#31,D3
	MOVE	0(A5,D3),D3
	NOT	D3
	MOVE	D3,-6(A6)
L3T132_008:
	MOVE	D5,D3
	ADD	D3,D3
	MOVE	0(A5,D3),A5
	SWAP	D5
	TST	D0
	BPL.S	L3T132_009
	LEA	L3T132_035_(PC),A2
	BRA.S	L3T132_011_
L3T132_009:
	ADD	D0,D0
	MOVE	D0,D3
	ADD	D0,D0
	ADD	D3,D0
	JMP	2(PC,D0)
L3T132_010:
	LEA	L3T132_019_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_020_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_021_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_022_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_023_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_024_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_025_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_026_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_027_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_028_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_029_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_030_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_031_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_032_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_033_(PC),A2
	BRA.S	L3T132_011_
	LEA	L3T132_034_(PC),A2
L3T132_011_:
	MOVE	-4(A6),D5
	SWAP	D5
	TST	D5
	BEQ.S	L3T132_013
	MOVE	A5,D4
	CMP	D5,D6
	BPL.S	L3T132_012
	MOVE	(A0)+,D1
	ROR	D5,D1
	AND	D4,D1
	SWAP	D1
	MOVE	(A0)+,D0
	ROR	D5,D0
	AND	D4,D0
	SWAP	D0
	MOVE	(A0)+,D3
	ROR	D5,D3
	AND	D4,D3
	SWAP	D3
	MOVE	(A0)+,D2
	ROR	D5,D2
	AND	D4,D2
	SWAP	D2
L3T132_012:
	SWAP	D6
	MOVE	(A0)+,D0
	ROR	D5,D0
	MOVE	D0,D6
	SWAP	D1
	AND	D4,D1
	NOT	D4
	AND	D4,D0
	OR	D1,D0
	MOVE	D6,D1
	SWAP	D1
	MOVE	(A0)+,D1
	ROR	D5,D1
	MOVE	D1,D6
	SWAP	D0
	AND	D4,D1
	NOT	D4
	AND	D4,D0
	OR	D0,D1
	MOVE	D6,D0
	SWAP	D0
	MOVE	(A0)+,D2
	ROR	D5,D2
	MOVE	D2,D6
	SWAP	D3
	AND	D4,D3
	NOT	D4
	AND	D4,D2
	OR	D3,D2
	MOVE	D6,D3
	SWAP	D3
	MOVE	(A0)+,D3
	ROR	D5,D3
	MOVE	D3,D6
	SWAP	D2
	AND	D4,D3
	NOT	D4
	AND	D4,D2
	OR	D2,D3
	MOVE	D6,D2
	SWAP	D2
	SWAP	D6
	SWAP	D5
	JMP	(A2)
L3T132_013:
	MOVEM	(A0)+,D0-D3
	SWAP	D5
	JMP	(A2)
L3T132_014:
	NOT	D4
	AND	D4,D0
	AND	D4,D1
	AND	D4,D2
	AND	D4,D3
	NOT	D4
	AND	D4,(A1)
	OR	D0,(A1)+
	AND	D4,(A1)
	OR	D1,(A1)+
	AND	D4,(A1)
	OR	D2,(A1)+
	AND	D4,(A1)
	OR	D3,(A1)+
L3T132_015:
	SUBI	#16,D7
	BLE.S	L3T132_018_
	CMPI	#16,D7
	BMI.S	L3T132_017
	CLR	D5
	SWAP	D5
L3T132_016:
	TST	D5
	BEQ.S	L3T132_013
	MOVE	A5,D4
	BRA	L3T132_012(PC)
L3T132_017:
	MOVE	-6(A6),D5
	SWAP	D5
	CMP	D7,D5
	BMI.S	L3T132_016
	SWAP	D0
	SWAP	D1
	SWAP	D2
	SWAP	D3
	MOVE	D0,D4
	MOVE	D1,D0
	MOVE	D4,D1
	MOVE	D2,D4
	MOVE	D3,D2
	MOVE	D4,D3
	SWAP	D5
	JMP	(A2)
L3T132_018_:
	SWAP	D7
	SUBQ	#1,D7
	BMI	L3T132_038_(PC)
	SWAP	D7
	MOVE	-2(A6),D7
	ADDA	A3,A0
	ADDA	A4,A1
	BRA	L3T132_011_(PC)
L3T132_019_:
	MOVE	D0,D4
	OR	D1,D4
	OR	D2,D4
	OR	D3,D4
	NOT	D4
	OR	D5,D4
	BNE.S	L3T132_014
	BRA	L3T132_036(PC)
L3T132_020_:
	MOVE	D1,D4
	OR	D2,D4
	OR	D3,D4
	NOT	D4
	AND	D0,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_021_:
	MOVE	D0,D4
	OR	D2,D4
	OR	D3,D4
	NOT	D4
	AND	D1,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_022_:
	MOVE	D2,D4
	OR	D3,D4
	NOT	D4
	AND	D0,D4
	AND	D1,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_023_:
	MOVE	D0,D4
	OR	D1,D4
	OR	D3,D4
	NOT	D4
	AND	D2,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_024_:
	MOVE	D1,D4
	OR	D3,D4
	NOT	D4
	AND	D0,D4
	AND	D2,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_025_:
	MOVE	D0,D4
	OR	D3,D4
	NOT	D4
	AND	D1,D4
	AND	D2,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_026_:
	MOVE	D3,D4
	NOT	D4
	AND	D0,D4
	AND	D1,D4
	AND	D2,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_027_:
	MOVE	D0,D4
	OR	D1,D4
	OR	D2,D4
	NOT	D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA	L3T132_036(PC)
L3T132_028_:
	MOVE	D1,D4
	OR	D2,D4
	NOT	D4
	AND	D0,D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA.S	L3T132_036
L3T132_029_:
	MOVE	D0,D4
	OR	D2,D4
	NOT	D4
	AND	D1,D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA.S	L3T132_036
L3T132_030_:
	MOVE	D2,D4
	NOT	D4
	AND	D0,D4
	AND	D1,D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA.S	L3T132_036
L3T132_031_:
	MOVE	D0,D4
	OR	D1,D4
	NOT	D4
	AND	D2,D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA.S	L3T132_036
L3T132_032_:
	MOVE	D1,D4
	NOT	D4
	AND	D0,D4
	AND	D2,D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA.S	L3T132_036
L3T132_033_:
	MOVE	D0,D4
	NOT	D4
	AND	D1,D4
	AND	D2,D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA.S	L3T132_036
L3T132_034_:
	MOVE	D0,D4
	AND	D1,D4
	AND	D2,D4
	AND	D3,D4
	OR	D5,D4
	BNE	L3T132_014(PC)
	BRA.S	L3T132_036
L3T132_035_:
	MOVE	D5,D4
	BNE	L3T132_014(PC)
L3T132_036:
	MOVE	D0,(A1)+
	MOVE	D1,(A1)+
	MOVE	D2,(A1)+
	MOVE	D3,(A1)+
	BRA	L3T132_015(PC)
L3V132_1_xx:
	ORI.B	#-32768,D0
	AND.B	D0,D0
	ASR.B	#8,D0
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
L3T132_038_:
	MOVEM.L	(A7)+,D4-D7/A2-A5
L7:
	UNLK	A6
	RTS
L$6:	.EQU	#-6
F133_xxxx_:/* global */
	LINK	A6,L$8
	MOVEM.L	A4-A2/D7-D5,-(A7)
	MOVE	34(A6),D0
	CMP.B	#255,D0
	BEQ.S	L4T133_001
	TST.B	D0
	BPL.S	L4T133_002
	ANDI	#127,34(A6)
L4T133_001:
	LEA	L4T133_026_(PC),A3
	BRA.S	L4T133_004
L4T133_002:
	LEA	L4T133_010_(PC),A3
	MOVE	D0,D1
	ADD	D0,D0
	ADD	D1,D0
	ADD	D0,D0
	JMP	2(PC,D0)
L4T133_003:
	LEA	L4T133_026_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_025_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_015_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_024_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_017_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_019_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_016_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_023_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_013_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_021_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_014_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_020_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_012_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_018_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_011_(PC),A1
	BRA.S	L4T133_004
	LEA	L4T133_022_(PC),A1
L4T133_004:
	MOVE.L	8(A6),A0
	MOVE	28(A6),D6
	MOVE	30(A6),D7
	MOVE	D7,D0
	LSL	#3,D0
	ADDA	D0,A0
	SWAP	D7
	MOVE.L	24(A6),A2
	MOVEQ	#0,D3
	MOVEQ	#0,D0
	TST	G578_B_Use(A4)
	BEQ.S	L4T133_005
	MOVE.B	(A2)+,D3
	MOVE.B	(A2)+,D0
	BRA.S	L4T133_006
L4T133_005:
	MOVE	(A2)+,D3
	MOVE	(A2)+,D0
L4T133_006:
	SUB	D3,D0
	LSR	#4,D0
	ADDQ	#1,D0
	MOVE	D0,-2(A6)
	MOVEQ	#0,D3
	MOVEQ	#0,D5
	TST	G578_B_Use(A4)
	BEQ.S	L4T133_007
	MOVE.B	(A2)+,D3
	MOVE.B	(A2),D5
	BRA.S	L4T133_008
L4T133_007:
	MOVE	(A2)+,D3
	MOVE	(A2),D5
L4T133_008:
	SUB	D3,D5
	ADDQ	#1,D5
	MULU	D0,D5
	SUBQ	#1,D5
	MOVE	D5,D7
	MOVE.L	A1,A4
	MOVE.L	16(A6),A1
	MOVE.L	20(A6),A2
L4T133_009_:
	MOVEM	(A0)+,D0-D3
	JMP	(A3)
L4T133_010_:
	MOVE	(A1),D5
	ADDQ.L	#8,A1
	AND	D5,D0
	AND	D5,D1
	AND	D5,D2
	AND	D5,D3
	NOT	D5
	JMP	(A4)
L4T133_011_:
	OR	D5,D1
L4T133_012_:
	OR	D5,D2
L4T133_013_:
	OR	D5,D3
	BRA.S	L4T133_026_
L4T133_014_:
	OR	D5,D3
L4T133_015_:
	OR	D5,D1
	BRA.S	L4T133_026_
L4T133_016_:
	OR	D5,D1
L4T133_017_:
	OR	D5,D2
	BRA.S	L4T133_026_
L4T133_018_:
	OR	D5,D3
L4T133_019_:
	OR	D5,D2
	OR	D5,D0
	BRA.S	L4T133_026_
L4T133_020_:
	OR	D5,D1
L4T133_021_:
	OR	D5,D3
	OR	D5,D0
	BRA.S	L4T133_026_
L4T133_022_:
	OR	D5,D3
L4T133_023_:
	OR	D5,D2
L4T133_024_:
	OR	D5,D1
L4T133_025_:
	OR	D5,D0
L4T133_026_:
	MOVEM	D0-D3,(A2)
	ADDQ.L	#8,A2
	SWAP	D7
	ADDQ	#1,D7
	CMP	D6,D7
	BEQ.S	L4T133_028
L4T133_027:
	SWAP	D7
	DBF	D7,L4T133_009_
	BRA.S	L4T133_029
L4T133_028:
	MOVE	#0,D7
	MOVE.L	8(A6),A0
	BRA.S	L4T133_027
L4T133_029:
	MOVEM.L	(A7)+,D5-D7/A2-A4
	MOVE	34(A6),-(A7)
	MOVE	32(A6),-(A7)
	MOVE	-2(A6),D0
	ASL	#3,D0
	MOVE	D0,-(A7)
	MOVE	38(A6),-(A7)
	MOVE	36(A6),-(A7)
	MOVE.L	24(A6),-(A7)
	MOVE.L	12(A6),-(A7)
	MOVE.L	20(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L9:
	UNLK	A6
	RTS
L$8:	.EQU	#-2
F134_zzzz_:/* global */
	LINK	A6,L$10
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	LSR	#1,D7
	BCC.S	L5T134_001
	NOT	D0
	SWAP	D0
L5T134_001:
	LSR	#1,D7
	BCC.S	L5T134_002
	NOT	D0
L5T134_002:
	LSR	#1,D7
	BCC.S	L5T134_003
	NOT	D1
	SWAP	D1
L5T134_003:
	LSR	#1,D7
	BCC.S	L5T134_004_
	NOT	D1
L5T134_004_:
	MOVE.L	D0,(A3)+
	MOVE.L	D1,(A3)+
	SUBQ	#1,D6
	BNE.S	L5T134_004_
L11:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$10:	.EQU	#0
F135_xzzz_:/* global */
	LINK	A6,L$12
	MOVEM.L	D7-D4,-(A7)
	MOVE.L	12(A6),A0
	TST	G578_B_Use(A4)
	BEQ.S	L6T135_001
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVEQ	#0,D2
	MOVEQ	#0,D3
	MOVE.B	(A0)+,D0
	MOVE.B	(A0)+,D1
	MOVE.B	(A0)+,D2
	MOVE.B	(A0),D3
	BRA.S	L6T135_002
L6T135_001:
	MOVE	(A0)+,D0
	MOVE	(A0)+,D1
	MOVE	(A0)+,D2
	MOVE	(A0),D3
L6T135_002:
	SWAP	D0
	MOVE	D2,D0
	SWAP	D0
	MOVE.L	8(A6),A1
	SUB	D2,D3
	SWAP	D3
	MULU	18(A6),D2
	ADDA	D2,A1
	LEA	L6V135_1_xx(PC),A0
	MOVEQ	#15,D6
	AND	D0,D6
	ADD	D6,D6
	MOVE	0(A0,D6),D6
	LSR	#4,D0
	MOVEQ	#15,D4
	AND	D1,D4
	ADDQ	#1,D4
	ADD	D4,D4
	MOVE	0(A0,D4),D4
	NOT	D4
	LSR	#4,D1
	MOVE	D0,D2
	LSL	#3,D2
	ADDA	D2,A1
	SUB	D0,D1
	MOVE	D1,D3
	BNE.S	L6T135_003
	OR	D4,D6
L6T135_003:
	SUBQ	#1,D3
	SWAP	D3
	ADDQ	#1,D1
	LSL	#3,D1
	MOVE	18(A6),D7
	SUB	D1,D7
	MOVE	D4,D5
	NOT	D5
	MOVE	D6,D1
	NOT	D1
	SWAP	D7
	CLR	D7
	BTST	#15,16(A6)
	BEQ.S	L6T135_004
	SWAP	D0
	MOVE	#21845,D7
	BTST	#0,D0
	BNE.S	L6T135_004
	ADD	D7,D7
L6T135_004:
	MOVEQ	#15,D0
	AND	16(A6),D0
	ADD	D0,D0
	MOVE	D0,D2
	ADD	D0,D0
	ADD	D2,D0
	JMP	2(PC,D0)
L6T135_005:
	LEA	L6T135_016(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_015(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_019(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_014(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_024(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_027(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_018(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_013(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_022(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_021(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_026(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_025(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_023(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_020(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_017(PC),A0
	BRA.S	L6T135_006
	LEA	L6T135_012(PC),A0
L6T135_006:
	SWAP	D3
	MOVE	D3,D2
	SWAP	D3
	MOVE	D6,D0
	OR	D7,D0
	AND	D0,(A1)
	AND	D0,2(A1)
	AND	D0,4(A1)
	AND	D0,6(A1)
	NOT	D7
	MOVE	D1,D0
	AND	D7,D0
	NOT	D7
	JSR	(A0)
	ADDQ.L	#8,A1
	TST	D2
	BMI.S	L6T135_010
	DBF	D2,L6T135_007
	BRA.S	L6T135_009
L6T135_007:
	MOVE	D7,D0
	NOT	D0
L6T135_008:
	AND	D7,(A1)
	AND	D7,2(A1)
	AND	D7,4(A1)
	AND	D7,6(A1)
	JSR	(A0)
	ADDQ.L	#8,A1
	DBF	D2,L6T135_008
L6T135_009:
	MOVE	D4,D0
	OR	D7,D0
	AND	D0,(A1)
	AND	D0,2(A1)
	AND	D0,4(A1)
	AND	D0,6(A1)
	NOT	D7
	MOVE	D5,D0
	AND	D7,D0
	NOT	D7
	JSR	(A0)
	ADDQ.L	#8,A1
L6T135_010:
	SWAP	D7
	ADDA	D7,A1
	SWAP	D7
	TST	D7
	BEQ.S	L6T135_011
	NOT	D7
L6T135_011:
	DBF	D3,L6T135_006
	MOVEM.L	(A7)+,D4-D7
	BRA.S	L6T135_029_
L6T135_012:
	OR	D0,6(A1)
L6T135_013:
	OR	D0,4(A1)
L6T135_014:
	OR	D0,2(A1)
L6T135_015:
	OR	D0,(A1)
L6T135_016:
	RTS
L6T135_017:
	OR	D0,6(A1)
L6T135_018:
	OR	D0,4(A1)
L6T135_019:
	OR	D0,2(A1)
	RTS
L6T135_020:
	OR	D0,4(A1)
L6T135_021:
	OR	D0,(A1)
L6T135_022:
	OR	D0,6(A1)
	RTS
L6T135_023:
	OR	D0,6(A1)
L6T135_024:
	OR	D0,4(A1)
	RTS
L6T135_025:
	OR	D0,(A1)
L6T135_026:
	OR	D0,6(A1)
	OR	D0,2(A1)
	RTS
L6T135_027:
	OR	D0,4(A1)
	OR	D0,(A1)
	RTS
L6V135_1_xx:
	ORI.B	#-32768,D0
	AND.B	D0,D0
	ASR.B	#8,D0
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
	*** illegal 1111 ***
L6T135_029_:
L13:
	UNLK	A6
	RTS
L$12:	.EQU	#0
F136_nzzz_:/* global */
	LINK	A6,L$14
	MOVE	#160,-(A7)
	MOVE	12(A6),D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	MOVE.L	8(A6),-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
L15:
	UNLK	A6
	RTS
L$14:	.EQU	#0
