CODE SEG "timeline"
F221_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D6,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BEQ.S	L3
	CMPI	#3,D6
	BNE.S	L2
L3:
	MOVE	#0,D0
	BRA.S	L1
L2:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L4
L5:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE.S	L8
	MOVE	D7,D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+60(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	CMPI	#50,D0
	BNE.S	L8
	MOVE	#1,D0
	BRA.S	L1
L8:
L6:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L4:
	CMPI	#-2,D7
	BNE.S	L5
L7:
	MOVE	#0,D0
L1:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F222_xxxx_:/* global */
	LINK	A6,L$9
	MOVEM.L	A3/D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE.S	L11
	MOVE	#0,D0
	BRA.S	L10
L11:
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#23,D0
	BNE.S	L12
	MOVE	D7,D0
	BRA.S	L10
L12:
	MOVE	#0,D0
L10:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$9:	.EQU	#0
F223_xxxx_:/* global */
	LINK	A6,L$13
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D7
	CMPI	#1,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L17
	CMPI	#5,D7
	SEQ	D0
	TST.B	D0
L17:
	TST.B	D0
	BNE.S	L16
	CMPI	#2,D7
	SEQ	D0
	TST.B	D0
L16:
	TST.B	D0
	BNE.S	L15
	CMPI	#4,D7
	SEQ	D0
	TST.B	D0
L15:
	AND	#1,D0
L14:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$13:	.EQU	#0
F224_zzzz_:/* global */
	LINK	A6,L$18
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	MOVE	D0,D4
	CMPI	#0,D0
	BEQ.S	L21
	CMPI	#3,D4
	BNE.S	L20
L21:
	BRA	L19(PC)
L20:
	MOVE	#15,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L22
	BRA	L19(PC)
L22:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#50,D0
	MOVE	D5,D1
	AND	#1023,D1
	MOVE.L	G284_apuc_+60(A4),D2
	ASL.L	#2,D1
	MOVE.L	D2,A0
	ADDA	D1,A0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A0)
	OR	D3,2(A0)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#100,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	#24,-6(A6)
	CLR.B	-5(A6)
	MOVE	D5,-2(A6)
	MOVE	D7,D0
	MOVE.B	D0,-4(A6)
	MOVE	D6,D0
	MOVE.B	D0,-3(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L23
	SUBQ	#1,D6
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L3T224_005
L23:
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L24
	SUBQ	#1,D7
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L3T224_005:
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D4
	BRA.S	L25
L24:
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L26
	ADDQ	#1,D7
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	BRA.S	L3T224_008
L26:
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L27
	ADDQ	#1,D6
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L3T224_008:
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D4
	BRA.S	L28
L27:
	CLR	D4
L28:
L25:
	CMPI	#2,D4
	BNE.S	L29
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L29:
L19:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$18:	.EQU	#-10
F225_dzzz_:/* global */
	LINK	A6,L$30
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	#255,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#255,-(A7)
	MOVE	#-125,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F222_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-16(A6)
	BEQ	L32(PC)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-14(A6)
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE	D1,-12(A6)
	ADD	D1,D0
	MOVE.L	D0,-(A7)
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE	D1,-10(A6)
	ADD	D1,D0
	MOVE.L	D0,-(A7)
	MOVE	D6,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F221_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE	D1,-8(A6)
	ADD	D1,D0
	MOVE	D0,-2(A6)
	BRA	L33(PC)
L34:
	MOVE	D7,D5
	MOVE	D6,D4
	MOVE	#5,D0
	MOVE	D0,-6(A6)
	JSR	F029_AA19_(PC)
	MOVE	D0,-4(A6)
	BRA.S	L36
L37:
	MOVE	-4(A6),D0
	ASL.L	#1,D0
	LEA	-14(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L39
	MOVE	-4(A6),D0
	ASL.L	#1,D0
	LEA	-14(A6),A0
	ADDA	D0,A0
	MOVE	#1,(A0)
	MOVE	-4(A6),D0
L40:
	CMP	#0,D0
	BEQ.S	L41
	BRA.S	L43
L41:
	SUBQ	#1,D5
	BRA.S	L42
	BRA.S	L44
L43:
	CMP	#1,D0
	BEQ.S	L44
	BRA.S	L45
L44:
	ADDQ	#1,D5
	BRA.S	L42
	BRA.S	L46
L45:
	CMP	#2,D0
	BEQ.S	L46
	BRA.S	L47
L46:
	SUBQ	#1,D4
	BRA.S	L42
	BRA.S	L48
L47:
	CMP	#3,D0
	BEQ.S	L48
	BRA.S	L49
L48:
	ADDQ	#1,D4
L49:
L50:
L42:
	BRA.S	L38
L39:
	MOVE	-4(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,-4(A6)
L36:
	SUBQ	#1,-6(A6)
	BNE.S	L37
L38:
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F223_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L51
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-16(A6),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L52
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	JSR	F180_hzzz_(PC)
	ADDQ.L	#4,A7
L52:
	BRA.S	L31
L51:
L33:
	MOVE	-2(A6),D0
	ADDQ	#1,-2(A6)
	CMPI	#4,D0
	BCS	L34(PC)
L35:
	JSR	F446_zzzz_(PC)
L32:
L31:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$30:	.EQU	#-16
F226_ozzz_:/* global */
	LINK	A6,L$53
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	SUB	12(A6),D0
	MOVE	D0,D7
	CMPI	#0,D0
	BGE.S	L55
	MOVE	D7,D0
	NEG	D0
	BRA.S	L56
L55:
	MOVE	D7,D0
L56:
	MOVE	D6,D1
	SUB	14(A6),D1
	MOVE	D1,D6
	CMPI	#0,D1
	BGE.S	L57
	MOVE	D6,D1
	NEG	D1
	BRA.S	L58
L57:
	MOVE	D6,D1
L58:
	ADD	D1,D0
L54:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$53:	.EQU	#0
F227_qzzz_:/* global */
	LINK	A6,L$59
	MOVEM.L	D7-D4,-(A7)
	MOVE	10(A6),D7
	MOVE	12(A6),D6
	MOVE	14(A6),D5
	MOVE	16(A6),D4
	MOVE	8(A6),D0
L61:
	CMP	#2,D0
	BEQ.S	L62
	BRA.S	L64
L62:
	EXG	D7,D4
	EXG	D5,D6
	BRA.S	L63
	BRA.S	L65
L64:
	CMP	#1,D0
	BEQ.S	L65
	BRA.S	L66
L65:
	EXG	D7,D5
	EXG	D6,D4
	BRA.S	L63
	BRA.S	L67
L66:
	CMP	#0,D0
	BEQ.S	L67
	BRA.S	L68
L67:
	EXG	D7,D6
	EXG	D5,D4
L68:
L69:
L63:
	MOVE	D5,D1
	SUBQ	#1,D1
	MOVE	D7,D0
	SUB	D1,D0
	MOVE	D0,D7
	CMPI	#0,D0
	SGT	D0
	TST.B	D0
	BEQ.S	L70
	MOVE	D6,D0
	SUB	D4,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BGE.S	L71
	MOVE	D6,D0
	NEG	D0
	BRA.S	L72
L71:
	MOVE	D6,D0
L72:
	CMP	D7,D0
	SLE	D0
	TST.B	D0
L70:
	AND	#1,D0
L60:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$59:	.EQU	#0
F228_uzzz_:/* global */
	LINK	A6,L$73
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D7,D0
	CMP	D5,D0
	BNE.S	L75
	JSR	F027_AA59_(PC)
	AND	#2,D0
	ADDQ	#1,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D6,D0
	CMP	14(A6),D0
	BLE.S	L76
	MOVE	#0,D0
	BRA	L74(PC)
L76:
	MOVE	#2,D0
	BRA	L74(PC)
L75:
	MOVE	D6,D0
	CMP	14(A6),D0
	BNE.S	L77
	JSR	F027_AA59_(PC)
	AND	#2,D0
	ADD	#0,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D7,D0
	CMP	D5,D0
	BLE.S	L78
	MOVE	#3,D0
	BRA	L74(PC)
L78:
	MOVE	#1,D0
	BRA	L74(PC)
L77:
	CLR	D4
L79:
	MOVE	14(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	JSR	F227_qzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ	L82(PC)
	MOVE	14(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D0,-(A7)
	JSR	F227_qzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L83
	CMPI	#0,D4
	BNE.S	L85
	MOVE	14(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,D0
	ADDQ	#3,D0
	AND	#3,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D0,-(A7)
	JSR	F227_qzzz_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L84
L85:
	JSR	F027_AA59_(PC)
	AND	#2,D0
	ADD	D4,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,G363_i_Sec(A4)
	MOVE	D4,D0
	BRA.S	L74
L84:
L83:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L86
	MOVE	G363_i_Sec(A4),D7
	MOVE	D4,G363_i_Sec(A4)
	MOVE	D7,D0
	BRA.S	L74
L86:
	MOVE	D4,D0
	BRA.S	L74
L82:
	ADDQ	#1,D4
L80:
	BRA	L79(PC)
L81:
L74:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$73:	.EQU	#0
F229_hzzz_:/* global */
	LINK	A6,L$87
	MOVE	D7,-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F228_uzzz_(PC)
	ADDQ.L	#8,A7
	ASL	#1,D0
	MOVE	D0,D7
	AND	#2,D0
	BNE.S	L89
	ADDQ	#1,20(A6)
L89:
	MOVE	20(A6),D0
	LSR	#1,D0
	AND	#1,D0
	ADD	D0,D7
	MOVE	#4,-(A7)
	MOVE.L	8(A6),-(A7)
	MOVE	D7,D0
	ASL.L	#2,D0
	LEA	G023_aac_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L88:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$87:	.EQU	#0
F230_ezzz_:/* global */
	LINK	A6,L$90
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	12(A6),D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L92
	MOVE	#0,D0
	BRA	L91(PC)
L92:
	MOVE	52(A2),D0
	BNE.S	L93
	MOVE	#0,D0
	BRA	L91(PC)
L93:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L94
	JSR	F314_gzzz_(PC)
L94:
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	ASL	#1,D0
	MOVE	D0,-2(A6)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-28(A6),A0
	MOVEQ	#12,D0
	JSR	_blockmv(PC)
	MOVE	-12(A6),D0
	LSR	#8,D0
	AND	#15,D0
	MOVE	D0,-(A7)
	MOVE	#7,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	G300_B_Par(A4),D0
	BNE.S	L96
	MOVE.L	A2,-(A7)
	JSR	F311_wzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	AND	#31,D1
	MOVE.B	-16(A6),D3
	AND	#255,D3
	ADD	D3,D1
	ADD	-2(A6),D1
	SUB	#16,D1
	CMP	D1,D0
	BCS.S	L97
	JSR	F029_AA19_(PC)
	TST	D0
	BNE	L95(PC)
L97:
	MOVE	#60,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F308_vzzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE	L95(PC)
L96:
	JSR	F027_AA59_(PC)
	MOVE	D0,D6
	AND	#112,D0
	BEQ.S	L98
	AND	#15,D6
	MOVE	-6(A6),D5
	CLR	D4
	BRA.S	L99
L100:
	MOVE	D5,D0
	LSR	#4,D0
	MOVE	D0,D5
	MOVE	D4,D0
	ADDQ	#1,D4
L99:
	MOVE	D6,D0
	MOVE	D5,D1
	AND	#15,D1
	CMP	D1,D0
	BHI.S	L100
L101:
	MOVE	D4,D0
	LEA	G024_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	BRA.S	L102
L98:
	MOVE	D6,D4
	AND	#1,D4
L102:
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE.B	-18(A6),D3
	AND	#255,D3
	ADD	D3,D0
	ADD	-2(A6),D0
	MOVE.L	D0,-(A7)
	MOVE	#7,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ASL	#1,D1
	SUB	D1,D0
	MOVE	D0,D7
	CMPI	#1,D0
	BGT.S	L103
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L104
	BRA	L9T230_014(PC)
L104:
	JSR	F029_AA19_(PC)
	ADDQ	#2,D0
	MOVE	D0,D7
L103:
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	MOVE.L	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	ADD	D0,D7
	MOVE	D7,D0
	ASR	#2,D0
	MOVE	D0,D7
	JSR	F029_AA19_(PC)
	ADDQ	#1,D0
	ADD	D0,D7
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L105
	JSR	F027_AA59_(PC)
	MOVE	D7,D1
	ASR	#1,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	SUBQ	#1,D0
	SUB	D0,D7
L105:
	MOVE.B	-4(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	BEQ.S	L106
	MOVE	#2,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#9,D0
	ADD	12(A6),D0
	MOVE	D0,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE.B	-17(A6),D0
	AND	#255,D0
	MOVE	D0,D6
	BEQ.S	L107
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L107
	MOVE	D6,-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D6
	CMPI	#0,D0
	BCS.S	L107
	MOVE	D6,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
L107:
	MOVE	D7,D0
	BRA.S	L91
L106:
L95:
L9T230_014:
	MOVE	#0,D0
L91:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$90:	.EQU	#-28
F231_izzz_:/* global */
	LINK	A6,L$108
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	14(A6),A2
	MOVE	12(A6),D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L110
	MOVE	#0,D0
	BRA	L109(PC)
L110:
	MOVE	52(A3),D0
	BNE.S	L111
	MOVE	#0,D0
	BRA	L109(PC)
L111:
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D5
	AND	#-4096,D5
	LSR	#4,D5
	LSR	#8,D5
	ASL	#1,D5
	MOVE.B	4(A2),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-10(A6)
	MOVE	214(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-6(A6)
	MOVE	24(A6),D0
	AND	#-32768,D0
	MOVE	D0,-4(A6)
	BEQ.S	L112
	ANDI	#32767,24(A6)
L112:
	MOVE.L	-10(A6),A0
	MOVE	2(A0),D0
	AND	#64,D0
	BEQ.S	L114
	MOVE	-4(A6),D0
	BEQ	L113(PC)
L114:
	MOVE.L	A3,-(A7)
	JSR	F311_wzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	AND	#31,D1
	MOVE.L	-10(A6),A0
	MOVE.B	12(A0),D3
	AND	#255,D3
	ADD	D3,D1
	ADD	D5,D1
	SUB	#16,D1
	CMP	D1,D0
	BHI.S	L115
	JSR	F029_AA19_(PC)
	TST	D0
	BEQ.S	L115
	MOVE	#75,D0
	SUB	24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F308_vzzz_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ	L113(PC)
L115:
	MOVE	#1,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BNE.S	L116
	BRA	L10T231_009(PC)
L116:
	JSR	F027_AA59_(PC)
	MOVE	D7,D1
	ASR	#1,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	ADD	D0,D7
	MOVE	D7,D0
	EXT.L	D0
	MOVE	26(A6),D1
	AND.L	#65535,D1
	MOVE.L	D0,-(A7)
	MOVE.L	D1,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	ASR.L	#5,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND	#31,D0
	MOVE.L	-10(A6),A0
	MOVE.B	8(A0),D3
	AND	#255,D3
	ADD	D3,D0
	ADD	D5,D0
	MOVE	D0,D4
	CMPI	#39,-6(A6)
	BNE.S	L117
	MOVE	D4,D0
	ASR	#2,D0
	SUB	D0,D4
	BRA.S	L118
L117:
	CMPI	#43,-6(A6)
	BNE.S	L119
	MOVE	D4,D0
	ASR	#3,D0
	SUB	D0,D4
L119:
L118:
	JSR	F027_AA59_(PC)
	AND	#31,D0
	ADD	D7,D0
	SUB	D4,D0
	MOVE	D0,D7
	MOVE	D0,D6
	CMPI	#1,D0
	BGT.S	L120
L10T231_009:
	JSR	F029_AA19_(PC)
	MOVE	D0,D7
	BNE.S	L121
	BRA	L10T231_015(PC)
L121:
	ADDQ	#1,D7
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#15,D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,D6
	CMP	#0,D0
	BGT.S	L123
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L122
L123:
	JSR	F029_AA19_(PC)
	ADD	D0,D7
	JSR	F029_AA19_(PC)
	TST	D0
	BNE.S	L124
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#15,D1
	MOVE	D6,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D7
L124:
L122:
L120:
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	MOVE.L	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	ADD	D0,D7
	MOVE	D7,D0
	ASR	#2,D0
	MOVE	D0,D7
	JSR	F029_AA19_(PC)
	ADDQ	#1,D0
	ADD	D0,D7
	CMPI	#40,-6(A6)
	BNE.S	L125
	MOVE.L	-10(A6),A0
	MOVE	2(A0),D0
	AND	#64,D0
	BNE.S	L125
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
	BNE.S	L125
	BRA	L10T231_015(PC)
L125:
	JSR	F027_AA59_(PC)
	AND	#63,D0
	MOVE.L	D0,-(A7)
	MOVE	28(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	CMP	D1,D0
	BCC.S	L126
	MOVE	D7,D0
	ADD	#10,D0
	ADD	D0,D7
L126:
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	MOVE	22(A6),-(A7)
	MOVE	20(A6),-(A7)
	MOVE	18(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F190_zzzz_(PC)
	ADDA	#14,A7
	MOVE	D0,-2(A6)
	MOVE	D7,D0
	MOVE.L	-10(A6),A0
	MOVE	16(A0),D1
	LSR	#8,D1
	AND	#15,D1
	MULU	D1,D0
	LSR	#4,D0
	ADDQ	#3,D0
	MOVE	D0,-(A7)
	MOVE	28(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	JSR	F029_AA19_(PC)
	ADDQ	#4,D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L10T231_016
L113:
L10T231_015:
	CLR	D7
	CLR	-2(A6)
	JSR	F028_a000_(PC)
	ADDQ	#2,D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
L10T231_016:
	MOVE	12(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#2,-2(A6)
	BEQ.S	L127
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	22(A6),-(A7)
	MOVE	20(A6),-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L127:
	MOVE	D7,D0
L109:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$108:	.EQU	#-10
F232_dzzz_:/* global */
	LINK	A6,L$128
	MOVEM.L	A3-A2,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A3
	MOVE	14(A6),D0
	BEQ.S	L132
	MOVE	2(A3),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L131
L132:
	MOVE	14(A6),D0
	BNE.S	L130
	MOVE	2(A3),D0
	AND	#256,D0
	LSR	#8,D0
	BNE.S	L130
L131:
	MOVE	#0,D0
	BRA	L129(PC)
L130:
	MOVE	12(A6),D0
	MOVE	2(A3),D1
	AND	#1,D1
	ASL.L	#1,D1
	LEA	G275_as_Cu+1(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BLT	L133(PC)
	MOVE	10(A6),D0
	MOVE	8(A6),D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#7,D0
	CMPI	#4,D0
	BNE.S	L134
	MOVE	16(A6),D0
	BEQ.S	L135
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	16(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	#2,-6(A6)
	CLR.B	-5(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-4(A6)
	MOVE	10(A6),D0
	MOVE.B	D0,-3(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L136
L135:
	MOVE.B	(A2),D0
	AND	#255,D0
	AND	#255,D0
	AND	#-8,D0
	OR	#5,D0
	MOVE.B	D0,(A2)
L136:
	MOVE	#1,D0
	BRA.S	L129
L134:
L133:
	MOVE	#0,D0
L129:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$128:	.EQU	#-10
