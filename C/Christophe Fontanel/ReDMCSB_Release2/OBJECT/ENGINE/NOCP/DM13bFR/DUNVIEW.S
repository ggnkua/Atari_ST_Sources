BSS SEG "bss"
G000_s_Gra:/* global */
	.WORD	#8
G001_s_Gra:/* global */
	.WORD	#8
G002_s_Gra:/* global */
	.WORD	#8
G003_s_Gra:/* global */
	.WORD	#8
G004_s_Gra:/* global */
	.WORD	#8
G005_s_Gra:/* global */
	.WORD	#8
G006_s_Gra:/* global */
	.WORD	#8
G007_s_Gra:/* global */
	.WORD	#8
G008_s_Gra:/* global */
	.WORD	#8
G009_s_Gra:/* global */
	.WORD	#8
G010_s_Gra:/* global */
	.WORD	#8
G011_s_Gra:/* global */
	.WORD	#8
G012_s_Gra:/* global */
	.WORD	#8
G013_s_Gra:/* global */
	.WORD	#8
G014_s_Gra:/* global */
	.WORD	#8
G015_s_Gra:/* global */
	.WORD	#8
G016_s_Gra:/* global */
	.WORD	#8
G017_auc_G:/* global */
	.WORD	#16
G018_ai_Gr:/* global */
	.WORD	#140
G019_aui_G:/* global */
	.WORD	#32
G020_aui_G:/* global */
	.WORD	#32
G021_aaui_:/* global */
	.WORD	#192
G022_i_Gra:/* global */
	.WORD	#2
G023_aac_G:/* global */
	.WORD	#32
G024_ac_Gr:/* global */
	.WORD	#4
G025_ac_Gr:/* global */
	.WORD	#8
G026_ai_Gr:/* global */
	.WORD	#14
G027_ac_Gr:/* global */
	.WORD	#4
G028_s_Gra:/* global */
	.WORD	#8
G029_auc_G:/* global */
	.WORD	#16
G030_as_Gr:/* global */
	.WORD	#276
G031_i_Gra:/* global */
	.WORD	#2
G032_s_Gra:/* global */
	.WORD	#8
G033_s_Gra:/* global */
	.WORD	#8
G034_s_Gra:/* global */
	.WORD	#8
G035_s_Gra:/* global */
	.WORD	#8
G036_s_Gra:/* global */
	.WORD	#8
G037_s_Gra:/* global */
	.WORD	#8
G038_ai_Gr:/* global */
	.WORD	#76
G039_ai_Gr:/* global */
	.WORD	#32
G040_ai_Gr:/* global */
	.WORD	#12
G041_s_Gra:/* global */
	.WORD	#8
G042_auc_G:/* global */
	.WORD	#128
G043_auc_G:/* global */
	.WORD	#128
G044_auc_G:/* global */
	.WORD	#16
G045_auc_G:/* global */
	.WORD	#16
G046_auc_G:/* global */
	.WORD	#4
G047_s_Gra:/* global */
	.WORD	#4
G048_s_Gra:/* global */
	.WORD	#8
G049_s_Gra:/* global */
	.WORD	#8
G050_auc_G:/* global */
	.WORD	#6
G051_ac_Gr:/* global */
	.WORD	#2
G052_ac_Gr:/* global */
	.WORD	#2
G053_ac_Gr:/* global */
	.WORD	#6
G054_ai_Gr:/* global */
	.WORD	#32
G055_aaaui:/* global */
	.WORD	#48
G056_aaui_:/* global */
	.WORD	#24
G057_ai_Gr:/* global */
	.WORD	#60
G058_i_Gra:/* global */
	.WORD	#2
G059_auc_G:/* global */
	.WORD	#8
G060_as_Gr:/* global */
	.WORD	#176
G061_s_Gra:/* global */
	.WORD	#8
G062_s_Gra:/* global */
	.WORD	#8
G063_s_Gra:/* global */
	.WORD	#8
G064_al_Gr:/* global */
	.WORD	#16
G065_al_Gr:/* global */
	.WORD	#16
G066_ac_Gr:/* global */
	.WORD	#2
G067_i_Gra:/* global */
	.WORD	#2
G074_puc_B:/* global */
	.WORD	#4
G075_apuc_:/* global */
	.WORD	#16
G076_B_Use:/* global */
	.WORD	#2
G077_B_DoN:/* global */
	.WORD	#2
G079_ai_St:/* global */
	.WORD	#36
G080_aai_D:/* global */
	.WORD	#12
G084_puc_B:/* global */
	.WORD	#4
G085_puc_B:/* global */
	.WORD	#4
G086_puc_B:/* global */
	.WORD	#4
G087_puc_B:/* global */
	.WORD	#4
G088_apuc_:/* global */
	.WORD	#60
G090_puc_B:/* global */
	.WORD	#4
G091_puc_B:/* global */
	.WORD	#4
G092_puc_B:/* global */
	.WORD	#4
G093_puc_B:/* global */
	.WORD	#4
G094_puc_B:/* global */
	.WORD	#4
G095_puc_B:/* global */
	.WORD	#4
G096_puc_B:/* global */
	.WORD	#4
G097_puc_B:/* global */
	.WORD	#4
G098_puc_B:/* global */
	.WORD	#4
G099_puc_B:/* global */
	.WORD	#4
G101_aai_C:/* global */
	.WORD	#64
G102_aai_C:/* global */
	.WORD	#64
G103_aai_C:/* global */
	.WORD	#68
G105_s_Gra:/* global */
	.WORD	#4
G106_s_Gra:/* global */
	.WORD	#4
G107_s_Gra:/* global */
	.WORD	#4
G108_s_Gra:/* global */
	.WORD	#4
G109_s_Gra:/* global */
	.WORD	#4
G110_s_Gra:/* global */
	.WORD	#8
G111_s_Gra:/* global */
	.WORD	#8
G112_s_Gra:/* global */
	.WORD	#8
G113_s_Gra:/* global */
	.WORD	#8
G114_s_Gra:/* global */
	.WORD	#8
G115_s_Gra:/* global */
	.WORD	#8
G116_s_Gra:/* global */
	.WORD	#8
G117_s_Gra:/* global */
	.WORD	#8
G118_s_Gra:/* global */
	.WORD	#8
G119_s_Gra:/* global */
	.WORD	#8
G120_s_Gra:/* global */
	.WORD	#8
G121_s_Gra:/* global */
	.WORD	#8
G122_s_Gra:/* global */
	.WORD	#8
G123_s_Gra:/* global */
	.WORD	#8
G124_s_Gra:/* global */
	.WORD	#8
G125_s_Gra:/* global */
	.WORD	#8
G126_s_Gra:/* global */
	.WORD	#8
G127_s_Gra:/* global */
	.WORD	#8
G128_s_Gra:/* global */
	.WORD	#8
G129_s_Gra:/* global */
	.WORD	#8
G130_s_Gra:/* global */
	.WORD	#8
G131_s_Gra:/* global */
	.WORD	#8
G132_s_Gra:/* global */
	.WORD	#8
G133_s_Gra:/* global */
	.WORD	#8
G134_s_Gra:/* global */
	.WORD	#8
G135_s_Gra:/* global */
	.WORD	#8
G136_s_Gra:/* global */
	.WORD	#8
G137_s_Gra:/* global */
	.WORD	#8
G138_s_Gra:/* global */
	.WORD	#8
G139_s_Gra:/* global */
	.WORD	#8
G140_s_Gra:/* global */
	.WORD	#8
G141_s_Gra:/* global */
	.WORD	#8
G142_s_Gra:/* global */
	.WORD	#8
G143_s_Gra:/* global */
	.WORD	#8
G144_s_Gra:/* global */
	.WORD	#8
G145_s_Gra:/* global */
	.WORD	#8
G146_s_Gra:/* global */
	.WORD	#8
G147_s_Gra:/* global */
	.WORD	#8
G148_s_Gra:/* global */
	.WORD	#8
G149_s_Gra:/* global */
	.WORD	#8
G150_s_Gra:/* global */
	.WORD	#8
G151_s_Gra:/* global */
	.WORD	#8
G152_s_Gra:/* global */
	.WORD	#8
G153_s_Gra:/* global */
	.WORD	#8
G154_s_Gra:/* global */
	.WORD	#8
G155_s_Gra:/* global */
	.WORD	#8
G156_s_Gra:/* global */
	.WORD	#8
G157_s_Gra:/* global */
	.WORD	#8
G158_s_Gra:/* global */
	.WORD	#8
G159_s_Gra:/* global */
	.WORD	#8
G160_s_Gra:/* global */
	.WORD	#8
G161_s_Gra:/* global */
	.WORD	#4
G162_s_Gra:/* global */
	.WORD	#4
G163_as_Gr:/* global */
	.WORD	#112
G164_s_Gra:/* global */
	.WORD	#8
G165_s_Gra:/* global */
	.WORD	#8
G166_s_Gra:/* global */
	.WORD	#8
G167_s_Gra:/* global */
	.WORD	#8
G168_s_Gra:/* global */
	.WORD	#8
G169_s_Gra:/* global */
	.WORD	#8
G170_s_Gra:/* global */
	.WORD	#8
G171_s_Gra:/* global */
	.WORD	#8
G172_s_Gra:/* global */
	.WORD	#8
G173_s_Gra:/* global */
	.WORD	#8
G174_s_Gra:/* global */
	.WORD	#8
G175_s_Gra:/* global */
	.WORD	#8
G176_s_Gra:/* global */
	.WORD	#8
G177_s_Gra:/* global */
	.WORD	#8
G178_s_Gra:/* global */
	.WORD	#8
G179_s_Gra:/* global */
	.WORD	#80
G180_s_Gra:/* global */
	.WORD	#80
G181_s_Gra:/* global */
	.WORD	#80
G182_s_Gra:/* global */
	.WORD	#80
G183_s_Gra:/* global */
	.WORD	#80
G184_s_Gra:/* global */
	.WORD	#80
G185_s_Gra:/* global */
	.WORD	#80
G186_s_Gra:/* global */
	.WORD	#80
G187_s_Gra:/* global */
	.WORD	#80
G188_as_Gr:/* global */
	.WORD	#96
G189_i_Gra:/* global */
	.WORD	#2
G190_auc_G:/* global */
	.WORD	#12
G191_auc_G:/* global */
	.WORD	#10
G192_auc_G:/* global */
	.WORD	#4
G193_ai_Gr:/* global */
	.WORD	#2
G194_auc_G:/* global */
	.WORD	#60
G195_auc_G:/* global */
	.WORD	#10
G196_auc_G:/* global */
	.WORD	#12
G197_auc_G:/* global */
	.WORD	#2
G198_auc_G:/* global */
	.WORD	#16
G199_auc_G:/* global */
	.WORD	#16
G200_auc_G:/* global */
	.WORD	#16
G201_auc_G:/* global */
	.WORD	#16
G202_ac_Gr:/* global */
	.WORD	#4
G203_ac_Gr:/* global */
	.WORD	#4
G204_ac_Gr:/* global */
	.WORD	#16
G205_aaauc:/* global */
	.WORD	#624
G206_aaauc:/* global */
	.WORD	#162
G207_aaauc:/* global */
	.WORD	#72
G208_aaauc:/* global */
	.WORD	#24
G209_as_Gr:/* global */
	.WORD	#510
G210_as_Gr:/* global */
	.WORD	#84
G211_as_Gr:/* global */
	.WORD	#8
G212_auc_G:/* global */
	.WORD	#16
G213_auc_G:/* global */
	.WORD	#16
G214_auc_G:/* global */
	.WORD	#16
G215_auc_G:/* global */
	.WORD	#8
G216_auc_G:/* global */
	.WORD	#6
G217_aauc_:/* global */
	.WORD	#32
G218_aaaau:/* global */
	.WORD	#300
G219_as_Gr:/* global */
	.WORD	#324
G220_as_Gr:/* global */
	.WORD	#182
G221_auc_G:/* global */
	.WORD	#16
G222_auc_G:/* global */
	.WORD	#16
G223_aac_G:/* global */
	.WORD	#24
G224_aaaau:/* global */
	.WORD	#330
G225_aai_G:/* global */
	.WORD	#60
G226_aaai_:/* global */
	.WORD	#120
G227_aai_G:/* global */
	.WORD	#42
G228_aai_G:/* global */
	.WORD	#42
G229_i_Gra:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G230_i_Cur(A4)
BSS SEG "bss"
G230_i_Cur:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G231_i_Cur(A4)
BSS SEG "bss"
G231_i_Cur:/* global */
	.WORD	#2
CODE SEG "show"
F093_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	CLR	D5
	BRA.S	L2
L3:
	MOVE	D5,D0
	MOVE	D6,D1
	MULS	#14,D1
	LEA	G220_as_Gr(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D0
	LEA	(A0),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D7,D1
	MOVE	D5,D2
	MULS	#32,D2
	LEA	G021_aaui_(A4),A0
	ADD.L	A0,D2
	ASL.L	#1,D1
	MOVE.L	D2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L4:
	ADDQ	#1,D5
L2:
	CMPI	#6,D5
	BLT.S	L3
L5:
	MOVE	D6,D0
	MULS	#14,D0
	LEA	G220_as_Gr+12(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	LEA	G222_auc_G(A4),A0
	ADDA	D7,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
	MOVE	D6,D0
	MULS	#14,D0
	LEA	G220_as_Gr+13(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	LEA	G221_auc_G(A4),A0
	ADDA	D7,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
L1:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F094_mzzz_:/* global */
	LINK	A6,L$6
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE	G230_i_Cur(A4),D0
	CMP	D7,D0
	BEQ.S	L8
	MOVE	D7,G230_i_Cur(A4)
	MOVE	D7,D0
	MULS	#2,D0
	ADD	#75,D0
	MOVE	D0,D7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G084_puc_B(A4),-(A7)
	MOVE	D7,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	G085_puc_B(A4),-(A7)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L8:
L7:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$6:	.EQU	#0
F095_izzz_:/* global */
	LINK	A6,L$9
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	G231_i_Cur(A4),D0
	CMP	D7,D0
	BNE.S	L12
	MOVE	G523_B_Res(A4),D0
	BEQ	L11(PC)
L12:
	MOVE	D7,G231_i_Cur(A4)
	MOVE	D7,D0
	MULS	#13,D0
	ADD	#77,D0
	MOVE	D0,D7
	LEA	G088_apuc_+4(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	MOVE	D7,D0
	ADD	#13,D0
	MOVE	D0,D6
	BRA.S	L13
L14:
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	(A3)+,-(A7)
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE	D0,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L13:
	MOVE	D7,D0
	CMP	D6,D0
	BLT.S	L14
L15:
	MOVE.B	G171_s_Gra+5(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G171_s_Gra+4(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G088_apuc_(A4),-(A7)
	MOVE.L	G088_apuc_+8(A4),-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.B	G163_as_Gr+101(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+100(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G088_apuc_+56(A4),-(A7)
	MOVE.L	G088_apuc_+52(A4),-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
L11:
L10:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$9:	.EQU	#0
F096_qzzz_:/* global */
	LINK	A6,L$16
CODE SEG "init!"
	MOVE	#1,4G232_B_Fi(A4)
BSS SEG "bss"
4G232_B_Fi:
	.WORD	#2
CODE SEG "show"
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	4G232_B_Fi(A4),D0
	BNE.S	L18
	MOVE	G661_B_Lar(A4),D0
	SEQ	D0
	TST.B	D0
L18:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-10(A6)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D5
	AND	#15,D5
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D4
	AND	#240,D4
	LSR	#4,D4
	MOVE	-10(A6),D0
	BNE.S	L21
	MOVE	D5,D0
	MOVE	G230_i_Cur(A4),D1
	CMP	D1,D0
	SNE	D0
	TST.B	D0
L21:
	SNE	D0
	TST.B	D0
	BNE.S	L20
	MOVE	D4,D0
	MOVE	G231_i_Cur(A4),D1
	CMP	D1,D0
	SNE	D0
	TST.B	D0
L20:
	AND	#1,D0
	MOVE	D0,-22(A6)
	BEQ.S	L19
	CLR	-(A7)
	CLR	-(A7)
	JSR	F428_AA39_(PC)
	ADDQ.L	#4,A7
	JSR	F477_izzz_(PC)
L19:
	MOVE	D5,-(A7)
	JSR	F094_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D4,-(A7)
	JSR	F095_izzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G661_B_Lar(A4),D0
	BEQ	L22(PC)
	CLR	-(A7)
	MOVE.L	#5112,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G074_puc_B(A4)
	MOVE	#1,G578_B_Use(A4)
	MOVE.B	G163_as_Gr+5(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+4(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+48(A4),D0
	MOVE.L	D0,G095_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#408,-(A7)
	MOVE	#10,-(A7)
	MOVE.L	G090_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-(A7)
	MOVE	#64,-(A7)
	MOVE	#64,-(A7)
	CLR	-(A7)
	MOVE	#11,-(A7)
	PEA	G161_s_Gra(A4)
	MOVE.L	G090_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE.B	G163_as_Gr+29(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+28(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+44(A4),D0
	MOVE.L	D0,G096_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#639,-(A7)
	MOVE	#10,-(A7)
	MOVE.L	G091_puc_B(A4),-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-(A7)
	MOVE	#72,-(A7)
	MOVE	#72,-(A7)
	CLR	-(A7)
	MOVE	#8,-(A7)
	PEA	G162_s_Gra(A4)
	MOVE.L	G091_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE.L	#5112,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	G163_as_Gr+53(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+52(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G092_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+40(A4),D0
	MOVE.L	D0,G097_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.B	G163_as_Gr+85(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+84(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G094_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+36(A4),D0
	MOVE.L	D0,G098_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.B	G163_as_Gr+85(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G163_as_Gr+84(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G093_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+32(A4),D0
	MOVE.L	D0,G099_puc_B(A4)
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
L22:
	CLR	-(A7)
	MOVE.L	#1100,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A2
	MOVE	#140,-(A7)
	MOVE.L	A2,-(A7)
	PEA	G018_ai_Gr(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#70,D4
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D0
	AND	#240,D0
	LSR	#4,D0
	BEQ.S	L24
	MOVE	G661_B_Lar(A4),D0
	BEQ.S	L23
L24:
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	#40,(A0)
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	#26,(A0)
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	#27,(A0)
L23:
	LEA	G079_ai_St+34(A4),A0
	MOVE.L	A0,-4(A6)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D6
	AND	#240,D6
	LSR	#4,D6
	MULU	#18,D6
	ADD	#90,D6
	MOVE	D6,D7
	ADD	#18,D7
	BRA.S	L25
L26:
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L28
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L28:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	-4(A6),A0
	SUBQ.L	#2,-4(A6)
	MOVE	D0,(A0)
L25:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L26
L27:
	MOVE	#556,D7
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L29
	SUBQ	#6,D7
L29:
	MOVE	#533,D6
	BRA.S	L30
L31:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L30:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L31
L32:
	CLR	D6
	BRA.S	L33
L34:
	MOVE	#360,D5
	MOVE	D6,D1
	MULS	#6,D1
	LEA	G209_as_Gr(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G209_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#16,D0
	BEQ.S	L37
	MOVE	D5,D0
	ADDQ	#1,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L37:
L35:
	ADDQ	#1,D6
L33:
	CMPI	#85,D6
	BLT.S	L34
L36:
	CLR	D6
	BRA.S	L38
L39:
	MOVE	#316,D5
	MOVE	D6,D1
	MULS	#6,D1
	LEA	G210_as_Gr(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G210_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#3,D0
	MOVE	D0,D7
	CMPI	#3,D0
	BEQ.S	L42
	MOVE	D5,D0
	ADDQ	#1,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	CMPI	#2,D7
	BEQ.S	L43
	MOVE	D5,D0
	ADDQ	#2,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L43:
L42:
L40:
	ADDQ	#1,D6
L38:
	CMPI	#14,D6
	BLT.S	L39
L41:
	MOVE	#348,D6
	BRA.S	L44
L45:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L44:
	CMPI	#360,D6
	BLT.S	L45
L46:
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#3840,D0
	LSR	#8,D0
	MOVE.B	D0,-6(A6)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	14(A0),D0
	AND	#-4096,D0
	LSR	#4,D0
	LSR	#8,D0
	MOVE.B	D0,-5(A6)
	CLR	D5
	BRA.S	L47
L48:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G080_aai_D+8(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
	MOVE	#108,D6
	MOVE	D5,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULS	#3,D1
	ADD	D1,D6
	MOVE	D6,D7
	ADDQ	#3,D7
	BRA.S	L51
L52:
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L54
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L54:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	-4(A6),A0
	MOVE	D0,(A0)
	SUBQ.L	#4,-4(A6)
L51:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L52
L53:
L49:
	ADDQ	#1,D5
L47:
	CMPI	#1,D5
	BLS.S	L48
L50:
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#3,-(A7)
	PEA	G267_ai_Cu(A4)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#2,-(A7)
	MOVE	#-1,-(A7)
	MOVE	#1,-(A7)
	PEA	G268_ai_Cu(A4)
	JSR	F010_aAA7_(PC)
	ADDA	#10,A7
	CLR	-18(A6)
	CLR	-20(A6)
	MOVE	#-1,G266_i_Cur(A4)
	CLR	D5
	BRA	L55(PC)
L56:
	MOVE	#121,D6
	MOVE	D5,D1
	LEA	G261_auc_C(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D7
	MULS	#2,D1
	ADD	D1,D6
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G101_aai_C(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	CLR	-16(A6)
	BRA.S	L59
L60:
	MOVE	D7,D0
	LEA	G192_auc_G(A4),A0
	ADDA	-16(A6),A0
	MOVE.B	(A0),D1
	AND	#255,D1
	CMP	D1,D0
	BNE.S	L63
	MOVE	-18(A6),D0
	ADDQ	#1,-18(A6)
	ASL.L	#1,D0
	LEA	G267_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
	CMPI	#2,D7
	BNE.S	L64
	MOVE	D5,G266_i_Cur(A4)
L64:
L63:
L61:
	ADDQ	#1,-16(A6)
L59:
	CMPI	#3,-16(A6)
	BLT.S	L60
L62:
	CLR	-16(A6)
	BRA.S	L65
L66:
	MOVE	D7,D0
	MOVE	-16(A6),D1
	ASL.L	#1,D1
	LEA	G193_ai_Gr(A4),A0
	ADDA	D1,A0
	CMP	(A0),D0
	BNE.S	L69
	MOVE	-20(A6),D0
	ADDQ	#1,-20(A6)
	ASL.L	#1,D0
	LEA	G268_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	D5,(A0)
L69:
L67:
	ADDQ	#1,-16(A6)
L65:
	CMPI	#1,-16(A6)
	BLT.S	L66
L68:
	LEA	G194_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	ASL.L	#2,D1
	LEA	G101_aai_C+2(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE	D0,(A0)
	MULS	#78,D0
	LEA	G205_aaauc(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L70
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L70:
	MOVE	#4,D7
	MOVE	D5,D1
	MULU	#4,D1
	ADD	D1,D7
	MOVE	D7,D6
	ADDQ	#4,D7
	BRA.S	L71
L72:
	MOVE	D6,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	MOVE	D7,D0
	SUB	D6,D0
	CMPI	#2,D0
	BNE.S	L74
	MOVE	#18,D0
	BRA.S	L75
L74:
	MOVE	#12,D0
L75:
	EXT.L	D0
	ADDA.L	D0,A3
L71:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L72
L73:
L57:
	ADDQ	#1,D5
L55:
	MOVE	D5,D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D1
	AND	#15,D1
	CMP	D1,D0
	BLS	L56(PC)
L58:
	CLR	D5
	BRA.S	L76
L77:
	MOVE	#247,D6
	MOVE	D5,D1
	LEA	G262_auc_C(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D7
	MULS	#6,D1
	ADD	D1,D6
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G102_aai_C(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	LEA	G195_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	ASL.L	#2,D1
	LEA	G102_aai_C+2(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE	D0,(A0)
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L80
	MOVE	D6,D7
	ADDQ	#6,D7
	BRA.S	L81
L82:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L81:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L82
L83:
L80:
L78:
	ADDQ	#1,D5
L76:
	MOVE	D5,D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	10(A0),D1
	AND	#3840,D1
	LSR	#8,D1
	CMP	D1,D0
	BCS.S	L77
L79:
	CLR	D5
	BRA	L84(PC)
L85:
	MOVE	#303,D6
	MOVE	D5,D1
	LEA	G263_auc_C(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D7
	ADD	D1,D6
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G103_aai_C(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	MOVE	G661_B_Lar(A4),D0
	BNE.S	L88
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L88:
	LEA	G196_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D0
	MOVE	D5,D1
	ASL.L	#2,D1
	LEA	G103_aai_C+2(A4),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE	D0,(A0)
	MULS	#18,D0
	LEA	G207_aaauc(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#68,D7
	MOVE	D5,D1
	MULU	#2,D1
	ADD	D1,D7
	MOVE	D7,D6
	ADDQ	#2,D7
	BRA.S	L89
L90:
	MOVE	D6,D0
	OR	#-32768,D0
	MOVE	D0,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ.L	#6,A3
L89:
	MOVE	D6,D0
	CMP	D7,D0
	BLT.S	L90
L91:
L86:
	ADDQ	#1,D5
L84:
	MOVE	D5,D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D1
	AND	#15,D1
	CMP	D1,D0
	BCS	L85(PC)
L87:
	MOVE	#102,D0
	MOVE	D0,D7
	MOVE	#0,D0
	MOVE	D0,D6
	BRA.S	L92
L93:
	MOVE	D6,D0
	ADD	#315,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	LEA	G197_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#24,D0
	LEA	G208_aaauc+6(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D7,D1
	ADDQ	#1,D7
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	ADDQ.L	#6,A3
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D7,D1
	ADDQ	#1,D7
	ASL.L	#1,D1
	MOVE.L	G639_pi_De(A4),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L94:
	ADDQ	#1,D6
L92:
	CMPI	#1,D6
	BLT.S	L93
L95:
	MOVE	#8,-(A7)
	MOVE	#9,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#12,-(A7)
	MOVE	#10,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-8(A6)
	BRA	L96(PC)
L97:
	MOVE.L	G264_puc_C(A4),A0
	ADDA	-8(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	MULS	#12,D0
	LEA	G219_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.B	11(A0),D5
	AND	#255,D5
	AND	#15,D5
	BEQ.S	L100
	MOVE	D5,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#9,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
L100:
	MOVE.L	A3,D5
	MOVE.L	D5,A0
	MOVE.B	11(A0),D5
	AND	#255,D5
	ASR	#4,D5
	AND	#15,D5
	BEQ.S	L101
	MOVE	D5,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#10,-(A7)
	JSR	F093_xxxx_(PC)
	ADDQ.L	#4,A7
L101:
	MOVE	G661_B_Lar(A4),D0
	BNE	L102(PC)
	MOVE	D7,D0
	MULS	#26,D0
	LEA	G243_as_Gr+1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	BEQ.S	L103
	CMPI	#6,D5
	BHI.S	L103
	MOVE	D5,D0
	ADD	#549,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L103:
	MOVE	#446,D6
	MOVE.L	A3,D1
	MOVE.L	D1,A0
	ADD	(A0),D6
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	MOVE	D7,D5
	MULS	#26,D5
	LEA	G243_as_Gr+4(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D5,D0
	AND	#8,D0
	BEQ.S	L104
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L104:
	MOVE	D5,D0
	AND	#16,D0
	BEQ.S	L105
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L105:
	MOVE	D5,D0
	AND	#128,D0
	BEQ.S	L106
	MOVE	D5,D0
	AND	#256,D0
	BNE.S	L106
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L106:
	MOVE	D5,D0
	AND	#32,D0
	BEQ.S	L107
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L107:
	MOVE	D5,D0
	AND	#3,D0
	MOVE	D0,-14(A6)
	BEQ.S	L108
L109:
	MOVE	D5,D0
	AND	#4,D0
	BNE.S	L112
	ADDQ	#1,D6
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L112:
L110:
	SUBQ	#1,-14(A6)
	BNE.S	L109
L111:
L108:
L102:
L98:
	ADDQ	#1,-8(A6)
L96:
	MOVE	-8(A6),D0
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D1
	AND	#240,D1
	LSR	#4,D1
	CMP	D1,D0
	BCS	L97(PC)
L99:
	MOVE	-10(A6),D0
	BEQ	L113(PC)
	MOVE	G661_B_Lar(A4),D0
	BEQ	L114(PC)
	MOVE	#90,D5
	BRA.S	L115
L116:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L115:
	CMPI	#108,D5
	BCS.S	L116
L117:
	MOVE	#108,D5
	BRA.S	L118
L119:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L118:
	CMPI	#120,D5
	BCS.S	L119
L120:
	MOVE	#121,D5
	BRA.S	L121
L122:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L121:
	CMPI	#247,D5
	BCS.S	L122
L123:
	MOVE	#247,D5
	BRA.S	L124
L125:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L124:
	CMPI	#301,D5
	BCS.S	L125
L126:
	MOVE	#303,D5
	BRA.S	L127
L128:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L127:
	CMPI	#316,D5
	BCS.S	L128
L129:
	MOVE	#446,D5
	BRA.S	L130
L131:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE	D4,D1
	ADDQ	#1,D4
	ASL.L	#1,D1
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L130:
	CMPI	#533,D5
	BCS.S	L131
L132:
L114:
	MOVE	D4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F484_gzzz_(PC)
	ADDQ.L	#6,A7
L113:
	MOVE	-22(A6),D0
	BEQ.S	L133
	JSR	F478_gzzz_(PC)
L133:
	MOVE.L	#1100,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,G297_B_Dra(A4)
	MOVE	#1,G342_B_Ref(A4)
	CLR	4G232_B_Fi(A4)
L17:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$16:	.EQU	#-22
F097_lzzz_:/* global */
	LINK	A6,L$134
	CMPI	#2,8(A6)
	BNE.S	L136
	MOVE	G322_B_Pal(A4),G323_B_Ena(A4)
	BRA.S	L137
L136:
	MOVE	8(A6),G323_B_Ena(A4)
L137:
	MOVE	#1,G324_B_Dra(A4)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L135:
	UNLK	A6
	RTS
L$134:	.EQU	#0
F098_rzzz_:/* global */
	LINK	A6,L$138
	MOVE	#4144,-(A7)
	MOVE.L	G086_puc_B(A4),-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#3248,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G085_puc_B(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#7840,-(A7)
	MOVE.L	G087_puc_B(A4),-(A7)
	MOVE.L	G084_puc_B(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR	G297_B_Dra(A4)
L139:
	UNLK	A6
	RTS
L$138:	.EQU	#0
F099_xxxx_:/* global */
	LINK	A6,L$140
	MOVE	16(A6),D0
	MULU	18(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	12(A6),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE.L	12(A6),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L141:
	UNLK	A6
	RTS
L$140:	.EQU	#0
F100_xxxx_:/* global */
	LINK	A6,L$142
	MOVE.L	A3,-(A7)
	MOVE.L	12(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L144
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L144:
L143:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$142:	.EQU	#0
F102_xxxx_:/* global */
	LINK	A6,L$145
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L147
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L147:
L146:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$145:	.EQU	#0
F103_xxxx_:/* global */
	LINK	A6,L$148
	MOVE.L	A3,-(A7)
	MOVE.L	12(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L150
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L150:
L149:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$148:	.EQU	#0
F104_xxxx_:/* global */
	LINK	A6,L$151
	MOVE.L	A3,-(A7)
	MOVE.L	10(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L153
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L153:
L152:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$151:	.EQU	#0
F105_xxxx_:/* global */
	LINK	A6,L$154
	MOVE.L	A3,-(A7)
	MOVE.L	10(A6),A3
	MOVE.B	4(A3),D0
	BEQ.S	L156
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	7(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L156:
L155:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$154:	.EQU	#0
F107_xxxx_:/* global */
	LINK	A6,L$157
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L159(PC)
	SUBQ	#1,D7
	MOVE	D7,D5
	ASL.L	#2,D5
	LEA	G101_aai_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G101_aai_C+2(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D1,D4
	MULS	#78,D1
	LEA	G205_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D7,-(A7)
	JSR	F149_aawz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-12(A6)
	MOVE	D7,D0
	CMP	G265_i_Cur(A4),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-10(A6)
	BEQ.S	L160
	CLR	-(A7)
	MOVE	G290_T_Dun(A4),-(A7)
	PEA	-92(A6)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
L160:
	CMPI	#10,D6
	BLT	L161(PC)
	CMPI	#12,D6
	BNE	L162(PC)
	MOVE	-10(A6),D0
	BEQ	L163(PC)
	MOVE	#-1,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	G163_as_Gr+52(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	#28,-(A7)
	MOVE	#94,-(A7)
	PEA	G202_ac_Gr(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	LEA	-92(A6),A0
	MOVE.L	A0,A3
	MOVE	#120,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CLR	-14(A6)
L164:
	CLR	D7
	MOVE.L	A3,A2
	BRA.S	L167
L168:
	ADDQ	#1,D7
L167:
	MOVE.B	(A2)+,D0
	AND	#255,D0
	CMP	#128,D0
	BLT.S	L168
L169:
	MOVE	#112,D0
	MOVE	D7,D1
	ASL	#2,D1
	SUB	D1,D0
	MOVE.B	D0,-22(A6)
	AND	#255,D0
	ADDQ	#7,D0
	MOVE.B	D0,-21(A6)
	MOVE	-14(A6),D0
	ADDQ	#1,-14(A6)
	LEA	G203_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE.B	D0,-19(A6)
	AND	#255,D0
	SUBQ	#7,D0
	MOVE.B	D0,-20(A6)
	BRA.S	L170
L171:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	#144,-(A7)
	CLR	-(A7)
	MOVE.B	(A3)+,D0
	AND	#255,D0
	ASL	#3,D0
	MOVE	D0,-(A7)
	PEA	-22(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	ADDQ.B	#8,-22(A6)
	ADDQ.B	#8,-21(A6)
L170:
	MOVE	D7,D0
	SUBQ	#1,D7
	TST	D0
	BNE.S	L171
L172:
L165:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#129,D0
	BNE	L164(PC)
L166:
	BRA	L13T107_031(PC)
L163:
	ADDQ	#1,D5
	MOVE	#4,-(A7)
	PEA	G291_aauc_+20(A4)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	-12(A6),G286_B_Fac(A4)
	MOVE	D7,D0
	CMP	G266_i_Cur(A4),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,G287_B_Fac(A4)
	CLR	G288_B_Fac(A4)
	CLR	D4
	BRA.S	L173
L174:
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G268_ai_Cu(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	CMP	D7,D0
	BNE.S	L177
	MOVE	#1,G288_B_Fac(A4)
	BRA.S	L176
L177:
L175:
	ADDQ	#1,D4
L173:
	CMPI	#1,D4
	BLT.S	L174
L176:
L162:
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#11,D6
	BNE.S	L178
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A2
L178:
	CLR	D4
	BRA	L179(PC)
L161:
	CLR	-6(A6)
	CMPI	#6,D6
	SEQ	D0
	TST.B	D0
	BNE.S	L181
	CMPI	#1,D6
	SEQ	D0
	TST.B	D0
L181:
	AND	#1,D0
	MOVE	D0,-8(A6)
	BEQ.S	L180
	MOVE	D4,D0
	MULS	#78,D0
	LEA	G205_aaauc+66(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	BRA.S	L182
L180:
	CMPI	#5,D6
	BEQ.S	L184
	CMPI	#0,D6
	BNE.S	L183
L184:
	MOVE	D4,D0
	MULS	#78,D0
	LEA	G205_aaauc+60(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	BRA.S	L185
L183:
	ADDQ	#1,D5
	MOVE	D4,D0
	MULS	#78,D0
	LEA	G205_aaauc+72(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#7,D6
	BNE.S	L186
	MOVE	#6,-6(A6)
	BRA.S	L187
L186:
	CMPI	#9,D6
	BNE.S	L188
	MOVE	#-6,-6(A6)
L188:
L187:
L185:
L182:
	MOVE.L	A3,D4
	MOVE	-6(A6),D3
	EXT.L	D3
	ADD.L	D3,D4
	MOVE.L	D4,A0
	MOVE.B	1(A0),D4
	MOVE.L	A3,D1
	MOVE	-6(A6),D3
	EXT.L	D3
	ADD.L	D3,D1
	MOVE.L	D1,A0
	AND	#255,D4
	MOVE.B	(A0),D3
	AND	#255,D3
	SUB	D3,D4
	MOVE	#4,D0
	MOVE	D7,D1
	ASL	#2,D1
	ADD	D1,D0
	LEA	G190_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE.S	L189
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#4,D6
	BGT.S	L190
	LEA	G198_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L191
L190:
	LEA	G199_auc_G(A4),A0
	MOVE.L	A0,D0
L191:
	MOVE.L	D0,-(A7)
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L189:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	-8(A6),D0
	BEQ.S	L192
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A2
	MOVE	#15,D0
	MOVE	D4,D1
	AND	#15,D1
	SUB	D1,D0
	MOVE	D0,D4
	BRA.S	L193
L192:
	CMPI	#7,D6
	BNE.S	L194
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	SUB	D3,D0
	SUB	D0,D4
	BRA.S	L195
L194:
	CLR	D4
L195:
L193:
L179:
	MOVE	-10(A6),D0
	BEQ.S	L196
	MOVE.L	A3,-4(A6)
	LEA	-92(A6),A0
	MOVE.L	A0,A3
	CLR	D5
L197:
	BRA.S	L200
L201:
	ADDQ.L	#1,A3
L200:
	MOVE.B	(A3),D0
	AND	#255,D0
	CMP	#128,D0
	BLT.S	L201
L202:
	ADDQ	#1,D5
L198:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	CMP	#129,D0
	BNE.S	L197
L199:
	MOVE.L	-4(A6),A3
	CMPI	#4,D5
	BGE.S	L203
	MOVE	#8,-(A7)
	PEA	-22(A6)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	LEA	-22(A6),A0
	MOVE.L	A0,A3
	LEA	G190_auc_G(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#3,D0
	ADD	D5,D0
	LEA	G204_ac_Gr+-1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),3(A3)
L203:
L196:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	CMPI	#12,D6
	BNE.S	L204
	MOVE	G289_i_Dun(A4),D0
	SUBQ	#1,G289_i_Dun(A4)
	TST	D0
	BEQ.S	L204
	MOVE	#1,-(A7)
	MOVE	#112,-(A7)
	MOVE	#128,-(A7)
	MOVE	G289_i_Dun(A4),D0
	ASR	#3,D0
	MULS	#29,D0
	MOVE	D0,-(A7)
	MOVE	G289_i_Dun(A4),D0
	AND	#7,D0
	ASL	#5,D0
	MOVE	D0,-(A7)
	PEA	G109_s_Gra(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	#26,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L204:
L13T107_031:
	MOVE	-12(A6),D0
	BRA.S	L158
L159:
	MOVE	#0,D0
L158:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$157:	.EQU	#-92
F108_xxxx_:/* global */
	LINK	A6,L$205
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L207(PC)
	MOVE	D7,D4
	AND	#-32768,D4
	BEQ.S	L208
	MOVE	D7,D0
	AND	#32767,D0
	MOVE	D0,D7
	BNE.S	L209
	BRA	L14T108_005(PC)
L209:
L208:
	SUBQ	#1,D7
	MOVE	D7,D5
	ASL.L	#2,D5
	LEA	G102_aai_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D6,D1
	LEA	G191_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D3
	AND	#255,D3
	ADD	D3,D5
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G102_aai_C+2(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MULS	#54,D1
	LEA	G206_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#8,D6
	BEQ.S	L211
	CMPI	#5,D6
	BEQ.S	L211
	CMPI	#2,D6
	BEQ.S	L211
	CMPI	#15,D7
	BNE.S	L210
	MOVE	G076_B_Use(A4),D0
	BEQ.S	L210
	CMPI	#7,D6
	BEQ.S	L212
	CMPI	#4,D6
	BEQ.S	L212
	CMPI	#1,D6
	BNE.S	L210
L212:
L211:
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L213
L210:
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
L213:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L14T108_005:
	MOVE	D4,D0
	BEQ.S	L214
	MOVE	D6,-(A7)
	MOVE	#16,-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L214:
L207:
L206:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$205:	.EQU	#0
F109_xxxx_:/* global */
	LINK	A6,L$215
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L217(PC)
	SUBQ	#1,D7
	MOVE	D7,D5
	ASL.L	#2,D5
	LEA	G103_aai_C(A4),A0
	ADDA	D5,A0
	MOVE	(A0),D5
	MOVE	D6,D0
	MOVE	D7,D1
	ASL.L	#2,D1
	LEA	G103_aai_C+2(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	D1,D4
	MULS	#18,D1
	LEA	G207_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#2,D6
	BNE.S	L218
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#48,D6
	BRA	L219(PC)
L218:
	MOVE	#68,D0
	MOVE	D7,D1
	MULS	#2,D1
	ADD	D1,D0
	ADD	D6,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE	L220(PC)
	MOVE	D4,D0
	MULS	#18,D0
	LEA	G207_aaauc+12(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#0,D6
	BNE.S	L221
	LEA	G200_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L222
L221:
	LEA	G201_auc_G(A4),A0
	MOVE.L	A0,D0
L222:
	MOVE.L	D0,-(A7)
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	SUB	D3,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L220:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#0,D6
	BNE.S	L223
	MOVE	#24,D6
	BRA.S	L224
L223:
	MOVE	#32,D6
L224:
L219:
	MOVE	#9,-(A7)
	MOVE	D6,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L217:
L216:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$215:	.EQU	#-4
F110_xxxx_:/* global */
	LINK	A6,L$225
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	D7,D0
	BEQ	L227(PC)
	SUBQ	#1,D7
	MOVE	D7,D5
	ADD	#315,D5
	MOVE	D6,D0
	LEA	G197_auc_G(A4),A0
	ADDA	D7,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MOVE	D1,D4
	MULS	#24,D1
	LEA	G208_aaauc(A4),A0
	ADD.L	A0,D1
	MULS	#6,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#3,D6
	BNE.S	L228
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#4,-(A7)
	PEA	G291_aauc_+20(A4)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	BRA	L229(PC)
L228:
	MOVE	#102,D0
	MOVE	D7,D1
	MULS	#2,D1
	ADD	D1,D0
	MOVE	D6,D1
	BNE.S	L231
	MOVE	#0,D1
	BRA.S	L232
L231:
	MOVE	D6,D1
	SUBQ	#1,D1
L232:
	ADD	D1,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE	L230(PC)
	MOVE	D4,D0
	MULS	#24,D0
	LEA	G208_aaauc+18(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D5,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#2,D6
	BNE.S	L233
	LEA	G199_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L234
L233:
	LEA	G198_auc_G(A4),A0
	MOVE.L	A0,D0
L234:
	MOVE.L	D0,-(A7)
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	SUB	D3,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L230:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
L229:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L227:
L226:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$225:	.EQU	#-4
F111_xxxx_:/* global */
	LINK	A6,L$235
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	10(A6),D7
	MOVE.L	20(A6),A3
	CMPI	#0,D7
	BEQ	L237(PC)
	MOVE.L	G284_apuc_(A4),D0
	MOVE	8(A6),D1
	AND.L	#65535,D1
	ASL.L	#2,D1
	ADD.L	D1,D0
	MOVE.L	D0,A2
	MOVE	16(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE	2(A2),D0
	AND	#1,D0
	MOVE	D0,D6
	ASL.L	#1,D0
	MOVE.L	12(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	18(A6),-(A7)
	MOVE	2(A2),D0
	AND	#30,D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	JSR	F109_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G275_as_Cu(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#4,D0
	BEQ.S	L238
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L239
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L239:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L240
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F131_xxxx_(PC)
	ADDQ.L	#8,A7
L240:
L238:
	MOVE.L	A3,D0
	LEA	G186_s_Gra(A4),A0
	CMP.L	A0,D0
	BNE.S	L241
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ.S	L241
	MOVE	#2,-(A7)
	MOVE	#17,-(A7)
	JSR	F109_xxxx_(PC)
	ADDQ.L	#4,A7
L241:
	CMPI	#4,D7
	BNE.S	L242
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L236
L242:
	CMPI	#5,D7
	BNE.S	L243
	MOVE	18(A6),-(A7)
	MOVE	#16,-(A7)
	JSR	F109_xxxx_(PC)
	ADDQ.L	#4,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L236
L243:
	SUBQ	#1,D7
	MOVE	2(A2),D0
	AND	#32,D0
	LSR	#5,D0
	BEQ.S	L244
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	8(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L245
L244:
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	32(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	56(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F102_xxxx_(PC)
	ADDQ.L	#4,A7
L245:
L237:
L236:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$235:	.EQU	#0
F112_xxxx_:/* global */
	LINK	A6,L$246
	MOVE	D7,-(A7)
	PEA	16(A6)
	PEA	14(A6)
	MOVE	#-1,-(A7)
	MOVE	G272_i_Cur(A4),-(A7)
	JSR	F154_afzz_(PC)
	ADDA	#12,A7
	MOVE	D0,D7
	CMPI	#0,D0
	BLT.S	L248
	MOVE	14(A6),D0
	MOVE	D7,D1
	ASL.L	#2,D1
	MOVE.L	G279_pppuc(A4),A0
	ADDA	D1,A0
	ASL.L	#2,D0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	16(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	ASR	#5,D0
	CMPI	#2,D0
	BNE.S	L248
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L248
	MOVE	18(A6),D0
	BEQ.S	L249
	MOVE.L	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L250
L249:
	MOVE.L	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L250:
L248:
L247:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$246:	.EQU	#0
F113_xxxx_:/* global */
	LINK	A6,L$251
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	3(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L253
	MOVE.L	#0,A2
	BRA.S	L254
L253:
	MOVE.B	4(A3),D0
	MOVE.B	5(A3),D1
	AND	#255,D1
	AND	#255,D0
	MULS	D1,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	MOVE	#69,D0
	MOVE.B	3(A3),D1
	AND	#255,D1
	AND	#127,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.B	3(A3),D0
	AND	#255,D0
	AND	#128,D0
	BEQ.S	L255
	MOVE.B	5(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L255:
L254:
	CLR	-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#73,D0
	MOVE.B	(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CLR	-(A7)
	MOVE.B	6(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	#112,-(A7)
	JSR	F027_AA59_(PC)
	AND	#31,D0
	MOVE	D0,-(A7)
	JSR	F028_a000_(PC)
	MOVE.B	1(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	MOVE.L	12(A6),-(A7)
	CLR	-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F133_xxxx_(PC)
	ADDA	#32,A7
	CLR	-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32768,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L252:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$251:	.EQU	#-4
F114_xxxx_:/* global */
	LINK	A6,L$256
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G211_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#32,10(A6)
	BLS.S	L258
	MOVE	#32,10(A6)
L258:
	MOVE.B	(A2),D6
	AND	#255,D6
	MULU	10(A6),D6
	MOVE	10(A6),D1
	LSR	#1,D1
	ADD	D1,D6
	LSR	#5,D6
	MOVE.B	1(A2),D5
	AND	#255,D5
	MULU	10(A6),D5
	MOVE	10(A6),D1
	LSR	#1,D1
	ADD	D1,D5
	LSR	#5,D5
	CMPI	#32,10(A6)
	BNE.S	L259
	CMPI	#3,D7
	BEQ.S	L259
	MOVE	D7,D0
	ADD	#348,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA	L260(PC)
L259:
	MOVE	D7,D0
	MULU	#14,D0
	MOVE	10(A6),D1
	LSR	#1,D1
	ADD	D1,D0
	ADD	#436,D0
	MOVE	D0,D4
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L261
	MOVE	D4,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L262
L261:
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	#348,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#3,D7
	BNE.S	L263
	LEA	G212_auc_G(A4),A0
	MOVE.L	A0,D0
	BRA.S	L264
L263:
	LEA	G017_auc_G(A4),A0
	MOVE.L	A0,D0
L264:
	MOVE.L	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	D4,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D4,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L262:
L260:
	MOVE.L	12(A6),A0
	MOVE	D6,(A0)
	MOVE.L	16(A6),A0
	MOVE	D5,(A0)
	MOVE.L	A3,D0
L257:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$256:	.EQU	#-4
F115_xxxx_:/* global */
	LINK	A6,L$265
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	16(A6),D6
	CMPI	#-2,D7
	BNE.S	L267
	BRA	L266(PC)
L267:
	CLR.L	-58(A6)
	MOVE	#-1,-54(A6)
	MOVE	#0,D0
	MOVE	D0,-158(A6)
	MOVE	D0,-134(A6)
	MOVE	D0,-108(A6)
	CLR	-48(A6)
	MOVE	D7,-44(A6)
	MOVE	18(A6),D0
	AND	#8,D0
	BEQ.S	L268
	MOVE	18(A6),D0
	AND	#1,D0
	ADDQ	#1,D0
	MOVE	D0,-110(A6)
	MOVE	18(A6),D0
	LSR	#4,D0
	MOVE	D0,18(A6)
	BRA.S	L269
L268:
	CLR	-110(A6)
L269:
	MOVE	18(A6),D0
	AND.L	#65535,D0
	MOVE.L	D0,-4(A6)
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-20(A6)
	MOVE	D6,-46(A6)
	MOVE	D6,D0
	ADDQ	#3,D0
	EXT.L	D0
	DIVS	#3,D0
	SWAP	D0
	MOVE	D0,-26(A6)
L270:
	MOVE	-20(A6),D0
	BEQ.S	L273
	MOVE	#4,D5
	MOVE	10(A6),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-28(A6)
	MOVE	#2,-50(A6)
	BRA.S	L274
L273:
	MOVE.L	-4(A6),D5
	AND	#15,D5
	SUBQ	#1,D5
	MOVE	D5,-136(A6)
	MOVE.L	-4(A6),D0
	LSR.L	#4,D0
	MOVE.L	D0,-4(A6)
	ADDQ	#1,-48(A6)
	MOVE	D5,D0
	ADD	10(A6),D0
	AND	#3,D0
	MOVE	D0,-28(A6)
	MOVE	-44(A6),D7
	MOVE	-46(A6),D6
	CLR	-50(A6)
L274:
	MOVE	-28(A6),D0
	AND	#1,D0
	ASL	#3,D0
	ADD	D0,-50(A6)
	CLR	-132(A6)
L275:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D4
	CMPI	#4,D0
	BNE.S	L278
	MOVE	D7,-54(A6)
	BRA	L276(PC)
L278:
	CMPI	#14,D4
	BNE.S	L279
	MOVE	#1,-134(A6)
	BRA	L276(PC)
L279:
	CMPI	#15,D4
	BNE.S	L280
	MOVE	#1,-158(A6)
	BRA	L276(PC)
L280:
	CMPI	#0,D6
	BLT	L281(PC)
	CMPI	#9,D6
	BGT	L281(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	-28(A6),D1
	CMP	D1,D0
	BNE	L281(PC)
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+2(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#6,D0
	LEA	G209_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	#360,D4
	MOVE.B	(A2),D3
	AND	#255,D3
	ADD	D3,D4
	MOVE	-20(A6),D0
	BEQ.S	L284
	MOVE.B	4(A2),D0
	AND	#255,D0
	AND	#16,D0
L284:
	SNE	D0
	TST.B	D0
	BEQ.S	L283
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
L283:
	AND	#1,D0
	MOVE	D0,-34(A6)
	BEQ.S	L282
	ADDQ	#1,D4
L282:
	MOVE	D6,D1
	MOVE.B	5(A2),D0
	AND	#255,D0
	MULS	#100,D0
	LEA	G218_aaaau(A4),A0
	ADD.L	A0,D0
	MULS	#10,D1
	ADD.L	D0,D1
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-16(A6)
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),D0
	BNE.S	L285
	BRA	L276(PC)
L285:
L21T115_015:
	MOVE.B	4(A2),D0
	AND	#255,D0
	AND	#1,D0
	BEQ.S	L287
	MOVE	-34(A6),D0
	SEQ	D0
	TST.B	D0
L287:
	SNE	D0
	TST.B	D0
	BEQ.S	L286
	CMPI	#2,-26(A6)
	SEQ	D0
	TST.B	D0
	BNE.S	L288
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L289
	CMPI	#1,D5
	SEQ	D0
	TST.B	D0
	BNE.S	L290
	CMPI	#2,D5
	SEQ	D0
	TST.B	D0
L290:
	TST.B	D0
L289:
	TST.B	D0
L288:
	TST.B	D0
L286:
	AND	#1,D0
	MOVE	D0,-36(A6)
	CLR	-30(A6)
	CMPI	#9,D6
	BEQ.S	L292
	CMPI	#6,D6
	BLT.S	L291
	CMPI	#2,D5
	BLT.S	L291
L292:
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L293
	MOVE	-132(A6),D0
	SEQ	D0
	TST.B	D0
L293:
	AND	#1,D0
	MOVE	D0,-38(A6)
	CLR	-52(A6)
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.B	2(A2),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	-36(A6),D0
	BEQ.S	L294
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A3
L294:
	BRA	L295(PC)
L291:
	CLR	-38(A6)
	MOVE	#104,D0
	MOVE.B	1(A2),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-18(A6)
	CMPI	#6,D6
	BGE.S	L297
	CMPI	#3,D6
	BLT.S	L296
	CMPI	#2,D5
	BLT.S	L296
L297:
	ADDQ	#1,-18(A6)
	MOVE	#1,-52(A6)
	MOVE.B	2(A2),D0
	AND	#255,D0
	MULS	#20,D0
	ADD	#10,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MULS	#20,D0
	ADD	#10,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	LEA	G214_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
	BRA.S	L298
L296:
	MOVE	#2,-52(A6)
	MOVE.B	2(A2),D0
	AND	#255,D0
	MULS	#16,D0
	ADDQ	#8,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MULS	#16,D0
	ADDQ	#8,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	LEA	G213_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
L298:
	MOVE	-36(A6),D0
	BEQ.S	L299
	ADDQ	#2,-18(A6)
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-30(A6)
	BRA.S	L300
L299:
	MOVE	-34(A6),D0
	BEQ.S	L301
	ADDQ	#4,-18(A6)
L301:
L300:
	MOVE	-18(A6),-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L302
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L303
L302:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE.L	-8(A6),-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A2),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	-36(A6),D0
	BEQ.S	L304
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L304:
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L303:
L295:
	MOVE.L	-16(A6),A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),-39(A6)
	MOVE	-132(A6),D0
	BNE.S	L305
	MOVE	-50(A6),D0
	ASL.L	#1,D0
	LEA	G217_aauc_(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	AND	#255,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,D4
	MOVE	-50(A6),D0
	ASL.L	#1,D0
	LEA	G217_aauc_+1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	AND	#255,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	ADD.B	D0,-39(A6)
	ADDQ	#1,-50(A6)
	MOVE	-20(A6),D0
	BEQ.S	L306
	CMPI	#14,-50(A6)
	BCS.S	L307
	MOVE	#2,-50(A6)
L307:
	BRA.S	L308
L306:
	ANDI	#15,-50(A6)
L308:
L305:
	MOVE.B	-39(A6),D0
	MOVE	-24(A6),D1
	SUBQ	#1,D1
	AND	#255,D0
	SUB	D1,D0
	MOVE.B	D0,-40(A6)
	MOVE.B	-39(A6),D0
	AND	#255,D0
	CMP	#135,D0
	BLE.S	L309
	MOVE.B	#-121,-39(A6)
L309:
	MOVE	D4,D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	MOVE	#223,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-41(A6)
	MOVE	D4,D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L310
	MOVE	-36(A6),D0
	BEQ.S	L311
	MOVE	-30(A6),D4
	BRA.S	L312
L311:
	CLR	D4
L312:
	BRA.S	L313
L310:
	MOVE	-22(A6),D0
	SUB	D4,D0
	SUBQ	#1,D0
	MOVE	D0,D4
L313:
	MOVE	-38(A6),D0
	BEQ	L314(PC)
	MOVE.L	A3,-12(A6)
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G291_aauc_(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	(A3),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L315
	MOVE	#4,-(A7)
	MOVE.L	A3,-(A7)
	PEA	-42(A6)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE.B	2(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,-32(A6)
	CMPI	#14,D0
	BGE.S	L316
	MOVE	-32(A6),D0
	ASR	#1,D0
	MOVE	D0,-32(A6)
	MOVE	-32(A6),D0
	SUBQ	#7,D0
	ADD.B	D0,2(A3)
	CMPI	#4,-32(A6)
	BGE.S	L317
	MOVE	-32(A6),D0
	SUBQ	#3,D0
	SUB.B	D0,3(A3)
L317:
L316:
	BRA.S	L318
L315:
	MOVE.B	-42(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,(A3)
	MOVE.B	-41(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,1(A3)
	MOVE.B	-40(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,2(A3)
	MOVE.B	-39(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	3(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,3(A3)
L318:
	MOVE.L	-12(A6),A3
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G292_aT_Pi(A4),A0
	ADDA	D0,A0
	MOVE	D7,(A0)
L314:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	-132(A6),D0
	BEQ.S	L319
	BRA	L21T115_171(PC)
L319:
L281:
L276:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE	L275(PC)
L277:
	CMPI	#4,D5
	BNE.S	L320
	BRA	L272(PC)
L320:
	CMPI	#0,D6
	BGE.S	L321
	BRA	L272(PC)
L321:
	CMPI	#1,D5
	SLE	D0
	TST.B	D0
	BNE.S	L323
	CMPI	#1,-48(A6)
	SEQ	D0
	TST.B	D0
L323:
	TST.B	D0
	BEQ.S	L322
	MOVE.L	-4(A6),D0
	SEQ	D0
	TST.B	D0
	BNE.S	L324
	MOVE.L	-4(A6),D0
	AND.L	#15,D0
	CMPI.L	#3,D0
	SCC	D0
	TST.B	D0
L324:
	TST.B	D0
L322:
	AND	#1,D0
	MOVE	D0,-96(A6)
	CMPI	#-1,-54(A6)
	BEQ.S	L326
	MOVE	-108(A6),D0
	BEQ.S	L325
L326:
	BRA	L21T115_129(PC)
L325:
	CMPI.L	#0,-58(A6)
	BNE.S	L327
	MOVE	-54(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-58(A6)
	MOVE.L	-58(A6),A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-62(A6)
	MOVE.L	-58(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-66(A6)
	MOVE.L	-66(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MULS	#12,D0
	LEA	G219_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-70(A6)
	MOVE.L	-66(A6),A0
	MOVE	2(A0),D0
	AND	#3,D0
	MOVE	D0,-72(A6)
	MOVE.L	-66(A6),A0
	MOVE	4(A0),-76(A6)
L327:
	MOVE.L	-70(A6),D0
	MOVE.L	D0,A2
	MOVE	-28(A6),-(A7)
	MOVE.L	-58(A6),-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	BEQ.S	L328
	SUBQ	#1,D7
	MOVE	D7,D0
	MOVE	D0,-82(A6)
	BRA.S	L329
L328:
	CMPI	#1,-72(A6)
	BNE.S	L330
	CLR	D7
	MOVE	#-1,-82(A6)
	BRA.S	L331
L330:
	BRA	L21T115_129(PC)
L331:
L329:
	MOVE.L	-62(A6),A0
	MOVE.B	2(A0),D0
	MOVE	D7,D1
	ASL	#1,D1
	AND	#255,D0
	ASR	D1,D0
	AND	#3,D0
	MOVE	D0,-180(A6)
	MOVE	10(A6),D0
	SUB	-180(A6),D0
	AND	#3,D0
	MOVE	D0,-74(A6)
	CLR	-94(A6)
	MOVE.L	-62(A6),A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	CMPI	#255,D0
	BNE.S	L332
	MOVE.L	-4(A6),D0
	BNE.S	L334
	CMPI	#1,-110(A6)
	BNE.S	L333
L334:
	BRA	L21T115_129(PC)
L333:
	MOVE	#1,-108(A6)
	CMPI	#1,-72(A6)
	BNE.S	L335
	MOVE	-74(A6),D0
	AND	#1,D0
	BEQ.S	L335
	MOVE	#3,D5
	BRA.S	L336
L335:
	MOVE	#4,D5
L336:
	BRA	L337(PC)
L332:
	CMPI	#1,-72(A6)
	BNE	L338(PC)
	MOVE	-96(A6),D0
	BNE.S	L339
	MOVE.L	-4(A6),D0
	BEQ.S	L339
	CMPI	#0,-82(A6)
	BGE	L338(PC)
L339:
	MOVE	-96(A6),D0
	BEQ.S	L340
	CMPI	#2,-110(A6)
	BEQ.S	L340
	CMPI	#0,-82(A6)
	BLT.S	L341
	MOVE	-74(A6),D0
	AND	#1,D0
	BEQ.S	L341
	MOVE	#2,D5
	BRA.S	L342
L341:
	BRA	L21T115_129(PC)
L342:
	BRA	L343(PC)
L340:
	CMPI	#1,-110(A6)
	BEQ.S	L344
	MOVE.L	-4(A6),D0
	BNE.S	L344
	MOVE	-74(A6),D0
	AND	#1,D0
	BEQ.S	L345
	CMPI	#0,-82(A6)
	BLT.S	L346
	MOVE	#4,D5
	BRA.S	L347
L346:
	BRA	L21T115_129(PC)
L347:
	BRA.S	L348
L345:
	MOVE	#1,-108(A6)
	CMPI	#0,-82(A6)
	BGE.S	L349
	CLR	-82(A6)
L349:
	MOVE.L	-58(A6),A0
	MOVE	14(A0),D0
	AND	#96,D0
	LSR	#5,D0
	MOVE	D0,-94(A6)
	MOVE	D4,D0
	MOVE	D7,D1
	ASL	#1,D1
	ASR	D1,D0
	AND	#3,D0
	MOVE	D0,D4
	CMP	10(A6),D0
	BEQ.S	L351
	MOVE	D4,D0
	MOVE	10(A6),D1
	SUBQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L350
L351:
	CLR	D5
	BRA.S	L352
L350:
	MOVE	#1,D5
L352:
L348:
	BRA.S	L353
L344:
	BRA	L21T115_129(PC)
L353:
L343:
	BRA.S	L354
L338:
	CMPI	#0,-72(A6)
	BEQ.S	L355
	BRA	L21T115_129(PC)
L355:
L354:
L337:
	MOVE.L	-62(A6),A0
	LEA	12(A0),A0
	ADDA	-82(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-78(A6)
	CMPI	#9,D6
	BLE.S	L356
	SUBQ	#1,D6
L356:
L21T115_077:
	MOVE	D6,D1
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	10(A0),D0
	AND	#255,D0
	ASR	#4,D0
	AND	#15,D0
	MULS	#110,D0
	LEA	G224_aaaau(A4),A0
	ADD.L	A0,D0
	MULS	#10,D1
	ADD.L	D0,D1
	MOVE	D5,D0
	ASL.L	#1,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-16(A6)
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),D0
	BNE.S	L357
	BRA	L21T115_126(PC)
L357:
	MOVE	-76(A6),D7
	MOVE	#446,D4
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	ADD	(A0),D4
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),-18(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L359
	MOVE	-74(A6),D0
	AND	#1,D0
L359:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-98(A6)
	BEQ.S	L358
	MOVE	#0,D0
	MOVE	D0,-100(A6)
	MOVE	D0,-106(A6)
	MOVE	D0,-104(A6)
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	6(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE	D0,-86(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	7(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	D0,-88(A6)
	BRA	L360(PC)
L358:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L361
	CMPI	#0,-74(A6)
	SEQ	D0
	TST.B	D0
L361:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-100(A6)
	MOVE	-100(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L364
	MOVE	-78(A6),D0
	AND	#128,D0
L364:
	SNE	D0
	TST.B	D0
	BEQ.S	L363
	MOVE	D7,D0
	AND	#32,D0
L363:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-104(A6)
	BEQ.S	L362
	CLR	-106(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	8(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE	D0,-86(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	9(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	D0,-88(A6)
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L365
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
L365:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L366
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
L366:
	BRA	L367(PC)
L362:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE	D0,-86(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	MOVE	D0,-88(A6)
	MOVE	-100(A6),D0
	BEQ.S	L368
	CLR	-106(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L369
	ADDQ	#2,D4
	ADDQ	#4,-18(A6)
	BRA.S	L370
L369:
	ADDQ	#1,D4
	ADDQ	#2,-18(A6)
L370:
	BRA.S	L371
L368:
	MOVE	D7,D0
	AND	#4,D0
	BEQ.S	L373
	MOVE	-78(A6),D0
	AND	#64,D0
L373:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-106(A6)
	BEQ.S	L372
	ADDQ	#2,-18(A6)
	MOVE	D7,D0
	AND	#8,D0
	BEQ.S	L374
	ADDQ	#2,-18(A6)
L374:
	MOVE	D7,D0
	AND	#16,D0
	BEQ.S	L375
	ADDQ	#2,-18(A6)
L375:
	MOVE	D7,D0
	AND	#32,D0
	BEQ.S	L376
	ADDQ	#2,-18(A6)
L376:
L372:
L371:
L367:
L360:
	CMPI	#6,D6
	BLT	L377(PC)
	CLR	-90(A6)
	CLR	-52(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	10(A0),D0
	AND	#255,D0
	AND	#15,D0
	MOVE	D0,-84(A6)
	MOVE	-98(A6),D0
	BEQ.S	L378
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	CMPI	#1,-74(A6)
	BNE.S	L379
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A3
L379:
	BRA	L380(PC)
L378:
	MOVE	-100(A6),D0
	BNE.S	L382
	MOVE	-106(A6),D0
	BNE.S	L381
L382:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	-104(A6),D0
	BEQ.S	L383
	MOVE	-78(A6),D0
	AND	#64,D0
	BEQ.S	L383
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	G074_puc_B(A4),A3
L383:
	BRA.S	L384
L381:
	MOVE	-18(A6),-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L385
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L386
L385:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE	D7,D0
	AND	#4,D0
	BEQ.S	L387
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F099_xxxx_(PC)
	ADDA	#12,A7
L387:
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L386:
L384:
L380:
	BRA	L388(PC)
L377:
	MOVE	-106(A6),D0
	BEQ.S	L389
	ADDQ	#1,-18(A6)
L389:
	CMPI	#3,D6
	BLT.S	L390
	ADDQ	#1,-18(A6)
	MOVE	#1,-52(A6)
	MOVE	D7,D0
	AND	#128,D0
	BEQ.S	L393
	MOVE	-98(A6),D0
	SEQ	D0
	TST.B	D0
L393:
	SNE	D0
	TST.B	D0
	BEQ.S	L392
	MOVE	-100(A6),D0
	SEQ	D0
	TST.B	D0
L392:
	TST.B	D0
	BEQ.S	L391
	MOVE	-104(A6),D0
	SEQ	D0
	TST.B	D0
L391:
	AND	#1,D0
	MOVE	D0,-102(A6)
	LEA	G222_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
	MOVE	#20,-112(A6)
	BRA.S	L394
L390:
	MOVE	#2,-52(A6)
	CLR	-102(A6)
	LEA	G221_auc_G(A4),A0
	MOVE.L	A0,-8(A6)
	MOVE	#16,-112(A6)
L394:
	MOVE	-86(A6),D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE	-88(A6),D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	10(A0),D0
	AND	#255,D0
	AND	#15,D0
	MOVE.L	-8(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-84(A6)
	MOVE	-18(A6),-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-114(A6)
	BEQ.S	L395
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L396
L395:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE.L	-8(A6),-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	-88(A6),-(A7)
	MOVE	-86(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L396:
	MOVE	-98(A6),D0
	BEQ.S	L399
	CMPI	#1,-74(A6)
	BEQ.S	L398
L399:
	MOVE	-104(A6),D0
	BEQ.S	L400
	MOVE	-78(A6),D0
	AND	#64,D0
	BNE.S	L398
L400:
	MOVE	-102(A6),D0
	BEQ.S	L401
	MOVE	D7,D0
	AND	#256,D0
	BNE.S	L398
L401:
	MOVE	-106(A6),D0
	BEQ.S	L397
	MOVE	D7,D0
	AND	#4,D0
	BEQ.S	L397
L398:
	MOVE	-106(A6),D0
	BEQ.S	L403
	MOVE	-114(A6),D0
	BNE.S	L402
L403:
	MOVE	-22(A6),D4
	ADDQ	#7,D4
	AND	#-8,D4
	MOVE	-106(A6),D0
	BNE.S	L404
	MOVE	D4,D0
	MULS	-24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G074_puc_B(A4),A3
L404:
	MOVE	-24(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L402:
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-90(A6)
	BRA.S	L405
L397:
	CLR	-90(A6)
L405:
L388:
	MOVE.L	-16(A6),A0
	MOVE.B	1(A0),D4
	AND	#255,D4
	MOVE	-78(A6),D0
	ASR	#3,D0
	AND	#7,D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,D4
	MOVE	#135,-(A7)
	MOVE	D4,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-39(A6)
	MOVE	D4,D0
	MOVE	-24(A6),D1
	SUBQ	#1,D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-40(A6)
	MOVE.L	-16(A6),A0
	MOVE.B	(A0),D4
	AND	#255,D4
	MOVE	-78(A6),D0
	AND	#7,D0
	MOVE	-52(A6),D1
	AND.L	#65535,D1
	ASL.L	#3,D1
	LEA	G223_aac_G(A4),A0
	ADD.L	A0,D1
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,D4
	CMPI	#1,-26(A6)
	BNE.S	L406
	SUB	#100,D4
	BRA.S	L407
L406:
	MOVE	-26(A6),D0
	BEQ.S	L408
	ADD	#100,D4
L408:
L407:
	MOVE	#223,-(A7)
	MOVE	D4,D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,-41(A6)
	BNE.S	L409
	BRA.S	L21T115_126
L409:
	MOVE	#223,-(A7)
	MOVE	D4,D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L410
	MOVE.B	-42(A6),D0
	AND	#255,D0
	CMP	#223,D0
	BNE.S	L411
	BRA.S	L21T115_126
L411:
	MOVE	-90(A6),D7
	BRA.S	L412
L410:
	MOVE	-90(A6),D7
	MOVE	-22(A6),D1
	SUB	D4,D1
	SUBQ	#1,D1
	ADD	D1,D7
L412:
	MOVE	-84(A6),-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L21T115_126:
	MOVE	-94(A6),D0
	BEQ.S	L413
	CLR	-94(A6)
	MOVE	-82(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE.L	-62(A6),A0
	LEA	12(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-78(A6)
	CMPI	#1,D5
	BNE.S	L414
	CLR	D5
	BRA.S	L415
L414:
	MOVE	#1,D5
L415:
	BRA	L21T115_077(PC)
L413:
L21T115_129:
	MOVE	-134(A6),D0
	BEQ.S	L417
	MOVE	-46(A6),D0
	MOVE	D0,D6
	CMPI	#9,D0
	BGT.S	L417
	MOVE	-136(A6),D0
	MOVE	D0,D5
	MOVE	D6,D1
	MULS	#10,D1
	LEA	G218_aaaau(A4),A0
	ADD.L	A0,D1
	ASL.L	#1,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-122(A6)
	BNE.S	L416
L417:
	BRA	L271(PC)
L416:
	MOVE	-44(A6),D7
L418:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#14,D0
	BNE	L421(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	-28(A6),D1
	CMP	D1,D0
	BNE	L421(PC)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-118(A6)
	MOVE.L	-118(A6),A0
	MOVE	2(A0),-(A7)
	JSR	F142_aqzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#0,D0
	BGE	L422(PC)
	MOVE	D4,D0
	NEG	D0
	MULS	#6,D0
	LEA	G210_as_Gr+-6(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	A2,D4
	MOVE.L	D4,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	ADD	#316,D4
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	4(A0),D0
	AND	#3,D0
	MOVE	D0,-126(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	4(A0),D0
	AND	#256,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-130(A6)
	BNE.S	L424
	MOVE.L	-118(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L423
L424:
	CMPI	#9,D6
	BNE.S	L423
	CLR	-112(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	MOVE	D0,-22(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-24(A6)
	BRA	L425(PC)
L423:
	MOVE	D6,D0
	EXT.L	D0
	DIVS	#3,D0
	ASL	#1,D0
	MOVE	D5,D1
	ASR	#1,D1
	ADD	D1,D0
	MOVE	D0,-52(A6)
	MOVE	-52(A6),D0
	LEA	G215_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-112(A6)
	MOVE	-130(A6),D0
	BNE.S	L426
	MOVE.L	-118(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#96,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-190(A6)
	MOVE	-112(A6),D0
	MULS	-190(A6),D0
	ASR	#8,D0
	MOVE	D0,-112(A6)
L426:
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MULS	-112(A6),D0
	MOVE	-112(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
L425:
	CMPI	#0,-126(A6)
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-140(A6)
	BEQ.S	L427
	MOVE	12(A6),D0
	ADD	14(A6),D0
	AND	#1,D0
	MOVE	D0,-138(A6)
L427:
	CMPI	#3,-126(A6)
	BNE.S	L428
	CLR	-128(A6)
	MOVE	#0,D0
	MOVE	D0,-36(A6)
	MOVE	D0,-142(A6)
	BRA	L429(PC)
L428:
	MOVE.L	-118(A6),A0
	MOVE	6(A0),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE	8(A0),D0
	AND	#3072,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-124(A6)
	AND	#1,D0
	MOVE	10(A6),D1
	AND	#1,D1
	CMP	D1,D0
	BEQ.S	L430
	CMPI	#2,-126(A6)
	BNE.S	L431
	MOVE	#1,-128(A6)
	BRA.S	L432
L431:
	MOVE	#2,-128(A6)
L432:
	MOVE	-140(A6),D0
	BEQ.S	L433
	MOVE	D5,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L434
	CMPI	#3,D5
	SEQ	D0
	TST.B	D0
L434:
	AND	#1,D0
	MOVE	D0,-36(A6)
	MOVE	-138(A6),D0
	MOVE	D0,-142(A6)
	BNE.S	L435
	MOVE	-36(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-36(A6)
L435:
	BRA.S	L436
L433:
	CLR	-142(A6)
	MOVE	10(A6),D0
	ADDQ	#1,D0
	AND	#3,D0
	CMP	-124(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-36(A6)
L436:
	BRA	L437(PC)
L430:
	CMPI	#2,-126(A6)
	BGE.S	L439
	CMPI	#1,-126(A6)
	BNE.S	L440
	MOVE	-124(A6),D0
	CMP	10(A6),D0
	BNE.S	L439
L440:
	MOVE	-140(A6),D0
	BEQ.S	L438
	MOVE	-138(A6),D0
	BEQ.S	L438
L439:
	CLR	-128(A6)
	BRA.S	L441
L438:
	MOVE	#1,-128(A6)
L441:
	MOVE	-140(A6),D0
	BEQ.S	L442
	CMPI	#2,D5
	SLT	D0
	TST.B	D0
L442:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-142(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	4(A0),D0
	AND	#16,D0
	BEQ.S	L443
	CMPI	#2,-26(A6)
	SEQ	D0
	TST.B	D0
	BNE.S	L444
	MOVE	-26(A6),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L445
	CMPI	#1,D5
	SEQ	D0
	TST.B	D0
	BNE.S	L446
	CMPI	#2,D5
	SEQ	D0
	TST.B	D0
L446:
	TST.B	D0
L445:
	TST.B	D0
L444:
	TST.B	D0
	SEQ	D0
	TST.B	D0
L443:
	SNE	D0
	AND	#1,D0
	MOVE	D0,-36(A6)
L437:
L429:
	ADD	-128(A6),D4
	CLR	-30(A6)
	MOVE	-112(A6),D0
	BNE.S	L447
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA	L448(PC)
L447:
	MOVE	-36(A6),D0
	BEQ.S	L449
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-30(A6)
L449:
	MOVE	-130(A6),D0
	BEQ.S	L450
	MOVE	#282,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	MOVE.B	1(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	-128(A6),D1
	MULS	#6,D1
	ADD	D1,D0
	ADD	-52(A6),D0
	MOVE	D0,-18(A6)
	MOVE	D0,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L450
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L451
L450:
	MOVE	D4,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-12(A6)
	MOVE	-130(A6),D0
	BEQ.S	L452
	MOVE	-18(A6),-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	BRA.S	L453
L452:
	MOVE.L	G074_puc_B(A4),A3
L453:
	MOVE	-52(A6),D0
	LSR	#1,D0
	ASL.L	#2,D0
	LEA	G075_apuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	-12(A6),-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	-130(A6),D0
	BEQ.S	L454
	MOVE	-18(A6),-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
L454:
L451:
L448:
	MOVE	-36(A6),D0
	BNE.S	L456
	MOVE	-142(A6),D0
	BEQ.S	L455
L456:
	MOVE	-22(A6),D4
	ADDQ	#7,D4
	AND	#-8,D4
	MOVE.L	A3,D0
	CMP.L	G074_puc_B(A4),D0
	BEQ.S	L457
	MOVE	D4,D0
	MULS	-24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G074_puc_B(A4),A3
L457:
	MOVE	-142(A6),D0
	BEQ.S	L458
	MOVE	-24(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F131_xxxx_(PC)
	ADDQ.L	#8,A7
L458:
	MOVE	-36(A6),D0
	BEQ.S	L459
	MOVE	-24(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L459:
L455:
	MOVE	-24(A6),D0
	ASR	#1,D0
	ADD	#47,D0
	MOVE.B	D0,-39(A6)
	MOVE	#47,D0
	MOVE	-24(A6),D1
	ASR	#1,D1
	SUB	D1,D0
	MOVE	-24(A6),D1
	AND	#1,D1
	SEQ	D1
	AND	#1,D1
	ADD	D1,D0
	MOVE.B	D0,-40(A6)
	MOVE	-122(A6),D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	MOVE	#223,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-41(A6)
	MOVE	-122(A6),D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L460
	MOVE	-36(A6),D0
	BEQ.S	L461
	MOVE	-30(A6),D4
	BRA.S	L462
L461:
	CLR	D4
L462:
	BRA.S	L463
L460:
	MOVE	-22(A6),D0
	SUB	-122(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	-30(A6),-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L463:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	BRA.S	L464
L422:
	CLR	-34(A6)
	MOVE	-122(A6),D0
	MOVE.B	D0,-120(A6)
	MOVE.B	#47,-119(A6)
	LEA	-120(A6),A0
	MOVE.L	A0,-16(A6)
	MOVE	D4,D0
	MULS	#6,D0
	LEA	G209_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D4
	AND	#255,D4
	ADD	#360,D4
	MOVE	#1,-132(A6)
	BRA	L21T115_015(PC)
L464:
L421:
L21T115_171:
L419:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE	L418(PC)
L420:
L271:
	MOVE.L	-4(A6),D0
	BNE	L270(PC)
L272:
	MOVE	-158(A6),D0
	BNE.S	L465
	BRA	L266(PC)
L465:
	CLR.L	-150(A6)
	MOVE	-46(A6),D6
	ADDQ	#3,D6
	MOVE	D6,D0
	EXT.L	D0
	DIVS	#3,D0
	MOVE	D0,-46(A6)
	MOVE	-44(A6),D7
L466:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BNE	L469(PC)
	MOVE	D7,D5
	LSR	#6,D5
	LSR	#8,D5
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-146(A6)
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D0
	AND	#127,D0
	MOVE	D0,D4
	CMPI	#100,D0
	SGE	D0
	AND	#1,D0
	MOVE	D0,-160(A6)
	BEQ.S	L470
	CMPI	#3,D6
	BLT.S	L471
	CMPI	#9,D6
	BGT.S	L471
	MOVE	D5,D0
	CMP	-28(A6),D0
	BEQ.S	L470
L471:
	BRA	L467(PC)
L470:
	CLR	-162(A6)
	CMPI	#0,D4
	BEQ.S	L473
	CMPI	#2,D4
	BEQ.S	L473
	CMPI	#101,D4
	BNE.S	L472
L473:
	CLR	D4
	BRA	L474(PC)
L472:
	CMPI	#6,D4
	BEQ.S	L476
	CMPI	#7,D4
	BNE.S	L475
L476:
	MOVE	#2,D4
	BRA	L477(PC)
L475:
	CMPI	#40,D4
	BNE.S	L478
	MOVE	#1,-162(A6)
	MOVE	#3,D4
	BRA	L479(PC)
L478:
	CMPI	#100,D4
	BNE	L480(PC)
	MOVE	#-126,-(A7)
	JSR	F142_aqzz_(PC)
	ADDQ.L	#2,A7
	NEG	D0
	MULS	#6,D0
	LEA	G210_as_Gr+-6(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	#317,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G228_aai_G+-18(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	MOVE.L	-154(A6),A0
	AND	#255,D0
	MULS	4(A0),D0
	MOVE.L	-154(A6),A0
	MOVE	4(A0),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-22(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	MOVE.L	-154(A6),A0
	AND	#255,D0
	MULS	4(A0),D0
	MOVE.L	-154(A6),A0
	MOVE	4(A0),D1
	ASR	#1,D1
	ADD	D1,D0
	ASR	#5,D0
	MOVE	D0,-24(A6)
	CMPI	#9,D6
	BEQ.S	L481
	PEA	G017_auc_G(A4)
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	3(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE.B	2(A0),D0
	AND	#255,D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE.L	G074_puc_B(A4),A3
L481:
	BRA	L21T115_200(PC)
L480:
	CMPI	#50,D4
	BNE.S	L482
	CMPI	#4,D6
	BLT.S	L483
	MOVE.L	-146(A6),-150(A6)
L483:
	BRA	L467(PC)
L482:
	MOVE	#1,D4
L479:
L477:
L474:
	CMPI	#12,D6
	BNE	L484(PC)
	MOVE	-162(A6),D0
	BEQ.S	L485
	SUBQ	#1,D4
L485:
	MOVE	D4,D0
	MULS	#3,D0
	MOVE	D0,D4
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D5
	AND	#-256,D5
	LSR	#8,D5
	LSR	#5,D5
	BEQ.S	L486
	ADDQ	#1,D4
	CMPI	#3,D5
	BLE.S	L487
	ADDQ	#1,D4
L487:
L486:
	CLR	-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D4,D0
	ADD	#351,D0
	MOVE	D0,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	-162(A6),D0
	BEQ.S	L488
	PEA	G212_auc_G(A4)
	MOVE	#32,-(A7)
	MOVE	#48,-(A7)
	MOVE	#32,-(A7)
	MOVE	#48,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE.L	G074_puc_B(A4),A3
L488:
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#138,-(A7)
	MOVE	#112,-(A7)
	JSR	F027_AA59_(PC)
	AND	#63,D0
	MOVE	D0,-(A7)
	JSR	F029_AA19_(PC)
	ADD	#87,D0
	MOVE	D0,-(A7)
	PEA	G105_s_Gra(A4)
	CLR	-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	CLR.L	-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F133_xxxx_(PC)
	ADDA	#32,A7
	CLR	-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32768,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
	BRA	L489(PC)
L484:
	MOVE	-160(A6),D0
	BEQ.S	L490
	MOVE	D6,D0
	MULS	#6,D0
	LEA	G227_aai_G+-18(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
	MOVE.L	-154(A6),A0
	MOVE	4(A0),-156(A6)
	BRA	L491(PC)
L490:
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D0
	AND	#128,D0
	LSR	#7,D0
	BEQ.S	L492
	MOVE	D6,D0
	ASL.L	#2,D0
	LEA	G225_aai_G(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
	BRA.S	L493
L492:
	MOVE	D5,D0
	CMP	10(A6),D0
	BEQ.S	L495
	MOVE	D5,D0
	MOVE	10(A6),D1
	SUBQ	#1,D1
	AND	#3,D1
	CMP	D1,D0
	BNE.S	L494
L495:
	CLR	D5
	BRA.S	L496
L494:
	MOVE	#1,D5
L496:
	MOVE	D5,D0
	MOVE	D6,D1
	EXT.L	D1
	ASL.L	#3,D1
	LEA	G226_aaai_(A4),A0
	ADD.L	A0,D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-154(A6)
L493:
	MOVE.L	-146(A6),A0
	MOVE	2(A0),D0
	AND	#-256,D0
	LSR	#8,D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#48,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	-46(A6),D1
	LEA	G216_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULS	D1,D0
	ASR	#8,D0
	MOVE	D0,-(A7)
	MOVE	#4,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	AND	#-2,D0
	MOVE	D0,-156(A6)
L491:
	PEA	-24(A6)
	PEA	-22(A6)
	MOVE	-156(A6),-(A7)
	MOVE	D4,-(A7)
	JSR	F114_xxxx_(PC)
	ADDA	#12,A7
	MOVE.L	D0,A3
L21T115_200:
	JSR	F028_a000_(PC)
	MOVE	D0,-142(A6)
	CLR	-30(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,-36(A6)
	BEQ.S	L497
	MOVE	#7,D0
	MOVE	-22(A6),D1
	SUBQ	#1,D1
	AND	#7,D1
	SUB	D1,D0
	ASL	#1,D0
	MOVE	D0,-30(A6)
L497:
	MOVE.L	-154(A6),A0
	MOVE	2(A0),D0
	MOVE	-24(A6),D1
	ASR	#1,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#135,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,-39(A6)
	MOVE.L	-154(A6),A0
	MOVE	2(A0),D0
	MOVE	-24(A6),D1
	ASR	#1,D1
	SUB	D1,D0
	MOVE	-24(A6),D1
	AND	#1,D1
	SEQ	D1
	AND	#1,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#136,D4
	BLT.S	L498
	BRA	L467(PC)
L498:
	MOVE	D4,D0
	MOVE.B	D0,-40(A6)
	MOVE.L	-154(A6),A0
	MOVE	(A0),D0
	ADD	-22(A6),D0
	MOVE	D0,-(A7)
	MOVE	#223,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#0,D0
	BGE.S	L499
	BRA	L467(PC)
L499:
	MOVE	D4,D0
	MOVE.B	D0,-41(A6)
	MOVE.L	-154(A6),A0
	MOVE	(A0),D4
	MOVE	#223,-(A7)
	MOVE	D4,D0
	SUB	-22(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,-42(A6)
	BEQ.S	L500
	MOVE	-30(A6),D4
	BRA.S	L501
L500:
	MOVE	-22(A6),D0
	SUB	D4,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	-30(A6),-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L501:
	MOVE.B	-41(A6),D0
	MOVE.B	-42(A6),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGT.S	L502
	BRA	L467(PC)
L502:
	MOVE	-22(A6),D0
	ADDQ	#7,D0
	AND	#-8,D0
	MOVE	D0,-22(A6)
	MOVE	-36(A6),D0
	BNE.S	L504
	MOVE	-142(A6),D0
	BEQ.S	L503
L504:
	MOVE	-22(A6),D0
	MULS	-24(A6),D0
	MOVE	D0,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE.L	G074_puc_B(A4),A3
L503:
	MOVE	-36(A6),D0
	BEQ.S	L505
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L505:
	MOVE	-142(A6),D0
	BEQ.S	L506
	MOVE	-24(A6),-(A7)
	MOVE	-22(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F131_xxxx_(PC)
	ADDQ.L	#8,A7
L506:
	MOVE	#10,-(A7)
	MOVE	#112,-(A7)
	MOVE	-22(A6),-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	PEA	-42(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L489:
L469:
L467:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE	L466(PC)
L468:
	CMPI.L	#0,-150(A6)
	BEQ.S	L507
	CMPI	#1,-110(A6)
	BEQ.S	L507
	MOVE	G077_B_DoN(A4),D0
	BNE.S	L507
	SUBQ	#3,D6
	MOVE	#8,-(A7)
	PEA	-170(A6)
	MOVE	D6,D0
	ASL.L	#3,D0
	LEA	G188_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	ADDQ.B	#1,-170(A6)
	MOVE	D6,D0
	ASL.L	#3,D0
	LEA	G163_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	PEA	-170(A6)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L507:
L266:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$265:	.EQU	#-190
F116_xxxx_:/* global */
	LINK	A6,L$508
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L510:
	CMP	#19,D0
	BEQ.S	L511
	BRA.S	L513
L511:
	MOVE	-6(A6),D0
	BEQ.S	L515
	PEA	G110_s_Gra(A4)
	MOVE	G079_ai_St+34(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L516
L515:
	PEA	G121_s_Gra(A4)
	MOVE	G079_ai_St+20(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L516:
	BRA	L22T116_015(PC)
	BRA.S	L514
L513:
	CMP	#0,D0
	BEQ.S	L514
	BRA.S	L517
L514:
	PEA	G163_as_Gr+8(A4)
	MOVE.L	G088_apuc_+48(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	CLR	-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#2,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L519
	CLR	D4
	BRA	L22T116_017(PC)
L519:
	BRA	L509(PC)
	BRA.S	L518
L517:
	CMP	#16,D0
	BEQ.S	L518
L520:
	CMP	#18,D0
	BEQ.S	L518
	BRA.S	L521
L518:
	MOVE	#801,D4
	BRA	L22T116_016(PC)
	BRA.S	L522
L521:
	CMP	#17,D0
	BEQ.S	L522
	BRA.S	L523
L522:
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G164_s_Gra(A4)
	MOVE.L	G088_apuc_+20(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G179_s_Gra(A4)
	CLR	-(A7)
	MOVE	#984,-(A7)
	PEA	G080_aai_D+8(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L22T116_017
	BRA.S	L524
L523:
	CMP	#2,D0
	BEQ.S	L524
	BRA.S	L525
L524:
	MOVE	-6(A6),D0
	BNE.S	L527
	PEA	G140_s_Gra(A4)
	MOVE	#49,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L527:
	BRA.S	L526
L525:
	CMP	#5,D0
	BEQ.S	L526
L528:
	CMP	#1,D0
	BEQ.S	L526
	BRA.S	L529
L526:
L22T116_015:
	MOVE	#13345,D4
L22T116_016:
	CLR	-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L22T116_017:
	MOVE	D4,-(A7)
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L529:
L530:
L512:
	CMPI	#5,-10(A6)
	BNE.S	L531
	MOVE	-6(A6),D0
	BEQ.S	L531
	PEA	G163_as_Gr+8(A4)
	PEA	G188_as_Gr+8(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L531:
L509:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$508:	.EQU	#-10
F117_xxxx_:/* global */
	LINK	A6,L$532
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L534:
	CMP	#19,D0
	BEQ.S	L535
	BRA.S	L537
L535:
	MOVE	-6(A6),D0
	BEQ.S	L539
	PEA	G112_s_Gra(A4)
	MOVE	G079_ai_St+34(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L540
L539:
	PEA	G123_s_Gra(A4)
	MOVE	G079_ai_St+20(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L540:
	BRA	L23T117_016(PC)
	BRA.S	L538
L537:
	CMP	#0,D0
	BEQ.S	L538
	BRA.S	L541
L538:
	PEA	G163_as_Gr+16(A4)
	MOVE.L	G088_apuc_+48(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#4,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L543
	CLR	D4
	BRA	L23T117_018(PC)
L543:
	BRA	L533(PC)
	BRA.S	L542
L541:
	CMP	#16,D0
	BEQ.S	L542
L544:
	CMP	#18,D0
	BEQ.S	L542
	BRA.S	L545
L542:
	MOVE	#1042,D4
	BRA	L23T117_017(PC)
	BRA.S	L546
L545:
	CMP	#17,D0
	BEQ.S	L546
	BRA	L547(PC)
L546:
	MOVE	#2,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#296,-(A7)
	MOVE	#2,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#704,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+20(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	PEA	G165_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F103_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L549
	CLR	-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L549:
	PEA	G181_s_Gra(A4)
	CLR	-(A7)
	MOVE	#984,-(A7)
	PEA	G080_aai_D+8(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#1081,D4
	BRA.S	L23T117_018
	BRA.S	L548
L547:
	CMP	#2,D0
	BEQ.S	L548
	BRA.S	L550
L548:
	MOVE	-6(A6),D0
	BNE.S	L552
	PEA	G142_s_Gra(A4)
	MOVE	#49,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L552:
	BRA.S	L551
L550:
	CMP	#5,D0
	BEQ.S	L551
L553:
	CMP	#1,D0
	BEQ.S	L551
	BRA.S	L554
L551:
L23T117_016:
	MOVE	#17170,D4
L23T117_017:
	MOVE	#2,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L23T117_018:
	MOVE	D4,-(A7)
	MOVE	#2,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L554:
L555:
L536:
	CMPI	#5,-10(A6)
	BNE.S	L556
	MOVE	-6(A6),D0
	BEQ.S	L556
	PEA	G163_as_Gr+16(A4)
	PEA	G188_as_Gr+16(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L556:
L533:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$532:	.EQU	#-10
F118_xxxx_:/* global */
	LINK	A6,L$557
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L559:
	CMP	#19,D0
	BEQ.S	L560
	BRA.S	L562
L560:
	MOVE	-6(A6),D0
	BEQ.S	L564
	PEA	G111_s_Gra(A4)
	MOVE	G079_ai_St+32(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L565
L564:
	PEA	G122_s_Gra(A4)
	MOVE	G079_ai_St+18(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L565:
	BRA	L24T118_027(PC)
	BRA.S	L563
L562:
	CMP	#0,D0
	BEQ.S	L563
	BRA.S	L566
L563:
	PEA	G163_as_Gr(A4)
	MOVE.L	G088_apuc_+48(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#3,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L568
	CLR	D4
	BRA	L24T118_028(PC)
L568:
	BRA	L558(PC)
	BRA.S	L567
L566:
	CMP	#17,D0
	BEQ.S	L567
	BRA	L569(PC)
L567:
	MOVE	#1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G166_s_Gra(A4)
	MOVE.L	G088_apuc_+16(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#704,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+16(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	PEA	G167_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F103_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L571
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L571:
	PEA	G180_s_Gra(A4)
	CLR	-(A7)
	MOVE	#984,-(A7)
	PEA	G080_aai_D+8(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L24T118_028
	BRA.S	L570
L569:
	CMP	#2,D0
	BEQ.S	L570
	BRA.S	L572
L570:
	MOVE	-6(A6),D0
	BNE.S	L574
	PEA	G141_s_Gra(A4)
	MOVE	#50,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L574:
	BRA.S	L573
L572:
	CMP	#1,D0
	BEQ.S	L573
	BRA.S	L575
L573:
L24T118_027:
	MOVE	#13345,D4
	MOVE	#1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L24T118_028:
	MOVE	D4,-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L575:
L576:
L561:
	CMPI	#5,-10(A6)
	BNE.S	L577
	MOVE	-6(A6),D0
	BEQ.S	L577
	PEA	G163_as_Gr(A4)
	PEA	G188_as_Gr(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L577:
L558:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$557:	.EQU	#-10
F119_xxxx_:/* global */
	LINK	A6,L$578
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L580:
	CMP	#19,D0
	BEQ.S	L581
	BRA.S	L583
L581:
	MOVE	-6(A6),D0
	BEQ.S	L585
	PEA	G113_s_Gra(A4)
	MOVE	G079_ai_St+30(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L586
L585:
	PEA	G124_s_Gra(A4)
	MOVE	G079_ai_St+16(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L586:
	BRA	L25T119_018(PC)
	BRA.S	L584
L583:
	CMP	#0,D0
	BEQ.S	L584
	BRA.S	L587
L584:
	PEA	G163_as_Gr+32(A4)
	MOVE.L	G088_apuc_+44(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#5,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#7,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L589
	CLR	D4
	BRA	L25T119_020(PC)
L589:
	BRA	L579(PC)
	BRA.S	L588
L587:
	CMP	#18,D0
	BEQ.S	L588
	BRA.S	L590
L588:
	PEA	G132_s_Gra(A4)
	MOVE	G079_ai_St+6(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L591
L590:
	CMP	#16,D0
	BEQ.S	L591
	BRA.S	L592
L591:
	MOVE	#834,D4
	BRA	L25T119_019(PC)
	BRA.S	L593
L592:
	CMP	#17,D0
	BEQ.S	L593
	BRA.S	L594
L593:
	MOVE	#3,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G173_s_Gra(A4)
	MOVE.L	G088_apuc_+28(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G182_s_Gra(A4)
	MOVE	#1,-(A7)
	MOVE	#1952,-(A7)
	PEA	G080_aai_D+4(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L25T119_020
	BRA.S	L595
L594:
	CMP	#2,D0
	BEQ.S	L595
	BRA.S	L596
L595:
	PEA	G143_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L598
	MOVE	#57,D0
	BRA.S	L599
L598:
	MOVE	#51,D0
L599:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L597
L596:
	CMP	#5,D0
	BEQ.S	L597
L600:
	CMP	#1,D0
	BEQ.S	L597
	BRA.S	L601
L597:
L25T119_018:
	MOVE	#13345,D4
L25T119_019:
	MOVE	#3,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
L25T119_020:
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G152_s_Gra(A4)
	MOVE	#63,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D4,-(A7)
	MOVE	#4,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L601:
L602:
L582:
	CMPI	#5,-10(A6)
	BNE.S	L603
	MOVE	-6(A6),D0
	BEQ.S	L603
	PEA	G163_as_Gr+32(A4)
	PEA	G188_as_Gr+32(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L603:
L579:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$578:	.EQU	#-10
F120_xxxx_:/* global */
	LINK	A6,L$604
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L606:
	CMP	#19,D0
	BEQ.S	L607
	BRA.S	L609
L607:
	MOVE	-6(A6),D0
	BEQ.S	L611
	PEA	G115_s_Gra(A4)
	MOVE	G079_ai_St+30(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L612
L611:
	PEA	G126_s_Gra(A4)
	MOVE	G079_ai_St+16(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L612:
	BRA	L26T120_027(PC)
	BRA.S	L610
L609:
	CMP	#0,D0
	BEQ.S	L610
	BRA.S	L613
L610:
	PEA	G163_as_Gr+40(A4)
	MOVE.L	G088_apuc_+44(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#6,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#9,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L615
	CLR	D4
	BRA	L26T120_029(PC)
L615:
	BRA	L605(PC)
	BRA.S	L614
L613:
	CMP	#18,D0
	BEQ.S	L614
	BRA.S	L616
L614:
	PEA	G133_s_Gra(A4)
	MOVE	G079_ai_St+6(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L617
L616:
	CMP	#16,D0
	BEQ.S	L617
	BRA.S	L618
L617:
	MOVE	#1073,D4
	BRA	L26T120_028(PC)
	BRA.S	L619
L618:
	CMP	#17,D0
	BEQ.S	L619
	BRA.S	L620
L619:
	MOVE	#5,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#296,-(A7)
	MOVE	#5,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G175_s_Gra(A4)
	MOVE.L	G088_apuc_+28(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G184_s_Gra(A4)
	MOVE	#1,-(A7)
	MOVE	#1952,-(A7)
	PEA	G080_aai_D+4(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#1081,D4
	BRA.S	L26T120_029
	BRA.S	L621
L620:
	CMP	#2,D0
	BEQ.S	L621
	BRA.S	L622
L621:
	PEA	G145_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L624
	MOVE	#57,D0
	BRA.S	L625
L624:
	MOVE	#51,D0
L625:
	MOVE	D0,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L623
L622:
	CMP	#5,D0
	BEQ.S	L623
L626:
	CMP	#1,D0
	BEQ.S	L623
	BRA.S	L627
L623:
L26T120_027:
	MOVE	#17170,D4
L26T120_028:
	MOVE	#5,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G154_s_Gra(A4)
	MOVE	#63,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L26T120_029:
	MOVE	D4,-(A7)
	MOVE	#5,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L627:
L628:
L608:
	CMPI	#5,-10(A6)
	BNE.S	L629
	MOVE	-6(A6),D0
	BEQ.S	L629
	PEA	G163_as_Gr+40(A4)
	PEA	G188_as_Gr+40(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L629:
L605:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$604:	.EQU	#-10
F121_xxxx_:/* global */
	LINK	A6,L$630
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L632:
	CMP	#19,D0
	BEQ.S	L633
	BRA.S	L635
L633:
	MOVE	-6(A6),D0
	BEQ.S	L637
	PEA	G114_s_Gra(A4)
	MOVE	G079_ai_St+28(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L638
L637:
	PEA	G125_s_Gra(A4)
	MOVE	G079_ai_St+14(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L638:
	BRA	L27T121_015(PC)
	BRA.S	L636
L635:
	CMP	#0,D0
	BEQ.S	L636
	BRA.S	L639
L636:
	PEA	G163_as_Gr+24(A4)
	MOVE.L	G088_apuc_+44(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#8,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L641
	CLR	D4
	BRA	L27T121_016(PC)
L641:
	BRA	L631(PC)
	BRA.S	L640
L639:
	CMP	#17,D0
	BEQ.S	L640
	BRA	L642(PC)
L640:
	MOVE	#4,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#3,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G174_s_Gra(A4)
	MOVE.L	G088_apuc_+28(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G168_s_Gra(A4)
	MOVE.L	G088_apuc_+12(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#1560,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+12(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	PEA	G169_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F103_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L644
	MOVE	#2,-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L644:
	PEA	G183_s_Gra(A4)
	MOVE	#1,-(A7)
	MOVE	#1952,-(A7)
	PEA	G080_aai_D+4(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L27T121_016
	BRA.S	L643
L642:
	CMP	#2,D0
	BEQ.S	L643
	BRA.S	L645
L643:
	PEA	G144_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L647
	MOVE	#58,D0
	BRA.S	L648
L647:
	MOVE	#52,D0
L648:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L646
L645:
	CMP	#5,D0
	BEQ.S	L646
L649:
	CMP	#1,D0
	BEQ.S	L646
	BRA.S	L650
L646:
L27T121_015:
	MOVE	#13345,D4
	MOVE	#4,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G153_s_Gra(A4)
	MOVE	#64,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L27T121_016:
	MOVE	D4,-(A7)
	MOVE	#3,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L650:
L651:
L634:
	CMPI	#5,-10(A6)
	BNE.S	L652
	MOVE	-6(A6),D0
	BEQ.S	L652
	PEA	-10(A6)
	PEA	G163_as_Gr+24(A4)
	PEA	G188_as_Gr+24(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L652:
L631:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$630:	.EQU	#-10
F122_xxxx_:/* global */
	LINK	A6,L$653
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L655:
	CMP	#19,D0
	BEQ.S	L656
	BRA.S	L658
L656:
	MOVE	-6(A6),D0
	BEQ.S	L660
	PEA	G116_s_Gra(A4)
	MOVE	G079_ai_St+26(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L661
L660:
	PEA	G127_s_Gra(A4)
	MOVE	G079_ai_St+12(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L661:
	BRA	L28T122_019(PC)
	BRA.S	L659
L658:
	CMP	#0,D0
	BEQ.S	L659
	BRA.S	L662
L659:
	PEA	G163_as_Gr+56(A4)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#10,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L654(PC)
	BRA.S	L663
L662:
	CMP	#18,D0
	BEQ.S	L663
	BRA.S	L664
L663:
	MOVE	-6(A6),D0
	BEQ.S	L666
	PEA	G134_s_Gra(A4)
	MOVE	G079_ai_St+4(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L667
L666:
	PEA	G136_s_Gra(A4)
	MOVE	G079_ai_St+2(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L667:
	BRA.S	L665
L664:
	CMP	#16,D0
	BEQ.S	L665
	BRA.S	L668
L665:
	MOVE	#50,D4
	BRA	L28T122_020(PC)
	BRA.S	L669
L668:
	CMP	#17,D0
	BEQ.S	L669
	BRA.S	L670
L669:
	MOVE	#6,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#40,-(A7)
	MOVE	#7,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G176_s_Gra(A4)
	MOVE.L	G088_apuc_+24(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G185_s_Gra(A4)
	MOVE	#2,-(A7)
	MOVE	#4224,-(A7)
	PEA	G080_aai_D(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#57,D4
	BRA.S	L28T122_021
	BRA.S	L671
L670:
	CMP	#2,D0
	BEQ.S	L671
	BRA.S	L672
L671:
	PEA	G146_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L674
	MOVE	#59,D0
	BRA.S	L675
L674:
	MOVE	#53,D0
L675:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L673
L672:
	CMP	#5,D0
	BEQ.S	L673
L676:
	CMP	#1,D0
	BEQ.S	L673
	BRA.S	L677
L673:
L28T122_019:
	MOVE	#50,D4
L28T122_020:
	MOVE	#6,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G155_s_Gra(A4)
	MOVE	#65,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L28T122_021:
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L677:
L678:
L657:
	CMPI	#5,-10(A6)
	BNE.S	L679
	MOVE	-6(A6),D0
	BEQ.S	L679
	PEA	-10(A6)
	PEA	G163_as_Gr+56(A4)
	PEA	G188_as_Gr+56(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L679:
L654:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$653:	.EQU	#-10
F123_xxxx_:/* global */
	LINK	A6,L$680
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L682:
	CMP	#19,D0
	BEQ.S	L683
	BRA.S	L685
L683:
	MOVE	-6(A6),D0
	BEQ.S	L687
	PEA	G118_s_Gra(A4)
	MOVE	G079_ai_St+26(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L688
L687:
	PEA	G129_s_Gra(A4)
	MOVE	G079_ai_St+12(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L688:
	BRA	L29T123_019(PC)
	BRA.S	L686
L685:
	CMP	#0,D0
	BEQ.S	L686
	BRA.S	L689
L686:
	PEA	G163_as_Gr+64(A4)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#11,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L681(PC)
	BRA.S	L690
L689:
	CMP	#18,D0
	BEQ.S	L690
	BRA.S	L691
L690:
	MOVE	-6(A6),D0
	BEQ.S	L693
	PEA	G135_s_Gra(A4)
	MOVE	G079_ai_St+4(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L694
L693:
	PEA	G137_s_Gra(A4)
	MOVE	G079_ai_St+2(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L694:
	BRA.S	L692
L691:
	CMP	#16,D0
	BEQ.S	L692
	BRA.S	L695
L692:
	MOVE	#65,D4
	BRA	L29T123_020(PC)
	BRA.S	L696
L695:
	CMP	#17,D0
	BEQ.S	L696
	BRA.S	L697
L696:
	MOVE	#8,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#24,-(A7)
	MOVE	#8,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G178_s_Gra(A4)
	MOVE.L	G088_apuc_+24(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G187_s_Gra(A4)
	MOVE	#2,-(A7)
	MOVE	#4224,-(A7)
	PEA	G080_aai_D(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#73,D4
	BRA.S	L29T123_021
	BRA.S	L698
L697:
	CMP	#2,D0
	BEQ.S	L698
	BRA.S	L699
L698:
	PEA	G148_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L701
	MOVE	#59,D0
	BRA.S	L702
L701:
	MOVE	#53,D0
L702:
	MOVE	D0,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L700
L699:
	CMP	#5,D0
	BEQ.S	L700
L703:
	CMP	#1,D0
	BEQ.S	L700
	BRA.S	L704
L700:
L29T123_019:
	MOVE	#65,D4
L29T123_020:
	MOVE	#8,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G157_s_Gra(A4)
	MOVE	#65,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L29T123_021:
	MOVE	D4,-(A7)
	MOVE	#8,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L704:
L705:
L684:
	CMPI	#5,-10(A6)
	BNE.S	L706
	MOVE	-6(A6),D0
	BEQ.S	L706
	PEA	-10(A6)
	PEA	G163_as_Gr+64(A4)
	PEA	G188_as_Gr+64(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L706:
L681:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$680:	.EQU	#-10
F124_xxxx_:/* global */
	LINK	A6,L$707
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
	MOVE	D0,G285_i_Squ(A4)
L709:
	CMP	#19,D0
	BEQ.S	L710
	BRA.S	L712
L710:
	MOVE	-6(A6),D0
	BEQ.S	L714
	PEA	G117_s_Gra(A4)
	MOVE	G079_ai_St+24(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L715
L714:
	PEA	G128_s_Gra(A4)
	MOVE	G079_ai_St+10(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L715:
	BRA	L30T124_017(PC)
	BRA.S	L713
L712:
	CMP	#0,D0
	BEQ.S	L713
	BRA	L716(PC)
L713:
	CLR	G286_B_Fac(A4)
	CLR	G287_B_Fac(A4)
	CLR	G288_B_Fac(A4)
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ	L718(PC)
	MOVE	#1,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	MOVE	#112,-(A7)
	MOVE.B	G106_s_Gra+2(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	G106_s_Gra(A4),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	PEA	G107_s_Gra(A4)
	MOVE	#1,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#41,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-14(A6)
	MOVE	#10,-(A7)
	MOVE	#48,-(A7)
	MOVE	#48,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G107_s_Gra(A4)
	MOVE	#1,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE.L	-14(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L718:
	PEA	G163_as_Gr+48(A4)
	MOVE.L	G088_apuc_+40(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#12,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F107_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L719
	CLR	-(A7)
	MOVE	#6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L719:
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ.S	L720
	MOVE	#9,-(A7)
	MOVE	#112,-(A7)
	MOVE	#48,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	G106_s_Gra(A4)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE	#1,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE	#1,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32767,-(A7)
	JSR	F480_AA07_(PC)
	ADDQ.L	#2,A7
L720:
	BRA	L708(PC)
	BRA.S	L717
L716:
	CMP	#17,D0
	BEQ.S	L717
	BRA	L721(PC)
L717:
	MOVE	#7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#536,-(A7)
	MOVE	#6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	PEA	G177_s_Gra(A4)
	MOVE.L	G088_apuc_+24(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G170_s_Gra(A4)
	MOVE.L	G088_apuc_+8(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	PEA	G171_s_Gra(A4)
	MOVE.L	G088_apuc_(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	-4(A6),D0
	MOVE.L	G284_apuc_(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L723
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	JSR	F110_xxxx_(PC)
	ADDQ.L	#4,A7
L723:
	PEA	G186_s_Gra(A4)
	MOVE	#2,-(A7)
	MOVE	#4224,-(A7)
	PEA	G080_aai_D(A4)
	MOVE	-6(A6),-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F111_xxxx_(PC)
	ADDA	#16,A7
	MOVE	#841,D4
	BRA.S	L30T124_018
	BRA.S	L722
L721:
	CMP	#2,D0
	BEQ.S	L722
	BRA.S	L724
L722:
	PEA	G147_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L726
	MOVE	#60,D0
	BRA.S	L727
L726:
	MOVE	#54,D0
L727:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L725
L724:
	CMP	#5,D0
	BEQ.S	L725
L728:
	CMP	#1,D0
	BEQ.S	L725
	BRA.S	L729
L725:
L30T124_017:
	MOVE	#13345,D4
	MOVE	#7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F108_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G156_s_Gra(A4)
	MOVE	#66,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
L30T124_018:
	MOVE	D4,-(A7)
	MOVE	#6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
L729:
L730:
L711:
	CMPI	#5,-10(A6)
	BNE.S	L731
	MOVE	-6(A6),D0
	BEQ.S	L731
	PEA	-10(A6)
	PEA	G163_as_Gr+48(A4)
	PEA	G188_as_Gr+48(A4)
	JSR	F113_xxxx_(PC)
	ADDA	#12,A7
L731:
L708:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$707:	.EQU	#-14
F125_xxxx_:/* global */
	LINK	A6,L$732
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L734:
	CMP	#18,D0
	BEQ.S	L735
	BRA.S	L737
L735:
	PEA	G138_s_Gra(A4)
	MOVE	G079_ai_St(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA	L733(PC)
	BRA.S	L738
L737:
	CMP	#2,D0
	BEQ.S	L738
	BRA.S	L739
L738:
	PEA	G149_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L741
	MOVE	#61,D0
	BRA.S	L742
L741:
	MOVE	#55,D0
L742:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L740
L739:
	CMP	#1,D0
	BEQ.S	L740
L743:
	CMP	#16,D0
	BEQ.S	L740
L744:
	CMP	#5,D0
	BEQ.S	L740
	BRA.S	L745
L740:
	MOVE	#2,-(A7)
	MOVE	#10,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L736
	BRA.S	L746
L745:
	CMP	#0,D0
	BEQ.S	L746
	BRA.S	L747
L746:
	PEA	G163_as_Gr+80(A4)
	MOVE.L	G088_apuc_+36(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L733
L747:
L748:
L736:
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G158_s_Gra(A4)
	MOVE	#67,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	CMPI	#5,-10(A6)
	BNE.S	L749
	MOVE	-6(A6),D0
	BEQ.S	L749
	PEA	G163_as_Gr+80(A4)
	PEA	G188_as_Gr+80(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L749:
L733:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$732:	.EQU	#-10
F126_xxxx_:/* global */
	LINK	A6,L$750
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L752:
	CMP	#18,D0
	BEQ.S	L753
	BRA.S	L755
L753:
	PEA	G139_s_Gra(A4)
	MOVE	G079_ai_St(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA	L751(PC)
	BRA.S	L756
L755:
	CMP	#2,D0
	BEQ.S	L756
	BRA.S	L757
L756:
	PEA	G151_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L759
	MOVE	#61,D0
	BRA.S	L760
L759:
	MOVE	#55,D0
L760:
	MOVE	D0,-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L758
L757:
	CMP	#1,D0
	BEQ.S	L758
L761:
	CMP	#16,D0
	BEQ.S	L758
L762:
	CMP	#5,D0
	BEQ.S	L758
	BRA.S	L763
L758:
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G160_s_Gra(A4)
	MOVE	#67,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#1,-(A7)
	MOVE	#11,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L754
	BRA.S	L764
L763:
	CMP	#0,D0
	BEQ.S	L764
	BRA.S	L765
L764:
	PEA	G163_as_Gr+88(A4)
	MOVE.L	G088_apuc_+32(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L751
L765:
L766:
L754:
	CMPI	#5,-10(A6)
	BNE.S	L767
	MOVE	-6(A6),D0
	BEQ.S	L767
	PEA	G163_as_Gr+88(A4)
	PEA	G188_as_Gr+88(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L767:
L751:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$750:	.EQU	#-10
F127_xxxx_:/* global */
	LINK	A6,L$768
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	PEA	-10(A6)
	JSR	F172_awzz_(PC)
	ADDA	#10,A7
	MOVE	-10(A6),D0
L770:
	CMP	#16,D0
	BEQ.S	L771
	BRA.S	L773
L771:
	MOVE.B	G407_s_Par+3202(A4),D0
	BEQ.S	L775
	MOVE	#1968,-(A7)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE.L	G088_apuc_+4(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#9,-(A7)
	MOVE	#16,-(A7)
	MOVE	#48,-(A7)
	CLR	-(A7)
	MOVE.B	G172_s_Gra(A4),D0
	AND	#255,D0
	MOVE.B	G106_s_Gra(A4),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,-(A7)
	PEA	G108_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	MOVE	#41,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	PEA	G172_s_Gra(A4)
	MOVE.L	G074_puc_B(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L776
L775:
	PEA	G172_s_Gra(A4)
	MOVE.L	G088_apuc_+4(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
L776:
	BRA.S	L772
	BRA.S	L774
L773:
	CMP	#19,D0
	BEQ.S	L774
	BRA.S	L777
L774:
	MOVE	-6(A6),D0
	BEQ.S	L779
	PEA	G119_s_Gra(A4)
	MOVE	G079_ai_St+22(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	PEA	G120_s_Gra(A4)
	MOVE	G079_ai_St+22(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L780
L779:
	PEA	G130_s_Gra(A4)
	MOVE	G079_ai_St+8(A4),-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
	PEA	G131_s_Gra(A4)
	MOVE	G079_ai_St+8(A4),-(A7)
	JSR	F105_xxxx_(PC)
	ADDQ.L	#6,A7
L780:
	BRA.S	L772
	BRA.S	L778
L777:
	CMP	#2,D0
	BEQ.S	L778
	BRA.S	L781
L778:
	PEA	G150_s_Gra(A4)
	MOVE	-6(A6),D0
	BEQ.S	L783
	MOVE	#62,D0
	BRA.S	L784
L783:
	MOVE	#56,D0
L784:
	MOVE	D0,-(A7)
	JSR	F104_xxxx_(PC)
	ADDQ.L	#6,A7
L781:
L782:
L772:
	CLR	-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	PEA	G159_s_Gra(A4)
	MOVE	#68,-(A7)
	JSR	F112_xxxx_(PC)
	ADDA	#12,A7
	MOVE	#33,-(A7)
	MOVE	#9,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	CMPI	#5,-10(A6)
	BNE.S	L785
	MOVE	-6(A6),D0
	BEQ.S	L785
	PEA	G163_as_Gr+72(A4)
	PEA	G188_as_Gr+72(A4)
	JSR	F113_xxxx_(PC)
	ADDQ.L	#8,A7
L785:
L769:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$768:	.EQU	#-10
F128_rzzz_:/* global */
	LINK	A6,L$786
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	CLR	D4
	MOVE	G297_B_Dra(A4),D0
	BEQ.S	L788
	JSR	F098_rzzz_(PC)
L788:
	MOVE	#1,G578_B_Use(A4)
	MOVE	#24,-(A7)
	PEA	G291_aauc_(A4)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#4,-(A7)
	MOVE	#255,-(A7)
	MOVE	#6,-(A7)
	PEA	G291_aauc_(A4)
	JSR	F009_aA49_(PC)
	ADDA	#10,A7
	CLR	-(A7)
	MOVE.L	#8880,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,G074_puc_B(A4)
	MOVE	D6,D0
	ADD	D5,D0
	ADD	D7,D0
	AND	#1,D0
	MOVE	D0,G076_B_Use(A4)
	BEQ.S	L789
	MOVE	#70,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G087_puc_B(A4),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	G661_B_Lar(A4),D4
	BEQ.S	L790
	MOVE.L	G090_puc_B(A4),G088_apuc_+48(A4)
	MOVE.L	G091_puc_B(A4),G088_apuc_+44(A4)
	MOVE.L	G092_puc_B(A4),G088_apuc_+40(A4)
	MOVE.L	G093_puc_B(A4),G088_apuc_+36(A4)
	MOVE.L	G094_puc_B(A4),G088_apuc_+32(A4)
L790:
	BRA.S	L791
L789:
	MOVE	#29,-(A7)
	MOVE	#112,-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F130_xxxx_(PC)
	ADDQ.L	#8,A7
L791:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	#-2,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F153_yzzz_(PC)
	ADDA	#10,A7
	CMPI	#0,D0
	BNE.S	L792
	PEA	G163_as_Gr+104(A4)
	MOVE.L	G088_apuc_+52(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
L792:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	#2,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F153_yzzz_(PC)
	ADDA	#10,A7
	CMPI	#0,D0
	BNE.S	L793
	PEA	G163_as_Gr+96(A4)
	MOVE.L	G088_apuc_+56(A4),-(A7)
	JSR	F100_xxxx_(PC)
	ADDQ.L	#8,A7
L793:
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#4,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	MOVE	#-2,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#4,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	MOVE	#-1,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	MOVE	#-3,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F115_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F116_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F117_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F118_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F119_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F120_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F121_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F122_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F123_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F124_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#-1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F125_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,-2(A6)
	MOVE	D5,-4(A6)
	PEA	-4(A6)
	PEA	-2(A6)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F150_wzzz_(PC)
	ADDA	#14,A7
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F126_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F127_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D4,D0
	BEQ.S	L794
	MOVE.L	G095_puc_B(A4),G088_apuc_+48(A4)
	MOVE.L	G096_puc_B(A4),G088_apuc_+44(A4)
	MOVE.L	G097_puc_B(A4),G088_apuc_+40(A4)
	MOVE.L	G098_puc_B(A4),G088_apuc_+36(A4)
	MOVE.L	G099_puc_B(A4),G088_apuc_+32(A4)
L794:
	MOVE.L	#8880,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#255,G309_i_Par(A4)
	SNE	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#255,G309_i_Par(A4)
	BEQ.S	L795
	JSR	F098_rzzz_(PC)
L795:
L787:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$786:	.EQU	#-4
