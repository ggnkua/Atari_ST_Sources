CODE SEG "init!"
	MOVE	#-1,G403_i_Sen(A4)
BSS SEG "bss"
G403_i_Sen:/* global */
	.WORD	#2
G404_i_Sen:/* global */
	.WORD	#2
G405_i_Sen:/* global */
	.WORD	#2
G406_i_Sen:/* global */
	.WORD	#2
CODE SEG "timeline"
F268_fzzz_:/* global */
	LINK	A6,L$0
	MOVE.L	18(A6),D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE.B	9(A6),-6(A6)
	CLR.B	-5(A6)
	MOVE.B	11(A6),-4(A6)
	MOVE.B	13(A6),-3(A6)
	MOVE.B	15(A6),-2(A6)
	MOVE.B	17(A6),-1(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#-10
F269_xxxx_:/* global */
	LINK	A6,L$2
	MOVEM.L	A3/D7,-(A7)
	MOVE	12(A6),D0
	BEQ.S	L4
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L5
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L5:
	BRA.S	L3
L4:
	MOVE	10(A6),D0
	AND.L	#65535,D0
	DIVU	G305_ui_Pa(A4),D0
	MOVE	D0,10(A6)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L6
L7:
	MOVE	52(A3),D0
	BEQ.S	L10
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L10:
L8:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L6:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L7
L9:
L3:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$2:	.EQU	#0
F270_xxxx_:/* global */
	LINK	A6,L$11
	CMPI	#10,8(A6)
	BNE.S	L13
	CMPI	#-1,14(A6)
	SNE	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	#300,-(A7)
	MOVE	#8,-(A7)
	JSR	F269_xxxx_(PC)
	ADDQ.L	#6,A7
	BRA.S	L14
L13:
	MOVE	8(A6),G403_i_Sen(A4)
	MOVE	10(A6),G404_i_Sen(A4)
	MOVE	12(A6),G405_i_Sen(A4)
	MOVE	14(A6),G406_i_Sen(A4)
L14:
L12:
	UNLK	A6
	RTS
L$11:	.EQU	#0
F271_xxxx_:/* global */
	LINK	A6,L$15
	MOVEM.L	A3-A2/D7-D6,-(A7)
	CMPI	#-1,G403_i_Sen(A4)
	BNE.S	L17
	BRA	L16(PC)
L17:
	MOVE	G403_i_Sen(A4),D0
L18:
	CMP	#1,D0
	BEQ.S	L19
L21:
	CMP	#2,D0
	BEQ.S	L19
	BRA	L22(PC)
L19:
	MOVE	G405_i_Sen(A4),-(A7)
	MOVE	G404_i_Sen(A4),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L24
L25:
L26:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L24:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L25
	CMPI	#-1,G406_i_Sen(A4)
	BEQ.S	L28
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	G406_i_Sen(A4),D1
	CMP	D1,D0
	BNE.S	L25
L28:
L27:
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	(A3),D6
	BRA.S	L29
L30:
L31:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L29:
	CMPI	#-2,D6
	BEQ.S	L33
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L30
	CMPI	#-1,G406_i_Sen(A4)
	BEQ.S	L34
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	G406_i_Sen(A4),D1
	CMP	D1,D0
	BNE.S	L30
L34:
L33:
L32:
	CMPI	#-2,D6
	BNE.S	L35
	BRA.S	L20
L35:
	MOVE	G405_i_Sen(A4),-(A7)
	MOVE	G404_i_Sen(A4),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	BRA.S	L36
L37:
	CMPI	#-1,G406_i_Sen(A4)
	BEQ.S	L41
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	G406_i_Sen(A4),D1
	CMP	D1,D0
	BNE.S	L40
L41:
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
L40:
L38:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L36:
	CMPI	#-2,D6
	BEQ.S	L42
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BEQ.S	L37
L42:
L39:
	MOVE	(A2),(A3)
	MOVE	D7,(A2)
L22:
L23:
L20:
	MOVE	#-1,G403_i_Sen(A4)
L16:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$15:	.EQU	#0
F272_xxxx_:/* global */
	LINK	A6,L$43
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	4(A3),D0
	AND	#4,D0
	LSR	#2,D0
	BEQ.S	L45
	ANDI	#-128,2(A3)
L45:
	MOVE.L	G313_ul_Ga(A4),D5
	MOVE	4(A3),D1
	AND	#1920,D1
	LSR	#7,D1
	AND.L	#65535,D1
	ADD.L	D1,D5
	MOVE	4(A3),D0
	AND	#2048,D0
	LSR	#3,D0
	LSR	#8,D0
	BEQ.S	L46
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	6(A3),D0
	AND	#-16,D0
	LSR	#4,D0
	MOVE	D0,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
	BRA.S	L47
L46:
	MOVE	6(A3),D7
	AND	#1984,D7
	LSR	#6,D7
	MOVE	6(A3),D6
	AND	#-2048,D6
	LSR	#3,D6
	LSR	#8,D6
	MOVE	D7,D4
	ASL.L	#2,D4
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D4,A0
	MOVE.L	(A0),A0
	ADDA	D6,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	ASR	#5,D4
	CMPI	#0,D4
	BNE.S	L48
	MOVE	6(A3),D0
	AND	#48,D0
	LSR	#4,D0
	MOVE	D0,-2(A6)
	BRA.S	L49
L48:
	CLR	-2(A6)
L49:
	MOVE.L	D5,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,D0
	LEA	G059_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F268_fzzz_(PC)
	ADDA	#14,A7
L47:
L44:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$43:	.EQU	#-2
F273_xxxx_:/* global */
	LINK	A6,L$50
	MOVEM.L	D7-D5,-(A7)
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	BRA.S	L52
L53:
	MOVE	D5,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	D6,D0
	BNE.S	L56
	CMPI	#-1,D7
	BEQ.S	L58
	MOVE	D5,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D7,D1
	CMP	D1,D0
	BNE.S	L57
L58:
	MOVE	D5,D0
	BRA.S	L51
L57:
L56:
L54:
	MOVE	D5,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
L52:
	CMPI	#-2,D5
	BNE.S	L53
L55:
	MOVE	#-1,D0
L51:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$50:	.EQU	#0
F274_xxxx_:/* global */
	LINK	A6,L$59
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	CLR	-4(A6)
	MOVE	#0,D0
	MOVE	D0,D6
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA	L61(PC)
L62:
	MOVE	52(A3),D0
	BEQ.S	L65
	LEA	212(A3),A0
	MOVE.L	A0,A2
	CLR	D5
	BRA.S	L66
L67:
	MOVE	(A2)+,D4
L6T274_003:
	MOVE	D4,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMP	D7,D0
	BNE.S	L70
	MOVE	#1,D0
	BRA.S	L60
L70:
	CMPI	#144,-2(A6)
	BNE.S	L71
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-8(A6)
	MOVE.L	-8(A6),A0
	MOVE	2(A0),D4
	BRA.S	L72
L73:
	MOVE	D4,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	D7,D0
	BNE.S	L76
	MOVE	#1,D0
	BRA.S	L60
L76:
L74:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L72:
	CMPI	#-2,D4
	BNE.S	L73
L75:
L71:
L68:
	ADDQ	#1,D5
L66:
	CMPI	#30,D5
	BCC.S	L77
	MOVE	-4(A6),D0
	BEQ.S	L67
L77:
L69:
L65:
L63:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	A3,D0
	ADDA	#800,A3
L61:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L62(PC)
L64:
	MOVE	-4(A6),D0
	BNE.S	L78
	MOVE	#1,-4(A6)
	MOVE	G414_T_Lea(A4),D4
	BRA	L6T274_003(PC)
L78:
	MOVE	#0,D0
L60:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$59:	.EQU	#-8
F275_aszz_:/* global */
	LINK	A6,L$79
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-8(A6)
	MOVE	G414_T_Lea(A4),-18(A6)
	CLR	D5
	BRA.S	L81
L82:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L83:
	ADDQ	#1,D5
L81:
	CMPI	#4,D5
	BCS.S	L82
L84:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	D0,-24(A6)
	BRA.S	L85
L86:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#3,D0
	BNE.S	L89
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	ADDQ	#1,(A0)
	BRA.S	L90
L89:
	CMPI	#4,D6
	BCS.S	L91
	BRA.S	L88
L91:
L90:
L87:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L85:
	CMPI	#-2,D7
	BNE.S	L86
L88:
	MOVE	-24(A6),D0
	MOVE	D0,D7
	MOVE	D0,-22(A6)
	BRA	L92(PC)
L93:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#3,D0
	BNE	L95(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,D5
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	SUBQ	#1,(A0)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	2(A2),D0
	AND	#127,D0
	MOVE	D0,-4(A6)
	CMPI	#0,D0
	BNE.S	L96
	BRA	L7T275_058_(PC)
L96:
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L97
	CMPI	#127,-4(A6)
	BEQ.S	L97
	BRA	L7T275_058_(PC)
L97:
	MOVE	D5,D0
	CMP	12(A6),D0
	BEQ.S	L98
	BRA	L7T275_058_(PC)
L98:
	MOVE	2(A2),D0
	LSR	#7,D0
	MOVE	D0,-6(A6)
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-2(A6)
	MOVE	-4(A6),D0
L99:
	CMP	#1,D0
	BEQ.S	L100
	BRA.S	L102
L100:
	CLR	D4
	MOVE	4(A2),D0
	AND	#24,D0
	LSR	#3,D0
	CMPI	#3,D0
	BNE.S	L104
	BRA	L7T275_058_(PC)
L104:
	BRA	L101(PC)
	BRA.S	L103
L102:
	CMP	#2,D0
	BEQ.S	L103
	BRA.S	L105
L103:
	MOVE	G415_B_Lea(A4),D4
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D4
	SNE	D4
	AND	#1,D4
	BRA	L101(PC)
	BRA.S	L106
L105:
	CMP	#17,D0
	BEQ.S	L106
L107:
	CMP	#11,D0
	BEQ.S	L106
	BRA.S	L108
L106:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BEQ.S	L110
	BRA	L7T275_058_(PC)
L110:
	BRA.S	L109
L108:
	CMP	#3,D0
	BEQ.S	L109
L111:
	CMP	#4,D0
	BEQ.S	L109
	BRA	L112(PC)
L109:
	MOVE	-18(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-38(A6)
	MOVE	-6(A6),D0
	CMP	-38(A6),D0
	SEQ	D0
	AND	#1,D0
	MOVE	4(A2),D1
	AND	#32,D1
	LSR	#5,D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,D4
	MOVE	D4,D0
	BNE.S	L114
	CMPI	#17,-4(A6)
	BNE.S	L114
	MOVE	-22(A6),D0
	CMP	D7,D0
	BNE.S	L115
	BRA	L101(PC)
L115:
	MOVE	-22(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-28(A6)
	MOVE.L	-28(A6),A0
	MOVE	(A2),(A0)
	MOVE	#-1,(A2)
	MOVE	-22(A6),D7
L114:
	MOVE	D4,D0
	BNE.S	L116
	CMPI	#11,-4(A6)
	BNE.S	L116
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#2,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
L116:
	BRA	L101(PC)
	BRA.S	L113
L112:
	CMP	#12,D0
	BEQ.S	L113
	BRA.S	L117
L113:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BEQ.S	L119
	BRA	L7T275_058_(PC)
L119:
	MOVE	G415_B_Lea(A4),D4
	SEQ	D4
	AND	#1,D4
	MOVE	D4,D0
	BNE.S	L120
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#2,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
L120:
	BRA	L101(PC)
	BRA.S	L118
L117:
	CMP	#13,D0
	BEQ.S	L118
	BRA	L121(PC)
L118:
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L123
	MOVE	-6(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F273_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,-18(A6)
	CMPI	#-1,D0
	BNE.S	L124
	BRA	L7T275_058_(PC)
L124:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L125
L123:
	MOVE	-18(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-6(A6),D0
	BNE.S	L127
	MOVE	-6(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F273_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#-1,D0
	BEQ.S	L126
L127:
	BRA	L7T275_058_(PC)
L126:
	JSR	F298_aqzz_(PC)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-18(A6),D0
	AND	#16383,D0
	MOVE	D5,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,-18(A6)
L125:
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#2,-(A7)
	JSR	F270_xxxx_(PC)
	ADDQ.L	#8,A7
	CMPI	#3,-2(A6)
	BNE.S	L128
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L128
	MOVE	#1,D4
	BRA.S	L129
L128:
	CLR	D4
L129:
	BRA	L101(PC)
	BRA.S	L122
L121:
	CMP	#16,D0
	BEQ.S	L122
	BRA	L130(PC)
L122:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	-16(A6),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BEQ.S	L132
	BRA	L7T275_058_(PC)
L132:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F162_afzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-20(A6)
	MOVE	-18(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-6(A6),D0
	BNE.S	L134
	CMPI	#-1,-20(A6)
	BNE.S	L133
L134:
	BRA	L7T275_058_(PC)
L133:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-20(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	JSR	F298_aqzz_(PC)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	-18(A6),D0
	AND	#16383,D0
	MOVE	D5,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#1,-(A7)
	MOVE	-20(A6),-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
	CLR	D4
	BRA.S	L101
	BRA.S	L131
L130:
	CMP	#127,D0
	BEQ.S	L131
	BRA.S	L135
L131:
	MOVE	-6(A6),-(A7)
	JSR	F280_agzz_(PC)
	ADDQ.L	#2,A7
	BRA	L7T275_058_(PC)
L136:
	BRA	L7T275_058_(PC)
	BRA.S	L137
L135:
	BRA.S	L136
L137:
L101:
	CMPI	#3,-2(A6)
	BNE.S	L138
	MOVE	D4,D0
	BEQ.S	L139
	MOVE	#1,D0
	BRA.S	L140
L139:
	MOVE	#0,D0
L140:
	MOVE	D0,-2(A6)
	CLR	D4
L138:
	MOVE	D4,D0
	BNE	L141(PC)
	MOVE	#1,-8(A6)
	MOVE	4(A2),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L142
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#1,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L142:
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L143
	CMPI	#4,-4(A6)
	BEQ.S	L144
	CMPI	#11,-4(A6)
	BEQ.S	L144
	CMPI	#17,-4(A6)
	BNE.S	L143
L144:
	MOVE	-18(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#-1,(A3)
	JSR	F298_aqzz_(PC)
	MOVE	#-1,-18(A6)
	BRA.S	L145
L143:
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L146
	CMPI	#12,-4(A6)
	BNE.S	L146
	MOVE	-6(A6),-(A7)
	JSR	F167_aozz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-18(A6)
	CMPI	#-1,D0
	BEQ.S	L146
	MOVE	#1,-(A7)
	MOVE	-18(A6),-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L146:
L145:
	MOVE	D5,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
L141:
	BRA.S	L7T275_058_
L95:
	CMPI	#4,D6
	BCS.S	L147
	BRA.S	L94
L147:
L7T275_058_:
	MOVE	D7,-22(A6)
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L92:
	CMPI	#-2,D7
	BNE	L93(PC)
L94:
	JSR	F271_xxxx_(PC)
	MOVE	-8(A6),D0
L80:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$79:	.EQU	#-38
F276_qzzz_:/* global */
	LINK	A6,L$148
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	14(A6),D7
	CMPI	#-1,12(A6)
	BEQ.S	L150
	MOVE	12(A6),D5
	AND	#15360,D5
	LSR	#2,D5
	LSR	#8,D5
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-10(A6)
	BRA.S	L151
L150:
	MOVE	#-1,D5
	MOVE	#-1,-10(A6)
L151:
	MOVE	16(A6),D0
	BNE.S	L152
	CMPI	#-1,D5
	BEQ.S	L152
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	12(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L152:
	MOVE	10(A6),D0
	MOVE	8(A6),D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-16(A6)
	LSR	#5,D0
	CMPI	#0,D0
	BNE.S	L153
	MOVE	12(A6),D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D0,-2(A6)
	BRA.S	L154
L153:
	MOVE	#-1,-2(A6)
L154:
	MOVE	#0,D0
	MOVE	D0,-14(A6)
	MOVE	D0,-12(A6)
	MOVE	D0,-8(A6)
	MOVE	D0,-6(A6)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	CMPI	#-1,-2(A6)
	BNE	L155(PC)
	BRA	L156(PC)
L157:
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-4(A6)
	CMPI	#4,D0
	BNE.S	L159
	MOVE	#1,-8(A6)
	BRA.S	L160
L159:
	CMPI	#2,-4(A6)
	BNE.S	L161
	CMPI	#-1,D5
	BNE.S	L161
	MOVE	16(A6),D0
	BEQ.S	L161
	MOVE	D7,D0
	BNE.S	L161
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	PEA	G353_ac_St(A4)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	#15,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L162
L161:
	CMPI	#4,-4(A6)
	BLS.S	L163
	CMPI	#14,-4(A6)
	BCC.S	L163
	MOVE	#1,-6(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SEQ	D0
	AND	#1,D0
	OR	D0,-12(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SNE	D0
	AND	#1,D0
	OR	D0,-14(A6)
L163:
L162:
L160:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L156:
	CMPI	#-2,D6
	BNE	L157(PC)
L158:
	BRA.S	L164
L155:
	BRA.S	L165
L166:
	MOVE	-2(A6),D0
	MOVE	D6,D1
	LSR	#6,D1
	LSR	#8,D1
	CMP	D1,D0
	BNE.S	L168
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#4,D0
	BLS.S	L168
	MOVE	#1,-6(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SEQ	D0
	AND	#1,D0
	OR	D0,-12(A6)
	MOVE	D6,-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	CMP	-10(A6),D0
	SNE	D0
	AND	#1,D0
	OR	D0,-14(A6)
L168:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L165:
	CMPI	#-2,D6
	BNE.S	L166
L167:
L164:
	MOVE	16(A6),D0
	BEQ.S	L169
	CMPI	#-1,D5
	BEQ.S	L169
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	CLR	-(A7)
	MOVE	12(A6),-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
L169:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA	L170(PC)
L171:
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-4(A6)
	CMPI	#3,D0
	BNE	L174(PC)
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	2(A3),D0
	AND	#127,D0
	CMPI	#0,D0
	BNE.S	L175
	BRA	L172(PC)
L175:
	MOVE	2(A3),D0
	LSR	#7,D0
	MOVE	D0,-20(A6)
	MOVE	16(A6),D4
	CMPI	#-1,-2(A6)
	BNE	L176(PC)
	MOVE	2(A3),D0
	AND	#127,D0
L177:
	CMP	#1,D0
	BEQ.S	L178
	BRA.S	L180
L178:
	MOVE	D7,D0
	BNE.S	L183
	MOVE	-6(A6),D0
	BNE.S	L183
	MOVE	-8(A6),D0
	BEQ.S	L182
L183:
	BRA	L172(PC)
L182:
	BRA	L179(PC)
	BRA.S	L181
L180:
	CMP	#2,D0
	BEQ.S	L181
	BRA.S	L184
L181:
	CMPI	#4,D5
	BGT.S	L187
	MOVE	D7,D0
	BNE.S	L187
	MOVE	-8(A6),D0
	BEQ.S	L186
L187:
	BRA	L172(PC)
L186:
	BRA	L179(PC)
	BRA.S	L185
L184:
	CMP	#3,D0
	BEQ.S	L185
	BRA.S	L188
L185:
	CMPI	#-1,D5
	BNE.S	L191
	CMPI	#0,G305_ui_Pa(A4)
	BNE.S	L190
L191:
	BRA	L172(PC)
L190:
	CMPI	#0,-20(A6)
	BNE.S	L192
	MOVE	D7,D0
	BEQ.S	L193
	BRA	L172(PC)
L193:
	BRA.S	L194
L192:
	MOVE	16(A6),D0
	BNE.S	L195
	CLR	D4
	BRA.S	L196
L195:
	MOVE	-20(A6),D4
	MOVE	G308_i_Par(A4),D1
	ADDQ	#1,D1
	CMP	D1,D4
	SEQ	D4
	AND	#1,D4
L196:
L194:
	BRA	L179(PC)
	BRA.S	L189
L188:
	CMP	#4,D0
	BEQ.S	L189
	BRA.S	L197
L189:
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-30(A6)
	MOVE	-20(A6),D0
	CMP	-30(A6),D0
	BNE.S	L200
	MOVE	-12(A6),D0
	BEQ.S	L199
L200:
	BRA	L172(PC)
L199:
	BRA	L179(PC)
	BRA.S	L198
L197:
	CMP	#5,D0
	BEQ.S	L198
	BRA.S	L201
L198:
	CMPI	#-1,-4(A6)
	BNE.S	L204
	MOVE	-16(A6),D0
	LSR	#5,D0
	CMPI	#3,D0
	BEQ.S	L203
L204:
	BRA	L172(PC)
L203:
	BRA	L179(PC)
	BRA.S	L202
L201:
	CMP	#6,D0
	BEQ.S	L202
	BRA.S	L205
L202:
	BRA	L172(PC)
	BRA.S	L206
L205:
	CMP	#7,D0
	BEQ.S	L206
	BRA.S	L207
L206:
	CMPI	#4,D5
	BGT.S	L210
	CMPI	#-1,D5
	BEQ.S	L210
	MOVE	-8(A6),D0
	BEQ.S	L209
L210:
	BRA	L172(PC)
L209:
	BRA.S	L179
	BRA.S	L208
L207:
	CMP	#8,D0
	BEQ.S	L208
	BRA.S	L211
L208:
	CMPI	#-1,D5
	BEQ.S	L213
	BRA	L172(PC)
L213:
	MOVE	-20(A6),-(A7)
	JSR	F274_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	BRA.S	L179
	BRA.S	L212
L211:
	CMP	#9,D0
	BEQ.S	L212
	BRA.S	L214
L212:
	CMPI	#-1,D5
	BNE.S	L217
	MOVE	16(A6),D0
	BEQ.S	L217
	MOVE	D7,D0
	BEQ.S	L216
L217:
	BRA	L172(PC)
L216:
	CMPI	#20,-20(A6)
	SLE	D4
	AND	#1,D4
	BRA.S	L179
L215:
	BRA	L172(PC)
	BRA.S	L218
L214:
	BRA.S	L215
L218:
L179:
	BRA	L219(PC)
L176:
	MOVE	-2(A6),D0
	MOVE	D6,D1
	LSR	#6,D1
	LSR	#8,D1
	CMP	D1,D0
	BEQ.S	L220
	BRA	L172(PC)
L220:
	MOVE	2(A3),D0
	AND	#127,D0
L221:
	CMP	#1,D0
	BEQ.S	L222
	BRA.S	L224
L222:
	MOVE	-6(A6),D0
	BEQ.S	L226
	BRA	L172(PC)
L226:
	BRA.S	L223
	BRA.S	L225
L224:
	CMP	#2,D0
	BEQ.S	L225
	BRA.S	L227
L225:
	MOVE	-12(A6),D0
	BNE.S	L230
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-40(A6)
	MOVE	2(A3),D0
	LSR	#7,D0
	CMP	-40(A6),D0
	BEQ.S	L229
L230:
	BRA	L172(PC)
L229:
	BRA.S	L223
	BRA.S	L228
L227:
	CMP	#3,D0
	BEQ.S	L228
	BRA.S	L231
L228:
	MOVE	-14(A6),D0
	BNE.S	L234
	MOVE	12(A6),-(A7)
	JSR	F032_aaaY_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-50(A6)
	MOVE	2(A3),D0
	LSR	#7,D0
	CMP	-50(A6),D0
	BNE.S	L233
L234:
	BRA	L172(PC)
L233:
	BRA.S	L223
L232:
	BRA	L172(PC)
	BRA.S	L235
L231:
	BRA.S	L232
L235:
L223:
L219:
	MOVE	4(A3),D0
	AND	#32,D0
	LSR	#5,D0
	EOR	D0,D4
	MOVE	4(A3),D0
	AND	#24,D0
	LSR	#3,D0
	MOVE	D0,-18(A6)
	CMPI	#3,D0
	BNE.S	L236
	MOVE	D4,D0
	BEQ.S	L237
	MOVE	#0,D0
	BRA.S	L238
L237:
	MOVE	#1,D0
L238:
	MOVE	D0,-18(A6)
	BRA.S	L239
L236:
	MOVE	D4,D0
	BNE.S	L240
	BRA.S	L172
L240:
L239:
	MOVE	4(A3),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L241
	MOVE	#1,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#1,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L241:
	MOVE	#-1,-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	-18(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F272_xxxx_(PC)
	ADDA	#12,A7
	BRA.S	L172
L174:
	CMPI	#4,-4(A6)
	BCS.S	L242
	BRA.S	L173
L242:
L172:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L170:
	CMPI	#-2,D6
	BNE	L171(PC)
L173:
	JSR	F271_xxxx_(PC)
L149:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$148:	.EQU	#-50
