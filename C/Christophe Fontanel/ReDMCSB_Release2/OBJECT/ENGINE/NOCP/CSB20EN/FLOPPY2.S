CODE SEG "start"
F451_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	D7-D6,-(A7)
	CLR.L	-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D6
	MOVE	1190.W,D7
	MOVE.L	D6,-(A7)
	MOVE	#32,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	CMPI	#2,D7
	BNE.S	L2
	MOVE	#1,G574_i_Sav(A4)
	BRA.S	L3
L2:
	MOVE	#1,G567_B_Sin(A4)
L3:
DATA SEG "s!"
s!:
	DATA 44 52 49 56 45 20 41 3A 00 00 
CODE SEG "start"
	LEA	s!(A4),A0
	MOVE.L	A0,G571_pc_D1(A4)
DATA SEG "s!"
	DATA 44 52 49 56 45 20 42 3A 00 00 
CODE SEG "start"
	LEA	s!+10(A4),A0
	MOVE.L	A0,G572_pc_D1(A4)
L1:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$0:	.EQU	#0
F452_xxxx_:/* global */
	LINK	A6,L$4
	MOVEM.L	A3/D7-D5,-(A7)
	CMPI	#0,8(A6)
	BNE.S	L6
	MOVE	#4,D0
	BRA	L5(PC)
L6:
	MOVE	G631_i_Gra(A4),D5
	BEQ.S	L7
	MOVE	#1,G631_i_Gra(A4)
	JSR	F478_gzzz_(PC)
L7:
	CLR	-(A7)
	MOVE.L	#1024,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A3
	CMPI	#1,8(A6)
	BNE.S	L8
	MOVE	G573_i_Gam(A4),D6
	BRA.S	L9
L8:
	MOVE	G574_i_Sav(A4),D6
L9:
	MOVE	8(A6),-(A7)
	JSR	F450_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#2,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	CLR.L	-(A7)
	MOVE.L	A3,-(A7)
	MOVE	#8,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	TST	D0
	BEQ.S	L10
	MOVE	#3,D7
	BRA.S	L11
L10:
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#10,-(A7)
	MOVE	D6,-(A7)
	CLR.L	-(A7)
	MOVE.L	A3,-(A7)
	MOVE	#8,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	TST	D0
	BNE.S	L12
	CLR	D7
	BRA.S	L13
L12:
	MOVE.L	A3,-(A7)
	MOVE	D6,-(A7)
	JSR	F449_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BEQ.S	L14
	MOVE	#2,D7
	BRA.S	L15
L14:
	MOVE	#1,D7
L15:
L13:
L11:
	MOVE.L	#1024,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D5,D0
	BEQ.S	L16
	JSR	F477_izzz_(PC)
	MOVE	D5,G631_i_Gra(A4)
L16:
	MOVE	D7,D0
	MOVE	D0,G568_i_Dis(A4)
L5:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$4:	.EQU	#0
F453_xxxx_:/* global */
	LINK	A6,L$17
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	#1,D6
	MOVE.L	G648_l_Ava(A4),D5
	CLR	-(A7)
	MOVE.L	D5,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A3
	CLR	D7
	BRA.S	L19
L20:
	CMPI	#1,D7
	BHI.S	L24
	MOVE	#0,D0
	BRA.S	L25
L24:
	MOVE	#-6683,D0
L25:
	MOVE	D0,-(A7)
	MOVE.L	#-2023406815,-(A7)
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	MOVE	#9,-(A7)
	MOVE	G574_i_Sav(A4),-(A7)
	CLR.L	-(A7)
	MOVE.L	A3,-(A7)
	MOVE	#10,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#26,A7
	TST.L	D0
	BEQ.S	L23
	BRA.S	L2T453_006
L23:
L21:
	ADDQ	#1,D7
L19:
	CMPI	#80,D7
	BCS.S	L20
L22:
	CLR	-(A7)
	MOVE	#2,-(A7)
	MOVE.L	#16777217,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	#18,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#14,A7
	MOVE	#1,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	G574_i_Sav(A4),-(A7)
	CLR.L	-(A7)
	MOVE.L	A3,-(A7)
	MOVE	#9,-(A7)
	JSR	R056_aaal_(PC)
	ADDA	#20,A7
	TST.L	D0
	BEQ.S	L26
L2T453_006:
	CLR	D6
L26:
	MOVE.L	D5,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D0
L18:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$17:	.EQU	#0
F454_xxxx_:/* global */
	LINK	A6,L$27
	MOVE	D7,-(A7)
	CMPI	#2,8(A6)
	BNE.S	L29
	MOVE	#3,D7
	BRA.S	L30
L29:
	LEA	G575_ac_Sa(A4),A0
	MOVE.L	A0,G569_pc_Sa(A4)
	LEA	G576_ac_Sa(A4),A0
	MOVE.L	A0,G570_pc_Sa(A4)
	MOVE	G567_B_Sin(A4),D0
	BEQ.S	L31
	MOVE	#65,D7
	BRA.S	L32
L31:
	MOVE	#66,D7
L32:
	MOVE	D7,D0
	MOVE.B	D0,G575_ac_Sa(A4)
	MOVE	D7,D0
	MOVE.B	D0,G576_ac_Sa(A4)
	MOVE	#1,D7
L30:
	MOVE	#2,-(A7)
	JSR	F452_xxxx_(PC)
	ADDQ.L	#2,A7
	CMP	D7,D0
	BNE.S	L33
	MOVE	#1,D0
	BRA.S	L28
L33:
	MOVE	#0,D0
L28:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$27:	.EQU	#0
F455_xxxx_:/* global */
	LINK	A6,L$34
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.L	16(A6),D7
	MOVE.L	A3,A0
	LEA	20(A3),A3
	MOVEQ	#0,D1
L4T455_001:
	MOVE	(A3)+,D1
	MOVEQ	#16,D0
L4T455_002_:
	BTST	#15,D1
	BEQ.S	L4T455_004
	MOVEQ	#2,D2
	BSR.S	L4T455_006_
	SUBQ	#2,D1
	BNE.S	L4T455_003
	SWAP	D1
	MOVEQ	#4,D2
	BSR.S	L4T455_006_
	MOVE.B	4(A0,D1),(A2)+
	BRA.S	L4T455_005
L4T455_003:
	SWAP	D1
	MOVEQ	#8,D2
	BSR.S	L4T455_006_
	MOVE.B	D1,(A2)+
	BRA.S	L4T455_005
L4T455_004:
	MOVEQ	#3,D2
	BSR.S	L4T455_006_
	MOVE.B	0(A0,D1),(A2)+
L4T455_005:
	SUBQ.L	#1,D7
	BEQ.S	L4T455_008_
	CLR	D1
	SWAP	D1
	TST	D0
	BNE.S	L4T455_002_
	BRA.S	L4T455_001
L4T455_006_:
	CMP	D2,D0
	BPL.S	L4T455_007
	SUB	D0,D2
	LSL.L	D0,D1
	MOVE	(A3)+,D1
	MOVEQ	#16,D0
L4T455_007:
	SUB	D2,D0
	LSL.L	D2,D1
	SWAP	D1
	RTS
L4T455_008_:
L35:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$34:	.EQU	#0
