BSS SEG "bss"
G485_aauc_:/* global */
	.WORD	#24
G486_auc_G:/* global */
	.WORD	#6
G487_as_Gr:/* global */
	.WORD	#200
G488_i_Gra:/* global */
	.WORD	#2
G489_as_Gr:/* global */
	.WORD	#352
G490_ac_Gr:/* global */
	.WORD	#300
G491_auc_G:/* global */
	.WORD	#44
G492_auc_G:/* global */
	.WORD	#44
G493_auc_G:/* global */
	.WORD	#44
G494_auc_G:/* global */
	.WORD	#44
G495_ac_Gr:/* global */
	.WORD	#44
G496_auc_G:/* global */
	.WORD	#44
G497_auc_G:/* global */
	.WORD	#44
G498_auc_G:/* global */
	.WORD	#16
G499_s_Gra:/* global */
	.WORD	#8
G500_s_Gra:/* global */
	.WORD	#8
G501_s_Gra:/* global */
	.WORD	#8
G502_s_Gra:/* global */
	.WORD	#8
G503_s_Gra:/* global */
	.WORD	#8
G504_s_Gra:/* global */
	.WORD	#8
G505_i_Gra:/* global */
	.WORD	#2
G506_i_Act:/* global */
	.WORD	#2
G507_ui_Ac:/* global */
	.WORD	#2
G508_B_Ref:/* global */
	.WORD	#2
G509_B_Act:/* global */
	.WORD	#2
G510_ac_Ac:/* global */
	.WORD	#4
G511_auc_A:/* global */
	.WORD	#4
G512_uc_Us:/* global */
	.WORD	#2
G513_i_Act:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G514_i_Mag(A4)
BSS SEG "bss"
G514_i_Mag:/* global */
	.WORD	#2
G515_aui_B:/* global */
	.WORD	#576
G516_aaui_:/* global */
	.WORD	#1728
G517_T_Act:/* global */
	.WORD	#2
CODE SEG "user"
F381_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2,-(A7)
	MOVE.L	8(A6),A3
	LEA	-132(A6),A0
	MOVE.L	A0,A2
	MOVE.B	#10,(A2)+
L2:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#64,D0
	BNE.S	L5
	ADDQ.L	#1,A3
	MOVE.L	A2,D0
	SUBQ.L	#1,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#10,D0
	BEQ.S	L6
	MOVE.B	#32,(A2)+
L6:
	MOVE.B	(A3),D0
	EXT	D0
	CMP	#112,D0
	BEQ.S	L7
	BRA.S	L8
L7:
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
L8:
	CLR.B	(A2)
	MOVE.L	-4(A6),-(A7)
	PEA	-132(A6)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE.L	-4(A6),-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	EXT.L	D0
	ADDA.L	D0,A2
	MOVE.B	#32,(A2)+
	BRA.S	L9
L5:
	MOVE.B	(A3),(A2)+
L9:
L3:
	MOVE.B	(A3)+,D0
	BNE.S	L2
L4:
	CLR.B	(A2)
	MOVE.B	-131(A6),D0
	BEQ.S	L10
	PEA	-132(A6)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L10:
L1:
	MOVEM.L	(A7)+,A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-132
F382_xxxx_:/* global */
	LINK	A6,L$11
	MOVEM.L	A3/D7,-(A7)
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-588(A4),A0
	ADDA	D0,A0
	MOVE	2(A0),D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L13:
	CMP	#5,D0
	BEQ.S	L14
	BRA.S	L16
L14:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	BRA.S	L12
	BRA.S	L17
L16:
	CMP	#6,D0
	BEQ.S	L17
	BRA.S	L18
L17:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#7680,D0
	LSR	#1,D0
	LSR	#8,D0
	BRA.S	L12
	BRA.S	L19
L18:
	CMP	#10,D0
	BEQ.S	L19
	BRA.S	L20
L19:
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	BRA.S	L12
L21:
	MOVE	#1,D0
	BRA.S	L12
	BRA.S	L22
L20:
	BRA.S	L21
L22:
L15:
L12:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$11:	.EQU	#0
F383_xxxx_:/* global */
	LINK	A6,L$23
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	(A3),G511_auc_A(A4)
	MOVE.B	#1,G510_ac_Ac(A4)
	MOVE	#1,D6
	MOVE	#1,D7
	BRA.S	L25
L26:
	MOVE	D7,D0
	LEA	(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D5
	CMPI	#255,D0
	BNE.S	L29
	BRA.S	L27
L29:
	MOVE	D7,D0
	LEA	3(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D4
	AND	#128,D0
	BEQ.S	L30
	JSR	F382_xxxx_(PC)
	TST	D0
	BNE.S	L30
	BRA.S	L27
L30:
	AND	#-129,D4
	MOVE	D5,D0
	LEA	G496_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	G506_i_Act(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	CMP	D4,D0
	BCS.S	L31
	MOVE	D5,D0
	MOVE	D6,D1
	LEA	G511_auc_A(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D4,D0
	MOVE	D6,D1
	LEA	G510_ac_Ac(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	ADDQ	#1,D6
L31:
L27:
	ADDQ	#1,D7
L25:
	CMPI	#3,D7
	BCS.S	L26
L28:
	MOVE	D6,G507_ui_Ac(A4)
	MOVE	D6,D7
	BRA.S	L32
L33:
	MOVE	D7,D0
	LEA	G511_auc_A(A4),A0
	ADDA	D0,A0
	MOVE.B	#-1,(A0)
L34:
	ADDQ	#1,D7
L32:
	CMPI	#3,D7
	BCS.S	L33
L35:
L24:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$23:	.EQU	#0
F384_xxxx_:/* global */
	LINK	A6,L$36
	MOVEM.L	A3/D7,-(A7)
	MOVE.B	9(A6),D7
	MOVE.B	D7,D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L38
DATA SEG "s!"
s!:
	DATA 00 00 
CODE SEG "user"
	LEA	s!(A4),A0
	MOVE.L	A0,D0
	BRA.S	L37
L38:
	LEA	G490_ac_Gr(A4),A0
	MOVE.L	A0,A3
	BRA.S	L39
L40:
L43:
L42:
	MOVE.B	(A3)+,D0
	BNE.S	L43
L44:
L39:
	MOVE.B	D7,D0
	AND	#255,D0
	SUBQ.B	#1,D7
	TST.B	D0
	BNE.S	L40
L41:
	MOVE.L	A3,D0
L37:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$36:	.EQU	#0
F385_xxxx_:/* global */
	LINK	A6,L$45
	MOVEM.L	A3-A2/D7-D5,-(A7)
	JSR	F077_aA39_(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G001_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	CMPI	#0,8(A6)
	BGE.S	L47
	CMPI	#-1,8(A6)
	BNE.S	L48
	MOVE	#242,D5
DATA SEG "s!"
	DATA 43 41 4E 27 54 20 52 45 41 43 48 00 
CODE SEG "user"
	LEA	s!+2(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	BRA.S	L49
L48:
	MOVE	#248,D5
DATA SEG "s!"
	DATA 4E 45 45 44 20 41 4D 4D 4F 00 
CODE SEG "user"
	LEA	s!+14(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
L49:
	MOVE.L	A2,-(A7)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#100,-(A7)
	MOVE	D5,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	BRA	L50(PC)
L47:
	CMPI	#40,8(A6)
	BLE.S	L51
	LEA	G499_s_Gra(A4),A0
	MOVE.L	A0,-10(A6)
	MOVE	#14,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	#48,D6
	BRA	L52(PC)
L51:
	CMPI	#15,8(A6)
	BLE.S	L53
	MOVE	#2,D7
	MOVE	#64,D5
	MOVE	#32,D6
	LEA	G502_s_Gra(A4),A0
	MOVE.L	A0,-10(A6)
	BRA.S	L54
L53:
	MOVE	#3,D7
	MOVE	#42,D5
	MOVE	#24,D6
	LEA	G503_s_Gra(A4),A0
	MOVE.L	A0,-10(A6)
L54:
	MOVE	D7,-(A7)
	JSR	F491_xzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE.S	L55
	MOVE	#14,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	PEA	G017_auc_G(A4)
	MOVE	#37,-(A7)
	MOVE	D5,-(A7)
	MOVE	#45,-(A7)
	MOVE	#96,-(A7)
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
	MOVE	D7,-(A7)
	JSR	F493_hzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L56
L55:
	MOVE	D7,-(A7)
	JSR	F492_mzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
L56:
L52:
	MOVE	#-1,-(A7)
	MOVE	D6,-(A7)
	MOVE.L	-10(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#5,D7
	MOVE	#274,D5
	CLR.B	-1(A6)
L57:
	MOVE	#48,D0
	MOVE	8(A6),D1
	EXT.L	D1
	DIVS	#10,D1
	SWAP	D1
	ADD	D1,D0
	SUBQ	#1,D7
	MOVE	D7,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	SUBQ	#3,D5
L58:
	MOVE	8(A6),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,8(A6)
	BNE.S	L57
L59:
	MOVE	D7,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#100,-(A7)
	MOVE	D5,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L50:
	JSR	F078_xzzz_(PC)
L46:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$45:	.EQU	#-10
F386_ezzz_:/* global */
	LINK	A6,L$60
	MOVEM.L	A3-A2/D7,-(A7)
	MOVE	G509_B_Act(A4),D0
	BNE.S	L62
	BRA	L61(PC)
L62:
	MOVE	8(A6),D0
	MULU	#22,D0
	ADD	#233,D0
	MOVE	D0,-8(A6)
	ADD	#19,D0
	MOVE	D0,-6(A6)
	MOVE	#86,-4(A6)
	MOVE	#120,-2(A6)
	CLR	G578_B_Use(A4)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	52(A2),D0
	BNE.S	L63
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	-8(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	BRA	L61(PC)
L63:
	CLR	-(A7)
	MOVE.L	#128,-(A7)
	JSR	F468_ozzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,A3
	MOVE	214(A2),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BNE.S	L64
	MOVE	#201,D7
	BRA.S	L65
L64:
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+3(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	BEQ.S	L66
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	BRA.S	L67
L66:
	MOVE	#16,-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F134_zzzz_(PC)
	ADDQ.L	#8,A7
	BRA.S	L5T386_006
L67:
L65:
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	PEA	G498_auc_G(A4)
	MOVE	#16,-(A7)
	MOVE	#16,-(A7)
	MOVE	#16,-(A7)
	MOVE	#16,-(A7)
	MOVE.L	A3,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F129_szzz_(PC)
	ADDA	#20,A7
L5T386_006:
	MOVE	#160,-(A7)
	MOVE	#4,-(A7)
	PEA	-8(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	-8(A6),D0
	ADDQ	#2,D0
	MOVE	D0,-16(A6)
	MOVE	-6(A6),D0
	SUBQ	#2,D0
	MOVE	D0,-14(A6)
	MOVE	#95,-12(A6)
	MOVE	#110,-10(A6)
	MOVE	#-1,-(A7)
	MOVE	#8,-(A7)
	PEA	-16(A6)
	MOVE.L	A3,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	48(A2),D0
	AND	#8,D0
	BNE.S	L69
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L69
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L68
L69:
	CLR	-(A7)
	PEA	-8(A6)
	JSR	F136_nzzz_(PC)
	ADDQ.L	#6,A7
L68:
	MOVE.L	#128,-(A7)
	JSR	F469_rzzz_(PC)
	ADDQ.L	#4,A7
L61:
	MOVEM.L	(A7)+,D7/A2-A3
	UNLK	A6
	RTS
L$60:	.EQU	#-16
F387_hzzz_:/* global */
	LINK	A6,L$70
	MOVEM.L	A3/D7,-(A7)
	JSR	F077_aA39_(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G001_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	G509_B_Act(A4),D0
	BEQ.S	L72
	CLR	D7
	BRA.S	L73
L74:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L73:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L74
L75:
	BRA	L76(PC)
L72:
	MOVE	G506_i_Act(A4),D0
	BEQ	L77(PC)
	LEA	G499_s_Gra(A4),A0
	MOVE.L	A0,A3
	MOVE.B	G511_auc_A+2(A4),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L78
	LEA	G500_s_Gra(A4),A0
	MOVE.L	A0,A3
L78:
	MOVE.B	G511_auc_A+1(A4),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L79
	LEA	G501_s_Gra(A4),A0
	MOVE.L	A0,A3
L79:
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	MOVE.L	A3,-(A7)
	MOVE	#10,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	MOVE	#7,-(A7)
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#83,-(A7)
	MOVE	#235,-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F041_aadZ_(PC)
	ADDA	#20,A7
	CLR	D7
	BRA.S	L80
L81:
	MOVE	#12,-(A7)
	MOVE	D7,D0
	LEA	G511_auc_A(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F384_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#93,D0
	MOVE	D7,D1
	MULU	#12,D1
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#241,-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F041_aadZ_(PC)
	ADDA	#20,A7
L82:
	ADDQ	#1,D7
L80:
	CMPI	#3,D7
	BCS.S	L81
L83:
L77:
L76:
	JSR	F078_xzzz_(PC)
	CLR	G508_B_Ref(A4)
L71:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$70:	.EQU	#0
F388_rzzz_:/* global */
	LINK	A6,L$84
	MOVE	G506_i_Act(A4),D0
	BEQ.S	L86
	SUBQ	#1,G506_i_Act(A4)
	MOVE	G506_i_Act(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#-32768,(A0)
	MOVE	G506_i_Act(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	CLR	G506_i_Act(A4)
	MOVE	#1,G508_B_Ref(A4)
L86:
L85:
	UNLK	A6
	RTS
L$84:	.EQU	#0
F389_xxxx_:/* global */
	LINK	A6,L$87
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	48(A3),D0
	AND	#8,D0
	BNE.S	L90
	MOVE	52(A3),D0
	BNE.S	L89
L90:
	BRA.S	L88
L89:
	MOVE	214(A3),D0
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L91
	MOVE	#2,D7
	BRA.S	L92
L91:
	MOVE	D6,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+3(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	CMPI	#0,D0
	BNE.S	L93
	BRA.S	L88
L93:
L92:
	MOVE	D7,D0
	ASL.L	#3,D0
	LEA	G489_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	8(A6),D0
	ADDQ	#1,D0
	MOVE	D0,G506_i_Act(A4)
	MOVE.B	6(A2),G512_uc_Us(A4)
	MOVE.L	A2,-(A7)
	JSR	F383_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	G509_B_Act(A4)
	ORI	#-32768,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F387_hzzz_(PC)
L88:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$87:	.EQU	#0
F390_rzzz_:/* global */
	LINK	A6,L$94
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BNE.S	L96
	BRA	L95(PC)
L96:
	MOVE	G300_B_Par(A4),D0
	BNE.S	L98
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L97
L98:
	MOVE	G506_i_Act(A4),D0
	BEQ.S	L99
	JSR	F388_rzzz_(PC)
	BRA	L95(PC)
L99:
	MOVE	G299_ui_Ca(A4),D0
	BNE.S	L100
	BRA	L95(PC)
L100:
	BRA.S	L101
L97:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
L102:
	MOVE	D7,D0
	CMP	G411_i_Lea(A4),D0
	BEQ.S	L105
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	G506_i_Act(A4),D0
	BEQ.S	L105
	MOVE.B	41(A3),D0
	BEQ.S	L105
	MOVE.B	28(A3),D0
	MOVE.B	40(A3),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BEQ.S	L105
	MOVE.B	40(A3),28(A3)
	ORI	#1024,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L105:
	CLR.B	41(A3)
	ADDA	#800,A3
	ADDQ	#1,D7
L103:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L102
L104:
L101:
	MOVE	G508_B_Ref(A4),D0
	BEQ.S	L106
	MOVE	G506_i_Act(A4),D0
	BNE.S	L107
	MOVE	G513_i_Act(A4),D0
	BEQ.S	L108
	MOVE	G513_i_Act(A4),-(A7)
	JSR	F385_xxxx_(PC)
	ADDQ.L	#2,A7
	CLR	G513_i_Act(A4)
	BRA.S	L109
L108:
	MOVE	#1,G509_B_Act(A4)
	JSR	F387_hzzz_(PC)
L109:
	BRA.S	L110
L107:
	CLR	G509_B_Act(A4)
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F387_hzzz_(PC)
L110:
L106:
L95:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$94:	.EQU	#0
F391_xxxx_:/* global */
	LINK	A6,L$111
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G506_i_Act(A4),D0
	BEQ.S	L114
	LEA	G511_auc_A(A4),A0
	ADDA	8(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	CMP	#255,D0
	BNE.S	L113
L114:
	MOVE	#0,D0
	BRA.S	L112
L113:
	MOVE	G506_i_Act(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#-1,8(A6)
	BNE.S	L115
	MOVE	#-1,D5
	BRA.S	L116
L115:
	LEA	G511_auc_A(A4),A0
	ADDA	8(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE	D6,D0
	LEA	G495_ac_Gr(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	ADD	D0,64(A3)
	ORI	#256,48(A3)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F407_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	MOVE	D6,D0
	MOVE.B	D0,32(A3)
L116:
	JSR	F388_rzzz_(PC)
	MOVE	D5,D0
L112:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$111:	.EQU	#0
F392_xxxx_:/* global */
	LINK	A6,L$117
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#2,8(A6)
	BNE.S	L119
	MOVE	#576,-(A7)
	PEA	G515_aui_B(A4)
	PEA	G516_aaui_+576(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	#1,D6
	MOVE	#6,D5
	MOVE.B	33(A3),D1
	AND	#255,D1
	MULS	D1,D5
	MOVE	D5,-12(A6)
	MOVE	#96,D5
	ADD	-12(A6),D5
	CLR.B	-1(A6)
	CLR	D7
	BRA.S	L120
L121:
	MOVE.B	D5,D0
	ADDQ.B	#1,D5
	MOVE.B	D0,-2(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#8,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#48,-(A7)
	PEA	G515_aui_B(A4)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L122:
	ADDQ	#1,D7
L120:
	CMPI	#6,D7
	BCS.S	L121
L123:
	BRA.S	L124
L119:
	CMPI	#3,8(A6)
	BNE.S	L125
	MOVE	#576,-(A7)
	PEA	G515_aui_B(A4)
	PEA	G516_aaui_+1152(A4)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	CLR.B	-1(A6)
	MOVE	#8,D6
	CLR	D7
	BRA.S	L126
L127:
	MOVE	D7,D0
	LEA	34(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE.B	D0,-2(A6)
	EXT	D0
	CMP	#0,D0
	BNE.S	L130
	BRA.S	L118
L130:
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#8,-(A7)
	MOVE	D6,D0
	ADD	#9,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	MOVE	#48,-(A7)
	PEA	G515_aui_B(A4)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
L128:
	ADDQ	#1,D7
L126:
	CMPI	#4,D7
	BCS.S	L127
L129:
L125:
L124:
L118:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$117:	.EQU	#-12
F393_lzzz_:/* global */
	LINK	A6,L$131
	MOVE.L	A3,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	G578_B_Use(A4)
	MOVE	G407_s_Par+52(A4),-2(A6)
	MOVE	G407_s_Par+852(A4),-4(A6)
	MOVE	G407_s_Par+1652(A4),-6(A6)
	MOVE	G407_s_Par+2452(A4),-8(A6)
	JSR	F077_aA39_(PC)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G504_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	8(A6),D0
L133:
	CMP	#0,D0
	BEQ.S	L134
	BRA	L136(PC)
L134:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#277,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#235,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	CMPI	#1,G305_ui_Pa(A4)
	BLS.S	L138
	MOVE	-4(A6),D0
	BEQ.S	L139
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#291,-(A7)
	MOVE	#280,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L139:
L12T393_002:
	CMPI	#2,G305_ui_Pa(A4)
	BLS.S	L140
	MOVE	-6(A6),D0
	BEQ.S	L141
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#305,-(A7)
	MOVE	#294,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L141:
L12T393_003:
	CMPI	#3,G305_ui_Pa(A4)
	BLS.S	L142
	MOVE	-8(A6),D0
	BEQ.S	L143
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#319,-(A7)
	MOVE	#308,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L143:
L142:
L140:
L138:
	BRA	L135(PC)
	BRA.S	L137
L136:
	CMP	#1,D0
	BEQ.S	L137
	BRA.S	L144
L137:
	MOVE	-2(A6),D0
	BEQ.S	L146
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#244,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L146:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#291,-(A7)
	MOVE	#247,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#249,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	BRA	L12T393_002(PC)
	BRA.S	L145
L144:
	CMP	#2,D0
	BEQ.S	L145
	BRA.S	L147
L145:
	MOVE	-2(A6),D0
	BEQ.S	L149
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#244,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L149:
	MOVE	-4(A6),D0
	BEQ.S	L150
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#258,-(A7)
	MOVE	#247,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L150:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#305,-(A7)
	MOVE	#261,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#263,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	BRA	L12T393_003(PC)
	BRA.S	L148
L147:
	CMP	#3,D0
	BEQ.S	L148
	BRA	L151(PC)
L148:
	MOVE	-2(A6),D0
	BEQ.S	L153
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#244,-(A7)
	MOVE	#233,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L153:
	MOVE	-4(A6),D0
	BEQ.S	L154
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#258,-(A7)
	MOVE	#247,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L154:
	MOVE	-6(A6),D0
	BEQ.S	L155
	MOVE	#48,-(A7)
	MOVE	#42,-(A7)
	MOVE	#272,-(A7)
	MOVE	#261,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
L155:
	MOVE	#49,-(A7)
	MOVE	#42,-(A7)
	MOVE	#319,-(A7)
	MOVE	#275,-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	CLR	-(A7)
	MOVE	#48,-(A7)
	MOVE	#277,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L151:
L152:
L135:
	JSR	F078_xzzz_(PC)
L132:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$131:	.EQU	#-8
F394_ozzz_:/* global */
	LINK	A6,L$156
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G514_i_Mag(A4),D0
	BEQ.S	L159
	CMPI	#-1,D7
	BEQ.S	L158
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L158
L159:
	BRA	L157(PC)
L158:
	CMPI	#-1,G514_i_Mag(A4)
	BNE.S	L160
	JSR	F077_aA39_(PC)
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	PEA	G000_s_Gra(A4)
	MOVE	#9,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
L160:
	CMPI	#-1,D7
	BNE.S	L161
	MOVE	#-1,G514_i_Mag(A4)
	JSR	F077_aA39_(PC)
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	G000_s_Gra(A4)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
	BRA	L162(PC)
L161:
	MOVE	D7,D0
	MOVE	D0,G514_i_Mag(A4)
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#2,-(A7)
	JSR	F392_xxxx_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	MOVE.L	G348_pl_Bi(A4),D4
	ADD.L	#8112,D4
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D6
	BRA.S	L163
L164:
	MOVE	#48,-(A7)
	MOVE.L	D4,D0
	ADD.L	#160,D0
	MOVE.L	D0,D4
	MOVE.L	D0,-(A7)
	MOVE	D5,D0
	ADD	#24,D0
	MOVE	D0,D5
	ASL.L	#1,D0
	LEA	G515_aui_B(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L165:
	ADDQ	#1,D6
L163:
	CMPI	#12,D6
	BCS.S	L164
L166:
	MOVE	#3,-(A7)
	JSR	F392_xxxx_(PC)
	ADDQ.L	#2,A7
	CLR	D5
	MOVE.L	G348_pl_Bi(A4),D4
	ADD.L	#10032,D4
	MOVE	#1,D6
	BRA.S	L167
L168:
	MOVE	#48,-(A7)
	MOVE.L	D4,D0
	ADD.L	#160,D0
	MOVE.L	D0,D4
	MOVE.L	D0,-(A7)
	MOVE	D5,D0
	ADD	#24,D0
	MOVE	D0,D5
	ASL.L	#1,D0
	LEA	G515_aui_B(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L169:
	ADDQ	#1,D6
L167:
	CMPI	#12,D6
	BCS.S	L168
L170:
	JSR	F078_xzzz_(PC)
L162:
L157:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$156:	.EQU	#0
F395_pzzz_:/* global */
	LINK	A6,L$171
	JSR	F077_aA39_(PC)
	MOVE	#-1,-(A7)
	MOVE	#48,-(A7)
	PEA	G002_s_Gra(A4)
	MOVE	#13,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	JSR	F078_xzzz_(PC)
L172:
	UNLK	A6
	RTS
L$171:	.EQU	#0
F396_pzzz_:/* global */
	LINK	A6,L$173
	CLR	-(A7)
	CLR	-(A7)
	PEA	G516_aaui_(A4)
	MOVE	#11,-(A7)
	JSR	F490_lzzz_(PC)
	ADDA	#10,A7
L174:
	UNLK	A6
	RTS
L$173:	.EQU	#0
F397_xxxx_:/* global */
	LINK	A6,L$175
	MOVEM.L	D7-D5,-(A7)
	CLR.B	-1(A6)
	MOVE	#96,D5
	MOVE	#6,D1
	MULU	8(A6),D1
	ADD	D1,D5
	MOVE	#225,D6
	CLR	D7
	BRA.S	L177
L178:
	MOVE.B	D5,D0
	ADDQ.B	#1,D5
	MOVE.B	D0,-2(A6)
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#58,-(A7)
	MOVE	D6,D0
	ADD	#14,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L179:
	ADDQ	#1,D7
L177:
	CMPI	#6,D7
	BCS.S	L178
L180:
L176:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$175:	.EQU	#-2
F398_xxxx_:/* global */
	LINK	A6,L$181
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	LEA	34(A3),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	MOVE	#232,D6
	CLR.B	-1(A6)
	CLR	D7
	BRA.S	L183
L184:
	MOVE	D7,D0
	CMP	D5,D0
	BCS.S	L187
	MOVE.B	#32,-2(A6)
	BRA.S	L188
L187:
	MOVE	D7,D0
	LEA	34(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),-2(A6)
L188:
	PEA	-2(A6)
	CLR	-(A7)
	MOVE	#4,-(A7)
	MOVE	#70,-(A7)
	MOVE	D6,D0
	ADD	#9,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L185:
	ADDQ	#1,D7
L183:
	CMPI	#4,D7
	BCS.S	L184
L186:
L182:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$181:	.EQU	#-2
F399_xxxx_:/* global */
	LINK	A6,L$189
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	33(A3),D7
	AND	#255,D7
	MOVE	D7,D6
	MULS	#6,D6
	LEA	G485_aauc_(A4),A0
	ADD.L	A0,D6
	MOVE.L	D6,A0
	ADDA	8(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE	D7,D0
	BEQ.S	L191
	MOVE	D6,D0
	MOVE.B	34(A3),D1
	EXT	D1
	SUB	#96,D1
	MOVE	D1,D5
	LEA	G486_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULU	D1,D0
	LSR	#3,D0
	MOVE	D0,D6
L191:
	MOVE	D6,D0
	MOVE	60(A3),D1
	CMP	D1,D0
	BHI.S	L192
	MOVE	D6,D0
	SUB	D0,60(A3)
	ORI	#256,48(A3)
	MOVE	#96,D0
	MOVE	D7,D1
	MULU	#6,D1
	ADD	D1,D0
	ADD	8(A6),D0
	MOVE	D7,D1
	LEA	34(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D7,D0
	LEA	35(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE	D7,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D0,D7
	MOVE.B	D0,33(A3)
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F397_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F398_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L192:
L190:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$189:	.EQU	#0
F400_xxxx_:/* global */
	LINK	A6,L$193
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	LEA	34(A3),A0
	MOVE.L	A0,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	TST	D0
	BNE.S	L195
	BRA.S	L194
L195:
	MOVE.B	33(A3),D0
	AND	#255,D0
	ADDQ	#3,D0
	AND	#3,D0
	MOVE	D0,D7
	MOVE.B	D0,33(A3)
	MOVE	D7,D0
	LEA	34(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	JSR	F077_aA39_(PC)
	MOVE	D7,-(A7)
	JSR	F397_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F398_xxxx_(PC)
	ADDQ.L	#4,A7
	JSR	F078_xzzz_(PC)
L194:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$193:	.EQU	#0
F401_xxxx_:/* global */
	LINK	A6,L$196
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	D4
	CMPI	#-2,G517_T_Act(A4)
	BNE.S	L198
	BRA	L199(PC)
L198:
	MOVE	10(A6),D0
L200:
	CMP	#8,D0
	BEQ.S	L201
	BRA.S	L203
L201:
	MOVE	#3,D7
	MOVE	#12,D5
	BRA.S	L202
	BRA.S	L204
L203:
	CMP	#37,D0
	BEQ.S	L204
	BRA.S	L205
L204:
	MOVE	#7,D7
	MOVE	#35,D5
	BRA.S	L202
	BRA.S	L206
L205:
	CMP	#41,D0
	BEQ.S	L206
	BRA.S	L207
L206:
	MOVE	#6,D7
	MOVE	#30,D5
	BRA.S	L202
	BRA.S	L208
L207:
	CMP	#4,D0
	BEQ.S	L208
	BRA.S	L209
L208:
	MOVE	#6,D7
	MOVE	#20,D5
	BRA.S	L202
	BRA.S	L210
L209:
	CMP	#22,D0
	BEQ.S	L210
	BRA.S	L211
L210:
	MOVE	#12,D7
	MOVE	#45,D5
L211:
L212:
L202:
	MOVE	#14,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D7
	MOVE	G517_T_Act(A4),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE.B	4(A3),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	MOVE	D0,-14(A6)
	MOVE	16(A2),D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,D6
	CMP	-14(A6),D0
	BHI.S	L214
	CMPI	#15,D6
	BNE.S	L213
L214:
	MOVE	D5,D0
	LSR	#1,D0
	MOVE	D0,D5
	BRA	L215(PC)
L213:
	MOVE.B	5(A3),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-4(A6)
	MOVE	14(A3),D0
	AND	#15,D0
	CMPI	#6,D0
	BNE.S	L216
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F182_aqzz_(PC)
	ADDQ.L	#8,A7
	MOVE	14(A6),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F180_hzzz_(PC)
	ADDQ.L	#4,A7
L216:
	MOVE	#5,D0
	AND	#15,D0
	MOVE	D0,D3
	ANDI	#-16,14(A3)
	OR	D3,14(A3)
	MOVE	#16,D0
	SUB	D6,D0
	ASL	#2,D0
	MOVE.B	6(A2),D1
	AND	#255,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	MOVE.L	-4(A6),A0
	MOVE.B	D0,5(A0)
	MOVE	#1,D4
L215:
	MOVE	D5,-(A7)
	MOVE	#14,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L199:
	MOVE	D4,D0
L197:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$196:	.EQU	#-14
F402_xxxx_:/* global */
	LINK	A6,L$217
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	10(A6),A3
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	CMPI	#-2,G517_T_Act(A4)
	BNE.S	L219
	BRA	L21T402_010(PC)
L219:
	MOVE.B	29(A3),D0
	AND	#255,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	JSR	F177_aszz_(PC)
	ADDA	#10,A7
	MOVE	D0,D5
	BEQ	L220(PC)
	MOVE	D7,D0
	ADDQ	#4,D0
	MOVE.B	28(A3),D3
	AND	#255,D3
	SUB	D3,D0
	AND	#3,D0
L221:
	CMP	#2,D0
	BEQ.S	L222
	BRA.S	L224
L222:
	MOVE	#3,D6
	BRA.S	L21T402_005
	BRA.S	L225
L224:
	CMP	#3,D0
	BEQ.S	L225
	BRA.S	L226
L225:
	MOVE	#1,D6
L21T402_005:
	MOVE	D7,D0
	ADD	D6,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L228
	MOVE	#-1,G513_i_Act(A4)
	BRA	L21T402_010(PC)
L228:
L226:
L227:
L223:
	CMPI	#24,14(A6)
	BNE.S	L229
	MOVE	G517_T_Act(A4),-(A7)
	JSR	F144_amzz_(PC)
	ADDQ.L	#2,A7
	AND	#64,D0
	BNE.S	L229
	BRA.S	L230
L229:
	LEA	G493_auc_G(A4),A0
	ADDA	14(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	LEA	G492_auc_G(A4),A0
	ADDA	14(A6),A0
	MOVE.B	(A0),D7
	AND	#255,D7
	MOVE	214(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#40,D0
	BEQ.S	L232
	CMPI	#24,14(A6)
	BNE.S	L231
L232:
	OR	#-32768,D6
L231:
	MOVE	20(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	D5,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	G517_T_Act(A4),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	8(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F231_izzz_(PC)
	ADDA	#22,A7
	MOVE	D0,G513_i_Act(A4)
	MOVE	#1,D0
	BRA.S	L218
L230:
L220:
L21T402_010:
	MOVE	#0,D0
L218:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$217:	.EQU	#0
F403_xxxx_:/* global */
	LINK	A6,L$233
	MOVEM.L	D7-D6,-(A7)
	MOVE	14(A6),D7
	MOVE	#1,D6
	MOVE	16(A6),D0
	BEQ.S	L235
	MOVE.L	8(A6),A0
	CMPI	#0,60(A0)
	BNE.S	L236
	MOVE	#0,D0
	BRA	L234(PC)
L236:
	MOVE.L	8(A6),A0
	CMPI	#4,60(A0)
	BGE.S	L237
	MOVE	D7,D0
	LSR	#1,D0
	MOVE	D0,D7
	MOVE.L	8(A6),A0
	CLR	60(A0)
	CLR	D6
	BRA.S	L238
L237:
	MOVE.L	8(A6),A0
	SUBQ	#4,60(A0)
L238:
L235:
	MOVE	D7,D0
	LSR	#5,D0
	MOVE	D0,-4(A6)
	MOVE	12(A6),D0
	BEQ.S	L239
	MOVE.B	#77,-6(A6)
	CMPI	#50,G407_s_Par+3208(A4)
	BLE.S	L240
	MOVE	-4(A6),D0
	ASR	#2,D0
	MOVE	D0,-4(A6)
L240:
	MOVE	-4(A6),D0
	ADD	D0,G407_s_Par+3208(A4)
	BRA.S	L241
L239:
	MOVE.B	#78,-6(A6)
	CMPI	#50,G407_s_Par+3206(A4)
	BLE.S	L242
	MOVE	-4(A6),D0
	ASR	#2,D0
	MOVE	D0,-4(A6)
L242:
	MOVE	-4(A6),D0
	ADD	D0,G407_s_Par+3206(A4)
L241:
	CLR.B	-5(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	AND.L	#65535,D7
	ADD.L	D7,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	JSR	F260_pzzz_(PC)
	MOVE	D6,D0
L234:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$233:	.EQU	#-10
F404_xxxx_:/* global */
	LINK	A6,L$243
	MOVE.B	#70,-6(A6)
	MOVE	8(A6),-4(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	CLR.B	-5(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	JSR	F337_akzz_(PC)
L244:
	UNLK	A6
	RTS
L$243:	.EQU	#-10
F405_xxxx_:/* global */
	LINK	A6,L$245
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A0
	MOVE	214(A0),D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
L247:
	CMP	#5,D0
	BEQ.S	L248
	BRA.S	L250
L248:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	BEQ.S	L252
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-15361,2(A0)
	OR	D3,2(A0)
L252:
	BRA	L249(PC)
	BRA.S	L251
L250:
	CMP	#6,D0
	BEQ.S	L251
	BRA.S	L253
L251:
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#7680,D0
	LSR	#1,D0
	LSR	#8,D0
	BEQ.S	L255
	MOVE.L	A3,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#7680,D0
	LSR	#1,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#1,D3
	ASL	#8,D3
	ANDI	#-7681,2(A0)
	OR	D3,2(A0)
L255:
	BRA.S	L249
	BRA.S	L254
L253:
	CMP	#10,D0
	BEQ.S	L254
	BRA.S	L256
L254:
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	BEQ.S	L258
	MOVE	2(A3),D0
	AND	#-16384,D0
	LSR	#6,D0
	LSR	#8,D0
	SUBQ	#1,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A3)
	OR	D3,2(A3)
L258:
L256:
L257:
L249:
	JSR	F296_aizz_(PC)
L246:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$245:	.EQU	#0
F406_xxxx_:/* global */
	LINK	A6,L$259
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	28(A3),D0
	AND	#255,D0
	CMP	G308_i_Par(A4),D0
	BEQ.S	L261
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	ORI	#1024,48(A3)
L261:
L260:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$259:	.EQU	#0
F407_xxxx_:/* global */
	LINK	A6,L$262
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L264
	MOVE	#0,D0
	BRA	L263(PC)
L264:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	214(A3),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	52(A3),D0
	BNE.S	L265
	MOVE	#0,D0
	BRA	L263(PC)
L265:
	MOVE	G306_i_Par(A4),-6(A6)
	MOVE	G307_i_Par(A4),-8(A6)
	MOVE.B	28(A3),D1
	AND	#255,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE.B	28(A3),D1
	AND	#255,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,G517_T_Act(A4)
	LEA	G491_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-2(A6)
	LEA	G496_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-12(A6)
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	LEA	G494_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D1,D0
	MOVE	D0,-10(A6)
	LEA	G497_auc_G(A4),A0
	ADDA	10(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-14(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D6
	MOVE	#1,D5
	CMPI	#16,-12(A6)
	BLT.S	L268
	CMPI	#19,-12(A6)
	BLE.S	L267
L268:
	CMPI	#3,-12(A6)
	BNE.S	L266
L267:
	MOVE	-12(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#6,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	#7,D0
	SUB	D1,D0
	MOVE	D0,D4
L266:
	MOVE	10(A6),D0
L269:
	CMP	#23,D0
	BEQ.S	L270
	BRA.S	L272
L270:
	MOVE	#180,-4(A6)
	MOVE	#-126,D5
	BRA.S	L26T407_014
	BRA.S	L273
L272:
	CMP	#21,D0
	BEQ.S	L273
	BRA.S	L274
L273:
	MOVE	#150,-4(A6)
	MOVE	#-125,D5
	BRA.S	L26T407_014
	BRA.S	L275
L274:
	CMP	#20,D0
	BEQ.S	L275
	BRA.S	L276
L275:
	MOVE	#150,-4(A6)
	BRA.S	L26T407_013
	BRA.S	L277
L276:
	CMP	#40,D0
	BEQ.S	L277
	BRA.S	L278
L277:
	MOVE	#250,-4(A6)
L26T407_013:
	MOVE	#-128,D5
L26T407_014:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	60(A3),D0
	CMP	D4,D0
	BGE.S	L280
	MOVE	60(A3),D0
	MULS	-4(A6),D0
	EXT.L	D0
	DIVS	D4,D0
	MOVE	D0,-(A7)
	MOVE	#2,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	60(A3),D4
L280:
	MOVE	D4,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F327_kzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	BNE.S	L281
	MOVE	-14(A6),D0
	ASR	#1,D0
	MOVE	D0,-14(A6)
L281:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L271(PC)
	BRA.S	L279
L278:
	CMP	#30,D0
	BEQ.S	L279
L282:
	CMP	#18,D0
	BEQ.S	L279
L283:
	CMP	#19,D0
	BEQ.S	L279
L284:
	CMP	#7,D0
	BEQ.S	L279
L285:
	CMP	#13,D0
	BEQ.S	L279
L286:
	CMP	#2,D0
	BEQ.S	L279
	BRA.S	L287
L279:
	MOVE	D6,D0
	LSR	#5,D0
	CMPI	#4,D0
	BNE.S	L289
	MOVE	D6,D0
	AND	#7,D0
	CMPI	#4,D0
	BNE.S	L289
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	#6,-2(A6)
	MOVE	#2,-(A7)
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F232_dzzz_(PC)
	ADDA	#10,A7
	MOVE	#2,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#4,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L271(PC)
L289:
	BRA.S	L288
L287:
	CMP	#24,D0
	BEQ.S	L288
L290:
	CMP	#16,D0
	BEQ.S	L288
L291:
	CMP	#17,D0
	BEQ.S	L288
L292:
	CMP	#14,D0
	BEQ.S	L288
L293:
	CMP	#9,D0
	BEQ.S	L288
L294:
	CMP	#31,D0
	BEQ.S	L288
L295:
	CMP	#15,D0
	BEQ.S	L288
L296:
	CMP	#25,D0
	BEQ.S	L288
L297:
	CMP	#28,D0
	BEQ.S	L288
L298:
	CMP	#29,D0
	BEQ.S	L288
L299:
	CMP	#6,D0
	BEQ.S	L288
	BRA.S	L300
L288:
	MOVE	-12(A6),-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE.L	A3,-(A7)
	MOVE	D7,-(A7)
	JSR	F402_xxxx_(PC)
	ADDA	#14,A7
	MOVE	D0,D5
	BNE.S	L302
	MOVE	-14(A6),D0
	ASR	#1,D0
	MOVE	D0,-14(A6)
	MOVE	-2(A6),D0
	LSR	#1,D0
	MOVE	D0,-2(A6)
L302:
	BRA	L271(PC)
	BRA.S	L301
L300:
	CMP	#22,D0
	BEQ.S	L301
	BRA.S	L303
L301:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L304
L303:
	CMP	#8,D0
	BEQ.S	L304
L305:
	CMP	#37,D0
	BEQ.S	L304
L306:
	CMP	#41,D0
	BEQ.S	L304
L307:
	CMP	#4,D0
	BEQ.S	L304
	BRA.S	L308
L304:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F401_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D5
	BRA	L271(PC)
	BRA.S	L309
L308:
	CMP	#32,D0
	BEQ.S	L309
	BRA	L310(PC)
L309:
	MOVE	212(A3),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BEQ.S	L312
	BRA.S	L26T407_032
L312:
	MOVE	2(A2),D0
	AND	#127,D0
	MULS	#6,D0
	LEA	G238_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-18(A6)
	MOVE	212(A3),-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-22(A6)
	MOVE.L	-18(A6),A0
	MOVE.B	1(A0),D4
	AND	#255,D4
	MOVE.L	-22(A6),A0
	MOVE.B	1(A0),D0
	AND	#255,D0
	MOVE	D0,-4(A6)
	CMPI	#16,D4
	BLT.S	L313
	CMPI	#31,D4
	BGT.S	L313
	CMPI	#10,-4(A6)
	BEQ.S	L314
	BRA.S	L26T407_032
L314:
	SUB	#16,D4
	BRA.S	L315
L313:
	CMPI	#32,D4
	BLT.S	L316
	CMPI	#47,D4
	BGT.S	L316
	CMPI	#11,-4(A6)
	BEQ.S	L317
L26T407_032:
	MOVE	#-2,G513_i_Act(A4)
	CLR	-14(A6)
	CLR	D5
	BRA	L271(PC)
L317:
	SUB	#32,D4
L316:
L315:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,-(A7)
	MOVE	#11,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-42(A6)
	MOVE.L	-18(A6),A0
	MOVE	4(A0),D0
	AND	#255,D0
	ADD	-42(A6),D0
	ASL	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	-18(A6),A0
	MOVE.B	3(A0),D0
	MOVE.L	-22(A6),A0
	AND	#255,D0
	MOVE.B	3(A0),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F326_ozzz_(PC)
	ADDA	#12,A7
	BRA	L271(PC)
	BRA.S	L311
L310:
	CMP	#5,D0
	BEQ.S	L311
	BRA.S	L318
L311:
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L320
DATA SEG "s!"
	DATA 49 54 20 43 4F 4D 45 53 20 55 50 20 48 45 41 44 53 2E 00 00 
CODE SEG "user"
	PEA	s!+24(A4)
	JSR	F381_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L321
L320:
DATA SEG "s!"
	DATA 49 54 20 43 4F 4D 45 53 20 55 50 20 54 41 49 4C 53 2E 00 00 
CODE SEG "user"
	PEA	s!+44(A4)
	JSR	F381_xxxx_(PC)
	ADDQ.L	#4,A7
L321:
	BRA	L271(PC)
	BRA.S	L319
L318:
	CMP	#33,D0
	BEQ.S	L319
L322:
	CMP	#34,D0
	BEQ.S	L319
	BRA.S	L323
L319:
	MOVE	#1,-(A7)
	MOVE	#280,-(A7)
	CMPI	#33,10(A6)
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F403_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BNE.S	L325
	MOVE	-14(A6),D0
	ASR	#2,D0
	MOVE	D0,-14(A6)
	MOVE	-2(A6),D0
	LSR	#1,D0
	MOVE	D0,-2(A6)
	BRA.S	L326
L325:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
L326:
	BRA	L271(PC)
	BRA.S	L324
L323:
	CMP	#27,D0
	BEQ.S	L324
	BRA.S	L327
L324:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	ADD	#100,D0
	MOVE	D0,-4(A6)
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#6,D0
	SWAP	D0
L329:
	CMP	#0,D0
	BEQ.S	L330
	BRA.S	L332
L330:
	MOVE	#-122,D5
	BRA	L26T407_014(PC)
	BRA.S	L333
L332:
	CMP	#1,D0
	BEQ.S	L333
	BRA.S	L334
L333:
	MOVE	#-121,D5
	BRA	L26T407_014(PC)
	BRA.S	L335
L334:
	CMP	#2,D0
	BEQ.S	L335
	BRA.S	L336
L335:
	MOVE	#-125,D5
	BRA	L26T407_014(PC)
L337:
	BRA	L26T407_013(PC)
	BRA.S	L338
L336:
	BRA.S	L337
L338:
L331:
	BRA.S	L328
L327:
	CMP	#35,D0
	BEQ.S	L328
	BRA.S	L339
L328:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F224_zzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L271(PC)
	BRA.S	L340
L339:
	CMP	#43,D0
	BEQ.S	L340
	BRA.S	L341
L340:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	G306_i_Par(A4),-6(A6)
	MOVE	G307_i_Par(A4),-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F225_dzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L271(PC)
	BRA.S	L342
L341:
	CMP	#36,D0
	BEQ.S	L342
	BRA	L343(PC)
L342:
	MOVE	54(A3),D0
	SUB	52(A3),D0
	MOVE	D0,-4(A6)
	CMPI	#0,D0
	BLE.S	L345
	MOVE	60(A3),D0
	BEQ.S	L345
	MOVE	#13,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	#10,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	MOVE	#2,-14(A6)
L346:
	MOVE	D4,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	MOVE	D6,D0
	ADD	D0,52(A3)
	ADDQ	#2,-14(A6)
L347:
	MOVE	60(A3),D0
	SUBQ	#2,D0
	MOVE	D0,60(A3)
	CMPI	#0,D0
	BLE.S	L349
	MOVE	-4(A6),D0
	SUB	D6,D0
	MOVE	D0,-4(A6)
	BNE.S	L346
L349:
L348:
	CMPI	#0,60(A3)
	BGE.S	L350
	CLR	60(A3)
L350:
	ORI	#256,48(A3)
	MOVE	#1,D5
L345:
	BRA	L271(PC)
	BRA.S	L344
L343:
	CMP	#39,D0
	BEQ.S	L344
	BRA.S	L351
L344:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,-(A7)
	MOVE	-12(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADDQ	#8,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	ADDQ	#5,D0
	MOVE	D0,D4
	CLR.B	-27(A6)
	MOVE.B	#73,-28(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	AND.L	#65535,D4
	ADD.L	D4,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-32(A6)
	PEA	-32(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	ADDQ.B	#1,G407_s_Par+3202(A4)
	BRA	L26T407_076(PC)
	BRA.S	L352
L351:
	CMP	#10,D0
	BEQ.S	L352
	BRA	L353(PC)
L352:
	MOVE	G306_i_Par(A4),-6(A6)
	MOVE	G307_i_Par(A4),-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	CMPI	#2,D0
	BNE.S	L355
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BNE.S	L355
	MOVE	#1,G402_B_Use(A4)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	CLR	G402_B_Use(A4)
	BRA.S	L356
L355:
	CLR	-2(A6)
L356:
	BRA	L271(PC)
	BRA.S	L354
L353:
	CMP	#11,D0
	BEQ.S	L354
	BRA.S	L357
L354:
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#42,D0
	BNE.S	L359
	MOVE	#30,D4
	BRA.S	L26T407_071
L359:
	MOVE	2(A2),D0
	AND	#127,D0
	CMPI	#43,D0
	BNE.S	L360
	MOVE	#125,D4
L26T407_071:
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	#-1,(A2)
	BRA.S	L361
L360:
	MOVE	#70,D4
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
L361:
	MOVE.B	G407_s_Par+3211(A4),D0
	AND	#255,D0
	ADD	D4,D0
	MOVE	D0,-(A7)
	MOVE	#200,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,G407_s_Par+3211(A4)
	BRA	L271(PC)
	BRA.S	L358
L357:
	CMP	#38,D0
	BEQ.S	L358
	BRA.S	L362
L358:
	MOVE	G039_ai_Gr+4(A4),D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	#2500,-(A7)
	MOVE	#-2,-(A7)
	JSR	F404_xxxx_(PC)
	ADDQ.L	#4,A7
L26T407_076:
	MOVE.L	A3,-(A7)
	JSR	F405_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L271
	BRA.S	L363
L362:
	CMP	#42,D0
	BEQ.S	L363
	BRA.S	L364
L363:
	MOVE.L	A3,-(A7)
	JSR	F406_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.B	29(A3),D0
	MOVE	G308_i_Par(A4),D1
	ADDQ	#1,D1
	AND	#3,D1
	AND	#255,D0
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L367
	MOVE.B	29(A3),D0
	MOVE	G308_i_Par(A4),D1
	ADDQ	#2,D1
	AND	#3,D1
	AND	#255,D0
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
L367:
	AND	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F328_nzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	BEQ.S	L366
	MOVE	44(A3),D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	MOVE.B	#2,6(A0)
L366:
L364:
L365:
L271:
	MOVE	-2(A6),D0
	BEQ.S	L368
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F330_szzz_(PC)
	ADDQ.L	#4,A7
L368:
	MOVE	-10(A6),D0
	BEQ.S	L369
	MOVE	-10(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
L369:
	MOVE	-14(A6),D0
	BEQ.S	L370
	MOVE	-14(A6),-(A7)
	MOVE	-12(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
L370:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
L263:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$262:	.EQU	#-42
F408_xxxx_:/* global */
	LINK	A6,L$371
	MOVEM.L	A3/D7,-(A7)
	MOVE	G514_i_Mag(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	JSR	F077_aA39_(PC)
	JSR	F363_pzzz_(PC)
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F412_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
	CMPI	#3,D0
	BEQ.S	L373
	CLR.B	34(A3)
	MOVE.B	#0,D0
	AND	#255,D0
	MOVE.B	D0,33(A3)
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F397_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE.L	A3,-(A7)
	JSR	F398_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA.S	L374
L373:
	CLR	D7
L374:
	JSR	F078_xzzz_(PC)
	MOVE	D7,D0
L372:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$371:	.EQU	#0
F409_xxxx_:/* global */
	LINK	A6,L$375
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,D0
	ADDQ.L	#1,D0
	MOVE.L	D0,A0
	MOVE.B	(A0),D0
	BEQ.S	L377
	MOVE	#24,D6
	CLR.L	D7
L378:
	MOVE.B	(A3)+,D0
	AND	#255,D0
	EXT.L	D0
	ASL.L	D6,D0
	OR.L	D0,D7
L379:
	MOVE.B	(A3),D0
	BEQ.S	L381
	MOVE	D6,D0
	SUBQ	#8,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BGE.S	L378
L381:
L380:
	LEA	G487_as_Gr(A4),A0
	MOVE.L	A0,A2
	MOVE	#25,D6
	BRA.S	L382
L383:
	MOVE.L	(A2),D0
	AND.L	#-16777216,D0
	BEQ.S	L385
	MOVE.L	D7,D0
	CMP.L	(A2),D0
	BNE.S	L386
	MOVE.L	A2,D0
	BRA.S	L376
L386:
	BRA.S	L387
L385:
	MOVE.L	D7,D0
	AND.L	#16777215,D0
	CMP.L	(A2),D0
	BNE.S	L388
	MOVE.L	A2,D0
	BRA.S	L376
L388:
L387:
	ADDQ.L	#8,A2
L382:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L383
L384:
L377:
	MOVE.L	#0,D0
L376:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$375:	.EQU	#0
F410_xxxx_:/* global */
	LINK	A6,L$389
	MOVE.L	A3,-(A7)
	CMPI	#3,14(A6)
	BLS.S	L391
	MOVE	14(A6),D0
	SUBQ	#4,D0
	AND.L	#65535,D0
	DIVU	#4,D0
	MOVE	D0,14(A6)
L391:
	JSR	F051_AA19_(PC)
	MOVE.L	8(A6),A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	12(A6),D0
L392:
	CMP	#0,D0
	BEQ.S	L393
	BRA.S	L395
L393:
DATA SEG "s!"
	DATA 20 4E 45 45 44 53 20 4D 4F 52 45 20 50 52 41 43 54 49 43 45 20 57 49 54 48 20 54 48 49 53 20 00 
CODE SEG "user"
	LEA	s!+64(A4),A0
	MOVE.L	A0,A3
DATA SEG "s!"
	DATA 20 4E 45 45 44 53 20 4D 4F 52 45 20 50 52 41 43 54 49 43 45 20 57 49 54 48 20 54 48 49 53 20 00 
CODE SEG "user"
	PEA	s!+96(A4)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	14(A6),D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 53 50 45 4C 4C 2E 00 
CODE SEG "user"
	LEA	s!+128(A4),A0
	MOVE.L	A0,A3
	BRA.S	L394
	BRA.S	L396
L395:
	CMP	#1,D0
	BEQ.S	L396
	BRA.S	L397
L396:
DATA SEG "s!"
	DATA 20 4D 55 4D 42 4C 45 53 20 41 20 4D 45 41 4E 49 4E 47 4C 45 53 53 20 53 50 45 4C 4C 2E 00 
CODE SEG "user"
	LEA	s!+136(A4),A0
	MOVE.L	A0,A3
	BRA.S	L394
	BRA.S	L398
L397:
	CMP	#10,D0
	BEQ.S	L398
	BRA.S	L399
L398:
DATA SEG "s!"
	DATA 20 4E 45 45 44 53 20 41 4E 20 45 4D 50 54 59 20 46 4C 41 53 4B 20 49 4E 20 48 41 4E 44 20 46 4F 52 20 50 4F 54 49 4F 4E 2E 00 
CODE SEG "user"
	LEA	s!+166(A4),A0
	MOVE.L	A0,A3
L399:
L400:
L394:
	MOVE.L	A3,-(A7)
	MOVE	#4,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L390:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$389:	.EQU	#0
F411_xxxx_:/* global */
	LINK	A6,L$401
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE	#2,D6
	BRA.S	L403
L404:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L406
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#195,D0
	BNE.S	L406
	MOVE	D7,(A2)
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L402
L406:
L403:
	SUBQ	#1,D6
	MOVE	D6,D0
	CMPI	#0,D0
	BGE.S	L404
L405:
	MOVE.L	#0,D0
L402:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$401:	.EQU	#0
F412_xxxx_:/* global */
	LINK	A6,L$407
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L409
	MOVE	#0,D0
	BRA	L408(PC)
L409:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BNE.S	L410
	MOVE	#0,D0
	BRA	L408(PC)
L410:
	LEA	34(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F409_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,A2
	CMPI.L	#0,D0
	BNE.S	L411
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F410_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#0,D0
	BRA	L408(PC)
L411:
	MOVE.B	34(A3),D5
	EXT	D5
	SUB	#95,D5
	JSR	F027_AA59_(PC)
	AND	#7,D0
	MOVE.B	4(A2),D1
	AND	#255,D1
	ADD	D5,D1
	MOVE	D1,D4
	ASL	#4,D1
	ADD	D1,D0
	MOVE	D5,D1
	SUBQ	#1,D1
	MOVE.B	4(A2),D2
	AND	#255,D2
	MULS	D2,D1
	ASL	#3,D1
	ADD	D1,D0
	MOVE	D4,D1
	MULU	D4,D1
	ADD	D1,D0
	MOVE	D0,-4(A6)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	MOVE	D6,D0
	CMP	D4,D0
	BCC.S	L412
	MOVE	D4,D0
	SUB	D6,D0
	MOVE	D0,-6(A6)
	BRA.S	L413
L414:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	MOVE.L	D0,-(A7)
	MOVE	#115,-(A7)
	MOVE.B	80(A3),D0
	AND	#255,D0
	ADD	#15,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	CMP	D1,D0
	BLS.S	L416
	MOVE	-4(A6),D0
	MOVE	D4,D1
	SUB	D6,D1
	LSR	D1,D0
	MOVE	D0,-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	JSR	F410_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#0,D0
	BRA	L408(PC)
L416:
L413:
	MOVE	-6(A6),D0
	SUBQ	#1,-6(A6)
	TST	D0
	BNE.S	L414
L415:
L412:
	MOVE	6(A2),D0
	AND	#15,D0
L417:
	CMP	#1,D0
	BEQ.S	L418
	BRA	L420(PC)
L418:
	PEA	-2(A6)
	MOVE.L	A3,-(A7)
	JSR	F411_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE.L	D0,-10(A6)
	CMPI.L	#0,D0
	BNE.S	L422
	CLR	-(A7)
	MOVE	#10,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F410_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#3,D0
	BRA	L408(PC)
L422:
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
	MOVE.L	-10(A6),A0
	AND	#127,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#-32513,2(A0)
	OR	D3,2(A0)
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE	D5,D1
	MULS	#40,D1
	ADD	D1,D0
	MOVE.L	-10(A6),A0
	AND	#255,D0
	MOVE	D0,D3
	ANDI	#-256,2(A0)
	OR	D3,2(A0)
	MOVE	-2(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	SUB	D4,D0
	ADD	D0,272(A3)
	JSR	F296_aizz_(PC)
	MOVE	G423_i_Inv(A4),D0
	MOVE	D7,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L423
	ORI	#512,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L423:
	BRA	L419(PC)
	BRA.S	L421
L420:
	CMP	#2,D0
	BEQ.S	L421
	BRA.S	L424
L421:
	MOVE.B	28(A3),D0
	AND	#255,D0
	CMP	G308_i_Par(A4),D0
	BEQ.S	L426
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	ORI	#1024,48(A3)
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L426:
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
	CMPI	#4,D0
	BNE.S	L427
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
L427:
	CLR	-(A7)
	MOVE	#255,-(A7)
	MOVE	#4,D1
	MOVE	D6,D0
	ASL	#1,D0
	ADD	D0,D1
	MOVE	D5,D0
	ADDQ	#2,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE	#21,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-(A7)
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
	ADD	#-128,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F327_kzzz_(PC)
	ADDQ.L	#8,A7
	BRA	L419(PC)
	BRA.S	L425
L424:
	CMP	#3,D0
	BEQ.S	L425
	BRA	L428(PC)
L425:
	CLR.B	-15(A6)
	MOVE	D5,D6
	ADDQ	#1,D6
	ASL	#2,D6
	MOVE	6(A2),D0
	LSR	#4,D0
	AND	#63,D0
L430:
	CMP	#0,D0
	BEQ.S	L431
	BRA.S	L433
L431:
	MOVE	#10000,D4
	MOVE	D6,D1
	SUBQ	#8,D1
	ASL	#1,D1
	ASL	#8,D1
	ADD	D1,D4
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	SUBQ	#1,D6
	BRA.S	L31T412_019
	BRA.S	L434
L433:
	CMP	#5,D0
	BEQ.S	L434
	BRA.S	L435
L434:
	MOVE	#2000,D4
	MOVE	D6,D1
	SUBQ	#3,D1
	ASL	#7,D1
	ADD	D1,D4
	MOVE	D6,D0
	LSR	#2,D0
	MOVE	D0,D6
	ADDQ	#1,D6
L31T412_019:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D0,G407_s_Par+3200(A4)
	MOVE	D4,-(A7)
	MOVE	D6,D0
	NEG	D0
	MOVE	D0,-(A7)
	JSR	F404_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L432(PC)
	BRA.S	L436
L435:
	CMP	#1,D0
	BEQ.S	L436
	BRA.S	L437
L436:
	MOVE	D6,D0
	LSR	#2,D0
	MOVE	D0,D6
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G039_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D0,G407_s_Par+3200(A4)
	MOVE	#98,-(A7)
	MOVE	D6,-(A7)
	JSR	F404_xxxx_(PC)
	ADDQ.L	#4,A7
	BRA	L432(PC)
	BRA.S	L438
L437:
	CMP	#2,D0
	BEQ.S	L438
	BRA.S	L439
L438:
	MOVE.B	#73,-16(A6)
	ADDQ.B	#1,G407_s_Par+3202(A4)
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,D6
	BRA.S	L31T412_032
	BRA.S	L440
L439:
	CMP	#3,D0
	BEQ.S	L440
	BRA.S	L441
L440:
	MOVE.B	#71,-16(A6)
	ADDQ.B	#1,G407_s_Par+3286(A4)
	BRA.S	L31T412_033
	BRA.S	L442
L441:
	CMP	#4,D0
	BEQ.S	L442
	BRA.S	L443
L442:
	MOVE.B	#74,-16(A6)
	MOVE	D6,-14(A6)
	CMPI	#50,G407_s_Par+3204(A4)
	BLE.S	L445
	MOVE	-14(A6),D0
	ASR	#2,D0
	MOVE	D0,-14(A6)
L445:
	MOVE	-14(A6),D0
	ADD	D0,G407_s_Par+3204(A4)
	JSR	F260_pzzz_(PC)
	BRA.S	L31T412_032
	BRA.S	L444
L443:
	CMP	#6,D0
	BEQ.S	L444
	BRA.S	L446
L444:
	MOVE.B	#79,-16(A6)
	ADDQ.B	#1,G407_s_Par+3203(A4)
	MOVE.B	G407_s_Par+3210(A4),G407_s_Par+3212(A4)
	CMPI	#3,D5
	BGE.S	L448
	MOVE.B	G407_s_Par+3212(A4),G407_s_Par+3213(A4)
	BRA.S	L449
L448:
	CLR.B	G407_s_Par+3213(A4)
L449:
L31T412_032:
	MOVE	D6,D0
	MULU	D6,D0
	MOVE	D0,D6
L31T412_033:
	MOVE.L	G313_ul_Ga(A4),D0
	AND.L	#65535,D6
	ADD.L	D6,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA	L432(PC)
	BRA.S	L447
L446:
	CMP	#7,D0
	BEQ.S	L447
	BRA	L450(PC)
L447:
	MOVE	#10,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	CMPI	#-1,D0
	BNE.S	L452
	BRA	L432(PC)
L452:
	MOVE	-2(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-24(A6)
	MOVE	#51,D0
	MOVE.L	-24(A6),A0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A0)
	OR	D3,2(A0)
	CMPI	#-1,212(A3)
	BNE.S	L453
	CLR	D6
	BRA.S	L454
L453:
	CMPI	#-1,214(A3)
	BNE.S	L455
	MOVE	#1,D6
	BRA.S	L456
L455:
	MOVE	#-1,D6
L456:
L454:
	CMPI	#0,D6
	BEQ.S	L458
	CMPI	#1,D6
	BNE.S	L457
L458:
	MOVE	D6,-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L459
L457:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L459:
	BRA.S	L432
	BRA.S	L451
L450:
	CMP	#8,D0
	BEQ.S	L451
	BRA.S	L460
L451:
	CLR	-(A7)
	MOVE	D6,D0
	MULU	D6,D0
	ADD	#100,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	MOVE.L	A3,-(A7)
	JSR	F403_xxxx_(PC)
	ADDA	#10,A7
L460:
L461:
L432:
L428:
L429:
L419:
	MOVE	-4(A6),-(A7)
	MOVE.B	5(A2),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	MOVE	6(A2),D0
	LSR	#2,D0
	LSR	#8,D0
	AND	#63,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F330_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
L408:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$407:	.EQU	#-24
