CODE SEG "init!"
	MOVE.L	#-200,G361_l_Las(A4)
BSS SEG "bss"
G361_l_Las:/* global */
	.WORD	#4
G362_l_Las:/* global */
	.WORD	#4
G363_i_Sec:/* global */
	.WORD	#2
G364_i_Cre:/* global */
	.WORD	#2
G365_B_Cre:/* global */
	.WORD	#2
G366_i_Pro:/* global */
	.WORD	#2
G367_i_Pro:/* global */
	.WORD	#2
CODE SEG "timeline"
F212_mzzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#14,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#-1,D0
	BNE.S	L2
	BRA	L1(PC)
L2:
	MOVE	D6,D0
	AND	#16383,D0
	MOVE	14(A6),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,D6
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	D7,2(A3)
	MOVE	#255,-(A7)
	MOVE.B	19(A6),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.B	D0,4(A3)
	MOVE.B	21(A6),5(A3)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#1,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE	G365_B_Cre(A4),D0
	BEQ.S	L3
	MOVE.B	#49,-6(A6)
	BRA.S	L4
L3:
	MOVE.B	#48,-6(A6)
L4:
	CLR.B	-5(A6)
	MOVE	D6,-4(A6)
	MOVE	10(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-2(A6)
	OR	D3,-2(A6)
	MOVE	12(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-2(A6)
	OR	D3,-2(A6)
	MOVE.B	23(A6),D0
	AND	#255,D0
	AND	#15,D0
	MOVE	D0,D3
	ASL	#4,D3
	ASL	#8,D3
	ANDI	#4095,-2(A6)
	OR	D3,-2(A6)
	MOVE	16(A6),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-3073,-2(A6)
	OR	D3,-2(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,6(A3)
L1:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#-10
F213_hzzz_:/* global */
	LINK	A6,L$5
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	10(A6),D7
	MOVE	12(A6),D6
	MOVE	14(A6),D5
	MOVE	#15,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-6(A6)
	CMPI	#-1,D0
	BNE.S	L7
	BRA	L6(PC)
L7:
	MOVE	-6(A6),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+60(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#255,D6
	BHI.S	L8
	MOVE	D6,-8(A6)
	MOVE	D5,-10(A6)
	BRA.S	L9
L8:
	MOVE	D6,D0
	AND	#255,D0
	MOVE	D0,-8(A6)
	MOVE	D5,D0
	AND	#255,D0
	MOVE	D0,-10(A6)
	MOVE	D6,D0
	LSR	#8,D0
	MOVE	D0,D6
	SUBQ	#1,D6
	MOVE	D5,D0
	LSR	#8,D0
	MOVE	D0,D5
L9:
	CMPI	#255,16(A6)
	BNE.S	L10
	MOVE	#1,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ANDI	#-129,2(A3)
	OR	D3,2(A3)
	BRA.S	L11
L10:
	MOVE	#0,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ANDI	#-129,2(A3)
	OR	D3,2(A3)
	MOVE	-6(A6),D0
	AND	#16383,D0
	MOVE	16(A6),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-6(A6)
L11:
	MOVE	8(A6),D0
	SUB	#-128,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A3)
	OR	D3,2(A3)
	MOVE	D7,D0
	AND	#255,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#255,2(A3)
	OR	D3,2(A3)
	CMPI	#-125,8(A6)
	BCC.S	L12
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	CMPI	#80,D7
	BLS.S	L13
	MOVE	#5,D0
	BRA.S	L14
L13:
	MOVE	#20,D0
L14:
	MOVE	D0,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA.S	L15
L12:
	CMPI	#-88,8(A6)
	BEQ.S	L16
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	#13,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L16:
L15:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	CLR	-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
	MOVE.L	G313_ul_Ga(A4),D0
	CMPI	#-28,8(A6)
	BNE.S	L17
	MOVE	#5,D1
	BRA.S	L18
L17:
	MOVE	#1,D1
L18:
	AND.L	#65535,D1
	ADD.L	D1,D0
	MOVE	G272_i_Cur(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-20(A6)
	MOVE.B	#25,-16(A6)
	CLR.B	-15(A6)
	MOVE	-6(A6),-12(A6)
	MOVE	D6,D0
	MOVE.B	D0,-14(A6)
	MOVE	D5,D0
	MOVE.B	D0,-13(A6)
	PEA	-20(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-126,8(A6)
	BEQ.S	L20
	CMPI	#-128,8(A6)
	BNE	L19(PC)
L20:
	MOVE	-8(A6),D6
	MOVE	-10(A6),D5
	MOVE	D7,D0
	LSR	#1,D0
	ADDQ	#1,D0
	MOVE	D0,D7
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D7,D0
	SWAP	D0
	ADDQ	#1,D0
	ADD	D0,D7
	CMPI	#-128,8(A6)
	BEQ.S	L22
	MOVE	D7,D0
	LSR	#1,D0
	MOVE	D0,D7
	BEQ	L21(PC)
L22:
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L23
	MOVE	D6,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L23
	MOVE	D5,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	BNE.S	L23
	MOVE	#1,-(A7)
	MOVE	#63,-(A7)
	MOVE	D7,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	BRA	L6(PC)
L23:
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-6(A6)
	CMPI	#-2,D0
	BEQ	L24(PC)
	MOVE	-6(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	18(A2),D0
	LSR	#4,D0
	AND	#15,D0
	MOVE	D0,D4
	CMPI	#15,D0
	BEQ.S	L25
	MOVE	2(A2),D0
	AND	#64,D0
	BEQ.S	L26
	MOVE	D7,D0
	LSR	#2,D0
	MOVE	D0,D7
L26:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE	D4,D0
	ASL	#1,D0
	ADDQ	#1,D0
	AND.L	#65535,D1
	DIVU	D0,D1
	SWAP	D1
	MOVE	D7,D0
	SUB	D1,D0
	MOVE	D0,D7
	CMPI	#0,D0
	BLS.S	L27
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	MOVE	D0,G364_i_Cre(A4)
L27:
L25:
L24:
L21:
L19:
L6:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$5:	.EQU	#-20
F214_pzzz_:/* global */
	LINK	A6,L$28
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	6(A0),-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L29:
	UNLK	A6
	RTS
L$28:	.EQU	#-4
F215_lzzz_:/* global */
	LINK	A6,L$30
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	2(A3),D0
	MOVE	D0,D6
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#15,D0
	BEQ.S	L32
	CMPI.L	#0,10(A6)
	BEQ.S	L33
	MOVE.L	10(A6),A0
	MOVE	(A0),D0
	MOVE	D0,D7
	CMPI	#-2,D0
	BNE.S	L34
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE	#-2,(A0)
	MOVE.L	10(A6),A0
	MOVE	D6,(A0)
	BRA.S	L35
L34:
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D7,-(A7)
	MOVE	D6,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
L35:
	BRA.S	L36
L33:
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	CLR	-(A7)
	MOVE	#-2,-(A7)
	MOVE	D6,D0
	AND	#16383,D0
	MOVE	8(A6),D1
	AND	#-16384,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L36:
L32:
	MOVE	#-1,(A3)
L31:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$30:	.EQU	#-14
F216_xxxx_:/* global */
	LINK	A6,L$37
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	CLR	G366_i_Pro(A4)
	MOVE	#3,G367_i_Pro(A4)
	MOVE.B	4(A3),D5
	AND	#255,D5
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D6
	CMPI	#15,D0
	BEQ.S	L39
	CMPI	#5,D6
	BNE.S	L40
	MOVE	D7,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	3(A2),D6
	AND	#255,D6
	MOVE	#3,G367_i_Pro(A4)
	BRA.S	L41
L40:
	JSR	F029_AA19_(PC)
	MOVE	D0,D6
L41:
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	LSR	#1,D0
	ADD	D0,D6
	BRA	L42(PC)
L39:
	CMPI	#-127,D7
	BNE.S	L43
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE	D0,D6
	MOVE	D6,D0
	ADD	#10,D0
	MOVE	D0,G366_i_Pro(A4)
	JSR	F027_AA59_(PC)
	AND	#31,D0
	ADD	D0,D6
	BRA.S	L44
L43:
	CMPI	#-125,D7
	BCS.S	L45
	MOVE	#5,G367_i_Pro(A4)
	CMPI	#-122,D7
	BNE.S	L46
	MOVE	D5,G366_i_Pro(A4)
	MOVE	#1,D0
	BRA	L38(PC)
L46:
	MOVE	#0,D0
	BRA	L38(PC)
L45:
	MOVE	#1,G367_i_Pro(A4)
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE.L	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	AND	#15,D1
	ADD	D1,D0
	ADD	#10,D0
	MOVE	D0,D6
	CMPI	#-126,D7
	BNE.S	L47
	MOVE	#7,G367_i_Pro(A4)
	MOVE	D6,D0
	MULU	#5,D0
	MOVE	D0,D6
L47:
L44:
L42:
	MOVE	D6,D0
	ADD	D5,D0
	LSR	#4,D0
	ADDQ	#1,D0
	MOVE	D0,D6
	JSR	F027_AA59_(PC)
	MOVE	D6,D1
	LSR	#1,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE.L	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	ADD	D0,D6
	MOVE	#32,D1
	MOVE.B	5(A3),D0
	AND	#255,D0
	ASR	#3,D0
	SUB	D0,D1
	MOVE	D6,D0
	SUB	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,D0
	LSR	#1,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	MOVE	D6,D0
L38:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$37:	.EQU	#0
F217_xxxx_:/* global */
	LINK	A6,L$48
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	16(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A3
	MOVE	10(A6),-32(A6)
	MOVE	12(A6),-34(A6)
	CLR	-56(A6)
	CLR	G364_i_Cre(A4)
	MOVE	2(A3),D0
	MOVE	D0,D7
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,-58(A6)
	CMPI	#8,D0
	BNE.S	L50
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#32512,D0
	LSR	#8,D0
L51:
	CMP	#3,D0
	BEQ.S	L52
	BRA.S	L54
L52:
	MOVE	#-121,-26(A6)
	BRA.S	L5T217_004
	BRA.S	L55
L54:
	CMP	#19,D0
	BEQ.S	L55
	BRA.S	L56
L55:
	MOVE	#-128,-26(A6)
L5T217_004:
	MOVE	#1,-56(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#255,D0
	MOVE	D0,-54(A6)
	MOVE.L	A2,D0
	MOVE.L	D0,-4(A6)
L56:
L57:
L53:
L50:
	CMPI	#15,-58(A6)
	SEQ	D0
	TST.B	D0
	BEQ.S	L59
	CMPI	#-127,D7
	SNE	D0
	TST.B	D0
L59:
	TST.B	D0
	BEQ.S	L58
	CMPI	#-122,D7
	SNE	D0
	TST.B	D0
L58:
	AND	#1,D0
	MOVE	D0,-48(A6)
	CLR.L	-24(A6)
	CLR	D4
	CMPI	#255,10(A6)
	BGT.S	L60
	MOVE	10(A6),-28(A6)
	MOVE	12(A6),-30(A6)
	BRA.S	L61
L60:
	MOVE	10(A6),D0
	ASR	#8,D0
	SUBQ	#1,D0
	MOVE	D0,-28(A6)
	MOVE	12(A6),D0
	ASR	#8,D0
	MOVE	D0,-30(A6)
	ANDI	#255,10(A6)
	ANDI	#255,12(A6)
L61:
	MOVE	8(A6),D0
L62:
	CMP	#4,D0
	BEQ.S	L63
	BRA	L65(PC)
L63:
	MOVE	10(A6),D6
	ASL.L	#2,D6
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D6,A0
	MOVE.L	(A0),A0
	ADDA	12(A6),A0
	MOVE.B	(A0),D6
	AND	#255,D6
	MOVE.B	D6,-35(A6)
	AND	#255,D6
	AND	#7,D6
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F157_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-12(A6)
	CMPI	#5,D6
	BEQ.S	L67
	CMPI	#-124,D7
	BNE.S	L67
	MOVE.L	-12(A6),A0
	MOVE	2(A0),D0
	AND	#64,D0
	LSR	#6,D0
	BEQ.S	L68
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#1,D0
	MOVE.L	D0,-(A7)
	MOVE	#2,-(A7)
	CLR	-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	#10,-(A7)
	JSR	F268_fzzz_(PC)
	ADDA	#14,A7
L68:
	BRA	L64(PC)
L67:
	CMPI	#5,D6
	BEQ	L70(PC)
	CMPI	#1,D6
	BLE	L70(PC)
	MOVE.L	-12(A6),A0
	MOVE	2(A0),D0
	AND	#1,D0
	ASL.L	#1,D0
	LEA	G275_as_Cu(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#2,D0
	BEQ	L69(PC)
	CMPI	#15,-58(A6)
	BNE.S	L71
	CMPI	#-125,D7
	SCC	D0
	AND	#1,D0
	BRA.S	L72
L71:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	MOVE	D0,-72(A6)
	MOVE.B	5(A3),D0
	AND	#255,D0
	CMP	-72(A6),D0
	SHI	D0
	TST.B	D0
	BEQ.S	L74
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	AND	#256,D0
L74:
	SNE	D0
	TST.B	D0
	BEQ.S	L73
	CMPI	#10,-58(A6)
	SNE	D0
	TST.B	D0
	BNE.S	L76
	MOVE	D7,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#0,D0
	SLT	D0
	TST.B	D0
L76:
	TST.B	D0
	BNE.S	L75
	CMPI	#176,D6
	SGE	D0
	TST.B	D0
	BEQ.S	L77
	CMPI	#191,D6
	SLE	D0
	TST.B	D0
L77:
	TST.B	D0
	SEQ	D0
	TST.B	D0
L75:
	TST.B	D0
L73:
	AND	#1,D0
L72:
	BEQ.S	L69
L70:
	MOVE	#0,D0
	BRA	L49(PC)
L69:
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F216_xxxx_(PC)
	ADDQ.L	#6,A7
	ADDQ	#1,D0
	MOVE	D0,D5
	CLR	-(A7)
	CLR	-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND.L	#65535,D1
	DIVU	D5,D1
	SWAP	D1
	MOVE	D5,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F232_dzzz_(PC)
	ADDA	#10,A7
	BRA	L64(PC)
	BRA.S	L66
L65:
	CMP	#-2,D0
	BEQ.S	L66
	BRA.S	L78
L66:
	MOVE	14(A6),-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,14(A6)
	CMPI	#0,D0
	BGE.S	L80
	MOVE	#0,D0
	BRA	L49(PC)
L80:
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F216_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D5
	MOVE	D0,D4
	BRA	L64(PC)
	BRA.S	L79
L78:
	CMP	#-1,D0
	BEQ.S	L79
	BRA	L81(PC)
L79:
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	14(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F176_avzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-62(A6)
	BNE.S	L83
	MOVE	#0,D0
	BRA	L49(PC)
L83:
	SUBQ	#1,-62(A6)
	MOVE.B	4(A2),D0
	AND	#255,D0
	MOVE	D0,-60(A6)
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
	CMPI	#-128,D7
	BNE.S	L84
	CMPI	#11,-60(A6)
	BNE.S	L84
	MOVE	-62(A6),D0
	ASL.L	#1,D0
	LEA	6(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-20(A6)
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F216_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D1
	MOVE.L	-20(A6),A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#1000,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	-20(A6),A0
	MOVE	D0,(A0)
	BRA	L5T217_044(PC)
L84:
	MOVE.L	-8(A6),A0
	MOVE	2(A0),D0
	AND	#64,D0
	BEQ.S	L85
	CMPI	#-125,D7
	BEQ.S	L85
	MOVE	#0,D0
	BRA	L49(PC)
L85:
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F216_xxxx_(PC)
	ADDQ.L	#6,A7
	AND.L	#65535,D0
	ASL.L	#6,D0
	MOVE.L	-8(A6),A0
	MOVE.B	8(A0),D1
	AND	#255,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	MOVE	D0,D5
	BEQ	L86(PC)
	MOVE	#1,-(A7)
	MOVE	G366_i_Pro(A4),-(A7)
	MOVE	-60(A6),-(A7)
	JSR	F192_ayzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	D5,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	-62(A6),-(A7)
	MOVE.L	A2,-(A7)
	JSR	F190_zzzz_(PC)
	ADDA	#14,A7
	MOVE	D0,D6
	CMPI	#2,D0
	BEQ.S	L87
	CLR	-(A7)
	MOVE	#-2,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L87:
	MOVE	D6,G364_i_Cre(A4)
	MOVE	-48(A6),D0
	BNE.S	L88
	CMPI	#0,D6
	BNE.S	L88
	CMPI	#5,-58(A6)
	BNE.S	L88
	MOVE.L	-8(A6),A0
	MOVE	2(A0),D0
	AND	#1024,D0
	BEQ.S	L88
	MOVE	D7,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-16(A6)
	MOVE.L	-16(A6),A0
	MOVE	2(A0),D6
	AND	#127,D6
	CMPI	#8,D6
	BEQ.S	L90
	CMPI	#27,D6
	BEQ.S	L90
	CMPI	#28,D6
	BEQ.S	L90
	CMPI	#31,D6
	BEQ.S	L90
	CMPI	#32,D6
	BNE.S	L89
L90:
	LEA	2(A2),A0
	MOVE.L	A0,-24(A6)
L89:
L88:
L86:
L81:
L82:
L64:
	MOVE	D4,D0
	BEQ.S	L91
	MOVE	G367_i_Pro(A4),-(A7)
	MOVE	#12,-(A7)
	MOVE	D5,-(A7)
	MOVE	14(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L91
	MOVE	G366_i_Pro(A4),D0
	BEQ.S	L91
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L91
	MOVE	G366_i_Pro(A4),-(A7)
	MOVE	14(A6),-(A7)
	JSR	F322_lzzz_(PC)
	ADDQ.L	#4,A7
L91:
	MOVE	-48(A6),D0
	BNE.S	L93
	MOVE	-56(A6),D0
	BEQ.S	L92
L93:
	MOVE	-56(A6),D0
	BEQ.S	L94
	MOVE	-26(A6),D7
	MOVE	-54(A6),-52(A6)
	BRA.S	L95
L94:
	MOVE.B	4(A3),D0
	AND	#255,D0
	MOVE	D0,-52(A6)
L95:
	CMPI	#-126,D7
	BNE.S	L96
	MOVE	-52(A6),D0
	LSR	#1,D0
	MOVE	D0,-52(A6)
	BNE.S	L96
	BRA.S	L5T217_044
L96:
	CMPI	#-121,D7
	BNE.S	L97
	MOVE	#255,D0
	BRA.S	L98
L97:
	MOVE	14(A6),D0
L98:
	MOVE	D0,-(A7)
	MOVE	-34(A6),-(A7)
	MOVE	-32(A6),-(A7)
	MOVE	-52(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F213_hzzz_(PC)
	ADDA	#10,A7
	BRA.S	L99
L92:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L100
	CLR	-52(A6)
	BRA.S	L101
L100:
	CMPI	#-122,D7
	BNE.S	L102
	MOVE	#13,-52(A6)
	BRA.S	L103
L102:
	MOVE	#4,-52(A6)
L103:
L101:
	MOVE	#1,-(A7)
	MOVE	-30(A6),-(A7)
	MOVE	-28(A6),-(A7)
	MOVE	-52(A6),-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
L99:
L5T217_044:
	MOVE	-56(A6),D0
	BEQ.S	L104
	MOVE.L	-4(A6),A0
	MOVE	#-1,(A0)
	MOVE	-26(A6),2(A3)
L104:
	MOVE	-30(A6),-(A7)
	MOVE	-28(A6),-(A7)
	CLR	-(A7)
	MOVE	16(A6),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-30(A6),-(A7)
	MOVE	-28(A6),-(A7)
	MOVE.L	-24(A6),-(A7)
	MOVE	16(A6),-(A7)
	JSR	F215_lzzz_(PC)
	ADDA	#10,A7
	MOVE	#1,D0
L49:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$48:	.EQU	#-72
F218_ezzz_:/* global */
	LINK	A6,L$105
	MOVEM.L	D7-D5,-(A7)
	MOVE	14(A6),D7
	CLR	D5
	CLR	G364_i_Cre(A4)
L6T218_001:
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	BRA.S	L107
L108:
	MOVE	D6,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#14,D0
	BNE.S	L111
	MOVE	D6,D0
	LSR	#6,D0
	LSR	#8,D0
	MOVE	D7,D1
	CMP	D1,D0
	BNE.S	L111
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F217_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L111
	MOVE	D6,-(A7)
	JSR	F214_pzzz_(PC)
	ADDQ.L	#2,A7
	ADDQ	#1,D5
	CMPI	#-1,8(A6)
	BNE.S	L112
	CMPI	#2,G364_i_Cre(A4)
	BNE.S	L112
	BRA.S	L110
L112:
	BRA.S	L6T218_001
L111:
L109:
	MOVE	D6,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
L107:
	CMPI	#-2,D6
	BNE.S	L108
L110:
	MOVE	D5,D0
L106:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$105:	.EQU	#0
F219_xxxx_:/* global */
	LINK	A6,L$113
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A0
	LEA	(A0),A1
	LEA	-22(A6),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
	LEA	-22(A6),A0
	MOVE.L	A0,A3
	MOVE	6(A3),D0
	MOVE	D0,D7
	MOVE	D0,-2(A6)
	MOVE	D0,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	8(A3),D0
	AND	#31,D0
	MOVE	D0,-6(A6)
	MOVE	8(A3),D0
	AND	#992,D0
	LSR	#5,D0
	MOVE	D0,-8(A6)
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#48,D0
	BNE.S	L115
	MOVE.B	#49,4(A3)
	BRA	L116(PC)
L115:
	MOVE	D7,D4
	LSR	#6,D4
	LSR	#8,D4
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE.S	L117
	MOVE	-6(A6),D0
	CMP	G306_i_Par(A4),D0
	BNE.S	L117
	MOVE	-8(A6),D0
	CMP	G307_i_Par(A4),D0
	BNE.S	L117
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#-2,-(A7)
	JSR	F217_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L117
	BRA	L114(PC)
L117:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-2,D0
	BEQ.S	L118
	MOVE	-2(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#-1,-(A7)
	JSR	F217_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L118
	BRA	L114(PC)
L118:
	MOVE.B	4(A2),D0
	MOVE	8(A3),D1
	AND	#-4096,D1
	LSR	#4,D1
	LSR	#8,D1
	MOVE	D1,D6
	AND	#255,D0
	CMP	D1,D0
	BHI.S	L119
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	CLR	-(A7)
	MOVE	-2(A6),D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	CLR.L	-(A7)
	MOVE	D7,-(A7)
	JSR	F215_lzzz_(PC)
	ADDA	#10,A7
	BRA	L114(PC)
L119:
	MOVE	D6,D0
	SUB.B	D0,4(A2)
	MOVE.B	5(A2),D0
	AND	#255,D0
	CMP	D6,D0
	BCC.S	L120
	CLR.B	5(A2)
	BRA.S	L121
L120:
	MOVE	D6,D0
	SUB.B	D0,5(A2)
L121:
L116:
	MOVE	8(A3),D0
	AND	#3072,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D5
	MOVE	6(A3),D1
	MOVE	D1,D7
	LSR	#6,D1
	LSR	#8,D1
	MOVE	D1,D4
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
	BNE.S	L123
	MOVE	D5,D0
	ADDQ	#1,D0
	AND	#3,D0
	MOVE	D4,D1
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
L123:
	AND	#1,D0
	MOVE	D0,-4(A6)
	BEQ	L122(PC)
	MOVE	-6(A6),-10(A6)
	MOVE	-8(A6),-12(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-6(A6),D0
	ADD	D1,D0
	MOVE	D0,-6(A6)
	MOVE	D5,D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	MOVE	D0,D6
	LSR	#5,D0
	CMPI	#0,D0
	BEQ.S	L125
	MOVE	D6,D0
	LSR	#5,D0
	CMPI	#6,D0
	BNE.S	L126
	MOVE	D6,D0
	AND	#5,D0
	BEQ.S	L125
L126:
	MOVE	D6,D0
	LSR	#5,D0
	CMPI	#3,D0
	BNE.S	L124
	MOVE	-10(A6),D0
	ASL.L	#2,D0
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),A0
	ADDA	-12(A6),A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ASR	#5,D0
	CMPI	#3,D0
	BNE.S	L124
L125:
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D6,D0
	LSR	#5,D0
	MOVE	D0,-(A7)
	JSR	F217_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L127
	BRA	L114(PC)
L127:
L124:
L122:
	MOVE	D5,D0
	AND	#1,D0
	MOVE	D4,D1
	AND	#1,D1
	CMP	D1,D0
	BNE.S	L128
	SUBQ	#1,D4
	BRA.S	L129
L128:
	ADDQ	#1,D4
L129:
	MOVE	D4,D1
	AND	#3,D1
	MOVE	D1,D4
	ASL	#6,D1
	ASL	#8,D1
	MOVE	D7,D0
	AND	#16383,D0
	OR	D1,D0
	MOVE	D0,D7
	MOVE	-4(A6),D0
	BEQ	L130(PC)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	-12(A6),-(A7)
	MOVE	-10(A6),-(A7)
	MOVE	D7,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	G397_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,8(A3)
	OR	D3,8(A3)
	MOVE	G398_i_Mov(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,8(A3)
	OR	D3,8(A3)
	MOVE	G400_i_Mov(A4),D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#-3073,8(A3)
	OR	D3,8(A3)
	MOVE	D7,D0
	AND	#16383,D0
	MOVE	G401_ui_Mo(A4),D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,D7
	MOVE.L	(A3),D0
	AND.L	#16777215,D0
	MOVE	G399_ui_Mo(A4),D1
	AND.L	#65535,D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A3)
	BRA.S	L131
L130:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F151_rzzz_(PC)
	ADDQ.L	#4,A7
	AND	#255,D0
	ASR	#5,D0
	CMPI	#4,D0
	BNE.S	L132
	MOVE	-2(A6),-(A7)
	MOVE	D4,-(A7)
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	MOVE	#4,-(A7)
	JSR	F217_xxxx_(PC)
	ADDA	#10,A7
	TST	D0
	BEQ.S	L132
	BRA.S	L114
L132:
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	-8(A6),-(A7)
	MOVE	-6(A6),-(A7)
	CLR	-(A7)
	MOVE	D7,-(A7)
	JSR	F163_amzz_(PC)
	ADDQ.L	#8,A7
L131:
	ADDQ.L	#1,(A3)
	MOVE	D7,6(A3)
	MOVE.L	A3,-(A7)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,6(A2)
L114:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$113:	.EQU	#-22
F220_xxxx_:/* global */
	LINK	A6,L$133
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	6(A3),D7
	AND	#255,D7
	MOVE.B	7(A3),D6
	AND	#255,D6
	MOVE	8(A3),D0
	AND	#1023,D0
	MOVE.L	G284_apuc_+60(A4),D1
	ASL.L	#2,D0
	MOVE.L	D1,A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	D6,D4
	MOVE	D7,D1
	ASL.L	#2,D1
	MOVE.L	G271_ppuc_(A4),A0
	ADDA	D1,A0
	MOVE.L	(A0),A0
	ADDA	D4,A0
	MOVE.B	(A0),D4
	AND	#255,D4
	ASR	#5,D4
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L136
	MOVE	D7,D0
	MOVE	G306_i_Par(A4),D1
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
L136:
	TST.B	D0
	BEQ.S	L135
	MOVE	D6,D0
	MOVE	G307_i_Par(A4),D1
	CMP	D1,D0
	SEQ	D0
	TST.B	D0
L135:
	AND	#1,D0
	MOVE	D0,-16(A6)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F175_gzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-10(A6)
	CMPI	#-2,D0
	BEQ.S	L137
	MOVE	-10(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	MOVE.L	-4(A6),A0
	MOVE.B	4(A0),D0
	AND	#255,D0
	MOVE	D0,-14(A6)
	MULS	#26,D0
	LEA	G243_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-8(A6)
L137:
	MOVE	#-128,D0
	MOVE	2(A2),D1
	AND	#127,D1
	ADD	D1,D0
	MOVE	D0,-12(A6)
	CMPI	#-121,D0
	BNE.S	L138
	MOVE	#4,-(A7)
	MOVE	2(A2),D0
	AND	#-256,D0
	LSR	#8,D0
	LSR	#5,D0
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	BRA.S	L139
L138:
	MOVE	2(A2),D5
	AND	#-256,D5
	LSR	#8,D5
	LSR	#1,D5
	ADDQ	#1,D5
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	D5,D0
	SWAP	D0
	ADDQ	#1,D0
	ADD	D0,D5
L139:
	MOVE	-12(A6),D0
L140:
	CMP	#-126,D0
	BEQ.S	L141
	BRA.S	L143
L141:
	MOVE	D5,D0
	ASR	#1,D0
	MOVE	D0,D5
	BNE.S	L145
	BRA	L142(PC)
L145:
	BRA.S	L144
L143:
	CMP	#-128,D0
	BEQ.S	L144
	BRA.S	L146
L144:
	CMPI	#4,D4
	BNE.S	L148
	CLR	-(A7)
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F232_dzzz_(PC)
	ADDA	#10,A7
L148:
	BRA	L142(PC)
	BRA.S	L147
L146:
	CMP	#-125,D0
	BEQ.S	L147
	BRA	L149(PC)
L147:
	CMPI	#-2,-10(A6)
	BEQ	L151(PC)
	MOVE.L	-8(A6),A0
	MOVE	2(A0),D0
	AND	#64,D0
	BEQ	L151(PC)
	CMPI	#19,-14(A6)
	BNE	L152(PC)
	MOVE	G272_i_Cur(A4),D0
	CMP	G309_i_Par(A4),D0
	BNE	L152(PC)
	MOVE	D5,D0
	ASR	#3,D0
	MOVE	D0,-14(A6)
	SUB	D0,D5
	MOVE	-14(A6),D0
	ASL	#1,D0
	MOVE	D0,-14(A6)
	ADDQ	#1,-14(A6)
	MOVE.L	-4(A6),A0
	MOVE	14(A0),D4
	AND	#96,D4
	LSR	#5,D4
L153:
	MOVE.L	-4(A6),A0
	MOVE.B	5(A0),D0
	AND	#255,D0
	MULS	#16,D0
	MOVE.L	G375_ps_Ac(A4),A0
	ADDA	D0,A0
	LEA	12(A0),A0
	ADDA	D4,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	AND	#128,D0
	BEQ.S	L156
	MOVE	#1,-(A7)
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	-14(A6),D0
	SWAP	D0
	MOVE	D0,-36(A6)
	MOVE	D5,D0
	ADD	-36(A6),D0
	MOVE.L	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	D4,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F190_zzzz_(PC)
	ADDA	#14,A7
L156:
L154:
	SUBQ	#1,D4
	MOVE	D4,D0
	CMPI	#0,D0
	BGE.S	L153
L155:
	BRA.S	L157
L152:
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
L157:
L151:
	BRA	L142(PC)
	BRA.S	L150
L149:
	CMP	#-28,D0
	BEQ.S	L150
	BRA.S	L158
L150:
	MOVE	2(A2),D0
	AND	#127,D0
	ADDQ	#1,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A2)
	OR	D3,2(A2)
	MOVE	#1,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	#5,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	BRA	L8T220_026(PC)
	BRA.S	L159
L158:
	CMP	#-88,D0
	BEQ.S	L159
	BRA.S	L160
L159:
	MOVE	2(A2),D0
	AND	#-256,D0
	LSR	#8,D0
	CMPI	#55,D0
	BLS.S	L162
	MOVE	2(A2),D0
	AND	#-256,D0
	LSR	#8,D0
	SUB	#40,D0
	AND	#255,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#255,2(A2)
	OR	D3,2(A2)
	BRA	L8T220_026(PC)
L162:
	BRA	L142(PC)
	BRA.S	L161
L160:
	CMP	#-121,D0
	BEQ.S	L161
	BRA	L163(PC)
L161:
	MOVE	-16(A6),D0
	BEQ.S	L165
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D5,-(A7)
	JSR	F324_aezz_(PC)
	ADDQ.L	#6,A7
	BRA.S	L166
L165:
	CMPI	#-2,-10(A6)
	BEQ.S	L167
	MOVE	D5,-(A7)
	MOVE	-14(A6),-(A7)
	JSR	F192_ayzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	BEQ.S	L167
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	-4(A6),-(A7)
	JSR	F191_aayz_(PC)
	ADDA	#12,A7
	CMPI	#2,D0
	BEQ.S	L167
	CMPI	#2,D5
	BLE.S	L167
	CLR	-(A7)
	MOVE	#-3,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F209_xzzz_(PC)
	ADDQ.L	#8,A7
L167:
L166:
	MOVE	2(A2),D0
	AND	#-256,D0
	LSR	#8,D0
	CMPI	#6,D0
	BCS.S	L168
	MOVE	2(A2),D0
	AND	#-256,D0
	LSR	#8,D0
	SUBQ	#3,D0
	AND	#255,D0
	MOVE	D0,D3
	ASL	#8,D3
	ANDI	#255,2(A2)
	OR	D3,2(A2)
L8T220_026:
	LEA	(A3),A1
	LEA	-26(A6),A0
	MOVEQ	#4,D0
	JSR	_blockmv(PC)
	ADDQ.L	#1,-26(A6)
	PEA	-26(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	BRA.S	L134
L168:
L163:
L164:
L142:
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	CLR	-(A7)
	MOVE	8(A3),-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	#-1,(A2)
L134:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$133:	.EQU	#-36
