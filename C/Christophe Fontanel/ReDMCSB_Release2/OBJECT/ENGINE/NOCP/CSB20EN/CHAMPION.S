BSS SEG "bss"
G407_s_Par:/* global */
	.WORD	#3328
G409_ai_Ch:/* global */
	.WORD	#8
G410_ai_Ch:/* global */
	.WORD	#8
CODE SEG "init!"
	MOVE	#-1,G411_i_Lea(A4)
BSS SEG "bss"
G411_i_Lea:/* global */
	.WORD	#2
G412_puc_B:/* global */
	.WORD	#4
G413_i_Lea:/* global */
	.WORD	#2
G414_T_Lea:/* global */
	.WORD	#2
G415_B_Lea:/* global */
	.WORD	#2
G416_i_Use:/* global */
	.WORD	#2
CODE SEG "init!"
	LEA	G417_apc_B(A4),A1
DATA SEG "s!"
s!:
	DATA 46 49 47 48 54 45 52 00 
CODE SEG "init!"
	LEA	s!(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 4E 49 4E 4A 41 00 
CODE SEG "init!"
	LEA	s!+8(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 50 52 49 45 53 54 00 00 
CODE SEG "init!"
	LEA	s!+14(A4),A0
	MOVE.L	A0,(A1)+
DATA SEG "s!"
	DATA 57 49 5A 41 52 44 00 00 
CODE SEG "init!"
	LEA	s!+22(A4),A0
	MOVE.L	A0,(A1)+
BSS SEG "bss"
G417_apc_B:/* global */
	.WORD	#16
CODE SEG "player"
F278_apzz_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	G298_B_New(A4),D0
	BNE	L2(PC)
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L3
	MOVE	#1,G415_B_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	JSR	F069_aaaL_(PC)
	BRA.S	L4
L3:
	MOVE	#1,-(A7)
	MOVE	D5,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L4:
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L5
L6:
	ANDI	#127,48(A3)
	ORI	#-27648,48(A3)
L7:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L5:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L6
L8:
	JSR	F293_ahzz_(PC)
	MOVE	G411_i_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L9
	MOVE	#-1,G411_i_Lea(A4)
	MOVE	D7,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L9:
	MOVE	G514_i_Mag(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L10
	MOVE	#-1,G514_i_Mag(A4)
	MOVE	D7,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
L10:
	BRA.S	L11
L2:
	MOVE	#-1,G414_T_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	MOVE	#1,G415_B_Lea(A4)
L11:
L1:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$0:	.EQU	#-8
F279_xxxx_:/* global */
	LINK	A6,L$12
	MOVE.L	8(A6),A0
	MOVEQ	#0,D0
L1T279_001_:
	ASL	#4,D0
	MOVEQ	#191,D1
	ADD.B	(A0)+,D1
	ADD.B	D1,D0
	SUBQ	#1,12(A6)
	BNE.S	L1T279_001_
L13:
	UNLK	A6
	RTS
L$12:	.EQU	#0
F280_agzz_:/* global */
	LINK	A6,L$14
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L16
	BRA	L15(PC)
L16:
	CMPI	#4,G305_ui_Pa(A4)
	BNE.S	L17
	BRA	L15(PC)
L17:
	MOVE	G305_ui_Pa(A4),D0
	MOVE	D0,-2(A6)
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	#800,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#-1,-(A7)
	MOVE	#16,-(A7)
	MOVE	#128,-(A7)
	MOVE	8(A6),D0
	LSR	#3,D0
	MULU	#29,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),D0
	AND	#7,D0
	ASL	#5,D0
	MOVE	D0,-(A7)
	PEA	G047_s_Gra(A4)
	LEA	336(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#26,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
	MOVE.B	#1,30(A3)
	MOVE.B	#2,31(A3)
	MOVE.B	#-1,32(A3)
	MOVE	#-1,44(A3)
	MOVE	#-1,46(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR	D6
	BRA.S	L18
L19:
L20:
	ADDQ	#1,D6
L18:
	MOVE	D6,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BNE.S	L19
L21:
	MOVE	D6,D0
	ADD	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE.B	D0,29(A3)
	MOVE	#1024,48(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,40(A3)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#255,D1
	MOVE	#1500,D0
	ADD	D1,D0
	MOVE	D0,66(A3)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#255,D1
	MOVE	#1500,D0
	ADD	D1,D0
	MOVE	D0,68(A3)
	CLR	D6
	BRA.S	L22
L23:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L24:
	ADDQ	#1,D6
L22:
	CMPI	#30,D6
	BCS.S	L23
L25:
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L26
L27:
L28:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L26:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#2,D0
	BNE.S	L27
L29:
	MOVE	#-32766,-(A7)
	MOVE	D7,-(A7)
	LEA	-96(A6),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	JSR	F168_ajzz_(PC)
	ADDQ.L	#8,A7
	CLR	D6
	BRA.S	L30
L31:
	MOVE	D4,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	LEA	(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L30:
	MOVE.B	(A2)+,D0
	AND	#255,D0
	MOVE	D0,D4
	CMPI	#10,D0
	BNE.S	L31
L32:
	MOVE	D6,D0
	LEA	(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	CLR	D6
	CLR	-4(A6)
L33:
	MOVE.B	(A2)+,D4
	AND	#255,D4
	CMPI	#10,D4
	BNE.S	L36
	MOVE	-4(A6),D0
	BEQ.S	L37
	BRA.S	L35
L37:
	MOVE	#1,-4(A6)
	BRA.S	L38
L36:
	MOVE	D4,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	LEA	8(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
L38:
L34:
	BRA.S	L33
L35:
	MOVE	D6,D0
	LEA	8(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	MOVE.B	(A2)+,D0
	EXT	D0
	CMP	#77,D0
	BNE.S	L39
	ORI	#16,48(A3)
L39:
	ADDQ.L	#1,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,54(A3)
	MOVE	D0,52(A3)
	ADDQ.L	#4,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,58(A3)
	MOVE	D0,56(A3)
	ADDQ.L	#4,A2
	MOVE	#4,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,62(A3)
	MOVE	D0,60(A3)
	ADDQ.L	#4,A2
	ADDQ.L	#1,A2
	CLR	D6
	BRA.S	L40
L41:
	MOVE	D6,D0
	MULS	#3,D0
	LEA	72(A3),A0
	ADDA	D0,A0
	MOVE.B	#30,(A0)
	MOVE	#2,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F279_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D6,D1
	MULS	#3,D1
	LEA	70(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D6,D1
	MULS	#3,D1
	LEA	71(A3),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
	ADDQ.L	#2,A2
L42:
	ADDQ	#1,D6
L40:
	CMPI	#6,D6
	BLS.S	L41
L43:
	MOVE.B	#10,72(A3)
	ADDQ.L	#1,A2
	MOVE	#4,D6
	BRA.S	L44
L45:
	MOVE.B	(A2)+,D0
	EXT	D0
	SUB	#65,D0
	MOVE	D0,D4
	CMPI	#0,D0
	BLS.S	L48
	MOVE.L	#125,D0
	ASL.L	D4,D0
	MOVE	D6,D1
	MULS	#6,D1
	LEA	94(A3),A0
	ADDA	D1,A0
	MOVE.L	D0,(A0)
L48:
L46:
	ADDQ	#1,D6
L44:
	CMPI	#19,D6
	BLS.S	L45
L47:
	CLR	D6
	BRA.S	L49
L50:
	CLR.L	-18(A6)
	MOVE	D6,D5
	ADDQ	#1,D5
	ASL	#2,D5
	CLR	-4(A6)
	BRA.S	L53
L54:
	MOVE	D5,D0
	ADD	-4(A6),D0
	MULS	#6,D0
	LEA	94(A3),A0
	ADDA	D0,A0
	MOVE.L	(A0),D0
	ADD.L	D0,-18(A6)
L55:
	ADDQ	#1,-4(A6)
L53:
	CMPI	#4,-4(A6)
	BCS.S	L54
L56:
	MOVE	D6,D0
	MULS	#6,D0
	LEA	94(A3),A0
	ADDA	D0,A0
	MOVE.L	-18(A6),(A0)
L51:
	ADDQ	#1,D6
L49:
	CMPI	#3,D6
	BLS.S	L50
L52:
	MOVE	-2(A6),D0
	ADDQ	#1,D0
	MOVE	D0,G299_ui_Ca(A4)
	ADDQ	#1,G305_ui_Pa(A4)
	MOVE	G305_ui_Pa(A4),D0
	CMPI	#1,D0
	BNE.S	L57
	CLR	-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,G508_B_Ref(A4)
	BRA.S	L58
L57:
	JSR	F388_rzzz_(PC)
	MOVE	G305_ui_Pa(A4),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L58:
	MOVE	G306_i_Par(A4),-8(A6)
	MOVE	G307_i_Par(A4),-10(A6)
	MOVE	G308_i_Par(A4),D0
	ADDQ	#2,D0
	AND	#3,D0
	MOVE	D0,-12(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-8(A6),D0
	ADD	D1,D0
	MOVE	D0,-8(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-10(A6),D0
	ADD	D1,D0
	MOVE	D0,-10(A6)
	MOVE	-10(A6),-(A7)
	MOVE	-8(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	#13,D6
	BRA	L59(PC)
L60:
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D4
	CMPI	#3,D0
	BLS	L62(PC)
	MOVE	D7,D0
	LSR	#6,D0
	LSR	#8,D0
	CMP	-12(A6),D0
	BNE	L62(PC)
	MOVE	D7,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-14(A6)
	MOVE	D4,D0
L63:
	CMP	#6,D0
	BEQ.S	L64
	BRA.S	L66
L64:
	MOVE	#2,-6(A6)
	BRA.S	L68
L69:
	MOVE	-14(A6),D0
	MOVE	-6(A6),D1
	ASL.L	#1,D1
	LEA	G038_ai_Gr(A4),A0
	ADDA	D1,A0
	AND	(A0),D0
	BEQ.S	L72
	BRA	L2T280_048(PC)
L72:
L70:
	ADDQ	#1,-6(A6)
L68:
	CMPI	#5,-6(A6)
	BLS.S	L69
L71:
	MOVE	-14(A6),D0
	AND	G038_ai_Gr+20(A4),D0
	BEQ.S	L73
	CMPI	#-1,232(A3)
	BNE.S	L73
	MOVE	#10,-6(A6)
	BRA.S	L74
L73:
	BRA.S	L2T280_046
L74:
	BRA	L65(PC)
	BRA.S	L67
L66:
	CMP	#5,D0
	BEQ.S	L67
	BRA.S	L75
L67:
	CMPI	#-1,214(A3)
	BNE.S	L77
	MOVE	#1,-6(A6)
	BRA.S	L78
L77:
	BRA.S	L2T280_046
L78:
	BRA.S	L65
	BRA.S	L76
L75:
	CMP	#7,D0
	BEQ.S	L76
L79:
	CMP	#8,D0
	BEQ.S	L76
	BRA.S	L80
L76:
	CMPI	#-1,234(A3)
	BNE.S	L82
	MOVE	#11,-6(A6)
	BRA.S	L83
L82:
	CMPI	#-1,224(A3)
	BNE.S	L84
	MOVE	#6,-6(A6)
	BRA.S	L85
L84:
	BRA.S	L2T280_046
L85:
L83:
	BRA.S	L65
	BRA.S	L81
L80:
	CMP	#9,D0
	BEQ.S	L81
L86:
	CMP	#10,D0
	BEQ.S	L81
	BRA.S	L87
L81:
L2T280_046:
	MOVE	-14(A6),D0
	AND	G038_ai_Gr+20(A4),D0
	BEQ.S	L89
	CMPI	#-1,232(A3)
	BNE.S	L89
	MOVE	#10,-6(A6)
	BRA.S	L90
L89:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE	D0,-6(A6)
L90:
L87:
L88:
L65:
L2T280_048:
	MOVE	-6(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	CMPI	#-1,(A0)
	BEQ.S	L91
	BRA.S	L2T280_046
L91:
	MOVE	-6(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
L62:
	MOVE	D7,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D7
L59:
	CMPI	#-2,D7
	BNE	L60(PC)
L61:
	MOVE	-2(A6),-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	JSR	F456_vzzz_(PC)
L15:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$14:	.EQU	#-96
F281_xxxx_:/* global */
	LINK	A6,L$92
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	#3,-8(A6)
	MOVE	#8,-6(A6)
	MOVE	#3,D0
	MOVE	D0,-12(A6)
	ADD	#167,D0
	MOVE	D0,-10(A6)
	MOVE	#112,-(A7)
	MOVE	#12,-(A7)
	PEA	-12(A6)
	MOVE.L	G296_puc_B(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#4,-(A7)
	MOVE	#72,-(A7)
	PEA	G032_s_Gra(A4)
	MOVE	#27,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
DATA SEG "s!"
	DATA 5F 5F 5F 5F 5F 5F 5F 00 
CODE SEG "player"
	PEA	s!+30(A4)
	MOVE	#13,-(A7)
	MOVE	#58,-(A7)
	MOVE	#177,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 5F 00 
CODE SEG "player"
	PEA	s!+38(A4)
	MOVE	#13,-(A7)
	MOVE	#76,-(A7)
	MOVE	#105,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	JSR	F077_aA39_(PC)
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	(A3),A0
	ADDA	D0,A0
	CLR.B	(A0)
	CLR.B	8(A3)
	MOVE	#1,D6
	LEA	(A3),A0
	MOVE.L	A0,A2
	MOVE	#177,-2(A6)
	MOVE	#91,-4(A6)
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	MOVE	D0,-20(A6)
L94:
	CMPI	#2,D6
	SEQ	D0
	TST.B	D0
	BEQ.S	L98
	CMPI	#19,D7
	SEQ	D0
	TST.B	D0
L98:
	AND	#1,D0
	MOVE	D0,D4
	BNE.S	L97
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#9,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L97:
	BRA	L99(PC)
L100:
	MOVE	G588_i_Mou(A4),D0
	AND	#2,D0
	MOVE	D0,-18(A6)
	MOVE	-18(A6),D0
	BEQ	L102(PC)
	MOVE	-20(A6),D0
	BNE	L102(PC)
	MOVE	G589_i_Mou(A4),-14(A6)
	MOVE	G590_i_Mou(A4),-16(A6)
	CMPI	#2,D6
	BEQ.S	L104
	CMPI	#0,D7
	BLS	L103(PC)
L104:
	CMPI	#197,-14(A6)
	BCS	L103(PC)
	CMPI	#215,-14(A6)
	BHI	L103(PC)
	CMPI	#147,-16(A6)
	BCS	L103(PC)
	CMPI	#155,-16(A6)
	BHI	L103(PC)
	MOVE	D7,-22(A6)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	PEA	-30(A6)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L105
L106:
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
L105:
	SUBQ	#1,D7
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	CMP	#32,D0
	BEQ.S	L106
L107:
	CLR	D7
	BRA.S	L108
L109:
	MOVE.L	A2,-(A7)
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	strcmp(PC)
	ADDQ.L	#8,A7
	TST	D0
	BNE.S	L112
	BRA.S	L3T281_011_
L112:
L110:
	ADDQ	#1,D7
L108:
	MOVE	D7,D0
	MOVE	G305_ui_Pa(A4),D1
	SUBQ	#1,D1
	CMP	D1,D0
	BCS.S	L109
L111:
	BRA	L93(PC)
L3T281_011_:
	CMPI	#2,D6
	BNE.S	L113
	LEA	8(A3),A0
	MOVE.L	A0,A2
L113:
	PEA	-30(A6)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
	MOVE	-22(A6),D7
	BRA	L114(PC)
L103:
	CMPI	#107,-14(A6)
	BCS.S	L115
	CMPI	#175,-14(A6)
	BHI.S	L115
	CMPI	#147,-16(A6)
	BCS.S	L115
	CMPI	#155,-16(A6)
	BHI.S	L115
	MOVE	#8,D5
	BRA	L101(PC)
L115:
	CMPI	#107,-14(A6)
	BCS.S	L117
	CMPI	#215,-14(A6)
	BHI.S	L117
	CMPI	#116,-16(A6)
	BCS.S	L117
	CMPI	#144,-16(A6)
	BLS.S	L116
L117:
	BRA	L3T281_023(PC)
L116:
	MOVE	-14(A6),D0
	ADDQ	#4,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	TST	D0
	BEQ.S	L119
	MOVE	-16(A6),D0
	ADDQ	#5,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	TST	D0
	BNE.S	L118
	CMPI	#207,-14(A6)
	BCS.S	L120
	CMPI	#135,-16(A6)
	BEQ.S	L118
L120:
L119:
	BRA.S	L3T281_023
L118:
	MOVE	#11,D5
	MOVE	-16(A6),D1
	SUB	#116,D1
	AND.L	#65535,D1
	DIVU	#10,D1
	MULU	D1,D5
	MOVE	D5,-40(A6)
	MOVE	#65,D5
	ADD	-40(A6),D5
	MOVE	-14(A6),D1
	SUB	#107,D1
	AND.L	#65535,D1
	DIVU	#10,D1
	ADD	D1,D5
	CMPI	#86,D5
	BEQ.S	L122
	CMPI	#97,D5
	BNE.S	L121
L122:
	MOVE	#13,D5
	BRA.S	L101
L121:
	CMPI	#87,D5
	BLT.S	L123
	SUBQ	#1,D5
L123:
	CMPI	#90,D5
	BLE.S	L124
	MOVE	D5,D0
	SUB	#90,D0
	LEA	G053_ac_Gr+-1(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	EXT	D0
	MOVE	D0,D5
L124:
	BRA.S	L101
L114:
L102:
L3T281_023:
	MOVE	-18(A6),-20(A6)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L99:
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ	L100(PC)
L101:
	MOVE	-18(A6),-20(A6)
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BEQ.S	L125
	MOVE	#7,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
L125:
	CMPI	#97,D5
	BLT.S	L126
	CMPI	#122,D5
	BGT.S	L126
	SUB	#32,D5
L126:
	CMPI	#65,D5
	BLT.S	L129
	CMPI	#90,D5
	BLE.S	L128
L129:
	CMPI	#46,D5
	BEQ.S	L128
	CMPI	#44,D5
	BEQ.S	L128
	CMPI	#59,D5
	BEQ.S	L128
	CMPI	#58,D5
	BEQ.S	L128
	CMPI	#32,D5
	BNE.S	L127
L128:
	CMPI	#32,D5
	BNE.S	L130
	CMPI	#0,D7
	BNE.S	L130
	BRA.S	L131
L130:
	MOVE	D4,D0
	BNE.S	L132
	MOVE	D5,D0
	MOVE.B	D0,G052_ac_Gr(A4)
	JSR	F077_aA39_(PC)
	PEA	G052_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
	MOVE	D5,D0
	MOVE	D7,D1
	ADDQ	#1,D7
	MOVE.L	A2,A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
	ADDQ	#6,-2(A6)
	CMPI	#1,D6
	BNE.S	L133
	CMPI	#7,D7
	BNE.S	L133
	BRA.S	L3T281_033_
L133:
L132:
L131:
	BRA	L134(PC)
L127:
	CMPI	#13,D5
	BNE.S	L135
	CMPI	#1,D6
	BNE.S	L136
	CMPI	#0,D7
	BLS.S	L136
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L3T281_033_:
	MOVE	#2,D6
	LEA	8(A3),A0
	MOVE.L	A0,A2
	MOVE	#105,-2(A6)
	MOVE	#109,-4(A6)
	CLR	D7
L136:
	BRA	L137(PC)
L135:
	CMPI	#8,D5
	BNE	L138(PC)
	CMPI	#1,D6
	BNE.S	L139
	CMPI	#0,D7
	BNE.S	L139
	BRA.S	L95
L139:
	MOVE	D4,D0
	BNE.S	L140
	JSR	F077_aA39_(PC)
	PEA	G051_ac_Gr(A4)
	MOVE	#12,-(A7)
	MOVE	#13,-(A7)
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F040_aacZ_(PC)
	ADDA	#18,A7
	JSR	F078_xzzz_(PC)
L140:
	CMPI	#0,D7
	BNE.S	L141
	LEA	(A3),A0
	MOVE.L	A0,A2
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	SUBQ	#1,D0
	MOVE	D0,D7
	MOVE	#1,D6
	MOVE	#177,D0
	MOVE	D7,D1
	MULU	#6,D1
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	#91,-4(A6)
	BRA.S	L142
L141:
	SUBQ	#1,D7
	SUBQ	#6,-2(A6)
L142:
	MOVE	D7,D0
	MOVE.L	A2,A0
	ADDA	D0,A0
	CLR.B	(A0)
L138:
L137:
L134:
L95:
	BRA	L94(PC)
L96:
L93:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$92:	.EQU	#-40
F282_xzzz_:/* global */
	LINK	A6,L$143
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	SUBQ	#1,D0
	MOVE	D0,D7
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#162,8(A6)
	BNE	L145(PC)
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	CLR	G299_ui_Ca(A4)
	CMPI	#1,G305_ui_Pa(A4)
	BNE.S	L146
	MOVE	#-1,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L146:
	SUBQ	#1,G305_ui_Pa(A4)
	CLR	-8(A6)
	MOVE	#28,-6(A6)
	MOVE	D7,D0
	MULU	#69,D0
	MOVE	D0,-12(A6)
	ADD	#66,D0
	MOVE	D0,-10(A6)
	CLR	G578_B_Use(A4)
	JSR	F077_aA39_(PC)
	MOVE	#160,-(A7)
	CLR	-(A7)
	PEA	-12(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#160,-(A7)
	CLR	-(A7)
	MOVE.B	29(A3),D0
	AND	#255,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	JSR	F457_AA08_(PC)
	JSR	F078_xzzz_(PC)
	BRA	L147(PC)
L145:
	CLR	G299_ui_Ca(A4)
	MOVE	G306_i_Par(A4),-2(A6)
	MOVE	G307_i_Par(A4),-4(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G233_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-2(A6),D0
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	G308_i_Par(A4),D1
	ASL.L	#1,D1
	LEA	G234_ai_Gr(A4),A0
	ADDA	D1,A0
	MOVE	(A0),D1
	MOVE	-4(A6),D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	CLR	D6
	BRA.S	L148
L149:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	CMPI	#-1,D0
	BEQ.S	L152
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F164_dzzz_(PC)
	ADDQ.L	#8,A7
L152:
L150:
	ADDQ	#1,D6
L148:
	CMPI	#30,D6
	BCS.S	L149
L151:
	MOVE	-4(A6),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F161_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
L153:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#3,D0
	BNE.S	L156
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	ANDI	#-128,2(A2)
	BRA.S	L155
L156:
	MOVE	D4,-(A7)
	JSR	F159_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
L154:
	BRA.S	L153
L155:
	CMPI	#161,8(A6)
	BNE	L157(PC)
	MOVE.L	A3,-(A7)
	JSR	F281_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	#120,-(A7)
	LEA	92(A3),A0
	MOVE.L	A0,-(A7)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE	#1,D6
	BRA.S	L158
L159:
	MOVE	D6,D5
	MULS	#3,D5
	LEA	71(A3),A0
	ADDA	D5,A0
	MOVE.B	(A0),D5
	AND	#255,D5
	ASR	#3,D5
	MOVE	D6,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	D6,D0
	MULS	#3,D0
	LEA	72(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	MULS	#3,D1
	LEA	70(A3),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	MOVE	D6,D1
	MULS	#3,D1
	LEA	71(A3),A0
	ADDA	D1,A0
	AND	#255,D0
	MOVE.B	D0,(A0)
L160:
	ADDQ	#1,D6
L158:
	CMPI	#6,D6
	BLS.S	L159
L161:
	MOVE	52(A3),D0
	ASR	#1,D0
	MOVE	D0,52(A3)
	MOVE	54(A3),D0
	ASR	#1,D0
	MOVE	D0,54(A3)
	MOVE	56(A3),D0
	ASR	#1,D0
	MOVE	D0,56(A3)
	MOVE	58(A3),D0
	ASR	#1,D0
	MOVE	D0,58(A3)
	MOVE	60(A3),D0
	ASR	#1,D0
	MOVE	D0,60(A3)
	MOVE	62(A3),D0
	ASR	#1,D0
	MOVE	D0,62(A3)
	CLR	D6
	BRA.S	L162
L163:
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#7,D0
	SWAP	D0
	MOVE	D0,D5
	MOVE	D5,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	ADDQ.B	#1,(A0)
	MOVE	D5,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	ADDQ.B	#1,(A0)
L164:
	ADDQ	#1,D6
L162:
	CMPI	#12,D6
	BCS.S	L163
L165:
L157:
	CMPI	#1,G305_ui_Pa(A4)
	BNE.S	L166
	MOVE.L	G313_ul_Ga(A4),G362_l_Las(A4)
	CLR	-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
	CLR	-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L167
L166:
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
L167:
	JSR	F051_AA19_(PC)
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D6
	MOVE	D0,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 52 45 53 55 52 52 45 43 54 45 44 2E 00 20 52 45 49 4E 43 41 52 4E 41 54 45 44 2E 00 00 
CODE SEG "player"
	CMPI	#160,8(A6)
	BNE.S	L168
	LEA	s!+58(A4),A0
	MOVE.L	A0,D0
	BRA.S	L169
L168:
	LEA	s!+72(A4),A0
	MOVE.L	A0,D0
L169:
	MOVE.L	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
	JSR	F457_AA08_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L170
	MOVE	#0,D0
	BRA.S	L171
L170:
	MOVE	#1,D0
L171:
	MOVE	D0,-(A7)
	JSR	F067_aaat_(PC)
	ADDQ.L	#2,A7
L147:
L144:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$143:	.EQU	#-12
F283_azzz_:/* global */
	LINK	A6,L$172
	MOVEM.L	A3/D7,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.B	29(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BEQ.S	L174
	CLR	D7
	BRA.S	L175
L176:
L177:
	ADDQ	#1,D7
L175:
	MOVE	D7,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	CMPI	#-1,D0
	BNE.S	L176
L178:
	MOVE	D7,D0
	MOVE.B	D0,29(A3)
L174:
	MOVE	54(A3),D7
	MOVE	D7,D0
	MOVE	D7,D1
	LSR	#6,D1
	SUB	D1,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#25,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,54(A3)
	ASR	#1,D0
	MOVE	D0,52(A3)
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	ORI	#-27648,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L173:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$172:	.EQU	#0
F284_czzz_:/* global */
	LINK	A6,L$179
	MOVE	8(A6),D3
	MOVE	G308_i_Par(A4),D2
	MOVE	D3,G308_i_Par(A4)
	SUB	D2,D3
	BEQ.S	L6T284_005_
	ADDQ	#4,D3
	LEA	G407_s_Par(A4),A0
	MOVE	G305_ui_Pa(A4),D0
L6T284_001_:
	ADD.B	D3,29(A0)
	ANDI.B	#3,29(A0)
	ADD.B	D3,28(A0)
	ANDI.B	#3,28(A0)
	LEA	800(A0),A0
	SUBQ	#1,D0
	BGT.S	L6T284_001_
	JSR	F296_aizz_(PC)
L6T284_005_:
L180:
	UNLK	A6
	RTS
L$179:	.EQU	#0
F285_szzz_:/* global */
	LINK	A6,L$181
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	8(A6),D7
	MOVE	#0,D0
	MOVE	D0,D6
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L183
L184:
	MOVE.B	29(A3),D0
	AND	#255,D0
	CMP	D7,D0
	BNE.S	L187
	MOVE	52(A3),D0
	BEQ.S	L187
	MOVE	D6,D0
	BRA.S	L182
L187:
L185:
	MOVE	D6,D0
	ADDQ	#1,D6
	MOVE.L	A3,D0
	ADDA	#800,A3
L183:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L184
L186:
	MOVE	#-1,D0
L182:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$181:	.EQU	#0
F286_hzzz_:/* global */
	LINK	A6,L$188
	MOVEM.L	D7-D6,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BEQ	L190(PC)
	MOVE	8(A6),D0
	MOVE	G306_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	MOVE	10(A6),D0
	MOVE	G307_i_Par(A4),D1
	SUB	D1,D0
	MOVE	D0,-(A7)
	JSR	F023_aarz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	CMPI	#1,D0
	BGT.S	L190
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	PEA	-4(A6)
	JSR	F229_hzzz_(PC)
	ADDA	#14,A7
	CLR	D7
	BRA.S	L191
L192:
	MOVE	D7,D0
	LEA	-4(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F285_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#0,D0
	BLT.S	L195
	MOVE	D6,D0
	BRA.S	L189
L195:
L193:
	ADDQ	#1,D7
L191:
	CMPI	#4,D7
	BCS.S	L192
L194:
L190:
	MOVE	#-1,D0
L189:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$188:	.EQU	#-4
F287_xxxx_:/* global */
	LINK	A6,L$196
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	D6
	CMPI	#0,52(A3)
	BLE.S	L198
	MOVE	52(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	54(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L199
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L200
L199:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L200:
	BRA.S	L201
L198:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L201:
	CMPI	#0,56(A3)
	BLE.S	L202
	MOVE	56(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	58(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L203
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L204
L203:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ADDQ	#1,D6
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L204:
	BRA.S	L205
L202:
	MOVE	D6,D0
	ADDQ	#1,D6
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L205:
	CMPI	#0,60(A3)
	BLE.S	L206
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BLE.S	L207
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	MOVE	#25,(A0)
	BRA.S	L208
L207:
	MOVE	60(A3),D5
	EXT.L	D5
	ASL.L	#2,D5
	ASL.L	#8,D5
	MOVE.L	D5,-(A7)
	MOVE.L	#25,D5
	MOVE.L	D5,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D5
	MOVE.L	D5,-(A7)
	MOVE	62(A3),D5
	EXT.L	D5
	MOVE.L	D5,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D5
	ADDQ.L	#4,A7
	MOVE.L	D5,D0
	AND.L	#1023,D0
	BEQ.S	L209
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	ADDQ.L	#1,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
	BRA.S	L210
L209:
	MOVE.L	D5,D0
	ASR.L	#2,D0
	ASR.L	#8,D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	-6(A6),A0
	ADDA	D1,A0
	MOVE	D0,(A0)
L210:
L208:
	BRA.S	L211
L206:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	-6(A6),A0
	ADDA	D0,A0
	CLR	(A0)
L211:
	JSR	F077_aA39_(PC)
	MOVE.L	G348_pl_Bi(A4),A0
	LEA	320(A0),A0
	MOVE	8(A6),D1
	EXT.L	D1
	CMP	#3,D1
	BCS.S	L9T287_014
	MOVE.L	#-./,),(-*,(,D6
	MOVE.L	D6,D7
	ADDQ.L	#1,D7
	BRA.S	L9T287_017
L9T287_014:
	CMP	#2,D1
	BCS.S	L9T287_015
	MOVEQ	#0,D6
	MOVE.L	#-./,),(-*,(,D7
	BRA.S	L9T287_017
L9T287_015:
	CMP	#1,D1
	BCS.S	L9T287_016
	MOVE.L	#-2147483647,D6
	MOVE.L	D6,D7
	SUBQ.L	#1,D7
	BRA.S	L9T287_017
L9T287_016:
	MOVE.L	#-2147483647,D6
	MOVEQ	#1,D7
L9T287_017:
	ADD	D1,D1
	MOVE	D1,D2
	ADD	D1,D1
	ADD	D2,D1
	MOVE	D1,-8(A6)
	ADDQ	#4,-8(A6)
	LEA	-6(A6),A3
L9T287_018_:
	MOVE.L	A0,A2
	LEA	G056_aaui_(A4),A1
	ADDA	0(A1,D1),A2
	LSL	#1,D1
	LEA	G055_aaaui(A4),A1
	MOVE	0(A1,D1),D2
	MOVE	2(A1,D1),D3
	MOVE	D2,D4
	NOT	D4
	MOVE	D3,D5
	NOT	D5
	LSR	#1,D1
	MOVE	(A3)+,D0
	JSR	S287_xxxx_(PC)
	CMP	-8(A6),D1
	BEQ	L9T287_030(PC)
	ADDQ	#2,D1
	BRA.S	L9T287_018_
S287_xxxx_:/* global */
	MOVE	D1,-(A7)
	MOVE	#24,D1
L9T287_020_:
	CMP	D1,D0
	BHI.S	L9T287_021
	AND	D4,(A2)
	AND	D5,8(A2)
	AND	D4,2(A2)
	AND	D5,10(A2)
	OR	D2,4(A2)
	OR	D3,12(A2)
	OR	D2,6(A2)
	OR	D3,14(A2)
	BRA.S	L9T287_029
L9T287_021:
	TST	D6
	BEQ.S	L9T287_022
	OR	D2,(A2)
	OR	D3,8(A2)
	BRA.S	L9T287_023
L9T287_022:
	AND	D4,(A2)
	AND	D5,8(A2)
L9T287_023:
	TST.L	D6
	BGE.S	L9T287_024
	OR	D2,2(A2)
	OR	D3,10(A2)
	BRA.S	L9T287_025
L9T287_024:
	AND	D4,2(A2)
	AND	D5,10(A2)
L9T287_025:
	TST	D7
	BEQ.S	L9T287_026
	OR	D2,4(A2)
	OR	D3,12(A2)
	BRA.S	L9T287_027
L9T287_026:
	AND	D4,4(A2)
	AND	D5,12(A2)
L9T287_027:
	TST.L	D7
	BGE.S	L9T287_028
	OR	D2,6(A2)
	OR	D3,14(A2)
	BRA.S	L9T287_029
L9T287_028:
	AND	D4,6(A2)
	AND	D5,14(A2)
L9T287_029:
	LEA	160(A2),A2
	DBF	D1,L9T287_020_
	MOVE	(A7)+,D1
	RTS
L9T287_030:
	JSR	F078_xzzz_(PC)
L197:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$196:	.EQU	#-8
F288_xxxx_:/* global */
	LINK	A6,L$212
BSS SEG "bss"
11G419_ac_:
	.WORD	#6
CODE SEG "player"
	MOVEQ	#4,D0
	SUB	12(A6),D0
	LEA	11G419_ac_(A4),A1
	ADD.L	A1,D0
	MOVE.L	#538976288,(A1)+
	CLR.B	(A1)
	MOVEQ	#0,D1
	MOVE	8(A6),D1
L10T288_003:
	DIVU	#10,D1
	SWAP	D1
	ADD.B	#48,D1
	MOVE.B	D1,-(A1)
	CLR	D1
	SWAP	D1
	BNE.S	L10T288_003
	TST	10(A6)
	BNE.S	L10T288_007
	MOVE.L	A1,D0
L10T288_007:
L213:
	UNLK	A6
	RTS
L$212:	.EQU	#0
F289_xxxx_:/* global */
	LINK	A6,L$214
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	10(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#55,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+88(A4)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#73,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	12(A6),-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#13,-(A7)
	MOVE	8(A6),-(A7)
	MOVE	#79,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
L215:
	UNLK	A6
	RTS
L$214:	.EQU	#0
F290_xxxx_:/* global */
	LINK	A6,L$216
	MOVE.L	A3,-(A7)
	MOVE.L	8(A6),A3
	MOVE	54(A3),-(A7)
	MOVE	52(A3),-(A7)
	MOVE	#116,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	58(A3),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-(A7)
	MOVE	56(A3),D0
	EXT.L	D0
	DIVS	#10,D0
	MOVE	D0,-(A7)
	MOVE	#124,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	62(A3),-(A7)
	MOVE	60(A3),-(A7)
	MOVE	#132,-(A7)
	JSR	F289_xxxx_(PC)
	ADDQ.L	#6,A7
L217:
	MOVE.L	(A7)+,A3
	UNLK	A6
	RTS
L$216:	.EQU	#0
F291_xxxx_:/* global */
	LINK	A6,L$218
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	10(A6),D7
	MOVE	#-1,-20(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	G423_i_Inv(A4),D5
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	MOVE	D5,D0
	BNE.S	L220
	CMPI	#1,D7
	BHI.S	L222
	MOVE	G299_ui_Ca(A4),D0
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L221
L222:
	BRA	L219(PC)
L221:
	MOVE	8(A6),D0
	ASL	#1,D0
	ADD	D7,D0
	MOVE	D0,-2(A6)
	BRA.S	L223
L220:
	MOVE	#8,D0
	ADD	D7,D0
	MOVE	D0,-2(A6)
L223:
	CMPI	#30,D7
	BCS.S	L224
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	BRA.S	L225
L224:
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	212(A3),A0
	ADDA	D6,A0
	MOVE	(A0),D6
L225:
	MOVE	-2(A6),D0
	MULS	#6,D0
	LEA	G030_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	(A2),D0
	SUBQ	#1,D0
	MOVE	D0,-18(A6)
	ADD	#17,D0
	MOVE	D0,-16(A6)
	MOVE	2(A2),D0
	SUBQ	#1,D0
	MOVE	D0,-14(A6)
	ADD	#17,D0
	MOVE	D0,-12(A6)
	MOVE	D5,D0
	BEQ.S	L226
	MOVE.L	G296_puc_B(A4),-24(A6)
	MOVE	#112,-26(A6)
	BRA.S	L227
L226:
	MOVE.L	G348_pl_Bi(A4),D0
	MOVE.L	D0,-24(A6)
	MOVE	#160,-26(A6)
	JSR	F077_aA39_(PC)
L227:
	CMPI	#-1,D6
	BNE.S	L228
	CMPI	#5,D7
	BHI.S	L229
	MOVE	#212,D4
	MOVE	D7,D1
	ASL	#1,D1
	ADD	D1,D4
	MOVE	50(A3),D0
	MOVE	#1,D1
	ASL	D7,D1
	AND	D1,D0
	BEQ.S	L230
	ADDQ	#1,D4
	MOVE	#34,-20(A6)
	BRA.S	L231
L230:
	MOVE	#33,-20(A6)
L231:
	BRA.S	L232
L229:
	CMPI	#10,D7
	BCS.S	L233
	CMPI	#13,D7
	BHI.S	L233
	MOVE	#208,D4
	MOVE	D7,D1
	SUB	#10,D1
	ADD	D1,D4
	BRA.S	L234
L233:
	MOVE	#204,D4
L234:
L232:
	BRA.S	L235
L228:
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	MOVE	D5,D0
	BEQ.S	L236
	CMPI	#1,D7
	BNE.S	L236
	CMPI	#144,D4
	BEQ.S	L237
	CMPI	#30,D4
	BNE.S	L236
L237:
	ADDQ	#1,D4
L236:
	CMPI	#5,D7
	BHI.S	L238
	MOVE	50(A3),D0
	MOVE	#1,D1
	ASL	D7,D1
	AND	D1,D0
	BEQ.S	L239
	MOVE	#34,-20(A6)
	BRA.S	L240
L239:
	MOVE	#33,-20(A6)
L240:
L238:
L235:
	CMPI	#1,D7
	BNE.S	L241
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G506_i_Act(A4),D0
	BNE.S	L241
	MOVE	#35,-20(A6)
L241:
	CMPI	#-1,-20(A6)
	BEQ.S	L242
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	#12,-(A7)
	MOVE	-26(A6),-(A7)
	MOVE	#16,-(A7)
	CLR	-(A7)
	CLR	-(A7)
	PEA	-18(A6)
	MOVE.L	-24(A6),-(A7)
	MOVE	-20(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L242:
	MOVE	D4,-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	D5,D0
	BNE.S	L243
	JSR	F078_xzzz_(PC)
L243:
L219:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$218:	.EQU	#-26
F292_arzz_:/* global */
	LINK	A6,L$244
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULU	#69,D0
	MOVE	D0,-4(A6)
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	48(A3),D6
	MOVE	D6,D0
	AND	#-128,D0
	BNE.S	L246
	BRA	L245(PC)
L246:
	MOVE	D7,D5
	ADDQ	#1,D5
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D5
	SEQ	D5
	AND	#1,D5
	CLR	G578_B_Use(A4)
	JSR	F077_aA39_(PC)
	MOVE	D6,D0
	AND	#4096,D0
	BEQ	L247(PC)
	CLR	-12(A6)
	MOVE	#28,-10(A6)
	MOVE	-4(A6),D0
	MOVE	D0,-16(A6)
	ADD	#66,D0
	MOVE	D0,-14(A6)
	MOVE	52(A3),D0
	BEQ	L248(PC)
	MOVE	#160,-(A7)
	MOVE	#12,-(A7)
	PEA	-16(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#6,-(A7)
	PEA	-22(A6)
	JSR	F008_aA19_(PC)
	ADDQ.L	#6,A7
	CLR	D4
	CMPI	#0,G407_s_Par+3206(A4)
	BLE.S	L249
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#38,(A0)
L249:
	CMPI	#0,G407_s_Par+3208(A4)
	BLE.S	L250
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#39,(A0)
L250:
	CMPI	#0,G407_s_Par+3204(A4)
	BGT.S	L252
	MOVE	274(A3),D0
	BEQ.S	L251
L252:
	MOVE	D4,D0
	ADDQ	#1,D4
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	#37,(A0)
L251:
	BRA.S	L253
L254:
	MOVE	#10,-(A7)
	MOVE	#40,-(A7)
	PEA	-16(A6)
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	-22(A6),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
L253:
	MOVE	D4,D0
	SUBQ	#1,D4
	TST	D0
	BNE.S	L254
L255:
	MOVE	D5,D0
	BEQ.S	L256
	MOVE	D7,-(A7)
	JSR	F354_szzz_(PC)
	ADDQ.L	#2,A7
	OR	#256,D6
	BRA.S	L257
L256:
	OR	#-24192,D6
L257:
	BRA.S	L258
L248:
	MOVE	#-1,-(A7)
	MOVE	#40,-(A7)
	PEA	-16(A6)
	MOVE	#8,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#1,-(A7)
	MOVE	#13,-(A7)
	MOVE	#5,-(A7)
	MOVE	-4(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	D7,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
	BRA	L15T292_042(PC)
L258:
L247:
	MOVE	52(A3),D0
	BNE.S	L259
	BRA	L15T292_042(PC)
L259:
	MOVE	D6,D0
	AND	#128,D0
	BEQ	L260(PC)
	MOVE	D7,D4
	MOVE	G411_i_Lea(A4),D1
	CMP	D1,D4
	BNE.S	L261
	MOVE	#9,D4
	BRA.S	L262
L261:
	MOVE	#13,D4
L262:
	MOVE	D5,D0
	BEQ	L263(PC)
	LEA	(A3),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A2
	MOVE.L	D0,-(A7)
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	#3,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE.L	A2,-(A7)
	JSR	strlen(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-32(A6)
	MOVE	#6,D0
	MULS	-32(A6),D0
	ADDQ	#3,D0
	MOVE	D0,-6(A6)
	MOVE.B	8(A3),-1(A6)
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#44,D0
	BEQ.S	L264
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#59,D0
	BEQ.S	L264
	MOVE.B	-1(A6),D0
	EXT	D0
	CMP	#45,D0
	BEQ.S	L264
	ADDQ	#6,-6(A6)
L264:
	LEA	8(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	D4,-(A7)
	MOVE	#7,-(A7)
	MOVE	-6(A6),-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	OR	#16384,D6
	BRA.S	L265
L263:
	CLR	-12(A6)
	MOVE	#6,-10(A6)
	MOVE	-4(A6),D0
	MOVE	D0,-16(A6)
	ADD	#42,D0
	MOVE	D0,-14(A6)
	MOVE	#160,-(A7)
	MOVE	#1,-(A7)
	PEA	-16(A6)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	LEA	(A3),A0
	MOVE.L	A0,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	MOVE	#5,-(A7)
	MOVE	-4(A6),D0
	ADDQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
L265:
L260:
	MOVE	D6,D0
	AND	#256,D0
	BEQ	L266(PC)
	MOVE	D7,-(A7)
	JSR	F287_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
	BEQ	L267(PC)
	MOVE.L	A3,-(A7)
	JSR	F290_xxxx_(PC)
	ADDQ.L	#4,A7
	CMPI	#0,66(A3)
	BLT.S	L269
	CMPI	#0,68(A3)
	BLT.S	L269
	MOVE.B	42(A3),D0
	BEQ.S	L268
L269:
	MOVE	#34,-8(A6)
	BRA.S	L270
L268:
	MOVE	#33,-8(A6)
L270:
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G048_s_Gra(A4)
	MOVE	-8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	MOVE	#33,-8(A6)
	MOVE	#1,D4
	BRA.S	L271
L272:
	MOVE	D4,D0
	MULS	#3,D0
	LEA	71(A3),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D4,D1
	MULS	#3,D1
	LEA	70(A3),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	AND	#255,D0
	CMP	D1,D0
	BGE.S	L275
	MOVE	#34,-8(A6)
	BRA.S	L274
L275:
L273:
	ADDQ	#1,D4
L271:
	CMPI	#6,D4
	BLE.S	L272
L274:
	MOVE	#12,-(A7)
	MOVE	#16,-(A7)
	PEA	G049_s_Gra(A4)
	MOVE	-8(A6),-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F020_aAA5_(PC)
	ADDA	#12,A7
	OR	#16384,D6
L267:
L266:
	MOVE	D6,D0
	AND	#8192,D0
	BEQ.S	L276
	MOVE	D5,D4
	BEQ.S	L281
	MOVE	#5,D4
	BRA.S	L282
L281:
	MOVE	#1,D4
L282:
	BRA.S	L277
L278:
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
L279:
	SUBQ	#1,D4
L277:
	CMPI	#0,D4
	BGE.S	L278
L280:
	MOVE	D5,D0
	BEQ.S	L283
	OR	#16384,D6
L283:
L276:
	MOVE	D6,D0
	AND	#512,D0
	BEQ	L284(PC)
	MOVE	D5,D0
	BEQ	L284(PC)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	MOVE	D0,-42(A6)
	MOVE	272(A3),D0
	CMP	-42(A6),D0
	BLS.S	L285
	MOVE	#8,-8(A6)
	BRA.S	L286
L285:
	MOVE	272(A3),D0
	AND.L	#65535,D0
	ASL.L	#3,D0
	MOVE	D4,D1
	EXT.L	D1
	MOVE.L	D1,-(A7)
	MOVE.L	#5,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	CMP.L	D1,D0
	BLE.S	L287
	MOVE	#11,-8(A6)
	BRA.S	L288
L287:
	MOVE	#13,-8(A6)
L288:
L286:
DATA SEG "s!"
	DATA 4C 4F 41 44 20 00 
CODE SEG "player"
	PEA	s!+90(A4)
	MOVE	-8(A6),-(A7)
	MOVE	#132,-(A7)
	MOVE	#104,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	MOVE	272(A3),D4
	AND.L	#65535,D4
	DIVU	#10,D4
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcpy(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2E 00 
CODE SEG "player"
	PEA	s!+96(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE	272(A3),D0
	MOVE	D4,D1
	MULS	#10,D1
	SUB	D1,D0
	MOVE	D0,D4
	MOVE	#1,-(A7)
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 2F 00 
CODE SEG "player"
	PEA	s!+98(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	ADDQ	#5,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	MOVE	D0,D4
	MOVE	#3,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
DATA SEG "s!"
	DATA 20 4B 47 00 
CODE SEG "player"
	PEA	s!+100(A4)
	PEA	G353_ac_St(A4)
	JSR	strcat(PC)
	ADDQ.L	#8,A7
	PEA	G353_ac_St(A4)
	MOVE	-8(A6),-(A7)
	MOVE	#132,-(A7)
	MOVE	#148,-(A7)
	JSR	F052_aaoz_(PC)
	ADDA	#10,A7
	OR	#16384,D6
L284:
	MOVE.B	29(A3),D4
	AND	#255,D4
	ADDQ	#4,D4
	SUB	G308_i_Par(A4),D4
	AND	#3,D4
	MOVE	D6,D0
	AND	#1024,D0
	BEQ	L289(PC)
	MOVE	G599_ui_Us(A4),D0
	MOVE	D4,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BEQ	L289(PC)
	MOVE	#160,-(A7)
	MOVE	D7,D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	#12,-(A7)
	MOVE	#160,-(A7)
	MOVE	#40,-(A7)
	CLR	-(A7)
	MOVE.B	28(A3),D0
	AND	#255,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	MULS	#19,D0
	MOVE	D0,-(A7)
	MOVE	D4,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE	#28,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L289:
	MOVE	D6,D0
	AND	#2048,D0
	BEQ.S	L290
	MOVE	D5,D0
	BEQ.S	L290
	MOVE	G333_B_Pre(A4),D0
	BEQ.S	L291
	JSR	F345_xxxx_(PC)
	BRA.S	L292
L291:
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L293
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L294
	JSR	F351_xxxx_(PC)
L294:
	BRA.S	L295
L293:
	JSR	F347_xxxx_(PC)
L295:
L292:
	OR	#16384,D6
L290:
	MOVE	D6,D0
	AND	#-32768,D0
	BEQ.S	L296
	MOVE	#1,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D7,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D5,D0
	BEQ.S	L297
	OR	#16384,D6
L297:
L296:
	MOVE	D6,D0
	AND	#16384,D0
	BEQ.S	L298
	CLR	-(A7)
	JSR	F097_lzzz_(PC)
	ADDQ.L	#2,A7
L298:
L15T292_042:
	ANDI	#127,48(A3)
	JSR	F078_xzzz_(PC)
L245:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$244:	.EQU	#-42
F293_ahzz_:/* global */
	LINK	A6,L$299
	MOVE	D7,-(A7)
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	CLR	D7
	BRA.S	L301
L302:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L303:
	ADDQ	#1,D7
L301:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L302
L304:
L300:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$299:	.EQU	#0
F294_aozz_:/* global */
	LINK	A6,L$305
	MOVEM.L	A3-A2/D7-D6,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	10(A6),D7
	ASL.L	#1,D7
	LEA	212(A3),A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BEQ.S	L307
	MOVE	#0,D0
	BRA	L306(PC)
L307:
	MOVE	D7,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#16,D0
	BLT.S	L308
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#31,D0
	BGT.S	L308
	MOVE	#10,D6
	BRA.S	L309
L308:
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#32,D0
	BLT.S	L310
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#47,D0
	BGT.S	L310
	MOVE	#11,D6
	BRA.S	L311
L310:
	MOVE	#0,D0
	BRA.S	L306
L311:
L309:
	MOVE	12(A6),D7
	ASL.L	#1,D7
	LEA	212(A3),A0
	ADDA	D7,A0
	MOVE	(A0),D7
	MOVE	D7,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	D7,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	SEQ	D0
	TST.B	D0
	BEQ.S	L312
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	D6,D0
	SEQ	D0
	TST.B	D0
L312:
	AND	#1,D0
L306:
	MOVEM.L	(A7)+,D6-D7/A2-A3
	UNLK	A6
	RTS
L$305:	.EQU	#0
F295_xxxx_:/* global */
	LINK	A6,L$313
	MOVEM.L	D7-D5,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,-(A7)
	JSR	F039_aaaL_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	CMPI	#32,D6
	BGE.S	L317
	CMPI	#0,D6
	BGE.S	L316
L317:
	CMPI	#148,D6
	BLT.S	L318
	CMPI	#163,D6
	BLE.S	L316
L318:
	CMPI	#195,D6
	BNE.S	L315
L316:
	MOVE	10(A6),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	D5,D0
	CMP	D6,D0
	BEQ.S	L319
	CMPI	#8,D7
	BGE.S	L320
	MOVE	G420_B_Mou(A4),D0
	BNE.S	L320
	MOVE	#1,G420_B_Mou(A4)
	JSR	F077_aA39_(PC)
L320:
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F038_AA07_(PC)
	ADDQ.L	#4,A7
	MOVE	#1,D0
	BRA.S	L314
L319:
L315:
	MOVE	#0,D0
L314:
	MOVEM.L	(A7)+,D5-D7
	UNLK	A6
	RTS
L$313:	.EQU	#0
F296_aizz_:/* global */
	LINK	A6,L$321
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G423_i_Inv(A4),D6
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L323
	MOVE	D6,D0
	BNE.S	L323
	BRA	L322(PC)
L323:
	CLR	G420_B_Mou(A4)
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#32,D0
	BGE.S	L326
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGE.S	L325
L326:
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#148,D0
	BLT.S	L327
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#163,D0
	BLE.S	L325
L327:
	MOVE	G413_i_Lea(A4),D0
	MOVE	D0,D5
	CMPI	#195,D0
	BNE.S	L324
L325:
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-2(A6)
	MOVE	-2(A6),D0
	CMP	D5,D0
	BEQ.S	L328
	MOVE	#1,G420_B_Mou(A4)
	JSR	F077_aA39_(PC)
	MOVE.L	G412_puc_B(A4),-(A7)
	MOVE	-2(A6),-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	MOVE.L	G412_puc_B(A4),-(A7)
	JSR	F068_aagz_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),G413_i_Lea(A4)
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L328:
L324:
	CLR	D7
	BRA.S	L329
L330:
	MOVE	D7,D4
	LSR	#1,D4
	MOVE	D6,D0
	MOVE	D4,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L333
	BRA.S	L331
L333:
	MOVE	D7,D0
	AND	#1,D0
	MOVE	D4,D1
	MULS	#800,D1
	LEA	G407_s_Par+212(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D0
	LEA	(A0),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	TST	D0
	BEQ.S	L334
	MOVE	D7,D0
	AND	#1,D0
	CMPI	#1,D0
	BNE.S	L334
	MOVE	D4,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L334:
L331:
	ADDQ	#1,D7
L329:
	MOVE	D7,D0
	MOVE	G305_ui_Pa(A4),D1
	ASL	#1,D1
	CMP	D1,D0
	BCS.S	L330
L332:
	MOVE	D6,D0
	BEQ	L335(PC)
	MOVE	D6,D0
	MULS	#800,D0
	LEA	G407_s_Par+-800(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	#0,D0
	MOVE	D0,D7
	ASL.L	#1,D0
	LEA	212(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	D5
	BRA.S	L336
L337:
	MOVE	(A3),-(A7)
	MOVE	D7,D0
	ADDQ	#8,D0
	MOVE	D0,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-4(A6)
	OR	D0,D5
	MOVE	-4(A6),D0
	BEQ.S	L340
	CMPI	#1,D7
	BNE.S	L340
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F386_ezzz_(PC)
	ADDQ.L	#2,A7
L340:
L338:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#2,A3
L336:
	CMPI	#30,D7
	BCS.S	L337
L339:
	CMPI	#4,G424_i_Pan(A4)
	BNE.S	L341
	LEA	G425_aT_Ch(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA.S	L342
L343:
	MOVE	(A3),-(A7)
	MOVE	D7,D0
	ADD	#38,D0
	MOVE	D0,-(A7)
	JSR	F295_xxxx_(PC)
	ADDQ.L	#4,A7
	OR	D0,D5
L344:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDQ.L	#2,A3
L342:
	CMPI	#8,D7
	BCS.S	L343
L345:
L341:
	MOVE	D5,D0
	BEQ.S	L346
	ORI	#16384,48(A2)
	MOVE	D6,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L346:
L335:
	MOVE	G420_B_Mou(A4),D0
	BEQ.S	L347
	JSR	F078_xzzz_(PC)
L347:
L322:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$321:	.EQU	#-4
F297_atzz_:/* global */
	LINK	A6,L$348
	CMPI	#-1,8(A6)
	BNE.S	L350
	BRA	L349(PC)
L350:
	CLR	G415_B_Lea(A4)
	MOVE.L	G412_puc_B(A4),-(A7)
	MOVE	8(A6),D0
	MOVE	D0,G414_T_Lea(A4)
	MOVE	D0,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,G413_i_Lea(A4)
	MOVE	D0,-(A7)
	JSR	F036_aA19_(PC)
	ADDQ.L	#6,A7
	JSR	F077_aA39_(PC)
	MOVE	8(A6),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
	MOVE	10(A6),D0
	BEQ.S	L351
	MOVE	#1,G325_B_Set(A4)
	BRA.S	L352
L351:
	MOVE.L	G412_puc_B(A4),-(A7)
	JSR	F068_aagz_(PC)
	ADDQ.L	#4,A7
L352:
	JSR	F078_xzzz_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L353
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L353:
L349:
	UNLK	A6
	RTS
L$348:	.EQU	#0
F298_aqzz_:/* global */
	LINK	A6,L$354
	MOVE	D7,-(A7)
	MOVE	#1,G415_B_Lea(A4)
	MOVE	G414_T_Lea(A4),D0
	MOVE	D0,D7
	CMPI	#-1,D0
	BEQ.S	L356
	MOVE	#-1,G414_T_Lea(A4)
	MOVE	#-1,G413_i_Lea(A4)
	JSR	F077_aA39_(PC)
	JSR	F035_aaaw_(PC)
	JSR	F069_aaaL_(PC)
	JSR	F078_xzzz_(PC)
	CMPI	#-1,G411_i_Lea(A4)
	BEQ.S	L357
	MOVE	D7,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,D1
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+272(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	SUB	D1,D0
	MOVE	D0,(A0)
	MOVE	G411_i_Lea(A4),D0
	MULS	#800,D0
	LEA	G407_s_Par+48(A4),A0
	ADDA	D0,A0
	ORI	#512,(A0)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L357:
L356:
	MOVE	D7,D0
L355:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$354:	.EQU	#0
F299_xxxx_:/* global */
	LINK	A6,L$358
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	CLR	D4
	MOVE	18(A6),D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	MOVE	D0,D5
	CMPI	#5,D0
	BEQ.S	L361
	CMPI	#6,D5
	BNE.S	L360
L361:
	CMPI	#0,D7
	BCS.S	L360
	CMPI	#12,D7
	BHI.S	L360
	MOVE	18(A6),-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-4(A6)
	CMPI	#5,D5
	BNE.S	L364
	MOVE.L	-4(A6),A0
	MOVE	2(A0),D0
	AND	#256,D0
	LSR	#8,D0
	BNE.S	L363
L364:
	CMPI	#6,D5
	BNE.S	L362
	MOVE.L	-4(A6),D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#256,D0
	LSR	#8,D0
	BEQ.S	L362
L363:
	CLR	D5
	MOVE	#-3,D4
	BRA	L22T299_044(PC)
L362:
L360:
	CMPI	#137,D6
	BNE.S	L365
	CMPI	#30,D7
	BCC.S	L365
	CLR	D5
	MOVE	#10,D4
	BRA	L366(PC)
L365:
	CMPI	#1,D7
	BNE	L367(PC)
	CMPI	#45,D6
	BNE.S	L368
	MOVE	#1,D5
	MOVE	#5,D4
	BRA	L369(PC)
L368:
	MOVE	#8,D5
	CMPI	#20,D6
	BCS.S	L370
	CMPI	#22,D6
	BHI.S	L370
	MOVE	#4,D4
	BRA	L371(PC)
L370:
	CMPI	#58,D6
	BCS	L372(PC)
	CMPI	#66,D6
	BHI	L372(PC)
	MOVE	D6,D0
L373:
	CMP	#58,D0
	BEQ.S	L374
	BRA.S	L376
L374:
	MOVE	#2,D4
	BRA	L375(PC)
	BRA.S	L377
L376:
	CMP	#59,D0
	BEQ.S	L377
	BRA.S	L378
L377:
	MOVE	#1,D4
	BRA.S	L375
	BRA.S	L379
L378:
	CMP	#60,D0
	BEQ.S	L379
	BRA.S	L380
L379:
	MOVE	#6,D4
	BRA.S	L375
	BRA.S	L381
L380:
	CMP	#61,D0
	BEQ.S	L381
	BRA.S	L382
L381:
	MOVE	#4,D4
	BRA.S	L375
	BRA.S	L383
L382:
	CMP	#62,D0
	BEQ.S	L383
	BRA.S	L384
L383:
	MOVE	#10,D4
	BRA.S	L375
	BRA.S	L385
L384:
	CMP	#63,D0
	BEQ.S	L385
	BRA.S	L386
L385:
	MOVE	#8,D4
	BRA.S	L375
	BRA.S	L387
L386:
	CMP	#64,D0
	BEQ.S	L387
	BRA.S	L388
L387:
	MOVE	#16,D4
	BRA.S	L375
	BRA.S	L389
L388:
	CMP	#65,D0
	BEQ.S	L389
	BRA.S	L390
L389:
	MOVE	#7,D4
	BRA.S	L375
	BRA.S	L391
L390:
	CMP	#66,D0
	BEQ.S	L391
	BRA.S	L392
L391:
	MOVE	#5,D4
L392:
L393:
L375:
	BRA.S	L394
L372:
	MOVE	D6,D0
L395:
	CMP	#38,D0
	BEQ.S	L396
	BRA.S	L398
L396:
	MOVE	#1,D4
	BRA.S	L397
	BRA.S	L399
L398:
	CMP	#41,D0
	BEQ.S	L399
	BRA.S	L400
L399:
	MOVE	#2,D4
	BRA.S	L397
	BRA.S	L401
L400:
	CMP	#40,D0
	BEQ.S	L401
	BRA.S	L402
L401:
	MOVE	#4,D4
L402:
L403:
L397:
L394:
L371:
L369:
	BRA	L404(PC)
L367:
	CMPI	#4,D7
	BNE.S	L405
	CMPI	#142,D6
	BNE.S	L406
	MOVE	#1,D5
	MOVE	#10,D4
L406:
	BRA	L407(PC)
L405:
	CMPI	#2,D7
	BNE.S	L408
	CMPI	#104,D6
	BNE.S	L409
	MOVE	#3,D5
	MOVE	#10,D4
	BRA.S	L410
L409:
	CMPI	#140,D6
	BNE.S	L411
	MOVE	#2,D5
	MOVE	#10,D4
L411:
L410:
	BRA.S	L412
L408:
	CMPI	#3,D7
	BNE.S	L413
	CMPI	#141,D6
	BNE.S	L414
	MOVE	#6,D5
	MOVE	#12,D4
	BRA.S	L415
L414:
	CMPI	#81,D6
	BNE.S	L416
	MOVE	#2,D5
	MOVE	#8,D4
L416:
L415:
	BRA.S	L417
L413:
	CMPI	#10,D7
	BNE.S	L418
	CMPI	#10,D6
	BCS.S	L419
	CMPI	#11,D6
	BHI.S	L419
	MOVE	#5,D5
	MOVE	#15,D4
	BRA.S	L420
L419:
	CMPI	#81,D6
	BNE.S	L421
	MOVE	#2,D5
	MOVE	#8,D4
	BRA.S	L422
L421:
	CMPI	#122,D6
	BNE.S	L423
	MOVE	#8,D5
	MOVE	#3,D4
L423:
L422:
L420:
L418:
L417:
L412:
L407:
L404:
L366:
L22T299_044:
	MOVE	D4,D0
	BEQ.S	L424
	MOVE	D4,D0
	MULS	16(A6),D0
	MOVE	D0,D4
	CMPI	#8,D5
	BNE.S	L425
	MOVE	D4,D0
	ADD	D0,62(A3)
	BRA.S	L426
L425:
	CMPI	#7,D5
	BGE.S	L427
	CLR	D7
	BRA.S	L428
L429:
	MOVE	D5,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADD.L	A0,D0
	MOVE.L	D0,-14(A6)
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	-14(A6),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D4,D0
	MOVE.B	D0,(A0)
L428:
	CMPI	#2,D7
	BLS.S	L429
L430:
L427:
L426:
	ORI	#2304,48(A3)
L424:
L359:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$358:	.EQU	#-14
F300_aozz_:/* global */
	LINK	A6,L$431
	MOVEM.L	A3-A2/D7-D5,-(A7)
	MOVE	10(A6),D7
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#30,D7
	BCS.S	L433
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
	BRA.S	L434
L433:
	MOVE	D7,D6
	ASL.L	#1,D6
	LEA	212(A3),A0
	ADDA	D6,A0
	MOVE	(A0),D6
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	#-1,(A0)
L434:
	CMPI	#-1,D6
	BNE.S	L435
	MOVE	#-1,D0
	BRA	L432(PC)
L435:
	MOVE	8(A6),D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	D6,-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F299_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#10,D7
	BNE.S	L436
	CMPI	#12,D5
	BLT.S	L437
	CMPI	#13,D5
	BGT.S	L437
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	MOVE	G039_ai_Gr+4(A4),D0
	SUB	D0,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	BRA.S	L438
L437:
	CMPI	#10,D5
	BLT.S	L439
	CMPI	#11,D5
	BGT.S	L439
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
L439:
L438:
L436:
	MOVE	D7,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),D0
	BEQ.S	L440
	ORI	#16384,48(A3)
L440:
	CMPI	#2,D7
	BCC	L441(PC)
	CMPI	#1,D7
	BNE.S	L442
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	MOVE	8(A6),D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L443
	JSR	F388_rzzz_(PC)
L443:
	CMPI	#30,D5
	BLT.S	L444
	CMPI	#31,D5
	BGT.S	L444
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,2(A0)
	OR	D3,2(A0)
	JSR	F296_aizz_(PC)
L444:
L442:
	CMPI	#4,D5
	BLT.S	L445
	CMPI	#7,D5
	BGT.S	L445
	MOVE	#0,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ASL	#8,D3
	ANDI	#32767,2(A2)
	OR	D3,2(A2)
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
L445:
	MOVE	-2(A6),D0
	BEQ.S	L446
	CMPI	#1,D7
	BNE.S	L446
	CMPI	#144,D5
	BNE.S	L447
	JSR	F334_akzz_(PC)
	BRA.S	L23T300_011
L447:
	CMPI	#30,D5
	BLT.S	L448
	CMPI	#31,D5
	BGT.S	L448
L23T300_011:
	ORI	#2048,48(A3)
L448:
L446:
L441:
	MOVE	D6,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	SUB	D0,272(A3)
	ORI	#512,48(A3)
	MOVE	D6,D0
L432:
	MOVEM.L	(A7)+,D5-D7/A2-A3
	UNLK	A6
	RTS
L$431:	.EQU	#-2
F301_apzz_:/* global */
	LINK	A6,L$449
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	10(A6),D6
	MOVE	12(A6),D5
	CMPI	#-1,D6
	BNE.S	L451
	BRA	L450(PC)
L451:
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#30,D5
	BCS.S	L452
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
	BRA.S	L453
L452:
	MOVE	D5,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	D6,(A0)
L453:
	MOVE	D6,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	ADD	D0,272(A3)
	ORI	#512,48(A3)
	MOVE	D6,-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	SEQ	D0
	AND	#1,D0
	MOVE	D0,-2(A6)
	MOVE	D6,-(A7)
	MOVE	#1,-(A7)
	MOVE	D4,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F299_xxxx_(PC)
	ADDA	#12,A7
	MOVE	D6,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	CMPI	#2,D5
	BCC	L454(PC)
	CMPI	#1,D5
	BNE.S	L455
	ORI	#-32768,48(A3)
	MOVE	G506_i_Act(A4),D0
	MOVE	D7,D1
	ADDQ	#1,D1
	CMP	D1,D0
	BNE.S	L456
	JSR	F388_rzzz_(PC)
L456:
	CMPI	#30,D4
	BLT.S	L457
	CMPI	#31,D4
	BGT.S	L457
	MOVE	#0,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,2(A0)
	OR	D3,2(A0)
	JSR	F296_aizz_(PC)
L457:
L455:
	CMPI	#4,D4
	BNE.S	L458
	MOVE	#1,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ASL	#8,D3
	ANDI	#32767,2(A2)
	OR	D3,2(A2)
	JSR	F337_akzz_(PC)
	JSR	F296_aizz_(PC)
	BRA.S	L459
L458:
	MOVE	-2(A6),D0
	BEQ.S	L460
	CMPI	#1,D5
	BNE.S	L460
	CMPI	#144,D4
	BEQ.S	L461
	CMPI	#30,D4
	BLT.S	L460
	CMPI	#31,D4
	BGT.S	L460
L461:
	ORI	#2048,48(A3)
L460:
L459:
	BRA.S	L462
L454:
	CMPI	#10,D5
	BNE.S	L463
	CMPI	#12,D4
	BLT.S	L464
	CMPI	#13,D4
	BGT.S	L464
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	MOVE	G039_ai_Gr+4(A4),D0
	ADD	D0,G407_s_Par+3200(A4)
	JSR	F337_akzz_(PC)
	ADDQ	#1,D4
	BRA.S	L465
L464:
	CMPI	#10,D4
	BLT.S	L466
	CMPI	#11,D4
	BGT.S	L466
	MOVE	#1,D0
	MOVE.L	A2,D1
	MOVE.L	D1,A0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A0)
	OR	D3,2(A0)
	ADDQ	#1,D4
L466:
L465:
L463:
L462:
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F291_xxxx_(PC)
	ADDQ.L	#4,A7
	MOVE	-2(A6),D0
	BEQ.S	L467
	ORI	#16384,48(A3)
L467:
L450:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$449:	.EQU	#-2
F302_mzzz_:/* global */
	LINK	A6,L$468
	MOVEM.L	D7-D4,-(A7)
	CMPI	#8,8(A6)
	BCC.S	L470
	MOVE	G299_ui_Ca(A4),D0
	BEQ.S	L471
	BRA	L469(PC)
L471:
	MOVE	8(A6),D7
	LSR	#1,D7
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCC.S	L473
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BEQ.S	L473
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par+52(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	BNE.S	L472
L473:
	BRA	L469(PC)
L472:
	MOVE	8(A6),D6
	AND	#1,D6
	BRA.S	L474
L470:
	MOVE	G423_i_Inv(A4),D7
	SUBQ	#1,D7
	MOVE	8(A6),D6
	SUBQ	#8,D6
L474:
	MOVE	G414_T_Lea(A4),D5
	CMPI	#30,D6
	BCS.S	L475
	MOVE	D6,D4
	ASL.L	#1,D4
	LEA	G425_aT_Ch+-60(A4),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	BRA.S	L476
L475:
	MOVE	D6,D4
	MOVE	D7,D1
	MULS	#800,D1
	LEA	G407_s_Par+212(A4),A0
	ADDA	D1,A0
	ASL.L	#1,D4
	LEA	(A0),A0
	ADDA	D4,A0
	MOVE	(A0),D4
L476:
	CMPI	#-1,D4
	BNE.S	L477
	CMPI	#-1,D5
	BNE.S	L477
	BRA.S	L469
L477:
	CMPI	#-1,D5
	BEQ.S	L478
	MOVE	D5,-(A7)
	JSR	F141_anzz_(PC)
	ADDQ.L	#2,A7
	MULS	#6,D0
	LEA	G237_as_Gr+4(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D6,D1
	ASL.L	#1,D1
	LEA	G038_ai_Gr(A4),A0
	ADDA	D1,A0
	AND	(A0),D0
	BNE.S	L478
	BRA.S	L469
L478:
	JSR	F077_aA39_(PC)
	CMPI	#-1,D5
	BEQ.S	L479
	JSR	F298_aqzz_(PC)
L479:
	CMPI	#-1,D4
	BEQ.S	L480
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	CLR	-(A7)
	MOVE	D4,-(A7)
	JSR	F297_atzz_(PC)
	ADDQ.L	#4,A7
L480:
	CMPI	#-1,D5
	BEQ.S	L481
	MOVE	D6,-(A7)
	MOVE	D5,-(A7)
	MOVE	D7,-(A7)
	JSR	F301_apzz_(PC)
	ADDQ.L	#6,A7
L481:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L469:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$468:	.EQU	#0
F303_AA09_:/* global */
	LINK	A6,L$482
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L484
	MOVE	#1,D0
	BRA	L483(PC)
L484:
	MOVE	10(A6),D0
	AND	#-32768,D0
	MOVE	D0,-2(A6)
	MOVE	10(A6),D0
	AND	#16384,D0
	MOVE	D0,-4(A6)
	ANDI	#16383,10(A6)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE	10(A6),D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	2(A3),D7
	MOVE	-2(A6),D0
	BNE.S	L485
	MOVE	(A3),D0
	EXT.L	D0
	ADD.L	D0,D7
L485:
	CMPI	#3,10(A6)
	BLS.S	L486
	MOVE	10(A6),D0
	SUBQ	#4,D0
	LSR	#2,D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	ADD.L	2(A3),D7
	MOVE	-2(A6),D0
	BNE.S	L487
	MOVE	(A3),D0
	EXT.L	D0
	ADD.L	D0,D7
L487:
	MOVE.L	D7,D0
	ASR.L	#1,D0
	MOVE.L	D0,D7
L486:
	MOVE	#1,D6
	BRA.S	L488
L489:
	MOVE.L	D7,D0
	ASR.L	#1,D0
	MOVE.L	D0,D7
	ADDQ	#1,D6
L488:
	CMPI.L	#500,D7
	BGE.S	L489
L490:
	MOVE	-4(A6),D0
	BNE	L491(PC)
	MOVE	214(A2),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#27,D0
	BNE.S	L492
	ADDQ	#1,D6
	BRA.S	L493
L492:
	CMPI	#28,D4
	BNE.S	L494
	ADDQ	#2,D6
L494:
L493:
	MOVE	232(A2),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D5
	MOVE	10(A6),D0
L495:
	CMP	#3,D0
	BEQ.S	L496
	BRA.S	L498
L496:
	CMPI	#124,D5
	BNE.S	L500
	ADDQ	#1,D6
L500:
	BRA.S	L497
	BRA.S	L499
L498:
	CMP	#15,D0
	BEQ.S	L499
	BRA.S	L501
L499:
	CMPI	#121,D5
	BNE.S	L503
	ADDQ	#1,D6
L503:
	BRA.S	L497
	BRA.S	L502
L501:
	CMP	#13,D0
	BEQ.S	L502
	BRA.S	L504
L502:
	CMPI	#120,D5
	BEQ.S	L507
	CMPI	#66,D4
	BNE.S	L506
L507:
	ADDQ	#1,D6
L506:
	BRA.S	L497
	BRA.S	L505
L504:
	CMP	#14,D0
	BEQ.S	L505
	BRA.S	L508
L505:
	CMPI	#122,D5
	BNE.S	L510
	ADDQ	#1,D6
L510:
L508:
L509:
L497:
L491:
	MOVE	D6,D0
L483:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$482:	.EQU	#-4
F304_apzz_:/* global */
	LINK	A6,L$511
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	12(A6),D7
	CMPI	#4,10(A6)
	BCS.S	L513
	CMPI	#11,10(A6)
	BHI.S	L513
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#150,D1
	CMP.L	D1,D0
	BGE.S	L513
	MOVE	D7,D0
	LSR	#1,D0
	MOVE	D0,D7
L513:
	MOVE	D7,D0
	BEQ	L514(PC)
	MOVE.L	G269_ps_Cu(A4),A0
	MOVE	12(A0),D6
	AND	#-4096,D6
	LSR	#4,D6
	LSR	#8,D6
	BEQ.S	L515
	MOVE	D7,D0
	MULU	D6,D0
	MOVE	D0,D7
L515:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	CMPI	#4,10(A6)
	BCS.S	L516
	MOVE	10(A6),D5
	SUBQ	#4,D5
	LSR	#2,D5
	BRA.S	L517
L516:
	MOVE	10(A6),D5
L517:
	MOVE.L	2(A3),D4
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	CMPI	#4,10(A6)
	BCS.S	L518
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#25,D1
	CMP.L	D1,D0
	BLE.S	L518
	MOVE	D7,D0
	ASL	#1,D0
	MOVE	D0,D7
L518:
	MOVE	10(A6),D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	D7,D0
	AND.L	#65535,D0
	ADD.L	D0,2(A3)
	CMPI	#32000,(A3)
	BGE.S	L519
	MOVE	#100,-(A7)
	MOVE	D7,D0
	LSR	#3,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	ADD	D0,(A3)
L519:
	MOVE	D5,D0
	MULS	#6,D0
	LEA	92(A2),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CMPI	#4,10(A6)
	BCS.S	L520
	MOVE	D7,D0
	AND.L	#65535,D0
	ADD.L	D0,2(A3)
L520:
	MOVE	D5,D0
	OR	#-16384,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	D7,D0
	CMP	D6,D0
	BLS	L521(PC)
	MOVE	D7,-6(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,-2(A6)
	JSR	F028_a000_(PC)
	MOVE.L	D0,D1
	MOVE	#1,D0
	ADD	D1,D0
	MOVE	D0,-4(A6)
	JSR	F028_a000_(PC)
	MOVE	D0,D6
	CMPI	#2,D5
	BEQ.S	L522
	AND	D7,D6
L522:
	MOVE	D6,D0
	ADD.B	D0,82(A2)
	MOVE	58(A2),D6
	JSR	F028_a000_(PC)
	MOVE	D7,D1
	NOT	D1
	AND	D1,D0
	ADD.B	D0,88(A2)
	MOVE	D5,D0
L523:
	CMP	#0,D0
	BEQ.S	L524
	BRA.S	L526
L524:
	MOVE	D6,D0
	LSR	#4,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MULU	#3,D0
	MOVE	D0,D7
	MOVE	-4(A6),D0
	ADD.B	D0,73(A2)
	MOVE	-2(A6),D0
	ADD.B	D0,76(A2)
	BRA	L525(PC)
	BRA.S	L527
L526:
	CMP	#1,D0
	BEQ.S	L527
	BRA.S	L528
L527:
	MOVE	D6,D0
	AND.L	#65535,D0
	DIVU	#21,D0
	MOVE	D0,D6
	MOVE	D7,D0
	ASL	#1,D0
	MOVE	D0,D7
	MOVE	-2(A6),D0
	ADD.B	D0,73(A2)
	MOVE	-4(A6),D0
	ADD.B	D0,76(A2)
	BRA	L525(PC)
	BRA.S	L529
L528:
	CMP	#3,D0
	BEQ.S	L529
	BRA.S	L530
L529:
	MOVE	D6,D0
	LSR	#5,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MOVE	D7,D1
	LSR	#1,D1
	ADD	D1,D0
	ADD	D0,62(A2)
	MOVE	-4(A6),D0
	ADD.B	D0,79(A2)
	BRA.S	L27T304_016
	BRA.S	L531
L530:
	CMP	#2,D0
	BEQ.S	L531
	BRA.S	L532
L531:
	MOVE	D6,D0
	AND.L	#65535,D0
	DIVU	#25,D0
	MOVE	D0,D6
	MOVE	D7,D0
	ADD	D0,62(A2)
	MOVE	D7,D0
	ADDQ	#1,D0
	LSR	#1,D0
	ADD	D0,D7
	MOVE	-2(A6),D0
	ADD.B	D0,79(A2)
L27T304_016:
	MOVE	-6(A6),D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	JSR	F029_AA19_(PC)
	MOVE	D0,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	62(A2),D0
	ADD	D1,D0
	MOVE	D0,62(A2)
	CMPI	#900,D0
	BLE.S	L534
	MOVE	#900,62(A2)
L534:
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#3,D0
	SWAP	D0
	ADD.B	D0,85(A2)
L532:
L533:
L525:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE	D7,D0
	LSR	#1,D0
	ADDQ	#1,D0
	AND.L	#65535,D1
	DIVU	D0,D1
	SWAP	D1
	MOVE	D1,-16(A6)
	MOVE	D7,D1
	ADD	-16(A6),D1
	MOVE	54(A2),D0
	ADD	D1,D0
	MOVE	D0,54(A2)
	CMP	#999,D0
	BLE.S	L535
	MOVE	#999,54(A2)
L535:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	MOVE	D6,D0
	LSR	#1,D0
	ADDQ	#1,D0
	AND.L	#65535,D1
	DIVU	D0,D1
	SWAP	D1
	MOVE	D1,-26(A6)
	MOVE	D6,D1
	ADD	-26(A6),D1
	MOVE	58(A2),D0
	ADD	D1,D0
	MOVE	D0,58(A2)
	CMP	#9999,D0
	BLE.S	L536
	MOVE	#9999,58(A2)
L536:
	ORI	#256,48(A2)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F051_AA19_(PC)
	LEA	(A2),A0
	MOVE.L	A0,-(A7)
	MOVE	8(A6),D0
	LEA	G046_auc_G(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 4A 55 53 54 20 47 41 49 4E 45 44 20 41 20 00 
CODE SEG "player"
	PEA	s!+104(A4)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	D5,D0
	ASL.L	#2,D0
	LEA	G417_apc_B(A4),A0
	ADDA	D0,A0
	MOVE.L	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
DATA SEG "s!"
	DATA 20 4C 45 56 45 4C 21 00 
CODE SEG "player"
	PEA	s!+120(A4)
	MOVE	D7,-(A7)
	JSR	F047_xzzz_(PC)
	ADDQ.L	#6,A7
L521:
L514:
L512:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$511:	.EQU	#-26
F305_xxxx_:/* global */
	LINK	A6,L$537
	MOVEM.L	D7-D6,-(A7)
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	LSR	#1,D0
	MOVE	D0,D7
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	BRA.S	L539
L540:
	MOVE	D7,D0
	ASR	#1,D0
	ADD	D0,D6
L539:
	MOVE	D7,D0
	SUB	#10,D0
	MOVE	D0,D7
	CMPI	#0,D0
	BGT.S	L540
L541:
	MOVE	D6,D0
L538:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$537:	.EQU	#0
F306_xxxx_:/* global */
	LINK	A6,L$542
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE	56(A3),D0
	MOVE	D0,D7
	MOVE	58(A3),D1
	ASR	#1,D1
	MOVE	D1,D6
	CMP	D1,D0
	BGE.S	L544
	MOVE	12(A6),D0
	ASR	#1,D0
	MOVE	D0,12(A6)
	MOVE	12(A6),D1
	EXT.L	D1
	MOVE	D7,D2
	EXT.L	D2
	MOVE.L	D1,-(A7)
	MOVE.L	D2,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	MOVE.L	D1,-(A7)
	MOVE	D6,D1
	EXT.L	D1
	MOVE.L	D1,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D1
	ADDQ.L	#4,A7
	ADD	D1,D0
	BRA.S	L543
L544:
	MOVE	12(A6),D0
L543:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$542:	.EQU	#0
F307_fzzz_:/* global */
	LINK	A6,L$545
	MOVE	D7,-(A7)
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	MULS	#3,D0
	LEA	71(A0),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	MOVE	D0,-10(A6)
	MOVE	#170,D0
	MOVE.B	-10(A6),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,D7
	CMPI	#16,D0
	BGE.S	L547
	MOVE	14(A6),D0
	LSR	#3,D0
	BRA.S	L546
L547:
	MOVE	D7,-(A7)
	MOVE	#7,-(A7)
	MOVE	14(A6),-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
L546:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$545:	.EQU	#-10
F308_vzzz_:/* global */
	LINK	A6,L$548
	MOVEM.L	A3/D7,-(A7)
	MOVE	12(A6),D7
	JSR	F028_a000_(PC)
	TST	D0
	BEQ.S	L550
	JSR	F027_AA59_(PC)
	AND.L	#65535,D0
	DIVU	#100,D0
	SWAP	D0
	CMP	D7,D0
	BLS.S	L550
	MOVE	#1,D0
	BRA.S	L549
L550:
	MOVE.L	8(A6),A0
	LEA	70(A0),A0
	MOVE.L	A0,A3
	JSR	F027_AA59_(PC)
	MOVE.B	1(A3),D1
	AND	#255,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	CMP	D7,D0
	SHI	D0
	AND	#1,D0
	MOVE	D0,D7
	MOVE.B	(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	MOVE.B	1(A3),D0
	MOVE	D7,D1
	BEQ.S	L551
	MOVE	#-2,D1
	BRA.S	L552
L551:
	MOVE	#2,D1
L552:
	AND	#255,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE.B	2(A3),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE.B	D0,1(A3)
	MOVE	D7,D0
L549:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$548:	.EQU	#0
F309_awzz_:/* global */
	LINK	A6,L$553
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	74(A3),D7
	AND	#255,D7
	ASL	#3,D7
	ADD	#100,D7
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F306_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	50(A3),D6
	BEQ.S	L555
	MOVE	D7,D0
	MOVE	D6,D1
	AND	#16,D1
	BEQ.S	L556
	MOVE	#2,D1
	BRA.S	L557
L556:
	MOVE	#3,D1
L557:
	LSR	D1,D0
	SUB	D0,D7
L555:
	MOVE	222(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#119,D0
	BNE.S	L558
	MOVE	D7,D0
	LSR	#4,D0
	ADD	D0,D7
L558:
	ADD	#9,D7
	MOVE	D7,D0
	AND.L	#65535,D0
	DIVU	#10,D0
	SWAP	D0
	SUB	D0,D7
	MOVE	D7,D0
L554:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$553:	.EQU	#0
F310_AA08_:/* global */
	LINK	A6,L$559
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
	MOVE	272(A3),D1
	MOVE	D1,D7
	CMP	D1,D0
	BLS.S	L561
	MOVE	#2,D5
	MOVE	D7,D0
	AND.L	#65535,D0
	ASL.L	#3,D0
	MOVE	D6,D1
	AND.L	#65535,D1
	MOVE.L	D1,-(A7)
	MOVE.L	#5,D1
	MOVE.L	D1,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D1
	CMP.L	D1,D0
	BLE.S	L562
	ADDQ	#1,D5
L562:
	MOVE	#1,D7
	BRA.S	L563
L561:
	MOVE	#4,D5
	MOVE	D7,D1
	SUB	D6,D1
	ASL	#2,D1
	AND.L	#65535,D1
	DIVU	D6,D1
	ADD	D1,D5
	MOVE	#2,D7
L563:
	MOVE	50(A3),D0
	AND	#32,D0
	BEQ.S	L564
	ADD	D7,D5
L564:
	MOVE	222(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#194,D0
	BNE.S	L565
	SUBQ	#1,D5
L565:
	MOVE	D5,D0
L560:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$559:	.EQU	#0
F311_wzzz_:/* global */
	LINK	A6,L$566
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	JSR	F027_AA59_(PC)
	AND	#7,D0
	MOVE.B	77(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	D7,D0
	ASR	#1,D0
	EXT.L	D0
	MOVE	272(A3),D1
	AND.L	#65535,D1
	MOVE.L	D0,-(A7)
	MOVE.L	D1,D0
	MOVE.L	D0,-(A7)
	JSR	_lmul(PC)
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	MOVE.L	D0,-(A7)
	MOVE	D1,D0
	AND.L	#65535,D0
	MOVE.L	D0,-(A7)
	JSR	_ldiv(PC)
	MOVE.L	(A7)+,D0
	ADDQ.L	#4,A7
	SUB	D0,D7
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L568
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L568:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	#100,D0
	SUB	D1,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	#1,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L567:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$566:	.EQU	#0
F312_xzzz_:/* global */
	LINK	A6,L$569
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE.B	74(A3),D3
	AND	#255,D3
	ADD	D3,D0
	MOVE	D0,D7
	MOVE	10(A6),D4
	ASL.L	#1,D4
	LEA	212(A3),A0
	ADDA	D4,A0
	MOVE	(A0),D4
	MOVE	D4,-(A7)
	JSR	F140_yzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D6
	MOVE.L	D0,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F309_awzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	LSR	#4,D1
	MOVE	D1,D5
	CMP	D1,D0
	BHI.S	L571
	MOVE	D6,D0
	SUB	#12,D0
	ADD	D0,D7
	BRA.S	L572
L571:
	MOVE	D5,D0
	MOVE	D5,D1
	SUB	#12,D1
	LSR	#1,D1
	ADD	D1,D0
	MOVE	D0,-2(A6)
	MOVE	D0,-12(A6)
	MOVE	D6,D0
	CMP	-12(A6),D0
	BHI.S	L573
	MOVE	D6,D0
	SUB	D5,D0
	LSR	#1,D0
	ADD	D0,D7
	BRA.S	L574
L573:
	MOVE	D6,D0
	SUB	-2(A6),D0
	ASL	#1,D0
	SUB	D0,D7
L574:
L572:
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L575
	MOVE	D4,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	2(A2),D0
	AND	#255,D0
	ADD	D0,D7
	CLR	D6
	MOVE.B	1(A2),D5
	AND	#255,D5
	CMPI	#0,D5
	BEQ.S	L577
	CMPI	#2,D5
	BNE.S	L576
L577:
	MOVE	#4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D6
L576:
	CMPI	#0,D5
	BEQ.S	L578
	CMPI	#16,D5
	BCC.S	L578
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D6
L578:
	CMPI	#16,D5
	BCS.S	L579
	CMPI	#112,D5
	BCC.S	L579
	MOVE	#11,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D6
L579:
	MOVE	D6,D0
	ASL	#1,D0
	ADD	D0,D7
L575:
	MOVE	D7,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F306_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	50(A3),D0
	CMPI	#0,10(A6)
	BNE.S	L581
	MOVE	#1,D1
	BRA.S	L582
L581:
	MOVE	#2,D1
L582:
	AND	D1,D0
	BEQ.S	L580
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L580:
	MOVE	#100,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L570:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$569:	.EQU	#-12
F313_xxxx_:/* global */
	LINK	A6,L$583
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	10(A6),D5
	AND	#-32768,D5
	BEQ.S	L585
	ANDI	#32767,10(A6)
L585:
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE	#0,D0
	MOVE	D0,D7
	BRA	L586(PC)
L587:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#6,D0
	BNE.S	L590
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	ASL.L	#2,D0
	LEA	G239_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	2(A2),D0
	AND	#255,D0
	AND	#128,D0
	BEQ.S	L591
	MOVE	D7,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	D5,-(A7)
	MOVE.L	A2,-(A7)
	JSR	F143_mzzz_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	10(A6),D1
	LEA	G050_auc_G(A4),A0
	ADDA	D1,A0
	MOVE.B	(A0),D1
	AND	#255,D1
	MULU	D1,D0
	MOVE	D7,D1
	CMP	10(A6),D1
	BNE.S	L592
	MOVE	#4,D1
	BRA.S	L593
L592:
	MOVE	#5,D1
L593:
	LSR	D1,D0
	ADD	D0,D6
L591:
L590:
L588:
	ADDQ	#1,D7
L586:
	CMPI	#1,D7
	BLE	L587(PC)
L589:
	JSR	F027_AA59_(PC)
	MOVE.B	83(A3),D1
	AND	#255,D1
	ASR	#3,D1
	ADDQ	#1,D1
	AND.L	#65535,D0
	DIVU	D1,D0
	SWAP	D0
	MOVE	D0,D7
	MOVE	D5,D0
	BEQ.S	L594
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L594:
	MOVE	64(A3),D0
	ADD	274(A3),D0
	ADD	G407_s_Par+3204(A4),D0
	ADD	D6,D0
	ADD	D0,D7
	CMPI	#1,10(A6)
	BLS.S	L595
	MOVE	10(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#6,D0
	BNE.S	L595
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	D5,-(A7)
	MOVE.L	A2,D0
	MOVE.L	D0,A0
	MOVE	2(A0),D0
	AND	#127,D0
	ASL.L	#2,D0
	LEA	G239_as_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F143_mzzz_(PC)
	ADDQ.L	#6,A7
	ADD	D0,D7
L595:
	MOVE	50(A3),D0
	MOVE	#1,D1
	MOVE	10(A6),D3
	ASL	D3,D1
	AND	D1,D0
	BEQ.S	L596
	JSR	F029_AA19_(PC)
	MOVE.L	D0,D1
	MOVE	#8,D0
	ADD	D1,D0
	SUB	D0,D7
L596:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L597
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,D7
L597:
	MOVE	#100,-(A7)
	MOVE	D7,D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
L584:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$583:	.EQU	#0
F314_gzzz_:/* global */
	LINK	A6,L$598
	MOVE	#1,G321_B_Sto(A4)
	CLR	G300_B_Par(A4)
	MOVE	#10,G318_i_Wai(A4)
	JSR	F098_rzzz_(PC)
	LEA	G447_as_Gr(A4),A0
	MOVE.L	A0,G441_ps_Pr(A4)
	LEA	G448_as_Gr(A4),A0
	MOVE.L	A0,G442_ps_Se(A4)
	LEA	G458_as_Gr(A4),A0
	MOVE.L	A0,G443_ps_Pr(A4)
	LEA	G459_as_Gr(A4),A0
	MOVE.L	A0,G444_ps_Se(A4)
	JSR	F357_qzzz_(PC)
	JSR	F457_AA08_(PC)
L599:
	UNLK	A6
	RTS
L$598:	.EQU	#-2
F315_arzz_:/* global */
	LINK	A6,L$600
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	BEQ.S	L602
	MOVE	8(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-2(A6)
	OR	D3,-2(A6)
	MOVE	10(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-2(A6)
	OR	D3,-2(A6)
	MOVE	G272_i_Cur(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-2(A6)
	OR	D3,-2(A6)
	MOVE	-2(A6),D7
	MOVE	D6,D0
	SUBQ	#1,D6
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
L603:
	MOVE	-(A3),D0
	CMP	D7,D0
	BNE.S	L606
	MOVE	D6,D0
	ADDQ	#1,D0
	BRA.S	L601
L606:
L604:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L603
L605:
L602:
	MOVE	#0,D0
L601:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$600:	.EQU	#-2
F316_aizz_:/* global */
	LINK	A6,L$607
	MOVEM.L	D7-D6,-(A7)
	MOVE	8(A6),D7
	AND	#255,D6
	SUBQ.B	#1,G407_s_Par+3210(A4)
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	SUB	D7,D6
	BEQ.S	L609
	MOVE	D6,D0
	MULU	#2,D0
	MOVE	D0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3216(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVE	D6,-(A7)
	MOVE	D7,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE	D7,D0
	LEA	G407_s_Par+3263(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
L609:
	MOVE	D7,D0
	MOVE.B	G407_s_Par+3212(A4),D1
	AND	#255,D1
	CMP	D1,D0
	BCC.S	L610
	SUBQ.B	#1,G407_s_Par+3212(A4)
L610:
	MOVE	D7,D0
	MOVE.B	G407_s_Par+3213(A4),D1
	AND	#255,D1
	CMP	D1,D0
	BCC.S	L611
	SUBQ.B	#1,G407_s_Par+3213(A4)
L611:
L608:
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
L$607:	.EQU	#0
F317_adzz_:/* global */
	LINK	A6,L$612
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	12(A6),D7
	MOVE.B	G407_s_Par+3210(A4),D6
	AND	#255,D6
	BEQ	L614(PC)
	MOVE	D7,D5
	AND	#-32768,D5
	BEQ.S	L615
	AND	#32767,D7
L615:
	MOVE	8(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-2(A6)
	OR	D3,-2(A6)
	MOVE	10(A6),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-2(A6)
	OR	D3,-2(A6)
	MOVE	G272_i_Cur(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-2(A6)
	OR	D3,-2(A6)
	LEA	G407_s_Par+3214(A4),A0
	MOVE.L	A0,A3
	CLR	D4
	BRA.S	L616
L617:
	MOVE.L	A3,A0
	ADDQ.L	#2,A3
	LEA	(A0),A1
	LEA	-2(A6),A0
	MOVEQ	#0,D0
	JSR	_blockcmp(PC)
	MOVE	D4,D0
	BNE.S	L619
	MOVE	#1,D4
	MOVE	D5,D0
	BEQ.S	L620
	MOVE	D7,-(A7)
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	MOVE	D0,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	BRA.S	L621
L620:
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	ADD	D7,D0
	MOVE	D0,-(A7)
	MOVE	#80,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
L621:
L619:
	MOVE	D7,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D6,A0
	MOVE.B	D0,(A0)
L616:
	MOVE	D6,D0
	SUBQ	#1,D6
	TST	D0
	BNE.S	L617
L618:
L614:
L613:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$612:	.EQU	#-2
F318_xxxx_:/* global */
	LINK	A6,L$622
	MOVEM.L	D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D6
	MULS	#800,D6
	LEA	G407_s_Par+29(A4),A0
	ADDA	D6,A0
	MOVE.B	(A0),D6
	AND	#255,D6
	CLR	D4
	BRA.S	L624
L625:
	MOVE	D4,D0
	ASL.L	#1,D0
	LEA	G057_ai_Gr(A4),A0
	ADDA	D0,A0
	MOVE	(A0),-(A7)
	MOVE	D7,-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	CMPI	#-1,D0
	BEQ.S	L628
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D5,D0
	AND	#16383,D0
	MOVE	D6,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L628:
L626:
	ADDQ	#1,D4
L624:
	CMPI	#30,D4
	BCS.S	L625
L627:
L623:
	MOVEM.L	(A7)+,D4-D7
	UNLK	A6
	RTS
L$622:	.EQU	#0
F319_xxxx_:/* global */
	LINK	A6,L$629
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	CLR	52(A3)
	ORI	#4096,48(A3)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L631
	MOVE	G331_B_Pre(A4),D0
	BEQ.S	L632
	CLR	G331_B_Pre(A4)
	CLR	G597_B_Ign(A4)
	MOVE	G415_B_Lea(A4),D0
	BNE.S	L633
	MOVE	G414_T_Lea(A4),-(A7)
	JSR	F034_aaau_(PC)
	ADDQ.L	#2,A7
L633:
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
	BRA.S	L634
L632:
	MOVE	G333_B_Pre(A4),D0
	BEQ.S	L635
	CLR	G333_B_Pre(A4)
	CLR	G597_B_Ign(A4)
	MOVE	#1,G587_i_Hid(A4)
	JSR	F078_xzzz_(PC)
L635:
L634:
	MOVE	#4,-(A7)
	JSR	F355_hzzz_(PC)
	ADDQ.L	#2,A7
L631:
	MOVE	D7,-(A7)
	JSR	F318_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	#-32758,-(A7)
	JSR	F166_szzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,D4
	CMPI	#-1,D4
	BNE.S	L636
	BRA.S	L637
L636:
	MOVE	D4,-(A7)
	JSR	F156_afzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE	#5,D0
	AND	#127,D0
	MOVE	D0,D3
	ANDI	#-128,2(A2)
	OR	D3,2(A2)
	MOVE	#1,D0
	AND	#1,D0
	MOVE	D0,D3
	ASL	#7,D3
	ANDI	#-129,2(A2)
	OR	D3,2(A2)
	MOVE	D7,D0
	AND	#3,D0
	MOVE	D0,D3
	ASL	#6,D3
	ASL	#8,D3
	ANDI	#16383,2(A2)
	OR	D3,2(A2)
	MOVE.B	29(A3),D6
	AND	#255,D6
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	D4,D0
	AND	#16383,D0
	MOVE	D6,D1
	ASL	#6,D1
	ASL	#8,D1
	OR	D1,D0
	MOVE	D0,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
L637:
	CLR.B	33(A3)
	CLR.B	34(A3)
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR.B	41(A3)
	MOVE	D6,D0
	ADDQ	#4,D0
	SUB	G308_i_Par(A4),D0
	AND	#3,D0
	MOVE	D0,D6
	MOVE	D6,D0
	ADDQ	#1,D0
	CMP	G599_ui_Us(A4),D0
	BNE.S	L638
	MOVE	#1,G598_B_Mou(A4)
	CLR	G599_ui_Us(A4)
	MOVE	#1,G592_B_Bui(A4)
L638:
	MOVE.B	42(A3),D0
	BEQ.S	L639
	MOVE	D7,-(A7)
	JSR	F323_xxxx_(PC)
	ADDQ.L	#2,A7
L639:
	CLR	G578_B_Use(A4)
	MOVE	#160,-(A7)
	CLR	-(A7)
	MOVE	D6,D0
	ASL	#2,D0
	ASL.L	#1,D0
	LEA	G054_ai_Gr(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	JSR	F135_xzzz_(PC)
	ADDA	#12,A7
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#0,D0
	MOVE	D0,D5
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA.S	L640
L641:
	MOVE	52(A3),D0
	BEQ.S	L644
	BRA.S	L643
L644:
L642:
	MOVE	D5,D0
	ADDQ	#1,D5
	MOVE.L	A3,D0
	ADDA	#800,A3
L640:
	MOVE	D5,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L641
L643:
	MOVE	D5,D0
	CMP	G305_ui_Pa(A4),D0
	BNE.S	L645
	MOVE	#1,G303_B_Par(A4)
	BRA.S	L630
L645:
	MOVE	D7,D0
	MOVE	G411_i_Lea(A4),D1
	CMP	D1,D0
	BNE.S	L646
	MOVE	D5,-(A7)
	JSR	F368_fzzz_(PC)
	ADDQ.L	#2,A7
L646:
	MOVE	D7,D0
	MOVE	G514_i_Mag(A4),D1
	CMP	D1,D0
	BNE.S	L647
	MOVE	D5,-(A7)
	JSR	F394_ozzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L630
L647:
	MOVE	G514_i_Mag(A4),-(A7)
	JSR	F393_lzzz_(PC)
	ADDQ.L	#2,A7
L630:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$629:	.EQU	#0
F320_akzz_:/* global */
	LINK	A6,L$648
	MOVEM.L	A3-A2/D7-D4,-(A7)
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,A3
	CLR	D7
	BRA	L650(PC)
L651:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D4
	OR	D0,50(A3)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	MOVE	D0,D6
	BNE.S	L654
	BRA	L652(PC)
L654:
	MOVE	D7,D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	CLR	(A0)
	MOVE	52(A3),D0
	MOVE	D0,D5
	BNE.S	L655
	BRA	L652(PC)
L655:
	MOVE	D5,D0
	SUB	D6,D0
	MOVE	D0,D5
	CMPI	#0,D0
	BGT.S	L656
	MOVE	D7,-(A7)
	JSR	F319_xxxx_(PC)
	ADDQ.L	#2,A7
	BRA	L657(PC)
L656:
	MOVE	D5,52(A3)
	ORI	#256,48(A3)
	MOVE	D4,D0
	BEQ.S	L658
	ORI	#8192,48(A3)
L658:
	MOVE	D7,D5
	MULU	#69,D5
	CLR	-16(A6)
	JSR	F077_aA39_(PC)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L659
	MOVE	#28,-14(A6)
	MOVE	D5,D0
	ADDQ	#7,D0
	MOVE	D0,-20(A6)
	ADD	#31,D0
	MOVE	D0,-18(A6)
	MOVE	#10,-(A7)
	MOVE	#16,-(A7)
	PEA	-20(A6)
	MOVE	#16,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	CMPI	#10,D6
	BCC.S	L660
	ADD	#21,D5
	BRA.S	L661
L660:
	CMPI	#100,D6
	BCC.S	L662
	ADD	#18,D5
	BRA.S	L663
L662:
	ADD	#15,D5
L663:
L661:
	MOVE	#16,-2(A6)
	BRA.S	L664
L659:
	MOVE	#6,-14(A6)
	MOVE	D5,D0
	MOVE	D0,-20(A6)
	ADD	#47,D0
	MOVE	D0,-18(A6)
	MOVE	#10,-(A7)
	MOVE	#24,-(A7)
	PEA	-20(A6)
	MOVE	#15,-(A7)
	JSR	F489_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F021_a002_(PC)
	ADDA	#12,A7
	CMPI	#10,D6
	BCC.S	L665
	ADD	#19,D5
	BRA.S	L666
L665:
	CMPI	#100,D6
	BCC.S	L667
	ADD	#16,D5
	BRA.S	L668
L667:
	ADD	#13,D5
L668:
L666:
	MOVE	#5,-2(A6)
L664:
	MOVE	#3,-(A7)
	CLR	-(A7)
	MOVE	D6,-(A7)
	JSR	F288_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE.L	D0,-(A7)
	MOVE	#8,-(A7)
	MOVE	#15,-(A7)
	MOVE	-2(A6),-(A7)
	MOVE	D5,-(A7)
	JSR	F053_aajz_(PC)
	ADDA	#12,A7
	MOVE	46(A3),D0
	MOVE	D0,D5
	CMPI	#-1,D0
	BNE.S	L669
	MOVE.B	#12,-8(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#5,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-12(A6)
	MOVE	D7,D0
	MOVE.B	D0,-7(A6)
	PEA	-12(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,46(A3)
	BRA.S	L670
L669:
	MOVE	D5,D0
	MULS	#10,D0
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.L	G313_ul_Ga(A4),D0
	ADDQ.L	#5,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,(A2)
	MOVE	D5,-(A7)
	JSR	F235_bzzz_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	JSR	F236_pzzz_(PC)
	ADDQ.L	#2,A7
L670:
	MOVE	D7,-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	JSR	F078_xzzz_(PC)
L657:
L652:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L650:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L651(PC)
L653:
L649:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$648:	.EQU	#-20
F321_AA29_:/* global */
	LINK	A6,L$671
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	10(A6),D7
	CMPI	#-1,8(A6)
	BEQ.S	L674
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ.S	L675
	MOVE	G302_B_Gam(A4),D0
	BEQ.S	L673
L675:
L674:
	BRA	L672(PC)
L673:
	CMPI	#0,D7
	BGT.S	L676
	MOVE	#0,D0
	BRA	L672(PC)
L676:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	52(A3),D0
	BNE.S	L677
L44T321_004:
	MOVE	#0,D0
	BRA	L672(PC)
L677:
	CMPI	#0,14(A6)
	BEQ	L678(PC)
	MOVE	#0,D0
	MOVE	D0,D4
	MOVE	#0,D0
	MOVE	D0,D6
	MOVE	#0,D0
	MOVE	D0,D5
	BRA.S	L679
L680:
	MOVE	12(A6),D0
	MOVE	#1,D1
	ASL	D6,D1
	AND	D1,D0
	BEQ.S	L683
	ADDQ	#1,D4
	MOVE	D6,D0
	CMPI	#4,14(A6)
	BNE.S	L684
	MOVE	#-32768,D1
	BRA.S	L685
L684:
	MOVE	#0,D1
L685:
	OR	D1,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F313_xxxx_(PC)
	ADDQ.L	#4,A7
	ADD	D0,D5
L683:
L681:
	ADDQ	#1,D6
L679:
	CMPI	#5,D6
	BLE.S	L680
L682:
	MOVE	D4,D0
	BEQ.S	L686
	MOVE	D5,D0
	AND.L	#65535,D0
	DIVU	D4,D0
	MOVE	D0,D5
L686:
	MOVE	14(A6),D0
L687:
	CMP	#6,D0
	BEQ.S	L688
	BRA.S	L690
L688:
	MOVE	#115,D0
	MOVE.B	80(A3),D3
	AND	#255,D3
	SUB	D3,D0
	MOVE	D0,D6
	CMPI	#0,D0
	BGT.S	L692
	CLR	D7
	BRA.S	L693
L692:
	MOVE	D6,-(A7)
	MOVE	#6,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L693:
	BRA	L44T321_024(PC)
	BRA.S	L691
L690:
	CMP	#5,D0
	BEQ.S	L691
	BRA.S	L694
L691:
	MOVE	D7,-(A7)
	MOVE	#5,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	SUB	G407_s_Par+3208(A4),D7
	BRA.S	L44T321_024
	BRA.S	L695
L694:
	CMP	#1,D0
	BEQ.S	L695
	BRA.S	L696
L695:
	MOVE	D7,-(A7)
	MOVE	#6,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D7
	SUB	G407_s_Par+3206(A4),D7
	BRA.S	L689
	BRA.S	L697
L696:
	CMP	#2,D0
	BEQ.S	L697
	BRA.S	L698
L697:
	MOVE	D5,D0
	LSR	#1,D0
	MOVE	D0,D5
	BRA.S	L699
L698:
	CMP	#3,D0
	BEQ.S	L699
L700:
	CMP	#4,D0
	BEQ.S	L699
L701:
	CMP	#7,D0
L702:
L699:
L689:
	CMPI	#0,D7
	BGT.S	L703
	BRA	L44T321_004(PC)
L703:
	MOVE	#130,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#6,-(A7)
	MOVE	D7,-(A7)
	JSR	F030_aaaW_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
L44T321_024:
	CMPI	#0,D7
	BGT.S	L704
	BRA	L44T321_004(PC)
L704:
	JSR	F027_AA59_(PC)
	AND	#127,D0
	ADD	#10,D0
	MOVE	D0,-(A7)
	MOVE	#4,-(A7)
	MOVE.L	A3,-(A7)
	JSR	F307_fzzz_(PC)
	ADDQ.L	#8,A7
	MOVE	D0,D6
	MOVE	D0,-10(A6)
	MOVE	D7,D0
	CMP	-10(A6),D0
	BLE.S	L705
L706:
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#7,D1
	MOVE	D1,-20(A6)
	MOVE	#1,D1
	MOVE	-20(A6),D3
	ASL	D3,D1
	AND	12(A6),D1
	MOVE	8(A6),D0
	ASL.L	#1,D0
	LEA	G410_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	OR	D1,D0
	MOVE	D0,(A0)
L707:
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
	MOVE	D0,-30(A6)
	MOVE	D7,D0
	CMP	-30(A6),D0
	BLE.S	L709
	MOVE	D6,D0
	BNE.S	L706
L709:
L708:
L705:
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L710
	JSR	F314_gzzz_(PC)
L710:
L678:
	CMPI	#0,D7
	BGT.S	L711
	CLR	D7
L711:
	MOVE	8(A6),D0
	ASL.L	#1,D0
	LEA	G409_ai_Ch(A4),A0
	ADDA	D0,A0
	MOVE	(A0),D0
	ADD	D7,D0
	MOVE	D0,(A0)
	MOVE	D7,D0
L672:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$671:	.EQU	#-30
F322_lzzz_:/* global */
	LINK	A6,L$712
	CMPI	#-1,8(A6)
	BEQ.S	L715
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BNE.S	L714
L715:
	BRA	L713(PC)
L714:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,-14(A6)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	10(A6),D0
	LSR	#6,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	MOVE.L	-14(A6),A0
	ORI	#256,48(A0)
	MOVE	8(A6),D0
	ADDQ	#1,D0
	CMP	G423_i_Inv(A4),D0
	BNE.S	L716
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L716
	MOVE.L	-14(A6),A0
	ORI	#2048,48(A0)
L716:
	SUBQ	#1,10(A6)
	BEQ.S	L717
	MOVE.L	-14(A6),A0
	ADDQ.B	#1,42(A0)
	MOVE.B	#75,-6(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-5(A6)
	MOVE.L	G313_ul_Ga(A4),D0
	ADD.L	#36,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	MOVE	10(A6),-4(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
L717:
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L713:
	UNLK	A6
	RTS
L$712:	.EQU	#-14
F323_xxxx_:/* global */
	LINK	A6,L$718
	MOVEM.L	A3/D7,-(A7)
	CMPI	#-1,8(A6)
	BNE.S	L720
	BRA.S	L719
L720:
	MOVE	#0,D0
	MOVE	D0,D7
	MOVE.L	G370_ps_Ev(A4),D0
	MOVE.L	D0,A3
	BRA.S	L721
L722:
	MOVE.B	4(A3),D0
	AND	#255,D0
	CMP	#75,D0
	BNE.S	L725
	MOVE.B	5(A3),D0
	AND	#255,D0
	CMP	8(A6),D0
	BNE.S	L725
	MOVE	D7,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
L725:
L723:
	MOVE.L	A3,D0
	ADDA	#10,A3
	MOVE	D7,D0
	ADDQ	#1,D7
L721:
	MOVE	D7,D0
	CMP	G369_ui_Ev(A4),D0
	BCS.S	L722
L724:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par+42(A4),A0
	ADDA	D0,A0
	CLR.B	(A0)
L719:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$718:	.EQU	#0
F324_aezz_:/* global */
	LINK	A6,L$726
	MOVEM.L	A3/D7-D4,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	BNE.S	L728
	BRA.S	L727
L728:
	MOVE	D7,D0
	LSR	#3,D0
	ADDQ	#1,D0
	MOVE	D0,D5
	SUB	D0,D7
	MOVE	D5,D0
	ASL	#1,D0
	MOVE	D0,D5
	MOVE	#0,D0
	MOVE	D0,D4
	MOVE	#0,D0
	MOVE	D0,D6
	BRA.S	L729
L730:
	MOVE	12(A6),-(A7)
	MOVE	10(A6),-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND.L	#65535,D1
	DIVU	D5,D1
	SWAP	D1
	MOVE	D7,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	TST	D0
	BEQ.S	L733
	ADDQ	#1,D4
L733:
L731:
	ADDQ	#1,D6
L729:
	MOVE	D6,D0
	CMP	G305_ui_Pa(A4),D0
	BCS.S	L730
L732:
	MOVE	D4,D0
L727:
	MOVEM.L	(A7)+,D4-D7/A3
	UNLK	A6
	RTS
L$726:	.EQU	#0
F325_bzzz_:/* global */
	LINK	A6,L$734
	MOVEM.L	A3/D7,-(A7)
	CMPI	#-1,8(A6)
	BNE.S	L736
	BRA.S	L735
L736:
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	56(A3),D0
	SUB	10(A6),D0
	MOVE	D0,56(A3)
	MOVE	D0,D7
	CMPI	#0,D0
	BGT.S	L737
	CLR	56(A3)
	CLR	-(A7)
	CLR	-(A7)
	MOVE	D7,D0
	NEG	D0
	ASR	#1,D0
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F321_AA29_(PC)
	ADDQ.L	#8,A7
	BRA.S	L738
L737:
	MOVE	D7,D0
	CMP	58(A3),D0
	BLE.S	L739
	MOVE	58(A3),56(A3)
L739:
L738:
	ORI	#768,48(A3)
L735:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$734:	.EQU	#0
F326_ozzz_:/* global */
	LINK	A6,L$740
	MOVEM.L	A3/D7,-(A7)
	MOVE.L	8(A6),A3
	MOVE.B	28(A3),D7
	AND	#255,D7
	MOVE	18(A6),-(A7)
	MOVE	16(A6),-(A7)
	MOVE	14(A6),-(A7)
	MOVE	D7,-(A7)
	MOVE.B	29(A3),D0
	AND	#255,D0
	SUB	D7,D0
	ADDQ	#1,D0
	AND	#2,D0
	LSR	#1,D0
	ADD	D7,D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	12(A6),-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
L741:
	MOVEM.L	(A7)+,D7/A3
	UNLK	A6
	RTS
L$740:	.EQU	#0
F327_kzzz_:/* global */
	LINK	A6,L$742
	MOVEM.L	A3/D7-D6,-(A7)
	MOVE	12(A6),D7
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	60(A3),D0
	CMP	14(A6),D0
	BCC.S	L744
	MOVE	#0,D0
	BRA.S	L743
L744:
	MOVE	14(A6),D0
	SUB	D0,60(A3)
	ORI	#256,48(A3)
	MOVE	62(A3),D0
	ASR	#3,D0
	MOVE	D0,-(A7)
	MOVE	#8,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	#10,D0
	SUB	D1,D0
	MOVE	D0,D6
	MOVE	D7,D0
	MOVE	D6,D1
	ASL	#2,D1
	CMP	D1,D0
	BGE.S	L745
	ADDQ	#3,D7
	SUBQ	#1,D6
L745:
	MOVE	D6,-(A7)
	MOVE	#90,-(A7)
	MOVE	D7,-(A7)
	MOVE	10(A6),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F326_ozzz_(PC)
	ADDA	#12,A7
L743:
	MOVEM.L	(A7)+,D6-D7/A3
	UNLK	A6
	RTS
L$742:	.EQU	#0
F328_nzzz_:/* global */
	LINK	A6,L$746
	MOVEM.L	A3-A2/D7-D4,-(A7)
	CLR	-4(A6)
	CMPI	#0,10(A6)
	BGE.S	L748
	MOVE	G415_B_Lea(A4),D0
	BEQ.S	L749
	MOVE	#0,D0
	BRA	L747(PC)
L749:
	JSR	F298_aqzz_(PC)
	MOVE	D0,D4
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE	214(A3),-2(A6)
	MOVE	D4,214(A3)
	MOVE	#1,10(A6)
	MOVE	#1,-4(A6)
L748:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F312_xzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D7
	MOVE	-4(A6),D0
	BEQ.S	L750
	MOVE	10(A6),D0
	ASL.L	#1,D0
	LEA	212(A3),A0
	ADDA	D0,A0
	MOVE	-2(A6),(A0)
	BRA.S	L751
L750:
	MOVE	10(A6),-(A7)
	MOVE	8(A6),-(A7)
	JSR	F300_aozz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D4
	CMPI	#-1,D0
	BNE.S	L752
	MOVE	#0,D0
	BRA	L747(PC)
L752:
L751:
	MOVE	#1,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	#16,-(A7)
	JSR	F064_aadz_(PC)
	ADDQ.L	#8,A7
	MOVE	D4,-(A7)
	JSR	F305_xxxx_(PC)
	ADDQ.L	#2,A7
	MOVE	D0,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#4,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F330_szzz_(PC)
	ADDQ.L	#4,A7
	MOVE	#8,D6
	MOVE	#1,D5
	MOVE	D4,D0
	AND	#15360,D0
	LSR	#2,D0
	LSR	#8,D0
	CMPI	#5,D0
	BNE.S	L753
	ADDQ	#4,D6
	MOVE	D4,-(A7)
	JSR	F158_ayzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,A2
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	#12,D0
	BGT.S	L754
	MOVE.B	3(A2),D0
	AND	#255,D0
	MOVE	D0,D5
	ASR	#2,D0
	ADD	D0,D6
L754:
L753:
	MOVE	D6,-(A7)
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F304_apzz_(PC)
	ADDQ.L	#6,A7
	ADD	D5,D7
	MOVE	#10,-(A7)
	MOVE	8(A6),-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	JSR	F027_AA59_(PC)
	AND	#15,D0
	MOVE	D7,D1
	ASR	#1,D1
	ADD	D1,D0
	ADD	D5,D0
	ADD	D0,D7
	MOVE	#200,-(A7)
	JSR	F027_AA59_(PC)
	MOVE.L	D0,D1
	AND	#31,D1
	MOVE	D5,D0
	ASL	#3,D0
	ADD	D1,D0
	MOVE	D0,-(A7)
	MOVE	#40,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D6
	MOVE	#11,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#5,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,D5
	MOVE	D5,-(A7)
	MOVE	D6,-(A7)
	MOVE	D7,-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),D0
	ADD	12(A6),D0
	AND	#3,D0
	MOVE	D0,-(A7)
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	D4,-(A7)
	JSR	F212_mzzz_(PC)
	ADDA	#16,A7
	MOVE	#4,G311_i_Pro(A4)
	MOVE	G308_i_Par(A4),G312_i_Las(A4)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
	MOVE	#1,D0
L747:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$746:	.EQU	#-4
F329_hzzz_:/* global */
	LINK	A6,L$755
	CMPI	#-1,G411_i_Lea(A4)
	BNE.S	L757
	MOVE	#0,D0
	BRA.S	L756
L757:
	MOVE	8(A6),-(A7)
	MOVE	#-1,-(A7)
	MOVE	G411_i_Lea(A4),-(A7)
	JSR	F328_nzzz_(PC)
	ADDQ.L	#6,A7
L756:
	UNLK	A6
	RTS
L$755:	.EQU	#0
F330_szzz_:/* global */
	LINK	A6,L$758
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	8(A6),D0
	MULS	#800,D0
	LEA	G407_s_Par(A4),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A3
	MOVE.L	G313_ul_Ga(A4),D7
	MOVE	10(A6),D3
	AND.L	#65535,D3
	ADD.L	D3,D7
	MOVE.B	#11,-6(A6)
	MOVE	8(A6),D0
	MOVE.B	D0,-5(A6)
	CLR.B	-4(A6)
	MOVE	44(A3),D0
	MOVE	D0,D5
	CMPI	#0,D0
	BLT.S	L760
	MOVE	D5,D6
	MULS	#10,D6
	MOVE.L	G370_ps_Ev(A4),A0
	ADDA	D6,A0
	MOVE.L	(A0),D6
	AND.L	#16777215,D6
	MOVE.L	D7,D0
	CMP.L	D6,D0
	BLT.S	L761
	MOVE.L	D6,D0
	SUB.L	G313_ul_Ga(A4),D0
	ASR.L	#1,D0
	ADD.L	D0,D7
	BRA.S	L762
L761:
	MOVE.L	D6,D7
	MOVE	10(A6),D1
	LSR	#1,D1
	AND.L	#65535,D1
	ADD.L	D1,D7
L762:
	MOVE	D5,-(A7)
	JSR	F237_rzzz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L763
L760:
	ORI	#-32760,48(A3)
	MOVE	8(A6),-(A7)
	JSR	F292_arzz_(PC)
	ADDQ.L	#2,A7
L763:
	MOVE.L	D7,D0
	MOVE	G309_i_Par(A4),D1
	EXT.L	D1
	MOVE.L	#24,D3
	ASL.L	D3,D1
	OR.L	D1,D0
	MOVE.L	D0,-10(A6)
	PEA	-10(A6)
	JSR	F238_pzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	D0,44(A3)
L759:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$758:	.EQU	#-10
F331_auzz_:/* global */
	LINK	A6,L$764
	MOVEM.L	A3-A2/D7-D4,-(A7)
	MOVE	G305_ui_Pa(A4),D0
	BNE.S	L766
	BRA	L765(PC)
L766:
	MOVE	G306_i_Par(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ANDI	#-32,-6(A6)
	OR	D3,-6(A6)
	MOVE	G307_i_Par(A4),D0
	AND	#31,D0
	MOVE	D0,D3
	ASL	#5,D3
	ANDI	#-993,-6(A6)
	OR	D3,-6(A6)
	MOVE	G309_i_Par(A4),D0
	AND	#63,D0
	MOVE	D0,D3
	ASL	#2,D3
	ASL	#8,D3
	ANDI	#1023,-6(A6)
	OR	D3,-6(A6)
	CLR	D6
	BRA.S	L767
L768:
	MOVE	D6,D0
	ASL.L	#1,D0
	LEA	G407_s_Par+3214(A4),A0
	ADDA	D0,A0
	LEA	(A0),A1
	LEA	-6(A6),A0
	MOVEQ	#0,D0
	JSR	_blockcmp(PC)
	MOVE	D6,D0
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D0,A0
	MOVE.B	(A0),D0
	AND	#255,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	CLR	-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE	D6,D1
	LEA	G407_s_Par+3262(A4),A0
	ADDA	D1,A0
	MOVE.B	D0,(A0)
	BNE.S	L770
	MOVE	D6,D0
	BNE.S	L770
	CLR	-(A7)
	JSR	F316_aizz_(PC)
	ADDQ.L	#2,A7
	BRA.S	L767
L770:
	ADDQ	#1,D6
L767:
	MOVE	D6,D0
	MOVE.B	G407_s_Par+3210(A4),D1
	AND	#255,D1
	SUBQ	#1,D1
	CMP	D1,D0
	BLT.S	L768
L769:
	MOVE.L	G313_ul_Ga(A4),D7
	MOVE	D7,D0
	AND	#128,D0
	MOVE	D7,D1
	AND	#256,D1
	LSR	#2,D1
	ADD	D1,D0
	MOVE	D7,D1
	AND	#64,D1
	ASL	#2,D1
	ADD	D1,D0
	LSR	#2,D0
	MOVE	D0,-2(A6)
	MOVE	#0,D0
	MOVE	D0,D7
	LEA	G407_s_Par(A4),A0
	MOVE.L	A0,D0
	MOVE.L	D0,A3
	BRA	L771(PC)
L772:
	MOVE	52(A3),D0
	BEQ	L775(PC)
	MOVE	D7,D0
	ADDQ	#1,D0
	CMP	G299_ui_Ca(A4),D0
	BEQ	L775(PC)
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BGE	L776(PC)
	MOVE	#3,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,-(A7)
	MOVE	#2,-(A7)
	MOVE	D7,-(A7)
	JSR	F303_AA09_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE.L	(A7)+,D0
	ADD	D1,D0
	MOVE	D0,D5
	MOVE	D0,-16(A6)
	MOVE.B	80(A3),D0
	AND	#255,D0
	ADD	-16(A6),D0
	MOVE	D0,-16(A6)
	MOVE	-2(A6),D0
	CMP	-16(A6),D0
	BCC.S	L776
	MOVE	62(A3),D6
	EXT.L	D6
	DIVS	#40,D6
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L777
	MOVE	D6,D0
	ASL	#1,D0
	MOVE	D0,D6
L777:
	ADDQ	#1,D6
	MOVE	#16,D0
	SUB	D5,D0
	MOVE	D0,-(A7)
	MOVE	#7,-(A7)
	JSR	F025_aatz_(PC)
	ADDQ.L	#4,A7
	MOVE.L	D0,D1
	MOVE	D6,D0
	MULU	D1,D0
	MOVE	D0,-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	62(A3),D0
	SUB	60(A3),D0
	MOVE	D0,-(A7)
	MOVE	D6,-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,60(A3)
	BRA.S	L778
L776:
	MOVE	60(A3),D0
	CMP	62(A3),D0
	BLE.S	L779
	SUBQ	#1,60(A3)
L779:
L778:
	MOVE	#19,D4
	BRA.S	L780
L781:
	MOVE	D4,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	CMPI	#0,(A0)
	BLE.S	L784
	MOVE	D4,D0
	MULS	#6,D0
	LEA	92(A3),A0
	ADDA	D0,A0
	SUBQ	#1,(A0)
L784:
L782:
	SUBQ	#1,D4
L780:
	CMPI	#0,D4
	BGE.S	L781
L783:
	MOVE	#4,D6
	MOVE	58(A3),D4
	BRA.S	L785
L786:
	ADDQ	#2,D6
L785:
	MOVE	D4,D0
	ASR	#1,D0
	MOVE	D0,D4
	MOVE	D0,-26(A6)
	MOVE	56(A3),D0
	CMP	-26(A6),D0
	BLT.S	L786
L787:
	CLR	D4
	MOVE	#6,-(A7)
	MOVE	58(A3),D0
	ASR	#8,D0
	SUBQ	#1,D0
	MOVE	D0,-(A7)
	MOVE	#1,-(A7)
	JSR	F026_a003_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,-4(A6)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L788
	MOVE	-4(A6),D0
	ASL	#1,D0
	MOVE	D0,-4(A6)
L788:
	MOVE.L	G313_ul_Ga(A4),D0
	SUB.L	G362_l_Las(A4),D0
	MOVE	D0,D5
	CMPI	#80,D0
	BLS.S	L789
	ADDQ	#1,-4(A6)
	CMPI	#250,D5
	BLS.S	L790
	ADDQ	#1,-4(A6)
L790:
L789:
L791:
	CMPI	#4,D6
	SLS	D5
	AND	#1,D5
	CMPI	#-512,66(A3)
	BGE.S	L794
	MOVE	D5,D0
	BEQ.S	L795
	ADD	-4(A6),D4
	SUBQ	#2,66(A3)
L795:
	BRA.S	L796
L794:
	CMPI	#0,66(A3)
	BLT.S	L797
	SUB	-4(A6),D4
L797:
	MOVE	D5,D0
	BEQ.S	L798
	MOVE	#2,D0
	BRA.S	L799
L798:
	MOVE	D6,D0
	LSR	#1,D0
L799:
	SUB	D0,66(A3)
L796:
	CMPI	#-512,68(A3)
	BGE.S	L800
	MOVE	D5,D0
	BEQ.S	L801
	ADD	-4(A6),D4
	SUBQ	#1,68(A3)
L801:
	BRA.S	L802
L800:
	CMPI	#0,68(A3)
	BLT.S	L803
	SUB	-4(A6),D4
L803:
	MOVE	D5,D0
	BEQ.S	L804
	MOVE	#1,D0
	BRA.S	L805
L804:
	MOVE	D6,D0
	LSR	#2,D0
L805:
	SUB	D0,68(A3)
L802:
	SUBQ	#1,D6
L792:
	MOVE	D6,D0
	BEQ.S	L806
	MOVE	56(A3),D0
	SUB	D4,D0
	CMP	58(A3),D0
	BLT	L791(PC)
L806:
L793:
	MOVE	D4,-(A7)
	MOVE	D7,-(A7)
	JSR	F325_bzzz_(PC)
	ADDQ.L	#4,A7
	CMPI	#-1024,66(A3)
	BGE.S	L807
	MOVE	#-1024,66(A3)
L807:
	CMPI	#-1024,68(A3)
	BGE.S	L808
	MOVE	#-1024,68(A3)
L808:
	MOVE	52(A3),D0
	CMP	54(A3),D0
	BGE.S	L809
	MOVE	56(A3),D0
	MOVE	58(A3),D1
	ASR	#2,D1
	CMP	D1,D0
	BLT.S	L809
	MOVE	-2(A6),D0
	MOVE.B	83(A3),D1
	AND	#255,D1
	ADD	#12,D1
	CMP	D1,D0
	BCC.S	L809
	MOVE	54(A3),D0
	ASR	#7,D0
	ADDQ	#1,D0
	MOVE	D0,-4(A6)
	MOVE	G300_B_Par(A4),D0
	BEQ.S	L810
	MOVE	-4(A6),D0
	ASL	#1,D0
	MOVE	D0,-4(A6)
L810:
	MOVE	232(A3),-(A7)
	JSR	F033_aaaz_(PC)
	ADDQ.L	#2,A7
	CMPI	#121,D0
	BNE.S	L811
	MOVE	-4(A6),D0
	ASR	#1,D0
	ADDQ	#1,D0
	ADD	D0,-4(A6)
L811:
	MOVE	54(A3),D0
	SUB	52(A3),D0
	MOVE	D0,-(A7)
	MOVE	-4(A6),-(A7)
	JSR	F024_aatz_(PC)
	ADDQ.L	#4,A7
	ADD	D0,52(A3)
L809:
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	G300_B_Par(A4),D1
	BEQ.S	L813
	MOVE	#63,D1
	BRA.S	L814
L813:
	MOVE	#255,D1
L814:
	AND	D1,D0
	BNE.S	L812
	CLR	D6
	BRA.S	L815
L816:
	MOVE	D6,D0
	MULS	#3,D0
	LEA	70(A3),A0
	ADDA	D0,A0
	LEA	(A0),A0
	MOVE.L	A0,A2
	MOVE.B	(A2),D5
	AND	#255,D5
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	D5,D0
	BCC.S	L818
	ADDQ.B	#1,1(A2)
	BRA.S	L819
L818:
	MOVE.B	1(A2),D0
	AND	#255,D0
	CMP	D5,D0
	BLS.S	L820
	MOVE.B	1(A2),D0
	AND	#255,D0
	AND.L	#65535,D0
	DIVU	D5,D0
	SUB.B	D0,1(A2)
L820:
L819:
	ADDQ	#1,D6
L815:
	CMPI	#6,D6
	BLS.S	L816
L817:
L812:
	MOVE	G300_B_Par(A4),D0
	BNE.S	L821
	MOVE.B	28(A3),D0
	AND	#255,D0
	CMP	G308_i_Par(A4),D0
	BEQ.S	L821
	MOVE.L	G361_l_Las(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	SUB.L	#60,D1
	CMP.L	D1,D0
	BGE.S	L821
	MOVE	G308_i_Par(A4),D0
	MOVE.B	D0,28(A3)
	CLR.B	41(A3)
	ORI	#1024,48(A3)
L821:
	ORI	#256,48(A3)
	MOVE	D7,D0
	ADDQ	#1,D0
	MOVE	G423_i_Inv(A4),D1
	CMP	D1,D0
	BNE.S	L822
	MOVE	G333_B_Pre(A4),D0
	BNE.S	L824
	MOVE	G331_B_Pre(A4),D0
	BNE.S	L824
	CMPI	#0,G424_i_Pan(A4)
	BNE.S	L823
L824:
	ORI	#2048,48(A3)
L823:
L822:
L775:
L773:
	MOVE	D7,D0
	ADDQ	#1,D7
	MOVE.L	A3,D0
	ADDA	#800,A3
L771:
	MOVE	D7,D0
	CMP	G305_ui_Pa(A4),D0
	BCS	L772(PC)
L774:
	JSR	F293_ahzz_(PC)
L765:
	MOVEM.L	(A7)+,D4-D7/A2-A3
	UNLK	A6
	RTS
L$764:	.EQU	#-26
