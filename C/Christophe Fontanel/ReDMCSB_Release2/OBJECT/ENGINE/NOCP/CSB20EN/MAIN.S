BSS SEG "bss"
G285_i_Squ:/* global */
	.WORD	#2
G286_B_Fac:/* global */
	.WORD	#2
G287_B_Fac:/* global */
	.WORD	#2
G288_B_Fac:/* global */
	.WORD	#2
G289_i_Dun:/* global */
	.WORD	#2
G290_T_Dun:/* global */
	.WORD	#2
G291_aauc_:/* global */
	.WORD	#24
G292_aT_Pi:/* global */
	.WORD	#10
G294_auc_L:/* global */
	.WORD	#16
G296_puc_B:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#1,G297_B_Dra(A4)
BSS SEG "bss"
G297_B_Dra:/* global */
	.WORD	#2
G298_B_New:/* global */
	.WORD	#2
G299_ui_Ca:/* global */
	.WORD	#2
G300_B_Par:/* global */
	.WORD	#2
G301_B_Gam:/* global */
	.WORD	#2
G302_B_Gam:/* global */
	.WORD	#2
G303_B_Par:/* global */
	.WORD	#2
G304_i_Dun:/* global */
	.WORD	#2
G305_ui_Pa:/* global */
	.WORD	#2
G306_i_Par:/* global */
	.WORD	#2
G307_i_Par:/* global */
	.WORD	#2
G308_i_Par:/* global */
	.WORD	#2
G309_i_Par:/* global */
	.WORD	#2
G310_i_Dis:/* global */
	.WORD	#2
G311_i_Pro:/* global */
	.WORD	#2
G312_i_Las:/* global */
	.WORD	#2
G313_ul_Ga:/* global */
	.WORD	#4
G317_i_Wai:/* global */
	.WORD	#2
G318_i_Wai:/* global */
	.WORD	#2
G320_i_Unr:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#1,G321_B_Sto(A4)
BSS SEG "bss"
G321_B_Sto:/* global */
	.WORD	#2
G322_B_Pal:/* global */
	.WORD	#2
G323_B_Ena:/* global */
	.WORD	#2
G324_B_Dra:/* global */
	.WORD	#2
G325_B_Set:/* global */
	.WORD	#2
G326_B_Ref:/* global */
	.WORD	#2
CODE SEG "init!"
	MOVE	#-1,G327_i_New(A4)
BSS SEG "bss"
G327_i_New:/* global */
	.WORD	#2
G331_B_Pre:/* global */
	.WORD	#2
G332_B_Sto:/* global */
	.WORD	#2
G333_B_Pre:/* global */
	.WORD	#2
G334_B_Sto:/* global */
	.WORD	#2
G335_i_Sel:/* global */
	.WORD	#2
G336_i_Hig:/* global */
	.WORD	#2
G337_i_Hig:/* global */
	.WORD	#2
G338_i_Hig:/* global */
	.WORD	#2
G339_i_Hig:/* global */
	.WORD	#2
G340_B_Hig:/* global */
	.WORD	#2
G341_B_Hig:/* global */
	.WORD	#2
G342_B_Ref:/* global */
	.WORD	#2
G343_puc_G:/* global */
	.WORD	#4
G345_aui_B:/* global */
	.WORD	#64
G346_aui_P:/* global */
	.WORD	#32
G347_aui_P:/* global */
	.WORD	#32
CODE SEG "init!"
	MOVE	#3,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,G348_pl_Bi(A4)
BSS SEG "bss"
G348_pl_Bi:/* global */
	.WORD	#4
CODE SEG "init!"
	MOVE	#17,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,G349_ul_La(A4)
BSS SEG "bss"
G349_ul_La:/* global */
	.WORD	#4
G350_B_Swi:/* global */
	.WORD	#2
G351_i_Con:/* global */
	.WORD	#2
CODE SEG "main"
F002_xxxx_:/* global */
	LINK	A6,L$0
	MOVE	#10,G318_i_Wai(A4)
L2:
	CLR	G317_i_Wai(A4)
	CMPI	#-1,G327_i_New(A4)
	BEQ.S	L5
L0T002_002:
	MOVE	G327_i_New(A4),-(A7)
	JSR	F003_aaaS_(PC)
	ADDQ.L	#2,A7
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	CLR	-(A7)
	MOVE	#-1,-(A7)
	MOVE	#-1,-(A7)
	JSR	F267_dzzz_(PC)
	ADDA	#10,A7
	MOVE	#-1,G327_i_New(A4)
	JSR	F357_qzzz_(PC)
L5:
	JSR	F261_hzzz_(PC)
	CMPI	#-1,G327_i_New(A4)
	BEQ.S	L6
	BRA.S	L0T002_002
L6:
	MOVE	G423_i_Inv(A4),D0
	BNE.S	L7
	MOVE	G300_B_Par(A4),D0
	BNE.S	L7
	MOVE	G307_i_Par(A4),-(A7)
	MOVE	G306_i_Par(A4),-(A7)
	MOVE	G308_i_Par(A4),-(A7)
	JSR	F128_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	G325_B_Set(A4),D0
	BEQ.S	L8
	CLR	G325_B_Set(A4)
	JSR	F077_aA39_(PC)
	MOVE.L	G412_puc_B(A4),-(A7)
	JSR	F068_aagz_(PC)
	ADDQ.L	#4,A7
	JSR	F078_xzzz_(PC)
L8:
	MOVE	G326_B_Ref(A4),D0
	BEQ.S	L9
	CLR	G326_B_Ref(A4)
	MOVE	#1,G598_B_Mou(A4)
	JSR	F077_aA39_(PC)
	JSR	F078_xzzz_(PC)
L9:
L7:
	JSR	F363_pzzz_(PC)
	JSR	F065_aanz_(PC)
	JSR	F320_akzz_(PC)
	MOVE	G303_B_Par(A4),D0
	BEQ.S	L10
	BRA	L1(PC)
L10:
	ADDQ.L	#1,G313_ul_Ga(A4)
	MOVE.L	G313_ul_Ga(A4),D0
	AND	#511,D0
	BNE.S	L11
	JSR	F338_atzz_(PC)
L11:
	MOVE.B	G407_s_Par+3211(A4),D0
	BEQ.S	L12
	SUBQ.B	#1,G407_s_Par+3211(A4)
L12:
	JSR	F390_rzzz_(PC)
	MOVE.L	G313_ul_Ga(A4),D0
	MOVE	G300_B_Par(A4),D1
	BEQ.S	L14
	MOVE	#15,D1
	BRA.S	L15
L14:
	MOVE	#63,D1
L15:
	AND	D1,D0
	BNE.S	L13
	JSR	F331_auzz_(PC)
L13:
	MOVE	G310_i_Dis(A4),D0
	BEQ.S	L16
	SUBQ	#1,G310_i_Dis(A4)
L16:
	MOVE	G311_i_Pro(A4),D0
	BEQ.S	L17
	SUBQ	#1,G311_i_Pro(A4)
L17:
	JSR	F044_xxxx_(PC)
	MOVE.L	G374_l_Wat(A4),D0
	MOVE.L	G313_ul_Ga(A4),D1
	CMP.L	D1,D0
	BGE.S	L18
	MOVE	#60,-(A7)
	JSR	F019_aarz_(PC)
	ADDQ.L	#2,A7
L18:
	CLR	G321_B_Sto(A4)
L19:
	BRA.S	L22
L23:
	MOVE	#7,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	MOVE.L	D0,-(A7)
	JSR	F361_nzzz_(PC)
	ADDQ.L	#4,A7
L22:
	MOVE	#11,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#2,A7
	TST	D0
	BNE.S	L23
L24:
	MOVE	G332_B_Sto(A4),D0
	BEQ.S	L25
	CLR	G331_B_Pre(A4)
	CLR	G332_B_Sto(A4)
	JSR	F353_auzz_(PC)
	BRA.S	L26
L25:
	MOVE	G334_B_Sto(A4),D0
	BEQ.S	L27
	CLR	G333_B_Pre(A4)
	CLR	G334_B_Sto(A4)
	JSR	F350_aqzz_(PC)
L27:
L26:
	JSR	F380_xzzz_(PC)
	MOVE	G321_B_Sto(A4),D0
	BNE.S	L28
	JSR	F363_pzzz_(PC)
L28:
L20:
	MOVE	G321_B_Sto(A4),D0
	BEQ.S	L19
	MOVE	G301_B_Gam(A4),D0
	BEQ.S	L19
L21:
L3:
	BRA	L2(PC)
L4:
L1:
	UNLK	A6
	RTS
L$0:	.EQU	#0
F003_aaaS_:/* global */
	LINK	A6,L$29
	JSR	F194_hzzz_(PC)
	MOVE	8(A6),-(A7)
	JSR	F174_aozz_(PC)
	ADDQ.L	#2,A7
	JSR	F096_qzzz_(PC)
	JSR	F195_akzz_(PC)
	JSR	F337_akzz_(PC)
L30:
	UNLK	A6
	RTS
L$29:	.EQU	#-10
main:/* global */
	LINK	A6,L$31
	LEA	V011_1_xxx(PC),A0
	MOVE.L	A4,(A0)
	LEA	V012_1_xxx(PC),A0
	MOVE.L	A5,(A0)
	JSR	F463_wzzz_(PC)
L34:
	JSR	F002_xxxx_(PC)
	MOVE	G303_B_Par(A4),-(A7)
	JSR	F444_AA29_(PC)
	ADDQ.L	#2,A7
L35:
	BRA.S	L34
L36:
L32:
	UNLK	A6
	RTS
L$31:	.EQU	#0
_initargcv:/* global */
	RTS
F006_aamz_:/* global */
	LINK	A6,L$37
	MOVEM.L	D7-D4,-(A7)
	MOVE.L	G348_pl_Bi(A4),A0
	MOVE	12(A6),D5
	MOVE	14(A6),D0
	SUB	D5,D0
	MULU	#160,D5
	ADDA	D5,A0
	MOVE	8(A6),D5
	MOVE	D5,D6
	LSR	#1,D5
	ANDI	#248,D5
	MOVE	D5,D7
	ADDA	D5,A0
	ADDQ.L	#4,A0
	ANDI	#15,D6
	MOVE	#-1,D3
	MOVE	D3,D4
	LSR	D6,D3
	MOVE	10(A6),D5
	MOVE	D5,D6
	LSR	#1,D6
	ANDI	#248,D6
	ANDI	#15,D5
	NEG	D5
	ADDI	#15,D5
	LSL	D5,D4
	CMP	D6,D7
	BEQ.S	L3T006_004
	MOVE	D6,D1
	SUB	D7,D1
	SUBQ	#8,D1
	LSR	#3,D1
L3T006_001:
	LEA	160(A0),A1
	MOVE	(A0),D5
	MOVE	D5,D6
	NOT	D5
	AND	D3,D5
	MOVE	D3,D7
	NOT	D7
	AND	D7,D6
	OR	D5,D6
	MOVE	D6,(A0)
	ADDQ.L	#8,A0
	MOVE	D1,D2
	BRA.S	L3T006_003
L3T006_002:
	NOT	(A0)
	ADDQ.L	#8,A0
L3T006_003:
	DBF	D2,L3T006_002
	MOVE	(A0),D5
	MOVE	D5,D6
	NOT	D5
	AND	D4,D5
	MOVE	D4,D7
	NOT	D7
	AND	D7,D6
	OR	D5,D6
	MOVE	D6,(A0)
	MOVE.L	A1,A0
	DBF	D0,L3T006_001
	BRA.S	L3T006_006_
L3T006_004:
	AND	D4,D3
L3T006_005:
	MOVE	(A0),D5
	MOVE	D5,D6
	NOT	D5
	AND	D3,D5
	MOVE	D3,D7
	NOT	D7
	AND	D7,D6
	OR	D5,D6
	MOVE	D6,(A0)
	LEA	160(A0),A0
	DBF	D0,L3T006_005
L3T006_006_:
	MOVEM.L	(A7)+,D4-D7
L38:
	UNLK	A6
	RTS
L$37:	.EQU	#0
F007_aAA7_:/* global */
	LINK	A6,L$39
	MOVEM.L	A6-A2/D7-D4,-(A7)
	MOVE	16(A6),D7
	MOVE.L	8(A6),A3
	MOVE.L	12(A6),A2
	MOVE.L	A3,D0
	MOVE.L	A2,D1
	ANDI	#1,D0
	BEQ.S	L4T007_001
	ANDI	#1,D1
	BNE.S	L4T007_004
	BRA.S	L4T007_003_
L4T007_001:
	ANDI	#1,D1
	BEQ.S	L4T007_005
	BRA.S	L4T007_003_
L4T007_002_:
	MOVE.B	(A3)+,(A2)+
	MOVE.B	(A3)+,(A2)+
	MOVE.B	(A3)+,(A2)+
	MOVE.B	(A3)+,(A2)+
	MOVE.B	(A3)+,(A2)+
	MOVE.B	(A3)+,(A2)+
	MOVE.B	(A3)+,(A2)+
	MOVE.B	(A3)+,(A2)+
L4T007_003_:
	SUBQ	#8,D7
	BPL.S	L4T007_002_
	ADDQ	#8,D7
	BRA.S	L4T007_013
L4T007_004:
	SUBQ	#1,D7
	BMI.S	L4T007_014_
	MOVE.B	(A3)+,(A2)+
L4T007_005:
	CMPA.L	A2,A3
	BPL.S	L4T007_011_
	ADDA	D7,A3
	ADDA	D7,A2
	MOVEQ	#1,D6
	AND	D7,D6
	BEQ.S	L4T007_007_
	SUBQ	#1,D7
	BMI.S	L4T007_014_
	MOVE.B	-(A3),-(A2)
	BRA.S	L4T007_007_
L4T007_006_:
	LEA	-48(A3),A3
	MOVEM.L	(A3),D0-D6/A0-A1/A4-A6
	MOVEM.L	A6-A4/A1-A0/D6-D0,-(A2)
L4T007_007_:
	SUBI	#48,D7
	BPL.S	L4T007_006_
	ADDI	#48,D7
	BRA.S	L4T007_009
L4T007_008:
	MOVE.B	-(A3),-(A2)
L4T007_009:
	DBF	D7,L4T007_008
	BRA.S	L4T007_014_
L4T007_010_:
	MOVEM.L	(A3)+,D0-D6/A0-A1/A4-A6
	MOVEM.L	D0-D6/A0-A1/A4-A6,(A2)
	LEA	48(A2),A2
L4T007_011_:
	SUBI	#48,D7
	BPL.S	L4T007_010_
	ADDI	#48,D7
	BRA.S	L4T007_013
L4T007_012:
	MOVE.B	(A3)+,(A2)+
L4T007_013:
	DBF	D7,L4T007_012
L4T007_014_:
	MOVEM.L	(A7)+,D4-D7/A2-A6
L40:
	UNLK	A6
	RTS
L$39:	.EQU	#0
F008_aA19_:/* global */
	LINK	A6,L$41
	MOVEM.L	A6-A2/D7-D4,-(A7)
	MOVE	12(A6),D0
	MOVE.L	8(A6),A0
	ADDA	D0,A0
	SUBI	#52,D0
	BMI.S	L5T008_002
	MOVEM.L	G345_aui_B(A4),D1-D7/A1-A6
L5T008_001:
	MOVEM.L	A6-A1/D7-D1,-(A0)
	SUBI	#52,D0
	BPL.S	L5T008_001
L5T008_002:
	ADDI	#52,D0
	BRA.S	L5T008_004
L5T008_003:
	CLR.B	-(A0)
L5T008_004:
	DBF	D0,L5T008_003
	MOVEM.L	(A7)+,D4-D7/A2-A6
L42:
	UNLK	A6
	RTS
L$41:	.EQU	#0
F009_aA49_:/* global */
	LINK	A6,L$43
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE.B	15(A6),D6
	MOVE	16(A6),D5
	CMPI	#1,D5
	BEQ.S	L45
L46:
	MOVE.B	D6,(A3)
	ADDA	D5,A3
L47:
	SUBQ	#1,D7
	BNE.S	L46
L48:
	BRA.S	L49
L45:
L50:
	MOVE.B	D6,(A3)+
L51:
	SUBQ	#1,D7
	BNE.S	L50
L52:
L49:
L44:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$43:	.EQU	#0
F010_aAA7_:/* global */
	LINK	A6,L$53
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE.L	8(A6),A3
	MOVE	12(A6),D7
	MOVE	14(A6),D6
	MOVE	16(A6),D5
	CMPI	#2,D5
	BEQ.S	L55
L56:
	MOVE	D6,(A3)
	ADDA	D5,A3
L57:
	SUBQ	#1,D7
	BNE.S	L56
L58:
	BRA.S	L59
L55:
L60:
	MOVE	D6,(A3)+
L61:
	SUBQ	#1,D7
	BNE.S	L60
L62:
L59:
L54:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$53:	.EQU	#0
V011_1_xxx:/* global */
	ORI.B	#0,D0
V012_1_xxx:/* global */
	ORI.B	#0,D0
E013_xxxx_:/* global */
	RTE
E014_xxxx_:/* global */
	MOVE	D0,-(A7)
	MOVE	SR,D0
	ANDI	#-1793,D0
	ORI	#1280,D0
	MOVE	D0,SR
	MOVE	(A7)+,D0
	JMP	*** absolute address expected ***

V014_1_xxx:/* global */
	ORI.B	#0,D0
E015_xxxx_:/* global */
	MOVEM.L	A4/A0,-(A7)
	MOVE.L	V011_1_xxx(PC),A4
	MOVE	#-1536,A0
	TST	G350_B_Swi(A4)
	BNE.S	L7T015_001
	CLR.B	27(A0)
	MOVE.B	#139,33(A0)
	MOVE.B	#8,27(A0)
	MOVEM.L	D7-D0,-(A7)
	MOVEM.L	G346_aui_P(A4),D0-D7
	MOVEM.L	D0-D7,-./'..L
	ADDQ	#1,G350_B_Swi(A4)
	BRA.S	L7T015_002
L7T015_001:
	MOVEM.L	D7-D0,-(A7)
	MOVEM.L	G347_aui_P(A4),D0-D7
	MOVEM.L	D0-D7,-./'..L
	ANDI.B	#254,19(A0)
	ANDI.B	#254,7(A0)
L7T015_002:
	BCLR	#0,15(A0)
	MOVEM.L	(A7)+,D0-A0/A4
	RTE
S016_xxxx_:/* global */
	TST	G595_B_Mou(A4)
	BNE.S	L7T016_002
	RTS
L7T016_002:
	TST	D0
	BNE.S	L7T016_008_
	TST	G354_i_Mes(A4)
	BLT.S	L7T016_003
	CMPI	#151,D5
	BCC.S	L7T016_008_
L7T016_003:
	TST	G324_B_Dra(A4)
	BEQ.S	L7T016_006
	CMPI	#169,D5
	BGE.S	L7T016_006
	CMPI	#224,D4
	BGE.S	L7T016_005
	TST	G600_B_Use(A4)
	BEQ.S	L7T016_004
	TST	G602_B_Cur(A4)
	BEQ.S	L7T016_004
	CMPI	#23,D5
	BLE.S	L7T016_006
	BRA.S	L7T016_008_
L7T016_004:
	CMPI	#16,D5
	BLT.S	L7T016_006
	BRA.S	L7T016_008_
L7T016_005:
	TST	G600_B_Use(A4)
	BEQ.S	L7T016_006
	CMPI	#28,D5
	BGT.S	L7T016_006
	CMPI	#23,D5
	BLE.S	L7T016_006
	CMPI	#232,D4
	BLT.S	L7T016_008_
L7T016_006:
	TST	G340_B_Hig(A4)
	BEQ.S	L7T016_007
	CMPI	#192,D4
	BGE.S	L7T016_008_
L7T016_007:
	RTS
L7T016_008_:
	MOVEQ	#1,D0
	JSR	S072_xxxx_(PC)
	RTS
E017_xxxx_:/* global */
	MOVEM.L	A5-A4/A0/D5-D0,-(A7)
	MOVE.L	V011_1_xxx(PC),A4
	MOVE.L	V012_1_xxx(PC),A5
	TST	G324_B_Dra(A4)
	BEQ.S	L7T017_001
	MOVE	G323_B_Ena(A4),G322_B_Pal(A4)
L7T017_001:
	TST	G322_B_Pal(A4)
	BEQ.S	L7T017_002
	CLR	G350_B_Swi(A4)
	MOVE	#-1536,A0
	CLR.B	27(A0)
	MOVE.B	#31,33(A0)
	MOVE.B	#8,27(A0)
	ORI.B	#1,19(A0)
	ORI.B	#1,7(A0)
L7T017_002:
	TST	G351_i_Con(A4)
	BEQ.S	L7T017_003
	ADDQ	#1,G351_i_Con(A4)
	MOVEM.L	(A7)+,D0-D5/A0/A4-A5
	RTE
L7T017_003:
	ADDQ	#1,G351_i_Con(A4)
L7T017_004_:
	MOVE	SR,D0
	ANDI	#-1793,D0
	ORI	#768,D0
	MOVE	D0,SR
	TST	G596_B_NoD(A4)
	BNE	L7T017_019(PC)
	MOVEQ	#0,D0
	MOVE.L	G590_i_Mou(A4),D3
	MOVE.L	D3,G591_l_Mou(A4)
	MOVE.L	D3,D2
	SWAP	D2
	MOVE	G603_i_Mou(A4),D4
	MOVE	G604_i_Mou(A4),D5
	TST	G599_ui_Us(A4)
	BEQ.S	L7T017_006
	CMPI	#274,D3
	BLT.S	L7T017_005
	CMPI	#28,D2
	BLE.S	L7T017_006
L7T017_005:
	MOVEM.L	A1-A0/D3-D0,-(A7)
	JSR	F071_xxxx_(PC)
	MOVEM.L	(A7)+,D0-D3/A0-A1
L7T017_006:
	MOVE	G593_B_Bui(A4),D0
	CLR	G593_B_Bui(A4)
	TST	G592_B_Bui(A4)
	BEQ.S	L7T017_007
	TST	G598_B_Mou(A4)
	BNE.S	L7T017_007
	CMP	D3,D4
	BNE.S	L7T017_007
	CMP	D2,D5
	BNE.S	L7T017_007
	MOVEQ	#1,D0
	CLR	G592_B_Bui(A4)
L7T017_007:
	JSR	S016_xxxx_(PC)
	TST	D0
	BEQ.S	L7T017_009
	CMPI	#15,D2
	BHI.S	L7T017_009
	JSR	S074_xxxx_(PC)
	MOVEQ	#0,D0
L7T017_009:
	TST	G354_i_Mes(A4)
	BLT.S	L7T017_010
	MOVEM.L	A1-A0/D3-D0,-(A7)
	MOVE	#27,D1
	SUB	G354_i_Mes(A4),D1
	MULU	#160,D1
	MOVE	D1,-(A7)
	MOVE.L	G348_pl_Bi(A4),D1
	ADDI.L	#27520,D1
	MOVE.L	D1,-(A7)
	ADDI.L	#160,D1
	MOVE.L	D1,-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVEM.L	(A7)+,D0-D3/A0-A1
	BRA.S	L7T017_011
L7T017_010:
	TST	G355_B_Scr(A4)
	BEQ.S	L7T017_013
	CLR	G355_B_Scr(A4)
L7T017_011:
	MOVEQ	#7,D1
	TST	G354_i_Mes(A4)
	BLT.S	L7T017_012
	ADDQ	#1,G354_i_Mes(A4)
	MOVE	G354_i_Mes(A4),D1
	CMPI	#7,D1
	BNE.S	L7T017_012
	MOVE	#-1,G354_i_Mes(A4)
L7T017_012:
	MOVEM.L	A1-A0/D3-D0,-(A7)
	MOVE	D1,D2
	MULU	#160,D1
	MOVE	D1,-(A7)
	NEG	D2
	ADDI	#200,D2
	MULU	#160,D2
	ADD.L	G348_pl_Bi(A4),D2
	MOVE.L	D2,-(A7)
	MOVE.L	G356_puc_B(A4),-(A7)
	JSR	F007_aAA7_(PC)
	ADDA	#10,A7
	MOVEM.L	(A7)+,D0-D3/A0-A1
L7T017_013:
	TST	G324_B_Dra(A4)
	BEQ.S	L7T017_016
	CLR	G324_B_Dra(A4)
	MOVEM.L	A4-D0,-(A7)
	TST	G342_B_Ref(A4)
	BEQ.S	L7T017_014
	CLR	G342_B_Ref(A4)
	LEA	G021_aaui_(A4),A0
	MOVE	G304_i_Dun(A4),D0
	LSL	#5,D0
	ADDA	D0,A0
	MOVEM.L	(A0),D0-D7
	MOVEM.L	D0-D7,G346_aui_P(A4)
L7T017_014:
	MOVE.L	G296_puc_B(A4),A0
	MOVE.L	G348_pl_Bi(A4),A1
	ADDA	#5280,A1
	MOVE	#135,D0
L7T017_015:
	MOVEM.L	(A0)+,D1-D7/A2-A4
	MOVEM.L	D1-D7/A2-A4,(A1)
	MOVEM.L	(A0)+,D1-D7/A2-A4
	MOVEM.L	D1-D7/A2-A4,40(A1)
	MOVEM.L	(A0)+,D1-D7/A2
	MOVEM.L	D1-D7/A2,80(A1)
	LEA	160(A1),A1
	DBF	D0,L7T017_015
	MOVEM.L	(A7)+,D0-A4
L7T017_016:
	TST	G340_B_Hig(A4)
	BEQ.S	L7T017_017
	CLR	G340_B_Hig(A4)
	NOT	G341_B_Hig(A4)
	MOVEM.L	A1-A0/D3-D0,-(A7)
	MOVE	G339_i_Hig(A4),-(A7)
	MOVE	G338_i_Hig(A4),-(A7)
	MOVE	G337_i_Hig(A4),-(A7)
	MOVE	G336_i_Hig(A4),-(A7)
	JSR	F006_aamz_(PC)
	ADDQ.L	#8,A7
	MOVEM.L	(A7)+,D0-D3/A0-A1
L7T017_017:
	TST	D0
	BEQ.S	L7T017_018
	JSR	S074_xxxx_(PC)
L7T017_018:
	TST	G592_B_Bui(A4)
	BEQ.S	L7T017_019
	CLR	G592_B_Bui(A4)
	MOVE	#1,G593_B_Bui(A4)
	CLR	G598_B_Mou(A4)
	MOVEM.L	A1-A0/D3-D0,-(A7)
	JSR	F073_xxxx_(PC)
	MOVEM.L	(A7)+,D0-D3/A0-A1
L7T017_019:
	ADDQ	#1,G317_i_Wai(A4)
	MOVE	G317_i_Wai(A4),D0
	CMP	G318_i_Wai(A4),D0
	BLS.S	L7T017_022
	MOVE	#1,G321_B_Sto(A4)
L7T017_022:
	TRAP	#4
	MOVE	SR,D0
	ANDI	#-1793,D0
	ORI	#1024,D0
	MOVE	D0,SR
	SUBQ	#1,G351_i_Con(A4)
	BNE	L7T017_004_(PC)
	MOVEM.L	(A7)+,D0-D5/A0/A4-A5
	RTE
F018_aaat_:/* global */
	LINK	A6,L$63
	LEA	E013_xxxx_(PC),A0
	MOVE.L	A0,276.W
	LEA	V014_1_xxx(PC),A0
	MOVE.L	280.W,(A0)
	LEA	E014_xxxx_(PC),A0
	MOVE.L	A0,280.W
	LEA	E015_xxxx_(PC),A0
	MOVE.L	A0,288.W
	MOVE.L	112.W,144.W
	LEA	E017_xxxx_(PC),A0
	MOVE.L	A0,112.W
L64:
	UNLK	A6
	RTS
L$63:	.EQU	#0
F019_aarz_:/* global */
	LINK	A6,L$65
DATA SEG "s!"
s!:
	DATA 1B 48 53 59 53 54 45 4D 20 45 52 52 4F 52 20 00 
CODE SEG "main"
	PEA	s!(A4)
	MOVE	#9,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#6,A7
	MOVE	8(A6),D0
	EXT.L	D0
	DIVS	#10,D0
	ADD	#48,D0
	MOVE	D0,-(A7)
	MOVE	#2,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
	MOVE	8(A6),D0
	EXT.L	D0
	DIVS	#10,D0
	SWAP	D0
	ADD	#48,D0
	MOVE	D0,-(A7)
	MOVE	#2,-(A7)
	JSR	R057_rzzz_(PC)
	ADDQ.L	#4,A7
L68:
L69:
	BRA.S	L68
L70:
L66:
	UNLK	A6
	RTS
L$65:	.EQU	#0
F020_aAA5_:/* global */
	LINK	A6,L$71
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	18(A6),-(A7)
	MOVE	#112,-(A7)
	MOVE	16(A6),-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	12(A6),-(A7)
	MOVE.L	G296_puc_B(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L72:
	UNLK	A6
	RTS
L$71:	.EQU	#0
F021_a002_:/* global */
	LINK	A6,L$73
	MOVE	#0,D0
	MOVE	D0,G578_B_Use(A4)
	MOVE	18(A6),-(A7)
	MOVE	#160,-(A7)
	MOVE	16(A6),-(A7)
	CLR	-(A7)
	CLR	-(A7)
	MOVE.L	12(A6),-(A7)
	MOVE.L	G348_pl_Bi(A4),-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F132_xzzz_(PC)
	ADDA	#22,A7
L74:
	UNLK	A6
	RTS
L$73:	.EQU	#0
F022_aaaU_:/* global */
	LINK	A6,L$75
	BRA.S	L77
L78:
	MOVE	#37,-(A7)
	JSR	R056_aaal_(PC)
	ADDQ.L	#2,A7
L77:
	MOVE	8(A6),D0
	SUBQ	#1,8(A6)
	TST	D0
	BNE.S	L78
L79:
L76:
	UNLK	A6
	RTS
L$75:	.EQU	#0
F023_aarz_:/* global */
	LINK	A6,L$80
	MOVE	8(A6),D0
	BPL.S	L13T023_002
	NEG	D0
L13T023_002:
L81:
	UNLK	A6
	RTS
L$80:	.EQU	#0
F024_aatz_:/* global */
	LINK	A6,L$82
	MOVE	8(A6),D0
	CMP	10(A6),D0
	BLT.S	L14T024_002
	MOVE	10(A6),D0
L14T024_002:
L83:
	UNLK	A6
	RTS
L$82:	.EQU	#0
F025_aatz_:/* global */
	LINK	A6,L$84
	MOVE	8(A6),D0
	CMP	10(A6),D0
	BGT.S	L15T025_002
	MOVE	10(A6),D0
L15T025_002:
L85:
	UNLK	A6
	RTS
L$84:	.EQU	#0
F026_a003_:/* global */
	LINK	A6,L$86
	MOVE	10(A6),D0
	CMP	8(A6),D0
	BGT.S	L16T026_001
	MOVE	8(A6),D0
	BRA.S	L16T026_003
L16T026_001:
	CMP	12(A6),D0
	BLE.S	L16T026_003
	MOVE	12(A6),D0
L16T026_003:
L87:
	UNLK	A6
	RTS
L$86:	.EQU	#0
F027_AA59_:/* global */
	LINK	A6,L$88
	MOVE.L	G349_ul_La(A4),-(A7)
	MOVE.L	#-1153374675,-(A7)
	JSR	_lmul(PC)
	MOVEQ	#11,D0
	ADD.L	(A7)+,D0
	MOVE.L	D0,G349_ul_La(A4)
	LSR.L	#8,D0
L89:
	UNLK	A6
	RTS
L$88:	.EQU	#0
F028_a000_:/* global */
	LINK	A6,L$90
	MOVE.L	G349_ul_La(A4),-(A7)
	MOVE.L	#-1153374675,-(A7)
	JSR	_lmul(PC)
	MOVEQ	#11,D0
	ADD.L	(A7)+,D0
	MOVE.L	D0,G349_ul_La(A4)
	LSR.L	#8,D0
	AND	#1,D0
L91:
	UNLK	A6
	RTS
L$90:	.EQU	#0
F029_AA19_:/* global */
	LINK	A6,L$92
	MOVE.L	G349_ul_La(A4),-(A7)
	MOVE.L	#-1153374675,-(A7)
	JSR	_lmul(PC)
	MOVEQ	#11,D0
	ADD.L	(A7)+,D0
	MOVE.L	D0,G349_ul_La(A4)
	LSR.L	#8,D0
	AND	#3,D0
L93:
	UNLK	A6
	RTS
L$92:	.EQU	#0
F030_aaaW_:/* global */
	LINK	A6,L$94
	MOVE	8(A6),D0
	MULU	12(A6),D0
	MOVE	10(A6),D1
	ASR.L	D1,D0
L95:
	UNLK	A6
	RTS
L$94:	.EQU	#0
