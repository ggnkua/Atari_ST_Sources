CODE SEG "start"
F429_xxxx_:/* global */
	LINK	A6,L$0
	MOVEM.L	A3/D7-D5,-(A7)
	MOVE	#512,-(A7)
	MOVE.L	8(A6),D0
	MOVE.L	D0,A3
	MOVE.L	D0,-(A7)
	JSR	F415_xxxx_(PC)
	ADDQ.L	#6,A7
	TST	D0
	BNE.S	L2
	MOVE	#0,D0
	BRA.S	L1
L2:
	MOVE	#32,D7
	CLR	D6
L3:
	ADD	(A3)+,D6
	MOVE	(A3)+,D0
	EOR	D0,D6
	SUB	(A3)+,D6
	MOVE	(A3)+,D0
	EOR	D0,D6
L4:
	SUBQ	#1,D7
	BNE.S	L3
L5:
	MOVE	#128,-(A7)
	MOVE.L	8(A6),A0
	MOVE	58(A0),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F417_xxxx_(PC)
	ADDQ.L	#8,A7
	CLR	D5
	MOVE	#128,D7
L6:
	ADD	(A3)+,D5
L7:
	SUBQ	#1,D7
	BNE.S	L6
L8:
	MOVE	D6,D0
	CMP	D5,D0
	SEQ	D0
	AND	#1,D0
L1:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$0:	.EQU	#0
F430_xxxx_:/* global */
	LINK	A6,L$9
	MOVEM.L	A3/D7-D5,-(A7)
	CLR	D5
	MOVE	#128,D7
	MOVE.L	8(A6),D0
	ADD.L	#256,D0
	MOVE.L	D0,A3
L11:
	ADD	(A3)+,D5
L12:
	SUBQ	#1,D7
	BNE.S	L11
L13:
	MOVE	#32,D7
	CLR	D6
	MOVE.L	8(A6),A3
L14:
	JSR	F027_AA59_(PC)
	MOVE	D0,(A3)+
	ADD	D0,D6
	JSR	F027_AA59_(PC)
	MOVE	D0,(A3)+
	EOR	D0,D6
	JSR	F027_AA59_(PC)
	MOVE	D0,(A3)+
	SUB	D0,D6
	SUBQ	#1,D7
	BEQ.S	L17
	JSR	F027_AA59_(PC)
	MOVE	D0,(A3)+
	EOR	D0,D6
	BRA.S	L18
L17:
	MOVE	D6,D0
	EOR	D5,D0
	MOVE	D0,(A3)+
	BRA.S	L16
L18:
L15:
	BRA.S	L14
L16:
	MOVE	#128,-(A7)
	MOVE.L	8(A6),A0
	MOVE	58(A0),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F417_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	#512,-(A7)
	MOVE.L	8(A6),-(A7)
	JSR	F416_xxxx_(PC)
	ADDQ.L	#6,A7
	MOVE	D0,D7
	MOVE	#128,-(A7)
	MOVE.L	8(A6),A0
	MOVE	58(A0),-(A7)
	MOVE.L	A3,-(A7)
	JSR	F417_xxxx_(PC)
	ADDQ.L	#8,A7
	MOVE	D7,D0
L10:
	MOVEM.L	(A7)+,D5-D7/A3
	UNLK	A6
	RTS
L$9:	.EQU	#0
F431_xxxx_:/* global */
	LINK	A6,L$19
	MOVE	D7,-(A7)
	MOVE	8(A6),D7
	MOVE	D7,D0
	AND	#7,D0
	BEQ.S	L21
	SUBQ	#1,D7
L21:
	MOVE	D7,D0
	AND	#112,D0
	BEQ.S	L22
	SUB	#16,D7
L22:
	MOVE	D7,D0
	AND	#1792,D0
	BEQ.S	L23
	SUB	#256,D7
L23:
	MOVE	D7,D0
L20:
	MOVE	(A7)+,D7
	UNLK	A6
	RTS
L$19:	.EQU	#0
