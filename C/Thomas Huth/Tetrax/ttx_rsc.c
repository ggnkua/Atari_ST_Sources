/* *** TTX_RSC.C - The resource file for TeTra *** */

#include <aes.h>
#include "ttx_rsc.h"

#ifndef FL3DACT
#define FL3DIND  0x0200
#define FL3DBAK  0x0400
#define FL3DACT  0x0600
#endif


#define TVERTITEL " Tetrax V1.03 "


/* Icon datas: */

long icnmask[]={
 0x3FFFFFFCL,
 0x7FFFFFFEL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0xFFFFFFFFL,
 0x7FFFFFFEL,
 0x3FFFFFFCL
};

long loadpic[]={
 0x3FFFFFFCL,	/* 00111111111111111111111111111100 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80018001L,	/* 10000000000000011000000000000001 */
 0x8003C001L,	/* 10000000000000111100000000000001 */
 0x8007E001L,	/* 10000000000001111110000000000001 */
 0x800FF001L,	/* 10000000000011111111000000000001 */
 0x801FF801L,	/* 10000000000111111111100000000001 */
 0x803FFC01L,	/* 10000000001111111111110000000001 */
 0x807FFE01L,	/* 10000000011111111111111000000001 */
 0x80FFFF01L,	/* 10000000111111111111111100000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x83FFFFC1L,	/* 10000011111111111111111111000001 */
 0x87FFFFE1L,	/* 10000111111111111111111111100001 */
 0x8FFFFFF1L,	/* 10001111111111111111111111110001 */
 0x8FFFFFF1L,	/* 10001111111111111111111111110001 */
 0x8FFFFFF1L,	/* 10001111111111111111111111110001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x8FFFFFF1L,	/* 10001111111111111111111111110001 */
 0x8FFFFFF1L,	/* 10001111111111111111111111110001 */
 0x8FFFFFF1L,	/* 10001111111111111111111111110001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x3FFFFFFCL	/* 00111111111111111111111111111100 */
};

long playpic[]={
 0x3FFFFFFCL,	/* 00111111111111111111111111111100 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x86000001L,	/* 10000110000000000000000000000001 */
 0x87800001L,	/* 10000111100000000000000000000001 */
 0x87E00001L,	/* 10000111111000000000000000000001 */
 0x87F80001L,	/* 10000111111110000000000000000001 */
 0x87FE0001L,	/* 10000111111111100000000000000001 */
 0x87FF8001L,	/* 10000111111111111000000000000001 */
 0x87FFE001L,	/* 10000111111111111110000000000001 */
 0x87FFF801L,	/* 10000111111111111111100000000001 */
 0x87FFFE01L,	/* 10000111111111111111111000000001 */
 0x87FFFF81L,	/* 10000111111111111111111110000001 */
 0x87FFFFE1L,	/* 10000111111111111111111111100001 */
 0x87FFFFE1L,	/* 10000111111111111111111111100001 */
 0x87FFFF81L,	/* 10000111111111111111111110000001 */
 0x87FFFE01L,	/* 10000111111111111111111000000001 */
 0x87FFF801L,	/* 10000111111111111111100000000001 */
 0x87FFE001L,	/* 10000111111111111110000000000001 */
 0x87FF8001L,	/* 10000111111111111000000000000001 */
 0x87FE0001L,	/* 10000111111111100000000000000001 */
 0x87F80001L,	/* 10000111111110000000000000000001 */
 0x87E00001L,	/* 10000111111000000000000000000001 */
 0x87800001L,	/* 10000111100000000000000000000001 */
 0x86000001L,	/* 10000110000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x3FFFFFFCL	/* 00111111111111111111111111111100 */
};

long stoppic[]={
 0x3FFFFFFCL,	/* 00111111111111111111111111111100 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x81FFFF81L,	/* 10000001111111111111111110000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x3FFFFFFCL	/* 00111111111111111111111111111100 */
};


long fwardpic[]={
 0x3FFFFFFCL,	/* 00111111111111111111111111111100 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x84004001L,	/* 10000100000000000100000000000001 */
 0x86006001L,	/* 10000110000000000110000000000001 */
 0x87007001L,	/* 10000111000000000111000000000001 */
 0x87807801L,	/* 10000111100000000111100000000001 */
 0x87C07C01L,	/* 10000111110000000111110000000001 */
 0x87E07E01L,	/* 10000111111000000111111000000001 */
 0x87F07F01L,	/* 10000111111100000111111100000001 */
 0x87F87F81L,	/* 10000111111110000111111110000001 */
 0x87FC7FC1L,	/* 10000111111111000111111111000001 */
 0x87FE7FE1L,	/* 10000111111111100111111111100001 */
 0x87FF7FF1L,	/* 10000111111111110111111111110001 */
 0x87FF7FF1L,	/* 10000111111111110111111111110001 */
 0x87FE7FE1L,	/* 10000111111111100111111111100001 */
 0x87FC7FC1L,	/* 10000111111111000111111111000001 */
 0x87F87F81L,	/* 10000111111110000111111110000001 */
 0x87F07F01L,	/* 10000111111100000111111100000001 */
 0x87E07E01L,	/* 10000111111000000111111000000001 */
 0x87C07C01L,	/* 10000111110000000111110000000001 */
 0x87807801L,	/* 10000111100000000111100000000001 */
 0x87007001L,	/* 10000111000000000111000000000001 */
 0x86006001L,	/* 10000110000000000110000000000001 */
 0x84004001L,	/* 10000100000000000100000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x3FFFFFFCL	/* 00111111111111111111111111111100 */
};


long bwardpic[]={
 0x3FFFFFFCL,	/* 00111111111111111111111111111100 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80020021L,	/* 10000000000000100000000000100001 */
 0x80060061L,	/* 10000000000001100000000001100001 */
 0x800E00E1L,	/* 10000000000011100000000011100001 */
 0x801E01E1L,	/* 10000000000111100000000111100001 */
 0x803E03E1L,	/* 10000000001111100000001111100001 */
 0x807E07E1L,	/* 10000000011111100000011111100001 */
 0x80FE0FE1L,	/* 10000000111111100000111111100001 */
 0x81FE1FE1L,	/* 10000001111111100001111111100001 */
 0x83FE3FE1L,	/* 10000011111111100011111111100001 */
 0x87FE7FE1L,	/* 10000111111111100111111111100001 */
 0x8FFEFFE1L,	/* 10001111111111101111111111100001 */
 0x8FFEFFE1L,	/* 10001111111111101111111111100001 */
 0x87FE7FE1L,	/* 10000111111111100111111111100001 */
 0x83FE3FE1L,	/* 10000011111111100011111111100001 */
 0x81FE1FE1L,	/* 10000001111111100001111111100001 */
 0x80FE0FE1L,	/* 10000000111111100000111111100001 */
 0x807E07E1L,	/* 10000000011111100000011111100001 */
 0x803E03E1L,	/* 10000000001111100000001111100001 */
 0x801E01E1L,	/* 10000000000111100000000111100001 */
 0x800E00E1L,	/* 10000000000011100000000011100001 */
 0x80060061L,	/* 10000000000001100000000001100001 */
 0x80020021L,	/* 10000000000000100000000000100001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x80000001L,	/* 10000000000000000000000000000001 */
 0x40000002L,	/* 01000000000000000000000000000010 */
 0x3FFFFFFCL	/* 00111111111111111111111111111100 */
};


long setuppic[]={
 0x3FFFFFFCL,
 0x40180002L,
 0x80240001L,
 0x8324C001L,
 0x84C32001L,
 0x84002001L,
 0x82004001L,
 0x82004001L,
 0x8C183001L,
 0x903C0801L,
 0x903C0801L,
 0x8C183001L,
 0x82004001L,
 0x82005801L,
 0x84002401L,
 0x84C324C1L,
 0x8324C321L,
 0x80240021L,
 0x801A0041L,
 0x80020041L,
 0x800C2431L,
 0x80101809L,
 0x80101809L,
 0x800C2431L,
 0x80020041L,
 0x80020041L,
 0x80040021L,
 0x8004C321L,
 0x800324C1L,
 0x80002401L,
 0x40002402L,
 0x3FFFFFFCL
};


long aboutpic[]={
 0x3FFFFFFCL,
 0x40000002L,
 0x801FF801L,
 0x80600601L,
 0x80800101L,
 0x81000081L,
 0x82000041L,
 0x82000041L,
 0x84000021L,
 0x84000021L,
 0x84010021L,
 0x84111021L,
 0x82092041L,
 0x82054041L,
 0x81038081L,
 0x80810101L,
 0x80410201L,
 0x80410201L,
 0x80410201L,
 0x80210401L,
 0x80210401L,
 0x80210401L,
 0x803FFC01L,
 0x80400201L,
 0x803FFC01L,
 0x80400201L,
 0x803FFC01L,
 0x80400201L,
 0x803FFC01L,
 0x800FF001L,
 0x40000002L,
 0x3FFFFFFCL
};


long exitpic[]={
 0x3FFFFFFCL,
 0x40000002L,
 0x8FFFFFF1L,
 0x88000AB1L,
 0x88000D51L,
 0x88038AB1L,
 0x88050D51L,
 0x88110AB1L,
 0x89550D51L,
 0x8A240AB1L,
 0x8B500D51L,
 0x8A400AB1L,
 0x8B004D51L,
 0x8800CAB1L,
 0x88004D51L,
 0x88000AB1L,
 0x88000D51L,
 0x88000AB1L,
 0x88000D51L,
 0x88000AB1L,
 0x88000D51L,
 0x88000AB1L,
 0x88000D51L,
 0x88000AB1L,
 0x88001D51L,
 0x88006AB1L,
 0x8801D551L,
 0x8806AAB1L,
 0x881D5551L,
 0x886AAAB1L,
 0x49D55552L,
 0x3FFFFFFCL
};


const ICONBLK loadblk=
	{(void *)icnmask, (void *)loadpic, "", 0x1000/*+'O'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};
const ICONBLK playblk=
	{(void *)icnmask, (void *)playpic, "", 0x1000/*+'P'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};
const ICONBLK stopblk=
	{(void *)icnmask, (void *)stoppic, "", 0x1000/*+'S'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};
const ICONBLK fwardblk=
	{(void *)icnmask, (void *)fwardpic, "", 0x1000/*+'F'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};
const ICONBLK bwardblk=
	{(void *)icnmask, (void *)bwardpic, "", 0x1000/*+'B'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};
const ICONBLK setupblk=
	{(void *)icnmask, (void *)setuppic, "", 0x1000/*+'U'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};
const ICONBLK aboutblk=
	{(void *)icnmask, (void *)aboutpic, "", 0x1000/*+'A'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};
const ICONBLK exitblk=
	{(void *)icnmask, (void *)exitpic, "", 0x1000/*+'Q'*/, 25, 2, 0, 0, 32, 32, 2, 2, 0, 0};



char modulename[21]="-- No MOD loaded -- ";
const TEDINFO moduletext =
	{ modulename, "", "", 5, 0, 2, 0x100, 0, 0, 21, 1};

/* The main resource tree: */
OBJECT _maindlg[]={
 { -1, BWARDBUT, MODNAME, G_BOX, FL3DBAK, NORMAL, 0x80L, 1, 1, 0x7C01, 0x4201 },
 { PLAYBUT, -1, -1, G_ICON, TOUCHEXIT|SELECTABLE, NORMAL, (long)&bwardblk, 0x0200, 0, 0x2000, 0x2000 },
 { FWARDBUT, -1, -1, G_ICON, EXIT|SELECTABLE, NORMAL, (long)&playblk, 0x2200, 0, 0x2000, 0x2000 },
 { STOPBUT, -1, -1, G_ICON, TOUCHEXIT|SELECTABLE, NORMAL, (long)&fwardblk, 0x4200, 0, 0x2000, 0x2000 },
 { LOADBUT, -1, -1, G_ICON, EXIT|SELECTABLE, NORMAL, (long)&stopblk, 0x6200, 0, 0x2000, 0x2000 },
 { SETUPBUT, -1, -1, G_ICON, EXIT|SELECTABLE, NORMAL, (long)&loadblk, 0x0200, 0x2000, 0x2000, 0x2000 },
 { ABOUTBUT, -1, -1, G_ICON, EXIT|SELECTABLE, NORMAL, (long)&setupblk, 0x2200, 0x2000, 0x2000, 0x2000 },
 { EXITBUT, -1, -1, G_ICON, EXIT|SELECTABLE, NORMAL, (long)&aboutblk, 0x4200, 0x2000, 0x2000, 0x2000 },
 { MODNAME, -1, -1, G_ICON, EXIT|SELECTABLE, NORMAL, (long)&exitblk, 0x6200, 0x2000, 0x2000, 0x2000 },
 { MAINBOX, -1, -1, G_TEXT, FL3DBAK|LASTOB, NORMAL, (long)&moduletext, 0, 0x4100, 0x7F00, 1 }
};

OBJECT *maindlg;


const TEDINFO titletext =
	{ TVERTITEL, "", "", 3, 0, 2, /*0x2470*/9363, 0, -1, 16, 1};
const TEDINFO copy_r1 =
	{ "(C) 2002 by Thomas Huth", "", "", 3, 0, 2, 0x100, 0, 0, 32, 1};
const TEDINFO copy_r2 =
	{ "Replay routine written by:", "", "", 3, 0, 2, 0x100, 0, 0, 32, 1};

#ifdef TTX_DSP
const TEDINFO copy_r3 =
	{ "Steffen 'the bITmASTER' Scharfe ", "", "", 3, 0, 2, 0x100, 0, 0, 34, 1};
#else
const TEDINFO copy_r3 =
	{ "Martin Griffiths & Peter Hanning", "", "", 3, 0, 2, 0x100, 0, 0, 34, 1};
#endif

const TEDINFO thanks1 =
	{ "Thanks to all beta testers and other", "", "", 5, 0, 2, 0x100, 0, 0, 36, 1};
const TEDINFO thanks2 =
	{ "people who contributed to this program!", "", "", 5, 0, 2, 0x100, 0, 0, 39, 1};


/* The "About Tetrax" resource dialog: */
OBJECT aboutdlg[]={
 { -1, ABTITLE, ABOKAY, G_BOX, FL3DBAK, NORMAL, 0x80L, 0, 0, 36, 11 },
 { ABCR1, -1, -1, G_BOXTEXT, NONE, NORMAL, (long)&titletext, 7, 0x0400, 22, 1 },
 { ABCR2, -1, -1, G_TEXT, FL3DBAK, NORMAL, (long)&copy_r1, 1, 2, 34, 1 },
 { ABCR3, -1, -1, G_TEXT, FL3DBAK, NORMAL, (long)&copy_r2, 1, 3, 34, 1 },
 { ABTHX1, -1, -1, G_TEXT, FL3DBAK, NORMAL, (long)&copy_r3, 1, 4, 34, 1 },
 { ABTHX2, -1, -1, G_TEXT, FL3DBAK, NORMAL, (long)&thanks1, 1, 6, 34, 1 },
 { ABOKAY, -1, -1, G_TEXT, FL3DBAK, NORMAL, (long)&thanks2, 1, 7, 34, 1 },
 { ABOUTBOX, -1, -1, G_BUTTON, LASTOB|SELECTABLE|DEFAULT|EXIT|FL3DIND|FL3DBAK, NORMAL, (long)"Okay", 15, 9, 6, 1 }
};


const TEDINFO sutitletxt =
	{ " Tetrax Setup ", "", "", 3, 0, 2, 9363, 0, -1, 16, 1};
TEDINFO eofrted =
	{ " Polling (normal)  ", "", "", 3, 0, 2, 0x1100, 0, -1, 20, 1};
TEDINFO freqted =
	{ "25 kHz", "", "", 3, 0, 2, 0x1100, 0, -1, 9, 1};
TEDINFO msted =
	{ "Stereo", "", "", 3, 0, 2, 0x1100, 0, -1, 7, 1};
TEDINFO lskinted =
	{ "Load", "", "", 5, 0, 2, 0x1100, 0, -1, 4, 1};

char skinname[13];

/* The setup resource dialog: */

#ifdef TTX_DSP

OBJECT setupdlg[]={    /* For the DSP player */
 { -1, SUTITEL, SUOKAY, G_BOX, FL3DBAK, NORMAL, 0x80L, 0, 0, 32, 11 },
 { EOFRSTR, -1, -1, G_BOXTEXT, NONE, NORMAL, (long)&sutitletxt, 6, 0x0400, 20, 1 },
 { EOFRBUT, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"DSP replay routine can", 5, 2, 25, 1 },
 { FREQSTR, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"not yet be configured!", 5, 3, 25, 1 },
 { FREQBUT, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"Frequency:", 2, 5, 11, 1 },
 { MSBUT, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"50 kHz", 15, 5, 6, 1 },
 { LSKININF, -1, -1, G_TEXT, FL3DBAK, NORMAL, (long)&msted, 23, 5, 8, 1 },
 { LSKINNAM, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"Skin:", 2, 7, 5, 1 },
 { LSKINBUT, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)skinname, 9, 7, 12, 1 },
 { SUOKAY, -1, -1, G_BOXTEXT, SELECTABLE|EXIT|FL3DIND|FL3DBAK, NORMAL, (long)&lskinted, 24, 7, 6, 1 },
 { SETUPBOX, -1, -1, G_BUTTON, LASTOB|SELECTABLE|DEFAULT|EXIT|FL3DIND|FL3DBAK, NORMAL, (long)"Okay", 13, 9, 7, 1 }
};

#else

OBJECT setupdlg[]={    /* For the XBIOS player */
 { -1, SUTITEL, SUOKAY, G_BOX, FL3DBAK, NORMAL, 0x80L, 0, 0, 32, 11 },
 { EOFRSTR, -1, -1, G_BOXTEXT, NONE, NORMAL, (long)&sutitletxt, 6, 0x0400, 20, 1 },
 { EOFRBUT, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"'End of frame' mode:", 2, 2, 21, 1 },
 { FREQSTR, -1, -1, G_BOXTEXT, TOUCHEXIT, SHADOWED, (long)&eofrted, 6, 3, 20, 1 },
 { FREQBUT, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"Frequency:", 2, 5, 11, 1 },
 { MSBUT, -1, -1, G_BOXTEXT, TOUCHEXIT, SHADOWED, (long)&freqted, 14, 5, 8, 1 },
 { LSKININF, -1, -1, /*G_BOXTEXT*/G_TEXT, FL3DBAK/*TOUCHEXIT*/, NORMAL/*SHADOWED*/, (long)&msted, 23, 5, 8, 1 },
 { LSKINNAM, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)"Skin:", 2, 7, 5, 1 },
 { LSKINBUT, -1, -1, G_STRING, FL3DBAK, NORMAL, (long)skinname, 9, 7, 12, 1 },
 { SUOKAY, -1, -1, G_BOXTEXT, SELECTABLE|EXIT|FL3DIND|FL3DBAK, NORMAL, (long)&lskinted, 24, 7, 6, 1 },
 { SETUPBOX, -1, -1, G_BUTTON, LASTOB|SELECTABLE|DEFAULT|EXIT|FL3DIND|FL3DBAK, NORMAL, (long)"Okay", 13, 9, 7, 1 }
};

#endif


/* The frequencies popup: */
OBJECT freqpop[]={
 { -1, FRLOW, FRHI, G_BOX, NONE, SHADOWED, 0xFF1080L, 1, 1, 9, 3 },
 { FRMID, -1, -1, G_STRING, TOUCHEXIT, NORMAL, (long)"  12 kHz", 0, 0, 9, 1 },
 { FRHI, -1, -1, G_STRING, TOUCHEXIT, CHECKED, (long)"  25 kHz", 0, 1, 9, 1 },
 { FREQBOX, -1, -1, G_STRING, TOUCHEXIT|LASTOB, NORMAL, (long)"  50 kHz", 0, 2, 9, 1 },
};


/* The 'end of frame' popup: */
OBJECT eofrpop[]={
 { -1, EOFRM0, EOFRM4, G_BOX, NONE, SHADOWED, 0xFF1080L, 1, 1, 22, 5 },
 { EOFRM1, -1, -1, G_STRING, TOUCHEXIT, CHECKED, (long)"  Polling (normal)", 0, 0, 22, 1 },
 { EOFRM2, -1, -1, G_STRING, TOUCHEXIT, NORMAL, (long)"  Polling (looping)", 0, 1, 22, 1 },
 { EOFRM3, -1, -1, G_STRING, TOUCHEXIT, NORMAL, (long)"  Interrupt (GSXB)", 0, 2, 22, 1 },
 { EOFRM4, -1, -1, G_STRING, TOUCHEXIT, NORMAL, (long)"  Interrupt (Timer-A)", 0, 3, 22, 1 },
 { EOFRBOX, -1, -1, G_STRING, TOUCHEXIT|LASTOB, NORMAL, (long)"  Interrupt (MFP-i7)", 0, 4, 22, 1 }
};


/* The mono/stereo popup: */
#if 0
OBJECT mostepop[]={
 { -1, MONO, STEREO, G_BOX, NONE, SHADOWED, 0xFF1080L, 1, 1, 9, 2 },
 { STEREO, -1, -1, G_STRING, TOUCHEXIT, NORMAL, (long)"  Mono", 0, 0, 9, 1 },
 { MOSTEBOX, -1, -1, G_STRING, TOUCHEXIT|LASTOB, CHECKED, (long)"  Stereo", 0, 1, 9, 1 }
};
#endif


/* The iconified object: */
OBJECT _itree[]={
 { -1, ICNFICON, ICNFICON, G_BOX, FL3DBAK, NORMAL, 0x80L, 1, 1, 8, 4 },
 { ICNFBOX, -1, -1, G_ICON, LASTOB, NORMAL, (long)&playblk, 1, 1, 0x2000, 0x2000 }
};

OBJECT *itree;

