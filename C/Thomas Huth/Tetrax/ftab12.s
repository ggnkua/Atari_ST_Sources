
; #### 12kHz frequency table ####

;*** Freq.-table: ***
;* extern unsigned short ftab2[3840];
;* void crefrqtb()
;* {
;*  unsigned short per;
;*  double work,freq_amiga=3579545.0,freq_st=25033.0/4;
;*  unsigned short *x;
;*  x = ftab2;
;*  for (per = 1 ; per <= (1024+256) ; per++) 
;*   {
;*    work = (freq_amiga/(double)per)/freq_st; /* whole part */
;*    *x++=(unsigned short)work;
;*    *(long *)x = (65536.0*frac(work)*65536.0); /* output frac */
;*    x+=2;		
;*   }
;* }
;* double frac(double x)
;* {
;*  long i=x;
;*  return (x - i);
;* }

    .data

.globl ftab12
ftab12:
 ds.w 3
 dc.b $02,$3B,$F8,$E1,$E2,$09,$01,$1D,$FC,$70,$F1,$04,$00,$BE,$A8,$4B,$4B,$58
 dc.b $00,$8E,$FE,$38,$78,$82,$00,$72,$64,$F9,$FA,$01,$00,$5F,$54,$25,$A5,$AC
 dc.b $00,$51,$B5,$D7,$20,$4A,$00,$47,$7F,$1C,$3C,$41,$00,$3F,$8D,$6E,$6E,$72
 dc.b $00,$39,$32,$7C,$FD,$00,$00,$33,$FF,$5A,$5A,$5D,$00,$2F,$AA,$12,$D2,$D6
 dc.b $00,$2B,$FF,$73,$D6,$4F,$00,$28,$DA,$EB,$90,$25,$00,$26,$21,$A8,$A8,$AB
 dc.b $00,$23,$BF,$8E,$1E,$20,$00,$21,$A5,$3A,$76,$B5,$00,$1F,$C6,$B7,$37,$39
 dc.b $00,$1E,$1A,$92,$A0,$1B,$00,$1C,$99,$3E,$7E,$80,$00,$1B,$3C,$9D,$0A,$C3
 dc.b $00,$19,$FF,$AD,$2D,$2E,$00,$18,$DE,$4C,$9A,$85,$00,$17,$D5,$09,$69,$6B
 dc.b $00,$16,$E0,$FE,$CB,$99,$00,$15,$FF,$B9,$EB,$27,$00,$15,$2F,$24,$CF,$7B
 dc.b $00,$14,$6D,$75,$C8,$12,$00,$13,$B9,$22,$45,$96,$00,$13,$10,$D4,$54,$55
 dc.b $00,$12,$73,$62,$20,$10,$00,$11,$DF,$C7,$0F,$10,$00,$11,$55,$1E,$1E,$1F
 dc.b $00,$10,$D2,$9D,$3B,$5A,$00,$10,$57,$91,$6C,$DB,$00,$0F,$E3,$5B,$9B,$9C
 dc.b $00,$0F,$75,$6D,$E3,$83,$00,$0F,$0D,$49,$50,$0D,$00,$0E,$AA,$7B,$F2,$1A
 dc.b $00,$0E,$4C,$9F,$3F,$40,$00,$0D,$F3,$56,$AE,$19,$00,$0D,$9E,$4E,$85,$61
 dc.b $00,$0D,$4D,$3A,$D5,$A0,$00,$0C,$FF,$D6,$96,$97,$00,$0C,$B5,$E2,$E2,$E3
 dc.b $00,$0C,$6F,$26,$4D,$42,$00,$0C,$2B,$6C,$4B,$9E,$00,$0B,$EA,$84,$B4,$B5
 dc.b $00,$0B,$AC,$43,$4D,$C1,$00,$0B,$70,$7F,$65,$CC,$00,$0B,$37,$13,$7C,$E7
 dc.b $00,$0A,$FF,$DC,$F5,$93,$00,$0A,$CA,$BB,$CF,$21,$00,$0A,$97,$92,$67,$BD
 dc.b $00,$0A,$66,$45,$45,$45,$00,$0A,$36,$BA,$E4,$09,$00,$0A,$08,$DB,$8A,$B3
 dc.b $00,$09,$DC,$91,$22,$CB,$00,$09,$B1,$C7,$15,$2F,$00,$09,$88,$6A,$2A,$2A
 dc.b $00,$09,$60,$68,$6C,$9F,$00,$09,$39,$B1,$10,$08,$00,$09,$14,$34,$58,$EB
 dc.b $00,$08,$EF,$E3,$87,$88,$00,$08,$CC,$B0,$C4,$76,$00,$08,$AA,$8F,$0F,$0F
 dc.b $00,$08,$89,$72,$2D,$67,$00,$08,$69,$4E,$9D,$AD,$00,$08,$4A,$19,$88,$D7
 dc.b $00,$08,$2B,$C8,$B6,$6D,$00,$08,$0E,$52,$81,$61,$00,$07,$F1,$AD,$CD,$CE
 dc.b $00,$07,$D5,$D1,$FF,$96,$00,$07,$BA,$B6,$F1,$C1,$00,$07,$A0,$54,$EE,$88
 dc.b $00,$07,$86,$A4,$A8,$06,$00,$07,$6D,$9F,$31,$7B,$00,$07,$55,$3D,$F9,$0D
 dc.b $00,$07,$3D,$7A,$C2,$0D,$00,$07,$26,$4F,$9F,$A0,$00,$07,$0F,$B6,$EF,$D3
 dc.b $00,$06,$F9,$AB,$57,$0C,$00,$06,$E4,$27,$BB,$C8,$00,$06,$CF,$27,$42,$B0
 dc.b $00,$06,$BA,$A5,$4A,$F1,$00,$06,$A6,$9D,$6A,$D0,$00,$06,$93,$0B,$6C,$87
 dc.b $00,$06,$7F,$EB,$4B,$4B,$00,$06,$6D,$39,$30,$8F,$00,$06,$5A,$F1,$71,$71
 dc.b $00,$06,$49,$10,$8C,$54,$00,$06,$37,$93,$26,$A1,$00,$06,$26,$76,$0A,$B0
 dc.b $00,$06,$15,$B6,$25,$CF,$00,$06,$05,$50,$86,$6B,$00,$05,$F5,$42,$5A,$5A
 dc.b $00,$05,$E5,$88,$ED,$37,$00,$05,$D6,$21,$A6,$E0,$00,$05,$C7,$0A,$0A,$0A
 dc.b $00,$05,$B8,$3F,$B2,$E6,$00,$05,$A9,$C0,$55,$E1,$00,$05,$9B,$89,$BE,$73
 dc.b $00,$05,$8D,$99,$CE,$00,$00,$05,$7F,$EE,$7A,$C9,$00,$05,$72,$85,$CE,$F3
 dc.b $00,$05,$65,$5D,$E7,$90,$00,$05,$58,$74,$F3,$C1,$00,$05,$4B,$C9,$33,$DE
 dc.b $00,$05,$3F,$58,$F8,$AD,$00,$05,$33,$22,$A2,$A2,$00,$05,$27,$24,$A1,$2B
 dc.b $00,$05,$1B,$5D,$72,$04,$00,$05,$0F,$CB,$A0,$95,$00,$05,$04,$6D,$C5,$59
 dc.b $00,$04,$F9,$42,$85,$4D,$00,$04,$EE,$48,$91,$65,$00,$04,$E3,$7E,$A6,$08
 dc.b $00,$04,$D8,$E3,$8A,$97,$00,$04,$CE,$76,$10,$F5,$00,$04,$C4,$35,$15,$15
 dc.b $00,$04,$BA,$1F,$7C,$94,$00,$04,$B0,$34,$36,$4F,$00,$04,$A6,$72,$3A,$08
 dc.b $00,$04,$9C,$D8,$88,$04,$00,$04,$93,$66,$28,$B8,$00,$04,$8A,$1A,$2C,$75
 dc.b $00,$04,$80,$F3,$AB,$1A,$00,$04,$77,$F1,$C3,$C4,$00,$04,$6F,$13,$9C,$8A
 dc.b $00,$04,$66,$58,$62,$3B,$00,$04,$5D,$BF,$48,$13,$00,$04,$55,$47,$87,$87
 dc.b $00,$04,$4C,$F0,$60,$03,$00,$04,$44,$B9,$16,$B3,$00,$04,$3C,$A0,$F6,$4B
 dc.b $00,$04,$34,$A7,$4E,$D6,$00,$04,$2C,$CB,$75,$81,$00,$04,$25,$0C,$C4,$6B
 dc.b $00,$04,$1D,$6A,$9A,$7D,$00,$04,$15,$E4,$5B,$36,$00,$04,$0E,$79,$6E,$8A
 dc.b $00,$04,$07,$29,$40,$B0,$00,$03,$FF,$F3,$42,$07,$00,$03,$F8,$D6,$E6,$E7
 dc.b $00,$03,$F1,$D3,$A7,$84,$00,$03,$EA,$E8,$FF,$CB,$00,$03,$E4,$16,$6F,$40
 dc.b $00,$03,$DD,$5B,$78,$E0,$00,$03,$D6,$B7,$A3,$05,$00,$03,$D0,$2A,$77,$44
 dc.b $00,$03,$C9,$B3,$82,$58,$00,$03,$C3,$52,$54,$03,$00,$03,$BD,$06,$7E,$F7
 dc.b $00,$03,$B6,$CF,$98,$BD,$00,$03,$B0,$AD,$39,$9C,$00,$03,$AA,$9E,$FC,$86
 dc.b $00,$03,$A4,$A4,$7E,$FE,$00,$03,$9E,$BD,$61,$06,$00,$03,$98,$E9,$45,$0B
 dc.b $00,$03,$93,$27,$CF,$D0,$00,$03,$8D,$78,$A8,$5C,$00,$03,$87,$DB,$77,$E9
 dc.b $00,$03,$82,$4F,$E9,$D4,$00,$03,$7C,$D5,$AB,$86,$00,$03,$77,$6C,$6C,$6C
 dc.b $00,$03,$72,$13,$DD,$E4,$00,$03,$6C,$CB,$B3,$2C,$00,$03,$67,$93,$A1,$58
 dc.b $00,$03,$62,$6B,$5F,$41,$00,$03,$5D,$52,$A5,$78,$00,$03,$58,$49,$2E,$3B
 dc.b $00,$03,$53,$4E,$B5,$68,$00,$03,$4E,$62,$F8,$6D,$00,$03,$49,$85,$B6,$43
 dc.b $00,$03,$44,$B6,$AF,$5F,$00,$03,$3F,$F5,$A5,$A5,$00,$03,$3B,$42,$5C,$65
 dc.b $00,$03,$36,$9C,$98,$47,$00,$03,$32,$04,$1F,$4B,$00,$03,$2D,$78,$B8,$B8
 dc.b $00,$03,$28,$FA,$2D,$18,$00,$03,$24,$88,$46,$2A,$00,$03,$20,$22,$CE,$DF
 dc.b $00,$03,$1B,$C9,$93,$50,$00,$03,$17,$7C,$60,$B3,$00,$03,$13,$3B,$05,$58
 dc.b $00,$03,$0F,$05,$50,$9C,$00,$03,$0A,$DB,$12,$E7,$00,$03,$06,$BC,$1D,$A3
 dc.b $00,$03,$02,$A8,$43,$35,$00,$02,$FE,$9F,$56,$F6,$00,$02,$FA,$A1,$2D,$2D
 dc.b $00,$02,$F6,$AD,$9B,$09,$00,$02,$F2,$C4,$76,$9B,$00,$02,$EE,$E5,$96,$D2
 dc.b $00,$02,$EB,$10,$D3,$70,$00,$02,$E7,$46,$05,$0B,$00,$02,$E3,$85,$05,$05
 dc.b $00,$02,$DF,$CD,$AD,$84,$00,$02,$DC,$1F,$D9,$73,$00,$02,$D8,$7B,$64,$77
 dc.b $00,$02,$D4,$E0,$2A,$F0,$00,$02,$D1,$4E,$09,$F0,$00,$02,$CD,$C4,$DF,$39
 dc.b $00,$02,$CA,$44,$89,$38,$00,$02,$C6,$CC,$E7,$00,$00,$02,$C3,$5D,$D8,$47
 dc.b $00,$02,$BF,$F7,$3D,$64,$00,$02,$BC,$98,$F7,$48,$00,$02,$B9,$42,$E7,$79
 dc.b $00,$02,$B5,$F4,$F0,$15,$00,$02,$B2,$AE,$F3,$C8,$00,$02,$AF,$70,$D5,$CB
 dc.b $00,$02,$AC,$3A,$79,$E0,$00,$02,$A9,$0B,$C4,$53,$00,$02,$A5,$E4,$99,$EF
 dc.b $00,$02,$A2,$C4,$E0,$02,$00,$02,$9F,$AC,$7C,$56,$00,$02,$9C,$9B,$55,$32
 dc.b $00,$02,$99,$91,$51,$51,$00,$02,$96,$8E,$57,$E6,$00,$02,$93,$92,$50,$95
 dc.b $00,$02,$90,$9D,$23,$73,$00,$02,$8D,$AE,$B9,$02,$00,$02,$8A,$C6,$FA,$2D
 dc.b $00,$02,$87,$E5,$D0,$4A,$00,$02,$85,$0B,$25,$15,$00,$02,$82,$36,$E2,$AC
 dc.b $00,$02,$7F,$68,$F3,$92,$00,$02,$7C,$A1,$42,$A6,$00,$02,$79,$DF,$BB,$29
 dc.b $00,$02,$77,$24,$48,$B2,$00,$02,$74,$6E,$D7,$38,$00,$02,$71,$BF,$53,$04
 dc.b $00,$02,$6F,$15,$A8,$B9,$00,$02,$6C,$71,$C5,$4B,$00,$02,$69,$D3,$96,$04
 dc.b $00,$02,$67,$3B,$08,$7A,$00,$02,$64,$A8,$0A,$95,$00,$02,$62,$1A,$8A,$8A
 dc.b $00,$02,$5F,$92,$76,$D8,$00,$02,$5D,$0F,$BE,$4A,$00,$02,$5A,$92,$4F,$F1
 dc.b $00,$02,$58,$1A,$1B,$27,$00,$02,$55,$A7,$0F,$8D,$00,$02,$53,$39,$1D,$04
 dc.b $00,$02,$50,$D0,$33,$B3,$00,$02,$4E,$6C,$44,$02,$00,$02,$4C,$0D,$3E,$98
 dc.b $00,$02,$49,$B3,$14,$5C,$00,$02,$47,$5D,$B6,$72,$00,$02,$45,$0D,$16,$3A
 dc.b $00,$02,$42,$C1,$25,$51,$00,$02,$40,$79,$D5,$8D,$00,$02,$3E,$37,$18,$FB
 dc.b $00,$02,$3B,$F8,$E1,$E2,$00,$02,$39,$BF,$22,$BF,$00,$02,$37,$89,$CE,$45
 dc.b $00,$02,$35,$58,$D7,$5B,$00,$02,$33,$2C,$31,$1D,$00,$02,$31,$03,$CE,$D7
 dc.b $00,$02,$2E,$DF,$A4,$09,$00,$02,$2C,$BF,$A4,$63,$00,$02,$2A,$A3,$C3,$C3
 dc.b $00,$02,$28,$8B,$F6,$39,$00,$02,$26,$78,$30,$01,$00,$02,$24,$68,$65,$85
 dc.b $00,$02,$22,$5C,$8B,$59,$00,$02,$20,$54,$96,$40,$00,$02,$1E,$50,$7B,$25
 dc.b $00,$02,$1C,$50,$2F,$1F,$00,$02,$1A,$53,$A7,$6B,$00,$02,$18,$5A,$D9,$71
 dc.b $00,$02,$16,$65,$BA,$C0,$00,$02,$14,$74,$41,$0D,$00,$02,$12,$86,$62,$35
 dc.b $00,$02,$10,$9C,$14,$39,$00,$02,$0E,$B5,$4D,$3E,$00,$02,$0C,$D2,$03,$90
 dc.b $00,$02,$0A,$F2,$2D,$9B,$00,$02,$09,$15,$C1,$F1,$00,$02,$07,$3C,$B7,$45
 dc.b $00,$02,$05,$67,$04,$6A,$00,$02,$03,$94,$A0,$58,$00,$02,$01,$C5,$82,$23
 dc.b $00,$01,$FF,$F9,$A1,$03,$00,$01,$FE,$30,$F4,$4C,$00,$01,$FC,$6B,$73,$73
 dc.b $00,$01,$FA,$A9,$16,$0A,$00,$01,$F8,$E9,$D3,$C2,$00,$01,$F7,$2D,$A4,$67
 dc.b $00,$01,$F5,$74,$7F,$E5,$00,$01,$F3,$BE,$5E,$42,$00,$01,$F2,$0B,$37,$A0
 dc.b $00,$01,$F0,$5B,$04,$3C,$00,$01,$EE,$AD,$BC,$70,$00,$01,$ED,$03,$58,$AE
 dc.b $00,$01,$EB,$5B,$D1,$82,$00,$01,$E9,$B7,$1F,$94,$00,$01,$E8,$15,$3B,$A2
 dc.b $00,$01,$E6,$76,$1E,$84,$00,$01,$E4,$D9,$C1,$2C,$00,$01,$E3,$40,$1C,$A0
 dc.b $00,$01,$E1,$A9,$2A,$01,$00,$01,$E0,$14,$E2,$86,$00,$01,$DE,$83,$3F,$7B
 dc.b $00,$01,$DC,$F4,$3A,$46,$00,$01,$DB,$67,$CC,$5E,$00,$01,$D9,$DD,$EF,$55
 dc.b $00,$01,$D8,$56,$9C,$CE,$00,$01,$D6,$D1,$CE,$83,$00,$01,$D5,$4F,$7E,$43
 dc.b $00,$01,$D3,$CF,$A5,$EF,$00,$01,$D2,$52,$3F,$7F,$00,$01,$D0,$D7,$44,$FB
 dc.b $00,$01,$CF,$5E,$B0,$83,$00,$01,$CD,$E8,$7C,$45,$00,$01,$CC,$74,$A2,$85
 dc.b $00,$01,$CB,$03,$1D,$99,$00,$01,$C9,$93,$E7,$E8,$00,$01,$C8,$26,$FB,$EB
 dc.b $00,$01,$C6,$BC,$54,$2E,$00,$01,$C5,$53,$EB,$4C,$00,$01,$C3,$ED,$BB,$F4
 dc.b $00,$01,$C2,$89,$C0,$E4,$00,$01,$C1,$27,$F4,$EA,$00,$01,$BF,$C8,$52,$E4
 dc.b $00,$01,$BE,$6A,$D5,$C3,$00,$01,$BD,$0F,$78,$84,$00,$01,$BB,$B6,$36,$36
 dc.b $00,$01,$BA,$5F,$09,$F6,$00,$01,$B9,$09,$EE,$F2,$00,$01,$B7,$B6,$E0,$63
 dc.b $00,$01,$B6,$65,$D9,$96,$00,$01,$B5,$16,$D5,$E1,$00,$01,$B3,$C9,$D0,$AC
 dc.b $00,$01,$B2,$7E,$C5,$6B,$00,$01,$B1,$35,$AF,$A0,$00,$01,$AF,$EE,$8A,$DC
 dc.b $00,$01,$AE,$A9,$52,$BC,$00,$01,$AD,$66,$02,$EA,$00,$01,$AC,$24,$97,$1D
 dc.b $00,$01,$AA,$E5,$0B,$1B,$00,$01,$A9,$A7,$5A,$B4,$00,$01,$A8,$6B,$81,$C4
 dc.b $00,$01,$A7,$31,$7C,$36,$00,$01,$A5,$F9,$46,$00,$00,$01,$A4,$C2,$DB,$21
 dc.b $00,$01,$A3,$8E,$37,$A9,$00,$01,$A2,$5B,$57,$AF,$00,$01,$A1,$2A,$37,$58
 dc.b $00,$01,$9F,$FA,$D2,$D2,$00,$01,$9E,$CD,$26,$59,$00,$01,$9D,$A1,$2E,$32
 dc.b $00,$01,$9C,$76,$E6,$AD,$00,$01,$9B,$4E,$4C,$23,$00,$01,$9A,$27,$5A,$FC
 dc.b $00,$01,$99,$02,$0F,$A5,$00,$01,$97,$DE,$66,$9A,$00,$01,$96,$BC,$5C,$5C
 dc.b $00,$01,$95,$9B,$ED,$7A,$00,$01,$94,$7D,$16,$8C,$00,$01,$93,$5F,$D4,$31
 dc.b $00,$01,$92,$44,$23,$15,$00,$01,$91,$29,$FF,$EA,$00,$01,$90,$11,$67,$6F
 dc.b $00,$01,$8E,$FA,$56,$6A,$00,$01,$8D,$E4,$C9,$A8,$00,$01,$8C,$D0,$BE,$02
 dc.b $00,$01,$8B,$BE,$30,$59,$00,$01,$8A,$AD,$1D,$97,$00,$01,$89,$9D,$82,$AC
 dc.b $00,$01,$88,$8F,$5C,$92,$00,$01,$87,$82,$A8,$4E,$00,$01,$86,$77,$62,$E8
 dc.b $00,$01,$85,$6D,$89,$73,$00,$01,$84,$65,$19,$0B,$00,$01,$83,$5E,$0E,$D1
 dc.b $00,$01,$82,$58,$67,$F1,$00,$01,$81,$54,$21,$9A,$00,$01,$80,$51,$39,$08
 dc.b $00,$01,$7F,$4F,$AB,$7B,$00,$01,$7E,$4F,$76,$3A,$00,$01,$7D,$50,$96,$96
 dc.b $00,$01,$7C,$53,$09,$E5,$00,$01,$7B,$56,$CD,$84,$00,$01,$7A,$5B,$DE,$D8
 dc.b $00,$01,$79,$62,$3B,$4D,$00,$01,$78,$69,$E0,$55,$00,$01,$77,$72,$CB,$69
 dc.b $00,$01,$76,$7C,$FA,$07,$00,$01,$75,$88,$69,$B8,$00,$01,$74,$95,$18,$06
 dc.b $00,$01,$73,$A3,$02,$85,$00,$01,$72,$B2,$26,$CF,$00,$01,$71,$C2,$82,$82
 dc.b $00,$01,$70,$D4,$13,$45,$00,$01,$6F,$E6,$D6,$C2,$00,$01,$6E,$FA,$CA,$AB
 dc.b $00,$01,$6E,$0F,$EC,$B9,$00,$01,$6D,$26,$3A,$A8,$00,$01,$6C,$3D,$B2,$3B
 dc.b $00,$01,$6B,$56,$51,$3C,$00,$01,$6A,$70,$15,$78,$00,$01,$69,$8A,$FC,$C3
 dc.b $00,$01,$68,$A7,$04,$F8,$00,$01,$67,$C4,$2B,$F4,$00,$01,$66,$E2,$6F,$9C
 dc.b $00,$01,$66,$01,$CD,$DA,$00,$01,$65,$22,$44,$9C,$00,$01,$64,$43,$D1,$D5
 dc.b $00,$01,$63,$66,$73,$80,$00,$01,$62,$8A,$27,$99,$00,$01,$61,$AE,$EC,$23
 dc.b $00,$01,$60,$D4,$BF,$28,$00,$01,$5F,$FB,$9E,$B2,$00,$01,$5F,$23,$88,$D4
 dc.b $00,$01,$5E,$4C,$7B,$A4,$00,$01,$5D,$76,$75,$3C,$00,$01,$5C,$A1,$73,$BC
 dc.b $00,$01,$5B,$CD,$75,$49,$00,$01,$5A,$FA,$78,$0A,$00,$01,$5A,$28,$7A,$2E
 dc.b $00,$01,$59,$57,$79,$E4,$00,$01,$58,$87,$75,$63,$00,$01,$57,$B8,$6A,$E5
 dc.b $00,$01,$56,$EA,$58,$A9,$00,$01,$56,$1D,$3C,$F0,$00,$01,$55,$51,$16,$02
 dc.b $00,$01,$54,$85,$E2,$29,$00,$01,$53,$BB,$9F,$B5,$00,$01,$52,$F2,$4C,$F7
 dc.b $00,$01,$52,$29,$E8,$48,$00,$01,$51,$62,$70,$01,$00,$01,$50,$9B,$E2,$81
 dc.b $00,$01,$4F,$D6,$3E,$2B,$00,$01,$4F,$11,$81,$65,$00,$01,$4E,$4D,$AA,$99
 dc.b $00,$01,$4D,$8A,$B8,$34,$00,$01,$4C,$C8,$A8,$A8,$00,$01,$4C,$07,$7A,$6A
 dc.b $00,$01,$4B,$47,$2B,$F3,$00,$01,$4A,$87,$BB,$BE,$00,$01,$49,$C9,$28,$4A
 dc.b $00,$01,$49,$0B,$70,$1C,$00,$01,$48,$4E,$91,$B9,$00,$01,$47,$92,$8B,$AC
 dc.b $00,$01,$46,$D7,$5C,$81,$00,$01,$46,$1D,$02,$C8,$00,$01,$45,$63,$7D,$16
 dc.b $00,$01,$44,$AA,$CA,$02,$00,$01,$43,$F2,$E8,$25,$00,$01,$43,$3B,$D6,$1D
 dc.b $00,$01,$42,$85,$92,$8A,$00,$01,$41,$D0,$1C,$10,$00,$01,$41,$1B,$71,$56
 dc.b $00,$01,$40,$67,$91,$05,$00,$01,$3F,$B4,$79,$C9,$00,$01,$3F,$02,$2A,$52
 dc.b $00,$01,$3E,$50,$A1,$53,$00,$01,$3D,$9F,$DD,$81,$00,$01,$3C,$EF,$DD,$94
 dc.b $00,$01,$3C,$40,$A0,$47,$00,$01,$3B,$92,$24,$59,$00,$01,$3A,$E4,$68,$89
 dc.b $00,$01,$3A,$37,$6B,$9C,$00,$01,$39,$8B,$2C,$56,$00,$01,$38,$DF,$A9,$82
 dc.b $00,$01,$38,$34,$E1,$EA,$00,$01,$37,$8A,$D4,$5C,$00,$01,$36,$E1,$7F,$AA
 dc.b $00,$01,$36,$38,$E2,$A5,$00,$01,$35,$90,$FC,$25,$00,$01,$34,$E9,$CB,$02
 dc.b $00,$01,$34,$43,$4E,$15,$00,$01,$33,$9D,$84,$3D,$00,$01,$32,$F8,$6C,$59
 dc.b $00,$01,$32,$54,$05,$4A,$00,$01,$31,$B0,$4D,$F7,$00,$01,$31,$0D,$45,$45
 dc.b $00,$01,$30,$6A,$EA,$1D,$00,$01,$2F,$C9,$3B,$6C,$00,$01,$2F,$28,$38,$1E
 dc.b $00,$01,$2E,$87,$DF,$25,$00,$01,$2D,$E8,$2F,$71,$00,$01,$2D,$49,$27,$F8
 dc.b $00,$01,$2C,$AA,$C7,$B1,$00,$01,$2C,$0D,$0D,$93,$00,$01,$2B,$6F,$F8,$9C
 dc.b $00,$01,$2A,$D3,$87,$C6,$00,$01,$2A,$37,$BA,$12,$00,$01,$29,$9C,$8E,$82
 dc.b $00,$01,$29,$02,$04,$17,$00,$01,$28,$68,$19,$D9,$00,$01,$27,$CE,$CE,$CE
 dc.b $00,$01,$27,$36,$22,$01,$00,$01,$26,$9E,$12,$7B,$00,$01,$26,$06,$9F,$4C
 dc.b $00,$01,$25,$6F,$C7,$81,$00,$01,$24,$D9,$8A,$2E,$00,$01,$24,$43,$E6,$64
 dc.b $00,$01,$23,$AE,$DB,$39,$00,$01,$23,$1A,$67,$C3,$00,$01,$22,$86,$8B,$1D
 dc.b $00,$01,$21,$F3,$44,$60,$00,$01,$21,$60,$92,$A8,$00,$01,$20,$CE,$75,$15
 dc.b $00,$01,$20,$3C,$EA,$C6,$00,$01,$1F,$AB,$F2,$DD,$00,$01,$1F,$1B,$8C,$7D
 dc.b $00,$01,$1E,$8B,$B6,$CC,$00,$01,$1D,$FC,$70,$F1,$00,$01,$1D,$6D,$BA,$13
 dc.b $00,$01,$1C,$DF,$91,$5F,$00,$01,$1C,$51,$F6,$00,$00,$01,$1B,$C4,$E7,$22
 dc.b $00,$01,$1B,$38,$63,$F7,$00,$01,$1A,$AC,$6B,$AD,$00,$01,$1A,$20,$FD,$79
 dc.b $00,$01,$19,$96,$18,$8E,$00,$01,$19,$0B,$BC,$22,$00,$01,$18,$81,$E7,$6B
 dc.b $00,$01,$17,$F8,$99,$A3,$00,$01,$17,$6F,$D2,$04,$00,$01,$16,$E7,$8F,$CA
 dc.b $00,$01,$16,$5F,$D2,$31,$00,$01,$15,$D8,$98,$79,$00,$01,$15,$51,$E1,$E1
 dc.b $00,$01,$14,$CB,$AD,$AC,$00,$01,$14,$45,$FB,$1C,$00,$01,$13,$C0,$C9,$77
 dc.b $00,$01,$13,$3C,$18,$00,$00,$01,$12,$B7,$E6,$01,$00,$01,$12,$34,$32,$C2
 dc.b $00,$01,$11,$B0,$FD,$8D,$00,$01,$11,$2E,$45,$AC,$00,$01,$10,$AC,$0A,$6E
 dc.b $00,$01,$10,$2A,$4B,$20,$00,$01,$0F,$A9,$07,$11,$00,$01,$0F,$28,$3D,$92
 dc.b $00,$01,$0E,$A7,$ED,$F6,$00,$01,$0E,$28,$17,$8F,$00,$01,$0D,$A8,$B9,$B2
 dc.b $00,$01,$0D,$29,$D3,$B5,$00,$01,$0C,$AB,$64,$EF,$00,$01,$0C,$2D,$6C,$B8
 dc.b $00,$01,$0B,$AF,$EA,$6A,$00,$01,$0B,$32,$DD,$60,$00,$01,$0A,$B6,$44,$F5
 dc.b $00,$01,$0A,$3A,$20,$86,$00,$01,$09,$BE,$6F,$73,$00,$01,$09,$43,$31,$1A
 dc.b $00,$01,$08,$C8,$64,$DD,$00,$01,$08,$4E,$0A,$1C,$00,$01,$07,$D4,$20,$3B
 dc.b $00,$01,$07,$5A,$A6,$9F,$00,$01,$06,$E1,$9C,$AB,$00,$01,$06,$69,$01,$C8
 dc.b $00,$01,$05,$F0,$D5,$5B,$00,$01,$05,$79,$16,$CD,$00,$01,$05,$01,$C5,$89
 dc.b $00,$01,$04,$8A,$E0,$F8,$00,$01,$04,$14,$68,$87,$00,$01,$03,$9E,$5B,$A2
 dc.b $00,$01,$03,$28,$B9,$B7,$00,$01,$02,$B3,$82,$35,$00,$01,$02,$3E,$B4,$8B
 dc.b $00,$01,$01,$CA,$50,$2C,$00,$01,$01,$56,$54,$87,$00,$01,$00,$E2,$C1,$11
 dc.b $00,$01,$00,$6F,$95,$3E,$00,$00,$FF,$FC,$D0,$81,$00,$00,$FF,$8A,$72,$52
 dc.b $00,$00,$FF,$18,$7A,$26,$00,$00,$FE,$A6,$E7,$75,$00,$00,$FE,$35,$B9,$B9
 dc.b $00,$00,$FD,$C4,$F0,$6B,$00,$00,$FD,$54,$8B,$05,$00,$00,$FC,$E4,$89,$03
 dc.b $00,$00,$FC,$74,$E9,$E1,$00,$00,$FC,$05,$AD,$1C,$00,$00,$FB,$96,$D2,$33
 dc.b $00,$00,$FB,$28,$58,$A5,$00,$00,$FA,$BA,$3F,$F2,$00,$00,$FA,$4C,$87,$9B
 dc.b $00,$00,$F9,$DF,$2F,$21,$00,$00,$F9,$72,$36,$06,$00,$00,$F9,$05,$9B,$D0
 dc.b $00,$00,$F8,$99,$60,$00,$00,$00,$F8,$2D,$82,$1E,$00,$00,$F7,$C2,$01,$AE
 dc.b $00,$00,$F7,$56,$DE,$38,$00,$00,$F6,$EC,$17,$42,$00,$00,$F6,$81,$AC,$57
 dc.b $00,$00,$F6,$17,$9C,$FD,$00,$00,$F5,$AD,$E8,$C1,$00,$00,$F5,$44,$8F,$2C
 dc.b $00,$00,$F4,$DB,$8F,$CA,$00,$00,$F4,$72,$EA,$27,$00,$00,$F4,$0A,$9D,$D1
 dc.b $00,$00,$F3,$A2,$AA,$55,$00,$00,$F3,$3B,$0F,$42,$00,$00,$F2,$D3,$CC,$27
 dc.b $00,$00,$F2,$6C,$E0,$96,$00,$00,$F2,$06,$4C,$1D,$00,$00,$F1,$A0,$0E,$50
 dc.b $00,$00,$F1,$3A,$26,$C0,$00,$00,$F0,$D4,$95,$00,$00,$00,$F0,$6F,$58,$A5
 dc.b $00,$00,$F0,$0A,$71,$43,$00,$00,$EF,$A5,$DE,$6E,$00,$00,$EF,$41,$9F,$BD
 dc.b $00,$00,$EE,$DD,$B4,$C7,$00,$00,$EE,$7A,$1D,$23,$00,$00,$EE,$16,$D8,$68
 dc.b $00,$00,$ED,$B3,$E6,$2F,$00,$00,$ED,$51,$46,$12,$00,$00,$EC,$EE,$F7,$AA
 dc.b $00,$00,$EC,$8C,$FA,$93,$00,$00,$EC,$2B,$4E,$67,$00,$00,$EB,$C9,$F2,$C2
 dc.b $00,$00,$EB,$68,$E7,$41,$00,$00,$EB,$08,$2B,$82,$00,$00,$EA,$A7,$BF,$21
 dc.b $00,$00,$EA,$47,$A1,$BE,$00,$00,$E9,$E7,$D2,$F7,$00,$00,$E9,$88,$52,$6D
 dc.b $00,$00,$E9,$29,$1F,$BF,$00,$00,$E8,$CA,$3A,$8F,$00,$00,$E8,$6B,$A2,$7D
 dc.b $00,$00,$E8,$0D,$57,$2D,$00,$00,$E7,$AF,$58,$41,$00,$00,$E7,$51,$A5,$5C
 dc.b $00,$00,$E6,$F4,$3E,$22,$00,$00,$E6,$97,$22,$38,$00,$00,$E6,$3A,$51,$42
 dc.b $00,$00,$E5,$DD,$CA,$E7,$00,$00,$E5,$81,$8E,$CC,$00,$00,$E5,$25,$9C,$99
 dc.b $00,$00,$E4,$C9,$F3,$F4,$00,$00,$E4,$6E,$94,$85,$00,$00,$E4,$13,$7D,$F5
 dc.b $00,$00,$E3,$B8,$AF,$ED,$00,$00,$E3,$5E,$2A,$17,$00,$00,$E3,$03,$EC,$1B
 dc.b $00,$00,$E2,$A9,$F5,$A6,$00,$00,$E2,$50,$46,$62,$00,$00,$E1,$F6,$DD,$FA
 dc.b $00,$00,$E1,$9D,$BC,$1B,$00,$00,$E1,$44,$E0,$72,$00,$00,$E0,$EC,$4A,$AB
 dc.b $00,$00,$E0,$93,$FA,$75,$00,$00,$E0,$3B,$EF,$7D,$00,$00,$DF,$E4,$29,$72
 dc.b $00,$00,$DF,$8C,$A8,$03,$00,$00,$DF,$35,$6A,$E1,$00,$00,$DE,$DE,$71,$BB
 dc.b $00,$00,$DE,$87,$BC,$42,$00,$00,$DE,$31,$4A,$26,$00,$00,$DD,$DB,$1B,$1B
 dc.b $00,$00,$DD,$85,$2E,$D1,$00,$00,$DD,$2F,$84,$FB,$00,$00,$DC,$DA,$1D,$4C
 dc.b $00,$00,$DC,$84,$F7,$79,$00,$00,$DC,$30,$13,$33,$00,$00,$DB,$DB,$70,$31
 dc.b $00,$00,$DB,$87,$0E,$27,$00,$00,$DB,$32,$EC,$CB,$00,$00,$DA,$DF,$0B,$D1
 dc.b $00,$00,$DA,$8B,$6A,$F0,$00,$00,$DA,$38,$09,$DF,$00,$00,$D9,$E4,$E8,$56
 dc.b $00,$00,$D9,$92,$06,$0A,$00,$00,$D9,$3F,$62,$B5,$00,$00,$D8,$EC,$FE,$0F
 dc.b $00,$00,$D8,$9A,$D7,$D0,$00,$00,$D8,$48,$EF,$B2,$00,$00,$D7,$F7,$45,$6E
 dc.b $00,$00,$D7,$A5,$D8,$BE,$00,$00,$D7,$54,$A9,$5E,$00,$00,$D7,$03,$B7,$07
 dc.b $00,$00,$D6,$B3,$01,$75,$00,$00,$D6,$62,$88,$63,$00,$00,$D6,$12,$4B,$8E
 dc.b $00,$00,$D5,$C2,$4A,$B3,$00,$00,$D5,$72,$85,$8D,$00,$00,$D5,$22,$FB,$DB
 dc.b $00,$00,$D4,$D3,$AD,$5A,$00,$00,$D4,$84,$99,$C7,$00,$00,$D4,$35,$C0,$E2
 dc.b $00,$00,$D3,$E7,$22,$69,$00,$00,$D3,$98,$BE,$1B,$00,$00,$D3,$4A,$93,$B8
 dc.b $00,$00,$D2,$FC,$A3,$00,$00,$00,$D2,$AE,$EB,$B2,$00,$00,$D2,$61,$6D,$90
 dc.b $00,$00,$D2,$14,$28,$5B,$00,$00,$D1,$C7,$1B,$D4,$00,$00,$D1,$7A,$47,$BD
 dc.b $00,$00,$D1,$2D,$AB,$D7,$00,$00,$D0,$E1,$47,$E6,$00,$00,$D0,$95,$1B,$AC
 dc.b $00,$00,$D0,$49,$26,$EB,$00,$00,$CF,$FD,$69,$69,$00,$00,$CF,$B1,$E2,$E8
 dc.b $00,$00,$CF,$66,$93,$2C,$00,$00,$CF,$1B,$79,$FB,$00,$00,$CE,$D0,$97,$19
 dc.b $00,$00,$CE,$85,$EA,$4B,$00,$00,$CE,$3B,$73,$56,$00,$00,$CD,$F1,$32,$01
 dc.b $00,$00,$CD,$A7,$26,$11,$00,$00,$CD,$5D,$4F,$4E,$00,$00,$CD,$13,$AD,$7E
 dc.b $00,$00,$CC,$CA,$40,$67,$00,$00,$CC,$81,$07,$D2,$00,$00,$CC,$38,$03,$87
 dc.b $00,$00,$CB,$EF,$33,$4D,$00,$00,$CB,$A6,$96,$EC,$00,$00,$CB,$5E,$2E,$2E
 dc.b $00,$00,$CB,$15,$F8,$DB,$00,$00,$CA,$CD,$F6,$BD,$00,$00,$CA,$86,$27,$9D
 dc.b $00,$00,$CA,$3E,$8B,$46,$00,$00,$C9,$F7,$21,$80,$00,$00,$C9,$AF,$EA,$18
 dc.b $00,$00,$C9,$68,$E4,$D8,$00,$00,$C9,$22,$11,$8A,$00,$00,$C8,$DB,$6F,$FB
 dc.b $00,$00,$C8,$94,$FF,$F5,$00,$00,$C8,$4E,$C1,$45,$00,$00,$C8,$08,$B3,$B7
 dc.b $00,$00,$C7,$C2,$D7,$18,$00,$00,$C7,$7D,$2B,$35,$00,$00,$C7,$37,$AF,$D9
 dc.b $00,$00,$C6,$F2,$64,$D4,$00,$00,$C6,$AD,$49,$F2,$00,$00,$C6,$68,$5F,$01
 dc.b $00,$00,$C6,$23,$A3,$D0,$00,$00,$C5,$DF,$18,$2C,$00,$00,$C5,$9A,$BB,$E6
 dc.b $00,$00,$C5,$56,$8E,$CB,$00,$00,$C5,$12,$90,$AB,$00,$00,$C4,$CE,$C1,$56
 dc.b $00,$00,$C4,$8B,$20,$9A,$00,$00,$C4,$47,$AE,$49,$00,$00,$C4,$04,$6A,$32
 dc.b $00,$00,$C3,$C1,$54,$27,$00,$00,$C3,$7E,$6B,$F7,$00,$00,$C3,$3B,$B1,$74
 dc.b $00,$00,$C2,$F9,$24,$6F,$00,$00,$C2,$B6,$C4,$B9,$00,$00,$C2,$74,$92,$26
 dc.b $00,$00,$C2,$32,$8C,$85,$00,$00,$C1,$F0,$B3,$AB,$00,$00,$C1,$AF,$07,$68
 dc.b $00,$00,$C1,$6D,$87,$91,$00,$00,$C1,$2C,$33,$F8,$00,$00,$C0,$EB,$0C,$70
 dc.b $00,$00,$C0,$AA,$10,$CD,$00,$00,$C0,$69,$40,$E2,$00,$00,$C0,$28,$9C,$84
 dc.b $00,$00,$BF,$E8,$23,$86,$00,$00,$BF,$A7,$D5,$BD,$00,$00,$BF,$67,$B2,$FE
 dc.b $00,$00,$BF,$27,$BB,$1D,$00,$00,$BE,$E7,$ED,$EF,$00,$00,$BE,$A8,$4B,$4B
 dc.b $00,$00,$BE,$68,$D3,$05,$00,$00,$BE,$29,$84,$F2,$00,$00,$BD,$EA,$60,$EA
 dc.b $00,$00,$BD,$AB,$66,$C2,$00,$00,$BD,$6C,$96,$50,$00,$00,$BD,$2D,$EF,$6C
 dc.b $00,$00,$BC,$EF,$71,$EC,$00,$00,$BC,$B1,$1D,$A6,$00,$00,$BC,$72,$F2,$73
 dc.b $00,$00,$BC,$34,$F0,$2A,$00,$00,$BB,$F7,$16,$A3,$00,$00,$BB,$B9,$65,$B4
 dc.b $00,$00,$BB,$7B,$DD,$37,$00,$00,$BB,$3E,$7D,$03,$00,$00,$BB,$01,$44,$F2
 dc.b $00,$00,$BA,$C4,$34,$DC,$00,$00,$BA,$87,$4C,$99,$00,$00,$BA,$4A,$8C,$03
 dc.b $00,$00,$BA,$0D,$F2,$F3,$00,$00,$B9,$D1,$81,$42,$00,$00,$B9,$95,$36,$CB
 dc.b $00,$00,$B9,$59,$13,$67,$00,$00,$B9,$1D,$16,$F0,$00,$00,$B8,$E1,$41,$41
 dc.b $00,$00,$B8,$A5,$92,$33,$00,$00,$B8,$6A,$09,$A2,$00,$00,$B8,$2E,$A7,$68
 dc.b $00,$00,$B7,$F3,$6B,$61,$00,$00,$B7,$B8,$55,$67,$00,$00,$B7,$7D,$65,$55
 dc.b $00,$00,$B7,$42,$9B,$09,$00,$00,$B7,$07,$F6,$5C,$00,$00,$B6,$CD,$77,$2C
 dc.b $00,$00,$B6,$93,$1D,$54,$00,$00,$B6,$58,$E8,$B0,$00,$00,$B6,$1E,$D9,$1D
 dc.b $00,$00,$B5,$E4,$EE,$78,$00,$00,$B5,$AB,$28,$9E,$00,$00,$B5,$71,$87,$6A
 dc.b $00,$00,$B5,$38,$0A,$BC,$00,$00,$B4,$FE,$B2,$6F,$00,$00,$B4,$C5,$7E,$61
 dc.b $00,$00,$B4,$8C,$6E,$71,$00,$00,$B4,$53,$82,$7C,$00,$00,$B4,$1A,$BA,$5F
 dc.b $00,$00,$B3,$E2,$15,$FA,$00,$00,$B3,$A9,$95,$2A,$00,$00,$B3,$71,$37,$CE
 dc.b $00,$00,$B3,$38,$FD,$C5,$00,$00,$B3,$00,$E6,$ED,$00,$00,$B2,$C8,$F3,$25
 dc.b $00,$00,$B2,$91,$22,$4E,$00,$00,$B2,$59,$74,$45,$00,$00,$B2,$21,$E8,$EA
 dc.b $00,$00,$B1,$EA,$80,$1E,$00,$00,$B1,$B3,$39,$C0,$00,$00,$B1,$7C,$15,$AF
 dc.b $00,$00,$B1,$45,$13,$CC,$00,$00,$B1,$0E,$33,$F7,$00,$00,$B0,$D7,$76,$11
 dc.b $00,$00,$B0,$A0,$D9,$FB,$00,$00,$B0,$6A,$5F,$94,$00,$00,$B0,$34,$06,$BD
 dc.b $00,$00,$AF,$FD,$CF,$59,$00,$00,$AF,$C7,$B9,$47,$00,$00,$AF,$91,$C4,$6A
 dc.b $00,$00,$AF,$5B,$F0,$A2,$00,$00,$AF,$26,$3D,$D2,$00,$00,$AE,$F0,$AB,$DA
 dc.b $00,$00,$AE,$BB,$3A,$9E,$00,$00,$AE,$85,$E9,$FE,$00,$00,$AE,$50,$B9,$DE
 dc.b $00,$00,$AE,$1B,$AA,$1F,$00,$00,$AD,$E6,$BA,$A4,$00,$00,$AD,$B1,$EB,$50
 dc.b $00,$00,$AD,$7D,$3C,$05,$00,$00,$AD,$48,$AC,$A6,$00,$00,$AD,$14,$3D,$17
 dc.b $00,$00,$AC,$DF,$ED,$39,$00,$00,$AC,$AB,$BC,$F2,$00,$00,$AC,$77,$AC,$23
 dc.b $00,$00,$AC,$43,$BA,$B1,$00,$00,$AC,$0F,$E8,$80,$00,$00,$AB,$DC,$35,$72
 dc.b $00,$00,$AB,$A8,$A1,$6D,$00,$00,$AB,$75,$2C,$54,$00,$00,$AB,$41,$D6,$0B
 dc.b $00,$00,$AB,$0E,$9E,$78,$00,$00,$AA,$DB,$85,$7D,$00,$00,$AA,$A8,$8B,$01
 dc.b $00,$00,$AA,$75,$AE,$E7,$00,$00,$AA,$42,$F1,$14,$00,$00,$AA,$10,$51,$6E
 dc.b $00,$00,$A9,$DD,$CF,$DA,$00,$00,$A9,$AB,$6C,$3D,$00,$00,$A9,$79,$26,$7B
 dc.b $00,$00,$A9,$46,$FE,$7C,$00,$00,$A9,$14,$F4,$24,$00,$00,$A8,$E3,$07,$58
 dc.b $00,$00,$A8,$B1,$38,$00,$00,$00,$A8,$7F,$86,$01,$00,$00,$A8,$4D,$F1,$40
 dc.b $00,$00,$A8,$1C,$79,$A5,$00,$00,$A7,$EB,$1F,$15,$00,$00,$A7,$B9,$E1,$77
 dc.b $00,$00,$A7,$88,$C0,$B2,$00,$00,$A7,$57,$BC,$AC,$00,$00,$A7,$26,$D5,$4C
 dc.b $00,$00,$A6,$F6,$0A,$79,$00,$00,$A6,$C5,$5C,$1A,$00,$00,$A6,$94,$CA,$16
 dc.b $00,$00,$A6,$64,$54,$54,$00,$00,$A6,$33,$FA,$BC,$00,$00,$A6,$03,$BD,$35
 dc.b $00,$00,$A5,$D3,$9B,$A7,$00,$00,$A5,$A3,$95,$F9,$00,$00,$A5,$73,$AC,$14
 dc.b $00,$00,$A5,$43,$DD,$DF,$00,$00,$A5,$14,$2B,$42,$00,$00,$A4,$E4,$94,$25
 dc.b $00,$00,$A4,$B5,$18,$71,$00,$00,$A4,$85,$B8,$0E,$00,$00,$A4,$56,$72,$E4
 dc.b $00,$00,$A4,$27,$48,$DC,$00,$00,$A3,$F8,$39,$DF,$00,$00,$A3,$C9,$45,$D6
 dc.b $00,$00,$A3,$9A,$6C,$A8,$00,$00,$A3,$6B,$AE,$40,$00,$00,$A3,$3D,$0A,$86
 dc.b $00,$00,$A3,$0E,$81,$64,$00,$00,$A2,$E0,$12,$C2,$00,$00,$A2,$B1,$BE,$8B
 dc.b $00,$00,$A2,$83,$84,$A7,$00,$00,$A2,$55,$65,$01,$00,$00,$A2,$27,$5F,$81
 dc.b $00,$00,$A1,$F9,$74,$12,$00,$00,$A1,$CB,$A2,$9E,$00,$00,$A1,$9D,$EB,$0E
 dc.b $00,$00,$A1,$70,$4D,$4D,$00,$00,$A1,$42,$C9,$45,$00,$00,$A1,$15,$5E,$E0
 dc.b $00,$00,$A0,$E8,$0E,$08,$00,$00,$A0,$BA,$D6,$A8,$00,$00,$A0,$8D,$B8,$AB
 dc.b $00,$00,$A0,$60,$B3,$FA,$00,$00,$A0,$33,$C8,$82,$00,$00,$A0,$06,$F6,$2C
 dc.b $00,$00,$9F,$DA,$3C,$E4,$00,$00,$9F,$AD,$9C,$95,$00,$00,$9F,$81,$15,$29
 dc.b $00,$00,$9F,$54,$A6,$8C,$00,$00,$9F,$28,$50,$A9,$00,$00,$9E,$FC,$13,$6C
 dc.b $00,$00,$9E,$CF,$EE,$C0,$00,$00,$9E,$A3,$E2,$91,$00,$00,$9E,$77,$EE,$CA
 dc.b $00,$00,$9E,$4C,$13,$57,$00,$00,$9E,$20,$50,$23,$00,$00,$9D,$F4,$A5,$1C
 dc.b $00,$00,$9D,$C9,$12,$2C,$00,$00,$9D,$9D,$97,$40,$00,$00,$9D,$72,$34,$44
 dc.b $00,$00,$9D,$46,$E9,$25,$00,$00,$9D,$1B,$B5,$CE,$00,$00,$9C,$F0,$9A,$2B
 dc.b $00,$00,$9C,$C5,$96,$2B,$00,$00,$9C,$9A,$A9,$B8,$00,$00,$9C,$6F,$D4,$C1
 dc.b $00,$00,$9C,$45,$17,$30,$00,$00,$9C,$1A,$70,$F5,$00,$00,$9B,$EF,$E1,$FA
 dc.b $00,$00,$9B,$C5,$6A,$2E,$00,$00,$9B,$9B,$09,$7D,$00,$00,$9B,$70,$BF,$D5
 dc.b $00,$00,$9B,$46,$8D,$22,$00,$00,$9B,$1C,$71,$52,$00,$00,$9A,$F2,$6C,$53
 dc.b $00,$00,$9A,$C8,$7E,$12,$00,$00,$9A,$9E,$A6,$7D,$00,$00,$9A,$74,$E5,$81
 dc.b $00,$00,$9A,$4B,$3B,$0B,$00,$00,$9A,$21,$A7,$0A,$00,$00,$99,$F8,$29,$6C
 dc.b $00,$00,$99,$CE,$C2,$1E,$00,$00,$99,$A5,$71,$0F,$00,$00,$99,$7C,$36,$2C
 dc.b $00,$00,$99,$53,$11,$64,$00,$00,$99,$2A,$02,$A5,$00,$00,$99,$01,$09,$DD
 dc.b $00,$00,$98,$D8,$26,$FB,$00,$00,$98,$AF,$59,$ED,$00,$00,$98,$86,$A2,$A2
 dc.b $00,$00,$98,$5E,$01,$08,$00,$00,$98,$35,$75,$0E,$00,$00,$98,$0C,$FE,$A3
 dc.b $00,$00,$97,$E4,$9D,$B6,$00,$00,$97,$BC,$52,$35,$00,$00,$97,$94,$1C,$0F
 dc.b $00,$00,$97,$6B,$FB,$34,$00,$00,$97,$43,$EF,$92,$00,$00,$97,$1B,$F9,$19
 dc.b $00,$00,$96,$F4,$17,$B8,$00,$00,$96,$CC,$4B,$5F,$00,$00,$96,$A4,$93,$FC
 dc.b $00,$00,$96,$7C,$F1,$7F,$00,$00,$96,$55,$63,$D8,$00,$00,$96,$2D,$EA,$F6
 dc.b $00,$00,$96,$06,$86,$C9,$00,$00,$95,$DF,$37,$41,$00,$00,$95,$B7,$FC,$4E
 dc.b $00,$00,$95,$90,$D5,$DE,$00,$00,$95,$69,$C3,$E3,$00,$00,$95,$42,$C6,$4C
 dc.b $00,$00,$95,$1B,$DD,$09,$00,$00,$94,$F5,$08,$0A,$00,$00,$94,$CE,$47,$41
 dc.b $00,$00,$94,$A7,$9A,$9B,$00,$00,$94,$81,$02,$0B,$00,$00,$94,$5A,$7D,$81
 dc.b $00,$00,$94,$34,$0C,$EC,$00,$00,$94,$0D,$B0,$3E,$00,$00,$93,$E7,$67,$67
 dc.b $00,$00,$93,$C1,$32,$57,$00,$00,$93,$9B,$11,$00,$00,$00,$93,$75,$03,$52
 dc.b $00,$00,$93,$4F,$09,$3D,$00,$00,$93,$29,$22,$B4,$00,$00,$93,$03,$4F,$A6
 dc.b $00,$00,$92,$DD,$90,$04,$00,$00,$92,$B7,$E3,$C0,$00,$00,$92,$92,$4A,$CB
 dc.b $00,$00,$92,$6C,$C5,$17,$00,$00,$92,$47,$52,$93,$00,$00,$92,$21,$F3,$32
 dc.b $00,$00,$91,$FC,$A6,$E4,$00,$00,$91,$D7,$6D,$9C,$00,$00,$91,$B2,$47,$4B
 dc.b $00,$00,$91,$8D,$33,$E1,$00,$00,$91,$68,$33,$52,$00,$00,$91,$43,$45,$8E
 dc.b $00,$00,$91,$1E,$6A,$88,$00,$00,$90,$F9,$A2,$30,$00,$00,$90,$D4,$EC,$79
 dc.b $00,$00,$90,$B0,$49,$54,$00,$00,$90,$8B,$B8,$B4,$00,$00,$90,$67,$3A,$8A
 dc.b $00,$00,$90,$42,$CE,$C9,$00,$00,$90,$1E,$75,$63,$00,$00,$8F,$FA,$2E,$49
 dc.b $00,$00,$8F,$D5,$F9,$6E,$00,$00,$8F,$B1,$D6,$C4,$00,$00,$8F,$8D,$C6,$3E
 dc.b $00,$00,$8F,$69,$C7,$CE,$00,$00,$8F,$45,$DB,$66,$00,$00,$8F,$22,$00,$F8
 dc.b $00,$00,$8E,$FE,$38,$78,$00,$00,$8E,$DA,$81,$D8,$00,$00,$8E,$B6,$DD,$09
 dc.b $00,$00,$8E,$93,$4A,$01,$00,$00,$8E,$6F,$C8,$AF,$00,$00,$8E,$4C,$59,$09
 dc.b $00,$00,$8E,$28,$FB,$00,$00,$00,$8E,$05,$AE,$87,$00,$00,$8D,$E2,$73,$91
 dc.b $00,$00,$8D,$BF,$4A,$11,$00,$00,$8D,$9C,$31,$FB,$00,$00,$8D,$79,$2B,$41
 dc.b $00,$00,$8D,$56,$35,$D6,$00,$00,$8D,$33,$51,$AF,$00,$00,$8D,$10,$7E,$BC
 dc.b $00,$00,$8C,$ED,$BC,$F3,$00,$00,$8C,$CB,$0C,$47,$00,$00,$8C,$A8,$6C,$AA
 dc.b $00,$00,$8C,$85,$DE,$11,$00,$00,$8C,$63,$60,$6E,$00,$00,$8C,$40,$F3,$B5
 dc.b $00,$00,$8C,$1E,$97,$DB,$00,$00,$8B,$FC,$4C,$D1,$00,$00,$8B,$DA,$12,$8D
 dc.b $00,$00,$8B,$B7,$E9,$02,$00,$00,$8B,$95,$D0,$23,$00,$00,$8B,$73,$C7,$E5
 dc.b $00,$00,$8B,$51,$D0,$3A,$00,$00,$8B,$2F,$E9,$18,$00,$00,$8B,$0E,$12,$72
 dc.b $00,$00,$8A,$EC,$4C,$3C,$00,$00,$8A,$CA,$96,$6A,$00,$00,$8A,$A8,$F0,$F0
 dc.b $00,$00,$8A,$87,$5B,$C3,$00,$00,$8A,$65,$D6,$D6,$00,$00,$8A,$44,$62,$1D
 dc.b $00,$00,$8A,$22,$FD,$8E,$00,$00,$8A,$01,$A9,$1C,$00,$00,$89,$E0,$64,$BB
 dc.b $00,$00,$89,$BF,$30,$60,$00,$00,$89,$9E,$0C,$00,$00,$00,$89,$7C,$F7,$8F
 dc.b $00,$00,$89,$5B,$F3,$00,$00,$00,$89,$3A,$FE,$4A,$00,$00,$89,$1A,$19,$61
 dc.b $00,$00,$88,$F9,$44,$39,$00,$00,$88,$D8,$7E,$C6,$00,$00,$88,$B7,$C8,$FE
 dc.b $00,$00,$88,$97,$22,$D6,$00,$00,$88,$76,$8C,$42,$00,$00,$88,$56,$05,$37
 dc.b $00,$00,$88,$35,$8D,$AA,$00,$00,$88,$15,$25,$90,$00,$00,$87,$F4,$CC,$DE
 dc.b $00,$00,$87,$D4,$83,$88,$00,$00,$87,$B4,$49,$85,$00,$00,$87,$94,$1E,$C9
 dc.b $00,$00,$87,$74,$03,$49,$00,$00,$87,$53,$F6,$FB,$00,$00,$87,$33,$F9,$D3
 dc.b $00,$00,$87,$14,$0B,$C7,$00,$00,$86,$F4,$2C,$CD,$00,$00,$86,$D4,$5C,$D9
 dc.b $00,$00,$86,$B4,$9B,$E1,$00,$00,$86,$94,$E9,$DA,$00,$00,$86,$75,$46,$BB
 dc.b $00,$00,$86,$55,$B2,$77,$00,$00,$86,$36,$2D,$06,$00,$00,$86,$16,$B6,$5C
 dc.b $00,$00,$85,$F7,$4E,$6F,$00,$00,$85,$D7,$F5,$35,$00,$00,$85,$B8,$AA,$A3
 dc.b $00,$00,$85,$99,$6E,$B0,$00,$00,$85,$7A,$41,$50,$00,$00,$85,$5B,$22,$7A
 dc.b $00,$00,$85,$3C,$12,$24,$00,$00,$85,$1D,$10,$43,$00,$00,$84,$FE,$1C,$CE
 dc.b $00,$00,$84,$DF,$37,$B9,$00,$00,$84,$C0,$60,$FC,$00,$00,$84,$A1,$98,$8D
 dc.b $00,$00,$84,$82,$DE,$61,$00,$00,$84,$64,$32,$6E,$00,$00,$84,$45,$94,$AB
 dc.b $00,$00,$84,$27,$05,$0E,$00,$00,$84,$08,$83,$8D,$00,$00,$83,$EA,$10,$1D
 dc.b $00,$00,$83,$CB,$AA,$B7,$00,$00,$83,$AD,$53,$4F,$00,$00,$83,$8F,$09,$DD
 dc.b $00,$00,$83,$70,$CE,$55,$00,$00,$83,$52,$A0,$B0,$00,$00,$83,$34,$80,$E4
 dc.b $00,$00,$83,$16,$6E,$E6,$00,$00,$82,$F8,$6A,$AD,$00,$00,$82,$DA,$74,$30
 dc.b $00,$00,$82,$BC,$8B,$66,$00,$00,$82,$9E,$B0,$45,$00,$00,$82,$80,$E2,$C4
 dc.b $00,$00,$82,$63,$22,$D9,$00,$00,$82,$45,$70,$7C,$00,$00,$82,$27,$CB,$A2
 dc.b $00,$00,$82,$0A,$34,$43,$00,$00,$81,$EC,$AA,$56,$00,$00,$81,$CF,$2D,$D1
 dc.b $00,$00,$81,$B1,$BE,$AB,$00,$00,$81,$94,$5C,$DB,$00,$00,$81,$77,$08,$59
 dc.b $00,$00,$81,$59,$C1,$1A,$00,$00,$81,$3C,$87,$17,$00,$00,$81,$1F,$5A,$45
 dc.b $00,$00,$81,$02,$3A,$9D,$00,$00,$80,$E5,$28,$16,$00,$00,$80,$C8,$22,$A5
 dc.b $00,$00,$80,$AB,$2A,$43,$00,$00,$80,$8E,$3E,$E7,$00,$00,$80,$71,$60,$88
 dc.b $00,$00,$80,$54,$8F,$1E,$00,$00,$80,$37,$CA,$9F,$00,$00,$80,$1B,$13,$02
 dc.b $00,$00,$7F,$FE,$68,$40,$00,$00,$7F,$E1,$CA,$50,$00,$00,$7F,$C5,$39,$29
 dc.b $00,$00,$7F,$A8,$B4,$C2,$00,$00,$7F,$8C,$3D,$13,$00,$00,$7F,$6F,$D2,$13
 dc.b $00,$00,$7F,$53,$73,$BA,$00,$00,$7F,$37,$22,$00,$00,$00,$7F,$1A,$DC,$DC
 dc.b $00,$00,$7E,$FE,$A4,$46,$00,$00,$7E,$E2,$78,$35,$00,$00,$7E,$C6,$58,$A1
 dc.b $00,$00,$7E,$AA,$45,$82,$00,$00,$7E,$8E,$3E,$CF,$00,$00,$7E,$72,$44,$81
 dc.b $00,$00,$7E,$56,$56,$8F,$00,$00,$7E,$3A,$74,$F0,$00,$00,$7E,$1E,$9F,$9D
 dc.b $00,$00,$7E,$02,$D6,$8E,$00,$00,$7D,$E7,$19,$BA,$00,$00,$7D,$CB,$69,$19
 dc.b $00,$00,$7D,$AF,$C4,$A4,$00,$00,$7D,$94,$2C,$52,$00,$00,$7D,$78,$A0,$1C
 dc.b $00,$00,$7D,$5D,$1F,$F9,$00,$00,$7D,$41,$AB,$E1,$00,$00,$7D,$26,$43,$CD
 dc.b $00,$00,$7D,$0A,$E7,$B5,$00,$00,$7C,$EF,$97,$90,$00,$00,$7C,$D4,$53,$57
 dc.b $00,$00,$7C,$B9,$1B,$03,$00,$00,$7C,$9D,$EE,$8B,$00,$00,$7C,$82,$CD,$E8
 dc.b $00,$00,$7C,$67,$B9,$11,$00,$00,$7C,$4C,$B0,$00,$00,$00,$7C,$31,$B2,$AC
 dc.b $00,$00,$7C,$16,$C1,$0F,$00,$00,$7B,$FB,$DB,$1F,$00,$00,$7B,$E1,$00,$D7
 dc.b $00,$00,$7B,$C6,$32,$2D,$00,$00,$7B,$AB,$6F,$1C,$00,$00,$7B,$90,$B7,$9A
 dc.b $00,$00,$7B,$76,$0B,$A1,$00,$00,$7B,$5B,$6B,$29,$00,$00,$7B,$40,$D6,$2B
 dc.b $00,$00,$7B,$26,$4C,$9F,$00,$00,$7B,$0B,$CE,$7E,$00,$00,$7A,$F1,$5B,$C1
 dc.b $00,$00,$7A,$D6,$F4,$60,$00,$00,$7A,$BC,$98,$54,$00,$00,$7A,$A2,$47,$96
 dc.b $00,$00,$7A,$88,$02,$1D,$00,$00,$7A,$6D,$C7,$E5,$00,$00,$7A,$53,$98,$E3
 dc.b $00,$00,$7A,$39,$75,$13,$00,$00,$7A,$1F,$5C,$6C,$00,$00,$7A,$05,$4E,$E8
 dc.b $00,$00,$79,$EB,$4C,$7F,$00,$00,$79,$D1,$55,$2A,$00,$00,$79,$B7,$68,$E2
 dc.b $00,$00,$79,$9D,$87,$A1,$00,$00,$79,$83,$B1,$5E,$00,$00,$79,$69,$E6,$13
 dc.b $00,$00,$79,$50,$25,$BA,$00,$00,$79,$36,$70,$4B,$00,$00,$79,$1C,$C5,$BE
 dc.b $00,$00,$79,$03,$26,$0E,$00,$00,$78,$E9,$91,$34,$00,$00,$78,$D0,$07,$28
 dc.b $00,$00,$78,$B6,$87,$E3,$00,$00,$78,$9D,$13,$60,$00,$00,$78,$83,$A9,$96
 dc.b $00,$00,$78,$6A,$4A,$80,$00,$00,$78,$50,$F6,$16,$00,$00,$78,$37,$AC,$52
 dc.b $00,$00,$78,$1E,$6D,$2D,$00,$00,$78,$05,$38,$A1,$00,$00,$77,$EC,$0E,$A6
 dc.b $00,$00,$77,$D2,$EF,$37,$00,$00,$77,$B9,$DA,$4C,$00,$00,$77,$A0,$CF,$DE
 dc.b $00,$00,$77,$87,$CF,$E9,$00,$00,$77,$6E,$DA,$63,$00,$00,$77,$55,$EF,$48
 dc.b $00,$00,$77,$3D,$0E,$91,$00,$00,$77,$24,$38,$37,$00,$00,$77,$0B,$6C,$34
 dc.b $00,$00,$76,$F2,$AA,$80,$00,$00,$76,$D9,$F3,$17,$00,$00,$76,$C1,$45,$F1
 dc.b $00,$00,$76,$A8,$A3,$09,$00,$00,$76,$90,$0A,$57,$00,$00,$76,$77,$7B,$D5
 dc.b $00,$00,$76,$5E,$F7,$7D,$00,$00,$76,$46,$7D,$49,$00,$00,$76,$2E,$0D,$33
 dc.b $00,$00,$76,$15,$A7,$33,$00,$00,$75,$FD,$4B,$45,$00,$00,$75,$E4,$F9,$61
 dc.b $00,$00,$75,$CC,$B1,$81,$00,$00,$75,$B4,$73,$A0,$00,$00,$75,$9C,$3F,$B8
 dc.b $00,$00,$75,$84,$15,$C1,$00,$00,$75,$6B,$F5,$B6,$00,$00,$75,$53,$DF,$90
 dc.b $00,$00,$75,$3B,$D3,$4B,$00,$00,$75,$23,$D0,$DF,$00,$00,$75,$0B,$D8,$46
 dc.b $00,$00,$74,$F3,$E9,$7B,$00,$00,$74,$DC,$04,$78,$00,$00,$74,$C4,$29,$36
 dc.b $00,$00,$74,$AC,$57,$B0,$00,$00,$74,$94,$8F,$DF,$00,$00,$74,$7C,$D1,$BE
 dc.b $00,$00,$74,$65,$1D,$47,$00,$00,$74,$4D,$72,$74,$00,$00,$74,$35,$D1,$3E
 dc.b $00,$00,$74,$1E,$39,$A1,$00,$00,$74,$06,$AB,$96,$00,$00,$73,$EF,$27,$18
 dc.b $00,$00,$73,$D7,$AC,$20,$00,$00,$73,$C0,$3A,$A9,$00,$00,$73,$A8,$D2,$AE
 dc.b $00,$00,$73,$91,$74,$28,$00,$00,$73,$7A,$1F,$11,$00,$00,$73,$62,$D3,$64
 dc.b $00,$00,$73,$4B,$91,$1C,$00,$00,$73,$34,$58,$32,$00,$00,$73,$1D,$28,$A1
 dc.b $00,$00,$73,$06,$02,$63,$00,$00,$72,$EE,$E5,$73,$00,$00,$72,$D7,$D1,$CB
 dc.b $00,$00,$72,$C0,$C7,$66,$00,$00,$72,$A9,$C6,$3D,$00,$00,$72,$92,$CE,$4C
 dc.b $00,$00,$72,$7B,$DF,$8D,$00,$00,$72,$64,$F9,$FA
