; *** DSP_MOD32 by bITmASTER (with NoCrew-Fix) ***
; *** Tetrax-Adaption made by Thothy ***

	.text

;*********************************
;*** A new cookie jar function ***
;*********************************
.globl _xgetcookie
_xgetcookie:
	move.l	4(sp),xgc_val
	move.l	8(sp),xgc_ptr
	movem.l	d1-d2/a1-a2,-(sp)

	clr.l	-(sp)
	move.l	xgc_val,-(sp)
	move.w	#8,-(sp)
	move.w	#$0154,-(sp)	; Ssystem(GETCOOKIE)
	trap	#1
	lea 	$0c(sp),sp
	cmp.l	#-32,d0			; Does Ssystem exist at all?
	beq.s	xgc_oldway
	cmp.l	#-1,d0
	beq.s	xgcnocookie
	move.l	xgc_ptr,a1
	move.l	d0,(a1)
	moveq	#1,d0
	bra.s	xgcret
xgcnocookie:
	moveq	#0,d0
xgcret:
	movem.l	(sp)+,d1-d2/a1-a2
	rts
xgc_oldway:
	pea 	hunt_cookie
	move.w	#38,-(sp)
	trap	#14
	addq.l	#6,sp
	bra.s	xgcret
hunt_cookie:
	move.l	$05A0,D0
	beq.s   cookie_ex
	movea.l	d0,a0
	move.l	xgc_val,d1
cookie_l:
	move.l	(a0)+,d2
	move.l	(a0)+,d3
	cmp.l	d1,d2
	beq.s	cookie_fnd
	tst.l	d2
	bne.s	cookie_l
cookie_ex:
	moveq	#0,d0
	rts
cookie_fnd:
	move.l	xgc_ptr,d0
	tst.l	d0
	beq.s	xhcnoptr
	move.l	d0,a0
	move.l	d3,(a0)
xhcnoptr:
	moveq   #1,d0
	rts


;************************
;*** Init the player: ***
;************************
.globl	_mod_init
_mod_init:
	movem.l	d1-d2/a0-a2,-(sp)
	clr.l	snd_cookie
	pea 	snd_cookie
	move.l	#$5F534E44,-(sp)	; '_SND' Cookie
	bsr 	_xgetcookie
	addq.l	#8,sp
	tst.l	d0
	beq.s	mainfail
	move.l	snd_cookie,d0
	tst.w	d0
	and.b	#$1E,d0
	cmp.b	#$1E,d0
	beq 	hwokay
mainfail:
	moveq	#-1,d0
	movem.l (sp)+,d1-d2/a0-a2
	rts
hwokay:
	move.w	#0,-(sp)				;mxalloc() - reserve stram only
	move.l	#8000,-(sp)				;for dma playbuffer
	move.w	#$44,-(sp)
	trap	#1
	addq.l	#8,sp
	tst.l	d0						;check if there is stram enough
	beq.s	mainfail				;nope
	bmi.s	mainfail
	move.l	d0,dm_dmabuf			;store address of stram buffer

	moveq	#0,d0
	movem.l (sp)+,d1-d2/a0-a2
	rts


; Check cookie for Falcon Hardware
checkcookie:
	move.l	$05a0,d0		; get cookie jar ptr
	beq 	no_falcsnd		; nul ptr = no cookie jar
	movea.l	d0,a0			; (no cookie jar= no dsp sound)
search_next:
	tst.l	(a0)
	beq 	no_falcsnd
	cmpi.l	#$5F534E44,(a0)	; '_SND' cookie found?
	beq 	search_found
	addq.l	#8,a0
	bra 	search_next
search_found:
	move.l	4(a0),d0		; get _SND const.
	and.b	#$1E,d0
	cmp.b	#$1E,d0
	bne 	no_falcsnd
	move.w	#0,d0			; FALCON SOUND HARDWARE FOUND!
	rts
no_falcsnd:
	move.w	#-1,d0			; NO FALCON SOUND HARDWARE!
	rts


;**************************************************
;*** Play a module, Address of mod on the stack ***
;**************************************************
.globl _mod_play
_mod_play:
	move.l	4(sp),modaddr
	tst.w	_playflag
	beq.s	mp1
	bsr 	_mod_stop
mp1:
	movem.l	d1-a6,-(sp)
	move.w	#128,-(sp)
	trap	#14						; Locksnd()
	addq.l	#2,sp
	cmp.w	#1,d0
	bne 	mperr

	pea 	mpinit(pc)
	move.w	#$26,-(sp)
	trap	#14						; Supexec
	addq.l	#6,sp

	tst.w	_playflag
	beq.s	mp2

	moveq	#0,d0
	movem.l	(sp)+,d1-a6
	rts
mp2:
	move.w	#129,-(sp)
	trap	#14						; Unlocksnd()
	addq.l	#2,sp
mperr:
	moveq	#-1,d0
	movem.l	(sp)+,d1-a6
	rts

mpinit:
	movea.l	$456,a0					; VBL-Queue
	addq.l	#4,a0
	move.w	$454,d0
	subq.w	#2,d0
such:
	move.l	(a0)+,d1
	beq.s	eintrag
	dbra	d0,such
	move.w	#0,_playflag
	rts
eintrag:
	subq.l	#4,a0
	move.l	a0,vbllstentr
	bsr 	dm_start				;init dspmod
	bsr 	dm_play_module			;start player
	move.l	vbllstentr,a0
	move.l	#dm_vbl,(a0)			;install our vbl	

	move.w	#1,_playflag
	rts


;****************************
;*** Stop Playing the mod ***
;****************************
.globl _mod_stop
_mod_stop:
	tst.w	_playflag
	beq.s	msret

	movem.l	d1-a6,-(sp)

	move.w	#0,_playflag
	pea 	off
	move.w	#$26,-(sp)
	trap	#14						; Supexec
	addq.l	#6,sp

	move.w	#129,-(sp)
	trap	#14						; Unlocksnd()
	addq.l	#2,sp

	movem.l	(sp)+,d1-a6
msret:
	rts

off:
	move.l	vbllstentr,a0
	clr.l	(a0)					; Stop our VBL
	bsr 	dm_stop					; stop player and restore dsp
	rts

;***********************
;**** Fast backward **** 
;***********************
.globl _mod_backward
_mod_backward:
	rts

;**********************
;**** Fast forward **** 
;**********************
.globl _mod_forward
_mod_forward:
	rts

;******************************
;**** Configure the player **** 
;******************************
.globl _mod_setup
_mod_setup:
	rts

; ** Polling mode: Check if the end of a buffer has been reached **
.globl _checkbuf
_checkbuf:
	rts



; This player is extremly flexible in the matter of 
; interval between the calls to it.
;
; I have tried with vbl freqs of 50 to 100 Hz
; and all modules seems to work well in all vbl-freqs.
;
; You can also replace the vbl with a timer if
; you would prefer that.
;
; Keep coding!
; 
; Anders Eriksson - ae@atari.org - http://dhs.atari.org

dm_init		equ 28
dm_off		equ 32
dm_playeron	equ 36
dm_playeroff	equ 40
dm_playmusic	equ 44
dm_playtime	equ 48
dm_modtype	equ 52
dm_fx		equ 56
dm_not_used		equ 60
dm_flags		equ 61
dm_surrounddelay	equ 62
dm_dsptracks	equ 64
dm_playinfos	equ 66
dm_samplesets	equ 70



dm_play_module:

		move.l	modaddr,a0				;address to module
		lea.l	dm_voltab4,a1			;4channel volumetable
		bsr 	dm_player+dm_modtype	;check mod type
		cmp.w	#4,d0					;if 4, start module
		beq.s	four					;
		lea.l	dm_voltab8,a1			;otherwise, use 8channel table
four:
		move.l	modaddr,a0				;address to module
		bsr 	dm_player+dm_playeron	;start playing

        ;bchg    #0,dm_player+dspmodflags		;toggle surround on/off
        ;bchg    #1,dm_player+dspmodflags		;toggle interpolation on/off

		rts


dm_vbl:
		bsr 	dm_player+44			;call player
		rts


dm_start:
		lea 	oldhregs,a0
		move.w	$ffff8932,(a0)+
		move.b	$ffff8900,(a0)+
		move.b	$ffff8936,(a0)+
		move.b	$ffff8921,(a0)+

		bsr 	dm_player+dm_init 		;install Player

		move.w	#$200b,$ffff8932 		;DSP-Out-> DAC & DMA-In
		clr.b	$ffff8900     			;no DMA-Interrupts
		clr.b	$ffff8936     			;record 1 Track
		move.b	#$40,$ffff8921 			;16 Bit

		move.b	#$80,$ffff8901 			;select Record-Frame-Register
		move.l	dm_dmabuf,-(sp)
		move.b	3(sp),$ffff8907	 		;Basis Low
		move.b	2(sp),$ffff8905			;Basis Mid
		move.b	1(sp),$ffff8903			;Basis High
		add.l	#8000,(sp)
		move.b	3(sp),$ffff8913			;End Low
		move.b	2(sp),$ffff8911	  		;End Mid
		move.b	1(sp),$ffff890f			;End High
		addq.l	#4,sp

		move.b	#$b0,$ffff8901 			;repeated record

		rts


dm_stop:
		clr.b	$ffff8901     			;DMA-Stop
		bsr 	dm_player+dm_playeroff	;stop module
		bsr 	dm_player+dm_off		;dsp system off
		bsr.s	dm_fix				;load new dsp bootstrap (bugfix)

		lea 	oldhregs,a0
		move.w	(a0)+,$ffff8932
		move.b	(a0)+,$ffff8900
		move.b	(a0)+,$ffff8936
		move.b	(a0)+,$ffff8921
		rts


; NoCrew DSP-Bootstrapcode fix:

dm_fix:
;;
;; COPYRIGHT (c) 1998 by NoCrew Laboratories.
;;
;; Implements:
;;
;;     extern Int dsp_load_program(Byte *program, Int length);
;;
;; Where length is the number of DSP words (e.i. 3 byte tuples).
;; A return value of 1 means that the loading was sucessful. 0
;; means something went wrong.
;;
;; This module will always load the DSP program. It is compatible
;; with the Dsp_ExecProg loader. However, as it reloads the DSP
;; bootstrap code every time -- which the TOS version does not --
;; this one does not freeze up.

	
dm_dsp_load_program:
		move.l	a0,dm_dsp_program
		move.l	d0,dm_dsp_length

		;Test for supervisor mode.
		move	sr,d0
		btst	#13,d0
		bne.s	dm_dsp_load
	
		move.l	#dm_dsp_load,-(sp)
		move.w	#$26,-(sp)
		trap	#14
		addq.w	#6,sp

		move.l	dm_dsp_status,d0
		rts

dm_dsp_load:	
		bsr	dm_dsp_reset
		bsr	dm_dsp_go
		move.l	d0,dm_dsp_status
		rts

dm_dsp_reset:	;Power down.
		move.b	#$e,$ffff8800
		move.b	$ffff8800,d0
		and.b	#$ef,d0
		move.b	d0,$ffff8802
		or.b	#$10,d0
		move.b	d0,$ffff8802

		;Wait for DSP to power down.
		move.w	#10000-1,d0
dm_wait:		nop
		dbra	d0,dm_wait

		;Power up.
		move.b	#$e,$ffff8800
		move.b	$ffff8800,d0
		and.b	#$ef,d0
		move.b	d0,$ffff8802
		rts

dm_dsp_go:
		;Load system startup code.
		lea	dm_dsp_bootstrap_code,a0
		move.w	#512-1,d0
dm_next:		btst.b	#1,$ffffa202
		beq.s	dm_next
		move.b	(a0)+,$ffffa205
		move.b	(a0)+,$ffffa206
		move.b	(a0)+,$ffffa207
		dbra	d0,dm_next
		rts


		;Load DSP binary
;		move.l	dsp_program,a0
;		move.l	dsp_length,d0
;		subq.w	#1,d0
;		bmi.s	no_way
;copy:		btst.b	#1,$ffffa202.w
;		beq.s	copy
;		move.b	(a0)+,$ffffa205.w
;		move.b	(a0)+,$ffffa206.w
;		move.b	(a0)+,$ffffa207.w
;		dbra	d0,copy
;
;		;Launch DSP binary
;go:		btst.b	#1,$ffffa202.w
;		beq.s	go
;		move.l	#3,$ffffa204.w
;	
;		moveq	#1,d0
;		rts
;no_way:	moveq	#0,d0
;		rts

; End of NoCrew DSP-Bootstrapcode fix




dm_player:
 dc.b $60,$1A,$00,$00,$12,$94,$00,$00,$1A,$C2,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$01,$00,$00,$60,$00,$01,$0C,$60,$00,$01,$72
 dc.b $60,$00,$01,$9A,$60,$00,$01,$D6,$60,$00,$01,$E6,$60,$00,$05,$72,$60,$00
 dc.b $04,$66,$60,$00,$03,$76,$00,$00,$08,$00,$00,$04,$00,$00,$28,$90,$00,$00
 dc.b $13,$42,$2A,$20,$20,$44,$53,$50,$2D,$50,$72,$6F,$74,$72,$61,$63,$6B,$65
 dc.b $72,$20,$33,$2E,$30,$20,$52,$65,$70,$6C,$61,$79,$20,$20,$20,$2A,$2A,$20
 dc.b $63,$6F,$64,$65,$72,$69,$67,$68,$74,$20,$62,$79,$20,$62,$49,$54,$6D,$41
 dc.b $53,$54,$45,$52,$20,$6F,$66,$20,$54,$43,$45,$2A,$2A,$20,$53,$74,$65,$66
 dc.b $66,$65,$6E,$20,$53,$63,$68,$61,$72,$66,$65,$20,$20,$20,$20,$20,$20,$20
 dc.b $20,$20,$20,$20,$20,$20,$20,$2A,$2A,$20,$20,$53,$61,$63,$68,$73,$65,$6E
 dc.b $62,$75,$72,$67,$77,$65,$67,$20,$36,$20,$20,$20,$20,$20,$20,$20,$20,$20
 dc.b $20,$20,$20,$2A,$2A,$20,$20,$20,$44,$2D,$39,$39,$30,$39,$34,$20,$45,$72
 dc.b $66,$75,$72,$74,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$2A
 dc.b $2A,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$65,$4D,$61,$69,$6C
 dc.b $3A,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$20,$2A,$2A,$20,$53,$74
 dc.b $65,$66,$66,$65,$6E,$20,$53,$63,$68,$61,$72,$66,$65,$20,$40,$48,$52,$4F
 dc.b $2E,$6D,$61,$75,$73,$2E,$64,$65,$20,$2A,$48,$E7,$FF,$FE,$61,$00,$04,$24
 dc.b $61,$00,$10,$AE,$30,$3C,$03,$D8,$33,$C0,$00,$00,$12,$AC,$33,$C0,$00,$00
 dc.b $12,$AE,$42,$39,$00,$00,$12,$AA,$61,$00,$03,$8C,$61,$00,$03,$D2,$41,$F8
 dc.b $89,$30,$23,$D0,$00,$00,$12,$9E,$33,$E8,$00,$04,$00,$00,$12,$A2,$33,$E8
 dc.b $00,$06,$00,$00,$12,$A4,$23,$E8,$00,$08,$00,$00,$12,$A6,$20,$BC,$00,$90
 dc.b $20,$00,$31,$7C,$01,$01,$00,$04,$31,$7C,$00,$02,$00,$06,$4C,$DF,$7F,$FF
 dc.b $41,$F9,$00,$00,$2D,$3E,$4E,$75,$48,$E7,$FF,$FE,$41,$F8,$89,$30,$20,$B9
 dc.b $00,$00,$12,$9E,$31,$79,$00,$00,$12,$A2,$00,$04,$31,$79,$00,$00,$12,$A4
 dc.b $00,$06,$21,$79,$00,$00,$12,$A6,$00,$08,$4C,$DF,$7F,$FF,$4E,$75,$48,$E7
 dc.b $FF,$FE,$23,$C8,$00,$00,$12,$B6,$41,$FA,$11,$92,$70,$07,$31,$59,$00,$18
 dc.b $D0,$FC,$00,$1C,$51,$C8,$FF,$F6,$61,$00,$0F,$C8,$61,$00,$02,$02,$30,$3C
 dc.b $03,$D8,$33,$C0,$00,$00,$12,$AC,$33,$C0,$00,$00,$12,$AE,$50,$F9,$00,$00
 dc.b $12,$AA,$4C,$DF,$7F,$FF,$4E,$75,$48,$E7,$FF,$FE,$42,$39,$00,$00,$12,$AA
 dc.b $61,$00,$02,$CE,$4C,$DF,$7F,$FF,$4E,$75,$4B,$F8,$A2,$06,$1B,$79,$00,$00
 dc.b $00,$21,$FF,$FF,$3A,$B9,$00,$00,$00,$22,$3A,$B9,$00,$00,$00,$24,$70,$00
 dc.b $08,$2D,$00,$00,$FF,$FC,$67,$F8,$33,$D5,$00,$00,$12,$B0,$30,$3A,$10,$8E
 dc.b $B0,$7A,$10,$88,$62,$2A,$33,$C0,$00,$00,$12,$B4,$61,$42,$2B,$7C,$00,$00
 dc.b $00,$01,$FF,$FE,$30,$3A,$10,$74,$91,$79,$00,$00,$12,$AE,$66,$0C,$61,$00
 dc.b $04,$60,$33,$FA,$10,$60,$00,$00,$12,$AE,$4E,$75,$30,$3A,$10,$58,$33,$C0
 dc.b $00,$00,$12,$B4,$91,$79,$00,$00,$12,$B0,$61,$0E,$61,$00,$04,$40,$33,$FA
 dc.b $10,$40,$00,$00,$12,$AE,$60,$AC,$41,$FA,$11,$AC,$43,$FA,$10,$C8,$4B,$F8
 dc.b $A2,$06,$42,$AD,$FF,$FE,$3C,$39,$00,$00,$00,$24,$53,$46,$30,$29,$00,$14
 dc.b $47,$F0,$04,$00,$20,$13,$4C,$3A,$04,$05,$10,$18,$28,$45,$56,$8C,$4C,$D1
 dc.b $00,$1E,$2C,$42,$9D,$C1,$B9,$CE,$63,$3C,$99,$CE,$3E,$0E,$24,$41,$61,$00
 dc.b $00,$C6,$B8,$BC,$00,$00,$00,$02,$67,$10,$B9,$C4,$65,$02,$28,$44,$3E,$0C
 dc.b $24,$43,$61,$00,$00,$B0,$60,$26,$42,$2D,$FF,$FF,$3A,$BC,$00,$02,$08,$2D
 dc.b $00,$01,$FF,$FC,$67,$F8,$3A,$BC,$00,$00,$3A,$BC,$00,$00,$60,$0C,$3E,$0C
 dc.b $24,$41,$61,$00,$00,$8C,$42,$AD,$FF,$FE,$4E,$71,$4E,$71,$4E,$71,$42,$2D
 dc.b $FF,$FF,$3A,$BA,$0F,$B4,$4E,$71,$4E,$71,$4E,$71,$1B,$69,$00,$17,$FF,$FF
 dc.b $42,$55,$4E,$71,$4E,$71,$4E,$71,$3B,$69,$00,$18,$FF,$FF,$42,$2D,$00,$01
 dc.b $4E,$71,$4E,$71,$4E,$71,$1B,$69,$00,$1B,$FF,$FF,$42,$55,$4E,$71,$4E,$71
 dc.b $4E,$71,$3B,$5B,$FF,$FF,$1B,$53,$00,$01,$4E,$71,$4E,$71,$4E,$71,$3B,$69
 dc.b $00,$10,$FF,$FF,$1B,$69,$00,$12,$00,$01,$D1,$A9,$00,$10,$D3,$85,$20,$01
 dc.b $90,$82,$63,$14,$B8,$BC,$00,$00,$00,$02,$66,$04,$22,$02,$60,$08,$22,$03
 dc.b $4C,$44,$00,$05,$D2,$85,$22,$81,$D2,$FC,$00,$1C,$51,$CE,$FF,$16,$4E,$75
 dc.b $42,$2D,$FF,$FF,$3A,$87,$67,$F6,$08,$2D,$00,$01,$FF,$FC,$67,$F8,$E2,$4F
 dc.b $3A,$9A,$51,$CF,$FF,$FC,$4E,$75,$48,$E7,$80,$08,$49,$F9,$00,$00,$13,$B2
 dc.b $C0,$FC,$00,$1C,$D8,$C0,$28,$88,$29,$49,$00,$04,$29,$4A,$00,$08,$29,$4B
 dc.b $00,$0C,$39,$41,$00,$14,$39,$42,$00,$16,$39,$43,$00,$1A,$42,$AC,$00,$10
 dc.b $4C,$DF,$10,$01,$4E,$75,$20,$79,$00,$00,$12,$B6,$43,$E8,$03,$B6,$45,$E9
 dc.b $00,$86,$72,$1E,$76,$01,$61,$00,$00,$A4,$4A,$40,$66,$0E,$43,$E8,$01,$D6
 dc.b $45,$E9,$00,$82,$70,$04,$72,$0E,$76,$00,$23,$C9,$00,$00,$12,$BA,$23,$CA
 dc.b $00,$00,$12,$BE,$33,$C0,$00,$00,$12,$C4,$33,$C0,$00,$00,$00,$24,$33,$C1
 dc.b $00,$00,$12,$C2,$22,$79,$00,$00,$12,$BA,$24,$49,$54,$89,$70,$7F,$72,$00
 dc.b $14,$19,$B2,$02,$64,$02,$12,$02,$51,$C8,$FF,$F6,$B2,$2A,$00,$01,$64,$04
 dc.b $42,$2A,$00,$01,$52,$41,$30,$39,$00,$00,$12,$C4,$E1,$48,$C2,$C0,$22,$79
 dc.b $00,$00,$12,$BE,$43,$F1,$18,$00,$D0,$FC,$00,$2A,$45,$F9,$00,$00,$12,$C6
 dc.b $30,$39,$00,$00,$12,$C2,$24,$C9,$72,$00,$32,$10,$D2,$81,$D3,$C1,$4A,$68
 dc.b $00,$06,$66,$06,$31,$7C,$00,$01,$00,$06,$4A,$43,$66,$04,$E2,$E8,$00,$04
 dc.b $D0,$FC,$00,$1E,$51,$C8,$FF,$DC,$4E,$75,$48,$E7,$40,$40,$43,$FA,$00,$16
 dc.b $70,$00,$22,$19,$67,$08,$30,$19,$B2,$A8,$04,$38,$66,$F2,$4C,$DF,$02,$02
 dc.b $4E,$75,$4D,$2E,$4B,$2E,$00,$04,$46,$4C,$54,$34,$00,$04,$43,$44,$38,$20
 dc.b $00,$08,$43,$44,$38,$31,$00,$08,$46,$41,$30,$38,$00,$08,$00,$00,$00,$00
 dc.b $41,$F9,$00,$00,$12,$9E,$43,$F9,$00,$00,$13,$42,$45,$F9,$00,$00,$12,$94
 dc.b $70,$07,$22,$88,$23,$48,$00,$04,$42,$A9,$00,$08,$23,$7C,$00,$00,$00,$02
 dc.b $00,$0C,$42,$A9,$00,$10,$33,$7C,$03,$20,$00,$14,$42,$69,$00,$16,$42,$69
 dc.b $00,$18,$72,$00,$12,$1A,$33,$41,$00,$1A,$D2,$FC,$00,$1C,$51,$C8,$FF,$CE
 dc.b $4E,$75,$41,$F9,$00,$00,$14,$22,$30,$3C,$00,$4F,$42,$98,$51,$C8,$FF,$FC
 dc.b $30,$3C,$03,$3D,$72,$50,$24,$3C,$24,$66,$52,$68,$76,$09,$28,$02,$4C,$41
 dc.b $40,$04,$E7,$AC,$20,$C4,$52,$81,$51,$C8,$FF,$F2,$4E,$75,$48,$E7,$C0,$E0
 dc.b $4A,$3A,$0D,$6D,$66,$40,$41,$FA,$FA,$A0,$20,$28,$00,$02,$D0,$A8,$00,$06
 dc.b $D0,$A8,$00,$0E,$D0,$FC,$00,$1C,$22,$08,$22,$48,$24,$49,$D3,$C0,$20,$19
 dc.b $D5,$C0,$D3,$92,$42,$80,$10,$19,$67,$12,$B0,$3C,$00,$01,$67,$06,$D5,$C0
 dc.b $D3,$92,$60,$F0,$D4,$FC,$00,$FE,$60,$EA,$41,$FA,$0D,$2D,$50,$D0,$4C,$DF
 dc.b $07,$03,$4E,$75,$48,$E7,$7F,$FE,$45,$E8,$03,$B6,$47,$EA,$00,$86,$61,$00
 dc.b $FE,$EA,$4A,$40,$66,$0A,$70,$04,$45,$E8,$01,$D6,$47,$EA,$00,$82,$32,$00
 dc.b $53,$40,$33,$C0,$00,$00,$22,$5A,$E1,$49,$33,$C1,$00,$00,$22,$5C,$20,$4A
 dc.b $70,$00,$7E,$00,$72,$06,$74,$00,$34,$7C,$4E,$20,$76,$00,$16,$30,$00,$02
 dc.b $C6,$F9,$00,$00,$22,$5C,$22,$4B,$D3,$C3,$76,$00,$28,$0A,$4C,$01,$40,$00
 dc.b $D4,$84,$38,$39,$00,$00,$22,$5A,$2A,$31,$30,$00,$3C,$05,$CA,$7C,$0F,$00
 dc.b $BA,$7C,$0B,$00,$67,$5E,$BA,$7C,$0D,$00,$67,$62,$BA,$7C,$0F,$00,$67,$00
 dc.b $00,$84,$58,$43,$51,$CC,$FF,$DE,$B6,$79,$00,$00,$22,$5C,$66,$C6,$B0,$47
 dc.b $65,$08,$3E,$00,$52,$40,$B0,$10,$65,$A8,$4C,$7C,$20,$02,$00,$0F,$42,$40
 dc.b $84,$FC,$00,$3C,$30,$02,$48,$C0,$80,$FC,$00,$0A,$22,$00,$48,$41,$E9,$48
 dc.b $80,$41,$E1,$48,$48,$42,$48,$C2,$84,$FC,$00,$0A,$22,$02,$48,$41,$E9,$4A
 dc.b $84,$41,$80,$42,$4C,$DF,$7F,$FE,$4E,$75,$CC,$7C,$00,$FF,$30,$06,$60,$00
 dc.b $FF,$6A,$52,$40,$B0,$10,$67,$BA,$76,$00,$16,$30,$00,$02,$C6,$F9,$00,$00
 dc.b $22,$5C,$22,$4B,$D3,$C3,$CC,$7C,$00,$FF,$CC,$F9,$00,$00,$22,$5A,$E5,$4E
 dc.b $36,$06,$60,$00,$FF,$44,$CC,$BC,$00,$00,$00,$FF,$BC,$7C,$00,$20,$64,$06
 dc.b $32,$06,$60,$00,$FF,$6E,$2A,$3C,$00,$26,$25,$A0,$4C,$46,$50,$05,$24,$45
 dc.b $60,$00,$FF,$5E,$4A,$39,$00,$00,$12,$AA,$67,$52,$20,$79,$00,$00,$12,$B6
 dc.b $52,$79,$00,$00,$28,$90,$30,$3A,$21,$D2,$B0,$7A,$21,$D0,$65,$14,$42,$79
 dc.b $00,$00,$28,$90,$4A,$39,$00,$00,$28,$A0,$67,$30,$61,$0A,$60,$00,$00,$8C
 dc.b $61,$04,$60,$00,$01,$2E,$3C,$39,$00,$00,$12,$C4,$53,$46,$4D,$FA,$20,$46
 dc.b $4B,$F9,$00,$00,$13,$42,$61,$00,$02,$D6,$DC,$FC,$00,$2C,$DA,$FC,$00,$1C
 dc.b $51,$CE,$FF,$F2,$4E,$75,$47,$E8,$00,$0C,$20,$79,$00,$00,$12,$BE,$72,$00
 dc.b $24,$79,$00,$00,$12,$BA,$30,$3A,$21,$7E,$12,$32,$00,$02,$E1,$89,$E5,$89
 dc.b $0C,$79,$00,$08,$00,$00,$12,$C4,$66,$02,$E3,$89,$30,$3A,$21,$64,$48,$C0
 dc.b $D2,$80,$7C,$00,$4B,$F9,$00,$00,$13,$42,$4D,$FA,$1F,$F0,$34,$06,$61,$00
 dc.b $00,$D0,$70,$00,$10,$2E,$00,$13,$3B,$40,$00,$16,$DA,$FC,$00,$1C,$DC,$FC
 dc.b $00,$2C,$52,$46,$BC,$79,$00,$00,$12,$C4,$66,$DE,$32,$39,$00,$00,$12,$C4
 dc.b $E5,$49,$D3,$79,$00,$00,$28,$94,$10,$39,$00,$00,$28,$9F,$67,$0C,$13,$C0
 dc.b $00,$00,$28,$A0,$42,$39,$00,$00,$28,$9F,$4A,$39,$00,$00,$28,$A0,$67,$0E
 dc.b $53,$39,$00,$00,$28,$A0,$67,$06,$93,$79,$00,$00,$28,$94,$4A,$39,$00,$00
 dc.b $28,$9D,$67,$1A,$51,$F9,$00,$00,$28,$9D,$70,$00,$10,$3A,$20,$ED,$C0,$C1
 dc.b $33,$C0,$00,$00,$28,$94,$42,$39,$00,$00,$28,$9B,$34,$01,$ED,$4A,$B4,$79
 dc.b $00,$00,$28,$94,$66,$42,$70,$00,$10,$3A,$20,$CD,$C0,$C1,$33,$C0,$00,$00
 dc.b $28,$94,$42,$39,$00,$00,$28,$9B,$42,$39,$00,$00,$28,$9C,$52,$79,$00,$00
 dc.b $28,$96,$02,$79,$00,$7F,$00,$00,$28,$96,$32,$3A,$20,$A2,$20,$79,$00,$00
 dc.b $12,$BA,$B2,$10,$65,$0C,$72,$00,$12,$28,$00,$01,$33,$C1,$00,$00,$28,$96
 dc.b $4A,$39,$00,$00,$28,$9C,$66,$B6,$4E,$75,$4A,$96,$66,$04,$61,$00,$02,$26
 dc.b $2C,$B0,$18,$00,$58,$81,$05,$39,$00,$00,$28,$98,$67,$00,$02,$14,$74,$00
 dc.b $14,$2E,$00,$02,$C4,$3C,$00,$F0,$E8,$0A,$10,$16,$C0,$3C,$00,$F0,$84,$00
 dc.b $4A,$02,$67,$00,$00,$86,$76,$00,$43,$F9,$00,$00,$12,$C6,$38,$02,$1D,$42
 dc.b $00,$2B,$53,$82,$E5,$8A,$C8,$FC,$00,$1E,$2D,$71,$28,$00,$00,$04,$3D,$73
 dc.b $48,$00,$00,$08,$3D,$73,$48,$00,$00,$28,$1D,$73,$48,$02,$00,$12,$1D,$73
 dc.b $48,$03,$00,$13,$36,$33,$48,$04,$67,$38,$24,$2E,$00,$04,$E3,$43,$D4,$83
 dc.b $2D,$42,$00,$0A,$2D,$42,$00,$24,$4C,$B3,$00,$05,$48,$04,$D0,$42,$36,$2E
 dc.b $00,$28,$B0,$43,$63,$0E,$3D,$43,$00,$08,$90,$43,$94,$40,$3D,$42,$00,$0E
 dc.b $60,$1C,$3D,$40,$00,$08,$3D,$42,$00,$0E,$60,$12,$24,$2E,$00,$04,$2D,$42
 dc.b $00,$0A,$2D,$42,$00,$24,$3D,$73,$48,$06,$00,$0E,$30,$16,$C0,$7C,$0F,$FF
 dc.b $67,$00,$05,$B4,$30,$2E,$00,$02,$C0,$7C,$0F,$F0,$B0,$7C,$0E,$50,$67,$20
 dc.b $10,$2E,$00,$02,$C0,$3C,$00,$0F,$B0,$3C,$00,$03,$67,$18,$B0,$3C,$00,$05
 dc.b $67,$12,$B0,$3C,$00,$09,$66,$14,$61,$00,$05,$88,$60,$0E,$61,$00,$06,$6E
 dc.b $60,$08,$61,$00,$02,$42,$60,$00,$05,$78,$48,$E7,$C0,$C0,$32,$16,$C2,$7C
 dc.b $0F,$FF,$43,$FA,$19,$72,$70,$00,$7E,$24,$B2,$71,$00,$00,$64,$06,$54,$80
 dc.b $51,$CF,$FF,$F6,$72,$00,$12,$2E,$00,$12,$C2,$FC,$00,$4A,$D3,$C1,$3D,$71
 dc.b $00,$00,$00,$10,$4C,$DF,$03,$03,$30,$2E,$00,$02,$C0,$7C,$0F,$F0,$B0,$7C
 dc.b $0E,$D0,$67,$00,$05,$34,$08,$2E,$00,$02,$00,$1E,$66,$04,$42,$2E,$00,$1B
 dc.b $08,$2E,$00,$06,$00,$1E,$66,$04,$42,$2E,$00,$1D,$42,$AD,$00,$10,$20,$2E
 dc.b $00,$04,$66,$1E,$20,$3C,$00,$00,$22,$90,$2A,$80,$2B,$40,$00,$04,$70,$02
 dc.b $2B,$40,$00,$0C,$42,$AE,$00,$0A,$3D,$7C,$00,$01,$00,$0E,$60,$22,$2A,$80
 dc.b $74,$00,$34,$2E,$00,$08,$D4,$82,$D0,$82,$2B,$40,$00,$04,$2B,$6E,$00,$0A
 dc.b $00,$08,$70,$00,$30,$2E,$00,$0E,$D0,$80,$2B,$40,$00,$0C,$3B,$6E,$00,$10
 dc.b $00,$14,$50,$EE,$00,$2A,$30,$2E,$00,$14,$60,$00,$04,$C0,$61,$0C,$70,$00
 dc.b $10,$2E,$00,$13,$3B,$40,$00,$16,$4E,$75,$61,$00,$07,$5E,$30,$2E,$00,$02
 dc.b $C0,$7C,$0F,$FF,$67,$5A,$10,$2E,$00,$02,$C0,$3C,$00,$0F,$4A,$00,$67,$58
 dc.b $B0,$3C,$00,$01,$67,$00,$00,$C4,$B0,$3C,$00,$02,$67,$00,$01,$0E,$B0,$3C
 dc.b $00,$03,$67,$00,$01,$A8,$B0,$3C,$00,$04,$67,$00,$02,$2E,$B0,$3C,$00,$05
 dc.b $67,$00,$02,$C2,$B0,$3C,$00,$06,$67,$00,$02,$C2,$B0,$3C,$00,$0E,$67,$00
 dc.b $04,$96,$3B,$6E,$00,$10,$00,$14,$B0,$3C,$00,$07,$67,$00,$02,$B2,$B0,$3C
 dc.b $00,$0A,$67,$00,$03,$86,$4E,$75,$3B,$6E,$00,$10,$00,$14,$4E,$75,$70,$00
 dc.b $30,$3A,$1E,$42,$81,$FC,$00,$03,$48,$40,$B0,$7C,$00,$01,$67,$0C,$B0,$7C
 dc.b $00,$02,$67,$10,$34,$2E,$00,$10,$60,$3E,$70,$00,$10,$2E,$00,$03,$E8,$08
 dc.b $60,$0A,$70,$00,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$E3,$40,$72,$00,$12,$2E
 dc.b $00,$12,$C2,$FC,$00,$4A,$41,$FA,$18,$06,$D1,$C1,$72,$00,$32,$2E,$00,$10
 dc.b $7E,$24,$34,$30,$00,$00,$B2,$50,$64,$08,$54,$88,$51,$CF,$FF,$F4,$4E,$75
 dc.b $3B,$42,$00,$14,$4E,$75,$4A,$79,$00,$00,$28,$90,$66,$8C,$13,$FC,$00,$0F
 dc.b $00,$00,$28,$9E,$70,$00,$10,$2E,$00,$03,$C0,$39,$00,$00,$28,$9E,$13,$FC
 dc.b $00,$FF,$00,$00,$28,$9E,$91,$6E,$00,$10,$30,$2E,$00,$10,$C0,$7C,$0F,$FF
 dc.b $B0,$7C,$00,$71,$6A,$0C,$02,$6E,$F0,$00,$00,$10,$00,$6E,$00,$71,$00,$10
 dc.b $30,$2E,$00,$10,$C0,$7C,$0F,$FF,$3B,$40,$00,$14,$4E,$75,$4A,$79,$00,$00
 dc.b $28,$90,$66,$00,$FF,$3C,$13,$FC,$00,$0F,$00,$00,$28,$9E,$42,$40,$10,$2E
 dc.b $00,$03,$C0,$39,$00,$00,$28,$9E,$13,$FC,$00,$FF,$00,$00,$28,$9E,$D1,$6E
 dc.b $00,$10,$30,$2E,$00,$10,$C0,$7C,$0F,$FF,$B0,$7C,$03,$58,$6B,$0C,$02,$6E
 dc.b $F0,$00,$00,$10,$00,$6E,$03,$58,$00,$10,$30,$2E,$00,$10,$C0,$7C,$0F,$FF
 dc.b $3B,$40,$00,$14,$4E,$75,$2F,$08,$34,$16,$C4,$7C,$0F,$FF,$70,$00,$10,$2E
 dc.b $00,$12,$C0,$FC,$00,$4A,$41,$FA,$17,$2E,$D1,$C0,$70,$00,$B4,$70,$00,$00
 dc.b $64,$0A,$54,$40,$B0,$7C,$00,$4A,$65,$F2,$70,$46,$14,$2E,$00,$12,$C4,$3C
 dc.b $00,$08,$67,$06,$4A,$40,$67,$02,$55,$40,$34,$30,$00,$00,$20,$5F,$3D,$42
 dc.b $00,$18,$30,$2E,$00,$10,$42,$2E,$00,$16,$B4,$40,$67,$0C,$6C,$00,$FE,$A0
 dc.b $1D,$7C,$00,$01,$00,$16,$4E,$75,$42,$6E,$00,$18,$4E,$75,$10,$2E,$00,$03
 dc.b $67,$08,$1D,$40,$00,$17,$42,$2E,$00,$03,$4A,$6E,$00,$18,$67,$00,$FE,$7C
 dc.b $70,$00,$10,$2E,$00,$17,$4A,$2E,$00,$16,$66,$1A,$D1,$6E,$00,$10,$30,$2E
 dc.b $00,$18,$B0,$6E,$00,$10,$6E,$24,$3D,$6E,$00,$18,$00,$10,$42,$6E,$00,$18
 dc.b $60,$18,$91,$6E,$00,$10,$30,$2E,$00,$18,$B0,$6E,$00,$10,$6D,$0A,$3D,$6E
 dc.b $00,$18,$00,$10,$42,$6E,$00,$18,$34,$2E,$00,$10,$10,$2E,$00,$1F,$C0,$3C
 dc.b $00,$0F,$67,$26,$70,$00,$10,$2E,$00,$12,$C0,$FC,$00,$4A,$41,$FA,$16,$72
 dc.b $D1,$C0,$70,$00,$B4,$70,$00,$00,$64,$0A,$54,$40,$B0,$7C,$00,$4A,$65,$F2
 dc.b $70,$46,$34,$30,$00,$00,$3B,$42,$00,$14,$4E,$75,$10,$2E,$00,$03,$67,$24
 dc.b $14,$2E,$00,$1A,$C0,$3C,$00,$0F,$67,$06,$C4,$3C,$00,$F0,$84,$00,$10,$2E
 dc.b $00,$03,$C0,$3C,$00,$F0,$67,$06,$C4,$3C,$00,$0F,$84,$00,$1D,$42,$00,$1A
 dc.b $2F,$0C,$10,$2E,$00,$1B,$49,$FA,$15,$FE,$E4,$48,$C0,$7C,$00,$1F,$74,$00
 dc.b $14,$2E,$00,$1E,$C4,$3C,$00,$03,$67,$20,$E7,$08,$B4,$3C,$00,$01,$67,$06
 dc.b $14,$3C,$00,$FF,$60,$16,$4A,$2E,$00,$1B,$6A,$08,$14,$3C,$00,$FF,$94,$00
 dc.b $60,$08,$14,$00,$60,$04,$14,$34,$00,$00,$10,$2E,$00,$1A,$C0,$7C,$00,$0F
 dc.b $C4,$C0,$EE,$4A,$30,$2E,$00,$10,$4A,$2E,$00,$1B,$6B,$04,$D0,$42,$60,$02
 dc.b $90,$42,$3B,$40,$00,$14,$10,$2E,$00,$1A,$E4,$48,$C0,$7C,$00,$3C,$D1,$2E
 dc.b $00,$1B,$28,$5F,$4E,$75,$61,$00,$FE,$E2,$60,$00,$00,$E4,$61,$84,$60,$00
 dc.b $00,$DE,$2F,$0C,$10,$2E,$00,$03,$67,$24,$14,$2E,$00,$1C,$C0,$3C,$00,$0F
 dc.b $67,$06,$C4,$3C,$00,$F0,$84,$00,$10,$2E,$00,$03,$C0,$3C,$00,$F0,$67,$06
 dc.b $C4,$3C,$00,$0F,$84,$00,$1D,$42,$00,$1C,$10,$2E,$00,$1D,$49,$FA,$15,$54
 dc.b $E4,$48,$C0,$7C,$00,$1F,$74,$00,$14,$2E,$00,$1E,$E8,$0A,$C4,$3C,$00,$03
 dc.b $67,$20,$E7,$08,$B4,$3C,$00,$01,$67,$06,$14,$3C,$00,$FF,$60,$16,$4A,$2E
 dc.b $00,$1B,$6A,$08,$14,$3C,$00,$FF,$94,$00,$60,$08,$14,$00,$60,$04,$14,$34
 dc.b $00,$00,$10,$2E,$00,$1C,$C0,$7C,$00,$0F,$C4,$C0,$EC,$4A,$70,$00,$10,$2E
 dc.b $00,$13,$4A,$2E,$00,$1D,$6B,$04,$D0,$42,$60,$02,$90,$42,$6A,$02,$42,$40
 dc.b $B0,$7C,$00,$40,$63,$04,$30,$3C,$00,$40,$3B,$40,$00,$16,$10,$2E,$00,$1C
 dc.b $E4,$48,$C0,$7C,$00,$3C,$D1,$2E,$00,$1D,$28,$5F,$58,$8F,$4E,$75,$70,$00
 dc.b $10,$2E,$00,$03,$67,$04,$1D,$40,$00,$20,$10,$2E,$00,$20,$EF,$48,$B0,$6E
 dc.b $00,$08,$6C,$0C,$91,$6E,$00,$08,$E3,$48,$D1,$AE,$00,$04,$4E,$75,$3D,$7C
 dc.b $00,$01,$00,$08,$4E,$75,$70,$00,$10,$2E,$00,$03,$E8,$08,$4A,$00,$67,$18
 dc.b $D1,$2E,$00,$13,$0C,$2E,$00,$40,$00,$13,$6B,$06,$1D,$7C,$00,$40,$00,$13
 dc.b $10,$2E,$00,$13,$4E,$75,$70,$00,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$91,$2E
 dc.b $00,$13,$6A,$04,$42,$2E,$00,$13,$10,$2E,$00,$13,$4E,$75,$70,$00,$10,$2E
 dc.b $00,$03,$53,$00,$33,$C0,$00,$00,$28,$96,$42,$39,$00,$00,$28,$9B,$50,$F9
 dc.b $00,$00,$28,$9C,$4E,$75,$70,$00,$10,$2E,$00,$03,$B0,$3C,$00,$40,$63,$02
 dc.b $70,$40,$1D,$40,$00,$13,$4E,$75,$70,$00,$10,$2E,$00,$03,$24,$00,$E8,$08
 dc.b $C0,$FC,$00,$0A,$C4,$3C,$00,$0F,$D0,$02,$B0,$3C,$00,$3F,$62,$C4,$13,$C0
 dc.b $00,$00,$28,$9B,$50,$F9,$00,$00,$28,$9C,$4E,$75,$10,$2E,$00,$03,$C0,$7C
 dc.b $00,$FF,$67,$12,$B0,$7C,$00,$20,$64,$0E,$42,$79,$00,$00,$28,$90,$33,$C0
 dc.b $00,$00,$28,$92,$4E,$75,$24,$3C,$00,$01,$E0,$2D,$84,$C0,$33,$C2,$00,$00
 dc.b $12,$AC,$4E,$75,$10,$2E,$00,$02,$C0,$3C,$00,$0F,$B0,$3C,$00,$09,$67,$00
 dc.b $FF,$02,$B0,$3C,$00,$0B,$67,$00,$FF,$64,$B0,$3C,$00,$0D,$67,$8C,$B0,$3C
 dc.b $00,$0E,$67,$12,$B0,$3C,$00,$0F,$67,$A8,$B0,$3C,$00,$0C,$67,$00,$FF,$66
 dc.b $60,$00,$FB,$86,$10,$2E,$00,$03,$C0,$3C,$00,$F0,$E8,$08,$67,$76,$B0,$3C
 dc.b $00,$01,$67,$00,$FB,$DC,$B0,$3C,$00,$02,$67,$00,$FC,$24,$B0,$3C,$00,$03
 dc.b $67,$6C,$B0,$3C,$00,$04,$67,$7A,$B0,$3C,$00,$05,$67,$00,$00,$88,$B0,$3C
 dc.b $00,$06,$67,$00,$00,$8E,$B0,$3C,$00,$07,$67,$00,$00,$D0,$B0,$3C,$00,$08
 dc.b $67,$00,$00,$DE,$B0,$3C,$00,$0E,$67,$00,$01,$E0,$B0,$3C,$00,$09,$67,$00
 dc.b $01,$08,$B0,$3C,$00,$0A,$67,$00,$01,$62,$B0,$3C,$00,$0B,$67,$00,$01,$72
 dc.b $B0,$3C,$00,$0C,$67,$00,$01,$82,$B0,$3C,$00,$0D,$67,$00,$01,$94,$B0,$3C
 dc.b $00,$0F,$67,$00,$01,$D8,$4E,$75,$10,$2E,$00,$03,$C0,$3C,$00,$01,$E3,$00
 dc.b $4E,$75,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$02,$2E,$00,$F0,$00,$1F,$81,$2E
 dc.b $00,$1F,$4E,$75,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$02,$2E,$00,$F0,$00,$1E
 dc.b $81,$2E,$00,$1E,$4E,$75,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$1D,$40,$00,$12
 dc.b $4E,$75,$4A,$79,$00,$00,$28,$90,$66,$00,$FA,$B6,$10,$2E,$00,$03,$C0,$3C
 dc.b $00,$0F,$67,$24,$4A,$2E,$00,$22,$67,$18,$53,$2E,$00,$22,$67,$00,$FA,$9E
 dc.b $13,$EE,$00,$21,$00,$00,$28,$9B,$50,$F9,$00,$00,$28,$9D,$4E,$75,$1D,$40
 dc.b $00,$22,$60,$EA,$30,$39,$00,$00,$28,$94,$E8,$88,$C0,$3C,$00,$3F,$1D,$40
 dc.b $00,$21,$4E,$75,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$E9,$08,$02,$2E,$00,$0F
 dc.b $00,$1E,$81,$2E,$00,$1E,$4E,$75,$48,$E7,$60,$C0,$20,$6E,$00,$0A,$22,$48
 dc.b $30,$2E,$00,$0E,$D0,$40,$55,$40,$12,$10,$48,$81,$14,$28,$00,$01,$48,$82
 dc.b $D4,$41,$E2,$42,$10,$C2,$51,$C8,$FF,$EE,$12,$10,$48,$81,$14,$11,$48,$82
 dc.b $D4,$41,$E2,$42,$10,$82,$4C,$DF,$03,$06,$4E,$75,$2F,$01,$70,$00,$10,$2E
 dc.b $00,$03,$C0,$3C,$00,$0F,$67,$50,$32,$39,$00,$00,$28,$90,$66,$0E,$32,$16
 dc.b $C2,$7C,$0F,$FF,$66,$40,$32,$39,$00,$00,$28,$90,$48,$C1,$82,$C0,$48,$41
 dc.b $4A,$41,$66,$30,$42,$AD,$00,$10,$20,$2E,$00,$04,$2A,$80,$72,$00,$32,$2E
 dc.b $00,$08,$D2,$81,$D0,$81,$2B,$40,$00,$04,$3B,$6E,$00,$10,$00,$14,$2B,$6E
 dc.b $00,$0A,$00,$08,$70,$00,$30,$2E,$00,$0E,$D0,$80,$2B,$40,$00,$0C,$22,$1F
 dc.b $4E,$75,$4A,$79,$00,$00,$28,$90,$66,$00,$F9,$BA,$70,$00,$10,$2E,$00,$03
 dc.b $C0,$3C,$00,$0F,$60,$00,$FD,$3C,$4A,$79,$00,$00,$28,$90,$66,$00,$F9,$A2
 dc.b $70,$00,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$60,$00,$FD,$46,$70,$00,$10,$2E
 dc.b $00,$03,$C0,$3C,$00,$0F,$B0,$79,$00,$00,$28,$90,$66,$00,$F9,$80,$42,$2E
 dc.b $00,$13,$4E,$75,$70,$00,$10,$2E,$00,$03,$C0,$3C,$00,$0F,$B0,$79,$00,$00
 dc.b $28,$90,$66,$00,$F9,$66,$30,$16,$C0,$7C,$0F,$FF,$67,$00,$F9,$5C,$2F,$01
 dc.b $60,$00,$FF,$60,$4A,$79,$00,$00,$28,$90,$66,$00,$F9,$4C,$70,$00,$10,$2E
 dc.b $00,$03,$C0,$3C,$00,$0F,$4A,$39,$00,$00,$28,$A0,$66,$00,$F9,$38,$52,$00
 dc.b $13,$C0,$00,$00,$28,$9F,$4E,$75,$4A,$79,$00,$00,$28,$90,$66,$00,$F9,$24
 dc.b $10,$2E,$00,$03,$C0,$3C,$00,$0F,$E9,$08,$02,$2E,$00,$0F,$00,$1F,$81,$2E
 dc.b $00,$1F,$4A,$00,$67,$00,$F9,$0A,$48,$E7,$40,$80,$70,$00,$10,$2E,$00,$1F
 dc.b $E8,$08,$67,$3E,$41,$FA,$11,$16,$10,$30,$00,$00,$D1,$2E,$00,$23,$08,$2E
 dc.b $00,$07,$00,$23,$67,$2A,$42,$2E,$00,$23,$20,$2E,$00,$0A,$72,$00,$32,$2E
 dc.b $00,$0E,$D0,$81,$D0,$81,$20,$6E,$00,$24,$52,$88,$B1,$C0,$65,$04,$20,$6E
 dc.b $00,$0A,$2D,$48,$00,$24,$70,$FF,$90,$10,$10,$80,$4C,$DF,$01,$02,$4E,$75
 dc.b $48,$E7,$80,$C0,$41,$FA,$15,$A0,$43,$FA,$17,$0D,$42,$18,$B3,$C8,$66,$FA
 dc.b $41,$FA,$15,$92,$41,$E8,$00,$14,$70,$01,$10,$80,$D0,$FC,$00,$2C,$E3,$08
 dc.b $64,$F6,$33,$FC,$00,$06,$00,$00,$28,$92,$13,$FC,$00,$FF,$00,$00,$28,$98
 dc.b $4C,$DF,$03,$01,$4E,$75,$48,$E7,$FF,$FE,$48,$79,$00,$00,$11,$DE,$3F,$3C
 dc.b $00,$26,$4E,$4E,$5C,$8F,$4C,$DF,$7F,$FF,$4E,$75,$41,$F8,$88,$00,$40,$C1
 dc.b $46,$FC,$27,$00,$10,$BC,$00,$0E,$10,$10,$C0,$3C,$00,$EF,$11,$40,$00,$02
 dc.b $80,$3C,$00,$10,$11,$40,$00,$02,$46,$C1,$20,$38,$04,$BA,$54,$80,$B0,$B8
 dc.b $04,$BA,$6D,$FA,$40,$C1,$46,$FC,$27,$00,$10,$BC,$00,$0E,$10,$10,$C0,$3C
 dc.b $00,$EF,$11,$40,$00,$02,$46,$C1,$41,$F8,$A2,$00,$43,$F9,$00,$00,$28,$A2
 dc.b $30,$3C,$02,$00,$32,$29,$00,$07,$53,$41,$43,$E9,$00,$09,$11,$59,$00,$05
 dc.b $11,$59,$00,$06,$11,$59,$00,$07,$53,$40,$51,$C9,$FF,$F0,$4A,$40,$67,$10
 dc.b $42,$28,$00,$05,$42,$28,$00,$06,$42,$28,$00,$07,$53,$40,$66,$F0,$43,$F9
 dc.b $00,$00,$29,$68,$20,$19,$80,$FC,$00,$03,$53,$40,$08,$28,$00,$02,$00,$02
 dc.b $67,$F8,$11,$59,$00,$05,$11,$59,$00,$06,$11,$59,$00,$07,$51,$C8,$FF,$EA
 dc.b $11,$7C,$00,$FF,$00,$05,$31,$7C,$FF,$FF,$00,$06,$4E,$75,$C9,$37,$37,$C9
 dc.b $C9,$37,$37,$C9,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$05,$06,$07,$08,$0A,$0B,$0D,$10,$13,$16,$1A
 dc.b $20,$2B,$40,$80,$00,$18,$31,$4A,$61,$78,$8D,$A1,$B4,$C5,$D4,$E0,$EB,$F4
 dc.b $FA,$FD,$FF,$FD,$FA,$F4,$EB,$E0,$D4,$C5,$B4,$A1,$8D,$78,$61,$4A,$31,$18
 dc.b $00,$00,$03,$58,$03,$28,$02,$FA,$02,$D0,$02,$A6,$02,$80,$02,$5C,$02,$3A
 dc.b $02,$1A,$01,$FC,$01,$E0,$01,$C5,$01,$AC,$01,$94,$01,$7D,$01,$68,$01,$53
 dc.b $01,$40,$01,$2E,$01,$1D,$01,$0D,$00,$FE,$00,$F0,$00,$E2,$00,$D6,$00,$CA
 dc.b $00,$BE,$00,$B4,$00,$AA,$00,$A0,$00,$97,$00,$8F,$00,$87,$00,$7F,$00,$78
 dc.b $00,$71,$00,$00,$03,$52,$03,$22,$02,$F5,$02,$CB,$02,$A2,$02,$7D,$02,$59
 dc.b $02,$37,$02,$17,$01,$F9,$01,$DD,$01,$C2,$01,$A9,$01,$91,$01,$7B,$01,$65
 dc.b $01,$51,$01,$3E,$01,$2C,$01,$1C,$01,$0C,$00,$FD,$00,$EF,$00,$E1,$00,$D5
 dc.b $00,$C9,$00,$BD,$00,$B3,$00,$A9,$00,$9F,$00,$96,$00,$8E,$00,$86,$00,$7E
 dc.b $00,$77,$00,$71,$00,$00,$03,$4C,$03,$1C,$02,$F0,$02,$C5,$02,$9E,$02,$78
 dc.b $02,$55,$02,$33,$02,$14,$01,$F6,$01,$DA,$01,$BF,$01,$A6,$01,$8E,$01,$78
 dc.b $01,$63,$01,$4F,$01,$3C,$01,$2A,$01,$1A,$01,$0A,$00,$FB,$00,$ED,$00,$E0
 dc.b $00,$D3,$00,$C7,$00,$BC,$00,$B1,$00,$A7,$00,$9E,$00,$95,$00,$8D,$00,$85
 dc.b $00,$7D,$00,$76,$00,$70,$00,$00,$03,$46,$03,$17,$02,$EA,$02,$C0,$02,$99
 dc.b $02,$74,$02,$50,$02,$2F,$02,$10,$01,$F2,$01,$D6,$01,$BC,$01,$A3,$01,$8B
 dc.b $01,$75,$01,$60,$01,$4C,$01,$3A,$01,$28,$01,$18,$01,$08,$00,$F9,$00,$EB
 dc.b $00,$DE,$00,$D1,$00,$C6,$00,$BB,$00,$B0,$00,$A6,$00,$9D,$00,$94,$00,$8C
 dc.b $00,$84,$00,$7D,$00,$76,$00,$6F,$00,$00,$03,$40,$03,$11,$02,$E5,$02,$BB
 dc.b $02,$94,$02,$6F,$02,$4C,$02,$2B,$02,$0C,$01,$EF,$01,$D3,$01,$B9,$01,$A0
 dc.b $01,$88,$01,$72,$01,$5E,$01,$4A,$01,$38,$01,$26,$01,$16,$01,$06,$00,$F7
 dc.b $00,$E9,$00,$DC,$00,$D0,$00,$C4,$00,$B9,$00,$AF,$00,$A5,$00,$9C,$00,$93
 dc.b $00,$8B,$00,$83,$00,$7C,$00,$75,$00,$6E,$00,$00,$03,$3A,$03,$0B,$02,$E0
 dc.b $02,$B6,$02,$8F,$02,$6B,$02,$48,$02,$27,$02,$08,$01,$EB,$01,$CF,$01,$B5
 dc.b $01,$9D,$01,$86,$01,$70,$01,$5B,$01,$48,$01,$35,$01,$24,$01,$14,$01,$04
 dc.b $00,$F5,$00,$E8,$00,$DB,$00,$CE,$00,$C3,$00,$B8,$00,$AE,$00,$A4,$00,$9B
 dc.b $00,$92,$00,$8A,$00,$82,$00,$7B,$00,$74,$00,$6D,$00,$00,$03,$34,$03,$06
 dc.b $02,$DA,$02,$B1,$02,$8B,$02,$66,$02,$44,$02,$23,$02,$04,$01,$E7,$01,$CC
 dc.b $01,$B2,$01,$9A,$01,$83,$01,$6D,$01,$59,$01,$45,$01,$33,$01,$22,$01,$12
 dc.b $01,$02,$00,$F4,$00,$E6,$00,$D9,$00,$CD,$00,$C1,$00,$B7,$00,$AC,$00,$A3
 dc.b $00,$9A,$00,$91,$00,$89,$00,$81,$00,$7A,$00,$73,$00,$6D,$00,$00,$03,$2E
 dc.b $03,$00,$02,$D5,$02,$AC,$02,$86,$02,$62,$02,$3F,$02,$1F,$02,$01,$01,$E4
 dc.b $01,$C9,$01,$AF,$01,$97,$01,$80,$01,$6B,$01,$56,$01,$43,$01,$31,$01,$20
 dc.b $01,$10,$01,$00,$00,$F2,$00,$E4,$00,$D8,$00,$CC,$00,$C0,$00,$B5,$00,$AB
 dc.b $00,$A1,$00,$98,$00,$90,$00,$88,$00,$80,$00,$79,$00,$72,$00,$6C,$00,$00
 dc.b $03,$8B,$03,$58,$03,$28,$02,$FA,$02,$D0,$02,$A6,$02,$80,$02,$5C,$02,$3A
 dc.b $02,$1A,$01,$FC,$01,$E0,$01,$C5,$01,$AC,$01,$94,$01,$7D,$01,$68,$01,$53
 dc.b $01,$40,$01,$2E,$01,$1D,$01,$0D,$00,$FE,$00,$F0,$00,$E2,$00,$D6,$00,$CA
 dc.b $00,$BE,$00,$B4,$00,$AA,$00,$A0,$00,$97,$00,$8F,$00,$87,$00,$7F,$00,$78
 dc.b $00,$00,$03,$84,$03,$52,$03,$22,$02,$F5,$02,$CB,$02,$A3,$02,$7C,$02,$59
 dc.b $02,$37,$02,$17,$01,$F9,$01,$DD,$01,$C2,$01,$A9,$01,$91,$01,$7B,$01,$65
 dc.b $01,$51,$01,$3E,$01,$2C,$01,$1C,$01,$0C,$00,$FD,$00,$EE,$00,$E1,$00,$D4
 dc.b $00,$C8,$00,$BD,$00,$B3,$00,$A9,$00,$9F,$00,$96,$00,$8E,$00,$86,$00,$7E
 dc.b $00,$77,$00,$00,$03,$7E,$03,$4C,$03,$1C,$02,$F0,$02,$C5,$02,$9E,$02,$78
 dc.b $02,$55,$02,$33,$02,$14,$01,$F6,$01,$DA,$01,$BF,$01,$A6,$01,$8E,$01,$78
 dc.b $01,$63,$01,$4F,$01,$3C,$01,$2A,$01,$1A,$01,$0A,$00,$FB,$00,$ED,$00,$DF
 dc.b $00,$D3,$00,$C7,$00,$BC,$00,$B1,$00,$A7,$00,$9E,$00,$95,$00,$8D,$00,$85
 dc.b $00,$7D,$00,$76,$00,$00,$03,$77,$03,$46,$03,$17,$02,$EA,$02,$C0,$02,$99
 dc.b $02,$74,$02,$50,$02,$2F,$02,$10,$01,$F2,$01,$D6,$01,$BC,$01,$A3,$01,$8B
 dc.b $01,$75,$01,$60,$01,$4C,$01,$3A,$01,$28,$01,$18,$01,$08,$00,$F9,$00,$EB
 dc.b $00,$DE,$00,$D1,$00,$C6,$00,$BB,$00,$B0,$00,$A6,$00,$9D,$00,$94,$00,$8C
 dc.b $00,$84,$00,$7D,$00,$76,$00,$00,$03,$71,$03,$40,$03,$11,$02,$E5,$02,$BB
 dc.b $02,$94,$02,$6F,$02,$4C,$02,$2B,$02,$0C,$01,$EE,$01,$D3,$01,$B9,$01,$A0
 dc.b $01,$88,$01,$72,$01,$5E,$01,$4A,$01,$38,$01,$26,$01,$16,$01,$06,$00,$F7
 dc.b $00,$E9,$00,$DC,$00,$D0,$00,$C4,$00,$B9,$00,$AF,$00,$A5,$00,$9C,$00,$93
 dc.b $00,$8B,$00,$83,$00,$7B,$00,$75,$00,$00,$03,$6B,$03,$3A,$03,$0B,$02,$E0
 dc.b $02,$B6,$02,$8F,$02,$6B,$02,$48,$02,$27,$02,$08,$01,$EB,$01,$CF,$01,$B5
 dc.b $01,$9D,$01,$86,$01,$70,$01,$5B,$01,$48,$01,$35,$01,$24,$01,$14,$01,$04
 dc.b $00,$F5,$00,$E8,$00,$DB,$00,$CE,$00,$C3,$00,$B8,$00,$AE,$00,$A4,$00,$9B
 dc.b $00,$92,$00,$8A,$00,$82,$00,$7B,$00,$74,$00,$00,$03,$64,$03,$34,$03,$06
 dc.b $02,$DA,$02,$B1,$02,$8B,$02,$66,$02,$44,$02,$23,$02,$04,$01,$E7,$01,$CC
 dc.b $01,$B2,$01,$9A,$01,$83,$01,$6D,$01,$59,$01,$45,$01,$33,$01,$22,$01,$12
 dc.b $01,$02,$00,$F4,$00,$E6,$00,$D9,$00,$CD,$00,$C1,$00,$B7,$00,$AC,$00,$A3
 dc.b $00,$9A,$00,$91,$00,$89,$00,$81,$00,$7A,$00,$73,$00,$00,$03,$5E,$03,$2E
 dc.b $03,$00,$02,$D5,$02,$AC,$02,$86,$02,$62,$02,$3F,$02,$1F,$02,$01,$01,$E4
 dc.b $01,$C9,$01,$AF,$01,$97,$01,$80,$01,$6B,$01,$56,$01,$43,$01,$31,$01,$20
 dc.b $01,$10,$01,$00,$00,$F2,$00,$E4,$00,$D8,$00,$CB,$00,$C0,$00,$B5,$00,$AB
 dc.b $00,$A1,$00,$98,$00,$90,$00,$88,$00,$80,$00,$79,$00,$72,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$01,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$02,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$04
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$08,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$10,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$20,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$40,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$80,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$3F,$44
 dc.b $F4,$00,$00,$00,$0E,$20,$92,$00,$56,$F4,$00,$00,$00,$3F,$20,$00,$44,$60
 dc.b $F4,$00,$00,$7C,$0E,$06,$CE,$00,$00,$00,$0B,$07,$DA,$84,$07,$58,$84,$0A
 dc.b $F0,$80,$00,$7C,$0E,$08,$F4,$A0,$00,$00,$01,$30,$00,$00,$20,$00,$13,$06
 dc.b $40,$A0,$07,$58,$8E,$0B,$F0,$80,$00,$7C,$3B,$56,$F4,$00,$FF,$FF,$FF,$20
 dc.b $00,$45,$0E,$A0,$00,$20,$85,$00,$0B,$F0,$80,$00,$7C,$3B,$20,$90,$00,$0B
 dc.b $F0,$80,$00,$7C,$3B,$06,$C4,$00,$00,$7C,$37,$0B,$F0,$80,$00,$7C,$3B,$20
 dc.b $00,$13,$56,$F4,$65,$00,$00,$01,$0A,$F0,$A2,$00,$7C,$2C,$07,$58,$84,$0A
 dc.b $F0,$80,$00,$7C,$37,$56,$F4,$65,$00,$00,$02,$0A,$F0,$A2,$00,$7C,$33,$44
 dc.b $58,$00,$0A,$F0,$80,$00,$7C,$37,$20,$00,$65,$0A,$F0,$A2,$00,$7C,$37,$4C
 dc.b $58,$00,$00,$00,$00,$00,$00,$00,$0A,$F0,$80,$00,$7C,$14,$0A,$A9,$80,$00
 dc.b $7C,$3B,$08,$44,$2B,$00,$00,$0C,$00,$00,$03,$D2,$00,$00,$02,$00,$00,$00
 dc.b $00,$00,$0B,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$02,$00,$00,$06,$00
 dc.b $00,$0A,$00,$00,$0E,$00,$00,$12,$00,$00,$16,$00,$00,$1A,$00,$00,$1E,$00
 dc.b $00,$00,$01,$00,$00,$00,$00,$00,$05,$00,$00,$00,$00,$00,$00,$00,$00,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$01,$00,$02,$00,$00,$00,$04,$00,$00,$00
 dc.b $00,$00,$02,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$02
 dc.b $0A,$F0,$80,$00,$00,$40,$00,$00,$00,$00,$00,$10,$00,$00,$01,$08,$DF,$EF
 dc.b $00,$00,$00,$00,$00,$40,$00,$01,$1D,$08,$F4,$BE,$00,$00,$00,$08,$F4,$A0
 dc.b $00,$00,$01,$05,$F4,$26,$00,$0F,$FF,$04,$67,$A6,$20,$00,$1B,$67,$F4,$00
 dc.b $00,$10,$00,$44,$F4,$00,$00,$10,$00,$06,$C4,$20,$5F,$5F,$00,$0B,$F0,$80
 dc.b $00,$01,$4B,$65,$F4,$00,$00,$30,$00,$05,$F4,$25,$00,$0F,$FF,$75,$F4,$00
 dc.b $00,$08,$00,$0B,$F0,$80,$00,$01,$44,$08,$F4,$BF,$00,$30,$00,$08,$F4,$AC
 dc.b $00,$41,$00,$08,$F4,$AD,$00,$58,$00,$08,$F4,$A1,$00,$01,$F0,$08,$F4,$A3
 dc.b $00,$00,$08,$00,$F0,$B8,$30,$00,$00,$0A,$A9,$80,$00,$00,$64,$08,$58,$EB
 dc.b $0A,$AE,$82,$00,$00,$67,$66,$F4,$00,$00,$10,$00,$67,$F4,$00,$00,$13,$D8
 dc.b $0A,$F0,$80,$00,$00,$73,$30,$00,$00,$0A,$A9,$80,$00,$00,$70,$08,$58,$EB
 dc.b $0A,$A9,$80,$00,$00,$73,$08,$58,$EB,$22,$EF,$00,$22,$C4,$00,$44,$F4,$4C
 dc.b $00,$10,$00,$0A,$F0,$A0,$00,$00,$7D,$20,$00,$48,$20,$00,$2B,$5F,$60,$00
 dc.b $0A,$A9,$81,$00,$00,$7F,$08,$CF,$2B,$33,$00,$00,$0A,$A9,$80,$00,$00,$83
 dc.b $08,$4E,$2B,$20,$00,$03,$0A,$F0,$A2,$00,$00,$93,$20,$5B,$00,$34,$0B,$00
 dc.b $06,$01,$40,$00,$00,$90,$68,$E4,$00,$0B,$F0,$80,$00,$01,$24,$68,$5C,$00
 dc.b $00,$00,$00,$0C,$00,$83,$63,$04,$00,$44,$F4,$00,$25,$00,$00,$0A,$00,$D1
 dc.b $00,$00,$9A,$44,$F4,$00,$21,$E5,$00,$07,$70,$84,$00,$01,$04,$44,$F4,$00
 dc.b $20,$00,$13,$07,$70,$84,$00,$01,$07,$07,$70,$84,$00,$01,$0A,$34,$03,$00
 dc.b $22,$DE,$00,$06,$01,$40,$00,$00,$AD,$68,$DC,$00,$0D,$00,$C3,$44,$F4,$00
 dc.b $5E,$E6,$00,$07,$70,$84,$00,$01,$07,$07,$70,$84,$00,$01,$0A,$0A,$00,$D0
 dc.b $00,$00,$C0,$7D,$F0,$00,$00,$00,$00,$23,$D6,$00,$46,$F4,$00,$3F,$FF,$FF
 dc.b $78,$82,$00,$06,$D8,$00,$00,$00,$BF,$5E,$DE,$00,$56,$6D,$00,$4F,$E5,$00
 dc.b $5F,$D6,$B3,$5F,$6D,$00,$47,$DD,$00,$5E,$5E,$BB,$5F,$5E,$00,$0B,$F0,$80
 dc.b $00,$01,$4B,$0C,$00,$6F,$23,$D6,$00,$06,$04,$00,$00,$01,$16,$61,$F4,$00
 dc.b $00,$04,$00,$57,$D8,$00,$21,$F9,$00,$20,$00,$0B,$0B,$F0,$A2,$00,$01,$19
 dc.b $61,$F4,$00,$00,$04,$00,$57,$D8,$00,$20,$49,$00,$21,$F9,$00,$22,$38,$00
 dc.b $20,$00,$0B,$0A,$F0,$AA,$00,$00,$E5,$0B,$F0,$80,$00,$01,$19,$23,$11,$00
 dc.b $23,$12,$00,$57,$F4,$00,$00,$04,$04,$44,$E0,$00,$20,$00,$48,$20,$49,$00
 dc.b $22,$24,$00,$20,$00,$4C,$06,$CF,$00,$00,$00,$E4,$4C,$DA,$00,$4C,$59,$00
 dc.b $70,$D8,$00,$44,$D8,$00,$45,$D8,$00,$47,$D8,$A0,$21,$C6,$00,$56,$F4,$00
 dc.b $3F,$FF,$FF,$20,$00,$74,$21,$C4,$00,$20,$00,$D0,$56,$00,$00,$56,$F4,$00
 dc.b $3F,$FF,$FF,$20,$00,$70,$21,$C4,$00,$20,$00,$D0,$56,$01,$00,$55,$D8,$00
 dc.b $20,$00,$2B,$55,$02,$00,$61,$F4,$00,$00,$04,$00,$55,$D8,$00,$20,$00,$2B
 dc.b $4C,$D9,$00,$5E,$D1,$00,$44,$03,$44,$21,$C4,$00,$06,$D8,$00,$00,$01,$15
 dc.b $56,$83,$00,$21,$E5,$00,$46,$80,$A3,$21,$C5,$00,$5E,$E6,$00,$46,$81,$E2
 dc.b $5E,$5E,$00,$5E,$E6,$00,$45,$82,$E2,$5E,$5E,$68,$0A,$F0,$A5,$00,$01,$15
 dc.b $20,$59,$00,$0A,$CD,$57,$4C,$D9,$00,$5E,$D1,$00,$44,$03,$44,$21,$C4,$00
 dc.b $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$0C,$44,$F4,$2B,$00,$00,$01
 dc.b $45,$F4,$48,$00,$80,$00,$06,$CF,$00,$00,$01,$22,$44,$D8,$00,$4C,$59,$00
 dc.b $44,$D8,$00,$4C,$59,$00,$00,$00,$0C,$0B,$F0,$80,$00,$01,$2E,$0B,$F0,$80
 dc.b $00,$01,$2E,$06,$06,$80,$00,$01,$2C,$0A,$A9,$80,$00,$01,$2A,$08,$58,$AB
 dc.b $00,$00,$0C,$0A,$A9,$80,$00,$01,$2E,$08,$4F,$2B,$57,$58,$00,$20,$00,$0B
 dc.b $0A,$F0,$AA,$00,$01,$43,$44,$F4,$2B,$00,$00,$01,$45,$F4,$48,$00,$80,$00
 dc.b $06,$CF,$00,$00,$01,$42,$0A,$A9,$80,$00,$01,$3B,$08,$44,$2B,$20,$00,$A0
 dc.b $21,$C4,$00,$21,$04,$A0,$50,$58,$00,$44,$58,$00,$00,$00,$0C,$20,$00,$1B
 dc.b $70,$F4,$00,$00,$10,$00,$06,$D8,$00,$00,$01,$49,$49,$5D,$00,$00,$00,$0C
 dc.b $30,$03,$00,$31,$0B,$00,$06,$08,$80,$00,$01,$50,$4C,$D8,$00,$4C,$59,$00
 dc.b $00,$00,$0C,$00,$00,$00,$62,$49,$54,$6D,$41,$53,$54,$45,$52,$20,$20,$20
 dc.b $6E,$6F,$20,$44,$53,$50,$20,$2D,$20,$6E,$6F,$20,$66,$75,$6E,$20,$21,$21
 dc.b $56,$65,$72,$73,$69,$6F,$6E,$20,$33,$2E,$31,$20,$44,$65,$63,$20,$20,$34
 dc.b $20,$31,$39,$39,$34,$00,$00,$00,$00,$26,$04,$F6,$06,$06,$12,$08,$08,$08
 dc.b $1C,$10,$06,$08,$08,$12,$24,$06,$06,$10,$14,$08,$06,$10,$10,$14,$0E,$0C
 dc.b $06,$0E,$18,$01,$16,$30,$28,$06,$06,$06,$06,$06,$26,$0A,$0E,$06,$6C,$06
 dc.b $06,$3E,$A2,$08,$1A,$14,$2A,$60,$0E,$30,$08,$06,$10,$06,$14,$0C,$1C,$08
 dc.b $14,$14,$24,$08,$08,$06,$08,$06,$06,$08,$08,$06,$08,$0E,$06,$0A,$10,$06
 dc.b $06,$06,$08,$0A,$10,$06,$18,$26,$01,$30,$01,$36,$0A,$0C,$08,$32,$0C,$0C
 dc.b $08,$01,$01,$F2,$06,$06,$36,$06,$18,$06,$10,$01,$04,$24,$06,$0E,$70,$10
 dc.b $44,$18,$22,$1A,$1A,$14,$0C,$08,$9E,$08,$10,$5C,$3A,$00

		even




; **** DATA Segment ****
.data

dm_dsp_bootstrap_code:
		dc.b	$0c,$00,$40,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$60,$f4,$00,$00,$00,$4f,$61,$f4
		dc.b	$00,$00,$7e,$a9,$06,$2e,$80,$00,$00,$47
		dc.b	$07,$d8,$84,$07,$59,$84,$08,$f4,$a8,$00
		dc.b	$00,$04,$08,$f4,$bf,$00,$0c,$00,$00,$fe
		dc.b	$b8,$0a,$f0,$80,$00,$7e,$a9,$08,$f4,$a0
		dc.b	$00,$00,$01,$08,$f4,$be,$00,$00,$00,$0a
		dc.b	$a9,$80,$00,$7e,$ad,$08,$4e,$2b,$44,$f4
		dc.b	$00,$00,$00,$03,$44,$f4,$45,$00,$00,$01
		dc.b	$0e,$a0,$00,$0a,$a9,$80,$00,$7e,$b5,$08
		dc.b	$50,$2b,$0a,$a9,$80,$00,$7e,$b8,$08,$46
		dc.b	$2b,$44,$f4,$45,$00,$00,$02,$0a,$f0,$aa
		dc.b	$00,$7e,$c9,$20,$00,$45,$0a,$f0,$aa,$00
		dc.b	$7e,$d0,$06,$c6,$00,$00,$7e,$c6,$0a,$a9
		dc.b	$80,$00,$7e,$c4,$08,$58,$6b,$0a,$f0,$80
		dc.b	$00,$7e,$ad,$06,$c6,$00,$00,$7e,$cd,$0a
		dc.b	$a9,$80,$00,$7e,$cb,$08,$58,$ab,$0a,$f0
		dc.b	$80,$00,$7e,$ad,$06,$c6,$00,$00,$7e,$d4
		dc.b	$0a,$a9,$80,$00,$7e,$d2,$08,$58,$eb,$0a
		dc.b	$f0,$80,$00,$7e,$ad,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
		dc.b	$00,$00,$00,$00,$00,$00



		even

dm_voltab4:
		dc.w $7fff,$7fff,$7fff,$7fff
		dc.w 0,0,0,0
		even


dm_voltab8:
		dc.w $3fff,$3fff,$3fff,$3fff
		dc.w $3fff,$3fff,$3fff,$3fff
		even


	even



;*** BSS Segment ***
.bss

dm_timer:		ds.w	1
dm_count:		ds.w	1
dm_dmabuf:	ds.l	1


dm_dsp_program:	ds.l	1
dm_dsp_length: 	ds.l	1
dm_dsp_status: 	ds.l	1



modaddr:
	ds.l	1

vbllstentr:
	ds.l	1

oldhregs:
	ds.b	5
	even

xgc_val:	ds.l	1
xgc_ptr:	ds.l	1

snd_cookie:	ds.l	1

.globl _playflag
_playflag:	ds.w	1



; **** EOF *****
