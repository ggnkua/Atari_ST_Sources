
;#### 50 kHz frequency table ####

;*** Freq.-table: ***
;* extern unsigned short ftab2[3840];
;* void crefrqtb()
;* {
;*  unsigned short per;
;*  double work,freq_amiga=3579545.0,freq_st=25033.0;
;*  unsigned short *x;
;*  x = ftab2;
;*  for (per = 1 ; per <= (1024+256) ; per++) 
;*   {
;*    work = (freq_amiga/(double)per)/freq_st; /* whole part */
;*    *x++=(unsigned short)work;
;*    *(long *)x = (65536.0*frac(work)*65536.0); /* output frac */
;*    x+=2;		
;*   }
;* }
;* double frac(double x)
;* {
;*  long i=x;
;*  return (x - i);
;* }

    .data

.globl ftab50
ftab50:
 ds.w 3
 dc.b $00,$8E,$FE,$38,$78,$82,$00,$47,$7F,$1C,$3C,$41,$00,$2F,$AA,$12,$D2,$D6
 dc.b $00,$23,$BF,$8E,$1E,$20,$00,$1C,$99,$3E,$7E,$80,$00,$17,$D5,$09,$69,$6B
 dc.b $00,$14,$6D,$75,$C8,$12,$00,$11,$DF,$C7,$0F,$10,$00,$0F,$E3,$5B,$9B,$9C
 dc.b $00,$0E,$4C,$9F,$3F,$40,$00,$0C,$FF,$D6,$96,$97,$00,$0B,$EA,$84,$B4,$B5
 dc.b $00,$0A,$FF,$DC,$F5,$93,$00,$0A,$36,$BA,$E4,$09,$00,$09,$88,$6A,$2A,$2A
 dc.b $00,$08,$EF,$E3,$87,$88,$00,$08,$69,$4E,$9D,$AD,$00,$07,$F1,$AD,$CD,$CE
 dc.b $00,$07,$86,$A4,$A8,$06,$00,$07,$26,$4F,$9F,$A0,$00,$06,$CF,$27,$42,$B0
 dc.b $00,$06,$7F,$EB,$4B,$4B,$00,$06,$37,$93,$26,$A1,$00,$05,$F5,$42,$5A,$5A
 dc.b $00,$05,$B8,$3F,$B2,$E6,$00,$05,$7F,$EE,$7A,$C9,$00,$05,$4B,$C9,$33,$DE
 dc.b $00,$05,$1B,$5D,$72,$04,$00,$04,$EE,$48,$91,$65,$00,$04,$C4,$35,$15,$15
 dc.b $00,$04,$9C,$D8,$88,$04,$00,$04,$77,$F1,$C3,$C4,$00,$04,$55,$47,$87,$87
 dc.b $00,$04,$34,$A7,$4E,$D6,$00,$04,$15,$E4,$5B,$36,$00,$03,$F8,$D6,$E6,$E7
 dc.b $00,$03,$DD,$5B,$78,$E0,$00,$03,$C3,$52,$54,$03,$00,$03,$AA,$9E,$FC,$86
 dc.b $00,$03,$93,$27,$CF,$D0,$00,$03,$7C,$D5,$AB,$86,$00,$03,$67,$93,$A1,$58
 dc.b $00,$03,$53,$4E,$B5,$68,$00,$03,$3F,$F5,$A5,$A5,$00,$03,$2D,$78,$B8,$B8
 dc.b $00,$03,$1B,$C9,$93,$50,$00,$03,$0A,$DB,$12,$E7,$00,$02,$FA,$A1,$2D,$2D
 dc.b $00,$02,$EB,$10,$D3,$70,$00,$02,$DC,$1F,$D9,$73,$00,$02,$CD,$C4,$DF,$39
 dc.b $00,$02,$BF,$F7,$3D,$64,$00,$02,$B2,$AE,$F3,$C8,$00,$02,$A5,$E4,$99,$EF
 dc.b $00,$02,$99,$91,$51,$51,$00,$02,$8D,$AE,$B9,$02,$00,$02,$82,$36,$E2,$AC
 dc.b $00,$02,$77,$24,$48,$B2,$00,$02,$6C,$71,$C5,$4B,$00,$02,$62,$1A,$8A,$8A
 dc.b $00,$02,$58,$1A,$1B,$27,$00,$02,$4E,$6C,$44,$02,$00,$02,$45,$0D,$16,$3A
 dc.b $00,$02,$3B,$F8,$E1,$E2,$00,$02,$33,$2C,$31,$1D,$00,$02,$2A,$A3,$C3,$C3
 dc.b $00,$02,$22,$5C,$8B,$59,$00,$02,$1A,$53,$A7,$6B,$00,$02,$12,$86,$62,$35
 dc.b $00,$02,$0A,$F2,$2D,$9B,$00,$02,$03,$94,$A0,$58,$00,$01,$FC,$6B,$73,$73
 dc.b $00,$01,$F5,$74,$7F,$E5,$00,$01,$EE,$AD,$BC,$70,$00,$01,$E8,$15,$3B,$A2
 dc.b $00,$01,$E1,$A9,$2A,$01,$00,$01,$DB,$67,$CC,$5E,$00,$01,$D5,$4F,$7E,$43
 dc.b $00,$01,$CF,$5E,$B0,$83,$00,$01,$C9,$93,$E7,$E8,$00,$01,$C3,$ED,$BB,$F4
 dc.b $00,$01,$BE,$6A,$D5,$C3,$00,$01,$B9,$09,$EE,$F2,$00,$01,$B3,$C9,$D0,$AC
 dc.b $00,$01,$AE,$A9,$52,$BC,$00,$01,$A9,$A7,$5A,$B4,$00,$01,$A4,$C2,$DB,$21
 dc.b $00,$01,$9F,$FA,$D2,$D2,$00,$01,$9B,$4E,$4C,$23,$00,$01,$96,$BC,$5C,$5C
 dc.b $00,$01,$92,$44,$23,$15,$00,$01,$8D,$E4,$C9,$A8,$00,$01,$89,$9D,$82,$AC
 dc.b $00,$01,$85,$6D,$89,$73,$00,$01,$81,$54,$21,$9A,$00,$01,$7D,$50,$96,$96
 dc.b $00,$01,$79,$62,$3B,$4D,$00,$01,$75,$88,$69,$B8,$00,$01,$71,$C2,$82,$82
 dc.b $00,$01,$6E,$0F,$EC,$B9,$00,$01,$6A,$70,$15,$78,$00,$01,$66,$E2,$6F,$9C
 dc.b $00,$01,$63,$66,$73,$80,$00,$01,$5F,$FB,$9E,$B2,$00,$01,$5C,$A1,$73,$BC
 dc.b $00,$01,$59,$57,$79,$E4,$00,$01,$56,$1D,$3C,$F0,$00,$01,$52,$F2,$4C,$F7
 dc.b $00,$01,$4F,$D6,$3E,$2B,$00,$01,$4C,$C8,$A8,$A8,$00,$01,$49,$C9,$28,$4A
 dc.b $00,$01,$46,$D7,$5C,$81,$00,$01,$43,$F2,$E8,$25,$00,$01,$41,$1B,$71,$56
 dc.b $00,$01,$3E,$50,$A1,$53,$00,$01,$3B,$92,$24,$59,$00,$01,$38,$DF,$A9,$82
 dc.b $00,$01,$36,$38,$E2,$A5,$00,$01,$33,$9D,$84,$3D,$00,$01,$31,$0D,$45,$45
 dc.b $00,$01,$2E,$87,$DF,$25,$00,$01,$2C,$0D,$0D,$93,$00,$01,$29,$9C,$8E,$82
 dc.b $00,$01,$27,$36,$22,$01,$00,$01,$24,$D9,$8A,$2E,$00,$01,$22,$86,$8B,$1D
 dc.b $00,$01,$20,$3C,$EA,$C6,$00,$01,$1D,$FC,$70,$F1,$00,$01,$1B,$C4,$E7,$22
 dc.b $00,$01,$19,$96,$18,$8E,$00,$01,$17,$6F,$D2,$04,$00,$01,$15,$51,$E1,$E1
 dc.b $00,$01,$13,$3C,$18,$00,$00,$01,$11,$2E,$45,$AC,$00,$01,$0F,$28,$3D,$92
 dc.b $00,$01,$0D,$29,$D3,$B5,$00,$01,$0B,$32,$DD,$60,$00,$01,$09,$43,$31,$1A
 dc.b $00,$01,$07,$5A,$A6,$9F,$00,$01,$05,$79,$16,$CD,$00,$01,$03,$9E,$5B,$A2
 dc.b $00,$01,$01,$CA,$50,$2C,$00,$00,$FF,$FC,$D0,$81,$00,$00,$FE,$35,$B9,$B9
 dc.b $00,$00,$FC,$74,$E9,$E1,$00,$00,$FA,$BA,$3F,$F2,$00,$00,$F9,$05,$9B,$D0
 dc.b $00,$00,$F7,$56,$DE,$38,$00,$00,$F5,$AD,$E8,$C1,$00,$00,$F4,$0A,$9D,$D1
 dc.b $00,$00,$F2,$6C,$E0,$96,$00,$00,$F0,$D4,$95,$00,$00,$00,$EF,$41,$9F,$BD
 dc.b $00,$00,$ED,$B3,$E6,$2F,$00,$00,$EC,$2B,$4E,$67,$00,$00,$EA,$A7,$BF,$21
 dc.b $00,$00,$E9,$29,$1F,$BF,$00,$00,$E7,$AF,$58,$41,$00,$00,$E6,$3A,$51,$42
 dc.b $00,$00,$E4,$C9,$F3,$F4,$00,$00,$E3,$5E,$2A,$17,$00,$00,$E1,$F6,$DD,$FA
 dc.b $00,$00,$E0,$93,$FA,$75,$00,$00,$DF,$35,$6A,$E1,$00,$00,$DD,$DB,$1B,$1B
 dc.b $00,$00,$DC,$84,$F7,$79,$00,$00,$DB,$32,$EC,$CB,$00,$00,$D9,$E4,$E8,$56
 dc.b $00,$00,$D8,$9A,$D7,$D0,$00,$00,$D7,$54,$A9,$5E,$00,$00,$D6,$12,$4B,$8E
 dc.b $00,$00,$D4,$D3,$AD,$5A,$00,$00,$D3,$98,$BE,$1B,$00,$00,$D2,$61,$6D,$90
 dc.b $00,$00,$D1,$2D,$AB,$D7,$00,$00,$CF,$FD,$69,$69,$00,$00,$CE,$D0,$97,$19
 dc.b $00,$00,$CD,$A7,$26,$11,$00,$00,$CC,$81,$07,$D2,$00,$00,$CB,$5E,$2E,$2E
 dc.b $00,$00,$CA,$3E,$8B,$46,$00,$00,$C9,$22,$11,$8A,$00,$00,$C8,$08,$B3,$B7
 dc.b $00,$00,$C6,$F2,$64,$D4,$00,$00,$C5,$DF,$18,$2C,$00,$00,$C4,$CE,$C1,$56
 dc.b $00,$00,$C3,$C1,$54,$27,$00,$00,$C2,$B6,$C4,$B9,$00,$00,$C1,$AF,$07,$68
 dc.b $00,$00,$C0,$AA,$10,$CD,$00,$00,$BF,$A7,$D5,$BD,$00,$00,$BE,$A8,$4B,$4B
 dc.b $00,$00,$BD,$AB,$66,$C2,$00,$00,$BC,$B1,$1D,$A6,$00,$00,$BB,$B9,$65,$B4
 dc.b $00,$00,$BA,$C4,$34,$DC,$00,$00,$B9,$D1,$81,$42,$00,$00,$B8,$E1,$41,$41
 dc.b $00,$00,$B7,$F3,$6B,$61,$00,$00,$B7,$07,$F6,$5C,$00,$00,$B6,$1E,$D9,$1D
 dc.b $00,$00,$B5,$38,$0A,$BC,$00,$00,$B4,$53,$82,$7C,$00,$00,$B3,$71,$37,$CE
 dc.b $00,$00,$B2,$91,$22,$4E,$00,$00,$B1,$B3,$39,$C0,$00,$00,$B0,$D7,$76,$11
 dc.b $00,$00,$AF,$FD,$CF,$59,$00,$00,$AF,$26,$3D,$D2,$00,$00,$AE,$50,$B9,$DE
 dc.b $00,$00,$AD,$7D,$3C,$05,$00,$00,$AC,$AB,$BC,$F2,$00,$00,$AB,$DC,$35,$72
 dc.b $00,$00,$AB,$0E,$9E,$78,$00,$00,$AA,$42,$F1,$14,$00,$00,$A9,$79,$26,$7B
 dc.b $00,$00,$A8,$B1,$38,$00,$00,$00,$A7,$EB,$1F,$15,$00,$00,$A7,$26,$D5,$4C
 dc.b $00,$00,$A6,$64,$54,$54,$00,$00,$A5,$A3,$95,$F9,$00,$00,$A4,$E4,$94,$25
 dc.b $00,$00,$A4,$27,$48,$DC,$00,$00,$A3,$6B,$AE,$40,$00,$00,$A2,$B1,$BE,$8B
 dc.b $00,$00,$A1,$F9,$74,$12,$00,$00,$A1,$42,$C9,$45,$00,$00,$A0,$8D,$B8,$AB
 dc.b $00,$00,$9F,$DA,$3C,$E4,$00,$00,$9F,$28,$50,$A9,$00,$00,$9E,$77,$EE,$CA
 dc.b $00,$00,$9D,$C9,$12,$2C,$00,$00,$9D,$1B,$B5,$CE,$00,$00,$9C,$6F,$D4,$C1
 dc.b $00,$00,$9B,$C5,$6A,$2E,$00,$00,$9B,$1C,$71,$52,$00,$00,$9A,$74,$E5,$81
 dc.b $00,$00,$99,$CE,$C2,$1E,$00,$00,$99,$2A,$02,$A5,$00,$00,$98,$86,$A2,$A2
 dc.b $00,$00,$97,$E4,$9D,$B6,$00,$00,$97,$43,$EF,$92,$00,$00,$96,$A4,$93,$FC
 dc.b $00,$00,$96,$06,$86,$C9,$00,$00,$95,$69,$C3,$E3,$00,$00,$94,$CE,$47,$41
 dc.b $00,$00,$94,$34,$0C,$EC,$00,$00,$93,$9B,$11,$00,$00,$00,$93,$03,$4F,$A6
 dc.b $00,$00,$92,$6C,$C5,$17,$00,$00,$91,$D7,$6D,$9C,$00,$00,$91,$43,$45,$8E
 dc.b $00,$00,$90,$B0,$49,$54,$00,$00,$90,$1E,$75,$63,$00,$00,$8F,$8D,$C6,$3E
 dc.b $00,$00,$8E,$FE,$38,$78,$00,$00,$8E,$6F,$C8,$AF,$00,$00,$8D,$E2,$73,$91
 dc.b $00,$00,$8D,$56,$35,$D6,$00,$00,$8C,$CB,$0C,$47,$00,$00,$8C,$40,$F3,$B5
 dc.b $00,$00,$8B,$B7,$E9,$02,$00,$00,$8B,$2F,$E9,$18,$00,$00,$8A,$A8,$F0,$F0
 dc.b $00,$00,$8A,$22,$FD,$8E,$00,$00,$89,$9E,$0C,$00,$00,$00,$89,$1A,$19,$61
 dc.b $00,$00,$88,$97,$22,$D6,$00,$00,$88,$15,$25,$90,$00,$00,$87,$94,$1E,$C9
 dc.b $00,$00,$87,$14,$0B,$C7,$00,$00,$86,$94,$E9,$DA,$00,$00,$86,$16,$B6,$5C
 dc.b $00,$00,$85,$99,$6E,$B0,$00,$00,$85,$1D,$10,$43,$00,$00,$84,$A1,$98,$8D
 dc.b $00,$00,$84,$27,$05,$0E,$00,$00,$83,$AD,$53,$4F,$00,$00,$83,$34,$80,$E4
 dc.b $00,$00,$82,$BC,$8B,$66,$00,$00,$82,$45,$70,$7C,$00,$00,$81,$CF,$2D,$D1
 dc.b $00,$00,$81,$59,$C1,$1A,$00,$00,$80,$E5,$28,$16,$00,$00,$80,$71,$60,$88
 dc.b $00,$00,$7F,$FE,$68,$40,$00,$00,$7F,$8C,$3D,$13,$00,$00,$7F,$1A,$DC,$DC
 dc.b $00,$00,$7E,$AA,$45,$82,$00,$00,$7E,$3A,$74,$F0,$00,$00,$7D,$CB,$69,$19
 dc.b $00,$00,$7D,$5D,$1F,$F9,$00,$00,$7C,$EF,$97,$90,$00,$00,$7C,$82,$CD,$E8
 dc.b $00,$00,$7C,$16,$C1,$0F,$00,$00,$7B,$AB,$6F,$1C,$00,$00,$7B,$40,$D6,$2B
 dc.b $00,$00,$7A,$D6,$F4,$60,$00,$00,$7A,$6D,$C7,$E5,$00,$00,$7A,$05,$4E,$E8
 dc.b $00,$00,$79,$9D,$87,$A1,$00,$00,$79,$36,$70,$4B,$00,$00,$78,$D0,$07,$28
 dc.b $00,$00,$78,$6A,$4A,$80,$00,$00,$78,$05,$38,$A1,$00,$00,$77,$A0,$CF,$DE
 dc.b $00,$00,$77,$3D,$0E,$91,$00,$00,$76,$D9,$F3,$17,$00,$00,$76,$77,$7B,$D5
 dc.b $00,$00,$76,$15,$A7,$33,$00,$00,$75,$B4,$73,$A0,$00,$00,$75,$53,$DF,$90
 dc.b $00,$00,$74,$F3,$E9,$7B,$00,$00,$74,$94,$8F,$DF,$00,$00,$74,$35,$D1,$3E
 dc.b $00,$00,$73,$D7,$AC,$20,$00,$00,$73,$7A,$1F,$11,$00,$00,$73,$1D,$28,$A1
 dc.b $00,$00,$72,$C0,$C7,$66,$00,$00,$72,$64,$F9,$FA,$00,$00,$72,$09,$BE,$FA
 dc.b $00,$00,$71,$AF,$15,$0B,$00,$00,$71,$54,$FA,$D3,$00,$00,$70,$FB,$6E,$FD
 dc.b $00,$00,$70,$A2,$70,$39,$00,$00,$70,$49,$FD,$3A,$00,$00,$6F,$F2,$14,$B9
 dc.b $00,$00,$6F,$9A,$B5,$70,$00,$00,$6F,$43,$DE,$21,$00,$00,$6E,$ED,$8D,$8D
 dc.b $00,$00,$6E,$97,$C2,$7D,$00,$00,$6E,$42,$7B,$BC,$00,$00,$6D,$ED,$B8,$18
 dc.b $00,$00,$6D,$99,$76,$65,$00,$00,$6D,$45,$B5,$78,$00,$00,$6C,$F2,$74,$2B
 dc.b $00,$00,$6C,$9F,$B1,$5A,$00,$00,$6C,$4D,$6B,$E8,$00,$00,$6B,$FB,$A2,$B7
 dc.b $00,$00,$6B,$AA,$54,$AF,$00,$00,$6B,$59,$80,$BA,$00,$00,$6B,$09,$25,$C7
 dc.b $00,$00,$6A,$B9,$42,$C6,$00,$00,$6A,$69,$D6,$AD,$00,$00,$6A,$1A,$E0,$71
 dc.b $00,$00,$69,$CC,$5F,$0D,$00,$00,$69,$7E,$51,$80,$00,$00,$69,$30,$B6,$C8
 dc.b $00,$00,$68,$E3,$8D,$EA,$00,$00,$68,$96,$D5,$EB,$00,$00,$68,$4A,$8D,$D6
 dc.b $00,$00,$67,$FE,$B4,$B4,$00,$00,$67,$B3,$49,$96,$00,$00,$67,$68,$4B,$8C
 dc.b $00,$00,$67,$1D,$B9,$AB,$00,$00,$66,$D3,$93,$08,$00,$00,$66,$89,$D6,$BF
 dc.b $00,$00,$66,$40,$83,$E9,$00,$00,$65,$F7,$99,$A6,$00,$00,$65,$AF,$17,$17
 dc.b $00,$00,$65,$66,$FB,$5E,$00,$00,$65,$1F,$45,$A3,$00,$00,$64,$D7,$F5,$0C
 dc.b $00,$00,$64,$91,$08,$C5,$00,$00,$64,$4A,$7F,$FA,$00,$00,$64,$04,$59,$DB
 dc.b $00,$00,$63,$BE,$95,$9A,$00,$00,$63,$79,$32,$6A,$00,$00,$63,$34,$2F,$80
 dc.b $00,$00,$62,$EF,$8C,$16,$00,$00,$62,$AB,$47,$65,$00,$00,$62,$67,$60,$AB
 dc.b $00,$00,$62,$23,$D7,$24,$00,$00,$61,$E0,$AA,$13,$00,$00,$61,$9D,$D8,$BA
 dc.b $00,$00,$61,$5B,$62,$5C,$00,$00,$61,$19,$46,$42,$00,$00,$60,$D7,$83,$B4
 dc.b $00,$00,$60,$96,$19,$FC,$00,$00,$60,$55,$08,$66,$00,$00,$60,$14,$4E,$42
 dc.b $00,$00,$5F,$D3,$EA,$DE,$00,$00,$5F,$93,$DD,$8E,$00,$00,$5F,$54,$25,$A5
 dc.b $00,$00,$5F,$14,$C2,$79,$00,$00,$5E,$D5,$B3,$61,$00,$00,$5E,$96,$F7,$B6
 dc.b $00,$00,$5E,$58,$8E,$D3,$00,$00,$5E,$1A,$78,$15,$00,$00,$5D,$DC,$B2,$DA
 dc.b $00,$00,$5D,$9F,$3E,$81,$00,$00,$5D,$62,$1A,$6E,$00,$00,$5D,$25,$46,$01
 dc.b $00,$00,$5C,$E8,$C0,$A1,$00,$00,$5C,$AC,$89,$B3,$00,$00,$5C,$70,$A0,$A0
 dc.b $00,$00,$5C,$35,$04,$D1,$00,$00,$5B,$F9,$B5,$B0,$00,$00,$5B,$BE,$B2,$AA
 dc.b $00,$00,$5B,$83,$FB,$2E,$00,$00,$5B,$49,$8E,$AA,$00,$00,$5B,$0F,$6C,$8E
 dc.b $00,$00,$5A,$D5,$94,$4F,$00,$00,$5A,$9C,$05,$5E,$00,$00,$5A,$62,$BF,$30
 dc.b $00,$00,$5A,$29,$C1,$3E,$00,$00,$59,$F1,$0A,$FD,$00,$00,$59,$B8,$9B,$E7
 dc.b $00,$00,$59,$80,$73,$76,$00,$00,$59,$48,$91,$27,$00,$00,$59,$10,$F4,$75
 dc.b $00,$00,$58,$D9,$9C,$E0,$00,$00,$58,$A2,$89,$E6,$00,$00,$58,$6B,$BB,$08
 dc.b $00,$00,$58,$35,$2F,$CA,$00,$00,$57,$FE,$E7,$AC,$00,$00,$57,$C8,$E2,$35
 dc.b $00,$00,$57,$93,$1E,$E9,$00,$00,$57,$5D,$9D,$4F,$00,$00,$57,$28,$5C,$EF
 dc.b $00,$00,$56,$F3,$5D,$52,$00,$00,$56,$BE,$9E,$02,$00,$00,$56,$8A,$1E,$8B
 dc.b $00,$00,$56,$55,$DE,$79,$00,$00,$56,$21,$DD,$58,$00,$00,$55,$EE,$1A,$B9
 dc.b $00,$00,$55,$BA,$96,$2A,$00,$00,$55,$87,$4F,$3C,$00,$00,$55,$54,$45,$80
 dc.b $00,$00,$55,$21,$78,$8A,$00,$00,$54,$EE,$E7,$ED,$00,$00,$54,$BC,$93,$3D
 dc.b $00,$00,$54,$8A,$7A,$12,$00,$00,$54,$58,$9C,$00,$00,$00,$54,$26,$F8,$A0
 dc.b $00,$00,$53,$F5,$8F,$8A,$00,$00,$53,$C4,$60,$59,$00,$00,$53,$93,$6A,$A6
 dc.b $00,$00,$53,$62,$AE,$0D,$00,$00,$53,$32,$2A,$2A,$00,$00,$53,$01,$DE,$9A
 dc.b $00,$00,$52,$D1,$CA,$FC,$00,$00,$52,$A1,$EE,$EF,$00,$00,$52,$72,$4A,$12
 dc.b $00,$00,$52,$42,$DC,$07,$00,$00,$52,$13,$A4,$6E,$00,$00,$51,$E4,$A2,$EB
 dc.b $00,$00,$51,$B5,$D7,$20,$00,$00,$51,$87,$40,$B2,$00,$00,$51,$58,$DF,$45
 dc.b $00,$00,$51,$2A,$B2,$80,$00,$00,$50,$FC,$BA,$09,$00,$00,$50,$CE,$F5,$87
 dc.b $00,$00,$50,$A1,$64,$A2,$00,$00,$50,$74,$07,$04,$00,$00,$50,$46,$DC,$55
 dc.b $00,$00,$50,$19,$E4,$41,$00,$00,$4F,$ED,$1E,$72,$00,$00,$4F,$C0,$8A,$94
 dc.b $00,$00,$4F,$94,$28,$54,$00,$00,$4F,$67,$F7,$60,$00,$00,$4F,$3B,$F7,$65
 dc.b $00,$00,$4F,$10,$28,$11,$00,$00,$4E,$E4,$89,$16,$00,$00,$4E,$B9,$1A,$22
 dc.b $00,$00,$4E,$8D,$DA,$E7,$00,$00,$4E,$62,$CB,$15,$00,$00,$4E,$37,$EA,$60
 dc.b $00,$00,$4E,$0D,$38,$7A,$00,$00,$4D,$E2,$B5,$17,$00,$00,$4D,$B8,$5F,$EA
 dc.b $00,$00,$4D,$8E,$38,$A9,$00,$00,$4D,$64,$3F,$09,$00,$00,$4D,$3A,$72,$C0
 dc.b $00,$00,$4D,$10,$D3,$85,$00,$00,$4C,$E7,$61,$0F,$00,$00,$4C,$BE,$1B,$16
 dc.b $00,$00,$4C,$95,$01,$52,$00,$00,$4C,$6C,$13,$7D,$00,$00,$4C,$43,$51,$51
 dc.b $00,$00,$4C,$1A,$BA,$87,$00,$00,$4B,$F2,$4E,$DB,$00,$00,$4B,$CA,$0E,$07
 dc.b $00,$00,$4B,$A1,$F7,$C9,$00,$00,$4B,$7A,$0B,$DC,$00,$00,$4B,$52,$49,$FE
 dc.b $00,$00,$4B,$2A,$B1,$EC,$00,$00,$4B,$03,$43,$64,$00,$00,$4A,$DB,$FE,$27
 dc.b $00,$00,$4A,$B4,$E1,$F1,$00,$00,$4A,$8D,$EE,$84,$00,$00,$4A,$67,$23,$A0
 dc.b $00,$00,$4A,$40,$81,$05,$00,$00,$4A,$1A,$06,$76,$00,$00,$49,$F3,$B3,$B3
 dc.b $00,$00,$49,$CD,$88,$80,$00,$00,$49,$A7,$84,$9E,$00,$00,$49,$81,$A7,$D3
 dc.b $00,$00,$49,$5B,$F1,$E0,$00,$00,$49,$36,$62,$8B,$00,$00,$49,$10,$F9,$99
 dc.b $00,$00,$48,$EB,$B6,$CE,$00,$00,$48,$C6,$99,$F0,$00,$00,$48,$A1,$A2,$C7
 dc.b $00,$00,$48,$7C,$D1,$18,$00,$00,$48,$58,$24,$AA,$00,$00,$48,$33,$9D,$45
 dc.b $00,$00,$48,$0F,$3A,$B1,$00,$00,$47,$EA,$FC,$B7,$00,$00,$47,$C6,$E3,$1F
 dc.b $00,$00,$47,$A2,$ED,$B3,$00,$00,$47,$7F,$1C,$3C,$00,$00,$47,$5B,$6E,$84
 dc.b $00,$00,$47,$37,$E4,$57,$00,$00,$47,$14,$7D,$80,$00,$00,$46,$F1,$39,$C8
 dc.b $00,$00,$46,$CE,$18,$FD,$00,$00,$46,$AB,$1A,$EB,$00,$00,$46,$88,$3F,$5E
 dc.b $00,$00,$46,$65,$86,$23,$00,$00,$46,$42,$EF,$08,$00,$00,$46,$20,$79,$DA
 dc.b $00,$00,$45,$FE,$26,$68,$00,$00,$45,$DB,$F4,$81,$00,$00,$45,$B9,$E3,$F2
 dc.b $00,$00,$45,$97,$F4,$8C,$00,$00,$45,$76,$26,$1E,$00,$00,$45,$54,$78,$78
 dc.b $00,$00,$45,$32,$EB,$6B,$00,$00,$45,$11,$7E,$C7,$00,$00,$44,$F0,$32,$5D
 dc.b $00,$00,$44,$CF,$06,$00,$00,$00,$44,$AD,$F9,$80,$00,$00,$44,$8D,$0C,$B0
 dc.b $00,$00,$44,$6C,$3F,$63,$00,$00,$44,$4B,$91,$6B,$00,$00,$44,$2B,$02,$9B
 dc.b $00,$00,$44,$0A,$92,$C8,$00,$00,$43,$EA,$41,$C4,$00,$00,$43,$CA,$0F,$64
 dc.b $00,$00,$43,$A9,$FB,$7D,$00,$00,$43,$8A,$05,$E3,$00,$00,$43,$6A,$2E,$6C
 dc.b $00,$00,$43,$4A,$74,$ED,$00,$00,$43,$2A,$D9,$3B,$00,$00,$43,$0B,$5B,$2E
 dc.b $00,$00,$42,$EB,$FA,$9A,$00,$00,$42,$CC,$B7,$58,$00,$00,$42,$AD,$91,$3D
 dc.b $00,$00,$42,$8E,$88,$21,$00,$00,$42,$6F,$9B,$DC,$00,$00,$42,$50,$CC,$46
 dc.b $00,$00,$42,$32,$19,$37,$00,$00,$42,$13,$82,$87,$00,$00,$41,$F5,$08,$0E
 dc.b $00,$00,$41,$D6,$A9,$A7,$00,$00,$41,$B8,$67,$2A,$00,$00,$41,$9A,$40,$72
 dc.b $00,$00,$41,$7C,$35,$56,$00,$00,$41,$5E,$45,$B3,$00,$00,$41,$40,$71,$62
 dc.b $00,$00,$41,$22,$B8,$3E,$00,$00,$41,$05,$1A,$21,$00,$00,$40,$E7,$96,$E8
 dc.b $00,$00,$40,$CA,$2E,$6D,$00,$00,$40,$AC,$E0,$8D,$00,$00,$40,$8F,$AD,$22
 dc.b $00,$00,$40,$72,$94,$0B,$00,$00,$40,$55,$95,$21,$00,$00,$40,$38,$B0,$44
 dc.b $00,$00,$40,$1B,$E5,$4F,$00,$00,$3F,$FF,$34,$20,$00,$00,$3F,$E2,$9C,$94
 dc.b $00,$00,$3F,$C6,$1E,$89,$00,$00,$3F,$A9,$B9,$DD,$00,$00,$3F,$8D,$6E,$6E
 dc.b $00,$00,$3F,$71,$3C,$1A,$00,$00,$3F,$55,$22,$C1,$00,$00,$3F,$39,$22,$40
 dc.b $00,$00,$3F,$1D,$3A,$78,$00,$00,$3F,$01,$6B,$47,$00,$00,$3E,$E5,$B4,$8C
 dc.b $00,$00,$3E,$CA,$16,$29,$00,$00,$3E,$AE,$8F,$FC,$00,$00,$3E,$93,$21,$E6
 dc.b $00,$00,$3E,$77,$CB,$C8,$00,$00,$3E,$5C,$8D,$81,$00,$00,$3E,$41,$66,$F4
 dc.b $00,$00,$3E,$26,$58,$00,$00,$00,$3E,$0B,$60,$87,$00,$00,$3D,$F0,$80,$6B
 dc.b $00,$00,$3D,$D5,$B7,$8E,$00,$00,$3D,$BB,$05,$D0,$00,$00,$3D,$A0,$6B,$15
 dc.b $00,$00,$3D,$85,$E7,$3F,$00,$00,$3D,$6B,$7A,$30,$00,$00,$3D,$51,$23,$CB
 dc.b $00,$00,$3D,$36,$E3,$F2,$00,$00,$3D,$1C,$BA,$89,$00,$00,$3D,$02,$A7,$74
 dc.b $00,$00,$3C,$E8,$AA,$95,$00,$00,$3C,$CE,$C3,$D0,$00,$00,$3C,$B4,$F3,$09
 dc.b $00,$00,$3C,$9B,$38,$25,$00,$00,$3C,$81,$93,$07,$00,$00,$3C,$68,$03,$94
 dc.b $00,$00,$3C,$4E,$89,$B0,$00,$00,$3C,$35,$25,$40,$00,$00,$3C,$1B,$D6,$29
 dc.b $00,$00,$3C,$02,$9C,$50,$00,$00,$3B,$E9,$77,$9B,$00,$00,$3B,$D0,$67,$EF
 dc.b $00,$00,$3B,$B7,$6D,$31,$00,$00,$3B,$9E,$87,$48,$00,$00,$3B,$85,$B6,$1A
 dc.b $00,$00,$3B,$6C,$F9,$8B,$00,$00,$3B,$54,$51,$84,$00,$00,$3B,$3B,$BD,$EA
 dc.b $00,$00,$3B,$23,$3E,$A4,$00,$00,$3B,$0A,$D3,$99,$00,$00,$3A,$F2,$7C,$B0
 dc.b $00,$00,$3A,$DA,$39,$D0,$00,$00,$3A,$C2,$0A,$E0,$00,$00,$3A,$A9,$EF,$C8
 dc.b $00,$00,$3A,$91,$E8,$6F,$00,$00,$3A,$79,$F4,$BD,$00,$00,$3A,$62,$14,$9B
 dc.b $00,$00,$3A,$4A,$47,$EF,$00,$00,$3A,$32,$8E,$A3,$00,$00,$3A,$1A,$E8,$9F
 dc.b $00,$00,$3A,$03,$55,$CB,$00,$00,$39,$EB,$D6,$10,$00,$00,$39,$D4,$69,$57
 dc.b $00,$00,$39,$BD,$0F,$88,$00,$00,$39,$A5,$C8,$8E,$00,$00,$39,$8E,$94,$50
 dc.b $00,$00,$39,$77,$72,$B9,$00,$00,$39,$60,$63,$B3,$00,$00,$39,$49,$67,$26
 dc.b $00,$00,$39,$32,$7C,$FD,$00,$00,$39,$1B,$A5,$21,$00,$00,$39,$04,$DF,$7D
 dc.b $00,$00,$38,$EE,$2B,$FB,$00,$00,$38,$D7,$8A,$85,$00,$00,$38,$C0,$FB,$06
 dc.b $00,$00,$38,$AA,$7D,$69,$00,$00,$38,$94,$11,$98,$00,$00,$38,$7D,$B7,$7E
 dc.b $00,$00,$38,$67,$6F,$06,$00,$00,$38,$51,$38,$1C,$00,$00,$38,$3B,$12,$AA
 dc.b $00,$00,$38,$24,$FE,$9D,$00,$00,$38,$0E,$FB,$DF,$00,$00,$37,$F9,$0A,$5C
 dc.b $00,$00,$37,$E3,$2A,$00,$00,$00,$37,$CD,$5A,$B8,$00,$00,$37,$B7,$9C,$6E
 dc.b $00,$00,$37,$A1,$EF,$10,$00,$00,$37,$8C,$52,$89,$00,$00,$37,$76,$C6,$C6
 dc.b $00,$00,$37,$61,$4B,$B4,$00,$00,$37,$4B,$E1,$3E,$00,$00,$37,$36,$87,$53
 dc.b $00,$00,$37,$21,$3D,$DE,$00,$00,$37,$0C,$04,$CC,$00,$00,$36,$F6,$DC,$0C
 dc.b $00,$00,$36,$E1,$C3,$89,$00,$00,$36,$CC,$BB,$32,$00,$00,$36,$B7,$C2,$F4
 dc.b $00,$00,$36,$A2,$DA,$BC,$00,$00,$36,$8E,$02,$77,$00,$00,$36,$79,$3A,$15
 dc.b $00,$00,$36,$64,$81,$82,$00,$00,$36,$4F,$D8,$AD,$00,$00,$36,$3B,$3F,$83
 dc.b $00,$00,$36,$26,$B5,$F4,$00,$00,$36,$12,$3B,$EC,$00,$00,$35,$FD,$D1,$5B
 dc.b $00,$00,$35,$E9,$76,$2F,$00,$00,$35,$D5,$2A,$57,$00,$00,$35,$C0,$ED,$C1
 dc.b $00,$00,$35,$AC,$C0,$5D,$00,$00,$35,$98,$A2,$18,$00,$00,$35,$84,$92,$E3
 dc.b $00,$00,$35,$70,$92,$AC,$00,$00,$35,$5C,$A1,$63,$00,$00,$35,$48,$BE,$F6
 dc.b $00,$00,$35,$34,$EB,$56,$00,$00,$35,$21,$26,$71,$00,$00,$35,$0D,$70,$38
 dc.b $00,$00,$34,$F9,$C8,$9A,$00,$00,$34,$E6,$2F,$86,$00,$00,$34,$D2,$A4,$EE
 dc.b $00,$00,$34,$BF,$28,$C0,$00,$00,$34,$AB,$BA,$EC,$00,$00,$34,$98,$5B,$64
 dc.b $00,$00,$34,$85,$0A,$16,$00,$00,$34,$71,$C6,$F5,$00,$00,$34,$5E,$91,$EF
 dc.b $00,$00,$34,$4B,$6A,$F5,$00,$00,$34,$38,$51,$F9,$00,$00,$34,$25,$46,$EB
 dc.b $00,$00,$34,$12,$49,$BA,$00,$00,$33,$FF,$5A,$5A,$00,$00,$33,$EC,$78,$BA
 dc.b $00,$00,$33,$D9,$A4,$CB,$00,$00,$33,$C6,$DE,$7E,$00,$00,$33,$B4,$25,$C6
 dc.b $00,$00,$33,$A1,$7A,$92,$00,$00,$33,$8E,$DC,$D5,$00,$00,$33,$7C,$4C,$80
 dc.b $00,$00,$33,$69,$C9,$84,$00,$00,$33,$57,$53,$D3,$00,$00,$33,$44,$EB,$5F
 dc.b $00,$00,$33,$32,$90,$19,$00,$00,$33,$20,$41,$F4,$00,$00,$33,$0E,$00,$E1
 dc.b $00,$00,$32,$FB,$CC,$D3,$00,$00,$32,$E9,$A5,$BB,$00,$00,$32,$D7,$8B,$8B
 dc.b $00,$00,$32,$C5,$7E,$36,$00,$00,$32,$B3,$7D,$AF,$00,$00,$32,$A1,$89,$E7
 dc.b $00,$00,$32,$8F,$A2,$D1,$00,$00,$32,$7D,$C8,$60,$00,$00,$32,$6B,$FA,$86
 dc.b $00,$00,$32,$5A,$39,$36,$00,$00,$32,$48,$84,$62,$00,$00,$32,$36,$DB,$FE
 dc.b $00,$00,$32,$25,$3F,$FD,$00,$00,$32,$13,$B0,$51,$00,$00,$32,$02,$2C,$ED
 dc.b $00,$00,$31,$F0,$B5,$C6,$00,$00,$31,$DF,$4A,$CD,$00,$00,$31,$CD,$EB,$F6
 dc.b $00,$00,$31,$BC,$99,$35,$00,$00,$31,$AB,$52,$7C,$00,$00,$31,$9A,$17,$C0
 dc.b $00,$00,$31,$88,$E8,$F4,$00,$00,$31,$77,$C6,$0B,$00,$00,$31,$66,$AE,$F9
 dc.b $00,$00,$31,$55,$A3,$B2,$00,$00,$31,$44,$A4,$2A,$00,$00,$31,$33,$B0,$55
 dc.b $00,$00,$31,$22,$C8,$26,$00,$00,$31,$11,$EB,$92,$00,$00,$31,$01,$1A,$8C
 dc.b $00,$00,$30,$F0,$55,$09,$00,$00,$30,$DF,$9A,$FD,$00,$00,$30,$CE,$EC,$5D
 dc.b $00,$00,$30,$BE,$49,$1B,$00,$00,$30,$AD,$B1,$2E,$00,$00,$30,$9D,$24,$89
 dc.b $00,$00,$30,$8C,$A3,$21,$00,$00,$30,$7C,$2C,$EA,$00,$00,$30,$6B,$C1,$DA
 dc.b $00,$00,$30,$5B,$61,$E4,$00,$00,$30,$4B,$0C,$FE,$00,$00,$30,$3A,$C3,$1C
 dc.b $00,$00,$30,$2A,$84,$33,$00,$00,$30,$1A,$50,$38,$00,$00,$30,$0A,$27,$21
 dc.b $00,$00,$2F,$FA,$08,$E1,$00,$00,$2F,$E9,$F5,$6F,$00,$00,$2F,$D9,$EC,$BF
 dc.b $00,$00,$2F,$C9,$EE,$C7,$00,$00,$2F,$B9,$FB,$7B,$00,$00,$2F,$AA,$12,$D2
 dc.b $00,$00,$2F,$9A,$34,$C1,$00,$00,$2F,$8A,$61,$3C,$00,$00,$2F,$7A,$98,$3A
 dc.b $00,$00,$2F,$6A,$D9,$B0,$00,$00,$2F,$5B,$25,$94,$00,$00,$2F,$4B,$7B,$DB
 dc.b $00,$00,$2F,$3B,$DC,$7B,$00,$00,$2F,$2C,$47,$69,$00,$00,$2F,$1C,$BC,$9C
 dc.b $00,$00,$2F,$0D,$3C,$0A,$00,$00,$2E,$FD,$C5,$A8,$00,$00,$2E,$EE,$59,$6D
 dc.b $00,$00,$2E,$DE,$F7,$4D,$00,$00,$2E,$CF,$9F,$40,$00,$00,$2E,$C0,$51,$3C
 dc.b $00,$00,$2E,$B1,$0D,$37,$00,$00,$2E,$A1,$D3,$26,$00,$00,$2E,$92,$A3,$00
 dc.b $00,$00,$2E,$83,$7C,$BC,$00,$00,$2E,$74,$60,$50,$00,$00,$2E,$65,$4D,$B2
 dc.b $00,$00,$2E,$56,$44,$D9,$00,$00,$2E,$47,$45,$BC,$00,$00,$2E,$38,$50,$50
 dc.b $00,$00,$2E,$29,$64,$8C,$00,$00,$2E,$1A,$82,$68,$00,$00,$2E,$0B,$A9,$DA
 dc.b $00,$00,$2D,$FC,$DA,$D8,$00,$00,$2D,$EE,$15,$59,$00,$00,$2D,$DF,$59,$55
 dc.b $00,$00,$2D,$D0,$A6,$C2,$00,$00,$2D,$C1,$FD,$97,$00,$00,$2D,$B3,$5D,$CB
 dc.b $00,$00,$2D,$A4,$C7,$55,$00,$00,$2D,$96,$3A,$2C,$00,$00,$2D,$87,$B6,$47
 dc.b $00,$00,$2D,$79,$3B,$9E,$00,$00,$2D,$6A,$CA,$27,$00,$00,$2D,$5C,$61,$DA
 dc.b $00,$00,$2D,$4E,$02,$AF,$00,$00,$2D,$3F,$AC,$9B,$00,$00,$2D,$31,$5F,$98
 dc.b $00,$00,$2D,$23,$1B,$9C,$00,$00,$2D,$14,$E0,$9F,$00,$00,$2D,$06,$AE,$97
 dc.b $00,$00,$2C,$F8,$85,$7E,$00,$00,$2C,$EA,$65,$4A,$00,$00,$2C,$DC,$4D,$F3
 dc.b $00,$00,$2C,$CE,$3F,$71,$00,$00,$2C,$C0,$39,$BB,$00,$00,$2C,$B2,$3C,$C9
 dc.b $00,$00,$2C,$A4,$48,$93,$00,$00,$2C,$96,$5D,$11,$00,$00,$2C,$88,$7A,$3A
 dc.b $00,$00,$2C,$7A,$A0,$07,$00,$00,$2C,$6C,$CE,$70,$00,$00,$2C,$5F,$05,$6B
 dc.b $00,$00,$2C,$51,$44,$F3,$00,$00,$2C,$43,$8C,$FD,$00,$00,$2C,$35,$DD,$84
 dc.b $00,$00,$2C,$28,$36,$7E,$00,$00,$2C,$1A,$97,$E5,$00,$00,$2C,$0D,$01,$AF
 dc.b $00,$00,$2B,$FF,$73,$D6,$00,$00,$2B,$F1,$EE,$51,$00,$00,$2B,$E4,$71,$1A
 dc.b $00,$00,$2B,$D6,$FC,$28,$00,$00,$2B,$C9,$8F,$74,$00,$00,$2B,$BC,$2A,$F6
 dc.b $00,$00,$2B,$AE,$CE,$A7,$00,$00,$2B,$A1,$7A,$7F,$00,$00,$2B,$94,$2E,$77
 dc.b $00,$00,$2B,$86,$EA,$87,$00,$00,$2B,$79,$AE,$A9,$00,$00,$2B,$6C,$7A,$D4
 dc.b $00,$00,$2B,$5F,$4F,$01,$00,$00,$2B,$52,$2B,$29,$00,$00,$2B,$45,$0F,$45
 dc.b $00,$00,$2B,$37,$FB,$4E,$00,$00,$2B,$2A,$EF,$3C,$00,$00,$2B,$1D,$EB,$08
 dc.b $00,$00,$2B,$10,$EE,$AC,$00,$00,$2B,$03,$FA,$20,$00,$00,$2A,$F7,$0D,$5C
 dc.b $00,$00,$2A,$EA,$28,$5B,$00,$00,$2A,$DD,$4B,$15,$00,$00,$2A,$D0,$75,$82
 dc.b $00,$00,$2A,$C3,$A7,$9E,$00,$00,$2A,$B6,$E1,$5F,$00,$00,$2A,$AA,$22,$C0
 dc.b $00,$00,$2A,$9D,$6B,$B9,$00,$00,$2A,$90,$BC,$45,$00,$00,$2A,$84,$14,$5B
 dc.b $00,$00,$2A,$77,$73,$F6,$00,$00,$2A,$6A,$DB,$0F,$00,$00,$2A,$5E,$49,$9E
 dc.b $00,$00,$2A,$51,$BF,$9F,$00,$00,$2A,$45,$3D,$09,$00,$00,$2A,$38,$C1,$D6
 dc.b $00,$00,$2A,$2C,$4E,$00,$00,$00,$2A,$1F,$E1,$80,$00,$00,$2A,$13,$7C,$50
 dc.b $00,$00,$2A,$07,$1E,$69,$00,$00,$29,$FA,$C7,$C5,$00,$00,$29,$EE,$78,$5D
 dc.b $00,$00,$29,$E2,$30,$2C,$00,$00,$29,$D5,$EF,$2B,$00,$00,$29,$C9,$B5,$53
 dc.b $00,$00,$29,$BD,$82,$9E,$00,$00,$29,$B1,$57,$06,$00,$00,$29,$A5,$32,$85
 dc.b $00,$00,$29,$99,$15,$15,$00,$00,$29,$8C,$FE,$AF,$00,$00,$29,$80,$EF,$4D
 dc.b $00,$00,$29,$74,$E6,$E9,$00,$00,$29,$68,$E5,$7E,$00,$00,$29,$5C,$EB,$05
 dc.b $00,$00,$29,$50,$F7,$77,$00,$00,$29,$45,$0A,$D0,$00,$00,$29,$39,$25,$09
 dc.b $00,$00,$29,$2D,$46,$1C,$00,$00,$29,$21,$6E,$03,$00,$00,$29,$15,$9C,$B9
 dc.b $00,$00,$29,$09,$D2,$37,$00,$00,$28,$FE,$0E,$77,$00,$00,$28,$F2,$51,$75
 dc.b $00,$00,$28,$E6,$9B,$2A,$00,$00,$28,$DA,$EB,$90,$00,$00,$28,$CF,$42,$A1
 dc.b $00,$00,$28,$C3,$A0,$59,$00,$00,$28,$B8,$04,$B0,$00,$00,$28,$AC,$6F,$A2
 dc.b $00,$00,$28,$A0,$E1,$29,$00,$00,$28,$95,$59,$40,$00,$00,$28,$89,$D7,$E0
 dc.b $00,$00,$28,$7E,$5D,$04,$00,$00,$28,$72,$E8,$A7,$00,$00,$28,$67,$7A,$C3
 dc.b $00,$00,$28,$5C,$13,$53,$00,$00,$28,$50,$B2,$51,$00,$00,$28,$45,$57,$B8
 dc.b $00,$00,$28,$3A,$03,$82,$00,$00,$28,$2E,$B5,$AA,$00,$00,$28,$23,$6E,$2A
 dc.b $00,$00,$28,$18,$2C,$FE,$00,$00,$28,$0C,$F2,$20,$00,$00,$28,$01,$BD,$8B
 dc.b $00,$00,$27,$F6,$8F,$39,$00,$00,$27,$EB,$67,$25,$00,$00,$27,$E0,$45,$4A
 dc.b $00,$00,$27,$D5,$29,$A3,$00,$00,$27,$CA,$14,$2A,$00,$00,$27,$BF,$04,$DB
 dc.b $00,$00,$27,$B3,$FB,$B0,$00,$00,$27,$A8,$F8,$A4,$00,$00,$27,$9D,$FB,$B2
 dc.b $00,$00,$27,$93,$04,$D5,$00,$00,$27,$88,$14,$08,$00,$00,$27,$7D,$29,$47
 dc.b $00,$00,$27,$72,$44,$8B,$00,$00,$27,$67,$65,$D0,$00,$00,$27,$5C,$8D,$11
 dc.b $00,$00,$27,$51,$BA,$49,$00,$00,$27,$46,$ED,$73,$00,$00,$27,$3C,$26,$8A
 dc.b $00,$00,$27,$31,$65,$8A,$00,$00,$27,$26,$AA,$6E,$00,$00,$27,$1B,$F5,$30
 dc.b $00,$00,$27,$11,$45,$CC,$00,$00,$27,$06,$9C,$3D,$00,$00,$26,$FB,$F8,$7E
 dc.b $00,$00,$26,$F1,$5A,$8B,$00,$00,$26,$E6,$C2,$5F,$00,$00,$26,$DC,$2F,$F5
 dc.b $00,$00,$26,$D1,$A3,$48,$00,$00,$26,$C7,$1C,$54,$00,$00,$26,$BC,$9B,$14
 dc.b $00,$00,$26,$B2,$1F,$84,$00,$00,$26,$A7,$A9,$9F,$00,$00,$26,$9D,$39,$60
 dc.b $00,$00,$26,$92,$CE,$C2,$00,$00,$26,$88,$69,$C2,$00,$00,$26,$7E,$0A,$5B
 dc.b $00,$00,$26,$73,$B0,$87,$00,$00,$26,$69,$5C,$43,$00,$00,$26,$5F,$0D,$8B
 dc.b $00,$00,$26,$54,$C4,$59,$00,$00,$26,$4A,$80,$A9,$00,$00,$26,$40,$42,$77
 dc.b $00,$00,$26,$36,$09,$BE,$00,$00,$26,$2B,$D6,$7B,$00,$00,$26,$21,$A8,$A8
 dc.b $00,$00,$26,$17,$80,$42,$00,$00,$26,$0D,$5D,$43,$00,$00,$26,$03,$3F,$A8
 dc.b $00,$00,$25,$F9,$27,$6D,$00,$00,$25,$EF,$14,$8D,$00,$00,$25,$E5,$07,$03
 dc.b $00,$00,$25,$DA,$FE,$CD,$00,$00,$25,$D0,$FB,$E4,$00,$00,$25,$C6,$FE,$46
 dc.b $00,$00,$25,$BD,$05,$EE,$00,$00,$25,$B3,$12,$D7,$00,$00,$25,$A9,$24,$FF
 dc.b $00,$00,$25,$9F,$3C,$5F,$00,$00,$25,$95,$58,$F6,$00,$00,$25,$8B,$7A,$BD
 dc.b $00,$00,$25,$81,$A1,$B2,$00,$00,$25,$77,$CD,$D0,$00,$00,$25,$6D,$FF,$13
 dc.b $00,$00,$25,$64,$35,$77,$00,$00,$25,$5A,$70,$F8,$00,$00,$25,$50,$B1,$93
 dc.b $00,$00,$25,$46,$F7,$42,$00,$00,$25,$3D,$42,$02,$00,$00,$25,$33,$91,$D0
 dc.b $00,$00,$25,$29,$E6,$A6,$00,$00,$25,$20,$40,$82,$00,$00,$25,$16,$9F,$60
 dc.b $00,$00,$25,$0D,$03,$3B,$00,$00,$25,$03,$6C,$0F,$00,$00,$24,$F9,$D9,$D9
 dc.b $00,$00,$24,$F0,$4C,$95,$00,$00,$24,$E6,$C4,$40,$00,$00,$24,$DD,$40,$D4
 dc.b $00,$00,$24,$D3,$C2,$4F,$00,$00,$24,$CA,$48,$AD,$00,$00,$24,$C0,$D3,$E9
 dc.b $00,$00,$24,$B7,$64,$01,$00,$00,$24,$AD,$F8,$F0,$00,$00,$24,$A4,$92,$B2
 dc.b $00,$00,$24,$9B,$31,$45,$00,$00,$24,$91,$D4,$A4,$00,$00,$24,$88,$7C,$CC
 dc.b $00,$00,$24,$7F,$29,$B9,$00,$00,$24,$75,$DB,$67,$00,$00,$24,$6C,$91,$D2
 dc.b $00,$00,$24,$63,$4C,$F8,$00,$00,$24,$5A,$0C,$D4,$00,$00,$24,$50,$D1,$63
 dc.b $00,$00,$24,$47,$9A,$A2,$00,$00,$24,$3E,$68,$8C,$00,$00,$24,$35,$3B,$1E
 dc.b $00,$00,$24,$2C,$12,$55,$00,$00,$24,$22,$EE,$2D,$00,$00,$24,$19,$CE,$A2
 dc.b $00,$00,$24,$10,$B3,$B2,$00,$00,$24,$07,$9D,$58,$00,$00,$23,$FE,$8B,$92
 dc.b $00,$00,$23,$F5,$7E,$5B,$00,$00,$23,$EC,$75,$B1,$00,$00,$23,$E3,$71,$8F
 dc.b $00,$00,$23,$DA,$71,$F3,$00,$00,$23,$D1,$76,$D9,$00,$00,$23,$C8,$80,$3E
 dc.b $00,$00,$23,$BF,$8E,$1E,$00,$00,$23,$B6,$A0,$76,$00,$00,$23,$AD,$B7,$42
 dc.b $00,$00,$23,$A4,$D2,$80,$00,$00,$23,$9B,$F2,$2B,$00,$00,$23,$93,$16,$42
 dc.b $00,$00,$23,$8A,$3E,$C0,$00,$00,$23,$81,$6B,$A1,$00,$00,$23,$78,$9C,$E4
 dc.b $00,$00,$23,$6F,$D2,$84,$00,$00,$23,$67,$0C,$7E,$00,$00,$23,$5E,$4A,$D0
 dc.b $00,$00,$23,$55,$8D,$75,$00,$00,$23,$4C,$D4,$6B,$00,$00,$23,$44,$1F,$AF
 dc.b $00,$00,$23,$3B,$6F,$3C,$00,$00,$23,$32,$C3,$11,$00,$00,$23,$2A,$1B,$2A
 dc.b $00,$00,$23,$21,$77,$84,$00,$00,$23,$18,$D8,$1B,$00,$00,$23,$10,$3C,$ED
 dc.b $00,$00,$23,$07,$A5,$F6,$00,$00,$22,$FF,$13,$34,$00,$00,$22,$F6,$84,$A3
 dc.b $00,$00,$22,$ED,$FA,$40,$00,$00,$22,$E5,$74,$08,$00,$00,$22,$DC,$F1,$F9
 dc.b $00,$00,$22,$D4,$74,$0E,$00,$00,$22,$CB,$FA,$46,$00,$00,$22,$C3,$84,$9C
 dc.b $00,$00,$22,$BB,$13,$0F,$00,$00,$22,$B2,$A5,$9A,$00,$00,$22,$AA,$3C,$3C
 dc.b $00,$00,$22,$A1,$D6,$F0,$00,$00,$22,$99,$75,$B5,$00,$00,$22,$91,$18,$87
 dc.b $00,$00,$22,$88,$BF,$63,$00,$00,$22,$80,$6A,$47,$00,$00,$22,$78,$19,$2E
 dc.b $00,$00,$22,$6F,$CC,$18,$00,$00,$22,$67,$83,$00,$00,$00,$22,$5F,$3D,$E3
 dc.b $00,$00,$22,$56,$FC,$C0,$00,$00,$22,$4E,$BF,$92,$00,$00,$22,$46,$86,$58
 dc.b $00,$00,$22,$3E,$51,$0E,$00,$00,$22,$36,$1F,$B1,$00,$00,$22,$2D,$F2,$3F
 dc.b $00,$00,$22,$25,$C8,$B5,$00,$00,$22,$1D,$A3,$10,$00,$00,$22,$15,$81,$4D
 dc.b $00,$00,$22,$0D,$63,$6A,$00,$00,$22,$05,$49,$64,$00,$00,$21,$FD,$33,$37
 dc.b $00,$00,$21,$F5,$20,$E2,$00,$00,$21,$ED,$12,$61,$00,$00,$21,$E5,$07,$B2
 dc.b $00,$00,$21,$DD,$00,$D2,$00,$00,$21,$D4,$FD,$BE,$00,$00,$21,$CC,$FE,$74
 dc.b $00,$00,$21,$C5,$02,$F1,$00,$00,$21,$BD,$0B,$33,$00,$00,$21,$B5,$17,$36
 dc.b $00,$00,$21,$AD,$26,$F8,$00,$00,$21,$A5,$3A,$76,$00,$00,$21,$9D,$51,$AE
 dc.b $00,$00,$21,$95,$6C,$9D,$00,$00,$21,$8D,$8B,$41,$00,$00,$21,$85,$AD,$97
 dc.b $00,$00,$21,$7D,$D3,$9B,$00,$00,$21,$75,$FD,$4D,$00,$00,$21,$6E,$2A,$A8
 dc.b $00,$00,$21,$66,$5B,$AC,$00,$00,$21,$5E,$90,$54,$00,$00,$21,$56,$C8,$9E
 dc.b $00,$00,$21,$4F,$04,$89,$00,$00,$21,$47,$44,$10,$00,$00,$21,$3F,$87,$33
 dc.b $00,$00,$21,$37,$CD,$EE,$00,$00,$21,$30,$18,$3F,$00,$00,$21,$28,$66,$23
 dc.b $00,$00,$21,$20,$B7,$98,$00,$00,$21,$19,$0C,$9B,$00,$00,$21,$11,$65,$2A
 dc.b $00,$00,$21,$09,$C1,$43,$00,$00,$21,$02,$20,$E3,$00,$00,$20,$FA,$84,$07
 dc.b $00,$00,$20,$F2,$EA,$AD,$00,$00,$20,$EB,$54,$D3,$00,$00,$20,$E3,$C2,$77
 dc.b $00,$00,$20,$DC,$33,$95,$00,$00,$20,$D4,$A8,$2C,$00,$00,$20,$CD,$20,$39
 dc.b $00,$00,$20,$C5,$9B,$B9,$00,$00,$20,$BE,$1A,$AB,$00,$00,$20,$B6,$9D,$0C
 dc.b $00,$00,$20,$AF,$22,$D9,$00,$00,$20,$A7,$AC,$11,$00,$00,$20,$A0,$38,$B1
 dc.b $00,$00,$20,$98,$C8,$B6,$00,$00,$20,$91,$5C,$1F,$00,$00,$20,$89,$F2,$E8
 dc.b $00,$00,$20,$82,$8D,$10,$00,$00,$20,$7B,$2A,$95,$00,$00,$20,$73,$CB,$74
 dc.b $00,$00,$20,$6C,$6F,$AA,$00,$00,$20,$65,$17,$36,$00,$00,$20,$5D,$C2,$16
 dc.b $00,$00,$20,$56,$70,$46,$00,$00,$20,$4F,$21,$C5,$00,$00,$20,$47,$D6,$91
 dc.b $00,$00,$20,$40,$8E,$A7,$00,$00,$20,$39,$4A,$05,$00,$00,$20,$32,$08,$A9
 dc.b $00,$00,$20,$2A,$CA,$90,$00,$00,$20,$23,$8F,$B9,$00,$00,$20,$1C,$58,$22
 dc.b $00,$00,$20,$15,$23,$C7,$00,$00,$20,$0D,$F2,$A7,$00,$00,$20,$06,$C4,$C0
 dc.b $00,$00,$1F,$FF,$9A,$10,$00,$00,$1F,$F8,$72,$94,$00,$00,$1F,$F1,$4E,$4A
 dc.b $00,$00,$1F,$EA,$2D,$30,$00,$00,$1F,$E3,$0F,$44,$00,$00,$1F,$DB,$F4,$84
 dc.b $00,$00,$1F,$D4,$DC,$EE,$00,$00,$1F,$CD,$C8,$80,$00,$00,$1F,$C6,$B7,$37
 dc.b $00,$00,$1F,$BF,$A9,$11,$00,$00,$1F,$B8,$9E,$0D,$00,$00,$1F,$B1,$96,$28
 dc.b $00,$00,$1F,$AA,$91,$60,$00,$00,$1F,$A3,$8F,$B3,$00,$00,$1F,$9C,$91,$20
 dc.b $00,$00,$1F,$95,$95,$A3,$00,$00,$1F,$8E,$9D,$3C,$00,$00,$1F,$87,$A7,$E7
 dc.b $00,$00,$1F,$80,$B5,$A3,$00,$00,$1F,$79,$C6,$6E,$00,$00,$1F,$72,$DA,$46
 dc.b $00,$00,$1F,$6B,$F1,$29,$00,$00,$1F,$65,$0B,$14,$00,$00,$1F,$5E,$28,$07
 dc.b $00,$00,$1F,$57,$47,$FE,$00,$00,$1F,$50,$6A,$F8,$00,$00,$1F,$49,$90,$F3
 dc.b $00,$00,$1F,$42,$B9,$ED,$00,$00,$1F,$3B,$E5,$E4,$00,$00,$1F,$35,$14,$D5
 dc.b $00,$00,$1F,$2E,$46,$C0,$00,$00,$1F,$27,$7B,$A2,$00,$00,$1F,$20,$B3,$7A
 dc.b $00,$00,$1F,$19,$EE,$44,$00,$00,$1F,$13,$2C,$00,$00,$00,$1F,$0C,$6C,$AB
 dc.b $00,$00,$1F,$05,$B0,$43,$00,$00,$1E,$FE,$F6,$C7,$00,$00,$1E,$F8,$40,$35
 dc.b $00,$00,$1E,$F1,$8C,$8B,$00,$00,$1E,$EA,$DB,$C7,$00,$00,$1E,$E4,$2D,$E6
 dc.b $00,$00,$1E,$DD,$82,$E8,$00,$00,$1E,$D6,$DA,$CA,$00,$00,$1E,$D0,$35,$8A
 dc.b $00,$00,$1E,$C9,$93,$27,$00,$00,$1E,$C2,$F3,$9F,$00,$00,$1E,$BC,$56,$F0
 dc.b $00,$00,$1E,$B5,$BD,$18,$00,$00,$1E,$AF,$26,$15,$00,$00,$1E,$A8,$91,$E5
 dc.b $00,$00,$1E,$A2,$00,$87,$00,$00,$1E,$9B,$71,$F9,$00,$00,$1E,$94,$E6,$38
 dc.b $00,$00,$1E,$8E,$5D,$44,$00,$00,$1E,$87,$D7,$1B,$00,$00,$1E,$81,$53,$BA
 dc.b $00,$00,$1E,$7A,$D3,$1F,$00,$00,$1E,$74,$55,$4A,$00,$00,$1E,$6D,$DA,$38
 dc.b $00,$00,$1E,$67,$61,$E8,$00,$00,$1E,$60,$EC,$57,$00,$00,$1E,$5A,$79,$84
 dc.b $00,$00,$1E,$54,$09,$6E,$00,$00,$1E,$4D,$9C,$12,$00,$00,$1E,$47,$31,$6F
 dc.b $00,$00,$1E,$40,$C9,$83,$00,$00,$1E,$3A,$64,$4D,$00,$00,$1E,$34,$01,$CA
 dc.b $00,$00,$1E,$2D,$A1,$F8,$00,$00,$1E,$27,$44,$D8,$00,$00,$1E,$20,$EA,$65
 dc.b $00,$00,$1E,$1A,$92,$A0,$00,$00,$1E,$14,$3D,$85,$00,$00,$1E,$0D,$EB,$14
 dc.b $00,$00,$1E,$07,$9B,$4B,$00,$00,$1E,$01,$4E,$28,$00,$00,$1D,$FB,$03,$A9
 dc.b $00,$00,$1D,$F4,$BB,$CD,$00,$00,$1D,$EE,$76,$93,$00,$00,$1D,$E8,$33,$F7
 dc.b $00,$00,$1D,$E1,$F3,$FA,$00,$00,$1D,$DB,$B6,$98,$00,$00,$1D,$D5,$7B,$D2
 dc.b $00,$00,$1D,$CF,$43,$A4,$00,$00,$1D,$C9,$0E,$0D,$00,$00,$1D,$C2,$DB,$0D
 dc.b $00,$00,$1D,$BC,$AA,$A0,$00,$00,$1D,$B6,$7C,$C5,$00,$00,$1D,$B0,$51,$7C
 dc.b $00,$00,$1D,$AA,$28,$C2,$00,$00,$1D,$A4,$02,$95,$00,$00,$1D,$9D,$DE,$F5
 dc.b $00,$00,$1D,$97,$BD,$DF,$00,$00,$1D,$91,$9F,$52,$00,$00,$1D,$8B,$83,$4C
 dc.b $00,$00,$1D,$85,$69,$CC,$00,$00,$1D,$7F,$52,$D1,$00,$00,$1D,$79,$3E,$58
 dc.b $00,$00,$1D,$73,$2C,$60,$00,$00,$1D,$6D,$1C,$E8,$00,$00,$1D,$67,$0F,$EE
 dc.b $00,$00,$1D,$61,$05,$70,$00,$00,$1D,$5A,$FD,$6D,$00,$00,$1D,$54,$F7,$E4
 dc.b $00,$00,$1D,$4E,$F4,$D2,$00,$00,$1D,$48,$F4,$37,$00,$00,$1D,$42,$F6,$11
 dc.b $00,$00,$1D,$3C,$FA,$5E,$00,$00,$1D,$37,$01,$1E,$00,$00,$1D,$31,$0A,$4D
 dc.b $00,$00,$1D,$2B,$15,$EC,$00,$00,$1D,$25,$23,$F7,$00,$00,$1D,$1F,$34,$6F
 dc.b $00,$00,$1D,$19,$47,$51,$00,$00,$1D,$13,$5C,$9D,$00,$00,$1D,$0D,$74,$4F
 dc.b $00,$00,$1D,$07,$8E,$68,$00,$00,$1D,$01,$AA,$E5,$00,$00,$1C,$FB,$C9,$C6
 dc.b $00,$00,$1C,$F5,$EB,$08,$00,$00,$1C,$F0,$0E,$AA,$00,$00,$1C,$EA,$34,$AB
 dc.b $00,$00,$1C,$E4,$5D,$0A,$00,$00,$1C,$DE,$87,$C4,$00,$00,$1C,$D8,$B4,$D9
 dc.b $00,$00,$1C,$D2,$E4,$47,$00,$00,$1C,$CD,$16,$0C,$00,$00,$1C,$C7,$4A,$28
 dc.b $00,$00,$1C,$C1,$80,$98,$00,$00,$1C,$BB,$B9,$5C,$00,$00,$1C,$B5,$F4,$72
 dc.b $00,$00,$1C,$B0,$31,$D9,$00,$00,$1C,$AA,$71,$8F,$00,$00,$1C,$A4,$B3,$93
 dc.b $00,$00,$1C,$9E,$F7,$E3,$00,$00,$1C,$99,$3E,$7E
