
; #### 25kHz frequency table ####

;*** Freq.-table: ***
;* extern unsigned short ftab2[3840];
;* void crefrqtb()
;* {
;*  unsigned short per;
;*  double work,freq_amiga=3579545.0,freq_st=25033.0/2;
;*  unsigned short *x;
;*  x = ftab2;
;*  for (per = 1 ; per <= (1024+256) ; per++) 
;*   {
;*    work = (freq_amiga/(double)per)/freq_st; /* whole part */
;*    *x++=(unsigned short)work;
;*    *(long *)x = (65536.0*frac(work)*65536.0); /* output frac */
;*    x+=2;		
;*   }
;* }
;* double frac(double x)
;* {
;*  long i=x;
;*  return (x - i);
;* }

.globl ftab25
ftab25:
 ds.w 3
 dc.b $01,$1D,$FC,$70,$F1,$04,$00,$8E,$FE,$38,$78,$82,$00,$5F,$54,$25,$A5,$AC
 dc.b $00,$47,$7F,$1C,$3C,$41,$00,$39,$32,$7C,$FD,$00,$00,$2F,$AA,$12,$D2,$D6
 dc.b $00,$28,$DA,$EB,$90,$25,$00,$23,$BF,$8E,$1E,$20,$00,$1F,$C6,$B7,$37,$39
 dc.b $00,$1C,$99,$3E,$7E,$80,$00,$19,$FF,$AD,$2D,$2E,$00,$17,$D5,$09,$69,$6B
 dc.b $00,$15,$FF,$B9,$EB,$27,$00,$14,$6D,$75,$C8,$12,$00,$13,$10,$D4,$54,$55
 dc.b $00,$11,$DF,$C7,$0F,$10,$00,$10,$D2,$9D,$3B,$5A,$00,$0F,$E3,$5B,$9B,$9C
 dc.b $00,$0F,$0D,$49,$50,$0D,$00,$0E,$4C,$9F,$3F,$40,$00,$0D,$9E,$4E,$85,$61
 dc.b $00,$0C,$FF,$D6,$96,$97,$00,$0C,$6F,$26,$4D,$42,$00,$0B,$EA,$84,$B4,$B5
 dc.b $00,$0B,$70,$7F,$65,$CC,$00,$0A,$FF,$DC,$F5,$93,$00,$0A,$97,$92,$67,$BD
 dc.b $00,$0A,$36,$BA,$E4,$09,$00,$09,$DC,$91,$22,$CB,$00,$09,$88,$6A,$2A,$2A
 dc.b $00,$09,$39,$B1,$10,$08,$00,$08,$EF,$E3,$87,$88,$00,$08,$AA,$8F,$0F,$0F
 dc.b $00,$08,$69,$4E,$9D,$AD,$00,$08,$2B,$C8,$B6,$6D,$00,$07,$F1,$AD,$CD,$CE
 dc.b $00,$07,$BA,$B6,$F1,$C1,$00,$07,$86,$A4,$A8,$06,$00,$07,$55,$3D,$F9,$0D
 dc.b $00,$07,$26,$4F,$9F,$A0,$00,$06,$F9,$AB,$57,$0C,$00,$06,$CF,$27,$42,$B0
 dc.b $00,$06,$A6,$9D,$6A,$D0,$00,$06,$7F,$EB,$4B,$4B,$00,$06,$5A,$F1,$71,$71
 dc.b $00,$06,$37,$93,$26,$A1,$00,$06,$15,$B6,$25,$CF,$00,$05,$F5,$42,$5A,$5A
 dc.b $00,$05,$D6,$21,$A6,$E0,$00,$05,$B8,$3F,$B2,$E6,$00,$05,$9B,$89,$BE,$73
 dc.b $00,$05,$7F,$EE,$7A,$C9,$00,$05,$65,$5D,$E7,$90,$00,$05,$4B,$C9,$33,$DE
 dc.b $00,$05,$33,$22,$A2,$A2,$00,$05,$1B,$5D,$72,$04,$00,$05,$04,$6D,$C5,$59
 dc.b $00,$04,$EE,$48,$91,$65,$00,$04,$D8,$E3,$8A,$97,$00,$04,$C4,$35,$15,$15
 dc.b $00,$04,$B0,$34,$36,$4F,$00,$04,$9C,$D8,$88,$04,$00,$04,$8A,$1A,$2C,$75
 dc.b $00,$04,$77,$F1,$C3,$C4,$00,$04,$66,$58,$62,$3B,$00,$04,$55,$47,$87,$87
 dc.b $00,$04,$44,$B9,$16,$B3,$00,$04,$34,$A7,$4E,$D6,$00,$04,$25,$0C,$C4,$6B
 dc.b $00,$04,$15,$E4,$5B,$36,$00,$04,$07,$29,$40,$B0,$00,$03,$F8,$D6,$E6,$E7
 dc.b $00,$03,$EA,$E8,$FF,$CB,$00,$03,$DD,$5B,$78,$E0,$00,$03,$D0,$2A,$77,$44
 dc.b $00,$03,$C3,$52,$54,$03,$00,$03,$B6,$CF,$98,$BD,$00,$03,$AA,$9E,$FC,$86
 dc.b $00,$03,$9E,$BD,$61,$06,$00,$03,$93,$27,$CF,$D0,$00,$03,$87,$DB,$77,$E9
 dc.b $00,$03,$7C,$D5,$AB,$86,$00,$03,$72,$13,$DD,$E4,$00,$03,$67,$93,$A1,$58
 dc.b $00,$03,$5D,$52,$A5,$78,$00,$03,$53,$4E,$B5,$68,$00,$03,$49,$85,$B6,$43
 dc.b $00,$03,$3F,$F5,$A5,$A5,$00,$03,$36,$9C,$98,$47,$00,$03,$2D,$78,$B8,$B8
 dc.b $00,$03,$24,$88,$46,$2A,$00,$03,$1B,$C9,$93,$50,$00,$03,$13,$3B,$05,$58
 dc.b $00,$03,$0A,$DB,$12,$E7,$00,$03,$02,$A8,$43,$35,$00,$02,$FA,$A1,$2D,$2D
 dc.b $00,$02,$F2,$C4,$76,$9B,$00,$02,$EB,$10,$D3,$70,$00,$02,$E3,$85,$05,$05
 dc.b $00,$02,$DC,$1F,$D9,$73,$00,$02,$D4,$E0,$2A,$F0,$00,$02,$CD,$C4,$DF,$39
 dc.b $00,$02,$C6,$CC,$E7,$00,$00,$02,$BF,$F7,$3D,$64,$00,$02,$B9,$42,$E7,$79
 dc.b $00,$02,$B2,$AE,$F3,$C8,$00,$02,$AC,$3A,$79,$E0,$00,$02,$A5,$E4,$99,$EF
 dc.b $00,$02,$9F,$AC,$7C,$56,$00,$02,$99,$91,$51,$51,$00,$02,$93,$92,$50,$95
 dc.b $00,$02,$8D,$AE,$B9,$02,$00,$02,$87,$E5,$D0,$4A,$00,$02,$82,$36,$E2,$AC
 dc.b $00,$02,$7C,$A1,$42,$A6,$00,$02,$77,$24,$48,$B2,$00,$02,$71,$BF,$53,$04
 dc.b $00,$02,$6C,$71,$C5,$4B,$00,$02,$67,$3B,$08,$7A,$00,$02,$62,$1A,$8A,$8A
 dc.b $00,$02,$5D,$0F,$BE,$4A,$00,$02,$58,$1A,$1B,$27,$00,$02,$53,$39,$1D,$04
 dc.b $00,$02,$4E,$6C,$44,$02,$00,$02,$49,$B3,$14,$5C,$00,$02,$45,$0D,$16,$3A
 dc.b $00,$02,$40,$79,$D5,$8D,$00,$02,$3B,$F8,$E1,$E2,$00,$02,$37,$89,$CE,$45
 dc.b $00,$02,$33,$2C,$31,$1D,$00,$02,$2E,$DF,$A4,$09,$00,$02,$2A,$A3,$C3,$C3
 dc.b $00,$02,$26,$78,$30,$01,$00,$02,$22,$5C,$8B,$59,$00,$02,$1E,$50,$7B,$25
 dc.b $00,$02,$1A,$53,$A7,$6B,$00,$02,$16,$65,$BA,$C0,$00,$02,$12,$86,$62,$35
 dc.b $00,$02,$0E,$B5,$4D,$3E,$00,$02,$0A,$F2,$2D,$9B,$00,$02,$07,$3C,$B7,$45
 dc.b $00,$02,$03,$94,$A0,$58,$00,$01,$FF,$F9,$A1,$03,$00,$01,$FC,$6B,$73,$73
 dc.b $00,$01,$F8,$E9,$D3,$C2,$00,$01,$F5,$74,$7F,$E5,$00,$01,$F2,$0B,$37,$A0
 dc.b $00,$01,$EE,$AD,$BC,$70,$00,$01,$EB,$5B,$D1,$82,$00,$01,$E8,$15,$3B,$A2
 dc.b $00,$01,$E4,$D9,$C1,$2C,$00,$01,$E1,$A9,$2A,$01,$00,$01,$DE,$83,$3F,$7B
 dc.b $00,$01,$DB,$67,$CC,$5E,$00,$01,$D8,$56,$9C,$CE,$00,$01,$D5,$4F,$7E,$43
 dc.b $00,$01,$D2,$52,$3F,$7F,$00,$01,$CF,$5E,$B0,$83,$00,$01,$CC,$74,$A2,$85
 dc.b $00,$01,$C9,$93,$E7,$E8,$00,$01,$C6,$BC,$54,$2E,$00,$01,$C3,$ED,$BB,$F4
 dc.b $00,$01,$C1,$27,$F4,$EA,$00,$01,$BE,$6A,$D5,$C3,$00,$01,$BB,$B6,$36,$36
 dc.b $00,$01,$B9,$09,$EE,$F2,$00,$01,$B6,$65,$D9,$96,$00,$01,$B3,$C9,$D0,$AC
 dc.b $00,$01,$B1,$35,$AF,$A0,$00,$01,$AE,$A9,$52,$BC,$00,$01,$AC,$24,$97,$1D
 dc.b $00,$01,$A9,$A7,$5A,$B4,$00,$01,$A7,$31,$7C,$36,$00,$01,$A4,$C2,$DB,$21
 dc.b $00,$01,$A2,$5B,$57,$AF,$00,$01,$9F,$FA,$D2,$D2,$00,$01,$9D,$A1,$2E,$32
 dc.b $00,$01,$9B,$4E,$4C,$23,$00,$01,$99,$02,$0F,$A5,$00,$01,$96,$BC,$5C,$5C
 dc.b $00,$01,$94,$7D,$16,$8C,$00,$01,$92,$44,$23,$15,$00,$01,$90,$11,$67,$6F
 dc.b $00,$01,$8D,$E4,$C9,$A8,$00,$01,$8B,$BE,$30,$59,$00,$01,$89,$9D,$82,$AC
 dc.b $00,$01,$87,$82,$A8,$4E,$00,$01,$85,$6D,$89,$73,$00,$01,$83,$5E,$0E,$D1
 dc.b $00,$01,$81,$54,$21,$9A,$00,$01,$7F,$4F,$AB,$7B,$00,$01,$7D,$50,$96,$96
 dc.b $00,$01,$7B,$56,$CD,$84,$00,$01,$79,$62,$3B,$4D,$00,$01,$77,$72,$CB,$69
 dc.b $00,$01,$75,$88,$69,$B8,$00,$01,$73,$A3,$02,$85,$00,$01,$71,$C2,$82,$82
 dc.b $00,$01,$6F,$E6,$D6,$C2,$00,$01,$6E,$0F,$EC,$B9,$00,$01,$6C,$3D,$B2,$3B
 dc.b $00,$01,$6A,$70,$15,$78,$00,$01,$68,$A7,$04,$F8,$00,$01,$66,$E2,$6F,$9C
 dc.b $00,$01,$65,$22,$44,$9C,$00,$01,$63,$66,$73,$80,$00,$01,$61,$AE,$EC,$23
 dc.b $00,$01,$5F,$FB,$9E,$B2,$00,$01,$5E,$4C,$7B,$A4,$00,$01,$5C,$A1,$73,$BC
 dc.b $00,$01,$5A,$FA,$78,$0A,$00,$01,$59,$57,$79,$E4,$00,$01,$57,$B8,$6A,$E5
 dc.b $00,$01,$56,$1D,$3C,$F0,$00,$01,$54,$85,$E2,$29,$00,$01,$52,$F2,$4C,$F7
 dc.b $00,$01,$51,$62,$70,$01,$00,$01,$4F,$D6,$3E,$2B,$00,$01,$4E,$4D,$AA,$99
 dc.b $00,$01,$4C,$C8,$A8,$A8,$00,$01,$4B,$47,$2B,$F3,$00,$01,$49,$C9,$28,$4A
 dc.b $00,$01,$48,$4E,$91,$B9,$00,$01,$46,$D7,$5C,$81,$00,$01,$45,$63,$7D,$16
 dc.b $00,$01,$43,$F2,$E8,$25,$00,$01,$42,$85,$92,$8A,$00,$01,$41,$1B,$71,$56
 dc.b $00,$01,$3F,$B4,$79,$C9,$00,$01,$3E,$50,$A1,$53,$00,$01,$3C,$EF,$DD,$94
 dc.b $00,$01,$3B,$92,$24,$59,$00,$01,$3A,$37,$6B,$9C,$00,$01,$38,$DF,$A9,$82
 dc.b $00,$01,$37,$8A,$D4,$5C,$00,$01,$36,$38,$E2,$A5,$00,$01,$34,$E9,$CB,$02
 dc.b $00,$01,$33,$9D,$84,$3D,$00,$01,$32,$54,$05,$4A,$00,$01,$31,$0D,$45,$45
 dc.b $00,$01,$2F,$C9,$3B,$6C,$00,$01,$2E,$87,$DF,$25,$00,$01,$2D,$49,$27,$F8
 dc.b $00,$01,$2C,$0D,$0D,$93,$00,$01,$2A,$D3,$87,$C6,$00,$01,$29,$9C,$8E,$82
 dc.b $00,$01,$28,$68,$19,$D9,$00,$01,$27,$36,$22,$01,$00,$01,$26,$06,$9F,$4C
 dc.b $00,$01,$24,$D9,$8A,$2E,$00,$01,$23,$AE,$DB,$39,$00,$01,$22,$86,$8B,$1D
 dc.b $00,$01,$21,$60,$92,$A8,$00,$01,$20,$3C,$EA,$C6,$00,$01,$1F,$1B,$8C,$7D
 dc.b $00,$01,$1D,$FC,$70,$F1,$00,$01,$1C,$DF,$91,$5F,$00,$01,$1B,$C4,$E7,$22
 dc.b $00,$01,$1A,$AC,$6B,$AD,$00,$01,$19,$96,$18,$8E,$00,$01,$18,$81,$E7,$6B
 dc.b $00,$01,$17,$6F,$D2,$04,$00,$01,$16,$5F,$D2,$31,$00,$01,$15,$51,$E1,$E1
 dc.b $00,$01,$14,$45,$FB,$1C,$00,$01,$13,$3C,$18,$00,$00,$01,$12,$34,$32,$C2
 dc.b $00,$01,$11,$2E,$45,$AC,$00,$01,$10,$2A,$4B,$20,$00,$01,$0F,$28,$3D,$92
 dc.b $00,$01,$0E,$28,$17,$8F,$00,$01,$0D,$29,$D3,$B5,$00,$01,$0C,$2D,$6C,$B8
 dc.b $00,$01,$0B,$32,$DD,$60,$00,$01,$0A,$3A,$20,$86,$00,$01,$09,$43,$31,$1A
 dc.b $00,$01,$08,$4E,$0A,$1C,$00,$01,$07,$5A,$A6,$9F,$00,$01,$06,$69,$01,$C8
 dc.b $00,$01,$05,$79,$16,$CD,$00,$01,$04,$8A,$E0,$F8,$00,$01,$03,$9E,$5B,$A2
 dc.b $00,$01,$02,$B3,$82,$35,$00,$01,$01,$CA,$50,$2C,$00,$01,$00,$E2,$C1,$11
 dc.b $00,$00,$FF,$FC,$D0,$81,$00,$00,$FF,$18,$7A,$26,$00,$00,$FE,$35,$B9,$B9
 dc.b $00,$00,$FD,$54,$8B,$05,$00,$00,$FC,$74,$E9,$E1,$00,$00,$FB,$96,$D2,$33
 dc.b $00,$00,$FA,$BA,$3F,$F2,$00,$00,$F9,$DF,$2F,$21,$00,$00,$F9,$05,$9B,$D0
 dc.b $00,$00,$F8,$2D,$82,$1E,$00,$00,$F7,$56,$DE,$38,$00,$00,$F6,$81,$AC,$57
 dc.b $00,$00,$F5,$AD,$E8,$C1,$00,$00,$F4,$DB,$8F,$CA,$00,$00,$F4,$0A,$9D,$D1
 dc.b $00,$00,$F3,$3B,$0F,$42,$00,$00,$F2,$6C,$E0,$96,$00,$00,$F1,$A0,$0E,$50
 dc.b $00,$00,$F0,$D4,$95,$00,$00,$00,$F0,$0A,$71,$43,$00,$00,$EF,$41,$9F,$BD
 dc.b $00,$00,$EE,$7A,$1D,$23,$00,$00,$ED,$B3,$E6,$2F,$00,$00,$EC,$EE,$F7,$AA
 dc.b $00,$00,$EC,$2B,$4E,$67,$00,$00,$EB,$68,$E7,$41,$00,$00,$EA,$A7,$BF,$21
 dc.b $00,$00,$E9,$E7,$D2,$F7,$00,$00,$E9,$29,$1F,$BF,$00,$00,$E8,$6B,$A2,$7D
 dc.b $00,$00,$E7,$AF,$58,$41,$00,$00,$E6,$F4,$3E,$22,$00,$00,$E6,$3A,$51,$42
 dc.b $00,$00,$E5,$81,$8E,$CC,$00,$00,$E4,$C9,$F3,$F4,$00,$00,$E4,$13,$7D,$F5
 dc.b $00,$00,$E3,$5E,$2A,$17,$00,$00,$E2,$A9,$F5,$A6,$00,$00,$E1,$F6,$DD,$FA
 dc.b $00,$00,$E1,$44,$E0,$72,$00,$00,$E0,$93,$FA,$75,$00,$00,$DF,$E4,$29,$72
 dc.b $00,$00,$DF,$35,$6A,$E1,$00,$00,$DE,$87,$BC,$42,$00,$00,$DD,$DB,$1B,$1B
 dc.b $00,$00,$DD,$2F,$84,$FB,$00,$00,$DC,$84,$F7,$79,$00,$00,$DB,$DB,$70,$31
 dc.b $00,$00,$DB,$32,$EC,$CB,$00,$00,$DA,$8B,$6A,$F0,$00,$00,$D9,$E4,$E8,$56
 dc.b $00,$00,$D9,$3F,$62,$B5,$00,$00,$D8,$9A,$D7,$D0,$00,$00,$D7,$F7,$45,$6E
 dc.b $00,$00,$D7,$54,$A9,$5E,$00,$00,$D6,$B3,$01,$75,$00,$00,$D6,$12,$4B,$8E
 dc.b $00,$00,$D5,$72,$85,$8D,$00,$00,$D4,$D3,$AD,$5A,$00,$00,$D4,$35,$C0,$E2
 dc.b $00,$00,$D3,$98,$BE,$1B,$00,$00,$D2,$FC,$A3,$00,$00,$00,$D2,$61,$6D,$90
 dc.b $00,$00,$D1,$C7,$1B,$D4,$00,$00,$D1,$2D,$AB,$D7,$00,$00,$D0,$95,$1B,$AC
 dc.b $00,$00,$CF,$FD,$69,$69,$00,$00,$CF,$66,$93,$2C,$00,$00,$CE,$D0,$97,$19
 dc.b $00,$00,$CE,$3B,$73,$56,$00,$00,$CD,$A7,$26,$11,$00,$00,$CD,$13,$AD,$7E
 dc.b $00,$00,$CC,$81,$07,$D2,$00,$00,$CB,$EF,$33,$4D,$00,$00,$CB,$5E,$2E,$2E
 dc.b $00,$00,$CA,$CD,$F6,$BD,$00,$00,$CA,$3E,$8B,$46,$00,$00,$C9,$AF,$EA,$18
 dc.b $00,$00,$C9,$22,$11,$8A,$00,$00,$C8,$94,$FF,$F5,$00,$00,$C8,$08,$B3,$B7
 dc.b $00,$00,$C7,$7D,$2B,$35,$00,$00,$C6,$F2,$64,$D4,$00,$00,$C6,$68,$5F,$01
 dc.b $00,$00,$C5,$DF,$18,$2C,$00,$00,$C5,$56,$8E,$CB,$00,$00,$C4,$CE,$C1,$56
 dc.b $00,$00,$C4,$47,$AE,$49,$00,$00,$C3,$C1,$54,$27,$00,$00,$C3,$3B,$B1,$74
 dc.b $00,$00,$C2,$B6,$C4,$B9,$00,$00,$C2,$32,$8C,$85,$00,$00,$C1,$AF,$07,$68
 dc.b $00,$00,$C1,$2C,$33,$F8,$00,$00,$C0,$AA,$10,$CD,$00,$00,$C0,$28,$9C,$84
 dc.b $00,$00,$BF,$A7,$D5,$BD,$00,$00,$BF,$27,$BB,$1D,$00,$00,$BE,$A8,$4B,$4B
 dc.b $00,$00,$BE,$29,$84,$F2,$00,$00,$BD,$AB,$66,$C2,$00,$00,$BD,$2D,$EF,$6C
 dc.b $00,$00,$BC,$B1,$1D,$A6,$00,$00,$BC,$34,$F0,$2A,$00,$00,$BB,$B9,$65,$B4
 dc.b $00,$00,$BB,$3E,$7D,$03,$00,$00,$BA,$C4,$34,$DC,$00,$00,$BA,$4A,$8C,$03
 dc.b $00,$00,$B9,$D1,$81,$42,$00,$00,$B9,$59,$13,$67,$00,$00,$B8,$E1,$41,$41
 dc.b $00,$00,$B8,$6A,$09,$A2,$00,$00,$B7,$F3,$6B,$61,$00,$00,$B7,$7D,$65,$55
 dc.b $00,$00,$B7,$07,$F6,$5C,$00,$00,$B6,$93,$1D,$54,$00,$00,$B6,$1E,$D9,$1D
 dc.b $00,$00,$B5,$AB,$28,$9E,$00,$00,$B5,$38,$0A,$BC,$00,$00,$B4,$C5,$7E,$61
 dc.b $00,$00,$B4,$53,$82,$7C,$00,$00,$B3,$E2,$15,$FA,$00,$00,$B3,$71,$37,$CE
 dc.b $00,$00,$B3,$00,$E6,$ED,$00,$00,$B2,$91,$22,$4E,$00,$00,$B2,$21,$E8,$EA
 dc.b $00,$00,$B1,$B3,$39,$C0,$00,$00,$B1,$45,$13,$CC,$00,$00,$B0,$D7,$76,$11
 dc.b $00,$00,$B0,$6A,$5F,$94,$00,$00,$AF,$FD,$CF,$59,$00,$00,$AF,$91,$C4,$6A
 dc.b $00,$00,$AF,$26,$3D,$D2,$00,$00,$AE,$BB,$3A,$9E,$00,$00,$AE,$50,$B9,$DE
 dc.b $00,$00,$AD,$E6,$BA,$A4,$00,$00,$AD,$7D,$3C,$05,$00,$00,$AD,$14,$3D,$17
 dc.b $00,$00,$AC,$AB,$BC,$F2,$00,$00,$AC,$43,$BA,$B1,$00,$00,$AB,$DC,$35,$72
 dc.b $00,$00,$AB,$75,$2C,$54,$00,$00,$AB,$0E,$9E,$78,$00,$00,$AA,$A8,$8B,$01
 dc.b $00,$00,$AA,$42,$F1,$14,$00,$00,$A9,$DD,$CF,$DA,$00,$00,$A9,$79,$26,$7B
 dc.b $00,$00,$A9,$14,$F4,$24,$00,$00,$A8,$B1,$38,$00,$00,$00,$A8,$4D,$F1,$40
 dc.b $00,$00,$A7,$EB,$1F,$15,$00,$00,$A7,$88,$C0,$B2,$00,$00,$A7,$26,$D5,$4C
 dc.b $00,$00,$A6,$C5,$5C,$1A,$00,$00,$A6,$64,$54,$54,$00,$00,$A6,$03,$BD,$35
 dc.b $00,$00,$A5,$A3,$95,$F9,$00,$00,$A5,$43,$DD,$DF,$00,$00,$A4,$E4,$94,$25
 dc.b $00,$00,$A4,$85,$B8,$0E,$00,$00,$A4,$27,$48,$DC,$00,$00,$A3,$C9,$45,$D6
 dc.b $00,$00,$A3,$6B,$AE,$40,$00,$00,$A3,$0E,$81,$64,$00,$00,$A2,$B1,$BE,$8B
 dc.b $00,$00,$A2,$55,$65,$01,$00,$00,$A1,$F9,$74,$12,$00,$00,$A1,$9D,$EB,$0E
 dc.b $00,$00,$A1,$42,$C9,$45,$00,$00,$A0,$E8,$0E,$08,$00,$00,$A0,$8D,$B8,$AB
 dc.b $00,$00,$A0,$33,$C8,$82,$00,$00,$9F,$DA,$3C,$E4,$00,$00,$9F,$81,$15,$29
 dc.b $00,$00,$9F,$28,$50,$A9,$00,$00,$9E,$CF,$EE,$C0,$00,$00,$9E,$77,$EE,$CA
 dc.b $00,$00,$9E,$20,$50,$23,$00,$00,$9D,$C9,$12,$2C,$00,$00,$9D,$72,$34,$44
 dc.b $00,$00,$9D,$1B,$B5,$CE,$00,$00,$9C,$C5,$96,$2B,$00,$00,$9C,$6F,$D4,$C1
 dc.b $00,$00,$9C,$1A,$70,$F5,$00,$00,$9B,$C5,$6A,$2E,$00,$00,$9B,$70,$BF,$D5
 dc.b $00,$00,$9B,$1C,$71,$52,$00,$00,$9A,$C8,$7E,$12,$00,$00,$9A,$74,$E5,$81
 dc.b $00,$00,$9A,$21,$A7,$0A,$00,$00,$99,$CE,$C2,$1E,$00,$00,$99,$7C,$36,$2C
 dc.b $00,$00,$99,$2A,$02,$A5,$00,$00,$98,$D8,$26,$FB,$00,$00,$98,$86,$A2,$A2
 dc.b $00,$00,$98,$35,$75,$0E,$00,$00,$97,$E4,$9D,$B6,$00,$00,$97,$94,$1C,$0F
 dc.b $00,$00,$97,$43,$EF,$92,$00,$00,$96,$F4,$17,$B8,$00,$00,$96,$A4,$93,$FC
 dc.b $00,$00,$96,$55,$63,$D8,$00,$00,$96,$06,$86,$C9,$00,$00,$95,$B7,$FC,$4E
 dc.b $00,$00,$95,$69,$C3,$E3,$00,$00,$95,$1B,$DD,$09,$00,$00,$94,$CE,$47,$41
 dc.b $00,$00,$94,$81,$02,$0B,$00,$00,$94,$34,$0C,$EC,$00,$00,$93,$E7,$67,$67
 dc.b $00,$00,$93,$9B,$11,$00,$00,$00,$93,$4F,$09,$3D,$00,$00,$93,$03,$4F,$A6
 dc.b $00,$00,$92,$B7,$E3,$C0,$00,$00,$92,$6C,$C5,$17,$00,$00,$92,$21,$F3,$32
 dc.b $00,$00,$91,$D7,$6D,$9C,$00,$00,$91,$8D,$33,$E1,$00,$00,$91,$43,$45,$8E
 dc.b $00,$00,$90,$F9,$A2,$30,$00,$00,$90,$B0,$49,$54,$00,$00,$90,$67,$3A,$8A
 dc.b $00,$00,$90,$1E,$75,$63,$00,$00,$8F,$D5,$F9,$6E,$00,$00,$8F,$8D,$C6,$3E
 dc.b $00,$00,$8F,$45,$DB,$66,$00,$00,$8E,$FE,$38,$78,$00,$00,$8E,$B6,$DD,$09
 dc.b $00,$00,$8E,$6F,$C8,$AF,$00,$00,$8E,$28,$FB,$00,$00,$00,$8D,$E2,$73,$91
 dc.b $00,$00,$8D,$9C,$31,$FB,$00,$00,$8D,$56,$35,$D6,$00,$00,$8D,$10,$7E,$BC
 dc.b $00,$00,$8C,$CB,$0C,$47,$00,$00,$8C,$85,$DE,$11,$00,$00,$8C,$40,$F3,$B5
 dc.b $00,$00,$8B,$FC,$4C,$D1,$00,$00,$8B,$B7,$E9,$02,$00,$00,$8B,$73,$C7,$E5
 dc.b $00,$00,$8B,$2F,$E9,$18,$00,$00,$8A,$EC,$4C,$3C,$00,$00,$8A,$A8,$F0,$F0
 dc.b $00,$00,$8A,$65,$D6,$D6,$00,$00,$8A,$22,$FD,$8E,$00,$00,$89,$E0,$64,$BB
 dc.b $00,$00,$89,$9E,$0C,$00,$00,$00,$89,$5B,$F3,$00,$00,$00,$89,$1A,$19,$61
 dc.b $00,$00,$88,$D8,$7E,$C6,$00,$00,$88,$97,$22,$D6,$00,$00,$88,$56,$05,$37
 dc.b $00,$00,$88,$15,$25,$90,$00,$00,$87,$D4,$83,$88,$00,$00,$87,$94,$1E,$C9
 dc.b $00,$00,$87,$53,$F6,$FB,$00,$00,$87,$14,$0B,$C7,$00,$00,$86,$D4,$5C,$D9
 dc.b $00,$00,$86,$94,$E9,$DA,$00,$00,$86,$55,$B2,$77,$00,$00,$86,$16,$B6,$5C
 dc.b $00,$00,$85,$D7,$F5,$35,$00,$00,$85,$99,$6E,$B0,$00,$00,$85,$5B,$22,$7A
 dc.b $00,$00,$85,$1D,$10,$43,$00,$00,$84,$DF,$37,$B9,$00,$00,$84,$A1,$98,$8D
 dc.b $00,$00,$84,$64,$32,$6E,$00,$00,$84,$27,$05,$0E,$00,$00,$83,$EA,$10,$1D
 dc.b $00,$00,$83,$AD,$53,$4F,$00,$00,$83,$70,$CE,$55,$00,$00,$83,$34,$80,$E4
 dc.b $00,$00,$82,$F8,$6A,$AD,$00,$00,$82,$BC,$8B,$66,$00,$00,$82,$80,$E2,$C4
 dc.b $00,$00,$82,$45,$70,$7C,$00,$00,$82,$0A,$34,$43,$00,$00,$81,$CF,$2D,$D1
 dc.b $00,$00,$81,$94,$5C,$DB,$00,$00,$81,$59,$C1,$1A,$00,$00,$81,$1F,$5A,$45
 dc.b $00,$00,$80,$E5,$28,$16,$00,$00,$80,$AB,$2A,$43,$00,$00,$80,$71,$60,$88
 dc.b $00,$00,$80,$37,$CA,$9F,$00,$00,$7F,$FE,$68,$40,$00,$00,$7F,$C5,$39,$29
 dc.b $00,$00,$7F,$8C,$3D,$13,$00,$00,$7F,$53,$73,$BA,$00,$00,$7F,$1A,$DC,$DC
 dc.b $00,$00,$7E,$E2,$78,$35,$00,$00,$7E,$AA,$45,$82,$00,$00,$7E,$72,$44,$81
 dc.b $00,$00,$7E,$3A,$74,$F0,$00,$00,$7E,$02,$D6,$8E,$00,$00,$7D,$CB,$69,$19
 dc.b $00,$00,$7D,$94,$2C,$52,$00,$00,$7D,$5D,$1F,$F9,$00,$00,$7D,$26,$43,$CD
 dc.b $00,$00,$7C,$EF,$97,$90,$00,$00,$7C,$B9,$1B,$03,$00,$00,$7C,$82,$CD,$E8
 dc.b $00,$00,$7C,$4C,$B0,$00,$00,$00,$7C,$16,$C1,$0F,$00,$00,$7B,$E1,$00,$D7
 dc.b $00,$00,$7B,$AB,$6F,$1C,$00,$00,$7B,$76,$0B,$A1,$00,$00,$7B,$40,$D6,$2B
 dc.b $00,$00,$7B,$0B,$CE,$7E,$00,$00,$7A,$D6,$F4,$60,$00,$00,$7A,$A2,$47,$96
 dc.b $00,$00,$7A,$6D,$C7,$E5,$00,$00,$7A,$39,$75,$13,$00,$00,$7A,$05,$4E,$E8
 dc.b $00,$00,$79,$D1,$55,$2A,$00,$00,$79,$9D,$87,$A1,$00,$00,$79,$69,$E6,$13
 dc.b $00,$00,$79,$36,$70,$4B,$00,$00,$79,$03,$26,$0E,$00,$00,$78,$D0,$07,$28
 dc.b $00,$00,$78,$9D,$13,$60,$00,$00,$78,$6A,$4A,$80,$00,$00,$78,$37,$AC,$52
 dc.b $00,$00,$78,$05,$38,$A1,$00,$00,$77,$D2,$EF,$37,$00,$00,$77,$A0,$CF,$DE
 dc.b $00,$00,$77,$6E,$DA,$63,$00,$00,$77,$3D,$0E,$91,$00,$00,$77,$0B,$6C,$34
 dc.b $00,$00,$76,$D9,$F3,$17,$00,$00,$76,$A8,$A3,$09,$00,$00,$76,$77,$7B,$D5
 dc.b $00,$00,$76,$46,$7D,$49,$00,$00,$76,$15,$A7,$33,$00,$00,$75,$E4,$F9,$61
 dc.b $00,$00,$75,$B4,$73,$A0,$00,$00,$75,$84,$15,$C1,$00,$00,$75,$53,$DF,$90
 dc.b $00,$00,$75,$23,$D0,$DF,$00,$00,$74,$F3,$E9,$7B,$00,$00,$74,$C4,$29,$36
 dc.b $00,$00,$74,$94,$8F,$DF,$00,$00,$74,$65,$1D,$47,$00,$00,$74,$35,$D1,$3E
 dc.b $00,$00,$74,$06,$AB,$96,$00,$00,$73,$D7,$AC,$20,$00,$00,$73,$A8,$D2,$AE
 dc.b $00,$00,$73,$7A,$1F,$11,$00,$00,$73,$4B,$91,$1C,$00,$00,$73,$1D,$28,$A1
 dc.b $00,$00,$72,$EE,$E5,$73,$00,$00,$72,$C0,$C7,$66,$00,$00,$72,$92,$CE,$4C
 dc.b $00,$00,$72,$64,$F9,$FA,$00,$00,$72,$37,$4A,$42,$00,$00,$72,$09,$BE,$FA
 dc.b $00,$00,$71,$DC,$57,$F6,$00,$00,$71,$AF,$15,$0B,$00,$00,$71,$81,$F6,$0D
 dc.b $00,$00,$71,$54,$FA,$D3,$00,$00,$71,$28,$23,$31,$00,$00,$70,$FB,$6E,$FD
 dc.b $00,$00,$70,$CE,$DE,$0D,$00,$00,$70,$A2,$70,$39,$00,$00,$70,$76,$25,$55
 dc.b $00,$00,$70,$49,$FD,$3A,$00,$00,$70,$1D,$F7,$BE,$00,$00,$6F,$F2,$14,$B9
 dc.b $00,$00,$6F,$C6,$54,$01,$00,$00,$6F,$9A,$B5,$70,$00,$00,$6F,$6F,$38,$DD
 dc.b $00,$00,$6F,$43,$DE,$21,$00,$00,$6F,$18,$A5,$13,$00,$00,$6E,$ED,$8D,$8D
 dc.b $00,$00,$6E,$C2,$97,$68,$00,$00,$6E,$97,$C2,$7D,$00,$00,$6E,$6D,$0E,$A6
 dc.b $00,$00,$6E,$42,$7B,$BC,$00,$00,$6E,$18,$09,$99,$00,$00,$6D,$ED,$B8,$18
 dc.b $00,$00,$6D,$C3,$87,$13,$00,$00,$6D,$99,$76,$65,$00,$00,$6D,$6F,$85,$E8
 dc.b $00,$00,$6D,$45,$B5,$78,$00,$00,$6D,$1C,$04,$EF,$00,$00,$6C,$F2,$74,$2B
 dc.b $00,$00,$6C,$C9,$03,$05,$00,$00,$6C,$9F,$B1,$5A,$00,$00,$6C,$76,$7F,$07
 dc.b $00,$00,$6C,$4D,$6B,$E8,$00,$00,$6C,$24,$77,$D9,$00,$00,$6B,$FB,$A2,$B7
 dc.b $00,$00,$6B,$D2,$EC,$5F,$00,$00,$6B,$AA,$54,$AF,$00,$00,$6B,$81,$DB,$83
 dc.b $00,$00,$6B,$59,$80,$BA,$00,$00,$6B,$31,$44,$31,$00,$00,$6B,$09,$25,$C7
 dc.b $00,$00,$6A,$E1,$25,$59,$00,$00,$6A,$B9,$42,$C6,$00,$00,$6A,$91,$7D,$ED
 dc.b $00,$00,$6A,$69,$D6,$AD,$00,$00,$6A,$42,$4C,$E3,$00,$00,$6A,$1A,$E0,$71
 dc.b $00,$00,$69,$F3,$91,$34,$00,$00,$69,$CC,$5F,$0D,$00,$00,$69,$A5,$49,$DC
 dc.b $00,$00,$69,$7E,$51,$80,$00,$00,$69,$57,$75,$D9,$00,$00,$69,$30,$B6,$C8
 dc.b $00,$00,$69,$0A,$14,$2D,$00,$00,$68,$E3,$8D,$EA,$00,$00,$68,$BD,$23,$DE
 dc.b $00,$00,$68,$96,$D5,$EB,$00,$00,$68,$70,$A3,$F3,$00,$00,$68,$4A,$8D,$D6
 dc.b $00,$00,$68,$24,$93,$75,$00,$00,$67,$FE,$B4,$B4,$00,$00,$67,$D8,$F1,$74
 dc.b $00,$00,$67,$B3,$49,$96,$00,$00,$67,$8D,$BC,$FD,$00,$00,$67,$68,$4B,$8C
 dc.b $00,$00,$67,$42,$F5,$25,$00,$00,$67,$1D,$B9,$AB,$00,$00,$66,$F8,$99,$00
 dc.b $00,$00,$66,$D3,$93,$08,$00,$00,$66,$AE,$A7,$A7,$00,$00,$66,$89,$D6,$BF
 dc.b $00,$00,$66,$65,$20,$33,$00,$00,$66,$40,$83,$E9,$00,$00,$66,$1C,$01,$C3
 dc.b $00,$00,$65,$F7,$99,$A6,$00,$00,$65,$D3,$4B,$76,$00,$00,$65,$AF,$17,$17
 dc.b $00,$00,$65,$8A,$FC,$6D,$00,$00,$65,$66,$FB,$5E,$00,$00,$65,$43,$13,$CE
 dc.b $00,$00,$65,$1F,$45,$A3,$00,$00,$64,$FB,$90,$C0,$00,$00,$64,$D7,$F5,$0C
 dc.b $00,$00,$64,$B4,$72,$6C,$00,$00,$64,$91,$08,$C5,$00,$00,$64,$6D,$B7,$FD
 dc.b $00,$00,$64,$4A,$7F,$FA,$00,$00,$64,$27,$60,$A2,$00,$00,$64,$04,$59,$DB
 dc.b $00,$00,$63,$E1,$6B,$8C,$00,$00,$63,$BE,$95,$9A,$00,$00,$63,$9B,$D7,$EC
 dc.b $00,$00,$63,$79,$32,$6A,$00,$00,$63,$56,$A4,$F9,$00,$00,$63,$34,$2F,$80
 dc.b $00,$00,$63,$11,$D1,$E8,$00,$00,$62,$EF,$8C,$16,$00,$00,$62,$CD,$5D,$F3
 dc.b $00,$00,$62,$AB,$47,$65,$00,$00,$62,$89,$48,$55,$00,$00,$62,$67,$60,$AB
 dc.b $00,$00,$62,$45,$90,$4D,$00,$00,$62,$23,$D7,$24,$00,$00,$62,$02,$35,$19
 dc.b $00,$00,$61,$E0,$AA,$13,$00,$00,$61,$BF,$35,$FB,$00,$00,$61,$9D,$D8,$BA
 dc.b $00,$00,$61,$7C,$92,$37,$00,$00,$61,$5B,$62,$5C,$00,$00,$61,$3A,$49,$13
 dc.b $00,$00,$61,$19,$46,$42,$00,$00,$60,$F8,$59,$D5,$00,$00,$60,$D7,$83,$B4
 dc.b $00,$00,$60,$B6,$C3,$C8,$00,$00,$60,$96,$19,$FC,$00,$00,$60,$75,$86,$38
 dc.b $00,$00,$60,$55,$08,$66,$00,$00,$60,$34,$A0,$71,$00,$00,$60,$14,$4E,$42
 dc.b $00,$00,$5F,$F4,$11,$C3,$00,$00,$5F,$D3,$EA,$DE,$00,$00,$5F,$B3,$D9,$7F
 dc.b $00,$00,$5F,$93,$DD,$8E,$00,$00,$5F,$73,$F6,$F7,$00,$00,$5F,$54,$25,$A5
 dc.b $00,$00,$5F,$34,$69,$82,$00,$00,$5F,$14,$C2,$79,$00,$00,$5E,$F5,$30,$75
 dc.b $00,$00,$5E,$D5,$B3,$61,$00,$00,$5E,$B6,$4B,$28,$00,$00,$5E,$96,$F7,$B6
 dc.b $00,$00,$5E,$77,$B8,$F6,$00,$00,$5E,$58,$8E,$D3,$00,$00,$5E,$39,$79,$39
 dc.b $00,$00,$5E,$1A,$78,$15,$00,$00,$5D,$FB,$8B,$51,$00,$00,$5D,$DC,$B2,$DA
 dc.b $00,$00,$5D,$BD,$EE,$9B,$00,$00,$5D,$9F,$3E,$81,$00,$00,$5D,$80,$A2,$79
 dc.b $00,$00,$5D,$62,$1A,$6E,$00,$00,$5D,$43,$A6,$4C,$00,$00,$5D,$25,$46,$01
 dc.b $00,$00,$5D,$06,$F9,$79,$00,$00,$5C,$E8,$C0,$A1,$00,$00,$5C,$CA,$9B,$65
 dc.b $00,$00,$5C,$AC,$89,$B3,$00,$00,$5C,$8E,$8B,$78,$00,$00,$5C,$70,$A0,$A0
 dc.b $00,$00,$5C,$52,$C9,$19,$00,$00,$5C,$35,$04,$D1,$00,$00,$5C,$17,$53,$B4
 dc.b $00,$00,$5B,$F9,$B5,$B0,$00,$00,$5B,$DC,$2A,$B3,$00,$00,$5B,$BE,$B2,$AA
 dc.b $00,$00,$5B,$A1,$4D,$84,$00,$00,$5B,$83,$FB,$2E,$00,$00,$5B,$66,$BB,$96
 dc.b $00,$00,$5B,$49,$8E,$AA,$00,$00,$5B,$2C,$74,$58,$00,$00,$5B,$0F,$6C,$8E
 dc.b $00,$00,$5A,$F2,$77,$3C,$00,$00,$5A,$D5,$94,$4F,$00,$00,$5A,$B8,$C3,$B5
 dc.b $00,$00,$5A,$9C,$05,$5E,$00,$00,$5A,$7F,$59,$37,$00,$00,$5A,$62,$BF,$30
 dc.b $00,$00,$5A,$46,$37,$38,$00,$00,$5A,$29,$C1,$3E,$00,$00,$5A,$0D,$5D,$2F
 dc.b $00,$00,$59,$F1,$0A,$FD,$00,$00,$59,$D4,$CA,$95,$00,$00,$59,$B8,$9B,$E7
 dc.b $00,$00,$59,$9C,$7E,$E2,$00,$00,$59,$80,$73,$76,$00,$00,$59,$64,$79,$92
 dc.b $00,$00,$59,$48,$91,$27,$00,$00,$59,$2C,$BA,$22,$00,$00,$59,$10,$F4,$75
 dc.b $00,$00,$58,$F5,$40,$0F,$00,$00,$58,$D9,$9C,$E0,$00,$00,$58,$BE,$0A,$D7
 dc.b $00,$00,$58,$A2,$89,$E6,$00,$00,$58,$87,$19,$FB,$00,$00,$58,$6B,$BB,$08
 dc.b $00,$00,$58,$50,$6C,$FD,$00,$00,$58,$35,$2F,$CA,$00,$00,$58,$1A,$03,$5E
 dc.b $00,$00,$57,$FE,$E7,$AC,$00,$00,$57,$E3,$DC,$A3,$00,$00,$57,$C8,$E2,$35
 dc.b $00,$00,$57,$AD,$F8,$51,$00,$00,$57,$93,$1E,$E9,$00,$00,$57,$78,$55,$ED
 dc.b $00,$00,$57,$5D,$9D,$4F,$00,$00,$57,$42,$F4,$FF,$00,$00,$57,$28,$5C,$EF
 dc.b $00,$00,$57,$0D,$D5,$0F,$00,$00,$56,$F3,$5D,$52,$00,$00,$56,$D8,$F5,$A8
 dc.b $00,$00,$56,$BE,$9E,$02,$00,$00,$56,$A4,$56,$53,$00,$00,$56,$8A,$1E,$8B
 dc.b $00,$00,$56,$6F,$F6,$9C,$00,$00,$56,$55,$DE,$79,$00,$00,$56,$3B,$D6,$11
 dc.b $00,$00,$56,$21,$DD,$58,$00,$00,$56,$07,$F4,$40,$00,$00,$55,$EE,$1A,$B9
 dc.b $00,$00,$55,$D4,$50,$B6,$00,$00,$55,$BA,$96,$2A,$00,$00,$55,$A0,$EB,$05
 dc.b $00,$00,$55,$87,$4F,$3C,$00,$00,$55,$6D,$C2,$BE,$00,$00,$55,$54,$45,$80
 dc.b $00,$00,$55,$3A,$D7,$73,$00,$00,$55,$21,$78,$8A,$00,$00,$55,$08,$28,$B7
 dc.b $00,$00,$54,$EE,$E7,$ED,$00,$00,$54,$D5,$B6,$1E,$00,$00,$54,$BC,$93,$3D
 dc.b $00,$00,$54,$A3,$7F,$3E,$00,$00,$54,$8A,$7A,$12,$00,$00,$54,$71,$83,$AC
 dc.b $00,$00,$54,$58,$9C,$00,$00,$00,$54,$3F,$C3,$00,$00,$00,$54,$26,$F8,$A0
 dc.b $00,$00,$54,$0E,$3C,$D2,$00,$00,$53,$F5,$8F,$8A,$00,$00,$53,$DC,$F0,$BB
 dc.b $00,$00,$53,$C4,$60,$59,$00,$00,$53,$AB,$DE,$56,$00,$00,$53,$93,$6A,$A6
 dc.b $00,$00,$53,$7B,$05,$3C,$00,$00,$53,$62,$AE,$0D,$00,$00,$53,$4A,$65,$0B
 dc.b $00,$00,$53,$32,$2A,$2A,$00,$00,$53,$19,$FD,$5E,$00,$00,$53,$01,$DE,$9A
 dc.b $00,$00,$52,$E9,$CD,$D3,$00,$00,$52,$D1,$CA,$FC,$00,$00,$52,$B9,$D6,$0A
 dc.b $00,$00,$52,$A1,$EE,$EF,$00,$00,$52,$8A,$15,$A1,$00,$00,$52,$72,$4A,$12
 dc.b $00,$00,$52,$5A,$8C,$38,$00,$00,$52,$42,$DC,$07,$00,$00,$52,$2B,$39,$72
 dc.b $00,$00,$52,$13,$A4,$6E,$00,$00,$51,$FC,$1C,$EF,$00,$00,$51,$E4,$A2,$EB
 dc.b $00,$00,$51,$CD,$36,$54,$00,$00,$51,$B5,$D7,$20,$00,$00,$51,$9E,$85,$43
 dc.b $00,$00,$51,$87,$40,$B2,$00,$00,$51,$70,$09,$61,$00,$00,$51,$58,$DF,$45
 dc.b $00,$00,$51,$41,$C2,$53,$00,$00,$51,$2A,$B2,$80,$00,$00,$51,$13,$AF,$C0
 dc.b $00,$00,$50,$FC,$BA,$09,$00,$00,$50,$E5,$D1,$4F,$00,$00,$50,$CE,$F5,$87
 dc.b $00,$00,$50,$B8,$26,$A6,$00,$00,$50,$A1,$64,$A2,$00,$00,$50,$8A,$AF,$70
 dc.b $00,$00,$50,$74,$07,$04,$00,$00,$50,$5D,$6B,$54,$00,$00,$50,$46,$DC,$55
 dc.b $00,$00,$50,$30,$59,$FD,$00,$00,$50,$19,$E4,$41,$00,$00,$50,$03,$7B,$16
 dc.b $00,$00,$4F,$ED,$1E,$72,$00,$00,$4F,$D6,$CE,$4A,$00,$00,$4F,$C0,$8A,$94
 dc.b $00,$00,$4F,$AA,$53,$46,$00,$00,$4F,$94,$28,$54,$00,$00,$4F,$7E,$09,$B6
 dc.b $00,$00,$4F,$67,$F7,$60,$00,$00,$4F,$51,$F1,$48,$00,$00,$4F,$3B,$F7,$65
 dc.b $00,$00,$4F,$26,$09,$AB,$00,$00,$4F,$10,$28,$11,$00,$00,$4E,$FA,$52,$8E
 dc.b $00,$00,$4E,$E4,$89,$16,$00,$00,$4E,$CE,$CB,$A0,$00,$00,$4E,$B9,$1A,$22
 dc.b $00,$00,$4E,$A3,$74,$92,$00,$00,$4E,$8D,$DA,$E7,$00,$00,$4E,$78,$4D,$15
 dc.b $00,$00,$4E,$62,$CB,$15,$00,$00,$4E,$4D,$54,$DC,$00,$00,$4E,$37,$EA,$60
 dc.b $00,$00,$4E,$22,$8B,$98,$00,$00,$4E,$0D,$38,$7A,$00,$00,$4D,$F7,$F0,$FD
 dc.b $00,$00,$4D,$E2,$B5,$17,$00,$00,$4D,$CD,$84,$BE,$00,$00,$4D,$B8,$5F,$EA
 dc.b $00,$00,$4D,$A3,$46,$91,$00,$00,$4D,$8E,$38,$A9,$00,$00,$4D,$79,$36,$29
 dc.b $00,$00,$4D,$64,$3F,$09,$00,$00,$4D,$4F,$53,$3E,$00,$00,$4D,$3A,$72,$C0
 dc.b $00,$00,$4D,$25,$9D,$85,$00,$00,$4D,$10,$D3,$85,$00,$00,$4C,$FC,$14,$B6
 dc.b $00,$00,$4C,$E7,$61,$0F,$00,$00,$4C,$D2,$B8,$87,$00,$00,$4C,$BE,$1B,$16
 dc.b $00,$00,$4C,$A9,$88,$B2,$00,$00,$4C,$95,$01,$52,$00,$00,$4C,$80,$84,$EE
 dc.b $00,$00,$4C,$6C,$13,$7D,$00,$00,$4C,$57,$AC,$F6,$00,$00,$4C,$43,$51,$51
 dc.b $00,$00,$4C,$2F,$00,$84,$00,$00,$4C,$1A,$BA,$87,$00,$00,$4C,$06,$7F,$51
 dc.b $00,$00,$4B,$F2,$4E,$DB,$00,$00,$4B,$DE,$29,$1A,$00,$00,$4B,$CA,$0E,$07
 dc.b $00,$00,$4B,$B5,$FD,$9A,$00,$00,$4B,$A1,$F7,$C9,$00,$00,$4B,$8D,$FC,$8C
 dc.b $00,$00,$4B,$7A,$0B,$DC,$00,$00,$4B,$66,$25,$AF,$00,$00,$4B,$52,$49,$FE
 dc.b $00,$00,$4B,$3E,$78,$BF,$00,$00,$4B,$2A,$B1,$EC,$00,$00,$4B,$16,$F5,$7B
 dc.b $00,$00,$4B,$03,$43,$64,$00,$00,$4A,$EF,$9B,$A0,$00,$00,$4A,$DB,$FE,$27
 dc.b $00,$00,$4A,$C8,$6A,$EF,$00,$00,$4A,$B4,$E1,$F1,$00,$00,$4A,$A1,$63,$26
 dc.b $00,$00,$4A,$8D,$EE,$84,$00,$00,$4A,$7A,$84,$05,$00,$00,$4A,$67,$23,$A0
 dc.b $00,$00,$4A,$53,$CD,$4D,$00,$00,$4A,$40,$81,$05,$00,$00,$4A,$2D,$3E,$C0
 dc.b $00,$00,$4A,$1A,$06,$76,$00,$00,$4A,$06,$D8,$1F,$00,$00,$49,$F3,$B3,$B3
 dc.b $00,$00,$49,$E0,$99,$2B,$00,$00,$49,$CD,$88,$80,$00,$00,$49,$BA,$81,$A9
 dc.b $00,$00,$49,$A7,$84,$9E,$00,$00,$49,$94,$91,$5A,$00,$00,$49,$81,$A7,$D3
 dc.b $00,$00,$49,$6E,$C8,$02,$00,$00,$49,$5B,$F1,$E0,$00,$00,$49,$49,$25,$65
 dc.b $00,$00,$49,$36,$62,$8B,$00,$00,$49,$23,$A9,$49,$00,$00,$49,$10,$F9,$99
 dc.b $00,$00,$48,$FE,$53,$72,$00,$00,$48,$EB,$B6,$CE,$00,$00,$48,$D9,$23,$A5
 dc.b $00,$00,$48,$C6,$99,$F0,$00,$00,$48,$B4,$19,$A9,$00,$00,$48,$A1,$A2,$C7
 dc.b $00,$00,$48,$8F,$35,$44,$00,$00,$48,$7C,$D1,$18,$00,$00,$48,$6A,$76,$3C
 dc.b $00,$00,$48,$58,$24,$AA,$00,$00,$48,$45,$DC,$5A,$00,$00,$48,$33,$9D,$45
 dc.b $00,$00,$48,$21,$67,$64,$00,$00,$48,$0F,$3A,$B1,$00,$00,$47,$FD,$17,$24
 dc.b $00,$00,$47,$EA,$FC,$B7,$00,$00,$47,$D8,$EB,$62,$00,$00,$47,$C6,$E3,$1F
 dc.b $00,$00,$47,$B4,$E3,$E7,$00,$00,$47,$A2,$ED,$B3,$00,$00,$47,$91,$00,$7C
 dc.b $00,$00,$47,$7F,$1C,$3C,$00,$00,$47,$6D,$40,$EC,$00,$00,$47,$5B,$6E,$84
 dc.b $00,$00,$47,$49,$A5,$00,$00,$00,$47,$37,$E4,$57,$00,$00,$47,$26,$2C,$84
 dc.b $00,$00,$47,$14,$7D,$80,$00,$00,$47,$02,$D7,$43,$00,$00,$46,$F1,$39,$C8
 dc.b $00,$00,$46,$DF,$A5,$08,$00,$00,$46,$CE,$18,$FD,$00,$00,$46,$BC,$95,$A0
 dc.b $00,$00,$46,$AB,$1A,$EB,$00,$00,$46,$99,$A8,$D7,$00,$00,$46,$88,$3F,$5E
 dc.b $00,$00,$46,$76,$DE,$79,$00,$00,$46,$65,$86,$23,$00,$00,$46,$54,$36,$55
 dc.b $00,$00,$46,$42,$EF,$08,$00,$00,$46,$31,$B0,$37,$00,$00,$46,$20,$79,$DA
 dc.b $00,$00,$46,$0F,$4B,$ED,$00,$00,$45,$FE,$26,$68,$00,$00,$45,$ED,$09,$46
 dc.b $00,$00,$45,$DB,$F4,$81,$00,$00,$45,$CA,$E8,$11,$00,$00,$45,$B9,$E3,$F2
 dc.b $00,$00,$45,$A8,$E8,$1D,$00,$00,$45,$97,$F4,$8C,$00,$00,$45,$87,$09,$39
 dc.b $00,$00,$45,$76,$26,$1E,$00,$00,$45,$65,$4B,$35,$00,$00,$45,$54,$78,$78
 dc.b $00,$00,$45,$43,$AD,$E1,$00,$00,$45,$32,$EB,$6B,$00,$00,$45,$22,$31,$0E
 dc.b $00,$00,$45,$11,$7E,$C7,$00,$00,$45,$00,$D4,$8E,$00,$00,$44,$F0,$32,$5D
 dc.b $00,$00,$44,$DF,$98,$30,$00,$00,$44,$CF,$06,$00,$00,$00,$44,$BE,$7B,$C7
 dc.b $00,$00,$44,$AD,$F9,$80,$00,$00,$44,$9D,$7F,$25,$00,$00,$44,$8D,$0C,$B0
 dc.b $00,$00,$44,$7C,$A2,$1C,$00,$00,$44,$6C,$3F,$63,$00,$00,$44,$5B,$E4,$7F
 dc.b $00,$00,$44,$4B,$91,$6B,$00,$00,$44,$3B,$46,$21,$00,$00,$44,$2B,$02,$9B
 dc.b $00,$00,$44,$1A,$C6,$D5,$00,$00,$44,$0A,$92,$C8,$00,$00,$43,$FA,$66,$6F
 dc.b $00,$00,$43,$EA,$41,$C4,$00,$00,$43,$DA,$24,$C2,$00,$00,$43,$CA,$0F,$64
 dc.b $00,$00,$43,$BA,$01,$A4,$00,$00,$43,$A9,$FB,$7D,$00,$00,$43,$99,$FC,$E9
 dc.b $00,$00,$43,$8A,$05,$E3,$00,$00,$43,$7A,$16,$66,$00,$00,$43,$6A,$2E,$6C
 dc.b $00,$00,$43,$5A,$4D,$F0,$00,$00,$43,$4A,$74,$ED,$00,$00,$43,$3A,$A3,$5D
 dc.b $00,$00,$43,$2A,$D9,$3B,$00,$00,$43,$1B,$16,$83,$00,$00,$43,$0B,$5B,$2E
 dc.b $00,$00,$42,$FB,$A7,$37,$00,$00,$42,$EB,$FA,$9A,$00,$00,$42,$DC,$55,$51
 dc.b $00,$00,$42,$CC,$B7,$58,$00,$00,$42,$BD,$20,$A8,$00,$00,$42,$AD,$91,$3D
 dc.b $00,$00,$42,$9E,$09,$12,$00,$00,$42,$8E,$88,$21,$00,$00,$42,$7F,$0E,$67
 dc.b $00,$00,$42,$6F,$9B,$DC,$00,$00,$42,$60,$30,$7E,$00,$00,$42,$50,$CC,$46
 dc.b $00,$00,$42,$41,$6F,$30,$00,$00,$42,$32,$19,$37,$00,$00,$42,$22,$CA,$55
 dc.b $00,$00,$42,$13,$82,$87,$00,$00,$42,$04,$41,$C6,$00,$00,$41,$F5,$08,$0E
 dc.b $00,$00,$41,$E5,$D5,$5B,$00,$00,$41,$D6,$A9,$A7,$00,$00,$41,$C7,$84,$EE
 dc.b $00,$00,$41,$B8,$67,$2A,$00,$00,$41,$A9,$50,$58,$00,$00,$41,$9A,$40,$72
 dc.b $00,$00,$41,$8B,$37,$73,$00,$00,$41,$7C,$35,$56,$00,$00,$41,$6D,$3A,$18
 dc.b $00,$00,$41,$5E,$45,$B3,$00,$00,$41,$4F,$58,$22,$00,$00,$41,$40,$71,$62
 dc.b $00,$00,$41,$31,$91,$6C,$00,$00,$41,$22,$B8,$3E,$00,$00,$41,$13,$E5,$D1
 dc.b $00,$00,$41,$05,$1A,$21,$00,$00,$40,$F6,$55,$2B,$00,$00,$40,$E7,$96,$E8
 dc.b $00,$00,$40,$D8,$DF,$55,$00,$00,$40,$CA,$2E,$6D,$00,$00,$40,$BB,$84,$2C
 dc.b $00,$00,$40,$AC,$E0,$8D,$00,$00,$40,$9E,$43,$8B,$00,$00,$40,$8F,$AD,$22
 dc.b $00,$00,$40,$81,$1D,$4E,$00,$00,$40,$72,$94,$0B,$00,$00,$40,$64,$11,$52
 dc.b $00,$00,$40,$55,$95,$21,$00,$00,$40,$47,$1F,$73,$00,$00,$40,$38,$B0,$44
 dc.b $00,$00,$40,$2A,$47,$8F,$00,$00,$40,$1B,$E5,$4F,$00,$00,$40,$0D,$89,$81
 dc.b $00,$00,$3F,$FF,$34,$20,$00,$00,$3F,$F0,$E5,$28,$00,$00,$3F,$E2,$9C,$94
 dc.b $00,$00,$3F,$D4,$5A,$61,$00,$00,$3F,$C6,$1E,$89,$00,$00,$3F,$B7,$E9,$09
 dc.b $00,$00,$3F,$A9,$B9,$DD,$00,$00,$3F,$9B,$91,$00,$00,$00,$3F,$8D,$6E,$6E
 dc.b $00,$00,$3F,$7F,$52,$23,$00,$00,$3F,$71,$3C,$1A,$00,$00,$3F,$63,$2C,$50
 dc.b $00,$00,$3F,$55,$22,$C1,$00,$00,$3F,$47,$1F,$67,$00,$00,$3F,$39,$22,$40
 dc.b $00,$00,$3F,$2B,$2B,$47,$00,$00,$3F,$1D,$3A,$78,$00,$00,$3F,$0F,$4F,$CE
 dc.b $00,$00,$3F,$01,$6B,$47,$00,$00,$3E,$F3,$8C,$DD,$00,$00,$3E,$E5,$B4,$8C
 dc.b $00,$00,$3E,$D7,$E2,$52,$00,$00,$3E,$CA,$16,$29,$00,$00,$3E,$BC,$50,$0E
 dc.b $00,$00,$3E,$AE,$8F,$FC,$00,$00,$3E,$A0,$D5,$F0,$00,$00,$3E,$93,$21,$E6
 dc.b $00,$00,$3E,$85,$73,$DA,$00,$00,$3E,$77,$CB,$C8,$00,$00,$3E,$6A,$29,$AB
 dc.b $00,$00,$3E,$5C,$8D,$81,$00,$00,$3E,$4E,$F7,$45,$00,$00,$3E,$41,$66,$F4
 dc.b $00,$00,$3E,$33,$DC,$88,$00,$00,$3E,$26,$58,$00,$00,$00,$3E,$18,$D9,$56
 dc.b $00,$00,$3E,$0B,$60,$87,$00,$00,$3D,$FD,$ED,$8F,$00,$00,$3D,$F0,$80,$6B
 dc.b $00,$00,$3D,$E3,$19,$16,$00,$00,$3D,$D5,$B7,$8E,$00,$00,$3D,$C8,$5B,$CD
 dc.b $00,$00,$3D,$BB,$05,$D0,$00,$00,$3D,$AD,$B5,$94,$00,$00,$3D,$A0,$6B,$15
 dc.b $00,$00,$3D,$93,$26,$4F,$00,$00,$3D,$85,$E7,$3F,$00,$00,$3D,$78,$AD,$E0
 dc.b $00,$00,$3D,$6B,$7A,$30,$00,$00,$3D,$5E,$4C,$2A,$00,$00,$3D,$51,$23,$CB
 dc.b $00,$00,$3D,$44,$01,$0E,$00,$00,$3D,$36,$E3,$F2,$00,$00,$3D,$29,$CC,$71
 dc.b $00,$00,$3D,$1C,$BA,$89,$00,$00,$3D,$0F,$AE,$36,$00,$00,$3D,$02,$A7,$74
 dc.b $00,$00,$3C,$F5,$A6,$3F,$00,$00,$3C,$E8,$AA,$95,$00,$00,$3C,$DB,$B4,$71
 dc.b $00,$00,$3C,$CE,$C3,$D0,$00,$00,$3C,$C1,$D8,$AF,$00,$00,$3C,$B4,$F3,$09
 dc.b $00,$00,$3C,$A8,$12,$DD,$00,$00,$3C,$9B,$38,$25,$00,$00,$3C,$8E,$62,$DF
 dc.b $00,$00,$3C,$81,$93,$07,$00,$00,$3C,$74,$C8,$9A,$00,$00,$3C,$68,$03,$94
 dc.b $00,$00,$3C,$5B,$43,$F1,$00,$00,$3C,$4E,$89,$B0,$00,$00,$3C,$41,$D4,$CB
 dc.b $00,$00,$3C,$35,$25,$40,$00,$00,$3C,$28,$7B,$0B,$00,$00,$3C,$1B,$D6,$29
 dc.b $00,$00,$3C,$0F,$36,$96,$00,$00,$3C,$02,$9C,$50,$00,$00,$3B,$F6,$07,$53
 dc.b $00,$00,$3B,$E9,$77,$9B,$00,$00,$3B,$DC,$ED,$26,$00,$00,$3B,$D0,$67,$EF
 dc.b $00,$00,$3B,$C3,$E7,$F4,$00,$00,$3B,$B7,$6D,$31,$00,$00,$3B,$AA,$F7,$A4
 dc.b $00,$00,$3B,$9E,$87,$48,$00,$00,$3B,$92,$1C,$1B,$00,$00,$3B,$85,$B6,$1A
 dc.b $00,$00,$3B,$79,$55,$40,$00,$00,$3B,$6C,$F9,$8B,$00,$00,$3B,$60,$A2,$F8
 dc.b $00,$00,$3B,$54,$51,$84,$00,$00,$3B,$48,$05,$2B,$00,$00,$3B,$3B,$BD,$EA
 dc.b $00,$00,$3B,$2F,$7B,$BE,$00,$00,$3B,$23,$3E,$A4,$00,$00,$3B,$17,$06,$99
 dc.b $00,$00,$3B,$0A,$D3,$99,$00,$00,$3A,$FE,$A5,$A2,$00,$00,$3A,$F2,$7C,$B0
 dc.b $00,$00,$3A,$E6,$58,$C0,$00,$00,$3A,$DA,$39,$D0,$00,$00,$3A,$CE,$1F,$DC
 dc.b $00,$00,$3A,$C2,$0A,$E0,$00,$00,$3A,$B5,$FA,$DB,$00,$00,$3A,$A9,$EF,$C8
 dc.b $00,$00,$3A,$9D,$E9,$A5,$00,$00,$3A,$91,$E8,$6F,$00,$00,$3A,$85,$EC,$23
 dc.b $00,$00,$3A,$79,$F4,$BD,$00,$00,$3A,$6E,$02,$3C,$00,$00,$3A,$62,$14,$9B
 dc.b $00,$00,$3A,$56,$2B,$D8,$00,$00,$3A,$4A,$47,$EF,$00,$00,$3A,$3E,$68,$DF
 dc.b $00,$00,$3A,$32,$8E,$A3,$00,$00,$3A,$26,$B9,$3A,$00,$00,$3A,$1A,$E8,$9F
 dc.b $00,$00,$3A,$0F,$1C,$D0,$00,$00,$3A,$03,$55,$CB,$00,$00,$39,$F7,$93,$8C
 dc.b $00,$00,$39,$EB,$D6,$10,$00,$00,$39,$E0,$1D,$54,$00,$00,$39,$D4,$69,$57
 dc.b $00,$00,$39,$C8,$BA,$14,$00,$00,$39,$BD,$0F,$88,$00,$00,$39,$B1,$69,$B2
 dc.b $00,$00,$39,$A5,$C8,$8E,$00,$00,$39,$9A,$2C,$19,$00,$00,$39,$8E,$94,$50
 dc.b $00,$00,$39,$83,$01,$31,$00,$00,$39,$77,$72,$B9,$00,$00,$39,$6B,$E8,$E5
 dc.b $00,$00,$39,$60,$63,$B3,$00,$00,$39,$54,$E3,$1E,$00,$00,$39,$49,$67,$26
 dc.b $00,$00,$39,$3D,$EF,$C6,$00,$00,$39,$32,$7C,$FD
