/* resource set indices for WINLABY */

#define LABMENUE   0 /* menu */
#define TITLE1     3 /* TITLE in tree LABMENUE */
#define SPIEL      4 /* TITLE in tree LABMENUE */
#define EXTRAS     5 /* TITLE in tree LABMENUE */
#define LABINFO    8 /* STRING in tree LABMENUE */
#define NEU       17 /* STRING in tree LABMENUE */
#define ENDE      19 /* STRING in tree LABMENUE */
#define LABMODUS  21 /* STRING in tree LABMENUE */

