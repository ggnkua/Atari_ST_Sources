/* Resource Datei Indizes f�r IKONKA */

#define FORM1            0   /* Formular/Dialog */
