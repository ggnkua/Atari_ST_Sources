/* Resource Datei Indizes f�r POPUP */

#define POPUP            0   /* Formular/Dialog */
#define COWHITE          17  /* STRING in Baum POPUP */
#define COBLACK          18  /* STRING in Baum POPUP */
#define CORED            19  /* STRING in Baum POPUP */
#define COGREEN          20  /* STRING in Baum POPUP */
#define COBLUE           21  /* STRING in Baum POPUP */
#define COCYAN           22  /* STRING in Baum POPUP */
#define COYELLOW         23  /* STRING in Baum POPUP */
#define COMAGENT         24  /* STRING in Baum POPUP */
#define COLGREY          25  /* STRING in Baum POPUP */
#define CODGREY          26  /* STRING in Baum POPUP */
#define CODRED           27  /* STRING in Baum POPUP */
#define CODGREEN         28  /* STRING in Baum POPUP */
#define CODBLUE          29  /* STRING in Baum POPUP */
#define CODCYAN          30  /* STRING in Baum POPUP */
#define CODYELLO         31  /* STRING in Baum POPUP */
#define CODMAGEN         32  /* STRING in Baum POPUP */
