/* Resource Datei Indizes f�r TITLE */

#define TITLE            0   /* Formular/Dialog */
#define INFO_OK          12  /* BUTTON in Baum TITLE */
#define INFO_URL         13  /* TEXT in Baum TITLE */
#define TIINFO_GEMLIB    14  /* TEXT in Baum TITLE */
