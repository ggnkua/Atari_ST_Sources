/* Indices du fichier ressource pour EXEMPLE5 */

#define MENU             0   /* Menu */
#define INFORMATIONS     7   /* STRING dans l'arbre MENU */
#define FORMN            16  /* STRING dans l'arbre MENU */
#define FORMW            17  /* STRING dans l'arbre MENU */
#define FENETRED         18  /* STRING dans l'arbre MENU */
#define FENETRET         19  /* STRING dans l'arbre MENU */
#define QUITTER          21  /* STRING dans l'arbre MENU */

#define BUREAU           1   /* Formulaire/Dialogue */

#define FORMULAIRE       2   /* Formulaire/Dialogue */
#define RB1              3   /* BUTTON dans l'arbre FORMULAIRE */
#define RB2              4   /* BUTTON dans l'arbre FORMULAIRE */
#define RB3              5   /* BUTTON dans l'arbre FORMULAIRE */
#define EDIT1            7   /* FBOXTEXT dans l'arbre FORMULAIRE */
#define EDIT2            9   /* FBOXTEXT dans l'arbre FORMULAIRE */
#define FLG              10  /* BUTTON dans l'arbre FORMULAIRE */
#define NBRE             12  /* BOXTEXT dans l'arbre FORMULAIRE */
#define FLD              13  /* BUTTON dans l'arbre FORMULAIRE */
#define BS               14  /* BUTTON dans l'arbre FORMULAIRE */
#define OK               15  /* BUTTON dans l'arbre FORMULAIRE */
#define ANNULE           16  /* BUTTON dans l'arbre FORMULAIRE */

#define FORMWIND         3   /* Formulaire/Dialogue */
#define T1               5   /* BUTTON dans l'arbre FORMWIND */
#define T2               6   /* BUTTON dans l'arbre FORMWIND */
#define T3               7   /* BUTTON dans l'arbre FORMWIND */
#define NFEN             9   /* BUTTON dans l'arbre FORMWIND */
#define NLIG             10  /* BUTTON dans l'arbre FORMWIND */
#define REMP             11  /* BUTTON dans l'arbre FORMWIND */
#define FW_OK            12  /* BUTTON dans l'arbre FORMWIND */

#define ICON             4   /* Formulaire/Dialogue */
#define MOTIF            1   /* IMAGE dans l'arbre ICON */

#define INFOS            0   /* Chaine d'alerte */
