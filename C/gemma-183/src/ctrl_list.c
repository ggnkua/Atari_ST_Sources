/* The GEM AES control list
 */

/*  This program is free software; you can redistribute it and/or modify
 *  it under the terms of the GNU General Public License as published by
 *  the Free Software Foundation; either version 2 of the License, or
 *  (at your option) any later version.
 *
 *  This program is distributed in the hope that it will be useful,
 *  but WITHOUT ANY WARRANTY; without even the implied warranty of
 *  MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 *  GNU General Public License for more details.
 *
 *  You should have received a copy of the GNU General Public License
 *  along with this program; if not, write to the Free Software
 *  Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.
 */

const long ctrl_list[] =
{

/* 0: none */

	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,

/* 10: appl_xxxx() */

	0x00010000, 0x02010100, 0x02010100, 0x00010100, 0x02010100,
	0x01010100, 0x00000000, 0x00010000, 0x01030100, 0x00010000,

/* 20: evnt_xxxx() */

	0x00010000, 0x03050000, 0x05050000, 0x00010100, 0x02010000,
	0x10070100, 0x02010000, 0x00000000, 0x00000000, 0x00000000,

/* 30: menu_xxxx() */

	0x01010100, 0x02010100, 0x02010100, 0x02010100, 0x01010200,
	0x01010100, 0x02010200, 0x02010200, 0x03010100, 0x01010100,

/* 40: objc_xxxx() */

	0x02010100, 0x01010100, 0x06010100, 0x04010100, 0x01030100,
	0x02010100, 0x04020100, 0x08010100, 0x04030000, 0x04010100,

/* 50: form_xxxx() */

	0x01010100, 0x09010000, 0x01010100, 0x01010000, 0x00050100,
	0x03030100, 0x02020100, 0x00000000, 0x00000000, 0x00000000,

/* 60: none */

	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x04030100,

/* 70: graf_xxxx() */

	0x04030000, 0x08030000, 0x06010000, 0x08010000, 0x08010000,
	0x04010100, 0x03010100, 0x00050000, 0x01010100, 0x00050000,

/* 80: scrp_xxxx() */

	0x00010100, 0x00010100, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,

/* 90: fsel_xxxx() */

	0x00020200, 0x00020300, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x02010000,

/* 100: wind_xxxx() */

	0x05010000, 0x05010000, 0x01010000, 0x01010000, 0x06050000,
	0x06010000, 0x02010000, 0x01010000, 0x06050000, 0x00000000,

/* 110: rsrc_xxxx() */

	0x00010100, 0x00010000, 0x02010001, 0x02010100, 0x01010100,
	0x00010100, 0x00000000, 0x00000000, 0x00000000, 0x00000000,

/* 120: shel_xxxx() */

	0x00010200, 0x03010200, 0x01010100, 0x01010100, 0x00010100,
	0x00010300, 0x00010200, 0x00010200, 0x01010200, 0x02010100,

/* 130: miscellaneous */

	0x01050000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x02010100, 0x00000000, 0x00000000, 0x00000000, 0x00000000,

/* 140: testing */

	0x00010000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,

/* 150: none */

	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,

/* 160: Mag!X wdialog */

	0x02000401, 0x04010300, 0x00010100, 0x00010100, 0x01010301,
	0x02010100, 0x00010200, 0x02010200, 0x00000000, 0x00000000,

/* 170: Mag!X scrollbox */

	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,

/* 180: Mag!X font selector */

	0x04000201, 0x01010100, 0x09010100, 0x00010100, 0x04020400,
	0x08010200, 0x00090200, 0x07080100, 0x00000000, 0x00000000,

/* 190: Mag!X non-modal fileselector */

	0x06010601, 0x00010100, 0x00010200, 0x00040401, 0x04040602,
	0x02020000, 0x00000000, 0x00000000, 0x00000000, 0x00000000
};

/* EOF */
