#define MENUBAR 0
#define DESK 3
#define EDIT 5
#define FILE 4
#define MARK 6
#define SEARCH 7
#define INFORM 9
#define WINDOWS 8
#define ABOUT 12
#define DIALOG5 5
#define NEW 21
#define OPEN 22
#define SAVE 25
#define CLOSE 24
#define SAVEAS 26
#define SPACE 29
#define DELETE 28
#define PRINT 31
#define DIALOG4 4
#define QUIT 33
#define AA 1
#define BB 2
#define CUT 35
#define JJ 4
#define II 3
#define PASTE 37
#define COPY 36
#define CC 5
#define ERASE 38
#define KK 6
#define LL 8
#define DD 7
#define REPLACE 41
#define INSERT 40
#define EE 9
#define PROTECT 42
#define MM 10
#define NN 12
#define FF 11
#define END 45
#define START 44
#define GG 13
#define CLEAR 46
#define OO 14
#define PP 16
#define HH 15
#define FORWARD 49
#define FIND 48
#define BACK 50
#define DRBOX 18
#define DREXIT 20
#define DRSTR1 19
#define ROTATE 52
#define FSIZE 54
#define POS 55
#define DIALOG6 6
#define DIALOG2 2
#define OK1 8
#define DIALOG3 3
#define ABBUT 1
#define SKBUT 3
#define RPBUT 2
#define RVER 1
#define DIALOG1 1
#define RALL 5
#define RONCE 6
#define SBACK 3
#define CANCEL1 4
#define SFORWARD 2
#define SSTRING 9
#define RSTRING 11
#define SSTRBUT 13
#define SCUTBUF 14
#define RSTRBUT 17
#define RCUTBUF 16
extern unsigned char XXEDRSC[];
