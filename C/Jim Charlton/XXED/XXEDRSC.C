/*
 * C version of 'D:\XXED.RSC'
 */

unsigned char XXEDRSC[] = {
	0,0,4,236,4,152,4,152,4,152,4,152,0,36,4,152,4,152,
	15,156,0,114,0,7,0,3,0,0,0,0,0,0,0,0,15,184,
	32,68,101,115,107,32,0,32,70,105,108,101,32,0,32,69,100,105,
	116,0,32,77,97,114,107,0,32,83,101,97,114,99,104,32,0,32,
	87,105,110,100,111,119,115,0,32,32,73,110,102,111,0,32,32,72,
	101,120,32,69,100,105,116,111,114,0,45,45,45,45,45,45,45,45,
	45,45,45,45,45,45,45,45,45,45,45,45,0,32,32,68,101,115,
	107,32,65,99,99,101,115,115,111,114,121,32,49,32,32,0,32,32,
	68,101,115,107,32,65,99,99,101,115,115,111,114,121,32,50,32,32,
	0,32,32,68,101,115,107,32,65,99,99,101,115,115,111,114,121,32,
	51,32,32,0,32,32,68,101,115,107,32,65,99,99,101,115,115,111,
	114,121,32,52,32,32,0,32,32,68,101,115,107,32,65,99,99,101,
	115,115,111,114,121,32,53,32,32,0,32,32,68,101,115,107,32,65,
	99,99,101,115,115,111,114,121,32,54,32,32,0,32,32,32,78,101,
	119,46,46,46,32,32,0,32,32,32,79,112,101,110,46,46,46,0,
	45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,0,32,32,
	32,67,108,111,115,101,32,32,32,0,32,83,32,83,97,118,101,32,
	32,32,0,32,32,32,83,97,118,101,32,65,115,46,46,46,32,32,
	0,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,0,32,
	32,32,68,101,108,101,116,101,46,46,46,0,32,32,32,68,105,115,
	107,32,83,112,97,99,101,0,45,45,45,45,45,45,45,45,45,45,
	45,45,45,45,45,0,32,32,32,80,114,105,110,116,0,45,45,45,
	45,45,45,45,45,45,45,45,45,45,45,45,0,32,81,32,81,117,
	105,116,32,32,32,32,32,32,32,0,32,88,32,67,117,116,0,32,
	67,32,67,111,112,121,32,32,0,32,86,32,80,97,115,116,101,32,
	0,32,69,32,69,114,97,115,101,32,0,45,45,45,45,45,45,45,
	45,45,45,45,0,32,32,32,73,110,115,101,114,116,0,32,32,32,
	82,101,112,108,97,99,101,0,32,32,32,80,114,111,116,101,99,116,
	0,32,73,32,77,97,114,107,32,83,116,97,114,116,0,32,79,32,
	77,97,114,107,32,69,110,100,32,0,32,80,32,67,108,101,97,114,
	32,77,97,114,107,115,32,0,32,70,32,70,105,110,100,0,32,65,
	32,70,111,114,119,97,114,100,0,32,66,32,66,97,99,107,0,32,
	82,111,116,97,116,101,32,119,105,110,100,111,119,115,0,32,70,105,
	108,101,32,115,105,122,101,58,0,32,80,111,115,105,116,105,111,110,
	58,0,83,65,86,73,78,71,32,70,73,76,69,0,65,0,66,0,
	73,0,74,0,67,0,75,0,68,0,76,0,69,0,77,0,70,0,
	78,0,71,0,79,0,72,0,80,0,83,69,76,69,67,84,32,68,
	82,73,86,69,0,0,69,88,73,84,0,68,69,76,69,84,73,78,
	71,32,70,73,76,69,0,98,121,0,74,46,32,67,104,97,114,108,
	116,111,110,0,40,72,101,120,97,100,101,99,105,109,97,108,32,101,
	100,105,116,111,114,32,118,101,114,115,105,111,110,32,49,46,49,41,
	0,65,76,76,32,82,73,71,72,84,83,32,82,69,83,69,82,86,
	69,68,0,0,84,101,108,32,40,50,48,52,41,45,50,54,49,45,
	55,53,49,50,0,51,48,32,80,114,101,115,99,111,116,32,82,100,
	44,32,87,105,110,110,105,112,101,103,44,32,67,97,110,97,100,97,
	0,79,75,0,88,88,69,68,0,65,66,79,82,84,0,82,69,80,
	76,65,67,69,0,83,75,73,80,0,82,101,112,108,97,99,101,32,
	65,108,108,32,119,105,116,104,32,86,101,114,105,102,121,0,82,101,
	112,108,97,99,101,32,65,108,108,0,82,101,112,108,97,99,101,32,
	79,110,99,101,0,67,65,78,67,69,76,0,83,101,97,114,99,104,
	32,66,65,67,75,87,65,82,68,83,0,83,101,97,114,99,104,32,
	70,79,82,87,65,82,68,0,83,101,97,114,99,104,32,97,110,100,
	32,82,101,112,108,97,99,101,32,68,105,97,108,111,103,32,66,111,
	120,0,95,95,95,95,95,95,0,83,101,97,114,99,104,32,32,83,
	116,114,105,110,103,58,95,95,95,95,95,95,95,95,95,95,95,95,
	95,95,95,95,95,95,95,95,95,95,95,95,0,88,88,88,88,88,
	88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,
	88,0,95,95,95,95,95,0,82,101,112,108,97,99,101,32,83,116,
	114,105,110,103,58,95,95,95,95,95,95,95,95,95,95,95,95,95,
	95,95,95,95,95,95,95,95,95,95,95,0,88,88,88,88,88,88,
	88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,88,
	0,83,101,97,114,99,104,32,115,116,114,105,110,103,0,67,117,116,
	32,98,117,102,102,101,114,0,67,117,116,32,98,117,102,102,101,114,
	0,82,101,112,108,97,99,101,32,115,116,114,105,110,103,0,83,101,
	97,114,99,104,32,102,111,114,58,0,82,101,112,108,97,99,101,32,
	119,105,116,104,58,0,0,0,2,227,0,0,0,0,0,0,2,247,
	0,5,0,6,0,0,17,128,0,0,0,255,0,20,0,1,0,0,
	3,188,0,0,3,195,0,0,3,235,0,3,0,6,0,0,17,128,
	0,0,0,255,0,7,0,40,0,0,4,4,0,0,4,10,0,0,
	4,50,0,3,0,6,0,0,17,128,0,0,0,255,0,6,0,40,
	255,255,0,1,0,10,0,25,0,0,0,0,0,0,0,0,0,0,
	0,0,0,80,0,25,0,10,0,2,0,2,0,20,0,0,0,0,
	0,0,17,0,0,0,0,0,0,80,2,1,0,1,0,3,0,9,
	0,25,0,0,0,0,0,0,0,0,0,2,0,0,0,51,3,1,
	0,4,255,255,255,255,0,32,0,0,0,0,0,0,0,36,0,0,
	0,0,0,6,3,1,0,5,255,255,255,255,0,32,0,0,0,0,
	0,0,0,43,0,6,0,0,0,6,3,1,0,6,255,255,255,255,
	0,32,0,0,0,0,0,0,0,50,0,12,0,0,0,6,3,1,
	0,7,255,255,255,255,0,32,0,0,0,0,0,0,0,56,0,18,
	0,0,0,6,3,1,0,8,255,255,255,255,0,32,0,0,0,0,
	0,0,0,62,0,24,0,0,0,9,3,1,0,9,255,255,255,255,
	0,32,0,0,0,0,0,0,0,71,0,33,0,0,0,9,3,1,
	0,2,255,255,255,255,0,32,0,0,0,0,0,0,0,80,0,42,
	0,0,0,9,3,1,0,0,0,11,0,53,0,25,0,0,0,0,
	0,0,0,0,0,0,3,1,0,80,0,19,0,20,0,12,0,19,
	0,20,0,0,0,0,0,255,17,0,0,2,0,0,0,20,0,8,
	0,13,255,255,255,255,0,28,0,0,0,0,0,0,0,87,0,0,
	0,0,0,20,0,1,0,14,255,255,255,255,0,28,0,0,0,8,
	0,0,0,100,0,0,0,1,0,20,0,1,0,15,255,255,255,255,
	0,28,0,0,0,0,0,0,0,121,0,0,0,2,0,20,0,1,
	0,16,255,255,255,255,0,28,0,0,0,0,0,0,0,142,0,0,
	0,3,0,20,0,1,0,17,255,255,255,255,0,28,0,0,0,0,
	0,0,0,163,0,0,0,4,0,20,0,1,0,18,255,255,255,255,
	0,28,0,0,0,0,0,0,0,184,0,0,0,5,0,20,0,1,
	0,19,255,255,255,255,0,28,0,0,0,0,0,0,0,205,0,0,
	0,6,0,20,0,1,0,11,255,255,255,255,0,28,0,0,0,0,
	0,0,0,226,0,0,0,7,0,20,0,1,0,34,0,21,0,33,
	0,20,0,0,0,0,0,255,17,0,0,8,0,0,0,15,0,13,
	0,22,255,255,255,255,0,28,0,0,0,0,0,0,0,247,0,0,
	0,0,0,15,0,1,0,23,255,255,255,255,0,28,0,0,0,0,
	0,0,1,3,0,0,0,1,0,15,0,1,0,24,255,255,255,255,
	0,28,0,0,0,8,0,0,1,14,0,0,0,2,0,15,0,1,
	0,25,255,255,255,255,0,28,0,0,0,0,0,0,1,30,0,0,
	0,3,0,15,0,1,0,26,255,255,255,255,0,28,0,0,0,0,
	0,0,1,42,0,0,0,4,0,15,0,1,0,27,255,255,255,255,
	0,28,0,0,0,0,0,0,1,53,0,0,0,5,0,15,0,1,
	0,28,255,255,255,255,0,28,0,0,0,8,0,0,1,69,0,0,
	0,6,0,15,0,1,0,29,255,255,255,255,0,28,0,0,0,0,
	0,0,1,85,0,0,0,7,0,15,0,1,0,30,255,255,255,255,
	0,28,0,0,0,0,0,0,1,98,0,0,0,8,0,15,0,1,
	0,31,255,255,255,255,0,28,0,0,0,8,0,0,1,112,0,0,
	0,9,0,15,0,1,0,32,255,255,255,255,0,28,0,0,0,0,
	0,0,1,128,0,0,0,10,0,15,0,1,0,33,255,255,255,255,
	0,28,0,0,0,8,0,0,1,137,0,0,0,11,0,15,0,1,
	0,20,255,255,255,255,0,28,0,0,0,0,0,0,1,153,0,0,
	0,12,0,15,0,1,0,43,0,35,0,42,0,20,0,0,0,0,
	0,255,17,0,0,14,0,0,0,11,0,8,0,36,255,255,255,255,
	0,28,0,0,0,8,0,0,1,168,0,0,0,0,0,11,0,1,
	0,37,255,255,255,255,0,28,0,0,0,8,0,0,1,175,0,0,
	0,1,0,11,0,1,0,38,255,255,255,255,0,28,0,0,0,8,
	0,0,1,185,0,0,0,2,0,11,0,1,0,39,255,255,255,255,
	0,28,0,0,0,8,0,0,1,195,0,0,0,3,0,11,0,1,
	0,40,255,255,255,255,0,28,0,0,0,8,0,0,1,205,0,0,
	0,4,0,11,0,1,0,41,255,255,255,255,0,28,0,0,0,0,
	0,0,1,217,0,0,0,5,0,11,0,1,0,42,255,255,255,255,
	0,28,0,0,0,4,0,0,1,227,0,0,0,6,0,11,0,1,
	0,34,255,255,255,255,0,28,0,0,0,4,0,0,1,238,0,0,
	0,7,0,11,0,1,0,47,0,44,0,46,0,20,0,0,0,0,
	0,255,17,0,0,20,0,0,0,15,0,3,0,45,255,255,255,255,
	0,28,0,0,0,0,0,0,1,249,0,0,0,0,0,15,0,1,
	0,46,255,255,255,255,0,28,0,0,0,0,0,0,2,7,0,0,
	0,1,0,15,0,1,0,43,255,255,255,255,0,28,0,0,0,0,
	0,0,2,20,0,0,0,2,0,15,0,1,0,51,0,48,0,50,
	0,20,0,0,0,0,0,255,17,0,0,26,0,0,0,11,0,3,
	0,49,255,255,255,255,0,28,0,0,0,0,0,0,2,36,0,0,
	0,0,0,10,0,1,0,50,255,255,255,255,0,28,0,0,0,0,
	0,0,2,44,0,0,0,1,0,11,0,1,0,47,255,255,255,255,
	0,28,0,0,0,0,0,0,2,55,0,0,0,2,0,11,0,1,
	0,53,0,52,0,52,0,20,0,0,0,0,0,255,17,0,0,35,
	0,0,0,16,0,1,0,51,255,255,255,255,0,28,0,0,0,0,
	0,0,2,63,0,0,0,0,0,16,0,1,0,10,0,54,0,55,
	0,20,0,0,0,0,0,255,17,0,0,44,0,0,0,20,0,2,
	0,55,255,255,255,255,0,28,0,8,0,0,0,0,2,79,0,0,
	0,0,0,20,0,1,0,53,255,255,255,255,0,28,0,40,0,0,
	0,0,2,91,0,0,0,1,0,20,0,1,255,255,0,1,0,1,
	0,20,0,0,0,0,0,2,17,0,0,0,0,0,0,22,0,1,
	0,0,255,255,255,255,0,28,0,32,0,0,0,0,2,102,0,6,
	0,0,0,11,0,1,255,255,0,1,0,20,0,20,0,0,0,16,
	0,2,17,0,0,0,0,0,0,44,0,12,0,2,255,255,255,255,
	0,26,0,21,0,8,0,0,2,114,0,3,0,2,0,3,0,1,
	0,3,255,255,255,255,0,26,0,21,0,8,0,0,2,116,0,8,
	0,2,0,3,0,1,0,4,255,255,255,255,0,26,0,21,0,8,
	0,0,2,118,0,3,0,4,0,3,0,1,0,5,255,255,255,255,
	0,26,0,21,0,8,0,0,2,120,0,8,0,4,0,3,0,1,
	0,6,255,255,255,255,0,26,0,21,0,8,0,0,2,122,0,13,
	0,2,0,3,0,1,0,7,255,255,255,255,0,26,0,21,0,8,
	0,0,2,124,0,13,0,4,0,3,0,1,0,8,255,255,255,255,
	0,26,0,21,0,8,0,0,2,126,0,18,0,2,0,3,0,1,
	0,9,255,255,255,255,0,26,0,21,0,8,0,0,2,128,0,18,
	0,4,0,3,0,1,0,10,255,255,255,255,0,26,0,21,0,8,
	0,0,2,130,0,23,0,2,0,3,0,1,0,11,255,255,255,255,
	0,26,0,21,0,8,0,0,2,132,0,23,0,4,0,3,0,1,
	0,12,255,255,255,255,0,26,0,21,0,8,0,0,2,134,0,28,
	0,2,0,3,0,1,0,13,255,255,255,255,0,26,0,21,0,8,
	0,0,2,136,0,28,0,4,0,3,0,1,0,14,255,255,255,255,
	0,26,0,21,0,8,0,0,2,138,0,33,0,2,0,3,0,1,
	0,15,255,255,255,255,0,26,0,21,0,8,0,0,2,140,0,33,
	0,4,0,3,0,1,0,16,255,255,255,255,0,26,0,21,0,8,
	0,0,2,142,0,38,0,2,0,3,0,1,0,17,255,255,255,255,
	0,26,0,21,0,8,0,0,2,144,0,38,0,4,0,3,0,1,
	0,18,255,255,255,255,0,28,0,0,0,0,0,0,2,146,0,15,
	0,6,0,12,0,1,0,20,0,19,0,19,0,20,0,0,0,0,
	0,255,1,0,0,2,0,7,0,40,0,2,0,18,255,255,255,255,
	0,28,0,0,0,0,0,0,2,159,0,1,0,1,0,37,0,1,
	0,0,255,255,255,255,0,26,0,39,0,0,0,0,2,160,0,17,
	0,10,0,8,0,1,255,255,0,1,0,1,0,20,0,0,0,0,
	0,2,17,0,0,0,0,0,0,22,0,1,0,0,255,255,255,255,
	0,28,0,32,0,0,0,0,2,165,0,4,0,0,0,13,0,1,
	255,255,0,1,0,7,0,20,0,0,0,16,0,2,17,0,0,0,
	0,0,0,58,0,16,0,2,255,255,255,255,0,28,0,0,0,0,
	0,0,2,179,0,26,0,6,0,2,0,1,0,3,255,255,255,255,
	0,28,0,0,0,0,0,0,2,182,0,22,0,8,0,11,0,1,
	0,4,255,255,255,255,0,28,0,0,0,0,0,0,2,194,0,12,
	0,4,0,32,0,1,0,5,255,255,255,255,0,21,0,0,0,0,
	0,0,4,152,0,20,0,11,0,15,0,1,0,6,255,255,255,255,
	0,28,0,0,0,0,0,0,2,248,0,18,0,10,0,18,0,1,
	0,8,255,255,255,255,0,28,0,0,0,0,0,0,3,11,0,12,
	0,9,0,31,0,1,0,0,255,255,255,255,0,28,0,32,0,0,
	0,0,3,46,0,25,0,2,0,4,0,1,0,7,255,255,255,255,
	0,26,0,7,0,0,0,0,3,43,0,23,0,13,0,8,0,1,
	255,255,0,1,0,3,0,20,0,0,0,16,0,2,17,0,0,0,
	0,0,0,31,0,3,0,2,255,255,255,255,0,26,0,21,0,0,
	0,0,3,51,0,21,0,1,0,8,0,1,0,3,255,255,255,255,
	0,26,0,23,0,0,0,0,3,57,0,1,0,1,0,8,0,1,
	0,0,255,255,255,255,0,26,0,53,0,0,0,0,3,65,0,11,
	0,1,0,8,0,1,255,255,0,1,0,19,0,20,0,0,0,16,
	0,2,17,0,0,0,0,0,0,59,0,17,0,5,255,255,255,255,
	0,26,0,5,0,0,0,0,3,70,0,30,0,15,0,25,0,1,
	0,7,255,255,255,255,0,26,0,7,0,0,0,0,3,143,0,3,
	0,11,0,21,0,1,0,2,255,255,255,255,0,26,0,5,0,0,
	0,0,3,126,0,3,0,13,0,21,0,1,0,3,255,255,255,255,
	0,26,0,5,0,0,0,0,3,119,0,3,0,15,0,21,0,1,
	0,6,255,255,255,255,0,26,0,5,0,0,0,0,3,94,0,30,
	0,13,0,25,0,1,0,4,255,255,255,255,0,26,0,5,0,0,
	0,0,3,106,0,30,0,11,0,25,0,1,0,8,255,255,255,255,
	0,28,0,0,0,0,0,0,3,158,0,15,0,1,0,29,0,1,
	0,10,0,9,0,9,0,20,0,0,0,0,0,255,17,0,0,12,
	0,3,0,39,0,1,0,8,255,255,255,255,0,29,0,8,0,0,
	0,0,4,180,0,0,0,0,0,39,0,1,0,12,0,11,0,11,
	0,20,0,0,0,0,0,255,17,0,0,12,0,5,0,39,0,1,
	0,10,255,255,255,255,0,29,0,8,0,0,0,0,4,208,0,0,
	0,0,0,39,0,1,0,15,0,13,0,14,0,20,0,0,0,0,
	0,255,1,0,0,25,0,7,0,29,0,1,0,14,255,255,255,255,
	0,26,0,17,0,0,0,0,4,75,0,1,0,0,0,15,0,1,
	0,12,255,255,255,255,0,26,0,17,0,0,0,0,4,89,0,17,
	0,0,0,11,0,1,0,18,0,16,0,17,0,20,0,0,0,0,
	0,255,1,0,0,25,0,9,0,29,0,1,0,17,255,255,255,255,
	0,26,0,17,0,0,0,0,4,100,0,17,0,0,0,11,0,1,
	0,15,255,255,255,255,0,26,0,17,0,0,0,0,4,111,0,1,
	0,0,0,15,0,1,0,19,255,255,255,255,0,28,0,0,0,0,
	0,0,4,126,0,8,0,7,0,11,0,1,0,0,255,255,255,255,
	0,28,0,32,0,0,0,0,4,138,0,8,0,9,0,13,0,1,
	0,0,4,236,0,0,13,188,0,0,12,132,0,0,13,92,0,0,
	10,92,0,0,10,44,0,0,12,84
};
