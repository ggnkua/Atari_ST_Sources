#define OBICONT 10
#define TCANCEL 13
#define TOK 14
#define XCROSS 12
#define TRADBUT 11
#define YBDBOX 21
#define XOK 13
#define OSTRING 3
#define OBUTBOX 2
#define TCROSS 12
#define YBDCOLOR 23
#define XCANCEL 14
#define OFTEXT 4
#define TIBGBOX 46
#define YBDDWN 24
#define OEDITBOX 5
#define YBDUP 25
#define XMT 18
#define OBOX 7
#define OIBOX 6
#define TIBGCOLO 48
#define YFBOX 27
#define XBDBOX 27
#define XMR 19
#define OTEXT 8
#define TIBGUP 50
#define TIBGDWN 49
#define OBOXCHAR 9
#define YFILL 29
#define XBDCOLOR 29
#define OBOXTEXT 10
#define TIFBOX 52
#define YFUP 31
#define YFDWN 30
#define XBDUP 31
#define XBDDWN 30
#define TIFDWN 55
#define TIFUP 56
#define YLBOX 33
#define XBGBOX 21
#define TIFILL 54
#define YLINE 35
#define XBGCOLOR 23
#define YLDWN 36
#define XBGDWN 24
#define TIMT 27
#define YLUP 37
#define XBGUP 25
#define TIMR 26
#define YEXBOX 40
#define XFBOX 39
#define MKRSCMNU 1
#define TIBDBOX 40
#define YEXAMPLE 39
#define XFILL 41
#define DESK 3
#define TIBDCOLO 42
#define XFUP 43
#define XFDWN 42
#define FILE 4
#define TIBDUP 44
#define TIBDDWN 43
#define EDIT 5
#define XTBOX 33
#define WINDOWS 7
#define CHOOSE 6
#define TITBOX 34
#define XTCOLOR 35
#define TITCOLOR 36
#define XTDWN 36
#define TITDWN 37
#define XTUP 37
#define ABOUT 10
#define TITUP 38
#define XBOXCHAR 15
#define OLDTREE 12
#define XEXBOX 44
#define TIJL 30
#define XEXAMPLE 45
#define OTEDIT 2
#define TIJC 31
#define XLBOX 47
#define TREICONT 7
#define OTDIALOG 4
#define OTMENU 3
#define TIJR 32
#define TMENU 2
#define OTUNKNOW 5
#define TILBOX 47
#define XLINE 49
#define TDIALOG 3
#define OTCANCEL 6
#define NEW 19
#define XLUP 51
#define XLDWN 50
#define TUNKNOWN 4
#define OTOK 7
#define OPEN 20
#define TILDWN 57
#define TILINE 53
#define TILUP 58
#define SAVE 23
#define CLOSE 22
#define SAVEAS 24
#define TIFL 18
#define TIFS 17
#define QUIT 26
#define CUT 28
#define TTMPLT 22
#define COPY 29
#define TVALID 23
#define ABOUTT 14
#define ERASE 31
#define PASTE 30
#define TIEXBOX 61
#define TTEXT 24
#define NAM 33
#define TIEXAMPL 65
#define SNAP 35
#define SALL 36
#define SSEL 37
#define COUT 39
#define SORT 38
#define AOK 10
#define ROTATE 41
#define SORTD 15
#define SRTYX 6
#define MTBOX2 5
#define SRTOK 7
#define SRTXY 3
#define SRTCAN 8
#define SRTX 4
#define SRTY 5
#define NEWTOP 16
#define DUMMNU 3
#define BUTTONT 9
#define DDESK 3
#define DFILE 4
#define BCHECKED 3
#define BSELECT 2
#define BEDITABL 4
#define NAMOBJT 13
#define DABOUT 7
#define BDEFAULT 5
#define BTOUCHEX 7
#define BSHADOW 6
#define BEXIT 8
#define BOUTLINE 9
#define BRADBUT 11
#define BDISABLE 10
#define BCROSSED 12
#define BCANCEL 13
#define DQUIT 16
#define BOK 15
#define BEDITSTR 14
#define MNUICONT 0
#define NOCANCEL 13
#define NOOK 14
#define ENTRY 3
#define TITLE 2
#define NOEDIT 15
#define DOTLINE1 4
#define MENUBOX 5
#define NEWTREE 8
#define NTEDIT 2
#define NTOK 3
#define NTCANCEL 4
#define MTBOX1 4
#define BOXT 11
#define YCHECKED 3
#define YSELECT 2
#define YEDITABL 4
#define YDEFAULT 5
#define YTOUCHEX 7
#define YSHADOW 6
#define TIST 2
#define YEXIT 8
#define BOXCT 6
#define YOUTLINE 9
#define TSELECT 2
#define YRADBUT 11
#define YDISABLE 10
#define XCHECKED 3
#define XSELECT 2
#define TDEFAULT 5
#define TEXIT 8
#define YCROSS 12
#define XEDITABL 4
#define TCHECKED 3
#define YOK 13
#define XDEFAULT 5
#define TSHADOW 6
#define YBGBOX 15
#define YCANCEL 14
#define XTOUCHEX 7
#define XSHADOW 6
#define TEDITABL 4
#define TOUTLINE 9
#define XEXIT 8
#define TTOUCHEX 7
#define YBGCOLOR 17
#define XOUTLINE 9
#define TDISABLE 10
#define YBGUP 19
#define YBGDWN 18
#define XRADBUT 11
#define XDISABLE 10
