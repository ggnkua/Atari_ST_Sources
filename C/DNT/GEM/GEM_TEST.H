#define DIALOGUE 0  	/* TREE */
#define INFOS 1  	/* TREE */
#define TEDOBJC 1  	/* OBJECT in TREE #0 */
#define RB2 3  	/* OBJECT in TREE #0 */
#define RB1 4  	/* OBJECT in TREE #0 */
#define RB4 6  	/* OBJECT in TREE #0 */
#define RB3 7  	/* OBJECT in TREE #0 */
#define SORTIE2 8  	/* OBJECT in TREE #0 */
#define ICONE 9  	/* OBJECT in TREE #0 */
#define SORTIE1 11  	/* OBJECT in TREE #0 */
#define OS 2  	/* OBJECT in TREE #1 */
#define NC 6  	/* OBJECT in TREE #1 */
#define RBE 7  	/* OBJECT in TREE #1 */
#define TF 8  	/* OBJECT in TREE #1 */
#define TE 10  	/* OBJECT in TREE #1 */
#define OK 11  	/* OBJECT in TREE #1 */
#define QUIT 12  	/* OBJECT in TREE #1 */
