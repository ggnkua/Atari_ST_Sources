/* resource set indices for MCPARM */

#define SYS        0 /* form/dialog */
#define MYNUM      2 /* TEXT in tree SYS */
#define RNAME      7 /* FTEXT in tree SYS */
#define TIMER      9 /* FTEXT in tree SYS */
#define MCTIMER   12 /* FTEXT in tree SYS */
#define PRIBLOCK  14 /* FTEXT in tree SYS */
#define PRXX      16 /* FTEXT in tree SYS */
#define PRFF      18 /* FTEXT in tree SYS */
#define PLUSFF    20 /* BUTTON in tree SYS */
#define NOFF      21 /* BUTTON in tree SYS */
#define FULLDEB   24 /* BUTTON in tree SYS */
#define ERRDEB    25 /* BUTTON in tree SYS */
#define NODEB     26 /* BUTTON in tree SYS */
#define OK        27 /* BUTTON in tree SYS */
#define SPEICHER  28 /* BUTTON in tree SYS */
#define CANCEL    29 /* BUTTON in tree SYS */

