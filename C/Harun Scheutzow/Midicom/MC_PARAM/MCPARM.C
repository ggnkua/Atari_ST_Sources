#include <aes.h>

static char string_0[] = "Station  :";
static char string_1[] = "7";
static char string_2[] = "_";
static char string_3[] = "9";
static char string_4[] = "MIDI_COM 3.7";
static char string_5[] = "";
static char string_6[] = "";
static char string_7[] = "Parameter-Kontrolle";
static char string_8[] = "";
static char string_9[] = "";
static char string_10[] = "Node-Name:";
static char string_11[] = "12345678";
static char string_12[] = "________";
static char string_13[] = "X";
static char string_14[] = "Ring-Timeout:";
static char string_15[] = "03";
static char string_16[] = "__";
static char string_17[] = "9";
static char string_18[] = "Sek.";
static char string_19[] = "EVENT-TIMER :";
static char string_20[] = "1234";
static char string_21[] = "____";
static char string_22[] = "9";
static char string_23[] = "Block-Gr”že:";
static char string_24[] = "1234";
static char string_25[] = "____";
static char string_26[] = "9";
static char string_27[] = "Timeoutxx:";
static char string_28[] = "1234";
static char string_29[] = "____";
static char string_30[] = "9";
static char string_31[] = "TimeoutFF:";
static char string_32[] = "1234";
static char string_33[] = "____";
static char string_34[] = "9";
static char string_35[] = "ergz. FF :";
static char string_36[] = "Ja";
static char string_37[] = "Nein";
static char string_38[] = "Kontrolle:";
static char string_39[] = "Voll";
static char string_40[] = " Err. sensitive ";
static char string_41[] = "NONE";
static char string_42[] = "OK";
static char string_43[] = "speichern";
static char string_44[] = "Abbruch";


static int IMAGE0[] = {
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x060C, 
0x0000, 0x0000, 0x0000, 0x030C, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x058B, 0x0000, 0x0000, 0x0000, 0x0D34, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0870, 
0xC000, 0x0000, 0x0000, 0x30C2, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0001, 0x8818, 0x3000, 0x0000, 0x0000, 0xC382, 
0x3000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 0x6816, 
0x3C00, 0x0000, 0x0003, 0x8C82, 0xD000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0002, 0x1811, 0xC700, 0x0000, 0x000C, 0x7083, 
0x0800, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0002, 0x1720, 
0x71C0, 0x0000, 0x0031, 0xC05D, 0x0800, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0002, 0x10E0, 0x4C70, 0x0000, 0x00C6, 0x4061, 
0x0800, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x001A, 0x1030, 
0x431C, 0x0000, 0x0318, 0x41C1, 0x0B00, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0016, 0x204E, 0x80E7, 0x0000, 0x0CE0, 0x2E20, 
0x8D00, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0015, 0xE041, 
0x80F9, 0xC000, 0x33E0, 0x3020, 0xF500, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0024, 0x3040, 0xE11E, 0x7000, 0xCF10, 0xE021, 
0x8480, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0024, 0x2E81, 
0x1D07, 0x9C03, 0x3C17, 0x102E, 0x8480, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0028, 0x4181, 0x0301, 0xE70C, 0xF018, 0x1030, 
0x4280, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0028, 0x40F1, 
0x01C0, 0x5FFF, 0x4070, 0x11D0, 0x4280, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0048, 0x408E, 0x0238, 0x33F9, 0x8388, 0x0E10, 
0x4240, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0078, 0x8103, 
0x0206, 0x0FFE, 0x0C08, 0x1808, 0x23C0, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x007C, 0x8102, 0xE201, 0x9FBF, 0x3008, 0xE808, 
0x27C0, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0073, 0x8102, 
0x1A04, 0x7EEF, 0xE40B, 0x0808, 0x39C0, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0050, 0xE204, 0x0707, 0xFDB7, 0xDC1C, 0x0404, 
0xE140, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x00D1, 0x1A04, 
0x04C7, 0xC318, 0x7664, 0x0407, 0x1160, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x00E1, 0x0704, 0x043F, 0x3CE7, 0x9F84, 0x041C, 
0x10E0, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x00E1, 0x04C8, 
0x046E, 0x3F1F, 0x8E64, 0x0264, 0x10E0, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x00E1, 0x0438, 0x09F9, 0xCE0E, 0x73DA, 0x0382, 
0x10E0, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x01A2, 0x040E, 
0x0FCB, 0x71B1, 0xDA76, 0x0E02, 0x08B0, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x01DA, 0x0409, 0xDF0D, 0x8EEE, 0x351F, 0xF202, 
0x0B70, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x01D6, 0x0810, 
0x7C1E, 0x03B8, 0x0F07, 0xE101, 0x0D70, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x01D5, 0x8813, 0xFC70, 0x05F4, 0x03C7, 0xD901, 
0x3570, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x01E4, 0x781F, 
0xD3D0, 0x1E0F, 0x0179, 0x7F01, 0xC4F0, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x03A4, 0x1C3F, 0x1772, 0x7803, 0xC9DD, 0x1F87, 
0x04B8, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x03A4, 0x13FC, 
0x181F, 0xC000, 0xFF83, 0x07F8, 0x84B8, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x03A8, 0x13F0, 0x7027, 0x6000, 0xDC81, 0xC1F8, 
0x82B8, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x03A8, 0x2F7B, 
0xE03E, 0xF803, 0xEF80, 0xFBDE, 0x82B8, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0328, 0xB9CF, 0x2072, 0x1E0F, 0x09C0, 0x9E73, 
0xE298, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0750, 0xE67D, 
0xA3E2, 0x07BC, 0x08F8, 0xB7CC, 0xE15C, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0753, 0xB9D0, 0x7F24, 0x01F0, 0x045F, 0xC173, 
0x795C, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x075E, 0xE6E0, 
0x7C44, 0x01B0, 0x0447, 0xC0EC, 0xEF5C, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0679, 0xD981, 0xDB44, 0x0E0E, 0x045B, 0x7033, 
0x33CC, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0AE7, 0xE6EE, 
0x60C4, 0x3803, 0x8460, 0xCEEC, 0xFCFA, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0F7B, 0x9939, 0x807C, 0xE000, 0xE7A0, 0x3393, 
0x3BDE, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0EED, 0xE1C6, 
0x8047, 0x8000, 0x3C20, 0x2C70, 0xD6EF, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x7DF1, 0x8709, 0x809F, 0x8000, 0x3F20, 0x321C, 
0x31F7, 0xC000, 0x0000, 0x0000, 0x0000, 0x0001, 0xCFC3, 0x39F0, 
0xC0EE, 0x7001, 0xCEE0, 0x61F3, 0x987E, 0x7000, 0x0000, 0x0000, 
0x0000, 0x0006, 0x1ECF, 0xC3E1, 0x33B6, 0x1C07, 0x0DB9, 0x90F8, 
0x6E6F, 0x0C00, 0x0000, 0x0000, 0x0000, 0x0018, 0x38F3, 0x0319, 
0x1CC6, 0x071C, 0x0C77, 0x1318, 0x19E3, 0x8300, 0x0000, 0x0000, 
0x0000, 0x0060, 0xD8DF, 0x0E05, 0x6386, 0x01F0, 0x0C18, 0xD40C, 
0x0F63, 0x60C0, 0x0000, 0x0000, 0x0000, 0x0383, 0x19E2, 0x1603, 
0x8DCA, 0x03F8, 0x0A76, 0x380F, 0x08F3, 0x1838, 0x0000, 0x0000, 
0x0000, 0x0E1C, 0x2F82, 0x660F, 0xB13A, 0x0F1E, 0x0B91, 0xBE0C, 
0xCC3E, 0x870E, 0x0000, 0x0000, 0x0000, 0x3870, 0x3D03, 0x8632, 
0x410D, 0x3C07, 0x9610, 0x498C, 0x3C17, 0x81C3, 0x8000, 0x0000, 
0x0000, 0xE1C0, 0x7106, 0x0BC3, 0xF10B, 0xF001, 0xFA09, 0xF87A, 
0x0C11, 0xC070, 0xE000, 0x0000, 0x0003, 0x8701, 0xB10C, 0x0E06, 
0x590F, 0xC000, 0x7E0B, 0x4C0E, 0x0611, 0xB01C, 0x3800, 0x0000, 
0x000E, 0x0606, 0x3134, 0x3C1C, 0x8E3B, 0x6000, 0xDB8E, 0x2707, 
0x8791, 0x8C0C, 0x0E00, 0x0000, 0x001C, 0x1A0E, 0x72CC, 0xCC64, 
0x876D, 0x1803, 0x16DC, 0x24C6, 0x6669, 0xCE0B, 0x0700, 0x0000, 
0x0064, 0x6131, 0x730F, 0x1584, 0x83BF, 0x064C, 0x1FBC, 0x2435, 
0x1E19, 0xD190, 0xC4C0, 0x0000, 0x0183, 0x80C1, 0x6E1C, 0x1604, 
0x8F7B, 0xE1F0, 0xFBD6, 0x240D, 0x070E, 0xD060, 0x3830, 0x0000, 
0x0607, 0x0340, 0xF668, 0x1C09, 0x3399, 0x18E3, 0x1335, 0x9207, 
0x03CD, 0xE058, 0x1C0C, 0x0000, 0x0219, 0x0440, 0xE798, 0x3409, 
0xC65D, 0x87BC, 0x374C, 0x7203, 0x833C, 0xE044, 0x1308, 0x0000, 
0x0260, 0x9821, 0xE698, 0xE80F, 0x1C3B, 0x45F4, 0x5B87, 0x1E02, 
0xE2AC, 0xF083, 0x20C8, 0x0000, 0x0180, 0x6016, 0xF45B, 0x2819, 
0x6419, 0xD9B3, 0x7302, 0xD302, 0x9AC5, 0xED00, 0xC030, 0x0000, 
0x0681, 0xA018, 0xDC2C, 0x2871, 0x8419, 0x660C, 0xD302, 0x31C2, 
0x8687, 0x6300, 0xB02C, 0x0000, 0x1846, 0x2038, 0xCC38, 0x4B96, 
0x041D, 0xBA0B, 0xB702, 0x0D3A, 0x4386, 0x6380, 0x8C43, 0x0000, 
0x2058, 0x10C5, 0xCC78, 0x4C1A, 0x0837, 0xDC07, 0x7D82, 0x0B06, 
0x43C6, 0x7461, 0x0340, 0x8000, 0x1020, 0x0B03, 0xCFD4, 0x7862, 
0x083F, 0x8C06, 0x3F82, 0x08C1, 0xC57E, 0x781A, 0x0081, 0x0000, 
0x10D0, 0x0C03, 0xD752, 0xD1A2, 0x0C7C, 0x8F1E, 0x27C7, 0x08B1, 
0x695D, 0x7806, 0x0161, 0x0000, 0x0B10, 0x1401, 0x98D1, 0xF624, 
0x0BF2, 0xCCA6, 0x69FB, 0x048D, 0xF123, 0x3005, 0x011A, 0x0000, 
0x0C08, 0x6203, 0xF8D0, 0x9824, 0x17FA, 0xAAEA, 0xABFD, 0x0483, 
0x2123, 0xF808, 0xC206, 0x0000, 0x3205, 0x8203, 0xA8D1, 0x7844, 
0x1E57, 0x9111, 0x3D4F, 0x0443, 0xD162, 0xB808, 0x3409, 0x8000, 
0x4206, 0x0103, 0xE8A1, 0xB644, 0x3292, 0xFAAB, 0xE929, 0x844D, 
0xB0A2, 0xF810, 0x0C08, 0x4000, 0x210A, 0x008E, 0xA8B7, 0x1144, 
0xD2A1, 0xAEAE, 0xB0A8, 0xE451, 0x9D92, 0xAE20, 0x0A10, 0x8000, 
0x10B1, 0x00B3, 0x3129, 0x28CF, 0x11A1, 0xB3F9, 0xB0B0, 0x9E62, 
0x9291, 0x99A0, 0x11A1, 0x0000, 0x10C0, 0x80C7, 0x513A, 0x24FC, 
0x21A1, 0xE7BC, 0xF0B0, 0x87E4, 0x8B91, 0x5C60, 0x2061, 0x0000, 
0x0B40, 0x8327, 0x59E6, 0x22F8, 0x21A0, 0xF8A3, 0xE0B0, 0x83E8, 
0x8CEB, 0x5C98, 0x205A, 0x0000, 0x0C20, 0x4C15, 0x5722, 0x23DF, 
0xA1A3, 0x81D0, 0x38B0, 0x7F78, 0x889D, 0x5506, 0x4086, 0x0000, 
0x1210, 0x3015, 0x9E45, 0x2D9A, 0x7FFC, 0x8338, 0x27FF, 0xCB36, 
0x944F, 0x3501, 0x8109, 0x0000, 0x0A10, 0x700E, 0xB244, 0xB179, 
0x23FF, 0xFA0B, 0xFFF8, 0x53D1, 0xE44D, 0xAE01, 0xC10A, 0x0000, 
0x0509, 0x900E, 0xE345, 0xC13C, 0xCE31, 0xCFFE, 0x718E, 0x6790, 
0x7454, 0xEE01, 0x3214, 0x0000, 0x0486, 0x080F, 0xA4C6, 0x4116, 
0xF27F, 0xF803, 0xFFC9, 0xED10, 0x4C64, 0xBE02, 0x0C24, 0x0000, 
0x025A, 0x040F, 0x24D8, 0x611F, 0xFFF2, 0x5001, 0x49FF, 0xFF10, 
0xC364, 0x9E04, 0x0B48, 0x0000, 0x0162, 0x043B, 0x24E8, 0x53FF, 
0x7E32, 0x7001, 0xC98E, 0xFFF9, 0x42E2, 0x9B84, 0x08D0, 0x0000, 
0x00A1, 0x02DB, 0x2BA8, 0xFFA2, 0xCE4C, 0x6000, 0xC64F, 0x28BF, 
0xE2BA, 0x9B68, 0x10A0, 0x0000, 0x0050, 0x8316, 0xACB0, 0x7E21, 
0x9BCC, 0xE000, 0xE67B, 0x308F, 0x61A6, 0xAD18, 0x2140, 0x0000, 
0x0028, 0x8C96, 0x7891, 0xE620, 0xE8CD, 0x6000, 0xD662, 0xF08C, 
0xF121, 0xCD26, 0x2280, 0x0000, 0x0034, 0x7097, 0xD09E, 0xA640, 
0xE87E, 0xD001, 0x6FC2, 0xF04C, 0xAF21, 0x7D21, 0xC580, 0x0000, 
0x0014, 0x6056, 0x70F4, 0x9541, 0xB85F, 0x5001, 0x5F43, 0x9055, 
0x25E1, 0xCD40, 0xC500, 0x0000, 0x000A, 0x303C, 0x53A4, 0x8CC6, 
0x985F, 0xD001, 0x5F43, 0x1C66, 0x24B9, 0x4781, 0x8A00, 0x0000, 
0x0005, 0x102C, 0x5922, 0x844D, 0x1C73, 0x7001, 0xF9C7, 0x1644, 
0x2892, 0xC681, 0x1400, 0x0000, 0x0002, 0x883C, 0x69A1, 0x8A43, 
0xD665, 0xD803, 0x74CD, 0x784A, 0x10B2, 0xC782, 0x2800, 0x0000, 
0x0001, 0x846A, 0xA541, 0x09A1, 0x3D69, 0x4E0E, 0x5257, 0x88B2, 
0x1054, 0xAAC4, 0x3000, 0x0000, 0x0001, 0xC64D, 0xA361, 0x8991, 
0x23C8, 0xE9F2, 0xE278, 0x8932, 0x30D8, 0x764C, 0x7000, 0x0000, 
0x0000, 0xE24C, 0xC361, 0x4889, 0x217C, 0xD8F3, 0x67D0, 0x8A22, 
0x50D8, 0x6648, 0xE000, 0x0000, 0x0000, 0x515A, 0xC191, 0x30C6, 
0x43A3, 0xE70C, 0xF8B8, 0x4C61, 0x5130, 0x6B51, 0x4000, 0x0000, 
0x0000, 0x30D1, 0xC189, 0x3126, 0x44B0, 0x7F1F, 0xC1A4, 0x4491, 
0x9230, 0x7161, 0x8000, 0x0000, 0x0000, 0x18D1, 0xA285, 0x1112, 
0x49C8, 0x67FC, 0xE272, 0x4D11, 0x0C28, 0xB163, 0x0000, 0x0000, 
0x0000, 0x1CF1, 0x92C2, 0x190B, 0x51C5, 0xA7FC, 0x9C71, 0x5613, 
0x0869, 0x31E7, 0x0000, 0x0000, 0x0000, 0x0EB1, 0xCB23, 0x290A, 
0xA2A6, 0x3BBB, 0x8EA8, 0xA612, 0x989A, 0x71AE, 0x0000, 0x0000, 
0x0000, 0x07B9, 0xA712, 0xA504, 0xC39B, 0xF209, 0xF9B8, 0x6614, 
0xA89C, 0x93BC, 0x0000, 0x0000, 0x0000, 0x03B5, 0x2312, 0x6206, 
0xA6FC, 0xAE0E, 0xA7EC, 0xAA08, 0xC918, 0x95B8, 0x0000, 0x0000, 
0x0000, 0x01AB, 0x130A, 0x2205, 0xF7C8, 0x7913, 0xC27D, 0xF208, 
0x8A19, 0x1AB0, 0x0000, 0x0000, 0x0000, 0x01E7, 0x0E86, 0x5305, 
0xBFFC, 0x2514, 0x87FF, 0xB219, 0x442E, 0x1CF0, 0x0000, 0x0000, 
0x0000, 0x03E3, 0x0E44, 0x5287, 0xF883, 0xFF1F, 0xF822, 0xFA29, 
0x444E, 0x18F8, 0x0000, 0x0000, 0x0000, 0x0362, 0x8446, 0x4C7E, 
0xDC83, 0x7FFF, 0xD827, 0x7FC6, 0x4C44, 0x28D8, 0x0000, 0x0000, 
0x0000, 0x0373, 0x4625, 0x47CB, 0x33FF, 0xA6AC, 0xBFF9, 0x8D7C, 
0x548C, 0x59D8, 0x0000, 0x0000, 0x0000, 0x02DE, 0xA515, 0xBE2F, 
0xFF0C, 0xA3B8, 0xA61F, 0xFF8F, 0xB50C, 0xAF68, 0x0000, 0x0000, 
0x0000, 0x06CE, 0x950C, 0xDFFA, 0x6910, 0xA1B0, 0xA112, 0xCBFF, 
0x6615, 0x2E6C, 0x0000, 0x0000, 0x0000, 0x06C6, 0x48FF, 0xE494, 
0x65A0, 0x50E1, 0x40B4, 0xC524, 0xFFE2, 0x4C6C, 0x0000, 0x0000, 
0x0000, 0x0786, 0x2FCA, 0x484C, 0xC3C0, 0x30E1, 0x8078, 0x6642, 
0x4A7E, 0x8E3C, 0x0000, 0x0000, 0x0000, 0x058F, 0x1A49, 0x2825, 
0x4320, 0x30E1, 0x8098, 0x5482, 0x924B, 0x1E34, 0x0000, 0x0000, 
0x0000, 0x0D8D, 0x9928, 0x981A, 0x8120, 0x1151, 0x0090, 0x2B03, 
0x2293, 0x3636, 0x0000, 0x0000, 0x0000, 0x0D8C, 0xC918, 0x481A, 
0x8090, 0x1AEB, 0x0120, 0x2B02, 0x4312, 0x6636, 0x0000, 0x0000, 
0x0000, 0x0E94, 0x6C98, 0x380F, 0xFFFF, 0xFFFF, 0xFFFF, 0xFE03, 
0x8326, 0xC52E, 0x0000, 0x0000, 0x0000, 0x0F1F, 0xFFFF, 0xFFFF, 
0xFF24, 0x1CA7, 0x04BF, 0xFFFF, 0xFFFF, 0xFF1E, 0x0000, 0x0000, 
0x0000, 0x1B08, 0x3A34, 0x1213, 0x8012, 0x1319, 0x0900, 0x3909, 
0x058B, 0x821B, 0x0000, 0x0000, 0x0000, 0x1D08, 0x1912, 0x1A13, 
0x4011, 0x0318, 0x1100, 0x590B, 0x0913, 0x0217, 0x0000, 0x0000, 
0x0000, 0x1D08, 0x1C9A, 0x1522, 0xA009, 0x0318, 0x1200, 0xA895, 
0x0B27, 0x0217, 0x0000, 0x0000, 0x0000, 0x1D08, 0x1695, 0x22A4, 
0x5004, 0x83B8, 0x2401, 0x44A8, 0x952D, 0x0217, 0x0000, 0x0000, 
0x0000, 0x2E08, 0x1352, 0xA1A4, 0x3002, 0x464C, 0x4801, 0x84B0, 
0xA959, 0x020E, 0x8000, 0x0000, 0x0000, 0x3A10, 0x23B1, 0xA0E8, 
0x1801, 0x264C, 0x9003, 0x02E0, 0xB0B8, 0x810B, 0x8000, 0x0000, 
0x0000, 0x3FFF, 0xA171, 0x6068, 0x1401, 0x1AAB, 0x1005, 0x02C0, 
0xD1D0, 0xBFFF, 0x8000, 0x0000, 0x0000, 0x3210, 0x7FFF, 0xFFF0, 
0x0C00, 0x9B1B, 0x2006, 0x01FF, 0xFFFF, 0xC109, 0x8000, 0x0000, 
0x0000, 0x5210, 0x2068, 0x507F, 0xFFFF, 0xFD17, 0xFFFF, 0xFFC1, 
0x42C0, 0x8109, 0x4000, 0x0000, 0x0000, 0x6410, 0x2034, 0x70B8, 
0x03FF, 0xFFFF, 0xFFF8, 0x03A1, 0xC580, 0x8104, 0xC000, 0x0000, 
0x0000, 0x6410, 0x203C, 0x58BF, 0xFF80, 0x3405, 0x803F, 0xFFA3, 
0x4780, 0x8104, 0xC000, 0x0000, 0x0000, 0x6420, 0x4036, 0x4C84, 
0x0080, 0x2C06, 0x8020, 0x0426, 0x4D40, 0x4084, 0xC000, 0x0000, 
0x0000, 0xA420, 0x404B, 0x8502, 0x0040, 0x4802, 0x4040, 0x0814, 
0x3A40, 0x4084, 0xA000, 0x0000, 0x0000, 0xFF20, 0x4045, 0x8301, 
0x0020, 0x5405, 0x4080, 0x1018, 0x3440, 0x409F, 0xE000, 0x0000, 
0x0000, 0x48FF, 0xFF42, 0x8101, 0x8030, 0x9209, 0x2180, 0x3010, 
0x285F, 0xFFE2, 0x4000, 0x0000, 0x0000, 0x4820, 0x40FF, 0xFF80, 
0xC018, 0xA110, 0xA300, 0x603F, 0xFFE0, 0x4082, 0x4000, 0x0000, 
0x0000, 0x4820, 0x4041, 0xE3FF, 0xFE09, 0x40A0, 0x520F, 0xFFF8, 
0xF040, 0x4082, 0x4000, 0x0000, 0x0000, 0x4840, 0x8041, 0xB240, 
0x51FF, 0xFE4F, 0xFFF1, 0x4049, 0xB020, 0x2042, 0x4000, 0x0000, 
0x0000, 0x8840, 0x8081, 0x5220, 0x2807, 0xFFFF, 0xFC02, 0x8089, 
0x5020, 0x2042, 0x2000, 0x0000, 0x0000, 0x9040, 0x8081, 0x6C37, 
0xFFFB, 0x00A0, 0x1BFF, 0xFD86, 0xD020, 0x2041, 0x2000, 0x0000, 
0x0000, 0xFFC0, 0x8081, 0x37F8, 0x1402, 0x8110, 0x2805, 0x03FD, 
0x9020, 0x207F, 0xE000, 0x0000, 0x0000, 0x107F, 0xFFC2, 0x1E0C, 
0x0A02, 0x4208, 0x480A, 0x060F, 0x087F, 0xFFC1, 0x0000, 0x0000, 
0x0000, 0x1040, 0x80BF, 0xFFC6, 0x0504, 0x2404, 0x8414, 0x0C7F, 
0xFFA0, 0x2041, 0x0000, 0x0000, 0x0000, 0x1081, 0x0082, 0x0D3F, 
0xFFE8, 0x1803, 0x02FF, 0xFF96, 0x0810, 0x1021, 0x0000, 0x0000, 
0x0000, 0x2081, 0x0102, 0x0682, 0x825F, 0xFFFF, 0xFF48, 0x282C, 
0x0810, 0x1020, 0x8000, 0x0000, 0x0000, 0x2081, 0x0104, 0x03C1, 
0x41FF, 0xFE0F, 0xFFF0, 0x5078, 0x0410, 0x1020, 0x8000, 0x0000, 
0x0000, 0x3FF9, 0x0104, 0x03FF, 0xFEB0, 0x2404, 0x81AF, 0xFFF8, 
0x0410, 0x13FF, 0x8000, 0x0000, 0x0000, 0x0087, 0xFFFF, 0xFCF0, 
0xA0A8, 0x4208, 0x42A0, 0xA1E7, 0xFFFF, 0xFC20, 0x0000, 0x0000, 
0x0000, 0x0081, 0x0100, 0x7FFF, 0xF844, 0x8110, 0x2443, 0xFFFF, 
0xC010, 0x1020, 0x0000, 0x0000, 0x0000, 0x0102, 0x0100, 0x0074, 
0x2FFF, 0xFFFF, 0xFFFE, 0x85C0, 0x0008, 0x0810, 0x0000, 0x0000, 
0x0000, 0x0102, 0x0200, 0x003C, 0x27FF, 0xFFFF, 0xFFFC, 0x8780, 
0x0008, 0x0810, 0x0000, 0x0000, 0x0000, 0x01FF, 0xFFFF, 0xFFFF, 
0xFFFF, 0xFCA7, 0xFFFF, 0xFFFF, 0xFFFF, 0xFFF0, 0x0000, 0x0000, 
0x0000, 0x0003, 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 0xFFFF, 
0xFFFF, 0xF800, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x000A, 
0x8888, 0x4208, 0x4222, 0x2A00, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0007, 0x4450, 0x2208, 0x8144, 0x5C00, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0003, 
0xA260, 0x1405, 0x00C8, 0xB800, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0002, 0x9120, 0x0802, 0x0091, 0x2800, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 
0x5150, 0x1405, 0x0151, 0x5000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0xA888, 0x2208, 0x8222, 0xA000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x7404, 0x4110, 0x4405, 0xC000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x5202, 0x8110, 0x2809, 0x4000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x2901, 0x00A0, 0x1012, 0x8000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x1482, 0x8040, 0x2825, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0E44, 0x40A0, 0x444E, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0744, 0x2110, 0x845C, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0528, 0x2208, 0x8294, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0290, 0x1405, 0x0128, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x01E8, 0x0802, 0x02F0, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x00E4, 0x1405, 0x04E0, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0092, 0x2208, 0x8920, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0049, 0x2110, 0x9240, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0028, 0xC0A0, 0x6280, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0014, 0x8040, 0x2500, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0013, 0x40A0, 0x5900, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x000B, 0x2110, 0x9A00, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0004, 0x9111, 0x2400, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x4A0A, 0x4000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x4404, 0x4000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x2A0A, 0x8000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x1209, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0110, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x00A0, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0040, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000};


char *rs_frstr[] = {
0
};


static BITBLK rs_bitblk[] = {
	{ IMAGE0, 24, 180, 0, 0, 1 },
};


BITBLK *rs_frimg[] = {
0
};


static TEDINFO rs_tedinfo[] = {
	{ string_1, string_2, string_3, 3, 6, 0, 0x1180, 0x0, -1, 2,2 },
	{ string_4, string_5, string_6, 3, 6, 2, 0x1180, 0x0, -1, 13,1 },
	{ string_7, string_8, string_9, 3, 6, 2, 0x1180, 0x0, -1, 20,1 },
	{ string_11, string_12, string_13, 3, 6, 0, 0x1180, 0x0, -1, 9,9 },
	{ string_15, string_16, string_17, 3, 6, 0, 0x1180, 0x0, -1, 3,3 },
	{ string_20, string_21, string_22, 3, 6, 0, 0x1180, 0x0, -1, 5,5 },
	{ string_24, string_25, string_26, 3, 6, 0, 0x1180, 0x0, -1, 5,5 },
	{ string_28, string_29, string_30, 3, 6, 0, 0x1180, 0x0, -1, 5,5 },
	{ string_32, string_33, string_34, 3, 6, 0, 0x1180, 0x0, -1, 5,5 },
};


OBJECT rs_object[] = {
/* SYS */

	{ -1, 1, 29, G_BOX, NONE, OUTLINED, (long)(0xFE1100L), 2,0, 46,17 },
	{ 2, -1, -1, G_STRING, NONE, NORMAL, (long)(string_0), 1,1, 10,1 },
	{ 3, -1, -1, G_TEXT, NONE, NORMAL, (long)(&rs_tedinfo[0]), 12,1, 1,1 },
	{ 6, 4, 5, G_IMAGE, NONE, NORMAL, (long)(&rs_bitblk[0]), 22,1, 24,11 },
	{ 5, -1, -1, G_BOXTEXT, NONE, NORMAL, (long)(&rs_tedinfo[1]), 4,3, 14,1 },
	{ 3, -1, -1, G_BOXTEXT, NONE, NORMAL, (long)(&rs_tedinfo[2]), 2,6, 19,1 },
	{ 7, -1, -1, G_STRING, NONE, NORMAL, (long)(string_10), 1,2, 10,1 },
	{ 8, -1, -1, G_FTEXT, EDITABLE, NORMAL, (long)(&rs_tedinfo[3]), 12,2, 8,1 },
	{ 9, -1, -1, G_STRING, NONE, NORMAL, (long)(string_14), 1,4, 13,1 },
	{ 10, -1, -1, G_FTEXT, EDITABLE, NORMAL, (long)(&rs_tedinfo[4]), 15,4, 2,1 },
	{ 11, -1, -1, G_STRING, NONE, NORMAL, (long)(string_18), 18,4, 4,1 },
	{ 12, -1, -1, G_STRING, NONE, NORMAL, (long)(string_19), 1,5, 13,1 },
	{ 13, -1, -1, G_FTEXT, EDITABLE, NORMAL, (long)(&rs_tedinfo[5]), 15,5, 4,1 },
	{ 14, -1, -1, G_STRING, NONE, NORMAL, (long)(string_23), 1,7, 12,1 },
	{ 15, -1, -1, G_FTEXT, EDITABLE, NORMAL, (long)(&rs_tedinfo[6]), 14,7, 4,1 },
	{ 16, -1, -1, G_STRING, NONE, NORMAL, (long)(string_27), 1,8, 10,1 },
	{ 17, -1, -1, G_FTEXT, EDITABLE, NORMAL, (long)(&rs_tedinfo[7]), 12,8, 4,1 },
	{ 18, -1, -1, G_STRING, NONE, NORMAL, (long)(string_31), 1,9, 10,1 },
	{ 19, -1, -1, G_FTEXT, EDITABLE, NORMAL, (long)(&rs_tedinfo[8]), 12,9, 4,1 },
	{ 20, -1, -1, G_STRING, NONE, NORMAL, (long)(string_35), 1,10, 10,1 },
	{ 21, -1, -1, G_BUTTON, 0x11, SELECTED, (long)(string_36), 12,10, 3,1 },
	{ 22, -1, -1, G_BUTTON, 0x11, NORMAL, (long)(string_37), 15,10, 4,1 },
	{ 23, -1, -1, G_STRING, NONE, NORMAL, (long)(string_38), 2,13, 10,1 },
	{ 27, 24, 26, G_BOX, NONE, NORMAL, (long)(0xFF1101L), 13,13, 29,1 },
	{ 25, -1, -1, G_BUTTON, 0x11, NORMAL, (long)(string_39), 22,0, 7,1 },
	{ 26, -1, -1, G_BUTTON, 0x11, NORMAL, (long)(string_40), 6,0, 16,1 },
	{ 23, -1, -1, G_BUTTON, 0x11, SELECTED, (long)(string_41), 0,0, 6,1 },
	{ 28, -1, -1, G_BUTTON, 0x7, NORMAL, (long)(string_42), 3,15, 8,1 },
	{ 29, -1, -1, G_BUTTON, 0x5, NORMAL, (long)(string_43), 17,15, 9,1 },
	{ 0, -1, -1, G_BUTTON, 0x25, NORMAL, (long)(string_44), 32,15, 9,1 },
};


OBJECT *rs_trindex[] = {
	&rs_object[0],
};


int rs_numstrings = 45;
int rs_nuser = 0;
int rs_numfrstr = 0;
int rs_numimages = 1;
int rs_numbb = 1;
int rs_numfrimg = 0;
int rs_numib = 0;
int rs_numti = 9;
int rs_numobs = 30;
int rs_numtree = 1;

char rs_name[] = "MCPARM.RSC";
