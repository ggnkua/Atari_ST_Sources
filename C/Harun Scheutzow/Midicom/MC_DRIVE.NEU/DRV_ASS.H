#include "drv_type.h"

io_rec 	*INSTALL(long size,char *buff);
void		INST_2(int i);
void 		MSEND(int LEN,char *buff);
void		MIDEIN(void);

extern	volatile	int		INTC;