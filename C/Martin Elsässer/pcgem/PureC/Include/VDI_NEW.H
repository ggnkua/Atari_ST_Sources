/* Diese Datei ersetzt die bisherige Datei VDI.H von Pure-C */
/* Die bisherige Datei umbenennen in VDI_ORI.H, dann diese  */
/* Datei in VDI.H umbenennen... fertig... ;-)               */

#ifndef __AES__
#define __AES__

#include <ACSVDI.H>

#endif
