/* Diese Datei ersetzt die bisherige Datei AES.H von Pure-C */
/* Die bisherige Datei umbenennen in AES_ORI.H, dann diese  */
/* Datei in AES.H umbenennen... fertig... ;-)               */

#ifndef __AES__
#define __AES__

#include <ACSAES.H>

#endif
