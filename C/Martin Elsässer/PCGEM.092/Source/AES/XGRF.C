/******************************************************************************/
/*																										*/
/*		Eine handoptimierte Bibliothek f�r Pure-C, Pure-Pascal und GNU-C			*/
/*																										*/
/* Die AES-Funktionen - XGRF-Bibliothek													*/
/*																										*/
/*	(c) 1998-2000 by Martin Els„sser															*/
/******************************************************************************/

#ifdef __COMPATIBLE__
	#include <AES.H>
#else
	#include <ACSAES.H>
#endif
#include <String.H>
#include <StdArg.H>

/******************************************************************************/
/*																										*/
/* Lokale Datentypen																				*/
/*																										*/
/******************************************************************************/

typedef struct
{
	int16 contrl[5];
	GlobalArray *globl;
	int16 intin[17];
	int16 intout[7];
	void *addrin[3];
	void *addrout[1];
} AESData;

/******************************************************************************/
/*																										*/
/* AES 130:	xgrf_stepcalc																		*/
/*																										*/
/******************************************************************************/

/* Aus CAT-Bibliothek geholt ... */

/******************************************************************************/
/*																										*/
/* AES 131:	xgrf_2box																			*/
/*																										*/
/******************************************************************************/

/* Aus CAT-Bibliothek geholt ... */

