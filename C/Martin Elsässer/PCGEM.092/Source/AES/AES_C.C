/******************************************************************************/
/*																										*/
/*		Eine handoptimierte Bibliothek f�r Pure-C, Pure-Pascal und GNU-C			*/
/*																										*/
/* Die AES-Funktionen - Allgemeines															*/
/*																										*/
/*	(c) 1998-2003 by Martin Els„sser															*/
/******************************************************************************/

#include <ACSAES.H>

/******************************************************************************/
