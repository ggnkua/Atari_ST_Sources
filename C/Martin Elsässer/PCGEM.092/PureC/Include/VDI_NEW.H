/******************************************************************************/
/*																										*/
/*		          Eine handoptimierte Bibliothek f�r Pure-C               		*/
/*																										*/
/* Die VDI-Funktionen - Headerdatei f�r PureC-kompatible VDI-Bindings			*/
/*																										*/
/* Diese Datei ersetzt die bisherige Datei VDI.H von PureC. Die bisherige		*/
/* Datei umbenennen in VDI_ORI.H, dann diese Datei in VDI.H umbenennen...		*/
/*																										*/
/*	(c) 1999-2006 by Martin Els„sser									1 Tab = 3 Spaces	*/
/******************************************************************************/

#ifndef __VDI__
#define __VDI__

/* Die neue Header-Datei einbinden */
#include <ACSVDI.H>

#endif

/******************************************************************************/
