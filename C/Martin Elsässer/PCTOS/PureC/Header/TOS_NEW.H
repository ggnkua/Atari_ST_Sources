/* Diese Datei ersetzt die bisherige Datei TOS.H von Pure-C */
/* Die bisherige Datei umbenennen in TOS_ORI.H, dann diese  */
/* Datei in TOS.H umbenennen... fertig... ;-)               */

#ifndef __TOS__
#define __TOS__

/* F�r die Pure-C kompatible Bibliothek muž das Makro __PCTOSLIB__ */
/* definiert sein, d.h. in der folgenden Zeile muž der Kommentar   */
/* entfernt werden...                                              */
/* #define __PCTOSLIB__ */

#include <ACSTOS.H>

#endif
