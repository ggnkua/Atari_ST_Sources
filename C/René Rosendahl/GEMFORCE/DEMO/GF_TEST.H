/* resource set indicies for GF_TEST */

#define USERIMG  0	/* form/dialog */

#define MENU     1	/* menu tree */
#define INFOPRG  10	/* STRING in tree MENU */
#define ENDE     19	/* STRING in tree MENU */
#define FORMDIAL 21	/* STRING in tree MENU */
#define FORMDO   22	/* STRING in tree MENU */
#define SYSTEM   24	/* STRING in tree MENU */
#define SHOPOPUP 26	/* STRING in tree MENU */
#define TEXT1    28	/* STRING in tree MENU */
#define TEXT2    29	/* STRING in tree MENU */
#define OBJEKT   30	/* STRING in tree MENU */
#define LOCK     32	/* STRING in tree MENU */
#define UNLOCK   33	/* STRING in tree MENU */
#define GROW     35	/* STRING in tree MENU */
#define SAVE     36	/* STRING in tree MENU */
#define TOPMES   37	/* STRING in tree MENU */

#define INFOFORM 2	/* form/dialog */

#define DEMOFORM 3	/* form/dialog */
#define MOVECORN 1	/* IBOX in tree DEMOFORM */
#define CHECKPRE 5	/* BOX in tree DEMOFORM */
#define CHECK    7	/* BOX in tree DEMOFORM */
#define RADIOPRE 9	/* BOX in tree DEMOFORM */
#define RADIO    11	/* BOX in tree DEMOFORM */
#define TOUCHBUT 13	/* BUTTON in tree DEMOFORM */
#define EXITBUT  14	/* BUTTON in tree DEMOFORM */

#define SYSINFO  4	/* form/dialog */
#define TOS      6	/* TEXT in tree SYSINFO */
#define PHYS     8	/* TEXT in tree SYSINFO */
#define VDI      10	/* TEXT in tree SYSINFO */
#define APPLID   12	/* TEXT in tree SYSINFO */
#define GDOS     14	/* TEXT in tree SYSINFO */
#define COLORS   16	/* TEXT in tree SYSINFO */
#define WBOX     18	/* TEXT in tree SYSINFO */
#define HBOX     20	/* TEXT in tree SYSINFO */
#define WCHAR    22	/* TEXT in tree SYSINFO */
#define HCHAR    24	/* TEXT in tree SYSINFO */
#define WATTR    26	/* TEXT in tree SYSINFO */
#define HATTR    28	/* TEXT in tree SYSINFO */
#define DESKX    30	/* TEXT in tree SYSINFO */
#define DESKY    32	/* TEXT in tree SYSINFO */
#define DESKW    34	/* TEXT in tree SYSINFO */
#define DESKH    36	/* TEXT in tree SYSINFO */

#define WINOBJ   5	/* form/dialog */

#define POPUP    6	/* form/dialog */
#define POPUPMEN 1	/* BOX in tree POPUP */
#define HEADING  2	/* STRING in tree POPUP */
#define DOLL     4	/* STRING in tree POPUP */
#define GEHT     5	/* STRING in tree POPUP */
#define SCHLECHT 6	/* STRING in tree POPUP */
