/* EXPORT.H zu GEM-Force */

#ifndef __EXPORT__
#define __EXPORT__

#ifdef GLOBAL
#undef GLOBAL
#endif

# define GLOBAL

#endif /* __EXPORT __ */