/* Resource Datei Indizes f�r DESKTOP */

#define MENU             0   /* Menuebaum */
#define TDESK            3   /* TITLE in Baum MENU */
#define TLFILE           4   /* TITLE in Baum MENU */
#define TVIEW            5   /* TITLE in Baum MENU */
#define TOPTIONS         6   /* TITLE in Baum MENU */
#define MINFO            9   /* STRING in Baum MENU */
#define MOPEN            18  /* STRING in Baum MENU */
#define MSHOWINF         19  /* STRING in Baum MENU */
#define MSEARCH          20  /* STRING in Baum MENU */
#define MNEWDIR          22  /* STRING in Baum MENU */
#define MPRINT           23  /* STRING in Baum MENU */
#define MDELETE          24  /* STRING in Baum MENU */
#define MCLOSE           26  /* STRING in Baum MENU */
#define MCLOSEW          27  /* STRING in Baum MENU */
#define MSELALL          28  /* STRING in Baum MENU */
#define MCYCLE           29  /* STRING in Baum MENU */
#define MFCOPY           31  /* STRING in Baum MENU */
#define MFFORMAT         32  /* STRING in Baum MENU */
#define MQUIT            34  /* STRING in Baum MENU */
#define MNVIEWBX         35  /* BOX in Baum MENU */
#define MSHOWTXT         36  /* STRING in Baum MENU */
#define MSHOWICN         37  /* STRING in Baum MENU */
#define MSNAME           39  /* STRING in Baum MENU */
#define MSEXT            40  /* STRING in Baum MENU */
#define MSDATE           41  /* STRING in Baum MENU */
#define MSSIZE           42  /* STRING in Baum MENU */
#define MSUNSORT         43  /* STRING in Baum MENU */
#define MSHSIZ           45  /* STRING in Baum MENU */
#define MSHDAT           46  /* STRING in Baum MENU */
#define MSHTIM           47  /* STRING in Baum MENU */
#define MSHATT           48  /* STRING in Baum MENU */
#define MSETMASK         50  /* STRING in Baum MENU */
#define MNOPTBOX         51  /* BOX in Baum MENU */
#define MAPPLIK          52  /* STRING in Baum MENU */
#define MIDSKICN         53  /* STRING in Baum MENU */
#define MIWDICN          54  /* STRING in Baum MENU */
#define MCHNGICN         55  /* STRING in Baum MENU */
#define MREMICON         56  /* STRING in Baum MENU */
#define MOPTIONS         58  /* STRING in Baum MENU */
#define MEDITOR          59  /* STRING in Baum MENU */
#define MCOPTS           60  /* STRING in Baum MENU */
#define MPRGOPT          61  /* STRING in Baum MENU */
#define MWDOPT           62  /* STRING in Baum MENU */
#define MVOPTS           63  /* STRING in Baum MENU */
#define MLOADOPT         65  /* STRING in Baum MENU */
#define MSAVESET         66  /* STRING in Baum MENU */
#define MSAVEAS          67  /* STRING in Baum MENU */

#define INFOBOX          1   /* Formular/Dialog */
#define INFOVERS         2   /* TEXT in Baum INFOBOX */
#define INFOSYS          3   /* TEXT in Baum INFOBOX */
#define COPYRGHT         4   /* TEXT in Baum INFOBOX */
#define OTHRINFO         5   /* TEXT in Baum INFOBOX */
#define INFSTMEM         8   /* FTEXT in Baum INFOBOX */
#define INFTTMEM         9   /* FTEXT in Baum INFOBOX */
#define INFOTV           10  /* FTEXT in Baum INFOBOX */
#define INFOAV           11  /* FTEXT in Baum INFOBOX */

#define OPENFILE         2   /* Formular/Dialog */
#define SHOWFILE         4   /* BUTTON in Baum OPENFILE */
#define EDITFILE         5   /* BUTTON in Baum OPENFILE */
#define PRTFILE          6   /* BUTTON in Baum OPENFILE */

#define GETCML           3   /* Formular/Dialog */
#define CMDLINE          3   /* FTEXT in Baum GETCML */
#define CMLOK            4   /* BUTTON in Baum GETCML */

#define NEWDIR           4   /* Formular/Dialog */
#define NDTITLE          2   /* STRING in Baum NEWDIR */
#define DIRNAME          4   /* FTEXT in Baum NEWDIR */
#define NEWDIROK         5   /* BUTTON in Baum NEWDIR */

#define ADDICON          5   /* Formular/Dialog */
#define AITITLE          2   /* STRING in Baum ADDICON */
#define DRIVEID          3   /* FTEXT in Baum ADDICON */
#define ICNTYPE          4   /* FTEXT in Baum ADDICON */
#define ICNLABEL         5   /* FTEXT in Baum ADDICON */
#define AIPARENT         6   /* BUTTON in Baum ADDICON */
#define ICBTNS           7   /* IBOX in Baum ADDICON */
#define APRINTER         8   /* BUTTON in Baum ADDICON */
#define ADISK            9   /* BUTTON in Baum ADDICON */
#define ATRASH           10  /* BUTTON in Baum ADDICON */
#define ICSHFIL          11  /* STRING in Baum ADDICON */
#define ICSHFLD          12  /* STRING in Baum ADDICON */
#define ICONBACK         14  /* BOX in Baum ADDICON */
#define ICONDATA         15  /* IMAGE in Baum ADDICON */
#define ICNUP            16  /* BUTTON in Baum ADDICON */
#define ICPARENT         17  /* BOX in Baum ADDICON */
#define ICSLIDER         18  /* BOX in Baum ADDICON */
#define ICNDWN           19  /* BUTTON in Baum ADDICON */
#define CHNBUTT          20  /* IBOX in Baum ADDICON */
#define CHNICNOK         21  /* BUTTON in Baum ADDICON */
#define CHNICNAB         23  /* BUTTON in Baum ADDICON */
#define ADDBUTT          24  /* IBOX in Baum ADDICON */
#define ADDICNOK         25  /* BUTTON in Baum ADDICON */

#define APPLIKAT         6   /* Formular/Dialog */
#define APNAME           3   /* FTEXT in Baum APPLIKAT */
#define APFKEY           4   /* FTEXT in Baum APPLIKAT */
#define APARGV           5   /* BUTTON in Baum APPLIKAT */
#define ADDTYPE          7   /* BUTTON in Baum APPLIKAT */
#define DELTYPE          8   /* BUTTON in Baum APPLIKAT */
#define APTYPE           9   /* FBOXTEXT in Baum APPLIKAT */
#define APNEXT           10  /* BOXCHAR in Baum APPLIKAT */
#define APPREV           11  /* BOXCHAR in Baum APPLIKAT */
#define APCMLINE         13  /* FTEXT in Baum APPLIKAT */
#define APPAR1           14  /* BUTTON in Baum APPLIKAT */
#define APPRG            15  /* BUTTON in Baum APPLIKAT */
#define APWINDOW         16  /* BUTTON in Baum APPLIKAT */
#define APPAR2           17  /* BUTTON in Baum APPLIKAT */
#define AGEM             18  /* BUTTON in Baum APPLIKAT */
#define AGTP             19  /* BUTTON in Baum APPLIKAT */
#define AACC             20  /* BUTTON in Baum APPLIKAT */
#define ATOS             21  /* BUTTON in Baum APPLIKAT */
#define ATTP             22  /* BUTTON in Baum APPLIKAT */
#define APOK             24  /* BUTTON in Baum APPLIKAT */
#define APREM            25  /* BUTTON in Baum APPLIKAT */

#define DRVINFO          7   /* Formular/Dialog */
#define DIDRIVE          4   /* BOXCHAR in Baum DRVINFO */
#define DILABEL          6   /* FTEXT in Baum DRVINFO */
#define DIFOLDER         8   /* FTEXT in Baum DRVINFO */
#define DIFILES          10  /* FTEXT in Baum DRVINFO */
#define DIBYTES          12  /* FTEXT in Baum DRVINFO */
#define DIFREE           14  /* FTEXT in Baum DRVINFO */
#define DISPACE          16  /* FTEXT in Baum DRVINFO */
#define DIOK             17  /* BUTTON in Baum DRVINFO */
#define DIABORT          18  /* BUTTON in Baum DRVINFO */

#define FLDRINFO         8   /* Formular/Dialog */
#define FIPATH           4   /* FTEXT in Baum FLDRINFO */
#define FINAME           6   /* FTEXT in Baum FLDRINFO */
#define FIDATE           8   /* FTEXT in Baum FLDRINFO */
#define FITIME           9   /* FTEXT in Baum FLDRINFO */
#define FIBYTES          11  /* FTEXT in Baum FLDRINFO */
#define FIFOLDER         13  /* FTEXT in Baum FLDRINFO */
#define FIFILES          15  /* FTEXT in Baum FLDRINFO */
#define FIOK             17  /* BUTTON in Baum FLDRINFO */
#define FISKIP           18  /* BUTTON in Baum FLDRINFO */
#define FIABORT          19  /* BUTTON in Baum FLDRINFO */

#define FILEINFO         9   /* Formular/Dialog */
#define FLPATH           4   /* FTEXT in Baum FILEINFO */
#define FLNAME           6   /* FTEXT in Baum FILEINFO */
#define FLDATE           8   /* FTEXT in Baum FILEINFO */
#define FLTIME           9   /* FTEXT in Baum FILEINFO */
#define FLBYTES          11  /* FTEXT in Baum FILEINFO */
#define ISWP             14  /* BUTTON in Baum FILEINFO */
#define ISHIDDEN         15  /* BUTTON in Baum FILEINFO */
#define ISSYSTEM         16  /* BUTTON in Baum FILEINFO */
#define FLOK             18  /* BUTTON in Baum FILEINFO */
#define FLSKIP           19  /* BUTTON in Baum FILEINFO */
#define FLABORT          20  /* BUTTON in Baum FILEINFO */

#define COPYINFO         10  /* Formular/Dialog */
#define CPTITLE          2   /* STRING in Baum COPYINFO */
#define NFOLDERS         3   /* FTEXT in Baum COPYINFO */
#define NFILES           4   /* FTEXT in Baum COPYINFO */
#define NBYTES           5   /* FTEXT in Baum COPYINFO */
#define CPFOLDER         7   /* FTEXT in Baum COPYINFO */
#define CPFILE           9   /* FTEXT in Baum COPYINFO */
#define COPYOK           11  /* BUTTON in Baum COPYINFO */

#define NAMECONF         11  /* Formular/Dialog */
#define RNMTITLE         2   /* STRING in Baum NAMECONF */
#define OLDNAME          4   /* FTEXT in Baum NAMECONF */
#define NEWNAME          6   /* FTEXT in Baum NAMECONF */
#define NCOK             8   /* BUTTON in Baum NAMECONF */
#define NCALL            9   /* BUTTON in Baum NAMECONF */
#define NCSKIP           10  /* BUTTON in Baum NAMECONF */
#define NCABORT          11  /* BUTTON in Baum NAMECONF */

#define SETMASK          12  /* Formular/Dialog */
#define FILETYPE         4   /* FTEXT in Baum SETMASK */
#define FTADD            5   /* BUTTON in Baum SETMASK */
#define FTSCROLL         6   /* BOX in Baum SETMASK */
#define FTPARENT         7   /* BOX in Baum SETMASK */
#define FTYPE1           8   /* FTEXT in Baum SETMASK */
#define FTYPE2           9   /* FTEXT in Baum SETMASK */
#define FTYPE3           10  /* FTEXT in Baum SETMASK */
#define FTYPE4           11  /* FTEXT in Baum SETMASK */
#define FTUP             12  /* BOXCHAR in Baum SETMASK */
#define FTDOWN           13  /* BOXCHAR in Baum SETMASK */
#define FTSPAR           14  /* BOX in Baum SETMASK */
#define FTSLIDER         15  /* BOX in Baum SETMASK */
#define FTDELETE         16  /* BUTTON in Baum SETMASK */
#define MSKATT           18  /* IBOX in Baum SETMASK */
#define MSKHID           19  /* BUTTON in Baum SETMASK */
#define MSKSYS           20  /* BUTTON in Baum SETMASK */
#define MSKDIR           21  /* BUTTON in Baum SETMASK */
#define MSKPAR           22  /* BUTTON in Baum SETMASK */
#define FTOK             23  /* BUTTON in Baum SETMASK */

#define OPTIONS          13  /* Formular/Dialog */
#define OPTPAR1          4   /* IBOX in Baum OPTIONS */
#define DNORMAL          5   /* BUTTON in Baum OPTIONS */
#define DBUFFERD         6   /* BUTTON in Baum OPTIONS */
#define DWINDOW          7   /* BUTTON in Baum OPTIONS */
#define OPTPAR2          8   /* IBOX in Baum OPTIONS */
#define DMOUSE           9   /* BUTTON in Baum OPTIONS */
#define DCENTER          10  /* BUTTON in Baum OPTIONS */
#define OPTMNEXT         14  /* BOXCHAR in Baum OPTIONS */
#define OPTMPREV         15  /* BOXCHAR in Baum OPTIONS */
#define OPTMTEXT         16  /* FTEXT in Baum OPTIONS */
#define OPTKKEY          17  /* FTEXT in Baum OPTIONS */
#define OPTKCLR          18  /* BUTTON in Baum OPTIONS */
#define TABSIZE          19  /* FTEXT in Baum OPTIONS */
#define OPTOK            20  /* BUTTON in Baum OPTIONS */
#define OPTCANC          21  /* BUTTON in Baum OPTIONS */

#define PRGOPTNS         14  /* Formular/Dialog */
#define PKEY             3   /* BUTTON in Baum PRGOPTNS */
#define PSTDERR          4   /* BUTTON in Baum PRGOPTNS */
#define PTPARENT         7   /* BOX in Baum PRGOPTNS */
#define PTYPE1           8   /* FBOXTEXT in Baum PRGOPTNS */
#define PTYPE2           9   /* FBOXTEXT in Baum PRGOPTNS */
#define PTYPE3           10  /* FBOXTEXT in Baum PRGOPTNS */
#define PTYPE4           11  /* FBOXTEXT in Baum PRGOPTNS */
#define PUP              12  /* BOXCHAR in Baum PRGOPTNS */
#define PSPARENT         13  /* BOX in Baum PRGOPTNS */
#define PSLIDER          14  /* BOX in Baum PRGOPTNS */
#define PDOWN            15  /* BOXCHAR in Baum PRGOPTNS */
#define PTADD            16  /* BUTTON in Baum PRGOPTNS */
#define PTDELETE         17  /* BUTTON in Baum PRGOPTNS */
#define PTEDIT           18  /* BUTTON in Baum PRGOPTNS */
#define POPTOK           19  /* BUTTON in Baum PRGOPTNS */

#define ADDPTYPE         15  /* Formular/Dialog */
#define APTITLE          2   /* STRING in Baum ADDPTYPE */
#define PRGNAME          4   /* FTEXT in Baum ADDPTYPE */
#define APTPAR1          5   /* BUTTON in Baum ADDPTYPE */
#define ATPRG            6   /* BUTTON in Baum ADDPTYPE */
#define ATWINDOW         7   /* BUTTON in Baum ADDPTYPE */
#define APTPAR2          8   /* BUTTON in Baum ADDPTYPE */
#define APGEM            9   /* BUTTON in Baum ADDPTYPE */
#define APGTP            10  /* BUTTON in Baum ADDPTYPE */
#define APACC            11  /* BUTTON in Baum ADDPTYPE */
#define APTOS            12  /* BUTTON in Baum ADDPTYPE */
#define APTTP            13  /* BUTTON in Baum ADDPTYPE */
#define ATARGV           14  /* BUTTON in Baum ADDPTYPE */
#define APTOK            16  /* BUTTON in Baum ADDPTYPE */

#define SETICONS         16  /* Formular/Dialog */
#define ITADD            4   /* BUTTON in Baum SETICONS */
#define IPARENT          6   /* BOX in Baum SETICONS */
#define ITYPE1           7   /* FBOXTEXT in Baum SETICONS */
#define ITYPE2           8   /* FBOXTEXT in Baum SETICONS */
#define ITYPE3           9   /* FBOXTEXT in Baum SETICONS */
#define ITYPE4           10  /* FBOXTEXT in Baum SETICONS */
#define IUP              11  /* BOXCHAR in Baum SETICONS */
#define IDOWN            12  /* BOXCHAR in Baum SETICONS */
#define ISPARENT         13  /* BOX in Baum SETICONS */
#define ISLIDER          14  /* BOX in Baum SETICONS */
#define ITDEL            15  /* BUTTON in Baum SETICONS */
#define ITCHNG           16  /* BUTTON in Baum SETICONS */
#define ITFILES          18  /* BUTTON in Baum SETICONS */
#define ITFOLDER         19  /* BUTTON in Baum SETICONS */
#define ITOK             20  /* BUTTON in Baum SETICONS */

#define VIEWMENU         17  /* Menuebaum */
#define VMTAB            6   /* STRING in Baum VIEWMENU */
#define VMHEX            7   /* STRING in Baum VIEWMENU */

#define STABSIZE         18  /* Formular/Dialog */
#define VTABSIZE         3   /* FTEXT in Baum STABSIZE */
#define STOK             4   /* BUTTON in Baum STABSIZE */

#define WOPTIONS         19  /* Formular/Dialog */
#define DSKPDOWN         4   /* BOXCHAR in Baum WOPTIONS */
#define DSKPAT           5   /* BOX in Baum WOPTIONS */
#define DSKPUP           6   /* BOXCHAR in Baum WOPTIONS */
#define DSKCDOWN         8   /* BOXCHAR in Baum WOPTIONS */
#define DSKCOLOR         9   /* BOX in Baum WOPTIONS */
#define DSKCUP           10  /* BOXCHAR in Baum WOPTIONS */
#define WINPDOWN         12  /* BOXCHAR in Baum WOPTIONS */
#define WINPAT           13  /* BOX in Baum WOPTIONS */
#define WINPUP           14  /* BOXCHAR in Baum WOPTIONS */
#define WINCDOWN         16  /* BOXCHAR in Baum WOPTIONS */
#define WINCOLOR         17  /* BOX in Baum WOPTIONS */
#define WINCUP           18  /* BOXCHAR in Baum WOPTIONS */
#define WODIR            19  /* BUTTON in Baum WOPTIONS */
#define WOVIEWER         20  /* BUTTON in Baum WOPTIONS */
#define WOPTOK           21  /* BUTTON in Baum WOPTIONS */

#define WDFONT           20  /* Formular/Dialog */
#define WDFTITLE         2   /* STRING in Baum WDFONT */
#define WDPARENT         4   /* BOX in Baum WDFONT */
#define WDFONT1          5   /* TEXT in Baum WDFONT */
#define WDFONT2          6   /* TEXT in Baum WDFONT */
#define WDFONT3          7   /* TEXT in Baum WDFONT */
#define WDFONT4          8   /* TEXT in Baum WDFONT */
#define WDFONT5          9   /* TEXT in Baum WDFONT */
#define WDFONT6          10  /* TEXT in Baum WDFONT */
#define WDFUP            11  /* BOXCHAR in Baum WDFONT */
#define WDFDOWN          12  /* BOXCHAR in Baum WDFONT */
#define FSPARENT         13  /* BOX in Baum WDFONT */
#define FSLIDER          14  /* BOX in Baum WDFONT */
#define WDFTEXT          16  /* BUTTON in Baum WDFONT */
#define WDFSUP           18  /* BOXCHAR in Baum WDFONT */
#define WDFSIZE          19  /* BUTTON in Baum WDFONT */
#define WDFSDOWN         20  /* BOXCHAR in Baum WDFONT */
#define WDFOK            21  /* BUTTON in Baum WDFONT */

#define HELP1            21  /* Formular/Dialog */
#define HELP1TIT         2   /* STRING in Baum HELP1 */
#define HELP1OK          15  /* BUTTON in Baum HELP1 */

#define HELP2            22  /* Formular/Dialog */
#define HELP2TIT         2   /* STRING in Baum HELP2 */

#define FLOPPY           23  /* Formular/Dialog */
#define FLTITLE          2   /* STRING in Baum FLOPPY */
#define FDRIVES          3   /* IBOX in Baum FLOPPY */
#define FSRCDRV          4   /* FTEXT in Baum FLOPPY */
#define FTGTDRV          5   /* FTEXT in Baum FLOPPY */
#define FFTYPE           6   /* BUTTON in Baum FLOPPY */
#define FPAR1            7   /* IBOX in Baum FLOPPY */
#define FSSIDED          8   /* BUTTON in Baum FLOPPY */
#define FDSIDED          9   /* BUTTON in Baum FLOPPY */
#define FHSIDED          10  /* BUTTON in Baum FLOPPY */
#define FESIDED          11  /* BUTTON in Baum FLOPPY */
#define FPAR2            12  /* BUTTON in Baum FLOPPY */
#define FPAR3            13  /* IBOX in Baum FLOPPY */
#define FSIDES           14  /* FTEXT in Baum FLOPPY */
#define FTRACKS          15  /* FTEXT in Baum FLOPPY */
#define FSECTORS         16  /* FTEXT in Baum FLOPPY */
#define FDIRSIZE         17  /* FTEXT in Baum FLOPPY */
#define FLABEL           18  /* FTEXT in Baum FLOPPY */
#define FPROGRES         19  /* FTEXT in Baum FLOPPY */
#define FMTOK            21  /* BUTTON in Baum FLOPPY */
#define FMTCANC          22  /* BUTTON in Baum FLOPPY */

#define VOPTIONS         24  /* Formular/Dialog */
#define VREZOL           4   /* IBOX in Baum VOPTIONS */
#define VSTLOW           5   /* BUTTON in Baum VOPTIONS */
#define VTTLOW           6   /* BUTTON in Baum VOPTIONS */
#define VSTMED           7   /* BUTTON in Baum VOPTIONS */
#define VTTMED           8   /* BUTTON in Baum VOPTIONS */
#define VSTHIGH          9   /* BUTTON in Baum VOPTIONS */
#define VTTHIGH          10  /* BUTTON in Baum VOPTIONS */
#define SVCOLORS         12  /* BUTTON in Baum VOPTIONS */
#define VBLITTER         14  /* BUTTON in Baum VOPTIONS */
#define VOVERSCN         16  /* BUTTON in Baum VOPTIONS */
#define VIDOK            18  /* BUTTON in Baum VOPTIONS */

#define COPTIONS         25  /* Formular/Dialog */
#define CPAR1            3   /* IBOX in Baum COPTIONS */
#define CCOPY            4   /* BUTTON in Baum COPTIONS */
#define CDEL             5   /* BUTTON in Baum COPTIONS */
#define COVERW           6   /* BUTTON in Baum COPTIONS */
#define CPRINT           7   /* BUTTON in Baum COPTIONS */
#define COPYBUF          8   /* FTEXT in Baum COPTIONS */
#define COPTOK           9   /* BUTTON in Baum COPTIONS */

#define DTNEWDIR         0   /* Freier String */

#define DTADDMSK         1   /* Freier String */

#define DTCOPY           2   /* Freier String */

#define DTCOPYRN         3   /* Freier String */

#define DTMOVE           4   /* Freier String */

#define DTMOVERN         5   /* Freier String */

#define DTDELETE         6   /* Freier String */

#define DTRENAME         7   /* Freier String */

#define DTNMECNF         8   /* Freier String */

#define DTADDICN         9   /* Freier String */

#define DTCHNICN         10  /* Freier String */

#define DTADDPRG         11  /* Freier String */

#define DTEDTPRG         12  /* Freier String */

#define DTADDICT         13  /* Freier String */

#define DTEDTICT         14  /* Freier String */

#define DTADDFT          15  /* Freier String */

#define DTDFONT          16  /* Freier String */

#define DTVFONT          17  /* Freier String */

#define FSTLFILE         18  /* Freier String */

#define FSTLPRG          19  /* Freier String */

#define FSTLFLDR         20  /* Freier String */

#define FSTLOADS         21  /* Freier String */

#define FSTSAVES         22  /* Freier String */

#define FSTEDIT          23  /* Freier String */

#define MPRINTER         24  /* Freier String */

#define MTRASHCN         25  /* Freier String */

#define MDRIVE           26  /* Freier String */

#define MFOLDER          27  /* Freier String */

#define MPROGRAM         28  /* Freier String */

#define MENDFILE         29  /* Freier String */

#define MITEMS           30  /* Freier String */

#define MSITEMS          31  /* Freier String */

#define MIPLURAL         32  /* Freier String */

#define MISINGUL         33  /* Freier String */

#define MDRVNAME         34  /* Freier String */

#define MKEYCONT         35  /* Freier String */

#define TERROR           36  /* Freier String */

#define TFILNF           37  /* Freier String */

#define TPATHNF          38  /* Freier String */

#define TACCDN           39  /* Freier String */

#define TENSMEM          40  /* Freier String */

#define TDSKFULL         41  /* Freier String */

#define TLOCKED          42  /* Freier String */

#define TPLFMT           43  /* Freier String */

#define TFNTLNG          44  /* Freier String */

#define TPTHTLNG         45  /* Freier String */

#define TREAD            46  /* Freier String */

#define TEOF             47  /* Freier String */

#define TABORT           48  /* Freier String */

#define TSKIPABT         49  /* Freier String */

#define FLINAME          50  /* Freier String */

#define HDINAME          51  /* Freier String */

#define TRINAME          52  /* Freier String */

#define PRINAME          53  /* Freier String */

#define FIINAME          54  /* Freier String */

#define APINAME          55  /* Freier String */

#define FOINAME          56  /* Freier String */

#define FOFINAME         57  /* Freier String */

#define TCMDTLNG         58  /* Freier String */

#define DTPRINT          59  /* Freier String */

#define DTPRINTD         60  /* Freier String */

#define OPENITEM         61  /* Freier String */

#define DTFFMT           62  /* Freier String */

#define DTFCPY           63  /* Freier String */

#define TWPROT           64  /* Freier String */

#define TDIROF           65  /* Freier String */

#define MRESTLOW         66  /* Alert String */

#define MDIALTBG         67  /* Alert String */

#define MVDIERR          68  /* Alert String */

#define MLOADCFG         69  /* Alert String */

#define MVALIDCF         70  /* Alert String */

#define MSAVECFG         71  /* Alert String */

#define MEBATCH          72  /* Alert String */

#define MBSYNTAX         73  /* Alert String */

#define MFKEYUSD         74  /* Alert String */

#define MAPPLPM          75  /* Alert String */

#define MPRGNFND         76  /* Alert String */

#define MAPPNFND         77  /* Alert String */

#define MILLCOPY         78  /* Alert String */

#define MILLDEST         79  /* Alert String */

#define MNOCOPY          80  /* Alert String */

#define MNODRAGP         81  /* Alert String */

#define MNOPRINT         82  /* Alert String */

#define MECOPY           83  /* Alert String */

#define MEMOVE           84  /* Alert String */

#define MEDELETE         85  /* Alert String */

#define MEREADDR         86  /* Alert String */

#define MERENAME         87  /* Alert String */

#define MEPRINT          88  /* Alert String */

#define MESHOWIF         89  /* Alert String */

#define MCOPYSLF         90  /* Alert String */

#define MFNEMPTY         91  /* Alert String */

#define MERROR           92  /* Alert String */

#define MCOPVIEW         93  /* Alert String */

#define MTMWIND          94  /* Alert String */

#define MDEXISTS         95  /* Alert String */

#define MDIRTBIG         96  /* Alert String */

#define MNEDITOR         97  /* Alert String */

#define MFNEXIST         98  /* Alert String */

#define MFNPRG           99  /* Alert String */

#define MNOROOT          100 /* Alert String */

#define MDRVEXIS         101 /* Alert String */

#define MICNPMEM         102 /* Alert String */

#define MICNNFND         103 /* Alert String */

#define MTMICONS         104 /* Alert String */

#define MMULITEM         105 /* Alert String */

#define MICNFNF          106 /* Alert String */

#define MICONNFD         107 /* Alert String */

#define MICNFRD          108 /* Alert String */

#define MREMICNS         109 /* Alert String */

#define MICNOPEN         110 /* Alert String */

#define MPRNRESP         111 /* Alert String */

#define MGEMBACK         112 /* Alert String */

#define MFSELERR         113 /* Alert String */

#define MECOLORS         114 /* Alert String */

#define MCANTACC         115 /* Alert String */

#define MERADISK         116 /* Alert String */

#define MFMTERR          117 /* Alert String */

#define MFPARERR         118 /* Alert String */

#define MERRACC          119 /* Alert String */

#define MDIFERR          120 /* Alert String */

#define QUITALRT         121 /* Alert String */

#define DUPKEY           122 /* Alert String */

#define ABOOP            123 /* Alert String */

#define GENALERT         124 /* Alert String */

#define APPNODD          125 /* Alert String */

#define APPNOEXT         126 /* Alert String */
