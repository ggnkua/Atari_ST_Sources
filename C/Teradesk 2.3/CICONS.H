/* Resource Datei Indizes f�r CICONS */

#define CICONS           0   /* Formular/Dialog */
