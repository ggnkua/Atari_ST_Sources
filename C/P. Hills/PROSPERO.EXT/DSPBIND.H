extern long xbios();

/* DSP XBIOS functions (trap #14) */
#define	Dsp_DoBlock(a,b,c,d)			(void) xbios(96+00,a,b,c,d)
#define	Dsp_BlkHandShake(a,b,c,d)		(void) xbios(96+01,a,b,c,d)
#define	Dsp_BlkUnpacked(a,b,c,d)		(void) xbios(96+02,a,b,c,d)
#define	Dsp_InStream(a,b,c,d)			(void) xbios(96+03,a,b,c,d)
#define	Dsp_OutStream(a,b,c,d)			(void) xbios(96+04,a,b,c,d)
#define	Dsp_IOStream(a,b,c,d,e,f)		(void) xbios(96+05,a,b,c,d,e,f)
#define	Dsp_RemoveInterrupts(a)			(void) xbios(96+06,a)
#define	Dsp_GetWordSize()			(int)  xbios(96+07)
#define	Dsp_Lock()				(int)  xbios(96+08)
#define	Dsp_Unlock()				(void) xbios(96+09)
#define	Dsp_Available(a,b)			(void) xbios(96+10,a,b)
#define	Dsp_Reserve(a,b)			(int) xbios(96+11,a,b)
#define	Dsp_LoadProg(a,b,c)			(int) xbios(96+12,a,b,c)
#define	Dsp_ExecProg(a,b,c)			(void) xbios(96+13,a,b,c)
#define	Dsp_ExecBoot(a,b,c)			(void) xbios(96+14,a,b,c)
#define	Dsp_LodToBinary(a,b)			(long) xbios(96+15,a,b)
#define	Dsp_TriggerHC(a)			(void) xbios(96+16,a)
#define	Dsp_RequestUniqueAbility()		(int)  xbios(96+17)
#define	Dsp_GetProgAbility()			(int)  xbios(96+18)
#define	Dsp_FlushSubroutines()			(void) xbios(96+19)
#define	Dsp_LoadSubroutine(a,b,c)		(int)  xbios(96+20,a,b,c)
#define	Dsp_InqSubrAbility(a)			(int)  xbios(96+21,a)
#define	Dsp_RunSubroutine(a)			(int)  xbios(96+22,a)
#define	Dsp_Hf0(a)				(int)  xbios(96+23,a)
#define	Dsp_Hf1(a)				(int)  xbios(96+24,a)
#define	Dsp_Hf2()				(int)  xbios(96+25)
#define	Dsp_Hf3()				(int)  xbios(96+26)
#define	Dsp_BlkWords(a,b,c,d)			(void) xbios(96+27,a,b,c,d)
#define	Dsp_BlkBytes(a,b,c,d)			(void) xbios(96+28,a,b,c,d)
#define	Dsp_HStat()				(char) xbios(96+29)
#define Dsp_SetVectors(a,b)			(void) xbios(96+30,a,b)
