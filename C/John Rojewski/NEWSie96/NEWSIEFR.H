
#define NEWSie             0 	/* TREE - MENU   */
#define M_NEWSie           3 	/* G_TITLE in (#0) NEWSie */
#define M_File             4 	/* G_TITLE in (#0) NEWSie */
#define M_Edit             5 	/* G_TITLE in (#0) NEWSie */
#define M_News             6 	/* G_TITLE in (#0) NEWSie */
#define M_Mail             7 	/* G_TITLE in (#0) NEWSie */
#define M_FTP              8 	/* G_TITLE in (#0) NEWSie */
#define M_Special          9 	/* G_TITLE in (#0) NEWSie */
#define M_Preferences     10 	/* G_TITLE in (#0) NEWSie */
#define MAbout            13 	/* G_STRING in (#0) NEWSie */
#define MF_NewGroup       22 	/* G_STRING in (#0) NEWSie */
#define MF_Close          23 	/* G_STRING in (#0) NEWSie */
#define MF_Open           24 	/* G_STRING in (#0) NEWSie */
#define MF_Save           26 	/* G_STRING in (#0) NEWSie */
#define MF_SaveAs         27 	/* G_STRING in (#0) NEWSie */
#define MF_Append         28 	/* G_STRING in (#0) NEWSie */
#define MF_Print          30 	/* G_STRING in (#0) NEWSie */
#define MF_Quit           31 	/* G_STRING in (#0) NEWSie */
#define ME_Clear          33 	/* G_STRING in (#0) NEWSie */
#define ME_Cut            34 	/* G_STRING in (#0) NEWSie */
#define ME_Copy           35 	/* G_STRING in (#0) NEWSie */
#define ME_Paste          36 	/* G_STRING in (#0) NEWSie */
#define ME_Find           38 	/* G_STRING in (#0) NEWSie */
#define ME_FindNext       39 	/* G_STRING in (#0) NEWSie */
#define ME_ShowDetails    41 	/* G_STRING in (#0) NEWSie */
#define MN_Article        43 	/* G_STRING in (#0) NEWSie */
#define MN_Thread         44 	/* G_STRING in (#0) NEWSie */
#define MN_Group          45 	/* G_STRING in (#0) NEWSie */
#define MN_MarkRead       47 	/* G_STRING in (#0) NEWSie */
#define MN_MarkUnread     48 	/* G_STRING in (#0) NEWSie */
#define MN_MarkAll        49 	/* G_STRING in (#0) NEWSie */
#define MN_NewPost        51 	/* G_STRING in (#0) NEWSie */
#define MN_FollowPost     52 	/* G_STRING in (#0) NEWSie */
#define MN_MarkThread     53 	/* G_STRING in (#0) NEWSie */
#define MN_ReadForOff     54 	/* G_STRING in (#0) NEWSie */
#define MN_PostBox        56 	/* G_STRING in (#0) NEWSie */
#define MM_SendMail       58 	/* G_STRING in (#0) NEWSie */
#define MM_ReplyMail      59 	/* G_STRING in (#0) NEWSie */
#define MM_ForwardMail    60 	/* G_STRING in (#0) NEWSie */
#define MM_EditNick       62 	/* G_STRING in (#0) NEWSie */
#define MM_OpenAddress    63 	/* G_STRING in (#0) NEWSie */
#define MM_AddToAddress   64 	/* G_STRING in (#0) NEWSie */
#define MM_CheckMail      66 	/* G_STRING in (#0) NEWSie */
#define MM_GetMail        67 	/* G_STRING in (#0) NEWSie */
#define MM_GetSelected    68 	/* G_STRING in (#0) NEWSie */
#define MM_SendQueued     69 	/* G_STRING in (#0) NEWSie */
#define MM_OpenInBox      70 	/* G_STRING in (#0) NEWSie */
#define MM_OpenMailbox    71 	/* G_STRING in (#0) NEWSie */
#define MT_SelectServer   73 	/* G_STRING in (#0) NEWSie */
#define MT_AddServer      74 	/* G_STRING in (#0) NEWSie */
#define MT_DeleteServer   75 	/* G_STRING in (#0) NEWSie */
#define MT_EditServer     76 	/* G_STRING in (#0) NEWSie */
#define MT_MakeDir        78 	/* G_STRING in (#0) NEWSie */
#define MT_ChangeDir      79 	/* G_STRING in (#0) NEWSie */
#define MT_DeleteDir      80 	/* G_STRING in (#0) NEWSie */
#define MT_GetFile        81 	/* G_STRING in (#0) NEWSie */
#define MT_PutFileName    83 	/* G_STRING in (#0) NEWSie */
#define MT_RenameFile     84 	/* G_STRING in (#0) NEWSie */
#define MT_PutFile        85 	/* G_STRING in (#0) NEWSie */
#define MT_DeleteFile     86 	/* G_STRING in (#0) NEWSie */
#define MS_ConnectHost    88 	/* G_STRING in (#0) NEWSie */
#define MS_Disconnect     89 	/* G_STRING in (#0) NEWSie */
#define MS_Extract        90 	/* G_STRING in (#0) NEWSie */
#define MS_CheckNew       92 	/* G_STRING in (#0) NEWSie */
#define MS_FullGroup      93 	/* G_STRING in (#0) NEWSie */
#define MS_Subscribe      94 	/* G_STRING in (#0) NEWSie */
#define MS_Unsubscribe    95 	/* G_STRING in (#0) NEWSie */
#define MS_ShowLog        96 	/* G_STRING in (#0) NEWSie */
#define MS_OpenURL        98 	/* G_STRING in (#0) NEWSie */
#define MP_Server        100 	/* G_STRING in (#0) NEWSie */
#define MP_Personal      101 	/* G_STRING in (#0) NEWSie */
#define MP_General       102 	/* G_STRING in (#0) NEWSie */
#define MP_NewsReading   103 	/* G_STRING in (#0) NEWSie */
#define MP_MailReading   104 	/* G_STRING in (#0) NEWSie */
#define MP_FTP           105 	/* G_STRING in (#0) NEWSie */
#define MP_Message       106 	/* G_STRING in (#0) NEWSie */
#define MP_Signature     107 	/* G_STRING in (#0) NEWSie */
#define MP_Fonts         108 	/* G_STRING in (#0) NEWSie */
#define MP_Path          109 	/* G_STRING in (#0) NEWSie */
#define MP_Log           110 	/* G_STRING in (#0) NEWSie */
#define MP_Browser       111 	/* G_STRING in (#0) NEWSie */
#define MP_EditFKeys     112 	/* G_STRING in (#0) NEWSie */
#define MP_Load          114 	/* G_STRING in (#0) NEWSie */
#define MP_Save          115 	/* G_STRING in (#0) NEWSie */

#define Pref_Server        1 	/* TREE - DIALOG */
#define PS_NewsServer      3 	/* G_FTEXT in (#1) Pref_Server */
#define PS_MailServer      5 	/* G_FTEXT in (#1) Pref_Server */
#define PS_PopServer       7 	/* G_FTEXT in (#1) Pref_Server */
#define PS_ConnectStart    8 	/* G_BOX in (#1) Pref_Server */
#define PS_ToMaximum      11 	/* G_FTEXT in (#1) Pref_Server */
#define PS_ToLastChar     14 	/* G_FTEXT in (#1) Pref_Server */
#define PS_Cancel         16 	/* G_BUTTON in (#1) Pref_Server */
#define PS_OK             17 	/* G_BUTTON in (#1) Pref_Server */
#define PS_NewsStart      18 	/* G_BOX in (#1) Pref_Server */

#define Pref_Personal      2 	/* TREE - DIALOG */
#define PP_OK              1 	/* G_BUTTON in (#2) Pref_Personal */
#define PP_Cancel          2 	/* G_BUTTON in (#2) Pref_Personal */
#define PP_FullName        3 	/* G_FTEXT in (#2) Pref_Personal */
#define PP_Organization    4 	/* G_FTEXT in (#2) Pref_Personal */
#define PP_Email           5 	/* G_FTEXT in (#2) Pref_Personal */
#define PP_AccountName    10 	/* G_FTEXT in (#2) Pref_Personal */

#define Pref_Message       3 	/* TREE - DIALOG */
#define PM_OK              1 	/* G_BUTTON in (#3) Pref_Message */
#define PM_Cancel          2 	/* G_BUTTON in (#3) Pref_Message */
#define PM_ReplyPosting    3 	/* G_BOX in (#3) Pref_Message */
#define PM_ReplyEmail      4 	/* G_BOX in (#3) Pref_Message */
#define PM_Copiestoself    5 	/* G_BOX in (#3) Pref_Message */
#define PM_QuoteString     9 	/* G_FTEXT in (#3) Pref_Message */
#define PM_AppendSig      12 	/* G_BOX in (#3) Pref_Message */

#define Pref_Read          4 	/* TREE - DIALOG */
#define PR_OK              1 	/* G_BUTTON in (#4) Pref_Read */
#define PR_Cancel          2 	/* G_BUTTON in (#4) Pref_Read */
#define PR_ShowAuthor      3 	/* G_BOX in (#4) Pref_Read */
#define PR_ShowHeaders     7 	/* G_BOX in (#4) Pref_Read */
#define PR_CollapseThr     8 	/* G_BOX in (#4) Pref_Read */
#define PR_MaxArticles     9 	/* G_FTEXT in (#4) Pref_Read */
#define PR_CreateThr      11 	/* G_BOX in (#4) Pref_Read */
#define PR_KeyboardNav    12 	/* G_BOX in (#4) Pref_Read */
#define PR_OfflineTest    14 	/* G_BOX in (#4) Pref_Read */
#define PR_ShowStatus     18 	/* G_BOX in (#4) Pref_Read */
#define PR_EraseArticles  20 	/* G_BOX in (#4) Pref_Read */
#define PR_UseExtViewer   22 	/* G_BOX in (#4) Pref_Read */
#define PR_RecentArticle  25 	/* G_FTEXT in (#4) Pref_Read */

#define Pref_Signature     5 	/* TREE - DIALOG */
#define PSig_File          2 	/* G_STRING in (#5) Pref_Signature */
#define PSig_Path          3 	/* G_TEXT in (#5) Pref_Signature */
#define PSig_Line1         4 	/* G_TEXT in (#5) Pref_Signature */
#define PSig_Cancel       10 	/* G_BUTTON in (#5) Pref_Signature */
#define PSig_OK           11 	/* G_BUTTON in (#5) Pref_Signature */

#define Pref_Fonts         6 	/* TREE - DIALOG */
#define PF_OK              1 	/* G_BUTTON in (#6) Pref_Fonts */
#define PF_Cancel          2 	/* G_BUTTON in (#6) Pref_Fonts */
#define PF_News_Fname      7 	/* G_TEXT in (#6) Pref_Fonts */
#define PF_News_Fsize      8 	/* G_FTEXT in (#6) Pref_Fonts */
#define PF_News_FSelect    9 	/* G_BOXCHAR in (#6) Pref_Fonts */
#define PF_Over_Fname     14 	/* G_TEXT in (#6) Pref_Fonts */
#define PF_Over_Fsize     15 	/* G_FTEXT in (#6) Pref_Fonts */
#define PF_Over_FSelect   16 	/* G_BOXCHAR in (#6) Pref_Fonts */
#define PF_Art_Fname      20 	/* G_TEXT in (#6) Pref_Fonts */
#define PF_Art_Fsize      21 	/* G_FTEXT in (#6) Pref_Fonts */
#define PF_Art_FSelect    22 	/* G_BOXCHAR in (#6) Pref_Fonts */

#define About_NEWSie       7 	/* TREE - DIALOG */
#define About_OK           1 	/* G_BUTTON in (#7) About_NEWSie */
#define About_Version      9 	/* G_TEXT in (#7) About_NEWSie */
#define About_Contribute  10 	/* G_BUTTON in (#7) About_NEWSie */
#define About_Register    12 	/* G_BUTTON in (#7) About_NEWSie */

#define Pref_Path          8 	/* TREE - DIALOG */
#define PPa_PathConst      2 	/* G_STRING in (#8) Pref_Path */
#define PPa_WorkPath       3 	/* G_TEXT in (#8) Pref_Path */
#define PPa_MailConst      4 	/* G_STRING in (#8) Pref_Path */
#define PPa_MailPath       5 	/* G_TEXT in (#8) Pref_Path */
#define PPa_OfflineConst   6 	/* G_STRING in (#8) Pref_Path */
#define PPa_OfflinePath    7 	/* G_TEXT in (#8) Pref_Path */
#define PPa_ViewConst      8 	/* G_STRING in (#8) Pref_Path */
#define PPa_ExtViewer      9 	/* G_TEXT in (#8) Pref_Path */
#define PPa_EditConst     10 	/* G_STRING in (#8) Pref_Path */
#define PPa_ExtEditor     11 	/* G_TEXT in (#8) Pref_Path */
#define PPa_FTPDownCon    12 	/* G_STRING in (#8) Pref_Path */
#define PPa_FTPDownload   13 	/* G_TEXT in (#8) Pref_Path */
#define PPa_Cancel        14 	/* G_BUTTON in (#8) Pref_Path */
#define PPa_OK            15 	/* G_BUTTON in (#8) Pref_Path */

#define News_Delete        9 	/* TREE - DIALOG */
#define ND_OK              1 	/* G_BUTTON in (#9) News_Delete */
#define ND_Cancel          2 	/* G_BUTTON in (#9) News_Delete */
#define ND_NewsGroup       4 	/* G_TEXT in (#9) News_Delete */

#define News_Add          10 	/* TREE - DIALOG */
#define NA_OK              1 	/* G_BUTTON in (#10) News_Add */
#define NA_Cancel          2 	/* G_BUTTON in (#10) News_Add */
#define NA_NewsGroup       4 	/* G_FTEXT in (#10) News_Add */

#define News_Status       11 	/* TREE - DIALOG */
#define NS_StatusMsg       2 	/* G_TEXT in (#11) News_Status */
#define NS_Esc             3 	/* G_TEXT in (#11) News_Status */
#define NS_Activity        4 	/* G_TEXT in (#11) News_Status */

#define FullList_Warning  12 	/* TREE - DIALOG */
#define FL_Continue        2 	/* G_BUTTON in (#12) FullList_Warning */
#define FL_Cancel          3 	/* G_BUTTON in (#12) FullList_Warning */

#define New_NewsGroup     13 	/* TREE - DIALOG */
#define NN_OK              1 	/* G_BUTTON in (#13) New_NewsGroup */
#define NN_Cancel          2 	/* G_BUTTON in (#13) New_NewsGroup */
#define NN_Date            4 	/* G_FTEXT in (#13) New_NewsGroup */
#define NN_Time            6 	/* G_FTEXT in (#13) New_NewsGroup */

#define FullList_Exists   14 	/* TREE - DIALOG */
#define FL_UseExisting     2 	/* G_BUTTON in (#14) FullList_Exists */
#define FL_Retrieve        3 	/* G_BUTTON in (#14) FullList_Exists */

#define Font_List         15 	/* TREE - DIALOG */
#define FL_FontName1       1 	/* G_STRING in (#15) Font_List */
#define FL_FontName10     10 	/* G_STRING in (#15) Font_List */
#define FL_UpArrow        11 	/* G_BOXCHAR in (#15) Font_List */
#define FL_DnArrow        12 	/* G_BOXCHAR in (#15) Font_List */
#define FL_Exit2          13 	/* G_BOXCHAR in (#15) Font_List */
#define FL_Exit1          14 	/* G_TEXT in (#15) Font_List */

#define Find_NewsGroup    16 	/* TREE - DIALOG */
#define S_OK               1 	/* G_BUTTON in (#16) Find_NewsGroup */
#define S_Cancel           2 	/* G_BUTTON in (#16) Find_NewsGroup */
#define S_Keyword          4 	/* G_FTEXT in (#16) Find_NewsGroup */
#define S_StartBegin       6 	/* G_BOX in (#16) Find_NewsGroup */

#define Pref_Log          17 	/* TREE - DIALOG */
#define PL_DataTrans       2 	/* G_BOX in (#17) Pref_Log */
#define PL_Commands        4 	/* G_BOX in (#17) Pref_Log */
#define PL_Responses       6 	/* G_BOX in (#17) Pref_Log */
#define PL_Cancel          8 	/* G_BUTTON in (#17) Pref_Log */
#define PL_OK              9 	/* G_BUTTON in (#17) Pref_Log */
#define PL_MaskPswd       10 	/* G_BOX in (#17) Pref_Log */

#define Post_Message      18 	/* TREE - DIALOG */
#define PO_NewsGroup       1 	/* G_FTEXT in (#18) Post_Message */
#define PO_Author          2 	/* G_FTEXT in (#18) Post_Message */
#define PO_Postit          4 	/* G_BOX in (#18) Post_Message */
#define PO_Mailit          6 	/* G_BOX in (#18) Post_Message */
#define PO_toSelf          8 	/* G_BOX in (#18) Post_Message */
#define PO_Subject        10 	/* G_FTEXT in (#18) Post_Message */
#define PO_Cancel         14 	/* G_BUTTON in (#18) Post_Message */
#define PO_Edit           15 	/* G_BUTTON in (#18) Post_Message */
#define PO_Send           16 	/* G_BUTTON in (#18) Post_Message */
#define PO_AppendSig      19 	/* G_BOX in (#18) Post_Message */
#define PO_Queue          20 	/* G_BUTTON in (#18) Post_Message */
#define PO_Attach         22 	/* G_BOXTEXT in (#18) Post_Message */
#define PO_None           24 	/* G_BOX in (#18) Post_Message */
#define PO_UUE            26 	/* G_BOX in (#18) Post_Message */
#define PO_MIME           28 	/* G_BOX in (#18) Post_Message */

#define Email_Password    19 	/* TREE - DIALOG */
#define EM_OK              1 	/* G_BUTTON in (#19) Email_Password */
#define EM_Cancel          2 	/* G_BUTTON in (#19) Email_Password */
#define EM_Password        4 	/* G_FTEXT in (#19) Email_Password */

#define Mail_Message      20 	/* TREE - DIALOG */
#define MM_ToButton        2 	/* G_BOXTEXT in (#20) Mail_Message */
#define MM_To              3 	/* G_FTEXT in (#20) Mail_Message */
#define MM_Subject         5 	/* G_FTEXT in (#20) Mail_Message */
#define MM_CcButton        6 	/* G_BOXTEXT in (#20) Mail_Message */
#define MM_Cc              7 	/* G_FTEXT in (#20) Mail_Message */
#define MM_CopyToSelf      8 	/* G_BOX in (#20) Mail_Message */
#define MM_AppendSig      10 	/* G_BOX in (#20) Mail_Message */
#define MM_Cancel         12 	/* G_BUTTON in (#20) Mail_Message */
#define MM_Edit           13 	/* G_BUTTON in (#20) Mail_Message */
#define MM_Send           14 	/* G_BUTTON in (#20) Mail_Message */
#define MM_Queue          15 	/* G_BUTTON in (#20) Mail_Message */
#define MM_Attach         17 	/* G_BOXTEXT in (#20) Mail_Message */
#define MM_None           19 	/* G_BOX in (#20) Mail_Message */
#define MM_UUE            21 	/* G_BOX in (#20) Mail_Message */
#define MM_MIME           23 	/* G_BOX in (#20) Mail_Message */

#define Open_URL          21 	/* TREE - DIALOG */
#define OU_OK              1 	/* G_BUTTON in (#21) Open_URL */
#define OU_Cancel          2 	/* G_BUTTON in (#21) Open_URL */
#define OU_url             4 	/* G_FTEXT in (#21) Open_URL */
#define OU_Home            5 	/* G_BUTTON in (#21) Open_URL */

#define NEWSie_Icon       22 	/* TREE - DIALOG */

#define Error_Message     23 	/* TREE - DIALOG */
#define EM_NewNewsGroups   1 	/* G_STRING in (#23) Error_Message */
#define EM_FullNewsGroup   2 	/* G_STRING in (#23) Error_Message */
#define EM_CloseConnect    3 	/* G_STRING in (#23) Error_Message */
#define EM_LogonValidate   4 	/* G_STRING in (#23) Error_Message */
#define EM_YouHaveMsgs     5 	/* G_STRING in (#23) Error_Message */
#define EM_PasswordRej     6 	/* G_STRING in (#23) Error_Message */
#define EM_UserReject      7 	/* G_STRING in (#23) Error_Message */
#define EM_NoPassword      8 	/* G_STRING in (#23) Error_Message */
#define EM_NoConnect       9 	/* G_STRING in (#23) Error_Message */
#define EM_RetrieveMail   10 	/* G_STRING in (#23) Error_Message */
#define EM_DeleteMail     11 	/* G_STRING in (#23) Error_Message */
#define EM_RetrieveOver   12 	/* G_STRING in (#23) Error_Message */
#define EM_SendingMail    13 	/* G_STRING in (#23) Error_Message */
#define EM_SendingNews    14 	/* G_STRING in (#23) Error_Message */
#define EM_LookBinary     15 	/* G_STRING in (#23) Error_Message */
#define EM_Decoding       16 	/* G_STRING in (#23) Error_Message */
#define EM_DecodeFailed   17 	/* G_STRING in (#23) Error_Message */
#define EM_DecodeComplet  18 	/* G_STRING in (#23) Error_Message */
#define EM_NoBinaryFound  19 	/* G_STRING in (#23) Error_Message */
#define EM_RetrieveURL    20 	/* G_STRING in (#23) Error_Message */
#define EM_FileRetrieved  21 	/* G_STRING in (#23) Error_Message */
#define EM_ExtEditNFound  22 	/* G_STRING in (#23) Error_Message */
#define EM_Connect        23 	/* G_STRING in (#23) Error_Message */
#define EM_ReceiveData    24 	/* G_STRING in (#23) Error_Message */
#define EM_WaitResponse   25 	/* G_STRING in (#23) Error_Message */
#define EM_ResolveHost    26 	/* G_STRING in (#23) Error_Message */
#define EM_SendRequest    27 	/* G_STRING in (#23) Error_Message */
#define EM_FormatText     28 	/* G_STRING in (#23) Error_Message */
#define EM_ConvertImage   29 	/* G_STRING in (#23) Error_Message */
#define EM_StartProgram   30 	/* G_STRING in (#23) Error_Message */
#define EM_FormatTable    31 	/* G_STRING in (#23) Error_Message */
#define EM_WaitData       32 	/* G_STRING in (#23) Error_Message */
#define EM_CheckPathPref  33 	/* G_STRING in (#23) Error_Message */
#define EM_MailInBox      34 	/* G_STRING in (#23) Error_Message */
#define EM_SelectNewsGrp  35 	/* G_STRING in (#23) Error_Message */
#define EM_RetrieveNews   36 	/* G_STRING in (#23) Error_Message */
#define EM_SubNewsGroup   37 	/* G_STRING in (#23) Error_Message */
#define EM_SaveNewsGroup  38 	/* G_STRING in (#23) Error_Message */
#define EM_NewNGrpList    39 	/* G_STRING in (#23) Error_Message */
#define EM_FullNGrpList   40 	/* G_STRING in (#23) Error_Message */
#define EM_RetrieveArt    41 	/* G_STRING in (#23) Error_Message */
#define EM_FileDeleted    42 	/* G_STRING in (#23) Error_Message */
#define EM_SizeFile       43 	/* G_STRING in (#23) Error_Message */
#define EM_LoadPrefs      44 	/* G_STRING in (#23) Error_Message */
#define EM_SavePrefs      45 	/* G_STRING in (#23) Error_Message */
#define EM_ConnectTo      46 	/* G_STRING in (#23) Error_Message */
#define EM_SMailbox       47 	/* G_STRING in (#23) Error_Message */
#define EM_CatchUp        48 	/* G_STRING in (#23) Error_Message */
#define EM_Mailbox        49 	/* G_STRING in (#23) Error_Message */
#define EM_NoServerAcc    50 	/* G_STRING in (#23) Error_Message */
#define EM_SendQueued     51 	/* G_STRING in (#23) Error_Message */
#define EM_InBoxFull      52 	/* G_STRING in (#23) Error_Message */
#define EM_MoreMail       53 	/* G_STRING in (#23) Error_Message */
#define EM_PostQueued     54 	/* G_STRING in (#23) Error_Message */
#define EM_PostBox        55 	/* G_STRING in (#23) Error_Message */
#define EM_MailboxFull    56 	/* G_STRING in (#23) Error_Message */
#define EM_TransCancel    57 	/* G_STRING in (#23) Error_Message */
#define EM_NearlyFull     58 	/* G_STRING in (#23) Error_Message */
#define EM_SortNewsGroup  59 	/* G_STRING in (#23) Error_Message */
#define EM_SortReadFile   60 	/* G_STRING in (#23) Error_Message */
#define EM_SortWriteFile  61 	/* G_STRING in (#23) Error_Message */
#define EM_SortStart      62 	/* G_STRING in (#23) Error_Message */
#define EM_StoreFile      63 	/* G_STRING in (#23) Error_Message */
#define EM_RetrieveFile   64 	/* G_STRING in (#23) Error_Message */
#define EM_RetrieveDir    65 	/* G_STRING in (#23) Error_Message */
#define EM_RenameFile     66 	/* G_STRING in (#23) Error_Message */
#define EM_DeleteFile     67 	/* G_STRING in (#23) Error_Message */
#define EM_DeleteDir      68 	/* G_STRING in (#23) Error_Message */
#define EM_CreateDir      69 	/* G_STRING in (#23) Error_Message */
#define EM_TransmitData   70 	/* G_STRING in (#23) Error_Message */
#define EM_SaveAs         71 	/* G_STRING in (#23) Error_Message */
#define EM_AddressBook    72 	/* G_STRING in (#23) Error_Message */
#define EM_UnableSave     73 	/* G_STRING in (#23) Error_Message */
#define EM_UnableQueue    74 	/* G_STRING in (#23) Error_Message */
#define EM_OpenFTP        75 	/* G_STRING in (#23) Error_Message */
#define EM_FTPServers     76 	/* G_STRING in (#23) Error_Message */
#define EM_FTPAscii       77 	/* G_STRING in (#23) Error_Message */
#define EM_FTPBinary      78 	/* G_STRING in (#23) Error_Message */
#define EM_SelectFile     79 	/* G_STRING in (#23) Error_Message */
#define EM_MailInfo       80 	/* G_STRING in (#23) Error_Message */
#define EM_OverInfo       81 	/* G_STRING in (#23) Error_Message */
#define EM_UnableAlloc    82 	/* G_STRING in (#23) Error_Message */
#define EM_CantLocate     83 	/* G_STRING in (#23) Error_Message */
#define EM_MailSInfo      84 	/* G_TEXT in (#23) Error_Message */
#define EM_RetrURLHelp    85 	/* G_STRING in (#23) Error_Message */
#define EM_InsuffDisk     86 	/* G_STRING in (#23) Error_Message */
#define EM_FileWrErr      87 	/* G_STRING in (#23) Error_Message */
#define EM_SAddrBook      88 	/* G_STRING in (#23) Error_Message */
#define EM_SelAttach      89 	/* G_STRING in (#23) Error_Message */
#define EM_UnknownMail    90 	/* G_STRING in (#23) Error_Message */
#define EM_DelAllArt      91 	/* G_STRING in (#23) Error_Message */

#define Pref_Mail         24 	/* TREE - DIALOG */
#define MR_OK              1 	/* G_BUTTON in (#24) Pref_Mail */
#define MR_Cancel          2 	/* G_BUTTON in (#24) Pref_Mail */
#define MR_DeleteMail      3 	/* G_BOX in (#24) Pref_Mail */
#define MR_ShowHeaders     6 	/* G_BOX in (#24) Pref_Mail */
#define MR_Password        7 	/* G_FTEXT in (#24) Pref_Mail */
#define MR_UsePassword     9 	/* G_BOX in (#24) Pref_Mail */
#define MR_DeleteQueued   11 	/* G_BOX in (#24) Pref_Mail */
#define MR_SendCheck      12 	/* G_BOX in (#24) Pref_Mail */
#define MR_MailDirs       15 	/* G_BOX in (#24) Pref_Mail */
#define MR_Ignore         19 	/* G_BOX in (#24) Pref_Mail */
#define MR_Respect        21 	/* G_BOX in (#24) Pref_Mail */
#define MR_Force          23 	/* G_BOX in (#24) Pref_Mail */

#define Contributors      25 	/* TREE - DIALOG */
#define Contrib_OK         1 	/* G_BUTTON in (#25) Contributors */

#define Nickname          26 	/* TREE - DIALOG */
#define NE_Nick1           4 	/* G_TEXT in (#26) Nickname */
#define NE_Nick2           5 	/* G_TEXT in (#26) Nickname */
#define NE_Nick3           6 	/* G_TEXT in (#26) Nickname */
#define NE_Nick4           7 	/* G_TEXT in (#26) Nickname */
#define NE_Nick5           8 	/* G_TEXT in (#26) Nickname */
#define NE_Nick6           9 	/* G_TEXT in (#26) Nickname */
#define NE_Nick7          10 	/* G_TEXT in (#26) Nickname */
#define NE_Nick8          11 	/* G_TEXT in (#26) Nickname */
#define NE_Nick9          12 	/* G_TEXT in (#26) Nickname */
#define NE_Nick10         13 	/* G_TEXT in (#26) Nickname */
#define NE_NickUp         14 	/* G_BOXCHAR in (#26) Nickname */
#define NE_NickDown       15 	/* G_BOXCHAR in (#26) Nickname */
#define NE_Addr1          17 	/* G_TEXT in (#26) Nickname */
#define NE_Addr2          18 	/* G_TEXT in (#26) Nickname */
#define NE_Addr3          19 	/* G_TEXT in (#26) Nickname */
#define NE_Addr4          20 	/* G_TEXT in (#26) Nickname */
#define NE_Addr5          21 	/* G_TEXT in (#26) Nickname */
#define NE_Addr6          22 	/* G_TEXT in (#26) Nickname */
#define NE_Addr7          23 	/* G_TEXT in (#26) Nickname */
#define NE_Addr8          24 	/* G_TEXT in (#26) Nickname */
#define NE_Addr9          25 	/* G_TEXT in (#26) Nickname */
#define NE_Addr10         26 	/* G_TEXT in (#26) Nickname */
#define NE_AddrUp         27 	/* G_BOXCHAR in (#26) Nickname */
#define NE_AddrDown       28 	/* G_BOXCHAR in (#26) Nickname */
#define NE_Description    30 	/* G_TEXT in (#26) Nickname */
#define NE_Add            31 	/* G_BUTTON in (#26) Nickname */
#define NE_Change         32 	/* G_BUTTON in (#26) Nickname */
#define NE_Delete         33 	/* G_BUTTON in (#26) Nickname */
#define NE_Cancel         34 	/* G_BUTTON in (#26) Nickname */
#define NE_OK             35 	/* G_BUTTON in (#26) Nickname */

#define Nick_Nick1        27 	/* TREE - DIALOG */
#define N1_OK              1 	/* G_BUTTON in (#27) Nick_Nick1 */
#define N1_Cancel          2 	/* G_BUTTON in (#27) Nick_Nick1 */
#define N1_Text            3 	/* G_STRING in (#27) Nick_Nick1 */
#define N1_Nick            4 	/* G_FTEXT in (#27) Nick_Nick1 */
#define N1_Desc            5 	/* G_FTEXT in (#27) Nick_Nick1 */

#define Nick_Nick2        28 	/* TREE - DIALOG */
#define N2_OK              1 	/* G_BUTTON in (#28) Nick_Nick2 */
#define N2_Cancel          2 	/* G_BUTTON in (#28) Nick_Nick2 */
#define N2_Text            3 	/* G_STRING in (#28) Nick_Nick2 */
#define N2_Addr            4 	/* G_FTEXT in (#28) Nick_Nick2 */
#define N2_Delete          5 	/* G_BUTTON in (#28) Nick_Nick2 */

#define Search_Group      29 	/* TREE - DIALOG */
#define SG_OK              1 	/* G_BUTTON in (#29) Search_Group */
#define SG_Cancel          2 	/* G_BUTTON in (#29) Search_Group */
#define SG_SearchGroup     4 	/* G_FTEXT in (#29) Search_Group */
#define SG_StartTop        5 	/* G_BOX in (#29) Search_Group */

#define Match_Group       30 	/* TREE - DIALOG */
#define MG_OK              1 	/* G_BUTTON in (#30) Match_Group */
#define MG_Cancel          2 	/* G_BUTTON in (#30) Match_Group */
#define MG_MatchGroup      4 	/* G_FTEXT in (#30) Match_Group */
#define MG_StartTop        5 	/* G_BOX in (#30) Match_Group */

#define Pop_Overview      31 	/* TREE - DIALOG */
#define PN_Help            1 	/* G_STRING in (#31) Pop_Overview */
#define PN_NextArticle     3 	/* G_STRING in (#31) Pop_Overview */
#define PN_NextThread      4 	/* G_STRING in (#31) Pop_Overview */
#define PN_NextGroup       5 	/* G_STRING in (#31) Pop_Overview */
#define PN_MarkRead        7 	/* G_STRING in (#31) Pop_Overview */
#define PN_MarkUnread      8 	/* G_STRING in (#31) Pop_Overview */
#define PN_MarkThread      9 	/* G_STRING in (#31) Pop_Overview */
#define PN_MarkAllRead    10 	/* G_STRING in (#31) Pop_Overview */
#define PN_NewPost        12 	/* G_STRING in (#31) Pop_Overview */
#define PN_FollowupPost   13 	/* G_STRING in (#31) Pop_Overview */
#define PN_ReadOffline    15 	/* G_STRING in (#31) Pop_Overview */
#define PN_OpenPostBox    16 	/* G_STRING in (#31) Pop_Overview */

#define Pop_Mail          32 	/* TREE - DIALOG */
#define PM_Help            1 	/* G_STRING in (#32) Pop_Mail */
#define PM_SendMail        3 	/* G_STRING in (#32) Pop_Mail */
#define PM_ReplyMail       4 	/* G_STRING in (#32) Pop_Mail */
#define PM_ForwardMail     5 	/* G_STRING in (#32) Pop_Mail */
#define PM_EditNicknames   7 	/* G_STRING in (#32) Pop_Mail */
#define PM_DeleteMsg       9 	/* G_STRING in (#32) Pop_Mail */
#define PM_SaveAs         10 	/* G_STRING in (#32) Pop_Mail */
#define PM_ExtractBinary  11 	/* G_STRING in (#32) Pop_Mail */

#define Pop_Mailbox       33 	/* TREE - DIALOG */
#define PMB_Help           1 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_ViewMessage    3 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_SendMail       4 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_ReplyMail      5 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_ForwardMail    6 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_EditNickname   8 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_OpenInBox     10 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_OpenMailbox   11 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_DeleteMsg     13 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_Transfer      14 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_SortAuthor    16 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_SortSubject   17 	/* G_STRING in (#33) Pop_Mailbox */
#define PMB_SortDate      18 	/* G_STRING in (#33) Pop_Mailbox */

#define Pop_Article       34 	/* TREE - DIALOG */
#define PA_Help            1 	/* G_STRING in (#34) Pop_Article */
#define PA_Post            3 	/* G_STRING in (#34) Pop_Article */
#define PA_Followup        4 	/* G_STRING in (#34) Pop_Article */
#define PA_DeleteArticle   6 	/* G_STRING in (#34) Pop_Article */
#define PA_SaveAs          7 	/* G_STRING in (#34) Pop_Article */
#define PA_ExtractBinary   8 	/* G_STRING in (#34) Pop_Article */

#define Pop_GroupList     35 	/* TREE - DIALOG */
#define PG_Help            1 	/* G_STRING in (#35) Pop_GroupList */
#define PG_Search          3 	/* G_STRING in (#35) Pop_GroupList */
#define PG_Match           4 	/* G_STRING in (#35) Pop_GroupList */
#define PG_Subscribe       6 	/* G_STRING in (#35) Pop_GroupList */

#define Pop_Subscribed    36 	/* TREE - DIALOG */
#define PS_Help            1 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_MarkAllRead     4 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_ReadOffline     6 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_OpenPostBox     7 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_Subscribe       8 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_UnSubscribe     9 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_Overview       10 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_Save           11 	/* G_STRING in (#36) Pop_Subscribed */
#define PS_OpenList       12 	/* G_STRING in (#36) Pop_Subscribed */

#define Pop_FTP_Server    37 	/* TREE - DIALOG */
#define PFS_Help           1 	/* G_STRING in (#37) Pop_FTP_Server */
#define PFS_OpenServer     3 	/* G_STRING in (#37) Pop_FTP_Server */
#define PFS_AddServer      4 	/* G_STRING in (#37) Pop_FTP_Server */
#define PFS_EditServer     5 	/* G_STRING in (#37) Pop_FTP_Server */
#define PFS_DeleteServer   6 	/* G_STRING in (#37) Pop_FTP_Server */

#define Pop_FTP_Dir       38 	/* TREE - DIALOG */
#define PFD_Help           1 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_MakeDir        3 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_ChangeDir      4 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_DeleteDir      5 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_GetFile        6 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_PutFileName    8 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_RenameFile     9 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_PutFile       10 	/* G_STRING in (#38) Pop_FTP_Dir */
#define PFD_DeleteFile    11 	/* G_STRING in (#38) Pop_FTP_Dir */

#define FTP_Edit_Server   39 	/* TREE - DIALOG */
#define DFS_Server         3 	/* G_FTEXT in (#39) FTP_Edit_Server */
#define DFS_Logon          5 	/* G_FTEXT in (#39) FTP_Edit_Server */
#define DFS_Password       7 	/* G_FTEXT in (#39) FTP_Edit_Server */
#define DFS_SaveDir        8 	/* G_BOX in (#39) FTP_Edit_Server */
#define DFS_ServerCancel  10 	/* G_BUTTON in (#39) FTP_Edit_Server */
#define DFS_ServerOK      11 	/* G_BUTTON in (#39) FTP_Edit_Server */
#define DFS_Directory     13 	/* G_FTEXT in (#39) FTP_Edit_Server */
#define DFS_Port          15 	/* G_FTEXT in (#39) FTP_Edit_Server */

#define FTP_SaveRename    40 	/* TREE - DIALOG */
#define DFS_SaveAsOK       1 	/* G_BUTTON in (#40) FTP_SaveRename */
#define DFS_SaveAsCancel   2 	/* G_BUTTON in (#40) FTP_SaveRename */
#define DFS_SaveAsRename   3 	/* G_FTEXT in (#40) FTP_SaveRename */
#define DFS_SaveOldName    6 	/* G_STRING in (#40) FTP_SaveRename */

#define Pref_General      41 	/* TREE - DIALOG */
#define PG_OK              1 	/* G_BUTTON in (#41) Pref_General */
#define PG_Cancel          2 	/* G_BUTTON in (#41) Pref_General */
#define PG_AutoTop         3 	/* G_BOX in (#41) Pref_General */
#define PG_ShowToolBar     6 	/* G_BOX in (#41) Pref_General */
#define PG_BottomToolBar   8 	/* G_BOX in (#41) Pref_General */
#define PG_WindowBuffer   10 	/* G_BOX in (#41) Pref_General */
#define PG_DynamicExp     12 	/* G_BOX in (#41) Pref_General */
#define PG_AutoLanguage   14 	/* G_BOX in (#41) Pref_General */
#define PG_SelLanguage    16 	/* G_BOXTEXT in (#41) Pref_General */
#define PG_BubbleHelp     17 	/* G_BOX in (#41) Pref_General */
#define PG_InfoStatus     19 	/* G_BOX in (#41) Pref_General */
#define PG_AutoExtract    21 	/* G_BOX in (#41) Pref_General */
#define PG_AutoPrompt     23 	/* G_BOX in (#41) Pref_General */

#define Pref_FTP          42 	/* TREE - DIALOG */
#define PFTP_SendHelp      2 	/* G_BOX in (#42) Pref_FTP */
#define PFTP_SendAlloc     4 	/* G_BOX in (#42) Pref_FTP */
#define PFTP_SaveLast      6 	/* G_BOX in (#42) Pref_FTP */
#define PFTP_Cancel        8 	/* G_BUTTON in (#42) Pref_FTP */
#define PFTP_OK            9 	/* G_BUTTON in (#42) Pref_FTP */
#define PFTP_UsePort      10 	/* G_BOX in (#42) Pref_FTP */
#define PFTP_SaveLower    12 	/* G_BOX in (#42) Pref_FTP */

#define Edit_FKeys        43 	/* TREE - DIALOG */
#define DF_F1             12 	/* G_FTEXT in (#43) Edit_FKeys */
#define DF_F11            32 	/* G_FTEXT in (#43) Edit_FKeys */
#define DF_Cancel         42 	/* G_BUTTON in (#43) Edit_FKeys */
#define DF_OK             43 	/* G_BUTTON in (#43) Edit_FKeys */

#define Tool_Mail         44 	/* TREE - DIALOG */
#define TM_Send            1 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_Reply           2 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_Forward         3 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_Nicknames       4 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_Delete          5 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_SaveAs          6 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_Extract         7 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_NextMail        8 	/* G_BOXTEXT in (#44) Tool_Mail */
#define TM_NextUnread      9 	/* G_BOXTEXT in (#44) Tool_Mail */

#define Tool_Server       45 	/* TREE - DIALOG */
#define TFS_Open           1 	/* G_BOXTEXT in (#45) Tool_Server */
#define TFS_Add            2 	/* G_BOXTEXT in (#45) Tool_Server */
#define TFS_Edit           3 	/* G_BOXTEXT in (#45) Tool_Server */
#define TFS_Delete         4 	/* G_BOXTEXT in (#45) Tool_Server */

#define Tool_Directory    46 	/* TREE - DIALOG */
#define TFD_MakeDir        1 	/* G_BOXTEXT in (#46) Tool_Directory */
#define TFD_ChangeDir      2 	/* G_BOXTEXT in (#46) Tool_Directory */
#define TFD_DeleteDir      3 	/* G_BOXTEXT in (#46) Tool_Directory */
#define TFD_Get            4 	/* G_BOXTEXT in (#46) Tool_Directory */
#define TFD_Put            5 	/* G_BOXTEXT in (#46) Tool_Directory */
#define TFD_PutName        6 	/* G_BOXTEXT in (#46) Tool_Directory */
#define TFD_Rename         7 	/* G_BOXTEXT in (#46) Tool_Directory */
#define TFD_Delete         8 	/* G_BOXTEXT in (#46) Tool_Directory */

#define Tool_MailBox      47 	/* TREE - DIALOG */
#define TMB_View           1 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Send           2 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Reply          3 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Forward        4 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Nicknames      5 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_InBox          6 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Other          7 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Delete         8 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Transfer       9 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Author        10 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Subject       11 	/* G_BOXTEXT in (#47) Tool_MailBox */
#define TMB_Date          12 	/* G_BOXTEXT in (#47) Tool_MailBox */

#define Tool_GroupList    48 	/* TREE - DIALOG */
#define TG_Search          1 	/* G_BOXTEXT in (#48) Tool_GroupList */
#define TG_Match           2 	/* G_BOXTEXT in (#48) Tool_GroupList */
#define TG_Subscribe       3 	/* G_BOXTEXT in (#48) Tool_GroupList */

#define Tool_Article      49 	/* TREE - DIALOG */
#define TA_Post            1 	/* G_BOXTEXT in (#49) Tool_Article */
#define TA_Followup        2 	/* G_BOXTEXT in (#49) Tool_Article */
#define TA_Delete          3 	/* G_BOXTEXT in (#49) Tool_Article */
#define TA_SaveAs          4 	/* G_BOXTEXT in (#49) Tool_Article */
#define TA_Extract         5 	/* G_BOXTEXT in (#49) Tool_Article */
#define TA_NextArticle     6 	/* G_BOXTEXT in (#49) Tool_Article */

#define Tool_Subscribed   50 	/* TREE - DIALOG */
#define TS_Subscribe       1 	/* G_BOXTEXT in (#50) Tool_Subscribed */
#define TS_UnSubscribe     2 	/* G_BOXTEXT in (#50) Tool_Subscribed */
#define TS_Overview        3 	/* G_BOXTEXT in (#50) Tool_Subscribed */
#define TS_Save            4 	/* G_BOXTEXT in (#50) Tool_Subscribed */
#define TS_Open            5 	/* G_BOXTEXT in (#50) Tool_Subscribed */
#define TS_MarkAll         6 	/* G_BOXTEXT in (#50) Tool_Subscribed */
#define TS_ReadOffline     7 	/* G_BOXTEXT in (#50) Tool_Subscribed */
#define TS_PostBox         8 	/* G_BOXTEXT in (#50) Tool_Subscribed */

#define Tool_Overview     51 	/* TREE - DIALOG */
#define TO_NextArticle     1 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_NextThread      2 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_NextGroup       3 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_MarkRead        4 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_MarkUnread      5 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_MarkThread      6 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_MarkAll         7 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_Post            8 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_Followup        9 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_ReadOffline    10 	/* G_BOXTEXT in (#51) Tool_Overview */
#define TO_Postbox        11 	/* G_BOXTEXT in (#51) Tool_Overview */

#define Address_Book      52 	/* TREE - DIALOG */
#define AB_Name            3 	/* G_FTEXT in (#52) Address_Book */
#define AB_Notes           5 	/* G_FTEXT in (#52) Address_Book */
#define AB_Email           7 	/* G_FTEXT in (#52) Address_Book */
#define AB_Cancel          8 	/* G_BUTTON in (#52) Address_Book */
#define AB_OK              9 	/* G_BUTTON in (#52) Address_Book */

#define Pop_Address_Book  53 	/* TREE - DIALOG */
#define PAB_SendMail       3 	/* G_STRING in (#53) Pop_Address_Book */
#define PAB_AddEntry       4 	/* G_STRING in (#53) Pop_Address_Book */
#define PAB_EditEntry      5 	/* G_STRING in (#53) Pop_Address_Book */
#define PAB_DeleteEntry    6 	/* G_STRING in (#53) Pop_Address_Book */
#define PAB_SortAddress    7 	/* G_STRING in (#53) Pop_Address_Book */
#define PAB_Load           9 	/* G_STRING in (#53) Pop_Address_Book */

#define Tool_Address      54 	/* TREE - DIALOG */
#define TAB_SendMail       1 	/* G_BOXTEXT in (#54) Tool_Address */
#define TAB_AddEntry       2 	/* G_BOXTEXT in (#54) Tool_Address */
#define TAB_EditEntry      3 	/* G_BOXTEXT in (#54) Tool_Address */
#define TAB_DeleteEntry    4 	/* G_BOXTEXT in (#54) Tool_Address */
#define TAB_SortAddress    5 	/* G_BOXTEXT in (#54) Tool_Address */
#define TAB_Load           6 	/* G_BOXTEXT in (#54) Tool_Address */

#define Tool_Browser      55 	/* TREE - DIALOG */
#define TB_Back            1 	/* G_BOXTEXT in (#55) Tool_Browser */
#define TB_Home            2 	/* G_BOXTEXT in (#55) Tool_Browser */
#define TB_URL             3 	/* G_BOXTEXT in (#55) Tool_Browser */
#define TB_File            4 	/* G_BOXTEXT in (#55) Tool_Browser */
#define TB_Source          5 	/* G_BOXTEXT in (#55) Tool_Browser */
#define TB_Reload          6 	/* G_BOXTEXT in (#55) Tool_Browser */
#define TB_HotList         7 	/* G_BOXTEXT in (#55) Tool_Browser */
#define TB_Stop            8 	/* G_BOXTEXT in (#55) Tool_Browser */

#define Pop_Browser       56 	/* TREE - DIALOG */
#define PB_Help            1 	/* G_STRING in (#56) Pop_Browser */
#define PB_Back            3 	/* G_STRING in (#56) Pop_Browser */
#define PB_Home            4 	/* G_STRING in (#56) Pop_Browser */
#define PB_URL             5 	/* G_STRING in (#56) Pop_Browser */
#define PB_File            6 	/* G_STRING in (#56) Pop_Browser */
#define PB_Source          8 	/* G_STRING in (#56) Pop_Browser */
#define PB_Reload          9 	/* G_STRING in (#56) Pop_Browser */
#define PB_HotList        10 	/* G_STRING in (#56) Pop_Browser */
#define PB_Stop           11 	/* G_STRING in (#56) Pop_Browser */

#define Pref_Browser      57 	/* TREE - DIALOG */
#define PB_HomeCon         2 	/* G_STRING in (#57) Pref_Browser */
#define PB_HomePath        3 	/* G_TEXT in (#57) Pref_Browser */
#define PB_HotCon          4 	/* G_STRING in (#57) Pref_Browser */
#define PB_HotPath         5 	/* G_TEXT in (#57) Pref_Browser */
#define PB_CacheCon        6 	/* G_STRING in (#57) Pref_Browser */
#define PB_CachePath       7 	/* G_TEXT in (#57) Pref_Browser */
#define PB_Cancel          8 	/* G_BUTTON in (#57) Pref_Browser */
#define PB_OK              9 	/* G_BUTTON in (#57) Pref_Browser */
#define PB_HistoryLog     10 	/* G_BOX in (#57) Pref_Browser */

#define TH_Mail           58 	/* TREE - DIALOG */
#define THM_Send           1 	/* G_STRING in (#58) TH_Mail */
#define THM_Reply          2 	/* G_STRING in (#58) TH_Mail */
#define THM_Forward        3 	/* G_STRING in (#58) TH_Mail */
#define THM_Nicknames      4 	/* G_STRING in (#58) TH_Mail */
#define THM_Delete         5 	/* G_STRING in (#58) TH_Mail */
#define THM_SaveAs         6 	/* G_STRING in (#58) TH_Mail */
#define THM_Extract        7 	/* G_STRING in (#58) TH_Mail */
#define THM_NextMail       8 	/* G_STRING in (#58) TH_Mail */
#define THM_NextUnread     9 	/* G_STRING in (#58) TH_Mail */

#define TH_Server         59 	/* TREE - DIALOG */
#define THFS_Open          1 	/* G_STRING in (#59) TH_Server */
#define THFS_Add           2 	/* G_STRING in (#59) TH_Server */
#define THFS_Edit          3 	/* G_STRING in (#59) TH_Server */
#define THFS_Delete        4 	/* G_STRING in (#59) TH_Server */

#define TH_Directory      60 	/* TREE - DIALOG */
#define THFD_MakeDir       1 	/* G_STRING in (#60) TH_Directory */
#define THFD_ChangeDir     2 	/* G_STRING in (#60) TH_Directory */
#define THFD_DeleteDir     3 	/* G_STRING in (#60) TH_Directory */
#define THFD_Get           4 	/* G_STRING in (#60) TH_Directory */
#define THFD_Put           5 	/* G_STRING in (#60) TH_Directory */
#define THFD_PutName       6 	/* G_STRING in (#60) TH_Directory */
#define THFD_Rename        7 	/* G_STRING in (#60) TH_Directory */
#define THFD_Delete        8 	/* G_STRING in (#60) TH_Directory */

#define TH_MailBox        61 	/* TREE - DIALOG */
#define THMB_View          1 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Send          2 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Reply         3 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Forward       4 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Nicknames     5 	/* G_STRING in (#61) TH_MailBox */
#define THMB_InBox         6 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Other         7 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Delete        8 	/* G_STRING in (#61) TH_MailBox */
#define OBJ0               9 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Author       10 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Subject      11 	/* G_STRING in (#61) TH_MailBox */
#define THMB_Date         12 	/* G_STRING in (#61) TH_MailBox */

#define TH_GroupList      62 	/* TREE - DIALOG */
#define THG_Search         1 	/* G_STRING in (#62) TH_GroupList */
#define THG_Match          2 	/* G_STRING in (#62) TH_GroupList */
#define THG_Subscribe      3 	/* G_STRING in (#62) TH_GroupList */

#define TH_Article        63 	/* TREE - DIALOG */
#define THA_Post           1 	/* G_STRING in (#63) TH_Article */
#define THA_Followup       2 	/* G_STRING in (#63) TH_Article */
#define THA_Delete         3 	/* G_STRING in (#63) TH_Article */
#define THA_SaveAs         4 	/* G_STRING in (#63) TH_Article */
#define THA_Extract        5 	/* G_STRING in (#63) TH_Article */
#define THA_NextArticle    6 	/* G_STRING in (#63) TH_Article */

#define TH_Subscribed     64 	/* TREE - DIALOG */
#define THS_Subscribe      1 	/* G_STRING in (#64) TH_Subscribed */
#define THS_UnSubscribe    2 	/* G_STRING in (#64) TH_Subscribed */
#define THS_Overview       3 	/* G_STRING in (#64) TH_Subscribed */
#define THS_Save           4 	/* G_STRING in (#64) TH_Subscribed */
#define THS_Open           5 	/* G_STRING in (#64) TH_Subscribed */
#define THS_MarkAll        6 	/* G_STRING in (#64) TH_Subscribed */
#define THS_ReadOffline    7 	/* G_STRING in (#64) TH_Subscribed */
#define THS_PostBox        8 	/* G_STRING in (#64) TH_Subscribed */

#define TH_Overview       65 	/* TREE - DIALOG */
#define THO_NextArticle    1 	/* G_STRING in (#65) TH_Overview */
#define THO_NextThread     2 	/* G_STRING in (#65) TH_Overview */
#define THO_NextGroup      3 	/* G_STRING in (#65) TH_Overview */
#define THO_MarkRead       4 	/* G_STRING in (#65) TH_Overview */
#define THO_MarkUnread     5 	/* G_STRING in (#65) TH_Overview */
#define THO_MarkThread     6 	/* G_STRING in (#65) TH_Overview */
#define THO_MarkAll        7 	/* G_STRING in (#65) TH_Overview */
#define THO_Post           8 	/* G_STRING in (#65) TH_Overview */
#define THO_Followup       9 	/* G_STRING in (#65) TH_Overview */
#define THO_ReadOffline   10 	/* G_STRING in (#65) TH_Overview */
#define THO_PostBox       11 	/* G_STRING in (#65) TH_Overview */

#define TH_Address        66 	/* TREE - DIALOG */
#define THAB_SendMail      1 	/* G_STRING in (#66) TH_Address */
#define THAB_AddEntry      2 	/* G_STRING in (#66) TH_Address */
#define THAB_EditEntry     3 	/* G_STRING in (#66) TH_Address */
#define THAB_DeleteEntry   4 	/* G_STRING in (#66) TH_Address */
#define THAB_SortAddress   5 	/* G_STRING in (#66) TH_Address */
#define THAB_Load          6 	/* G_STRING in (#66) TH_Address */

#define TH_Browser        67 	/* TREE - DIALOG */
#define THB_Back           1 	/* G_STRING in (#67) TH_Browser */
#define THB_Home           2 	/* G_STRING in (#67) TH_Browser */
#define THB_URL            3 	/* G_STRING in (#67) TH_Browser */
#define THB_File           4 	/* G_STRING in (#67) TH_Browser */
#define THB_Source         5 	/* G_STRING in (#67) TH_Browser */
#define THB_Reload         6 	/* G_STRING in (#67) TH_Browser */
#define THB_HotList        7 	/* G_STRING in (#67) TH_Browser */
#define THB_Stop           8 	/* G_STRING in (#67) TH_Browser */

#define Translate         68 	/* TREE - DIALOG */
#define DTF_Atari          3 	/* G_BUTTON in (#68) Translate */
#define DTF_MAC            4 	/* G_BUTTON in (#68) Translate */
#define DTF_Windows        5 	/* G_BUTTON in (#68) Translate */
#define DTF_DOS            6 	/* G_BUTTON in (#68) Translate */
#define DFT_Unix           7 	/* G_BUTTON in (#68) Translate */
#define DTT_Atari          9 	/* G_BUTTON in (#68) Translate */
#define DTT_MAC           10 	/* G_BUTTON in (#68) Translate */
#define DTT_Windows       11 	/* G_BUTTON in (#68) Translate */
#define DTT_DOS           12 	/* G_BUTTON in (#68) Translate */
#define DTT_Unix          13 	/* G_BUTTON in (#68) Translate */
#define DT_Cancel         14 	/* G_BUTTON in (#68) Translate */
#define DT_OK             15 	/* G_BUTTON in (#68) Translate */

#define NewsGroup_Edit    69 	/* TREE - DIALOG */
#define NG_First           3 	/* G_FTEXT in (#69) NewsGroup_Edit */
#define NG_Last            5 	/* G_FTEXT in (#69) NewsGroup_Edit */
#define NG_Cancel          6 	/* G_BUTTON in (#69) NewsGroup_Edit */
#define NG_OK              7 	/* G_BUTTON in (#69) NewsGroup_Edit */

#define WWW_Auth          70 	/* TREE - DIALOG */
#define WWW_What           2 	/* G_TEXT in (#70) WWW_Auth */
#define WWW_User           4 	/* G_FTEXT in (#70) WWW_Auth */
#define WWW_Pass           6 	/* G_FTEXT in (#70) WWW_Auth */
#define WWW_Cancel         7 	/* G_BUTTON in (#70) WWW_Auth */
#define WWW_OK             8 	/* G_BUTTON in (#70) WWW_Auth */

#define Pop_MailSelect    71 	/* TREE - DIALOG */
#define PMS_Help           1 	/* G_STRING in (#71) Pop_MailSelect */
#define PMS_Retrieve       3 	/* G_STRING in (#71) Pop_MailSelect */
#define PMS_Delete         4 	/* G_STRING in (#71) Pop_MailSelect */
#define PMS_RetrieveAll    5 	/* G_STRING in (#71) Pop_MailSelect */
#define PMS_ResetAll       6 	/* G_STRING in (#71) Pop_MailSelect */
#define PMS_DeleteRead     8 	/* G_STRING in (#71) Pop_MailSelect */
#define PMS_DeleteAll      9 	/* G_STRING in (#71) Pop_MailSelect */
#define PMS_Close         10 	/* G_STRING in (#71) Pop_MailSelect */

#define Tool_MailSelect   72 	/* TREE - DIALOG */
#define TMS_Retrieve       1 	/* G_BOXTEXT in (#72) Tool_MailSelect */
#define TMS_Delete         2 	/* G_BOXTEXT in (#72) Tool_MailSelect */
#define TMS_RetrieveAll    3 	/* G_BOXTEXT in (#72) Tool_MailSelect */
#define TMS_ResetAll       4 	/* G_BOXTEXT in (#72) Tool_MailSelect */
#define TMS_DeleteRead     5 	/* G_BOXTEXT in (#72) Tool_MailSelect */
#define TMS_DeleteAll      6 	/* G_BOXTEXT in (#72) Tool_MailSelect */
#define TMS_Close          7 	/* G_BOXTEXT in (#72) Tool_MailSelect */

#define TH_MailSelect     73 	/* TREE - DIALOG */
#define THMS_Retrieve      1 	/* G_STRING in (#73) TH_MailSelect */
#define THMS_Delete        2 	/* G_STRING in (#73) TH_MailSelect */
#define THMS_RetrievAll    3 	/* G_STRING in (#73) TH_MailSelect */
#define THMS_ResetAll      4 	/* G_STRING in (#73) TH_MailSelect */
#define THMS_DeleteRead    5 	/* G_STRING in (#73) TH_MailSelect */
#define THMS_DeleteAll     6 	/* G_STRING in (#73) TH_MailSelect */
#define THMS_Close         7 	/* G_STRING in (#73) TH_MailSelect */
#define NoSTiK             1 	/* STRING */
#define NoWindow           2 	/* STRING */
#define Insuff_Memory      3 	/* STRING */
#define Rsc_Version        4 	/* STRING */
#define Rsc_Incompat       5 	/* STRING */
#define Extract_From       6 	/* STRING */
#define NEWSie_Version     0 	/* FREE STRING */
#define Mouse_Form         0 	/* FREE IMAGE  */
