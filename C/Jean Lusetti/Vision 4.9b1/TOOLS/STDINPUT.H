#ifndef __STDINPUT_H
#define __STDINPUT_H

void stdinput_fix(void) ;
void std_input(char *title, char *text, char *txt_cancel) ;

#endif