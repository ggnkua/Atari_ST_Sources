#ifndef __TG_H
#define __TG_H

/* Pre-calcul des niveaux de gris pour 16 bits --> 8 et 4 plans */
unsigned char tg_16bto4b[32*3] = {
0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x01, 0x01, 
0x01, 0x01, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 
0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x04, 0x04, 
0x04, 0x04, 0x04, 0x04, 0x05, 0x05, 0x05, 0x05, 
0x05, 0x05, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 
0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x08, 0x08, 
0x08, 0x08, 0x08, 0x08, 0x09, 0x09, 0x09, 0x09, 
0x09, 0x09, 0x0a, 0x0a, 0x0a, 0x0a, 0x0a, 0x0a, 
0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0c, 0x0c, 
0x0c, 0x0c, 0x0c, 0x0c, 0x0d, 0x0d, 0x0d, 0x0d, 
0x0d, 0x0d, 0x0e, 0x0e, 0x0e, 0x0e, 0x0e, 0x0e, 
0x0f, 0x0f, 0x0f, 0x0f, 0x0f, 0x0f, 0x0f, 0x0f
} ;

unsigned char tg_16bto8b[32*3] = {
0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x12, 
0x15, 0x18, 0x1b, 0x1d, 0x20, 0x22, 0x25, 0x28, 
0x2a, 0x2d, 0x30, 0x32, 0x35, 0x38, 0x3a, 0x3d, 
0x40, 0x42, 0x45, 0x48, 0x4a, 0x4d, 0x50, 0x52, 
0x55, 0x57, 0x5a, 0x5d, 0x60, 0x62, 0x65, 0x68, 
0x6a, 0x6d, 0x6f, 0x72, 0x75, 0x77, 0x7a, 0x7d, 
0x80, 0x82, 0x85, 0x87, 0x8a, 0x8d, 0x8f, 0x92, 
0x95, 0x97, 0x9a, 0x9d, 0x9f, 0xa2, 0xa4, 0xa7, 
0xaa, 0xad, 0xaf, 0xb2, 0xb5, 0xb7, 0xba, 0xbc, 
0xbf, 0xc2, 0xc4, 0xc7, 0xca, 0xcd, 0xcf, 0xd2, 
0xd4, 0xd7, 0xda, 0xdc, 0xdf, 0xe2, 0xe4, 0xe7, 
0xea, 0xec, 0xef, 0xf1, 0xf4, 0xf7, 0xfa, 0xfc
} ;

#endif
