#ifndef __IBROWSER
#define __IBROWSER

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

GEM_WINDOW *CreateImgBrowser(char *filename) ;

#endif
