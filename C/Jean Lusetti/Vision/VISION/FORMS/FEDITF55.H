#ifndef __FEDITF55
#define __FEDITF55

#if !defined(__CONVOLUTION)
#include "..\tools\convol.h"
#endif

void edit_5x5filter(CONVOLUTION_FILTRE *in_filter) ;


#endif
