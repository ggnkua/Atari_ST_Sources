#ifndef __FSYM
#define __FSYM

#ifndef __GWINDOWS
#include "gwindows.h"
#endif


void traite_symetrie(GEM_WINDOW *gwnd) ;


#endif
