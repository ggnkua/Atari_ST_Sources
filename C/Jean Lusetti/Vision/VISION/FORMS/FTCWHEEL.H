#ifndef __FTCWHEEL
#define __FTCWHEEL

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

void ReleaseTCWheel(void) ;
void traite_24bitspal(GEM_WINDOW *gwnd) ;

#endif
