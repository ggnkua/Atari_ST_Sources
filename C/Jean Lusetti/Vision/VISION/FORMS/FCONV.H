#ifndef __FCONV
#define __FCONV

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

void traite_conversion(GEM_WINDOW *gwnd) ;


#endif
