#ifndef __FTIFF
#define __FTIFF

#if !defined(__IMAGE_IO)
#include "..\tools\image_io.h"
#endif

int tiff_options(INFO_IMAGE *inf) ;


#endif
