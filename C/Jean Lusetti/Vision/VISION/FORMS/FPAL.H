#ifndef __FPAL
#define __FPAL

#ifndef __GWINDOWS
#include "gwindows.h"
#endif

void traite_makepalette(GEM_WINDOW *gwnd) ;


#endif
