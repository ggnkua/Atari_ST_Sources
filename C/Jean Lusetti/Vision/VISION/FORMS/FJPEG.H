#ifndef __FJPEG
#define __FJPEG

#if !defined(__IMAGE_IO)
#include "..\tools\image_io.h"
#endif

int jpeg_options(INFO_IMAGE *inf) ;


#endif
