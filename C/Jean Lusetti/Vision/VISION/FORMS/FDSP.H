#ifndef __FDSP
#define __FDSP

void pref_dsp(void) ;


#endif
