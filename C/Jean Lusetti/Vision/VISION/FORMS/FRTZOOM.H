#ifndef __FRTZOOM
#define __FRTZOOM

#ifndef __RTZOOM
#include  "rtzoom.h"
#endif

int pref_rtzoom(void) ;


#endif
