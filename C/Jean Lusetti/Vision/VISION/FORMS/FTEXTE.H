#ifndef __FTEXTE
#define __FTEXTE

void traite_ptexte(void) ;


#endif
