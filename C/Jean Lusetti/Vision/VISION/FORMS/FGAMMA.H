#ifndef __FGAMMA
#define __FGAMMA

#ifndef __GWINDOWS
#include "gwindows.h"
#endif

void traite_gamma(GEM_WINDOW *gwnd) ;


#endif
