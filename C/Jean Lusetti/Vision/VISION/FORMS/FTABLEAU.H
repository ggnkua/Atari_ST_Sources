#ifndef __FTABLEAU
#define __FTABLEAU

int get_tableau(int *w, int *h) ;

#endif
