#ifndef __FEHTML
#define __FEHTML

void HTMLCatalogExport(long first, long last) ;

#endif
