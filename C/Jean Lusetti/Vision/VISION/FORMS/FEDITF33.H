#ifndef __FEDITF33
#define __FEDITF33

#if !defined(__CONVOLUTION)
#include "..\tools\convol.h"
#endif

void edit_3x3filter(CONVOLUTION_FILTRE *in_filter) ;


#endif
