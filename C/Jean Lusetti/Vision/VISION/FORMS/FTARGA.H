#ifndef __FTARGA
#define __FTARGA

#if !defined(__IMAGE_IO)
#include "..\tools\image_io.h"
#endif

int targa_options(INFO_IMAGE *inf) ;


#endif
