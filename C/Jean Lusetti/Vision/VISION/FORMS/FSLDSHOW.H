#ifndef __FSLDSHOW
#define __FSLDSHOW

void pref_sldshow(void) ;


#endif
