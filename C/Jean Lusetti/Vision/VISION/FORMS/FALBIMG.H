#ifndef __FALBIMG
#define __FALBIMG

void show_imginfo(long index, char *img_comment) ;

#endif
