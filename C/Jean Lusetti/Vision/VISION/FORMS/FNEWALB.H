#ifndef __FNEWALB
#define __FNEWALB

int get_newalbum(char *name) ;


#endif
