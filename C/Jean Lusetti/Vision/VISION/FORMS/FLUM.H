#ifndef __FLUM
#define __FLUM

#ifndef __GWINDOWS
#include "gwindows.h"
#endif


void traite_lumiere(GEM_WINDOW *gwnd) ;


#endif
