#ifndef __FTAILLE
#define __FTAILLE

#ifndef __GWINDOWS
#include "gwindows.h"
#endif

void traite_taille(GEM_WINDOW *gwnd) ;


#endif
