#ifndef __FWPAL
#define __FWPAL

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

#define SETPALINDEX_CLASSNAME "CN_SELPALINDEX"
void traite_selpalindex(GEM_WINDOW *wnd) ;


#endif
