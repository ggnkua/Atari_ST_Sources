#ifndef __FINPUTTEXT
#define __FINPUTTEXT

#define NB_TEXTS   4

int input_text(char texts[NB_TEXTS][100]) ;

#endif
