#ifndef __FPENCIL
#define __FPENCIL

void traite_ppinceau(void) ;


#endif
