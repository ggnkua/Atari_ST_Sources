#ifndef __FAPPLYLDV
#define __FAPPLYLDV

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

#ifndef __LDVCOM
#include "..\ldv\ldvcom.h"
#endif

int ApplyLDV(LDV_MODULE *ldv, GEM_WINDOW *wnd,LDV_PARAMS *params) ;


#endif
