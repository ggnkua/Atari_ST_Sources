#ifndef __FUNDO
#define __FUNDO

void pref_undo(void) ;


#endif
