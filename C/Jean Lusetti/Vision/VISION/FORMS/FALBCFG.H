#ifndef __FALBCFG
#define __FALBCFG

int album_config(void) ;

#endif
