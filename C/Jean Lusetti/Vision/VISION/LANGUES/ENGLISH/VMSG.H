/* Indice du ressource pour VMSG */

#define FORM_MESSAGES 0   /* Formulaire/Dialogue */
#define MSG_FILENOTEXIST 1   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NOMOREWINDOW 2   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_WRITEERROR 3   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ERRFORMAT 4   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DECOMPRESERR 5   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ERRIMGFMT 6   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNKNOWNFMT 7   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNKNOWNSAVE 8   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NOIMG 9   /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NOWINDOW 10  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_WARNPASTE 11  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NOTOOLZ 12  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_INFOBAR 13  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NOPALETTE 14  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_COLORERROR 15  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ZOOMFILL 16  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNDOERROR 17  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNDOIMG 18  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UUNDO 19  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_FMTNOSUPPORT 20  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNKNOWNCOMP 21  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_FILEEXISTS 22  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_IMAGECHANGE 23  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_RESOLSCREEN 24  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_IMGNOTSAVED 25  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DECNPLAN 26  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_REGSUCCES 27  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PALETTEDISPO 28  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PIXEL 29  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CM   30  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_MM   31  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POUCE 32  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LH   33  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_XYLH 34  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_RVB  35  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_RVBI 36  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_XY   37  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_R    38  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_FILL 39  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CERCLE 40  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_RECTANGLE 41  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CALCULZOOM 42  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CLICCOULEUR 43  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DECODAGELZW 44  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DECODAGEPCB 45  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TRSFFMTSTD 46  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ENCODAGELZW 47  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CALCREDUC 48  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_GDOS 49  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_INITTC 50  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_WFNAMES 51  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_REGISTER 52  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TAILLE 53  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TITREOUTIL 54  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_FILTRE 55  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LOOKFILTERS 56  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LOOKSPDDRV 57  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNDO 58  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UPOINT 59  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UTRACE 60  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UAEROSOL 61  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ULIGNE 62  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ULIGNES 63  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UCERCLE 64  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UDISQUE 65  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_URECT 66  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UPLAN 67  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UTEXTE 68  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UPEINT 69  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UEFFACE 70  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UCOUPE 71  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UCOLLE 72  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UGOMME 73  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UREFAIRE 74  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNEGATIF 75  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UTAB 76  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_USYMX 77  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_USYMY 78  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_USYMXY 79  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UPINCEAU 80  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ULUMIERE 81  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UGAMMA 82  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UFILTRE 83  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UROTATION 84  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UTAILLE 85  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UCONVERT 86  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UNEGLASSO 87  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ULDV 88  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UEND 89  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LOADINGIMG 90  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_SAVINGIMG 91  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVPINVALID 92  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVNBPLANES 93  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVMEMORY 94  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVNOPREV 95  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVRUN 96  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVVAPI 97  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVIMGFMT 98  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ELDVGENERAL 99  /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PNOGDOS 100 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PWRITERR 101 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PTIMEOUT 102 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PNOHANDLE 103 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PNODRIVER 104 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DITHER 105 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ROTATING 106 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DOGDOSIMG 107 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PRINTING 108 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CHANGELNG 109 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPOINT 110 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HTRACE 111 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPINCEAU 112 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HAEROSOL 113 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HKLIGNES 114 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HLIGNE 115 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HCERCLE 116 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HRECTANGLE 117 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HDISQUE 118 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPLAN 119 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPEINTURE 120 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HGOMME 121 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HTEXTE 122 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HLOUPE 123 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HTEMP 124 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HTABLEAU 125 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HMAIN 126 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HBLOC 127 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPALETTE 128 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HZONE 129 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DSPLOCK 130 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BADFILTER 131 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_FNBCOLORS 132 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DSPISLOCKED 133 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BADLOD 134 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DSPNOLOD 135 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NOJPEGDRIVER 136 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CPNONE 137 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CPMINI 138 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CPMAXI 139 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DITHERAUTO 140 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DITHERMAT 141 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_DITHERGREY 142 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ADDCAT 143 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ERRSEEFILE 144 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATAHEADER 145 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ERRCATADD 146 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATAMEM 147 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATADATA 148 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATAFMT 149 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATACOMPRESS 150 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATADSPDRV 151 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATADSPLCK 152 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATACANCEL 153 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATAEXIST 154 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BCONVERR 155 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ERRCONV 156 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BCONVOUTERR 157 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BCONVDELERR 158 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BCONVMOVEERR 159 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATAEND 160 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BCONV 161 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LOADCATALOG 162 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATENEW 163 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_UPDATECAT 164 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATBADVER 165 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATERRMINOR 166 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATADDERR 167 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATITEMEXIST 168 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NEWCAT 169 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMNEW 170 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMOPEN 171 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMINFOS 172 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMREMOVE 173 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMADD 174 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMADDF 175 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMLOAD 176 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMCONFIG 177 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMUPDATE 178 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMCAT 179 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMIMG 180 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMPAL 181 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HALMTOVSS 182 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HACONFV2M 183 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HACONFM2V 184 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HACONFINDEX 185 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HACONFSHIFT 186 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HACONFVIS 187 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HACONFMASK 188 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFFULLSCR 189 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFQUIT 190 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFCLIP 191 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFINFO 192 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFMOUSE 193 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFHELP 194 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HLONGFNAME 195 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFUNDOS 196 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFDSP 197 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFPATH 198 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFSSHOW 199 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFDITHER 200 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSTDVDI 201 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HPREFGEMP 202 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSPLASH 203 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CATINFO 204 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HISTO 205 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CALCLASSO 206 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_XYLASSO 207 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_YES  208 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NO   209 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PRINTCOLOR 210 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PRINTBW 211 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TRANSIT0 212 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TRANSIT1 213 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TRANSIT2 214 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TRANSIT3 215 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_SAVEVSS 216 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_NOIR 217 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BLANC 218 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPOPEN 219 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPMAX 220 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPPALETTE 221 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPINFO 222 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPSAVE 223 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPSAVEAS 224 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPCLOSE 225 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPRUN 226 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_POPLDV 227 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BCONVDIT 228 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_BCONVCAN 229 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_VSSERRCMDU 230 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHTRANSIT 231 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHWAITMINI 232 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHNOTIMER 233 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHAFFREDUC 234 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHAFFZOOM 235 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHCLS 236 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHCYCLE 237 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHAFFNAME 238 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HSSHAFFPROG 239 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_TITRERTZOOM 240 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_MULTIMG 241 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PLOADIMG 242 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PIMGINFO 243 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_PEHTML 244 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_EHTML 245 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HIBOPEN 246 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HIBPREV 247 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HIBNEXT 248 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HIBSCALE 249 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HIBEDIT 250 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HIBPRINT 251 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_HIBDELETE 252 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_CONFIRMDEL 253 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LDVSTDFMT 254 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LDVATARIFMT 255 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LDVSPECFMT 256 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LDVSUPPROG 257 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_LDVSUPPREV 258 /* STRING dans l'arbre FORM_MESSAGES */
#define MSG_ENDLIST 259 /* STRING dans l'arbre FORM_MESSAGES */
