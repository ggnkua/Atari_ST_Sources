#ifndef __IMGLFMT
#define __IMGLFMT

typedef long IID ;

#define IID_UNKNOWN     0
#define IID_JPEG    'JPG'
#define IID_PNG     'PNG'
#define IID_TIFF    'TIF'
#define IID_GIF     'GIF'
#define IID_TARGA   'TGA'
#define IID_BMP     'BMP'
#define IID_IMG     'IMG'
#define IID_ART     'ART'
#define IID_NEO     'NEO'
#define IID_MAC     'MAC'
#define IID_DEGAS   'DEG'
#define IID_HEXDUMP 'HEX'

#define IID_ME      '_ME'

#endif
