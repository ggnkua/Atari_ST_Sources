#ifndef __STDINPUT
#define __STDINPUT

void stdinput_fix(void) ;
void std_input(char *title, char *text, char *txt_cancel) ;

#endif