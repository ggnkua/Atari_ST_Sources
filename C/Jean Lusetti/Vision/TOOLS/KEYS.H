#ifndef __KEYS
#define __KEYS

#define F1          0x3B00
#define F2          0x3C00
#define F3          0x3D00
#define F4          0x3E00
#define F5          0x3F00
#define F6          0x4000
#define F7          0x4100
#define F8          0x4200
#define F9          0x4300
#define F10         0x4400
#define SF1         0x5400
#define SF2         0x5500
#define SF3         0x5600
#define SF4         0x5700
#define SF5         0x5800
#define SF6         0x5900
#define SF7         0x5A00
#define SF8         0x5B00
#define SF9         0x5C00
#define SF10        0x5D00

#define CURSOR_UP   0x4800
#define CURSOR_SUP  0x4838
#define CURSOR_DN   0x5000
#define CURSOR_SDN  0x5032
#define CURSOR_LT   0x4B00
#define CURSOR_SLT  0x4B34
#define CURSOR_RT   0x4D00
#define CURSOR_SRT  0x4D36

#endif