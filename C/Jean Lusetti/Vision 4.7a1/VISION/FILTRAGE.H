/***********************************************/
/*                  FILTRAGE.H                 */
/***********************************************/
#if !defined __FILTRAGE
#define __FILTRAGE

void traite_convolution(GEM_WINDOW *gwnd) ;

#endif
