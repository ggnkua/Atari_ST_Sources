#ifndef __FPAL
#define __FPAL

#ifndef __GWINDOWS_H
#include "gwindows.h"
#endif

void traite_makepalette(GEM_WINDOW *gwnd) ;


#endif
