#ifndef __FCONV
#define __FCONV

#ifndef __GWINDOWS_H
#include "..\tools\gwindows.h"
#endif

void traite_conversion(GEM_WINDOW *gwnd) ;


#endif
