#ifndef __FNEWALB
#define __FNEWALB

HCAT get_newalbum(char *name, int* status) ;


#endif
