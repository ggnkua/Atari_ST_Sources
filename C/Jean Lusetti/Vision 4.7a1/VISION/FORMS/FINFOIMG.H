#ifndef __FINFOIMG
#define __FINFOIMG

#ifndef __GWINDOWS_H
#include "..\tools\gwindows.h"
#endif

void traite_info(GEM_WINDOW *gwnd) ;


#endif
