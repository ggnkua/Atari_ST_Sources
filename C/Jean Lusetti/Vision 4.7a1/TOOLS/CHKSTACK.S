.EXPORT sGetSP

*
*  long sGetSP(void)
*
sGetSP:
  MOVE.L SP,D0
  RTS
