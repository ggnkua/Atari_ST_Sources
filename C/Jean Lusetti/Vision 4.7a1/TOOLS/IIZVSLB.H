#ifndef __IIZVSLB_H
#define __IIZVSLB_H

#include "imgmodul.h"

short iizvslb_init(IMG_MODULE* img_module) ; /* Fill in IMG_MODULE structure */
void  iizviewSLB_GetDrvCaps(IMG_MODULE* ImgModule, INFO_IMAGE_DRIVER* caps) ;

#endif
