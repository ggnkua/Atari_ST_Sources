/* Indice du ressource pour BULLE */

#define FORM_BULLE 0   /* Formulaire/Dialogue */
