#ifndef __RZOOM
#define RZOOM

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

int RasterZoom(MFDB *in, MFDB *out,GEM_WINDOW *wprog) ;


#endif
