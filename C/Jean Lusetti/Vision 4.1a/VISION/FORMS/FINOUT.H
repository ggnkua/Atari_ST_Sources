#ifndef __FINOUT
#define __FINOUT

#ifndef __FDECOUP
#include "fdecoup.h"
#endif

long get_format(DECOUP *decoup, int flag_out) ;


#endif
