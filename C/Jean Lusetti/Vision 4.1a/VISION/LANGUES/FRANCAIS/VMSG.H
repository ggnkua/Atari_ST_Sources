/* Indice du ressource pour VMSG */

#define MSG_FILENOTEXIST 1  
#define MSG_NOMOREWINDOW 2  
#define MSG_WRITEERROR 3  
#define MSG_ERRFORMAT 4  
#define MSG_DECOMPRESERR 5  
#define MSG_ERRIMGFMT 6  
#define MSG_UNKNOWNFMT 7  
#define MSG_UNKNOWNSAVE 8  
#define MSG_NOIMG 9  
#define MSG_FREE1 10 
#define MSG_WARNPASTE 11 
#define MSG_NOTOOLZ 12 
#define MSG_FREE2 13 
#define MSG_FREE3 14 
#define MSG_COLORERROR 15 
#define MSG_ZOOMFILL 16 
#define MSG_UNDOERROR 17 
#define MSG_UNDOIMG 18 
#define MSG_UUNDO 19 
#define MSG_FMTNOSUPPORT 20 
#define MSG_UNKNOWNCOMP 21 
#define MSG_FILEEXISTS 22 
#define MSG_IMAGECHANGE 23 
#define MSG_RESOLSCREEN 24 
#define MSG_FREE4 25 
#define MSG_DECNPLAN 26 
#define MSG_FREE5 27 
#define MSG_PALETTEDISPO 28 
#define MSG_PIXEL 29 
#define MSG_FREE6  30 
#define MSG_FREE7   31 
#define MSG_FREE8 32 
#define MSG_LH   33 
#define MSG_XYLH 34 
#define MSG_RVB  35 
#define MSG_RVBI 36 
#define MSG_XY   37 
#define MSG_R    38 
#define MSG_FILL 39 
#define MSG_CERCLE 40 
#define MSG_RECTANGLE 41 
#define MSG_CALCULZOOM 42 
#define MSG_FREE9 43 
#define MSG_DECODAGELZW 44 
#define MSG_DECODAGEPCB 45 
#define MSG_TRSFFMTSTD 46 
#define MSG_ENCODAGELZW 47 
#define MSG_CALCREDUC 48 
#define MSG_FREE10 49 
#define MSG_FREE11 50 
#define MSG_WFNAMES 51 
#define MSG_FREE12 52 
#define MSG_TAILLE 53 
#define MSG_TITREOUTIL 54 
#define MSG_FILTRE 55 
#define MSG_LOOKFILTERS 56 
#define MSG_LOOKSPDDRV 57 
#define MSG_UNDO 58 
#define MSG_UPOINT 59 
#define MSG_UTRACE 60 
#define MSG_UAEROSOL 61 
#define MSG_ULIGNE 62 
#define MSG_ULIGNES 63 
#define MSG_UCERCLE 64 
#define MSG_UDISQUE 65 
#define MSG_URECT 66 
#define MSG_UPLAN 67 
#define MSG_UTEXTE 68 
#define MSG_UPEINT 69 
#define MSG_UEFFACE 70 
#define MSG_UCOUPE 71 
#define MSG_UCOLLE 72 
#define MSG_UGOMME 73 
#define MSG_UREFAIRE 74 
#define MSG_UNEGATIF 75 
#define MSG_UTAB 76 
#define MSG_USYMX 77 
#define MSG_USYMY 78 
#define MSG_USYMXY 79 
#define MSG_UPINCEAU 80 
#define MSG_ULUMIERE 81 
#define MSG_UGAMMA 82 
#define MSG_UFILTRE 83 
#define MSG_UROTATION 84 
#define MSG_UTAILLE 85 
#define MSG_UCONVERT 86 
#define MSG_UNEGLASSO 87 
#define MSG_ULDV 88 
#define MSG_UEND 89 
#define MSG_LOADINGIMG 90 
#define MSG_SAVINGIMG 91 
#define MSG_ELDVPINVALID 92 
#define MSG_ELDVNBPLANES 93 
#define MSG_ELDVMEMORY 94 
#define MSG_ELDVNOPREV 95 
#define MSG_ELDVRUN 96 
#define MSG_ELDVVAPI 97 
#define MSG_ELDVIMGFMT 98 
#define MSG_ELDVGENERAL 99 
#define MSG_PNOGDOS 100
#define MSG_PWRITERR 101
#define MSG_PTIMEOUT 102
#define MSG_PNOHANDLE 103
#define MSG_PNODRIVER 104
#define MSG_DITHER 105
#define MSG_ROTATING 106
#define MSG_DOGDOSIMG 107
#define MSG_PRINTING 108
#define MSG_CHANGELNG 109
#define MSG_HPOINT 110
#define MSG_HTRACE 111
#define MSG_HPINCEAU 112
#define MSG_HAEROSOL 113
#define MSG_HKLIGNES 114
#define MSG_HLIGNE 115
#define MSG_HCERCLE 116
#define MSG_HRECTANGLE 117
#define MSG_HDISQUE 118
#define MSG_HPLAN 119
#define MSG_HPEINTURE 120
#define MSG_HGOMME 121
#define MSG_HTEXTE 122
#define MSG_HLOUPE 123
#define MSG_HTEMP 124
#define MSG_HTABLEAU 125
#define MSG_HMAIN 126
#define MSG_HBLOC 127
#define MSG_HPALETTE 128
#define MSG_HZONE 129
#define MSG_DSPLOCK 130
#define MSG_BADFILTER 131
#define MSG_FNBCOLORS 132
#define MSG_DSPISLOCKED 133
#define MSG_BADLOD 134
#define MSG_DSPNOLOD 135
#define MSG_NOJPEGDRIVER 136
#define MSG_CPNONE 137
#define MSG_CPMINI 138
#define MSG_CPMAXI 139
#define MSG_DITHERAUTO 140
#define MSG_DITHERMAT 141
#define MSG_DITHERGREY 142
#define MSG_ADDCAT 143
#define MSG_ERRSEEFILE 144
#define MSG_CATAHEADER 145
#define MSG_ERRCATADD 146
#define MSG_CATAMEM 147
#define MSG_CATADATA 148
#define MSG_CATAFMT 149
#define MSG_CATACOMPRESS 150
#define MSG_CATADSPDRV 151
#define MSG_CATADSPLCK 152
#define MSG_CATACANCEL 153
#define MSG_CATAEXIST 154
#define MSG_BCONVERR 155
#define MSG_ERRCONV 156
#define MSG_BCONVOUTERR 157
#define MSG_FREE13 158
#define MSG_BCONVMOVERR 159
#define MSG_CATAEND 160
#define MSG_BCONV 161
#define MSG_LOADCATALOG 162
#define MSG_CATENEW 163
#define MSG_UPDATECAT 164
#define MSG_CATBADVER 165
#define MSG_CATERRMINOR 166
#define MSG_CATADDERR 167
#define MSG_CATITEMEXIST 168
#define MSG_NEWCAT 169
#define MSG_HALMNEW 170
#define MSG_HALMOPEN 171
#define MSG_HALMINFOS 172
#define MSG_HALMREMOVE 173
#define MSG_HALMADD 174
#define MSG_HALMADDF 175
#define MSG_HALMLOAD 176
#define MSG_HALMCONFIG 177
#define MSG_HALMUPDATE 178
#define MSG_HALMCAT 179
#define MSG_HALMIMG 180
#define MSG_HALMPAL 181
#define MSG_HALMTOVSS 182
#define MSG_HACONFV2M 183
#define MSG_HACONFM2V 184
#define MSG_HACONFINDEX 185
#define MSG_HACONFSHIFT 186
#define MSG_HACONFVIS 187
#define MSG_HACONFMASK 188
#define MSG_HPREFFULLSCR 189
#define MSG_HPREFQUIT 190
#define MSG_HPREFCLIP 191
#define MSG_HPREFINFO 192
#define MSG_HPREFMOUSE 193
#define MSG_HPREFHELP 194
#define MSG_HLONGFNAME 195
#define MSG_FREE14 196
#define MSG_HPREFDSP 197
#define MSG_HPREFPATH 198
#define MSG_FREE15 199
#define MSG_HPREFDITHER 200
#define MSG_HDITHERAUTO 201
#define MSG_HPREFGEMP 202
#define MSG_HSPLASH 203
#define MSG_CATINFO 204
#define MSG_HISTO 205
#define MSG_CALCLASSO 206
#define MSG_XYLASSO 207
#define MSG_YES  208
#define MSG_NO   209
#define MSG_PRINTCOLOR 210
#define MSG_PRINTBW 211
#define MSG_TRANSIT0 212
#define MSG_TRANSIT1 213
#define MSG_TRANSIT2 214
#define MSG_TRANSIT3 215
#define MSG_SAVEVSS 216
#define MSG_NOIR 217
#define MSG_BLANC 218
#define MSG_POPOPEN 219
#define MSG_POPMAX 220
#define MSG_POPPALETTE 221
#define MSG_POPINFO 222
#define MSG_POPSAVE 223
#define MSG_POPSAVEAS 224
#define MSG_POPCLOSE 225
#define MSG_POPRUN 226
#define MSG_POPLDV 227
#define MSG_BCONVDIT 228
#define MSG_BCONVCAN 229
#define MSG_VSSERRCMDU 230
#define MSG_HSSHTRANSIT 231
#define MSG_HSSHWAITMINI 232
#define MSG_HSSHNOTIMER 233
#define MSG_HSSHAFFREDUC 234
#define MSG_HSSHAFFZOOM 235
#define MSG_HSSHCLS 236
#define MSG_HSSHCYCLE 237
#define MSG_HSSHAFFNAME 238
#define MSG_HSSHAFFPROG 239
#define MSG_TITRERTZOOM 240
#define MSG_MULTIMG 241
#define MSG_PLOADIMG 242
#define MSG_PIMGINFO 243
#define MSG_PEHTML 244
#define MSG_EHTML 245
#define MSG_HIBOPEN 246
#define MSG_HIBPREV 247
#define MSG_HIBNEXT 248
#define MSG_HIBSCALE 249
#define MSG_HIBEDIT 250
#define MSG_HIBPRINT 251
#define MSG_HIBDELETE 252
#define MSG_CONFIRMDEL 253
#define MSG_LDVSTDFMT 254
#define MSG_LDVATARIFMT 255
#define MSG_LDVSPECFMT 256
#define MSG_LDVSUPPROG 257
#define MSG_LDVSUPPREV 258
#define MSG_QCATUPTINI 259
#define MSG_CATUPTINI 260
#define MSG_HPLBYTE 261
#define MSG_HPLWORD 262
#define MSG_HPLLONG 263
#define MSG_HPLMIXED 264
#define MSG_HPLFIND 265
#define MSG_HPLFINDNEXT 266
#define MSG_SPTITLE 267
#define MSG_SPHEXLABEL 268
#define MSG_SPSTRLABEL 269
#define MSG_SPSTRCAPS 270
#define MSG_SPCOUNT 271
#define MSG_CANCEL 272
#define MSG_WRAPAROUND 273
#define MSG_ASKUPGCATALOG 274
#define MSG_UPGCATALOG 275
#define MSG_ERRUPGCATALOG 276
#define MSG_CATDELICON 277
#define MSG_CATSDELICON 278
#define MSG_CATSDELREC 279
#define MSG_CATSDELRECIMG 280
#define MSG_WASALL 281
#define MSG_WADELICONS 282
#define MSG_WADELFILES 283
#define MSG_ENDLIST 284
