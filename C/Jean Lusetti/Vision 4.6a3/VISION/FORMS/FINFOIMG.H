#ifndef __FINFOIMG
#define __FINFOIMG

#ifndef __GWINDOWS
#include "..\tools\gwindows.h"
#endif

void traite_info(GEM_WINDOW *gwnd) ;


#endif
