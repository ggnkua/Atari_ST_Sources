#ifndef __FALBCFG
#define __FALBCFG

int album_config(HCAT hCat) ;

#endif
