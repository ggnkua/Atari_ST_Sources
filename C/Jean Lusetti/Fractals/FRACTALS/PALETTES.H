extern char path_palette[200] ;

int cdecl draw_currentcolor(PARMBLK *parmblock) ;
int cdecl draw_colors(PARMBLK *parmblock) ;
