/********************************************************/
/*------------------- TOUCHES.H ------------------------*/
/* Touches dВclenchant les options des menus dВroulants */
/********************************************************/

#define NOUVEAU  0x310E      /* CTRL-N */
#define OUVRIR   0x180F      /* CTRL-O */
#define FERMER   0x2C17      /* CTRL-W */
#define SAUVE    0x1F13      /* CTRL-S */
#define SAUVES   0x1312      /* CTRL-R */
#define COPIER   0x2E03      /* CTRL-C */
#define EXPORT   0x1205      /* CTRL-E */
#define IMPRIMER 0x1910      /* CTRL-P */
#define QUITTER  0x1E11      /* CTRL-Q */

#define ZOOMC    0x2F16      /* CTRL-V */
#define ZOOMF    0x2106      /* CTRL-F */
#define CALCULER 0x260C      /* CTRL-L */
#define LINIT    0x2308      /* CTRL-H */
#define INIT     0x1709      /* CTRL-I */
#define DUPLIQUE 0x2004      /* CTRL-D */
#define TAILLE   0x1414      /* CTRL-T */
#define PALETTE  0x3002      /* CTRL-B */
#define INFOF    0x1001      /* CTRL-A */
#define REPORT   0x270D      /* CTRL-M */
#define CYCLING1 0x2F16      /* CTRL-V */
#define CYCLING2 0x3002      /* CTRL-B */
#define PREFS    0x2207      /* CTRL-G */
