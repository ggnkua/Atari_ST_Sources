#ifndef __IIZVIEW_H
#define __IIZVIEW_H


int iizview_init(IMG_MODULE* img_module) ; /* Fill in IMG_MODULE structure */

#endif
