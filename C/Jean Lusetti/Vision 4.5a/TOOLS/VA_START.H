#ifndef __VA_START
#define __VA_START

#define WM_VASTART  0x4711

char *GetNextVaStartFileName(char *start_pos, char *filename) ;

#endif
