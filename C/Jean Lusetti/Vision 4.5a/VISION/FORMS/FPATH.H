#ifndef __FPATH
#define __FPATH

void get_paths(void) ;


#endif
