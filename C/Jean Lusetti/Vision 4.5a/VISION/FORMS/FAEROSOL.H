#ifndef __FAEROSOL
#define __FAEROSOL

void traite_paerosol(void) ;


#endif
