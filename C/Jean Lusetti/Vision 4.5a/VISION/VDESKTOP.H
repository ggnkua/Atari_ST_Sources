/* Indice du ressource pour VDESKTOP */

#define FORM_ICON 0   /* Formulaire/Dialogue */
