#ifndef __CRC_H
#define __CRC_H

#include <stddef.h>

unsigned long simple_crc(void* buffer, size_t nb_bytes) ;

#endif