#ifndef __INT_REV_H
#define __INT_REV_H

unsigned short int_reverse(unsigned short n) ;
unsigned long  long_reverse(unsigned long n) ;

#endif