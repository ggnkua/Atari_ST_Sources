/* Indice du ressource pour STD */

#define FORM_PROG 0   /* Formulaire/Dialogue */
#define PROG_DSPON 1   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TITRE1 2   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TITRE2 3   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TITRE3 4   /* TEXT dans l'arbre FORM_PROG */
#define PROG_TOTALPC 5   /* BOX dans l'arbre FORM_PROG */
#define PROG_PC  6   /* BOX dans l'arbre FORM_PROG */
#define PROG_TPC 9   /* TEXT dans l'arbre FORM_PROG */
#define PROG_030 11  /* TEXT dans l'arbre FORM_PROG */
#define PROG_TPCTXT 12  /* TEXT dans l'arbre FORM_PROG */
#define PROG_FPU 13  /* TEXT dans l'arbre FORM_PROG */
#define PROG_REMAIN 14  /* TEXT dans l'arbre FORM_PROG */

#define FORM_INPUT 1   /* Formulaire/Dialogue */
#define INPUT_TITLE 1   /* TEXT dans l'arbre FORM_INPUT */
#define INPUT_TEXT 2   /* FTEXT dans l'arbre FORM_INPUT */
#define INPUT_OK 3   /* BUTTON dans l'arbre FORM_INPUT */
#define INPUT_CANCEL 4   /* BUTTON dans l'arbre FORM_INPUT */

#define FORM_MLINES 2   /* Formulaire/Dialogue */
#define MLINES_FIRSTMSG 1   /* FTEXT dans l'arbre FORM_MLINES */
#define MLINES_LASTMSG 8   /* FTEXT dans l'arbre FORM_MLINES */
#define MLINES_OK 9   /* BUTTON dans l'arbre FORM_MLINES */
#define MLINES_CANCEL 10  /* BUTTON dans l'arbre FORM_MLINES */
#define MLINES_TEMPLATES 11  /* BUTTON dans l'arbre FORM_MLINES */

#define FORM_SPATTERN 3   /* Formulaire/Dialogue */
#define SP_TITLE 1   /* TEXT dans l'arbre FORM_SPATTERN */
#define SP_HEXLABEL 2   /* TEXT dans l'arbre FORM_SPATTERN */
#define SP_HEX   3   /* BOX dans l'arbre FORM_SPATTERN */
#define SP_HEXT  4   /* FTEXT dans l'arbre FORM_SPATTERN */
#define SP_STRLABEL 5   /* TEXT dans l'arbre FORM_SPATTERN */
#define SP_STRING 6   /* BOX dans l'arbre FORM_SPATTERN */
#define SP_STRT  7   /* FTEXT dans l'arbre FORM_SPATTERN */
#define SP_STRCAPS 8   /* TEXT dans l'arbre FORM_SPATTERN */
#define SP_BSTRCAPS 9   /* BOX dans l'arbre FORM_SPATTERN */
#define SP_COUNT 10  /* TEXT dans l'arbre FORM_SPATTERN */
#define SP_BCOUNT 11  /* BOX dans l'arbre FORM_SPATTERN */
#define SP_OK    12  /* BUTTON dans l'arbre FORM_SPATTERN */
#define SP_CANCEL 13  /* BUTTON dans l'arbre FORM_SPATTERN */
#define SP_BWRAPAROUND 14  /* BOX dans l'arbre FORM_SPATTERN */
#define SP_WRAPAROUND 15  /* TEXT dans l'arbre FORM_SPATTERN */
