#ifndef __EXECV_H
#define __EXECV_H

long execv(char* childname, char* args[]) ;

#endif
