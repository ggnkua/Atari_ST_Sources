#ifndef __AIDES__H
#define __AIDES__H

int  bulle_aide(int m_x, int m_y, char* txt) ;
int  BHelpInit(void) ;
void BHelpExit(void) ;

#endif