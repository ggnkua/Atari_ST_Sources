#ifndef __PRINT_DIALOG_H
#define __PRINT_DIALOG_H

/* Extracted from VISION.H to avoid including VISION.H or DEFS.H in TOOLS */
/* Make sure to have this file in sync with VISION.H !                    */

#define FORM_PRINT 21  /* Formulaire/Dialogue */
#define PRINT_GROUP 1   /* BOX dans l'arbre FORM_PRINT */
#define PRINT_PAGE 2   /* BOX dans l'arbre FORM_PRINT */
#define PRINT_IMAGE 3   /* BOX dans l'arbre FORM_PRINT */
#define PRINT_XPCMOINS 6   /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_YPCMOINS 7   /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_XPC 9   /* FBOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_YPC 10  /* FBOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_OK 13  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_XPCPLUS 14  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_YPCPLUS 15  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_SIZEX 16  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_SIZEY 17  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_RESOL 18  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_CANCEL 23  /* BUTTON dans l'arbre FORM_PRINT */
#define PRINT_SIZEPAGEW 24  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_CONFIGPAGE 25  /* BOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_SIZEPAGEH 28  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_ID 29  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TYPE 32  /* BOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_PRINTER 34  /* BOXTEXT dans l'arbre FORM_PRINT */
#define PRINT_CENTREY 36  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_CENTREX 37  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_R90 38  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_KEEPRATIO 39  /* BOX dans l'arbre FORM_PRINT */
#define PRINT_TKEEPRATIO 40  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TCENTREY 41  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TCENTREX 42  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_TR90 43  /* TEXT dans l'arbre FORM_PRINT */
#define PRINT_FILE 45  /* BOXTEXT dans l'arbre FORM_PRINT */

#endif