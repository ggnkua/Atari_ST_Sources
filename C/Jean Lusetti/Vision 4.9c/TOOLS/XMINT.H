#ifndef __XMINT
#define  __XMINT

int CreateThread(int (*ThreadProc)(void *param), void *param) ;

#endif
