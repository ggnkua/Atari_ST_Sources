#ifndef __FLDVDETAILS
#define __FLDVDETAILS

void LDVDetails(LDV_MODULE *ldv_module) ;


#endif
