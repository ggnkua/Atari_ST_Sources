#ifndef __FHISTO
#define __FHISTO

#ifndef __GWINDOWS_H
#include "gwindows.h"
#endif

void traite_histo(GEM_WINDOW* gwnd) ;


#endif
