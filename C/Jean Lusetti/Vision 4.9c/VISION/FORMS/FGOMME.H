#ifndef __FGOMME
#define __FGOMME

void traite_pgomme(void) ;


#endif
