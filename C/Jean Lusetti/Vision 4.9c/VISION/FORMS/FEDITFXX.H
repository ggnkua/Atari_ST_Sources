#ifndef __FEDITFXX
#define __FEDITFXX

#ifndef __CONVOL_H)
#include "..\tools\convol.h"
#endif

void edit_filterxx(CONVOLUTION_FILTRE* in_filter, short size) ;


#endif
