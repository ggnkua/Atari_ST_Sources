#ifndef __FTCWHEEL_H
#define __FTCWHEEL_H

#ifndef __GWINDOWS_H
#include "..\tools\gwindows.h"
#endif

void ReleaseTCWheel(void) ;
void traite_24bitspal(GEM_WINDOW* gwnd) ;

#endif
