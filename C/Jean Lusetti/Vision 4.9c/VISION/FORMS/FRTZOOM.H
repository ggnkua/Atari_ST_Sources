#ifndef __FRTZOOM_H
#define __FRTZOOM_H

#ifndef __RTZOOM_H
#include  "rtzoom.h"
#endif

int pref_rtzoom(void) ;


#endif
