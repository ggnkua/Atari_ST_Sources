#ifndef __FALBIMG
#define __FALBIMG

void show_imginfo(HCAT hCat, long index, char *img_comment) ;

#endif
