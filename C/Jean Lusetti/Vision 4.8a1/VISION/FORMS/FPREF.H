#ifndef __FPREF
#define __FPREF

void traite_preferences(void) ;


#endif
