#ifndef __FEHTML
#define __FEHTML

void HTMLCatalogExport(HCAT hCat, long first, long last) ;

#endif
