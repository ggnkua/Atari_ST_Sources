#ifndef __FTAILLE
#define __FTAILLE

#ifndef __GWINDOWS_H
#include "gwindows.h"
#endif

void traite_taille(GEM_WINDOW* gwnd) ;


#endif
