/***********************/
/* Header de FULLSCR.C */
/***********************/
#ifndef __FULLSCR
#define __FULLSCR

#ifndef __GWINDOWS_H
#include "..\tools\gwindows.h"
#endif

void pleine_page(GEM_WINDOW* gwnd) ;
void traite_pleinecran(GEM_WINDOW* gwnd) ;

#endif