#ifndef __FBARATIN
#define __FBARATIN

#ifndef __GWINDOWS_H
#include "..\tools\gwindows.h"
#endif

void       display_baratin(char high_res) ;
GEM_WINDOW* display_splash(char high_res) ;

#endif
