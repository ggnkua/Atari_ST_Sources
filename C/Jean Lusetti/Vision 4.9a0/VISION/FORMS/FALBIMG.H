#ifndef __FALBIMG_H
#define __FALBIMG_H

void show_imginfo(HCAT hCat, long index, char *img_comment) ;

#endif
