struct SYSLIB
{
	char	name[17];
	char	fnc;
	char	trap;
	char	size;
}	syslib[] =
{
	"GETMPB",0,13,6,
	"BCONSTAT",1,13,4,
	"BCONIN",2,13,4,
	"BCONOUT",3,13,6,
	"RWABS",4,13,14,
	"SETEXE",5,13,8,
	"TICKALL",6,13,2,
	"GETBPB",7,13,4,
	"BCOSTAT",8,13,4,
	"MEDIACH",9,13,4,
	"DRVMAP",10,13,2,
	"KBSHIFT",11,13,4,
	"INITMOUS",0,14,12,
	"SSBRK",1,14,6,
	"PHYSBASE",2,14,2,
	"LOGBASE",3,14,2,
	"GETREZ",4,14,2,
	"SETSCREEN",5,14,12,
	"SETPALETTE",6,14,6,
	"SETCOLOR",7,14,6,
	"FLOPRD",8,14,20,
	"FLOPWR",9,14,20,
	"FLOPFMT",10,14,26,
	"MIDIWS",12,14,8,
	"MFPINT",13,14,8,
	"IOREC",14,14,4,
	"RSCONF",15,14,14,
	"KEYTBL",16,14,14,
	"RANDOM",17,14,2,
	"PROTOPT",18,14,14,
	"FLOPVER",19,14,20,
	"SCRDMP",20,14,2,
	"CURSCONF",21,14,6,
	"SETTIME",22,14,6,
	"GETTIME",23,14,2,
	"BIOSKEY",24,14,2,
	"IKBDWS",25,14,8,
	"JDISINT",26,14,4,
	"JENABINT",27,14,4,
	"GIGACESS",28,14,6,
	"OFFGIBIT",29,14,4,
	"ONGIBIT",30,14,4,
	"XBTIMER",31,14,12,
	"DOSOUND",32,14,6,
	"SETPRT",33,14,4,
	"KDBVBASE",34,14,2,
	"KBRATE",35,14,6,
	"PRTBLK",36,14,6,
	"VSYNC",37,14,2,
	"SUPEXEC",38,14,6,
	"PUNTAES",39,14,2,
	"BLITMODE",64,14,4,
	"PTERM0",0,1,0,
	"CCONIN",1,1,2,
	"CCONOUT",2,1,4,
	"CAUXIN",3,1,2,
	"CAUXOUT",4,1,4,
	"CPRNOUT",5,1,4,
	"CRAWIO",6,1,4,
	"CRAWCIN",7,1,2,
	"CNECIN",8,1,2,
	"CCONWS",9,1,6,
	"CCONRS",10,1,6,
	"CCONIS",11,1,2,
	"DSETDRV",14,1,4,
	"CCONOS",16,1,2,
	"CPRNOS",17,1,2,
	"CAIXIS",18,1,2,
	"CAUXOS",19,1,2,
	"DGETDRV",25,1,2,
	"FSETDTA",26,1,6,
	"SUPER",32,1,6,
	"TGETDATE",42,1,2,
	"TSETDATE",43,1,4,
	"TGETTIME",44,1,2,
	"TSETTIME",45,1,4,
	"FGETDTA",47,1,2,
	"SVERSION",48,1,2,
	"PTERMRES",49,1,8,
	"DFREE",54,1,8,
	"DCREATE",57,1,6,
	"DDELETE",58,1,6,
	"DSETPATH",59,1,6,
	"FCREATE",60,1,8,
	"FOPEN",61,1,8,
	"DCLOSE",62,1,4,
	"FREAD",63,1,12,
	"FWRITE",64,1,12,
	"FDELETE",65,1,6,
	"FSEEK",66,1,10,
	"FATTRIB",67,1,10,
	"FDUP",69,1,4,
	"FFORCE",70,1,6,
	"DGETPATH",71,1,8,
	"MALLOC",72,1,6,
	"MFREE",73,1,6,
	"MSHRINK",74,1,12,
	"PEXEC",75,1,16,
	"PTERM",76,1,0,
	"FSFIRST",78,1,8,
	"FSNEXT",79,1,2,
	"FRENAME",86,1,12,
	"FDATETIME",87,1,10,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0,
	"",0,0,0
};
