/*
 * Version information for CPP
 */

#define CPP_VERSION	1
#define CPP_RELEASE	0
#define CPP_PATCHLEVEL	1
