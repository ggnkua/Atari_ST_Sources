/* Resource-Set indicies fuer REMOTE */

#define SETMSG   0	/* Formula/Dialog */
#define NACHRICH 2	/* FBOXTEXT in Baum SETMSG */
#define SEND     3	/* BUTTON in Baum SETMSG */

