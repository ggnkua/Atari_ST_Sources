/* Resource-Set indicies fuer DEMO */

#define MENU     0	/* Menuebaum */
#define POWERGEM 3	/* TITLE in Baum MENU */
#define TEST     4	/* TITLE in Baum MENU */
#define MENINFO  7	/* STRING in Baum MENU */
#define DODIAL   16	/* STRING in Baum MENU */
#define SETTIMER 17	/* STRING in Baum MENU */
#define DOGRAFIK 18	/* STRING in Baum MENU */
#define DOTEXT   19	/* STRING in Baum MENU */
#define QUIT     21	/* STRING in Baum MENU */

#define DIALDEMO 1	/* Formula/Dialog */
#define FAMNAME  2	/* FTEXT in Baum DIALDEMO */
#define VORNAME  3	/* FTEXT in Baum DIALDEMO */
#define ALTER    4	/* FTEXT in Baum DIALDEMO */
#define FEMALE   6	/* BUTTON in Baum DIALDEMO */
#define MALE     7	/* BUTTON in Baum DIALDEMO */
#define GEHTSO   9	/* BUTTON in Baum DIALDEMO */
#define SCHWACH  10	/* BUTTON in Baum DIALDEMO */
#define SEHRGUT  11	/* BUTTON in Baum DIALDEMO */
#define GUT      12	/* BUTTON in Baum DIALDEMO */
#define OKAY     14	/* BUTTON in Baum DIALDEMO */
#define ABBRUCH  15	/* BUTTON in Baum DIALDEMO */
#define TAKEIT   16	/* BUTTON in Baum DIALDEMO */

#define MELDUNG  2	/* Formula/Dialog */
#define BOAHEYH  1	/* BUTTON in Baum MELDUNG */

#define PANEL    3	/* Formula/Dialog */
#define BEGDEC   2	/* BOXCHAR in Baum PANEL */
#define ANFWINKL 3	/* BOXTEXT in Baum PANEL */
#define BEGINC   4	/* BOXCHAR in Baum PANEL */
#define ENDDEC   6	/* BOXCHAR in Baum PANEL */
#define ENDWINKL 7	/* BOXTEXT in Baum PANEL */
#define ENDINC   8	/* BOXCHAR in Baum PANEL */

#define SETBEEP  4	/* Formula/Dialog */
#define BEEPON   3	/* BUTTON in Baum SETBEEP */
#define BEEPOFF  4	/* BUTTON in Baum SETBEEP */
#define TIMER    6	/* FTEXT in Baum SETBEEP */
#define TIMEROK  7	/* BUTTON in Baum SETBEEP */
#define TIMERCNC 8	/* BUTTON in Baum SETBEEP */
#define TIMERSET 9	/* BUTTON in Baum SETBEEP */

#define SHOWMSG  5	/* Formula/Dialog */
#define MESSAGE  3	/* TEXT in Baum SHOWMSG */
#define EXITMSG  5	/* BUTTON in Baum SHOWMSG */

