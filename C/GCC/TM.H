
/* we use an extra file here, cause we don't do links */

#include "tm-atari.h"
