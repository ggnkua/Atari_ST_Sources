/* Generated automatically by the program `gencodes'
from the machine description file `md'.  */

#ifndef MAX_INSN_CODE

enum insn_code {
  CODE_FOR_tstsi = 2,
  CODE_FOR_tsthi = 3,
  CODE_FOR_tstqi = 4,
  CODE_FOR_tstsf = 5,
  CODE_FOR_tstdf = 6,
  CODE_FOR_cmpsi = 7,
  CODE_FOR_cmphi = 8,
  CODE_FOR_cmpqi = 10,
  CODE_FOR_cmpdf = 11,
  CODE_FOR_cmpsf = 12,
  CODE_FOR_swapsi = 22,
  CODE_FOR_movsi = 25,
  CODE_FOR_movhi = 26,
  CODE_FOR_movstricthi = 27,
  CODE_FOR_movqi = 28,
  CODE_FOR_movstrictqi = 29,
  CODE_FOR_movsf = 30,
  CODE_FOR_movdf = 31,
  CODE_FOR_movdi = 32,
  CODE_FOR_pushasi = 33,
  CODE_FOR_truncsiqi2 = 35,
  CODE_FOR_trunchiqi2 = 36,
  CODE_FOR_truncsihi2 = 37,
  CODE_FOR_zero_extendhisi2 = 38,
  CODE_FOR_zero_extendqihi2 = 39,
  CODE_FOR_zero_extendqisi2 = 40,
  CODE_FOR_extendhisi2 = 41,
  CODE_FOR_extendqihi2 = 42,
  CODE_FOR_extendqisi2 = 43,
  CODE_FOR_extendsfdf2 = 44,
  CODE_FOR_truncdfsf2 = 45,
  CODE_FOR_floatsisf2 = 46,
  CODE_FOR_floatsidf2 = 47,
  CODE_FOR_floathisf2 = 48,
  CODE_FOR_floathidf2 = 49,
  CODE_FOR_floatqisf2 = 50,
  CODE_FOR_floatqidf2 = 51,
  CODE_FOR_ftruncdf2 = 52,
  CODE_FOR_ftruncsf2 = 53,
  CODE_FOR_fixsfqi2 = 54,
  CODE_FOR_fixsfhi2 = 55,
  CODE_FOR_fixsfsi2 = 56,
  CODE_FOR_fixdfqi2 = 57,
  CODE_FOR_fixdfhi2 = 58,
  CODE_FOR_fixdfsi2 = 59,
  CODE_FOR_addsi3 = 60,
  CODE_FOR_addhi3 = 62,
  CODE_FOR_addqi3 = 64,
  CODE_FOR_adddf3 = 66,
  CODE_FOR_addsf3 = 67,
  CODE_FOR_subsi3 = 68,
  CODE_FOR_subhi3 = 70,
  CODE_FOR_subqi3 = 72,
  CODE_FOR_subdf3 = 74,
  CODE_FOR_subsf3 = 75,
  CODE_FOR_mulhi3 = 76,
  CODE_FOR_mulhisi3 = 77,
  CODE_FOR_mulsi3 = 78,
  CODE_FOR_umulhi3 = 79,
  CODE_FOR_umulhisi3 = 80,
  CODE_FOR_umulsi3 = 81,
  CODE_FOR_muldf3 = 82,
  CODE_FOR_mulsf3 = 83,
  CODE_FOR_divhi3 = 84,
  CODE_FOR_divhisi3 = 85,
  CODE_FOR_divsi3 = 86,
  CODE_FOR_udivhi3 = 87,
  CODE_FOR_udivhisi3 = 88,
  CODE_FOR_udivsi3 = 89,
  CODE_FOR_divdf3 = 90,
  CODE_FOR_divsf3 = 91,
  CODE_FOR_modhi3 = 92,
  CODE_FOR_modhisi3 = 93,
  CODE_FOR_umodhi3 = 94,
  CODE_FOR_umodhisi3 = 95,
  CODE_FOR_divmodsi4 = 96,
  CODE_FOR_udivmodsi4 = 97,
  CODE_FOR_andsi3 = 98,
  CODE_FOR_andhi3 = 99,
  CODE_FOR_andqi3 = 100,
  CODE_FOR_iorsi3 = 103,
  CODE_FOR_iorhi3 = 104,
  CODE_FOR_iorqi3 = 105,
  CODE_FOR_xorsi3 = 106,
  CODE_FOR_xorhi3 = 107,
  CODE_FOR_xorqi3 = 108,
  CODE_FOR_negsi2 = 109,
  CODE_FOR_neghi2 = 110,
  CODE_FOR_negqi2 = 111,
  CODE_FOR_negsf2 = 112,
  CODE_FOR_negdf2 = 113,
  CODE_FOR_abssf2 = 114,
  CODE_FOR_absdf2 = 115,
  CODE_FOR_one_cmplsi2 = 116,
  CODE_FOR_one_cmplhi2 = 117,
  CODE_FOR_one_cmplqi2 = 118,
  CODE_FOR_ashlsi3 = 125,
  CODE_FOR_ashlhi3 = 126,
  CODE_FOR_ashlqi3 = 127,
  CODE_FOR_ashrsi3 = 128,
  CODE_FOR_ashrhi3 = 129,
  CODE_FOR_ashrqi3 = 130,
  CODE_FOR_lshlsi3 = 131,
  CODE_FOR_lshlhi3 = 132,
  CODE_FOR_lshlqi3 = 133,
  CODE_FOR_lshrsi3 = 134,
  CODE_FOR_lshrhi3 = 135,
  CODE_FOR_lshrqi3 = 136,
  CODE_FOR_rotlsi3 = 137,
  CODE_FOR_rotlhi3 = 138,
  CODE_FOR_rotlqi3 = 139,
  CODE_FOR_rotrsi3 = 140,
  CODE_FOR_rotrhi3 = 141,
  CODE_FOR_rotrqi3 = 142,
  CODE_FOR_extv = 146,
  CODE_FOR_extzv = 147,
  CODE_FOR_insv = 151,
  CODE_FOR_seq = 163,
  CODE_FOR_sne = 164,
  CODE_FOR_sgt = 165,
  CODE_FOR_sgtu = 166,
  CODE_FOR_slt = 167,
  CODE_FOR_sltu = 168,
  CODE_FOR_sge = 169,
  CODE_FOR_sgeu = 170,
  CODE_FOR_sle = 171,
  CODE_FOR_sleu = 172,
  CODE_FOR_beq = 173,
  CODE_FOR_bne = 174,
  CODE_FOR_bgt = 175,
  CODE_FOR_bgtu = 176,
  CODE_FOR_blt = 177,
  CODE_FOR_bltu = 178,
  CODE_FOR_bge = 179,
  CODE_FOR_bgeu = 180,
  CODE_FOR_ble = 181,
  CODE_FOR_bleu = 182,
  CODE_FOR_casesi_1 = 193,
  CODE_FOR_casesi_2 = 194,
  CODE_FOR_casesi = 195,
  CODE_FOR_jump = 197,
  CODE_FOR_call = 200,
  CODE_FOR_call_value = 201,
  CODE_FOR_return = 202,
  CODE_FOR_nothing };

#define MAX_INSN_CODE ((int) CODE_FOR_nothing)
#endif /* MAX_INSN_CODE */
