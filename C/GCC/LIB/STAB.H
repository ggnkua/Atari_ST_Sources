
/* this symbol table include file was generated by jrd after reading
   documentation about what all these values were supposed to be.
   I think it doesn't make any difference whether I've got them right,
   as, according to the doc I saw, the only thing that has a use for them
   is a debugger that doesn't run on the ST anyhow.  Just as well; the code
   compiles with this file, but I have no confidence that it agrees with
   anybody else's definitions
*/

#define	N_STAB	0xE0	/* mask for syms that are 'permanent' (?) */
#define	N_GSYM	0x20	/* some kind of external or global */
#define	N_FNAME	0x22	/* the name of a function? */
#define	N_FUN	0x24	/* another value for function name? */
#define	N_STSYM	0x26	/* local; C calls it "static" */
#define	N_LCSYM	0x28	/* a local symbol */
#define	N_RSYM	0x40	/* somthing declared to be in a register */
#define	N_SLINE	0x44	/* source line tag */
#define	N_SSYM	0x60	/* a structure slot.  value is offset from struct */
#define	N_SO	0x64	/* name of source file (this sym?) */
#define	N_LSYM	0x80	/* another value for local symbol? */
#define	N_SOL	0x84	/* another value for source file? */
#define	N_PSYM	0xA0	/* a parameter name */
#define	N_ENTRY	0xA4	/* entry point?  (how different than function??? )*/
#define	N_LBRAC	0xC0	/* left brace??? */
#define	N_RBRAC	0xE0	/* right brace?????? */
#define	N_BCOMM	0xE2	/* somthing declared "common" to assembler */
#define	N_ECOMM	0xE4	/* more of the same?? */
#define	N_ECOML	0xE8	/* yet more??? */
#define	N_LENG	0xFE	/* length of symbol table? */


/* will probably need to add more as I find missing defs... */
