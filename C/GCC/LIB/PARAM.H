/*
 *		Cross Development System for Atari ST 
 *     Copyright (c) 1988, Memorial University of Newfoundland
 *
 * $Header: param.h,v 1.1 88/01/29 17:22:30 m68k Exp $
 *
 * $Log:	param.h,v $
 * Revision 1.1  88/01/29  17:22:30  m68k
 * Initial revision
 * 
 */
#define	MAXPATHLEN	67		/* 64 + 2 for a: and 1 for null */
#define	NOFILE		20		/* max. number of open files/proc */
#define	NCARGS		127		/* max number of chars in argv */
#define	CANBSIZ		NCARGS		/* max # chars of input on one line */
