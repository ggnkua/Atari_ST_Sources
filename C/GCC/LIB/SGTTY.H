/*
 *		Cross Development System for Atari ST 
 *     Copyright (c) 1988, Memorial University of Newfoundland
 *
 * $Header: sgtty.h,v 1.1 88/02/03 20:14:18 m68k Exp $
 *
 * $Log:	sgtty.h,v $
 * Revision 1.1  88/02/03  20:14:18  m68k
 * Initial revision
 * 
 */
#ifndef	_IOCTL_
# include <ioctl.h>
#endif	/* _IOCTL_ */
