
#include "ctype.h"

char _ctype_[128] =
	{
	_C,	_S|_C,	_S|_C,	_S|_C,			/* #x00 .. #x03 */
	_S|_C,	_S|_C,	_S|_C,	_S|_C,			/* #x04 .. #x07 */
	_S|_C,	_S|_C,	_S|_C,	_S|_C,			/* #x08 .. #x0B */
	_S|_C,	_S|_C,	_S|_C,	_S|_C,			/* #x0C .. #x0F */
	_S|_C,	_S|_C,	_S|_C,	_S|_C,			/* #x10 .. #x13 */
	_S|_C,	_S|_C,	_S|_C,	_S|_C,			/* #x14 .. #x17 */
	_S|_C,	_S|_C,	_S|_C,	_S|_C,			/* #x18 .. #x1B */
	_S|_C,	_S|_C,	_S|_C,	_S|_C,			/* #x1C .. #x1F */
	_S|_P,	_P,	_P,	_P,			/* ' '  .. '#'  */
	_P,	_P,	_P,	_P,			/* '$'  .. '''  */
	_P,	_P,	_P,	_P,			/* '('  .. '+'  */
	_P,	_P,	_P,	_P,			/* ','  .. '/'  */
	_N|_P,	_N|_P,	_N|_P,	_N|_P,			/* '0'  .. '3'  */
	_N|_P,	_N|_P,	_N|_P,	_N|_P,			/* '4'  .. '7'  */
	_N|_P,	_N|_P,	_P,	_P,			/* '8'  .. ';'  */
	_P,	_P,	_P,	_P,			/* '<'  .. '?'  */
	_P,	_U|_P|_X, _U|_P|_X, _U|_P|_X, 		/* '@'  .. 'C'  */
	_U|_P|_X, _U|_P|_X, _U|_P|_X, _U|_P,		/* 'D'  .. 'G'  */
	_U|_P,	_U|_P,	_U|_P,	_U|_P,			/* 'H'  .. 'K'  */
	_U|_P,	_U|_P,	_U|_P,	_U|_P,			/* 'L'  .. 'O'  */
	_U|_P,	_U|_P,	_U|_P,	_U|_P,			/* 'P'  .. 'S'  */
	_U|_P,	_U|_P,	_U|_P,	_U|_P,			/* 'T'  .. 'W'  */
	_U|_P,	_U|_P,	_U|_P,	_P,			/* 'X'  .. '['  */
	_P,	_P,	_P,	_P,			/* '\'  .. '_'  */
/* zzz I guess for now lower case a..f are hex digits... */
	_P,	_L|_P|_X, _L|_P|_X, _L|_P|_X, 		/* '`'  .. 'c'  */
	_L|_P|_X, _L|_P|_X, _L|_P|_X, _L|_P,		/* 'd'  .. 'g'  */
	_L|_P,	_L|_P,	_L|_P,	_L|_P,			/* 'h'  .. 'k'  */
	_L|_P,	_L|_P,	_L|_P,	_L|_P,			/* 'l'  .. 'o'  */
	_L|_P,	_L|_P,	_L|_P,	_L|_P,			/* 'p'  .. 's'  */
	_L|_P,	_L|_P,	_L|_P,	_L|_P,			/* 't'  .. 'w'  */
	_L|_P,	_L|_P,	_L|_P,	_P,			/* 'x'  .. '{'  */
	_P,	_P,	_P,	_P			/* '|'  .. #x7F  */
	};
