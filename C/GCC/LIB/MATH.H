
/* math routines */

extern double sin();
extern double atof();

#define	pi	3.141592654
