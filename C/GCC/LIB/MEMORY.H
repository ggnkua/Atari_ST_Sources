
extern char * malloc();
extern char * realloc();
extern char * calloc();
extern void free();
