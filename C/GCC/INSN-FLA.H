/* Generated automatically by the program `genflags'
from the machine description file `md'.  */

#define HAVE_tstsi (1)
extern rtx gen_tstsi ();
#define HAVE_tsthi (1)
extern rtx gen_tsthi ();
#define HAVE_tstqi (1)
extern rtx gen_tstqi ();
#define HAVE_tstsf (TARGET_68881)
extern rtx gen_tstsf ();
#define HAVE_tstdf (TARGET_68881)
extern rtx gen_tstdf ();
#define HAVE_cmpsi (1)
extern rtx gen_cmpsi ();
#define HAVE_cmphi (1)
extern rtx gen_cmphi ();
#define HAVE_cmpqi (1)
extern rtx gen_cmpqi ();
#define HAVE_cmpdf (TARGET_68881)
extern rtx gen_cmpdf ();
#define HAVE_cmpsf (TARGET_68881)
extern rtx gen_cmpsf ();
#define HAVE_swapsi (1)
extern rtx gen_swapsi ();
#define HAVE_movsi (1)
extern rtx gen_movsi ();
#define HAVE_movhi (1)
extern rtx gen_movhi ();
#define HAVE_movstricthi (1)
extern rtx gen_movstricthi ();
#define HAVE_movqi (1)
extern rtx gen_movqi ();
#define HAVE_movstrictqi (1)
extern rtx gen_movstrictqi ();
#define HAVE_movsf (1)
extern rtx gen_movsf ();
#define HAVE_movdf (1)
extern rtx gen_movdf ();
#define HAVE_movdi (1)
extern rtx gen_movdi ();
#define HAVE_pushasi (1)
extern rtx gen_pushasi ();
#define HAVE_truncsiqi2 (1)
extern rtx gen_truncsiqi2 ();
#define HAVE_trunchiqi2 (1)
extern rtx gen_trunchiqi2 ();
#define HAVE_truncsihi2 (1)
extern rtx gen_truncsihi2 ();
#define HAVE_zero_extendhisi2 (1)
extern rtx gen_zero_extendhisi2 ();
#define HAVE_zero_extendqihi2 (1)
extern rtx gen_zero_extendqihi2 ();
#define HAVE_zero_extendqisi2 (1)
extern rtx gen_zero_extendqisi2 ();
#define HAVE_extendhisi2 (1)
extern rtx gen_extendhisi2 ();
#define HAVE_extendqihi2 (1)
extern rtx gen_extendqihi2 ();
#define HAVE_extendqisi2 (TARGET_68020)
extern rtx gen_extendqisi2 ();
#define HAVE_extendsfdf2 (TARGET_68881)
extern rtx gen_extendsfdf2 ();
#define HAVE_truncdfsf2 (TARGET_68881)
extern rtx gen_truncdfsf2 ();
#define HAVE_floatsisf2 (TARGET_68881)
extern rtx gen_floatsisf2 ();
#define HAVE_floatsidf2 (TARGET_68881)
extern rtx gen_floatsidf2 ();
#define HAVE_floathisf2 (TARGET_68881)
extern rtx gen_floathisf2 ();
#define HAVE_floathidf2 (TARGET_68881)
extern rtx gen_floathidf2 ();
#define HAVE_floatqisf2 (TARGET_68881)
extern rtx gen_floatqisf2 ();
#define HAVE_floatqidf2 (TARGET_68881)
extern rtx gen_floatqidf2 ();
#define HAVE_ftruncdf2 (TARGET_68881)
extern rtx gen_ftruncdf2 ();
#define HAVE_ftruncsf2 (TARGET_68881)
extern rtx gen_ftruncsf2 ();
#define HAVE_fixsfqi2 (TARGET_68881)
extern rtx gen_fixsfqi2 ();
#define HAVE_fixsfhi2 (TARGET_68881)
extern rtx gen_fixsfhi2 ();
#define HAVE_fixsfsi2 (TARGET_68881)
extern rtx gen_fixsfsi2 ();
#define HAVE_fixdfqi2 (TARGET_68881)
extern rtx gen_fixdfqi2 ();
#define HAVE_fixdfhi2 (TARGET_68881)
extern rtx gen_fixdfhi2 ();
#define HAVE_fixdfsi2 (TARGET_68881)
extern rtx gen_fixdfsi2 ();
#define HAVE_addsi3 (1)
extern rtx gen_addsi3 ();
#define HAVE_addhi3 (1)
extern rtx gen_addhi3 ();
#define HAVE_addqi3 (1)
extern rtx gen_addqi3 ();
#define HAVE_adddf3 (TARGET_68881)
extern rtx gen_adddf3 ();
#define HAVE_addsf3 (TARGET_68881)
extern rtx gen_addsf3 ();
#define HAVE_subsi3 (1)
extern rtx gen_subsi3 ();
#define HAVE_subhi3 (1)
extern rtx gen_subhi3 ();
#define HAVE_subqi3 (1)
extern rtx gen_subqi3 ();
#define HAVE_subdf3 (TARGET_68881)
extern rtx gen_subdf3 ();
#define HAVE_subsf3 (TARGET_68881)
extern rtx gen_subsf3 ();
#define HAVE_mulhi3 (1)
extern rtx gen_mulhi3 ();
#define HAVE_mulhisi3 (1)
extern rtx gen_mulhisi3 ();
#define HAVE_mulsi3 (TARGET_68020)
extern rtx gen_mulsi3 ();
#define HAVE_umulhi3 (1)
extern rtx gen_umulhi3 ();
#define HAVE_umulhisi3 (1)
extern rtx gen_umulhisi3 ();
#define HAVE_umulsi3 (TARGET_68020)
extern rtx gen_umulsi3 ();
#define HAVE_muldf3 (TARGET_68881)
extern rtx gen_muldf3 ();
#define HAVE_mulsf3 (TARGET_68881)
extern rtx gen_mulsf3 ();
#define HAVE_divhi3 (1)
extern rtx gen_divhi3 ();
#define HAVE_divhisi3 (1)
extern rtx gen_divhisi3 ();
#define HAVE_divsi3 (TARGET_68020)
extern rtx gen_divsi3 ();
#define HAVE_udivhi3 (1)
extern rtx gen_udivhi3 ();
#define HAVE_udivhisi3 (1)
extern rtx gen_udivhisi3 ();
#define HAVE_udivsi3 (TARGET_68020)
extern rtx gen_udivsi3 ();
#define HAVE_divdf3 (TARGET_68881)
extern rtx gen_divdf3 ();
#define HAVE_divsf3 (TARGET_68881)
extern rtx gen_divsf3 ();
#define HAVE_modhi3 (1)
extern rtx gen_modhi3 ();
#define HAVE_modhisi3 (1)
extern rtx gen_modhisi3 ();
#define HAVE_umodhi3 (1)
extern rtx gen_umodhi3 ();
#define HAVE_umodhisi3 (1)
extern rtx gen_umodhisi3 ();
#define HAVE_divmodsi4 (TARGET_68020)
extern rtx gen_divmodsi4 ();
#define HAVE_udivmodsi4 (TARGET_68020)
extern rtx gen_udivmodsi4 ();
#define HAVE_andsi3 (1)
extern rtx gen_andsi3 ();
#define HAVE_andhi3 (1)
extern rtx gen_andhi3 ();
#define HAVE_andqi3 (1)
extern rtx gen_andqi3 ();
#define HAVE_iorsi3 (1)
extern rtx gen_iorsi3 ();
#define HAVE_iorhi3 (1)
extern rtx gen_iorhi3 ();
#define HAVE_iorqi3 (1)
extern rtx gen_iorqi3 ();
#define HAVE_xorsi3 (1)
extern rtx gen_xorsi3 ();
#define HAVE_xorhi3 (1)
extern rtx gen_xorhi3 ();
#define HAVE_xorqi3 (1)
extern rtx gen_xorqi3 ();
#define HAVE_negsi2 (1)
extern rtx gen_negsi2 ();
#define HAVE_neghi2 (1)
extern rtx gen_neghi2 ();
#define HAVE_negqi2 (1)
extern rtx gen_negqi2 ();
#define HAVE_negsf2 (TARGET_68881)
extern rtx gen_negsf2 ();
#define HAVE_negdf2 (TARGET_68881)
extern rtx gen_negdf2 ();
#define HAVE_abssf2 (TARGET_68881)
extern rtx gen_abssf2 ();
#define HAVE_absdf2 (TARGET_68881)
extern rtx gen_absdf2 ();
#define HAVE_one_cmplsi2 (1)
extern rtx gen_one_cmplsi2 ();
#define HAVE_one_cmplhi2 (1)
extern rtx gen_one_cmplhi2 ();
#define HAVE_one_cmplqi2 (1)
extern rtx gen_one_cmplqi2 ();
#define HAVE_ashlsi3 (1)
extern rtx gen_ashlsi3 ();
#define HAVE_ashlhi3 (1)
extern rtx gen_ashlhi3 ();
#define HAVE_ashlqi3 (1)
extern rtx gen_ashlqi3 ();
#define HAVE_ashrsi3 (1)
extern rtx gen_ashrsi3 ();
#define HAVE_ashrhi3 (1)
extern rtx gen_ashrhi3 ();
#define HAVE_ashrqi3 (1)
extern rtx gen_ashrqi3 ();
#define HAVE_lshlsi3 (1)
extern rtx gen_lshlsi3 ();
#define HAVE_lshlhi3 (1)
extern rtx gen_lshlhi3 ();
#define HAVE_lshlqi3 (1)
extern rtx gen_lshlqi3 ();
#define HAVE_lshrsi3 (1)
extern rtx gen_lshrsi3 ();
#define HAVE_lshrhi3 (1)
extern rtx gen_lshrhi3 ();
#define HAVE_lshrqi3 (1)
extern rtx gen_lshrqi3 ();
#define HAVE_rotlsi3 (1)
extern rtx gen_rotlsi3 ();
#define HAVE_rotlhi3 (1)
extern rtx gen_rotlhi3 ();
#define HAVE_rotlqi3 (1)
extern rtx gen_rotlqi3 ();
#define HAVE_rotrsi3 (1)
extern rtx gen_rotrsi3 ();
#define HAVE_rotrhi3 (1)
extern rtx gen_rotrhi3 ();
#define HAVE_rotrqi3 (1)
extern rtx gen_rotrqi3 ();
#define HAVE_extv (TARGET_68020 && TARGET_BITFIELD)
extern rtx gen_extv ();
#define HAVE_extzv (TARGET_68020 && TARGET_BITFIELD)
extern rtx gen_extzv ();
#define HAVE_insv (TARGET_68020 && TARGET_BITFIELD)
extern rtx gen_insv ();
#define HAVE_seq (1)
extern rtx gen_seq ();
#define HAVE_sne (1)
extern rtx gen_sne ();
#define HAVE_sgt (1)
extern rtx gen_sgt ();
#define HAVE_sgtu (1)
extern rtx gen_sgtu ();
#define HAVE_slt (1)
extern rtx gen_slt ();
#define HAVE_sltu (1)
extern rtx gen_sltu ();
#define HAVE_sge (1)
extern rtx gen_sge ();
#define HAVE_sgeu (1)
extern rtx gen_sgeu ();
#define HAVE_sle (1)
extern rtx gen_sle ();
#define HAVE_sleu (1)
extern rtx gen_sleu ();
#define HAVE_beq (1)
extern rtx gen_beq ();
#define HAVE_bne (1)
extern rtx gen_bne ();
#define HAVE_bgt (1)
extern rtx gen_bgt ();
#define HAVE_bgtu (1)
extern rtx gen_bgtu ();
#define HAVE_blt (1)
extern rtx gen_blt ();
#define HAVE_bltu (1)
extern rtx gen_bltu ();
#define HAVE_bge (1)
extern rtx gen_bge ();
#define HAVE_bgeu (1)
extern rtx gen_bgeu ();
#define HAVE_ble (1)
extern rtx gen_ble ();
#define HAVE_bleu (1)
extern rtx gen_bleu ();
#define HAVE_casesi_1 (1)
extern rtx gen_casesi_1 ();
#define HAVE_casesi_2 (1)
extern rtx gen_casesi_2 ();
#define HAVE_casesi (1)
extern rtx gen_casesi ();
#define HAVE_jump (1)
extern rtx gen_jump ();
#define HAVE_call (1)
extern rtx gen_call ();
#define HAVE_call_value (1)
extern rtx gen_call_value ();
#define HAVE_return (1)
extern rtx gen_return ();
