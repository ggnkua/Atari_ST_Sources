/* keymap for German keyboards */

/* Scan codes to ASCII for unshifted keys */
PUBLIC unsigned char keynorm[] = {
/*00*/    0x00, 0x1B,  '1',  '2',  '3',  '4',  '5',  '6',
/*08*/     '7',  '8',  '9',  '0', 0x9E, '\'', '\b', '\t',
/*10*/     'q',  'w',  'e',  'r',  't',  'z',  'u',  'i',
/*18*/     'o',  'p', 0x81,  '+', '\r', 0x00,  'a',  's',
/*20*/     'd',  'f',  'g',  'h',  'j',  'k',  'l', 0x94,
/*28*/    0x84,  '#', 0x00,  '~',  'y',  'x',  'c',  'v',
/*30*/     'b',  'n',  'm',  ',',  '.',  '-', 0x00, 0x00,
/*38*/    0x00,  ' ', 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*40*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*48*/    0x00, 0x00,  '-', 0x00, 0x00, 0x00,  '+', 0x00,
/*50*/    0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
/*58*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*60*/     '<', 0x00, 0x00,  '(',  ')',  '/',  '*',  '7',
/*68*/     '8',  '9',  '4',  '5',  '6',  '1',  '2',  '3',
/*70*/     '0',  '.', '\r', 0x00, 0x00, 0x00, 0x00, 0x00,
/*78*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

/* Scan codes to ASCII for shifted keys */
PUBLIC unsigned char keyshft[] = {
/*00*/    0x00, 0x1B,  '!',  '"', 0xDD,  '$',  '%',  '&',
/*08*/     '/',  '(',  ')',  '=',  '?',  '`', '\b', '\t',
/*10*/     'Q',  'W',  'E',  'R',  'T',  'Z',  'U',  'I',
/*18*/     'O',  'P', 0x9A,  '*', '\r', 0x00,  'A',  'S',
/*20*/     'D',  'F',  'G',  'H',  'J',  'K',  'L', 0x99,
/*28*/    0x8E,  '^', 0x00,  '|',  'Y',  'X',  'C',  'V',
/*30*/     'B',  'N',  'M',  ';',  ':',  '_', 0x00, 0x00,
/*38*/    0x00,  ' ', 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*40*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,  '7',
/*48*/     '8', 0x00,  '-',  '4', 0x00,  '6',  '+', 0x00,
/*50*/     '2', 0x00,  '0', 0x7F, 0x00, 0x00, 0x00, 0x00,
/*58*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*60*/     '>', 0x00, 0x00,  '(',  ')',  '/',  '*',  '7',
/*68*/     '8',  '9',  '4',  '5',  '6',  '1',  '2',  '3',
/*70*/     '0',  '.', '\r', 0x00, 0x00, 0x00, 0x00, 0x00,
/*78*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

/* Scan codes to ASCII for capslocked keys */
PUBLIC unsigned char keycaps[] = {
/*00*/    0x00, 0x1B,  '1',  '2',  '3',  '4',  '5',  '6',
/*08*/     '7',  '8',  '9',  '0', 0x9E, '\'', '\b', '\t',
/*10*/     'Q',  'W',  'E',  'R',  'T',  'Z',  'U',  'I',
/*18*/     'O',  'P', 0x9A,  '+', '\r', 0x00,  'A',  'S',
/*20*/     'D',  'F',  'G',  'H',  'J',  'K',  'L', 0x99,
/*28*/    0x8E,  '#', 0x00,  '~',  'Y',  'X',  'C',  'V',
/*30*/     'B',  'N',  'M',  ',',  '.',  '-', 0x00, 0x00,
/*38*/    0x00,  ' ', 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*40*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*48*/    0x00, 0x00,  '-', 0x00, 0x00, 0x00,  '+', 0x00,
/*50*/    0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
/*58*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
/*60*/     '<', 0x00, 0x00,  '(',  ')',  '/',  '*',  '7',
/*68*/     '8',  '9',  '4',  '5',  '6',  '1',  '2',  '3',
/*70*/     '0',  '.', '\r', 0x00, 0x00, 0x00, 0x00, 0x00,
/*78*/    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};

