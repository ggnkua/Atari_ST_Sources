/* Resource Datei Indizes f�r DIGGER */

#define AMENU            0   /* Menuebaum */
#define MTDESK           3   /* TITLE in Baum AMENU */
#define MT1              4   /* TITLE in Baum AMENU */
#define MTM              5   /* TITLE in Baum AMENU */
#define MNTITEL          8   /* STRING in Baum AMENU */
#define MNO              17  /* STRING in Baum AMENU */
#define MNL              18  /* STRING in Baum AMENU */
#define MNTTP            19  /* STRING in Baum AMENU */
#define MNPRG            20  /* STRING in Baum AMENU */
#define MNAPP            21  /* STRING in Baum AMENU */
#define MNDISK           23  /* STRING in Baum AMENU */
#define MNRAM            24  /* STRING in Baum AMENU */
#define MNTOS            25  /* STRING in Baum AMENU */
#define MNTOSIMG         26  /* STRING in Baum AMENU */
#define MNCARTR          27  /* STRING in Baum AMENU */
#define MNPPU            29  /* STRING in Baum AMENU */
#define MNQUIT           31  /* STRING in Baum AMENU */
#define MNTILE           33  /* STRING in Baum AMENU */
#define MNOVLAP          34  /* STRING in Baum AMENU */
#define MNCYCL           35  /* STRING in Baum AMENU */
#define MNCONFIG         37  /* STRING in Baum AMENU */
#define MNSIDF           38  /* STRING in Baum AMENU */
#define AOPT             39  /* STRING in Baum AMENU */
#define HELP             41  /* STRING in Baum AMENU */

#define OMENU            1   /* Menuebaum */
#define DMOUT            3   /* TITLE in Baum OMENU */
#define DMGOTO           4   /* TITLE in Baum OMENU */
#define DMFIND           5   /* TITLE in Baum OMENU */
#define DMMARK           6   /* TITLE in Baum OMENU */
#define DMDO             7   /* TITLE in Baum OMENU */
#define DMOPT            8   /* TITLE in Baum OMENU */
#define DMMACH           9   /* TITLE in Baum OMENU */
#define DMSAVE           12  /* STRING in Baum OMENU */
#define DMLIND           13  /* STRING in Baum OMENU */
#define DMSIND           14  /* STRING in Baum OMENU */
#define DMUIND           15  /* STRING in Baum OMENU */
#define DMCLOSE          17  /* STRING in Baum OMENU */
#define DMHOME           19  /* STRING in Baum OMENU */
#define DMEND            20  /* STRING in Baum OMENU */
#define DMEXTRA          21  /* STRING in Baum OMENU */
#define DMUNDO           22  /* STRING in Baum OMENU */
#define DMNXP            23  /* STRING in Baum OMENU */
#define DMSAMP           24  /* STRING in Baum OMENU */
#define DMPRVP           25  /* STRING in Baum OMENU */
#define DMLEFT           26  /* STRING in Baum OMENU */
#define DMRIGHT          27  /* STRING in Baum OMENU */
#define DMSTAS           28  /* STRING in Baum OMENU */
#define DMENDS           29  /* STRING in Baum OMENU */
#define DMDC             30  /* STRING in Baum OMENU */
#define DMADDR           32  /* STRING in Baum OMENU */
#define DMBKADDR         33  /* STRING in Baum OMENU */
#define DMHEX            34  /* STRING in Baum OMENU */
#define DMNXHEX          35  /* STRING in Baum OMENU */
#define DMTEXT           36  /* STRING in Baum OMENU */
#define DMNXTEXT         37  /* STRING in Baum OMENU */
#define DMREF            38  /* STRING in Baum OMENU */
#define DMNEXTREF        39  /* STRING in Baum OMENU */
#define DMLREF           40  /* STRING in Baum OMENU */
#define DMJMPIND         42  /* STRING in Baum OMENU */
#define DMFMARK          43  /* STRING in Baum OMENU */
#define DMCOMPARE        44  /* STRING in Baum OMENU */
#define DMBYTE           46  /* STRING in Baum OMENU */
#define DMBYTES          47  /* STRING in Baum OMENU */
#define DMBYTEC          48  /* STRING in Baum OMENU */
#define DMWORD           49  /* STRING in Baum OMENU */
#define DMWORDS          50  /* STRING in Baum OMENU */
#define DMWORDC          51  /* STRING in Baum OMENU */
#define DMLONG           52  /* STRING in Baum OMENU */
#define DMLONGS          53  /* STRING in Baum OMENU */
#define DMLONGC          54  /* STRING in Baum OMENU */
#define DMCODE           55  /* STRING in Baum OMENU */
#define DMCODES          56  /* STRING in Baum OMENU */
#define DMCODEC          57  /* STRING in Baum OMENU */
#define DMJMPT           59  /* STRING in Baum OMENU */
#define DMBMARK          60  /* STRING in Baum OMENU */
#define DMBCMARK         61  /* STRING in Baum OMENU */
#define DMSSEL           63  /* STRING in Baum OMENU */
#define DMESEL           64  /* STRING in Baum OMENU */
#define DMXSEL           65  /* STRING in Baum OMENU */
#define DMLNAME          67  /* STRING in Baum OMENU */
#define DMWNAME          68  /* STRING in Baum OMENU */
#define DMCOM            69  /* STRING in Baum OMENU */
#define DMF1             71  /* STRING in Baum OMENU */
#define DMF2             72  /* STRING in Baum OMENU */
#define DMF3             73  /* STRING in Baum OMENU */
#define DMF4             75  /* STRING in Baum OMENU */
#define DMF5             76  /* STRING in Baum OMENU */
#define DMF6             77  /* STRING in Baum OMENU */
#define DMF7             79  /* STRING in Baum OMENU */
#define DMF8             80  /* STRING in Baum OMENU */
#define DMF9             82  /* STRING in Baum OMENU */
#define DMCF             84  /* STRING in Baum OMENU */
#define DM00             85  /* STRING in Baum OMENU */
#define DM20             86  /* STRING in Baum OMENU */
#define DM30             87  /* STRING in Baum OMENU */
#define DM40             88  /* STRING in Baum OMENU */
#define DM60             89  /* STRING in Baum OMENU */
#define DM51             91  /* STRING in Baum OMENU */
#define DM81             92  /* STRING in Baum OMENU */
#define DMTNL            94  /* STRING in Baum OMENU */
#define DMOPOC           95  /* STRING in Baum OMENU */
#define DMDEC            96  /* STRING in Baum OMENU */
#define DMUSYSV          98  /* STRING in Baum OMENU */
#define DMISYSV          99  /* STRING in Baum OMENU */

#define JOURNAL          2   /* Menuebaum */
#define MTJ1             3   /* TITLE in Baum JOURNAL */
#define MNJVOLAT         6   /* STRING in Baum JOURNAL */
#define MNJSAVES         8   /* STRING in Baum JOURNAL */
#define MNJPRI           9   /* STRING in Baum JOURNAL */
#define MNJCLOSE         11  /* STRING in Baum JOURNAL */

#define TTD_KIT          3   /* Formular/Dialog */
#define TTDK1            0   /* BOX in Baum TTD_KIT */
#define TKBLOK           1   /* BUTTON in Baum TTD_KIT */
#define KASVE            2   /* BUTTON in Baum TTD_KIT */
#define KSIDF            3   /* BUTTON in Baum TTD_KIT */
#define KPPUU            4   /* BUTTON in Baum TTD_KIT */
#define KPPUP            5   /* FTEXT in Baum TTD_KIT */
#define KJVOL            6   /* BUTTON in Baum TTD_KIT */
#define KSIZER           7   /* BUTTON in Baum TTD_KIT */
#define KVSLID           8   /* BUTTON in Baum TTD_KIT */
#define KHSLID           9   /* BUTTON in Baum TTD_KIT */
#define KWIDTH           11  /* FTEXT in Baum TTD_KIT */
#define KHEIGHT          12  /* FTEXT in Baum TTD_KIT */
#define KTITLBLOK        15  /* BUTTON in Baum TTD_KIT */
#define KB0              16  /* BUTTON in Baum TTD_KIT */
#define KB1              17  /* BUTTON in Baum TTD_KIT */
#define KB2              18  /* BUTTON in Baum TTD_KIT */
#define KB3              19  /* BUTTON in Baum TTD_KIT */
#define KB4              20  /* BUTTON in Baum TTD_KIT */
#define KT0              21  /* FTEXT in Baum TTD_KIT */
#define KT1              22  /* FTEXT in Baum TTD_KIT */
#define KT2              23  /* FTEXT in Baum TTD_KIT */
#define KT3              24  /* FTEXT in Baum TTD_KIT */
#define KT4              25  /* FTEXT in Baum TTD_KIT */
#define KMACHBLOK        26  /* BUTTON in Baum TTD_KIT */
#define KMC_CF           27  /* BUTTON in Baum TTD_KIT */
#define KMC000           28  /* BUTTON in Baum TTD_KIT */
#define KMC851           29  /* BUTTON in Baum TTD_KIT */
#define KMC020           30  /* BUTTON in Baum TTD_KIT */
#define KMC881           31  /* BUTTON in Baum TTD_KIT */
#define KMC030           32  /* BUTTON in Baum TTD_KIT */
#define KDBLF            33  /* BUTTON in Baum TTD_KIT */
#define KMC040           34  /* BUTTON in Baum TTD_KIT */
#define KMC060           35  /* BUTTON in Baum TTD_KIT */
#define KDISPBLOK        36  /* BUTTON in Baum TTD_KIT */
#define KLBNL            42  /* BUTTON in Baum TTD_KIT */
#define KXOOO            43  /* BUTTON in Baum TTD_KIT */
#define KDECI            44  /* BUTTON in Baum TTD_KIT */
#define KOPC             46  /* BUTTON in Baum TTD_KIT */
#define KHASC            47  /* BUTTON in Baum TTD_KIT */
#define KOASC            48  /* BUTTON in Baum TTD_KIT */
#define KSTAND           50  /* BUTTON in Baum TTD_KIT */
#define KLBLS            51  /* BUTTON in Baum TTD_KIT */
#define KSYMS            52  /* BUTTON in Baum TTD_KIT */
#define KLSEP            53  /* FTEXT in Baum TTD_KIT */
#define KKPRE            54  /* FTEXT in Baum TTD_KIT */
#define KCOP             55  /* FTEXT in Baum TTD_KIT */
#define KHEXA            56  /* FTEXT in Baum TTD_KIT */
#define KILLEGAL         57  /* FTEXT in Baum TTD_KIT */
#define KVISBLOK         58  /* BUTTON in Baum TTD_KIT */
#define KVCUST           60  /* BUTTON in Baum TTD_KIT */
#define KV95             61  /* BUTTON in Baum TTD_KIT */
#define KVGER            62  /* BUTTON in Baum TTD_KIT */
#define KVFRA            63  /* BUTTON in Baum TTD_KIT */
#define KVLAT            64  /* BUTTON in Baum TTD_KIT */
#define KVSCAN           65  /* BUTTON in Baum TTD_KIT */
#define KVMATH           66  /* BUTTON in Baum TTD_KIT */
#define KVALL            67  /* BUTTON in Baum TTD_KIT */
#define KVNONE           68  /* BUTTON in Baum TTD_KIT */
#define KVIS             69  /* BOX in Baum TTD_KIT */
#define VIS0             70  /* STRING in Baum TTD_KIT */
#define VIS1             71  /* STRING in Baum TTD_KIT */
#define VIS2             72  /* STRING in Baum TTD_KIT */
#define VIS3             73  /* STRING in Baum TTD_KIT */
#define VIS4             74  /* STRING in Baum TTD_KIT */
#define VIS5             75  /* STRING in Baum TTD_KIT */
#define VIS6             76  /* STRING in Baum TTD_KIT */
#define VIS7             77  /* STRING in Baum TTD_KIT */
#define KTOCUST          78  /* BUTTON in Baum TTD_KIT */
#define KVIST            79  /* FTEXT in Baum TTD_KIT */
#define KSIZEBLOK        80  /* BUTTON in Baum TTD_KIT */
#define KSBRA            82  /* FTEXT in Baum TTD_KIT */
#define KWBRA            84  /* FTEXT in Baum TTD_KIT */
#define KLBRA            86  /* FTEXT in Baum TTD_KIT */
#define KWABS            88  /* FTEXT in Baum TTD_KIT */
#define KLABS            90  /* FTEXT in Baum TTD_KIT */
#define KWORD            92  /* FTEXT in Baum TTD_KIT */
#define KDIRW            93  /* BUTTON in Baum TTD_KIT */
#define KWABX            94  /* BUTTON in Baum TTD_KIT */
#define KDIRBLOK         95  /* BUTTON in Baum TTD_KIT */
#define KTEXT            97  /* FTEXT in Baum TTD_KIT */
#define KDATA            98  /* FTEXT in Baum TTD_KIT */
#define KBSS             99  /* FTEXT in Baum TTD_KIT */
#define KXDEF            101 /* FTEXT in Baum TTD_KIT */
#define KXREF            102 /* FTEXT in Baum TTD_KIT */
#define KCOMMON          103 /* FTEXT in Baum TTD_KIT */
#define KMODULE          104 /* FTEXT in Baum TTD_KIT */
#define KENDMOD          105 /* FTEXT in Baum TTD_KIT */
#define KEQUATE          106 /* FTEXT in Baum TTD_KIT */
#define KEXTS            109 /* FTEXT in Baum TTD_KIT */
#define KEXTH            111 /* FTEXT in Baum TTD_KIT */
#define KEXTST           113 /* FTEXT in Baum TTD_KIT */
#define KSYSVBLOK        114 /* BUTTON in Baum TTD_KIT */
#define KUSYS            115 /* BUTTON in Baum TTD_KIT */
#define KISYS            116 /* BUTTON in Baum TTD_KIT */
#define KNAMA            118 /* FTEXT in Baum TTD_KIT */
#define KINCA            120 /* FTEXT in Baum TTD_KIT */
#define KINCT            122 /* FTEXT in Baum TTD_KIT */
#define KGNCO            124 /* FTEXT in Baum TTD_KIT */
#define KGNCE            125 /* FTEXT in Baum TTD_KIT */
#define KLNCO            127 /* FTEXT in Baum TTD_KIT */
#define KLNCE            128 /* FTEXT in Baum TTD_KIT */
#define KTODEF           132 /* BUTTON in Baum TTD_KIT */

#define IW               0   /* Alert String */

#define WINDIAL          1   /* Freier String */

#define CREABY           2   /* Freier String */

#define DECO             3   /* Freier String */

#define ERR_REL          4   /* Freier String */

#define I_INDEX          5   /* Freier String */

#define S_IDX            6   /* Freier String */

#define L_SCAN           7   /* Freier String */

#define SEG_STA          8   /* Freier String */

#define EXTLIST          9   /* Freier String */

#define MODSUP           10  /* Freier String */

#define NOTAB            11  /* Freier String */

#define FIXER            12  /* Freier String */

#define DRIHDERR         13  /* Freier String */

#define PCHDERR          14  /* Freier String */

#define TOOSMALL         15  /* Freier String */

#define RANOUT           16  /* Freier String */

#define WINOP            17  /* Freier String */

#define FNW              18  /* Freier String */

#define FNOP             19  /* Freier String */

#define FNF              20  /* Freier String */

#define MWW              21  /* Freier String */

#define S_ASM            22  /* Freier String */

#define EXT_I            23  /* Freier String */

#define S_ASMSEL         24  /* Freier String */

#define MINICONS         25  /* Freier String */

#define P_ADDR           26  /* Freier String */

#define P_ADNM           27  /* Freier String */

#define P_TEXT           28  /* Freier String */

#define P_HEX            29  /* Freier String */

#define NF               30  /* Freier String */

#define NFEXT            31  /* Freier String */

#define SCAN_REL         32  /* Freier String */

#define P_ORG            33  /* Freier String */

#define CARTR            34  /* Freier String */

#define P_RAM            35  /* Freier String */

#define NEED2A           36  /* Freier String */

#define RAM              37  /* Freier String */

#define P_DISK           38  /* Freier String */

#define DISK             39  /* Freier String */

#define BPS              40  /* Freier String */

#define CLSIZ            41  /* Freier String */

#define CLSIZB           42  /* Freier String */

#define RDLEN            43  /* Freier String */

#define FSIZ             44  /* Freier String */

#define FATREC           45  /* Freier String */

#define DATREC           46  /* Freier String */

#define NUMCL            47  /* Freier String */

#define BFLAG            48  /* Freier String */

#define BOOTEX           49  /* Freier String */

#define PPUWARN          50  /* Freier String */

#define LOCATE           51  /* Freier String */

#define SVINDEX          52  /* Freier String */

#define SAVEOB           53  /* Freier String */

#define BROKE            54  /* Freier String */

#define SEGM             55  /* Freier String */

#define DRANGE           56  /* Freier String */

#define TTDCFG           57  /* Freier String */

#define HELPNAME         58  /* Freier String */

#define GUIDENAME        59  /* Freier String */

#define HELPFAIL         60  /* Freier String */

#define NOGUIDE          61  /* Freier String */

#define WNALLOC          62  /* Freier String */

#define FIX_UP           63  /* Freier String */

#define WORD_NAME        64  /* Freier String */

#define SUPERRAM         65  /* Freier String */

#define SUPROOM          66  /* Freier String */

#define LABL_NAME        67  /* Freier String */

#define COMMENT          68  /* Freier String */

#define DUPNAM           69  /* Freier String */

#define TABFUL           70  /* Freier String */

#define NOKEEP           71  /* Freier String */

#define NLDMEM           72  /* Freier String */

#define RETNBY           73  /* Freier String */

#define INVBPB           74  /* Freier String */

#define INVDRV           75  /* Freier String */

#define NOPRG            76  /* Freier String */

#define NAGIDX           77  /* Freier String */

#define NCREIDX          78  /* Freier String */

#define SRTTARG          79  /* Freier String */

#define SYMTITLE         80  /* Freier String */

#define NMEMSORT         81  /* Freier String */

#define EOLIST           82  /* Freier String */

#define XCLOSED          83  /* Freier String */

#define NMEMJPT          84  /* Freier String */

#define LDIDX            85  /* Freier String */

#define OLDSTYLE         86  /* Freier String */

#define SVIDX            87  /* Freier String */

#define TMANM            88  /* Freier String */

#define XSYMTITLE        89  /* Freier String */

#define SRTADDR          90  /* Freier String */

#define INCSAVE          91  /* Freier String */

#define MUSTNAM          92  /* Freier String */

#define GLOBABS          93  /* Freier String */

#define LSYSV            94  /* Freier String */

#define NNAMES           95  /* Freier String */

#define SYMTAB           96  /* Freier String */

#define PROGM            97  /* Freier String */

#define XTRAB            98  /* Freier String */

#define SYSVINC          99  /* Freier String */

#define DELIDX           100 /* Freier String */

#define BMCOM            101 /* Freier String */

#define EXT_F            102 /* Freier String */

#define PRESS            103 /* Freier String */

#define TOSIMG           104 /* Freier String */

#define DRAGDROP         105 /* Freier String */

#define NODROPWIN        106 /* Freier String */

#define GFAM             107 /* Freier String */

#define RELOD            108 /* Freier String */

#define RELOT            109 /* Freier String */
