/* Resource Datei Indizes f�r CALC */

#define AMENU            0   /* Menuebaum */
#define MTDESK           3   /* TITLE in Baum AMENU */
#define MT1              4   /* TITLE in Baum AMENU */
#define MTM              5   /* TITLE in Baum AMENU */
#define MNTITEL          8   /* STRING in Baum AMENU */
#define MNWKS            17  /* STRING in Baum AMENU */
#define MNQUIT           18  /* STRING in Baum AMENU */
#define MNTILE           20  /* STRING in Baum AMENU */
#define MNOVLAP          21  /* STRING in Baum AMENU */
#define MNCYCL           22  /* STRING in Baum AMENU */

#define CMENU            1   /* Menuebaum */
#define MTC1             3   /* TITLE in Baum CMENU */
#define MTCEDIT          4   /* TITLE in Baum CMENU */
#define MNCSAVE          7   /* STRING in Baum CMENU */
#define MNCSAVES         8   /* STRING in Baum CMENU */
#define MNCPRI           10  /* STRING in Baum CMENU */
#define MNCRECALC        11  /* STRING in Baum CMENU */
#define MNCLRV           12  /* STRING in Baum CMENU */
#define MNCSORT          14  /* STRING in Baum CMENU */
#define MNCCLOSE         16  /* STRING in Baum CMENU */
#define MCSHL            18  /* STRING in Baum CMENU */
#define MCSHU            19  /* STRING in Baum CMENU */
#define MCSHR            20  /* STRING in Baum CMENU */
#define MCSHD            21  /* STRING in Baum CMENU */
#define MNCCOPY          22  /* STRING in Baum CMENU */
#define MNCCUT           23  /* STRING in Baum CMENU */
#define MNCDEL           24  /* STRING in Baum CMENU */
#define MNCPASTE         25  /* STRING in Baum CMENU */
#define MNCUNDO          26  /* STRING in Baum CMENU */

#define TITEL            2   /* Formular/Dialog */
#define TEXTS            2   /* BOXTEXT in Baum TITEL */
#define OKT              6   /* BUTTON in Baum TITEL */

#define SH_EDOB          3   /* Formular/Dialog */
#define SH_CSTR          1   /* TEXT in Baum SH_EDOB */
#define SH_TYSTR         2   /* TEXT in Baum SH_EDOB */
#define SH_EDSTR         3   /* FTEXT in Baum SH_EDOB */
#define SH_COSTR         4   /* FTEXT in Baum SH_EDOB */
#define SH_NEW           5   /* FTEXT in Baum SH_EDOB */
#define SH_UPD           6   /* FTEXT in Baum SH_EDOB */

#define FNOP             0   /* Alert String */

#define FNW              1   /* Alert String */

#define ALCHA            2   /* Alert String */

#define WINOP            3   /* Alert String */

#define RANOUT           4   /* Alert String */

#define FNF              5   /* Alert String */
