/* Resource Datei Indizes f�r AHCX */

#define AMENU            0   /* Menuebaum */
#define MTDESK           3   /* TITLE in Baum AMENU */
#define MT1              4   /* TITLE in Baum AMENU */
#define MTM              5   /* TITLE in Baum AMENU */
#define MNTITEL          8   /* STRING in Baum AMENU */
#define MNOPEN           17  /* STRING in Baum AMENU */
#define MNC              18  /* STRING in Baum AMENU */
#define MNH              19  /* STRING in Baum AMENU */
#define MNS              20  /* STRING in Baum AMENU */
#define MNP              21  /* STRING in Baum AMENU */
#define MNOPENB          22  /* STRING in Baum AMENU */
#define MNQUIT           24  /* STRING in Baum AMENU */
#define MNWINDOW         26  /* STRING in Baum AMENU */
#define MNTILE           28  /* STRING in Baum AMENU */
#define MNOVLAP          29  /* STRING in Baum AMENU */
#define MNCYCL           30  /* STRING in Baum AMENU */
#define MNBUF            32  /* STRING in Baum AMENU */
#define MNMULT           34  /* STRING in Baum AMENU */
#define MNFCOMP          35  /* STRING in Baum AMENU */
#define MNHOOKS          36  /* STRING in Baum AMENU */
#define RTUN             38  /* STRING in Baum AMENU */
#define AOPT             39  /* STRING in Baum AMENU */
#define HELP             40  /* STRING in Baum AMENU */

#define TMENU            1   /* Menuebaum */
#define MTT1             3   /* TITLE in Baum TMENU */
#define MTEDITOR         4   /* TITLE in Baum TMENU */
#define MTBUFFER         5   /* TITLE in Baum TMENU */
#define MTSEARCH         6   /* TITLE in Baum TMENU */
#define MNTSAVE          9   /* STRING in Baum TMENU */
#define MNTSAVES         10  /* STRING in Baum TMENU */
#define MNTPRI           12  /* STRING in Baum TMENU */
#define MNTPRISEL        13  /* STRING in Baum TMENU */
#define MNTCLOSE         15  /* STRING in Baum TMENU */
#define MNTABAN          16  /* STRING in Baum TMENU */
#define MNUNDO           18  /* STRING in Baum TMENU */
#define MNCRLF           19  /* STRING in Baum TMENU */
#define MNFICHA          20  /* STRING in Baum TMENU */
#define MNSHL            22  /* STRING in Baum TMENU */
#define MNSHR            23  /* STRING in Baum TMENU */
#define MNRETAB          24  /* STRING in Baum TMENU */
#define MNUPR            26  /* STRING in Baum TMENU */
#define MNLWR            27  /* STRING in Baum TMENU */
#define MNREPL           29  /* STRING in Baum TMENU */
#define MNREPSAM         30  /* STRING in Baum TMENU */
#define MNCUT            32  /* STRING in Baum TMENU */
#define MNCUTAP          33  /* STRING in Baum TMENU */
#define MNCOPY           34  /* STRING in Baum TMENU */
#define MNCOPYAP         35  /* STRING in Baum TMENU */
#define MNPASTE          36  /* STRING in Baum TMENU */
#define MNFIND           38  /* STRING in Baum TMENU */
#define MNFISAM          39  /* STRING in Baum TMENU */
#define MNFIRSAM         40  /* STRING in Baum TMENU */
#define MNFISEL          41  /* STRING in Baum TMENU */
#define MNFISELM         42  /* STRING in Baum TMENU */
#define MNSELALL         43  /* STRING in Baum TMENU */
#define MNFICU           45  /* STRING in Baum TMENU */
#define MNFIES           46  /* STRING in Baum TMENU */
#define MNGOTL           47  /* STRING in Baum TMENU */
#define MNCOMPARE        49  /* STRING in Baum TMENU */
#define MNBRACE          50  /* STRING in Baum TMENU */

#define JOURNAL          2   /* Menuebaum */
#define MTJ1             3   /* TITLE in Baum JOURNAL */
#define MTJS             4   /* TITLE in Baum JOURNAL */
#define MNJSAVES         7   /* STRING in Baum JOURNAL */
#define MNJPRI           9   /* STRING in Baum JOURNAL */
#define MNJPRIS          10  /* STRING in Baum JOURNAL */
#define MNJCLOSE         12  /* STRING in Baum JOURNAL */
#define MNJFIND          14  /* STRING in Baum JOURNAL */
#define MNJFISAM         15  /* STRING in Baum JOURNAL */
#define MNJFIRSAM        16  /* STRING in Baum JOURNAL */
#define MNJFISEL         17  /* STRING in Baum JOURNAL */
#define MNJFISELMPL      18  /* STRING in Baum JOURNAL */
#define MNJSELALL        19  /* STRING in Baum JOURNAL */
#define MNJCOPY          21  /* STRING in Baum JOURNAL */
#define MNJFICU          22  /* STRING in Baum JOURNAL */
#define MNJFIES          23  /* STRING in Baum JOURNAL */

#define TITEL            3   /* Formular/Dialog */
#define TEXTS            2   /* BOXTEXT in Baum TITEL */
#define OKT              6   /* BUTTON in Baum TITEL */

#define KIT              4   /* Formular/Dialog */
#define KIT1             0   /* BOX in Baum KIT */
#define DFBLOK           1   /* BUTTON in Baum KIT */
#define EDBUTBLOK        3   /* IBOX in Baum KIT */
#define DFB1             4   /* BUTTON in Baum KIT */
#define DFB2             5   /* BUTTON in Baum KIT */
#define DFB3             6   /* BUTTON in Baum KIT */
#define DFB4             7   /* BUTTON in Baum KIT */
#define DFB5             8   /* BUTTON in Baum KIT */
#define DFB6             9   /* BUTTON in Baum KIT */
#define DFB7             10  /* BUTTON in Baum KIT */
#define DFB8             11  /* BUTTON in Baum KIT */
#define DFB9             12  /* BUTTON in Baum KIT */
#define DFB10            13  /* BUTTON in Baum KIT */
#define EDCURBLOK        14  /* IBOX in Baum KIT */
#define DFS1             15  /* FTEXT in Baum KIT */
#define DFS2             16  /* FTEXT in Baum KIT */
#define DFS3             17  /* FTEXT in Baum KIT */
#define DFS4             18  /* FTEXT in Baum KIT */
#define DFS5             19  /* FTEXT in Baum KIT */
#define DFS6             20  /* FTEXT in Baum KIT */
#define DFS7             21  /* FTEXT in Baum KIT */
#define DFS8             22  /* FTEXT in Baum KIT */
#define DFS9             23  /* FTEXT in Baum KIT */
#define DFS10            24  /* FTEXT in Baum KIT */
#define DSALL            27  /* BUTTON in Baum KIT */
#define DSREPSTR         28  /* FTEXT in Baum KIT */
#define DSBTNS           29  /* IBOX in Baum KIT */
#define DSRADIO          30  /* IBOX in Baum KIT */
#define DSTOPW           31  /* BUTTON in Baum KIT */
#define DSMULT           32  /* BUTTON in Baum KIT */
#define DSW              35  /* BUTTON in Baum KIT */
#define DSANY            36  /* BUTTON in Baum KIT */
#define DSPRE            37  /* BUTTON in Baum KIT */
#define DSPOST           38  /* BUTTON in Baum KIT */
#define DSCASE           39  /* BUTTON in Baum KIT */
#define DSRICH           40  /* IBOX in Baum KIT */
#define DSBCKWRD         41  /* BUTTON in Baum KIT */
#define DSFORWRD         42  /* BUTTON in Baum KIT */
#define DSSURND          43  /* BUTTON in Baum KIT */
#define DSMULBLOK        44  /* IBOX in Baum KIT */
#define DSMULSTR         45  /* FTEXT in Baum KIT */
#define DSMULXTR         46  /* FTEXT in Baum KIT */
#define DSMDEEP          47  /* BUTTON in Baum KIT */
#define DSMTALK          48  /* BUTTON in Baum KIT */
#define DSMONCE          49  /* BUTTON in Baum KIT */
#define DCFBLOK          50  /* BUTTON in Baum KIT */
#define DSCPF1STR        52  /* FTEXT in Baum KIT */
#define DSCPF1XTR        53  /* FTEXT in Baum KIT */
#define DSCPF2STR        55  /* FTEXT in Baum KIT */
#define DSCPF2XTR        56  /* FTEXT in Baum KIT */
#define DSFDEEP          58  /* BUTTON in Baum KIT */
#define DCFOK            59  /* BUTTON in Baum KIT */
#define DSCBLOK          60  /* BUTTON in Baum KIT */
#define SCSPLIT          61  /* FTEXT in Baum KIT */
#define SCTABS           62  /* FTEXT in Baum KIT */
#define SCAUTOI          63  /* BUTTON in Baum KIT */
#define SCVISTAB         64  /* FTEXT in Baum KIT */
#define SCFONT           65  /* BUTTON in Baum KIT */
#define SCTRAIL          66  /* BUTTON in Baum KIT */
#define SCBOLD           67  /* BUTTON in Baum KIT */
#define SCVARR           69  /* FTEXT in Baum KIT */
#define SCV              71  /* BUTTON in Baum KIT */
#define SCVGRT           72  /* FTEXT in Baum KIT */
#define SCVGRN           74  /* FTEXT in Baum KIT */
#define SCHARR           76  /* FTEXT in Baum KIT */
#define SCH              78  /* BUTTON in Baum KIT */
#define SCHGRT           79  /* FTEXT in Baum KIT */
#define SCHGRN           81  /* FTEXT in Baum KIT */
#define DLINBLOK         83  /* IBOX in Baum KIT */
#define DSLNNR           84  /* FTEXT in Baum KIT */
#define RETABBLOK        85  /* BUTTON in Baum KIT */
#define SCTABNEW         86  /* FTEXT in Baum KIT */
#define SCTABLEAD        87  /* BUTTON in Baum KIT */
#define SCTABPHYS        88  /* FTEXT in Baum KIT */
#define DHKSBLOK         89  /* BUTTON in Baum KIT */
#define HKSWL0           91  /* FTEXT in Baum KIT */
#define HKSWR0           92  /* FTEXT in Baum KIT */
#define HKSWL1           93  /* FTEXT in Baum KIT */
#define HKSWR1           94  /* FTEXT in Baum KIT */
#define HKSWL2           95  /* FTEXT in Baum KIT */
#define HKSWR2           96  /* FTEXT in Baum KIT */
#define HKSWL3           97  /* FTEXT in Baum KIT */
#define HKSWR3           98  /* FTEXT in Baum KIT */
#define HKSWL4           99  /* FTEXT in Baum KIT */
#define HKSWR4           100 /* FTEXT in Baum KIT */
#define HKSWL5           101 /* FTEXT in Baum KIT */
#define HKSWR5           102 /* FTEXT in Baum KIT */
#define HKSWL6           103 /* FTEXT in Baum KIT */
#define HKSWR6           104 /* FTEXT in Baum KIT */
#define HKSWL7           105 /* FTEXT in Baum KIT */
#define HKSWR7           106 /* FTEXT in Baum KIT */
#define HKSWL8           107 /* FTEXT in Baum KIT */
#define HKSWR8           108 /* FTEXT in Baum KIT */
#define HKSWL9           109 /* FTEXT in Baum KIT */
#define HKSWR9           110 /* FTEXT in Baum KIT */
#define HKSCASE          111 /* BUTTON in Baum KIT */
#define KIT_MAX          121 /* TEXT in Baum KIT */

#define BOLDTAGS         5   /* Formular/Dialog */

#define IW               0   /* Alert String */

#define ABCHA            1   /* Alert String */

#define ALCHA            2   /* Alert String */

#define BEMP             3   /* Alert String */

#define INCTAB           4   /* Alert String */

#define WINDIAL          5   /* Freier String */

#define FNF              6   /* Freier String */

#define FNOP             7   /* Freier String */

#define FNW              8   /* Freier String */

#define WINOP            9   /* Freier String */

#define RANOUT           10  /* Freier String */

#define LLONG            11  /* Freier String */

#define ROMW             12  /* Freier String */

#define HELPNAME         13  /* Freier String */

#define GUIDENAME        14  /* Freier String */

#define HELPFAIL         15  /* Freier String */

#define NOGUIDE          16  /* Freier String */

#define ALMOD            17  /* Freier String */

#define DROPWIN          18  /* Freier String */

#define DRAGDROP         19  /* Freier String */
