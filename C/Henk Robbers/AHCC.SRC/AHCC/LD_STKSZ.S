
		xdef _StkSize
offset
		 ds.b 4096
_StkSize:
end
