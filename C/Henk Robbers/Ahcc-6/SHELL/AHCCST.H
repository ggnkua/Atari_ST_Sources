/* Resource Datei Indizes f�r AHCCST */

#define AMENU            0   /* Menuebaum */
#define MTDESK           3   /* TITLE in Baum AMENU */
#define MT1              4   /* TITLE in Baum AMENU */
#define MTM              5   /* TITLE in Baum AMENU */
#define MTPRJS           6   /* TITLE in Baum AMENU */
#define MTPRJ            7   /* TITLE in Baum AMENU */
#define MTDEBUG          8   /* TITLE in Baum AMENU */
#define MNTITEL          11  /* STRING in Baum AMENU */
#define MNOPEN           20  /* STRING in Baum AMENU */
#define MNC              21  /* STRING in Baum AMENU */
#define MNH              22  /* STRING in Baum AMENU */
#define MNS              23  /* STRING in Baum AMENU */
#define MNP              24  /* STRING in Baum AMENU */
#define MNQUIT           26  /* STRING in Baum AMENU */
#define MNWINDOW         28  /* STRING in Baum AMENU */
#define MNTILE           30  /* STRING in Baum AMENU */
#define MNOVLAP          31  /* STRING in Baum AMENU */
#define MNCYCL           32  /* STRING in Baum AMENU */
#define MNFKEYS          34  /* STRING in Baum AMENU */
#define MNBUF            35  /* STRING in Baum AMENU */
#define MNMULT           37  /* STRING in Baum AMENU */
#define MNFCOMP          38  /* STRING in Baum AMENU */
#define MNHOOKS          39  /* STRING in Baum AMENU */
#define RTUN             41  /* STRING in Baum AMENU */
#define AOPT             42  /* STRING in Baum AMENU */
#define MNLMAKE          44  /* STRING in Baum AMENU */
#define MNEDPRJ          46  /* STRING in Baum AMENU */
#define MNRELOAD         47  /* STRING in Baum AMENU */
#define MNCOOPT          49  /* STRING in Baum AMENU */
#define MNDOWN           50  /* STRING in Baum AMENU */
#define MNPROJ           51  /* STRING in Baum AMENU */
#define MNPRJD           52  /* STRING in Baum AMENU */
#define MNCOMP           54  /* STRING in Baum AMENU */
#define MNCOMPF          55  /* STRING in Baum AMENU */
#define MNASSEMF         56  /* STRING in Baum AMENU */
#define MNMAKE           58  /* STRING in Baum AMENU */
#define MNMAKEAL         59  /* STRING in Baum AMENU */
#define MNLINK           60  /* STRING in Baum AMENU */
#define CODBG            62  /* STRING in Baum AMENU */
#define CONDBG           63  /* STRING in Baum AMENU */
#define DBGTXT           64  /* STRING in Baum AMENU */

#define TMENU            1   /* Menuebaum */
#define MTT1             3   /* TITLE in Baum TMENU */
#define MTEDITOR         4   /* TITLE in Baum TMENU */
#define MTBUFFER         5   /* TITLE in Baum TMENU */
#define MTSEARCH         6   /* TITLE in Baum TMENU */
#define MNTSAVE          9   /* STRING in Baum TMENU */
#define MNTSAVES         10  /* STRING in Baum TMENU */
#define MNTPRI           12  /* STRING in Baum TMENU */
#define MNTPRISEL        13  /* STRING in Baum TMENU */
#define MNTCLOSE         15  /* STRING in Baum TMENU */
#define MNTABAN          16  /* STRING in Baum TMENU */
#define MNUNDO           18  /* STRING in Baum TMENU */
#define MNCRLF           19  /* STRING in Baum TMENU */
#define MNFICHA          20  /* STRING in Baum TMENU */
#define MNSHL            22  /* STRING in Baum TMENU */
#define MNSHR            23  /* STRING in Baum TMENU */
#define MNRETAB          24  /* STRING in Baum TMENU */
#define MNUPR            26  /* STRING in Baum TMENU */
#define MNLWR            27  /* STRING in Baum TMENU */
#define MNREPL           29  /* STRING in Baum TMENU */
#define MNREPSAM         30  /* STRING in Baum TMENU */
#define MNCUT            32  /* STRING in Baum TMENU */
#define MNCUTAP          33  /* STRING in Baum TMENU */
#define MNCOPY           34  /* STRING in Baum TMENU */
#define MNCOPYAP         35  /* STRING in Baum TMENU */
#define MNPASTE          36  /* STRING in Baum TMENU */
#define MNHELP           38  /* STRING in Baum TMENU */
#define MNFIND           40  /* STRING in Baum TMENU */
#define MNFISAM          41  /* STRING in Baum TMENU */
#define MNFIRSAM         42  /* STRING in Baum TMENU */
#define MNFISEL          43  /* STRING in Baum TMENU */
#define MNFISELM         44  /* STRING in Baum TMENU */
#define MNFISELP         45  /* STRING in Baum TMENU */
#define MNSELALL         46  /* STRING in Baum TMENU */
#define MNCOMPARE        48  /* STRING in Baum TMENU */
#define MNFICU           49  /* STRING in Baum TMENU */
#define MNFIES           50  /* STRING in Baum TMENU */
#define MNGOTL           51  /* STRING in Baum TMENU */
#define MNBRACE          52  /* STRING in Baum TMENU */

#define JOURNAL          2   /* Menuebaum */
#define MTJ1             3   /* TITLE in Baum JOURNAL */
#define MTJS             4   /* TITLE in Baum JOURNAL */
#define MNJSAVES         7   /* STRING in Baum JOURNAL */
#define MNJPRI           9   /* STRING in Baum JOURNAL */
#define MNJPRIS          10  /* STRING in Baum JOURNAL */
#define MNJCLOSE         12  /* STRING in Baum JOURNAL */
#define MNJFIND          14  /* STRING in Baum JOURNAL */
#define MNJFISAM         15  /* STRING in Baum JOURNAL */
#define MNJFIRSAM        16  /* STRING in Baum JOURNAL */
#define MNJFISEL         17  /* STRING in Baum JOURNAL */
#define MNJFISELMPL      18  /* STRING in Baum JOURNAL */
#define MNJFISELPRJ      19  /* STRING in Baum JOURNAL */
#define MNJSELALL        20  /* STRING in Baum JOURNAL */
#define MNJHELP          22  /* STRING in Baum JOURNAL */
#define MNJUNDO          23  /* STRING in Baum JOURNAL */
#define MNJCOPY          24  /* STRING in Baum JOURNAL */
#define MNJFICU          25  /* STRING in Baum JOURNAL */
#define MNJFIES          26  /* STRING in Baum JOURNAL */

#define KIT              3   /* Formular/Dialog */
#define KIT1             0   /* BOX in Baum KIT */
#define DFBLOK           1   /* BUTTON in Baum KIT */
#define EDBUTBLOK        3   /* IBOX in Baum KIT */
#define DFB1             4   /* BUTTON in Baum KIT */
#define DFB2             5   /* BUTTON in Baum KIT */
#define DFB3             6   /* BUTTON in Baum KIT */
#define DFB4             7   /* BUTTON in Baum KIT */
#define DFB5             8   /* BUTTON in Baum KIT */
#define DFB6             9   /* BUTTON in Baum KIT */
#define DFB7             10  /* BUTTON in Baum KIT */
#define DFB8             11  /* BUTTON in Baum KIT */
#define DFB9             12  /* BUTTON in Baum KIT */
#define DFB10            13  /* BUTTON in Baum KIT */
#define EDCURBLOK        14  /* IBOX in Baum KIT */
#define DFS1             15  /* FTEXT in Baum KIT */
#define DFS2             16  /* FTEXT in Baum KIT */
#define DFS3             17  /* FTEXT in Baum KIT */
#define DFS4             18  /* FTEXT in Baum KIT */
#define DFS5             19  /* FTEXT in Baum KIT */
#define DFS6             20  /* FTEXT in Baum KIT */
#define DFS7             21  /* FTEXT in Baum KIT */
#define DFS8             22  /* FTEXT in Baum KIT */
#define DFS9             23  /* FTEXT in Baum KIT */
#define DFS10            24  /* FTEXT in Baum KIT */
#define DSALL            27  /* BUTTON in Baum KIT */
#define DSREPSTR         28  /* FTEXT in Baum KIT */
#define DSBTNS           29  /* IBOX in Baum KIT */
#define DSRADIO          30  /* IBOX in Baum KIT */
#define DSTOPW           31  /* BUTTON in Baum KIT */
#define DSPROJ           32  /* BUTTON in Baum KIT */
#define DSMULT           33  /* BUTTON in Baum KIT */
#define DSW              36  /* BUTTON in Baum KIT */
#define DSANY            37  /* BUTTON in Baum KIT */
#define DSPRE            38  /* BUTTON in Baum KIT */
#define DSPOST           39  /* BUTTON in Baum KIT */
#define DSCASE           40  /* BUTTON in Baum KIT */
#define DSRICH           41  /* IBOX in Baum KIT */
#define DSBCKWRD         42  /* BUTTON in Baum KIT */
#define DSFORWRD         43  /* BUTTON in Baum KIT */
#define DSSURND          44  /* BUTTON in Baum KIT */
#define DSMULBLOK        45  /* IBOX in Baum KIT */
#define DSMULSTR         46  /* FTEXT in Baum KIT */
#define DSMULXTR         47  /* FTEXT in Baum KIT */
#define DSMDEEP          48  /* BUTTON in Baum KIT */
#define DSMTALK          49  /* BUTTON in Baum KIT */
#define DSMONCE          50  /* BUTTON in Baum KIT */
#define DCFBLOK          51  /* BUTTON in Baum KIT */
#define DSCPF1STR        53  /* FTEXT in Baum KIT */
#define DSCPF1XTR        54  /* FTEXT in Baum KIT */
#define DSCPF2STR        56  /* FTEXT in Baum KIT */
#define DSCPF2XTR        57  /* FTEXT in Baum KIT */
#define DSFDEEP          59  /* BUTTON in Baum KIT */
#define DCFOK            60  /* BUTTON in Baum KIT */
#define DSCBLOK          61  /* BUTTON in Baum KIT */
#define SCSPLIT          62  /* FTEXT in Baum KIT */
#define SCTABS           63  /* FTEXT in Baum KIT */
#define SCAUTOI          64  /* BUTTON in Baum KIT */
#define SCVISTAB         65  /* FTEXT in Baum KIT */
#define SCFONT           66  /* BUTTON in Baum KIT */
#define SCTRAIL          67  /* BUTTON in Baum KIT */
#define SCBOLD           68  /* BUTTON in Baum KIT */
#define SCVARR           70  /* FTEXT in Baum KIT */
#define SCV              72  /* BUTTON in Baum KIT */
#define SCVGRT           73  /* FTEXT in Baum KIT */
#define SCVGRN           75  /* FTEXT in Baum KIT */
#define SCHARR           77  /* FTEXT in Baum KIT */
#define SCH              79  /* BUTTON in Baum KIT */
#define SCHGRT           80  /* FTEXT in Baum KIT */
#define SCHGRN           82  /* FTEXT in Baum KIT */
#define DLINBLOK         84  /* IBOX in Baum KIT */
#define DSLNNR           85  /* FTEXT in Baum KIT */
#define RETABBLOK        86  /* BUTTON in Baum KIT */
#define SCTABNEW         87  /* FTEXT in Baum KIT */
#define SCTABLEAD        88  /* BUTTON in Baum KIT */
#define SCTABPHYS        89  /* FTEXT in Baum KIT */
#define DHKSBLOK         90  /* BUTTON in Baum KIT */
#define HKSWL0           92  /* FTEXT in Baum KIT */
#define HKSWR0           93  /* FTEXT in Baum KIT */
#define HKSWL1           94  /* FTEXT in Baum KIT */
#define HKSWR1           95  /* FTEXT in Baum KIT */
#define HKSWL2           96  /* FTEXT in Baum KIT */
#define HKSWR2           97  /* FTEXT in Baum KIT */
#define HKSWL3           98  /* FTEXT in Baum KIT */
#define HKSWR3           99  /* FTEXT in Baum KIT */
#define HKSWL4           100 /* FTEXT in Baum KIT */
#define HKSWR4           101 /* FTEXT in Baum KIT */
#define HKSWL5           102 /* FTEXT in Baum KIT */
#define HKSWR5           103 /* FTEXT in Baum KIT */
#define HKSWL6           104 /* FTEXT in Baum KIT */
#define HKSWR6           105 /* FTEXT in Baum KIT */
#define HKSWL7           106 /* FTEXT in Baum KIT */
#define HKSWR7           107 /* FTEXT in Baum KIT */
#define HKSWL8           108 /* FTEXT in Baum KIT */
#define HKSWR8           109 /* FTEXT in Baum KIT */
#define HKSWL9           110 /* FTEXT in Baum KIT */
#define HKSWR9           111 /* FTEXT in Baum KIT */
#define HKSCASE          112 /* BUTTON in Baum KIT */
#define LOPBLOK          122 /* BUTTON in Baum KIT */
#define COG              123 /* BUTTON in Baum KIT */
#define COSY             124 /* BUTTON in Baum KIT */
#define COT              125 /* BUTTON in Baum KIT */
#define COL              126 /* BUTTON in Baum KIT */
#define COFL             127 /* BUTTON in Baum KIT */
#define COJ              128 /* BUTTON in Baum KIT */
#define COMST            129 /* BUTTON in Baum KIT */
#define COLST            130 /* BUTTON in Baum KIT */
#define COLIB            131 /* BUTTON in Baum KIT */
#define COLIBDIR         132 /* FTEXT in Baum KIT */
#define KIT_MAX          133 /* TEXT in Baum KIT */
#define OPTBLOK          134 /* IBOX in Baum KIT */
#define SOPBLOK          135 /* BUTTON in Baum KIT */
#define COV0             136 /* BUTTON in Baum KIT */
#define COV1             137 /* BUTTON in Baum KIT */
#define COV2             138 /* BUTTON in Baum KIT */
#define COV3             139 /* BUTTON in Baum KIT */
#define COPH             140 /* BUTTON in Baum KIT */
#define COAP             141 /* BUTTON in Baum KIT */
#define COH              142 /* BUTTON in Baum KIT */
#define COINH            143 /* BUTTON in Baum KIT */
#define CODM             144 /* BUTTON in Baum KIT */
#define COMATCH          145 /* FTEXT in Baum KIT */
#define AH1              146 /* BUTTON in Baum KIT */
#define DOPBLOK          147 /* BUTTON in Baum KIT */
#define COC              148 /* BUTTON in Baum KIT */
#define COGO             149 /* BUTTON in Baum KIT */
#define COK              150 /* BUTTON in Baum KIT */
#define CO2              151 /* BUTTON in Baum KIT */
#define CORP             152 /* BUTTON in Baum KIT */
#define CO8              153 /* BUTTON in Baum KIT */
#define CO32             154 /* BUTTON in Baum KIT */
#define CO1              155 /* BUTTON in Baum KIT */
#define COXNL            156 /* BUTTON in Baum KIT */
#define COSUP            157 /* BUTTON in Baum KIT */
#define COE              158 /* BUTTON in Baum KIT */
#define COEN             159 /* FTEXT in Baum KIT */
#define COF              160 /* BUTTON in Baum KIT */
#define COWN             161 /* FTEXT in Baum KIT */
#define COD              163 /* BUTTON in Baum KIT */
#define CODEF            164 /* FTEXT in Baum KIT */
#define COD1             165 /* BUTTON in Baum KIT */
#define CODEF1           166 /* FTEXT in Baum KIT */
#define COD2             167 /* BUTTON in Baum KIT */
#define CODEF2           168 /* FTEXT in Baum KIT */
#define COD3             169 /* BUTTON in Baum KIT */
#define CODEF3           170 /* FTEXT in Baum KIT */
#define COD4             171 /* BUTTON in Baum KIT */
#define CODEF4           172 /* FTEXT in Baum KIT */
#define COI              174 /* BUTTON in Baum KIT */
#define COINCL           175 /* FTEXT in Baum KIT */
#define COI1             176 /* BUTTON in Baum KIT */
#define COINCL1          177 /* FTEXT in Baum KIT */
#define COI2             178 /* BUTTON in Baum KIT */
#define COINCL2          179 /* FTEXT in Baum KIT */
#define COI3             180 /* BUTTON in Baum KIT */
#define COINCL3          181 /* FTEXT in Baum KIT */
#define COI4             182 /* BUTTON in Baum KIT */
#define COINCL4          183 /* FTEXT in Baum KIT */

#define BUGGER           4   /* Formular/Dialog */
#define B2MOVER          1   /* STRING in Baum BUGGER */
#define COKL             2   /* BUTTON in Baum BUGGER */
#define CONN             3   /* BUTTON in Baum BUGGER */
#define COX              6   /* BUTTON in Baum BUGGER */
#define COXL             7   /* FTEXT in Baum BUGGER */
#define COY              9   /* BUTTON in Baum BUGGER */
#define COYL             10  /* FTEXT in Baum BUGGER */
#define COA              11  /* BUTTON in Baum BUGGER */
#define COZ              12  /* BUTTON in Baum BUGGER */
#define COLN             13  /* BUTTON in Baum BUGGER */
#define COSL             14  /* BUTTON in Baum BUGGER */
#define B2BTNS           15  /* IBOX in Baum BUGGER */
#define B2CANC           16  /* BUTTON in Baum BUGGER */
#define B2OK             17  /* BUTTON in Baum BUGGER */

#define IW               0   /* Alert String */

#define ABCHA            1   /* Alert String */

#define ALCHA            2   /* Alert String */

#define BEMP             3   /* Alert String */

#define INITDIR          4   /* Freier String */

#define WINDIAL          5   /* Freier String */

#define FNF              6   /* Freier String */

#define FNOP             7   /* Freier String */

#define FNW              8   /* Freier String */

#define WINOP            9   /* Freier String */

#define RANOUT           10  /* Freier String */

#define LLONG            11  /* Freier String */

#define ROMW             12  /* Freier String */

#define DRAGDROP         13  /* Freier String */

#define ALMOD            14  /* Freier String */
