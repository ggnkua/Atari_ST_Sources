/* Resource Datei Indizes f�r AHCC */

#define AMENU            0   /* Menuebaum */
#define MTDESK           3   /* TITLE in Baum AMENU */
#define MT1              4   /* TITLE in Baum AMENU */
#define MTM              5   /* TITLE in Baum AMENU */
#define MTPRJS           6   /* TITLE in Baum AMENU */
#define MTPRJ            7   /* TITLE in Baum AMENU */
#define MTDEBUG          8   /* TITLE in Baum AMENU */
#define MNTITEL          11  /* STRING in Baum AMENU */
#define MNOPEN           20  /* STRING in Baum AMENU */
#define MNC              21  /* STRING in Baum AMENU */
#define MNH              22  /* STRING in Baum AMENU */
#define MNS              23  /* STRING in Baum AMENU */
#define MNP              24  /* STRING in Baum AMENU */
#define MNQUIT           26  /* STRING in Baum AMENU */
#define MNWINDOW         28  /* STRING in Baum AMENU */
#define MNTILE           30  /* STRING in Baum AMENU */
#define MNOVLAP          31  /* STRING in Baum AMENU */
#define MNCYCL           32  /* STRING in Baum AMENU */
#define MNFKEYS          34  /* STRING in Baum AMENU */
#define MNBUF            35  /* STRING in Baum AMENU */
#define MNMULT           37  /* STRING in Baum AMENU */
#define MNFOLDERS        38  /* STRING in Baum AMENU */
#define MNFCOMP          39  /* STRING in Baum AMENU */
#define MNHOOKS          40  /* STRING in Baum AMENU */
#define RTUN             42  /* STRING in Baum AMENU */
#define AOPT             43  /* STRING in Baum AMENU */
#define HELP             44  /* STRING in Baum AMENU */
#define MNLMAKE          46  /* STRING in Baum AMENU */
#define MNDMAKE          47  /* STRING in Baum AMENU */
#define MNLFOLD          48  /* STRING in Baum AMENU */
#define MNEDPRJ          50  /* STRING in Baum AMENU */
#define MNRELOAD         51  /* STRING in Baum AMENU */
#define MNCOOPT          53  /* STRING in Baum AMENU */
#define MNDOWN           54  /* STRING in Baum AMENU */
#define MNPROJ           55  /* STRING in Baum AMENU */
#define MNPRJD           56  /* STRING in Baum AMENU */
#define MNPRJT           57  /* STRING in Baum AMENU */
#define MNCOMP           59  /* STRING in Baum AMENU */
#define MNCOMPF          60  /* STRING in Baum AMENU */
#define MNMAKE           62  /* STRING in Baum AMENU */
#define MNMAKEAL         63  /* STRING in Baum AMENU */
#define MNLINK           64  /* STRING in Baum AMENU */
#define CODBG            66  /* STRING in Baum AMENU */
#define MNTOKS           67  /* STRING in Baum AMENU */
#define CONDBG           68  /* STRING in Baum AMENU */
#define DBGTXT           69  /* STRING in Baum AMENU */

#define TMENU            1   /* Menuebaum */
#define MTT1             3   /* TITLE in Baum TMENU */
#define MTEDITOR         4   /* TITLE in Baum TMENU */
#define MTBUFFER         5   /* TITLE in Baum TMENU */
#define MTSEARCH         6   /* TITLE in Baum TMENU */
#define MNTSAVE          9   /* STRING in Baum TMENU */
#define MNTSAVES         10  /* STRING in Baum TMENU */
#define MNTPRI           12  /* STRING in Baum TMENU */
#define MNTPRISEL        13  /* STRING in Baum TMENU */
#define MNTCLOSE         15  /* STRING in Baum TMENU */
#define MNTABAN          16  /* STRING in Baum TMENU */
#define MNUNDO           18  /* STRING in Baum TMENU */
#define MNCRLF           19  /* STRING in Baum TMENU */
#define MNFICHA          20  /* STRING in Baum TMENU */
#define MNSHL            22  /* STRING in Baum TMENU */
#define MNSHR            23  /* STRING in Baum TMENU */
#define MNRETAB          24  /* STRING in Baum TMENU */
#define MNUPR            26  /* STRING in Baum TMENU */
#define MNLWR            27  /* STRING in Baum TMENU */
#define MNREPL           29  /* STRING in Baum TMENU */
#define MNREPSAM         30  /* STRING in Baum TMENU */
#define MNCUT            32  /* STRING in Baum TMENU */
#define MNCUTAP          33  /* STRING in Baum TMENU */
#define MNCOPY           34  /* STRING in Baum TMENU */
#define MNCOPYAP         35  /* STRING in Baum TMENU */
#define MNPASTE          36  /* STRING in Baum TMENU */
#define MNHELP           38  /* STRING in Baum TMENU */
#define MNFIND           40  /* STRING in Baum TMENU */
#define MNFISAM          41  /* STRING in Baum TMENU */
#define MNFIRSAM         42  /* STRING in Baum TMENU */
#define MNFISEL          43  /* STRING in Baum TMENU */
#define MNFISELM         44  /* STRING in Baum TMENU */
#define MNFISELP         45  /* STRING in Baum TMENU */
#define MNSELALL         46  /* STRING in Baum TMENU */
#define MNCOMPARE        48  /* STRING in Baum TMENU */
#define MNFICU           49  /* STRING in Baum TMENU */
#define MNFIES           50  /* STRING in Baum TMENU */
#define MNGOTL           51  /* STRING in Baum TMENU */
#define MNBRACE          52  /* STRING in Baum TMENU */

#define JOURNAL          2   /* Menuebaum */
#define MTJ1             3   /* TITLE in Baum JOURNAL */
#define MTJS             4   /* TITLE in Baum JOURNAL */
#define MNJSAVES         7   /* STRING in Baum JOURNAL */
#define MNJCALC          8   /* STRING in Baum JOURNAL */
#define MNJDEP           10  /* STRING in Baum JOURNAL */
#define MNJFU            11  /* STRING in Baum JOURNAL */
#define MNJPRI           12  /* STRING in Baum JOURNAL */
#define MNJPRIS          13  /* STRING in Baum JOURNAL */
#define MNJCLOSE         15  /* STRING in Baum JOURNAL */
#define MNJFIND          17  /* STRING in Baum JOURNAL */
#define MNJFISAM         18  /* STRING in Baum JOURNAL */
#define MNJFIRSAM        19  /* STRING in Baum JOURNAL */
#define MNJFISEL         20  /* STRING in Baum JOURNAL */
#define MNJFISELMPL      21  /* STRING in Baum JOURNAL */
#define MNJFISELPRJ      22  /* STRING in Baum JOURNAL */
#define MNJSELALL        23  /* STRING in Baum JOURNAL */
#define MNJHELP          25  /* STRING in Baum JOURNAL */
#define MNJUNDO          26  /* STRING in Baum JOURNAL */
#define MNJCOPY          27  /* STRING in Baum JOURNAL */
#define MNJFICU          28  /* STRING in Baum JOURNAL */
#define MNJFIES          29  /* STRING in Baum JOURNAL */

#define BUGGER           3   /* Formular/Dialog */
#define B2MOVER          1   /* STRING in Baum BUGGER */
#define COLN             2   /* BUTTON in Baum BUGGER */
#define CONN             3   /* BUTTON in Baum BUGGER */
#define COSL             4   /* BUTTON in Baum BUGGER */
#define COX              7   /* BUTTON in Baum BUGGER */
#define COXL             8   /* FTEXT in Baum BUGGER */
#define COY              10  /* BUTTON in Baum BUGGER */
#define COYL             11  /* FTEXT in Baum BUGGER */
#define COA              12  /* BUTTON in Baum BUGGER */
#define COZ              13  /* BUTTON in Baum BUGGER */
#define B2BTNS           14  /* IBOX in Baum BUGGER */
#define B2CANC           15  /* BUTTON in Baum BUGGER */
#define B2OK             16  /* BUTTON in Baum BUGGER */

#define KIT              4   /* Formular/Dialog */
#define KIT1             0   /* BOX in Baum KIT */
#define DFBLOK           1   /* BUTTON in Baum KIT */
#define DSBTNS           2   /* IBOX in Baum KIT */
#define DSRADIO          3   /* IBOX in Baum KIT */
#define DSTOPW           4   /* BUTTON in Baum KIT */
#define DSPROJ           5   /* BUTTON in Baum KIT */
#define DSMULT           6   /* BUTTON in Baum KIT */
#define DSCASE           7   /* BUTTON in Baum KIT */
#define DSRICH           8   /* IBOX in Baum KIT */
#define DSBCKWRD         9   /* BUTTON in Baum KIT */
#define DSFORWRD         10  /* BUTTON in Baum KIT */
#define DSSURND          11  /* BUTTON in Baum KIT */
#define DSW              13  /* BUTTON in Baum KIT */
#define DSANY            14  /* BUTTON in Baum KIT */
#define DSPRE            15  /* BUTTON in Baum KIT */
#define DSPOST           16  /* BUTTON in Baum KIT */
#define DSMULBLOK        17  /* IBOX in Baum KIT */
#define DSMULSTR         18  /* FTEXT in Baum KIT */
#define DSMULXTR         19  /* FTEXT in Baum KIT */
#define DSMDEEP          20  /* BUTTON in Baum KIT */
#define DSMTALK          21  /* BUTTON in Baum KIT */
#define DSMONCE          22  /* BUTTON in Baum KIT */
#define EDBUTBLOK        24  /* IBOX in Baum KIT */
#define DFB1             25  /* BUTTON in Baum KIT */
#define DFB2             26  /* BUTTON in Baum KIT */
#define DFB3             27  /* BUTTON in Baum KIT */
#define DFB4             28  /* BUTTON in Baum KIT */
#define DFB5             29  /* BUTTON in Baum KIT */
#define DFB6             30  /* BUTTON in Baum KIT */
#define DFB7             31  /* BUTTON in Baum KIT */
#define DFB8             32  /* BUTTON in Baum KIT */
#define DFB9             33  /* BUTTON in Baum KIT */
#define DFB10            34  /* BUTTON in Baum KIT */
#define DSALL            37  /* BUTTON in Baum KIT */
#define DSREPSTR         38  /* FTEXT in Baum KIT */
#define EDCURBLOK        39  /* IBOX in Baum KIT */
#define DFS1             40  /* FTEXT in Baum KIT */
#define DFS2             41  /* FTEXT in Baum KIT */
#define DFS3             42  /* FTEXT in Baum KIT */
#define DFS4             43  /* FTEXT in Baum KIT */
#define DFS5             44  /* FTEXT in Baum KIT */
#define DFS6             45  /* FTEXT in Baum KIT */
#define DFS7             46  /* FTEXT in Baum KIT */
#define DFS8             47  /* FTEXT in Baum KIT */
#define DFS9             48  /* FTEXT in Baum KIT */
#define DFS10            49  /* FTEXT in Baum KIT */
#define DCFBLOK          50  /* BUTTON in Baum KIT */
#define DSCPF1STR        52  /* FTEXT in Baum KIT */
#define DSCPF1XTR        53  /* FTEXT in Baum KIT */
#define DSCPF2STR        55  /* FTEXT in Baum KIT */
#define DSCPF2XTR        56  /* FTEXT in Baum KIT */
#define DSFDEEP          58  /* BUTTON in Baum KIT */
#define DCFOK            59  /* BUTTON in Baum KIT */
#define DSCBLOK          60  /* BUTTON in Baum KIT */
#define SCSPLIT          61  /* FTEXT in Baum KIT */
#define SCAUTOI          62  /* BUTTON in Baum KIT */
#define SCTABS           63  /* FTEXT in Baum KIT */
#define SCFONT           64  /* BUTTON in Baum KIT */
#define SCVISTAB         65  /* FTEXT in Baum KIT */
#define SCBOLD           66  /* BUTTON in Baum KIT */
#define SCTRAIL          67  /* BUTTON in Baum KIT */
#define SCLIN            68  /* BUTTON in Baum KIT */
#define SCVARR           70  /* FTEXT in Baum KIT */
#define SCV              72  /* BUTTON in Baum KIT */
#define SCVGRT           73  /* FTEXT in Baum KIT */
#define SCVGRN           75  /* FTEXT in Baum KIT */
#define SCHARR           77  /* FTEXT in Baum KIT */
#define SCH              79  /* BUTTON in Baum KIT */
#define SCHGRT           80  /* FTEXT in Baum KIT */
#define SCHGRN           82  /* FTEXT in Baum KIT */
#define DLINBLOK         84  /* IBOX in Baum KIT */
#define DSLNNR           85  /* FTEXT in Baum KIT */
#define RETABBLOK        86  /* BUTTON in Baum KIT */
#define SCTABNEW         87  /* FTEXT in Baum KIT */
#define SCTABLEAD        88  /* BUTTON in Baum KIT */
#define SCTABPHYS        89  /* FTEXT in Baum KIT */
#define DHKSBLOK         90  /* BUTTON in Baum KIT */
#define HKSWL0           92  /* FTEXT in Baum KIT */
#define HKSWR0           93  /* FTEXT in Baum KIT */
#define HKSWL1           94  /* FTEXT in Baum KIT */
#define HKSWR1           95  /* FTEXT in Baum KIT */
#define HKSWL2           96  /* FTEXT in Baum KIT */
#define HKSWR2           97  /* FTEXT in Baum KIT */
#define HKSWL3           98  /* FTEXT in Baum KIT */
#define HKSWR3           99  /* FTEXT in Baum KIT */
#define HKSWL4           100 /* FTEXT in Baum KIT */
#define HKSWR4           101 /* FTEXT in Baum KIT */
#define HKSWL5           102 /* FTEXT in Baum KIT */
#define HKSWR5           103 /* FTEXT in Baum KIT */
#define HKSWL6           104 /* FTEXT in Baum KIT */
#define HKSWR6           105 /* FTEXT in Baum KIT */
#define HKSWL7           106 /* FTEXT in Baum KIT */
#define HKSWR7           107 /* FTEXT in Baum KIT */
#define HKSWL8           108 /* FTEXT in Baum KIT */
#define HKSWR8           109 /* FTEXT in Baum KIT */
#define HKSWL9           110 /* FTEXT in Baum KIT */
#define HKSWR9           111 /* FTEXT in Baum KIT */
#define HKSCASE          112 /* BUTTON in Baum KIT */
#define OPTBLOK          122 /* IBOX in Baum KIT */
#define SOPBLOK          123 /* BUTTON in Baum KIT */
#define COV0             124 /* BUTTON in Baum KIT */
#define COV1             125 /* BUTTON in Baum KIT */
#define COV2             126 /* BUTTON in Baum KIT */
#define COV3             127 /* BUTTON in Baum KIT */
#define COPH             128 /* BUTTON in Baum KIT */
#define COAP             129 /* BUTTON in Baum KIT */
#define AHBLOK           130 /* BOXTEXT in Baum KIT */
#define COFT             131 /* BUTTON in Baum KIT */
#define COINH            132 /* BUTTON in Baum KIT */
#define COH              133 /* BUTTON in Baum KIT */
#define AH1              135 /* BUTTON in Baum KIT */
#define AH2              136 /* BUTTON in Baum KIT */
#define AH3              137 /* BUTTON in Baum KIT */
#define AH4              138 /* BUTTON in Baum KIT */
#define AH5              139 /* BUTTON in Baum KIT */
#define CODM             140 /* BUTTON in Baum KIT */
#define COMATCH          141 /* FTEXT in Baum KIT */
#define CORN             143 /* FTEXT in Baum KIT */
#define DOPBLOK          144 /* BUTTON in Baum KIT */
#define COK              145 /* BUTTON in Baum KIT */
#define CO32             146 /* BUTTON in Baum KIT */
#define COE              147 /* BUTTON in Baum KIT */
#define COEN             148 /* FTEXT in Baum KIT */
#define COF              149 /* BUTTON in Baum KIT */
#define COWN             150 /* FTEXT in Baum KIT */
#define COD              152 /* BUTTON in Baum KIT */
#define CODEF            153 /* FTEXT in Baum KIT */
#define COD1             154 /* BUTTON in Baum KIT */
#define CODEF1           155 /* FTEXT in Baum KIT */
#define COD2             156 /* BUTTON in Baum KIT */
#define CODEF2           157 /* FTEXT in Baum KIT */
#define COD3             158 /* BUTTON in Baum KIT */
#define CODEF3           159 /* FTEXT in Baum KIT */
#define COD4             160 /* BUTTON in Baum KIT */
#define CODEF4           161 /* FTEXT in Baum KIT */
#define COI              163 /* BUTTON in Baum KIT */
#define COINCL           164 /* FTEXT in Baum KIT */
#define COI1             165 /* BUTTON in Baum KIT */
#define COINCL1          166 /* FTEXT in Baum KIT */
#define COI2             167 /* BUTTON in Baum KIT */
#define COINCL2          168 /* FTEXT in Baum KIT */
#define COI3             169 /* BUTTON in Baum KIT */
#define COINCL3          170 /* FTEXT in Baum KIT */
#define COI4             171 /* BUTTON in Baum KIT */
#define COINCL4          172 /* FTEXT in Baum KIT */
#define LOPBLOK          173 /* BUTTON in Baum KIT */
#define COG              174 /* BUTTON in Baum KIT */
#define COT              175 /* BUTTON in Baum KIT */
#define COFL             176 /* BUTTON in Baum KIT */
#define COMST            177 /* BUTTON in Baum KIT */
#define COLIB            178 /* BUTTON in Baum KIT */
#define COLIBDIR         179 /* FTEXT in Baum KIT */
#define COSY             180 /* BUTTON in Baum KIT */
#define COL              181 /* BUTTON in Baum KIT */
#define COJ              182 /* BUTTON in Baum KIT */
#define COLST            183 /* BUTTON in Baum KIT */
#define KIT_MAX          184 /* TEXT in Baum KIT */

#define DMENU            5   /* Menuebaum */
#define MTDP             3   /* TITLE in Baum DMENU */
#define DPEXPAND         6   /* STRING in Baum DMENU */
#define DPOPEN           7   /* STRING in Baum DMENU */

#define IW               0   /* Alert String */

#define ABCHA            1   /* Alert String */

#define ALCHA            2   /* Alert String */

#define BEMP             3   /* Alert String */

#define WINDIAL          4   /* Freier String */

#define FNF              5   /* Freier String */

#define FNOP             6   /* Freier String */

#define FNW              7   /* Freier String */

#define WINOP            8   /* Freier String */

#define RANOUT           9   /* Freier String */

#define LLONG            10  /* Freier String */

#define ROMW             11  /* Freier String */

#define HELPNAME         12  /* Freier String */

#define GUIDENAME        13  /* Freier String */

#define HELPFAIL         14  /* Freier String */

#define NOGUIDE          15  /* Freier String */

#define ALMOD            16  /* Freier String */

#define JCALC            17  /* Freier String */

#define DROPWIN          18  /* Freier String */

#define DRAGDROP         19  /* Freier String */
