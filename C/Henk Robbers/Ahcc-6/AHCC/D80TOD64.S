
	globl d80tod64
	text
d80tod64:
	fmove.d	fp0,(a0)
	rts

	end
