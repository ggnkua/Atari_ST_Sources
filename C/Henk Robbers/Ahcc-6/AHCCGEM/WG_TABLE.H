static unsigned char wind_get_table[] =
{
    0,0,0,0,4,4,4,4,
    1,1,
    3,                  /* 10  WF_TOP (was 1, 3 since AES 3.3) */
    4,4,0,
    2,                  /* 14  WF_NEWDESK   */
    1,1,4,
    1,                  /* 18  WF_COLOR     (since AES 3.3) */
    4,                  /* 19  WF_DCOLOR    (since AES 3.3) */
    1,                  /* 20  WF_OWNER     */
    0,0,0,
    1,                  /* 24  WF_BEVENT    */
    1,                  /* 25  WF_BOTTOM    */
    3,                  /* 26  WF_ICONIFY   */
    4,                  /* 27  WF_UNICONIFY */
    0,0,
    2,                  /* 30  WF_TOOLBAR   */
    4,                  /* 31  WF_FTOOLBAR  */
    4,                  /* 32  WF_NTOOLBAR  */
    2,                  /* 33  WF_MENU      */
    0,0,0,0,0,0,0,
    4,                  /* 41  WF_OPTS      */
    0,0,0,0,0,0,
    0,0,0,0,0,0,0,0,
    0,0,0,0,0,0,0,0
};
