/* Resource Datei Indizes f�r WORMS */

#define DB               0   /* Formular/Dialog */
#define WMOVE            1   /* BOXTEXT in Baum DB */
#define WORML            5   /* FTEXT in Baum DB */
#define WORMEN           6   /* FTEXT in Baum DB */
#define WORMK            7   /* FTEXT in Baum DB */
#define WORMR            8   /* FTEXT in Baum DB */
#define WORMS            9   /* FTEXT in Baum DB */
#define QUIT             10  /* BOXTEXT in Baum DB */
#define CONT             11  /* BOXTEXT in Baum DB */
#define OK               12  /* BUTTON in Baum DB */
