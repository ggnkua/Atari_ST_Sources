#define SRC_OPNERR "[3][Druckersource kann |nicht gelesen werden! ][ OK ]"
#define DES_OPNERR "[3][Zieldatei konnte |nicht ge”ffnet werden! ][ OK ]"
#define SRC_ERR "[3][Fehler im Druckersource! ][ OK ]"
