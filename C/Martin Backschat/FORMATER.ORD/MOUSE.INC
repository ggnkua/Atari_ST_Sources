/***********************************************************************/
/*   cursor aus                                                        */
/***********************************************************************/
hide_mouse()
{
     if(!hidden) {
          graf_mouse(M_OFF,0x0L);
          hidden=TRUE;
     }
}

/***********************************************************************/
/*   cursor an                                                         */
/***********************************************************************/
show_mouse()
{
     if(hidden) {
          graf_mouse(M_ON,0x0L);
          hidden=FALSE;
     }
}
