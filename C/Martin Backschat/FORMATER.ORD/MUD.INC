/*        MABA's VDI & AES Grafphics Deklarations           */

int  contrl[12],
     intin[128],
     ptsin[128],
     intout[128],
     ptsout[128];

int handle;

int  work_in[12],
     work_out[57];

/*        End of MUD     */

