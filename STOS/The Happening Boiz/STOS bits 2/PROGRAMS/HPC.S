	MOVE.B	CHECK,D0
	CMP.B	#1,D0
	BEQ	STOP_TIME
	MOVE.B	#1,CHECK
			
	MOVE.L $118.W,OLD118
	MOVE.L $120.W,OLD120
	MOVE.L $70.W,OLD70
	MOVE.B $FFFFFA07.W,OLDA07
	MOVE.B $FFFFFA13.W,OLDA13
	MOVE.B $FFFFFA1B.W,OLDA1B
	MOVE.B $FFFFFA21.W,OLDA21
	DC.W $A000
	DC.W $A00A			;HIDE MOUSE
	MOVE.B #$12,$FFFFFC02.W 	;DISABLE MOUSE
	MOVE.W #5,-(A7)			;5=TIMER C INTERRUPT
	MOVE.W #26,-(A7)		;26=DISBALE INTERRUPT
	TRAP #14
	ADDQ.L #4,A7
 	ORI.B #1,$FFFFFA07.W		;ENABLE TIMER B
	ORI.B #1,$FFFFFA13.W
	MOVE.L #TIMERB,$120.W
	MOVE.L #VBL,$70.W

	RTS

STOP_TIME
	MOVE.B	#0,CHECK
	MOVE.W #$2700,SR		;DISBALE INTERRUPTS
	MOVE.L OLD70,$70.W
	MOVE.L OLD120,$120.W
	MOVE.L OLD118,$118.W
	MOVE.B OLDA07,$FFFFFA07.W
	MOVE.B OLDA13,$FFFFFA13.W
	MOVE.B OLDA1B,$FFFFFA1B.W
	MOVE.B OLDA21,$FFFFFA21.W
	MOVE.W #5,-(A7)			;5=TIMER C INTERRUPT
	MOVE.W #27,-(A7)		;27=ENABLE INTERRUPT
	TRAP #14
	ADDQ.L #4,A7
	DC.W $A000
	DC.W $A009			;SHOW MOUSE
	MOVE.B #$08,$FFFFFC02.W 	;ENABLE MOUSE
	MOVE.W #$000,$FFFF8240.W	;SET COLOUR 0 TO WHITE
	MOVE.W #$2300,SR
	RTS
VBL	CLR.B $FFFFFA1B.W	    ;STOP TIMER B FOR SYNCRONISATION
	ADD.L	#1,$462
	ADD.L	#1,$466
	MOVE.L	A0-A1,-(A7)
	MOVE.L	#PAL,A0
	MOVE.L	$FFFFF8240.W,A1
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+		*SET PALETTE
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.L	(A7)+,A0-A1



	MOVE.B #5,$FFFFFA21.W      ;COUNTER=10 SCANLINES
        MOVE.W $007,$FFFF8242.W  ;SET COLOUR 0 TO FIRST COLOUR
	MOVE.L	#TIMERB,$120.W
	MOVE.B #8,$FFFFFA1B.W	    ;START TIMER B
	RTE			    ;PISS OFF

TIMERB	CLR.B $FFFFFA1B.W	   
	MOVE.W #$107,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T2,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE			   

T2	CLR.B $FFFFFA1B.W	   
	MOVE.W #$207,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T3,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE

T3	CLR.B $FFFFFA1B.W	   
	MOVE.W #$307,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T4,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T4	CLR.B $FFFFFA1B.W	   
	MOVE.W #$407,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T5,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T5	CLR.B $FFFFFA1B.W	   
	MOVE.W #$507,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T6,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T6	CLR.B $FFFFFA1B.W	   
	MOVE.W #$607,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T7,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T7	CLR.B $FFFFFA1B.W	   
	MOVE.W #$707,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T8,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T8	CLR.B $FFFFFA1B.W	   
	MOVE.W #$716,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T9,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T9	CLR.B $FFFFFA1B.W	   
	MOVE.W #$725,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T10,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T10	CLR.B $FFFFFA1B.W	   
	MOVE.W #$734,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T11,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE

T11	CLR.B $FFFFFA1B.W	   
	MOVE.W #$743,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T12,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE

T12	CLR.B $FFFFFA1B.W	   
	MOVE.W #$752,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T13,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE

T13	CLR.B $FFFFFA1B.W	   
	MOVE.W #$761,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T14,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE

T14	CLR.B $FFFFFA1B.W	   
	MOVE.W #$770,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T15,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
T15	CLR.B $FFFFFA1B.W	   
	MOVE.W #$771,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#T16,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE

T16	CLR.B $FFFFFA1B.W	   
	MOVE.W #$772,$FFFF8242.W   
	MOVE.B #10,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#SCROLL,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE
SCROLL	CLR.B $FFFFFA1B.W	   
	MOVE.L	A0-A1,-(A7)
	MOVE.L	#PAL1,A0
	MOVE.L	$FFFFF8240.W,A1
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+	*SET SCROLL LINE PALETTE
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	MOVE.L	(A7)+,A0-A1   
	MOVE.B #100,$FFFFFA21.W      
	MOVE.B #8,$FFFFFA1B.W	   
	MOVE.L	#SCROLL,$120.W
	BCLR #0,$FFFFFA0F.W	   
	RTE



OLD70	DS.L 1
OLD118	DS.L 1
OLD120	DS.L 1
OLDA07	DS.B 1
OLDA13	DS.B 1
OLDA21	DS.B 1
OLDA1B	DS.B 1
STACK	DS.L 1
CHECK	DC.B	0

PAL	DC.W	$000,$000,$110,$221,$332,$443,$712,$777,$554,$757
	DC.W	$757,$020,$231,$342,$453,$574
PAL1	DC.W	$000,$200,$300,$400,$500,$600,$217,$216,$215,$214
	DC.W	$373,$773,$337,$737,$000,$700
