CHANGES.S


	This file details changes made to the DEVELOPMENT Extension from
28th November 1995.  The DEVELOPMENT extension is (C) STORM Developments,
and may not be used without prior permission from the author: Neil 
Halliday.



Date		Description
--------------------------------------------------------------------------

28/11/1995	Added the first blitter graphics routine to the extension.
		Had a bit of trouble with the command name, so ended up
		having to call it bfcopy. It is a full screen, four plane
		screen copying routine. Needs adding into the compiler
		program. Added to extension DEV1_INT.S