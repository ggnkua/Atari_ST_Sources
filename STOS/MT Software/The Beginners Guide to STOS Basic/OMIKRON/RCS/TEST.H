#define MENU_1 0  	/* TREE */
#define S_DIALOG 1  	/* TREE */
#define S_REQUES 2  	/* TREE */
#define MESSAGE 11  	/* OBJECT in TREE #0 */
#define DESK 3  	/* OBJECT in TREE #0 */
#define DISK 4  	/* OBJECT in TREE #0 */
#define F_SAVE 20  	/* OBJECT in TREE #0 */
#define F_LOAD 21  	/* OBJECT in TREE #0 */
#define K_LOAD 23  	/* OBJECT in TREE #0 */
#define NEW_DISK 24  	/* OBJECT in TREE #0 */
#define QUIT 26  	/* OBJECT in TREE #0 */
#define WORK 5  	/* OBJECT in TREE #0 */
#define B_NOTEN 28  	/* OBJECT in TREE #0 */
#define B_SCHUEL 29  	/* OBJECT in TREE #0 */
#define INTERNA 31  	/* OBJECT in TREE #0 */
#define ANALYSIS 6  	/* OBJECT in TREE #0 */
#define A_KLASSE 33  	/* OBJECT in TREE #0 */
#define A_SCHUEL 34  	/* OBJECT in TREE #0 */
#define A_ZEUGNS 36  	/* OBJECT in TREE #0 */
#define PRINTER 7  	/* OBJECT in TREE #0 */
#define F_PRINT 38  	/* OBJECT in TREE #0 */
#define HARDCOPY 39  	/* OBJECT in TREE #0 */
#define SCHRIFT 8  	/* OBJECT in TREE #0 */
#define LITTLE 41  	/* OBJECT in TREE #0 */
#define NORMAL 42  	/* OBJECT in TREE #0 */
#define GREAT 43  	/* OBJECT in TREE #0 */
#define N_NAME 2  	/* OBJECT in TREE #1 */
#define V_NAME 3  	/* OBJECT in TREE #1 */
#define GEB_DAT 4  	/* OBJECT in TREE #1 */
#define STRASSE 5  	/* OBJECT in TREE #1 */
#define ORT 6  	/* OBJECT in TREE #1 */
#define PHONE 7  	/* OBJECT in TREE #1 */
#define S_WRITE 10  	/* OBJECT in TREE #1 */
#define S_FIRST 11  	/* OBJECT in TREE #1 */
#define S_PRIOR 12  	/* OBJECT in TREE #1 */
#define S_NEXT 13  	/* OBJECT in TREE #1 */
#define S_LAST 19  	/* OBJECT in TREE #1 */
#define S_SEARCH 14  	/* OBJECT in TREE #1 */
#define S_REPLAC 15  	/* OBJECT in TREE #1 */
#define S_PRINT 18  	/* OBJECT in TREE #1 */
#define S_DELETE 16  	/* OBJECT in TREE #1 */
#define S_QUIT 17  	/* OBJECT in TREE #1 */
#define S_SHOWN 2  	/* OBJECT in TREE #2 */
#define S_BACKWD 3  	/* OBJECT in TREE #2 */
#define S_FORWRD 4  	/* OBJECT in TREE #2 */
#define S_CANCEL 5  	/* OBJECT in TREE #2 */
#define SELECTED 6  	/* OBJECT in TREE #2 */
