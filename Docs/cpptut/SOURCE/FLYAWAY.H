// This file contains a few general purpose definitions to be used
//  with several of the FLYAWAY adventure game classes.

#ifndef FLYAWAY_H
#define FLYAWAY_H

#define FALSE 0
#define TRUE  1

enum word {north = 1, east, south, west, drop, get,
           look, inventory, read, buy, help, quit,
           keys, candy, ticket, money, monitor, paper};

#endif