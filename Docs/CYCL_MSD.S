*************************************************************************
*									*
*	MOTOROLA MC68000 INSTRUCTION SET CYCLES TIMES USING ATARI STF	*
*									*
*		Compiled by MAC SYS DATA of PERSISTENCE OF VISION	*
*									*
*************************************************************************

				MOVE (BYTE AND WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | (An)+ | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  4 |   8  |   8   |    8  |   12  |     16   |   12  |   16  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  4 |  4 |   8  |   8   |    8  |   12  |     16   |   12  |   16  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)     |  8 |  8 |  12  |  12   |   12  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  8 |  8 |  12  |  12   |   12  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 12 | 12 |  16  |  16   |   16  |   20  |     24   |   20  |   24  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 12 | 12 |  16  |  16   |   16  |   20  |     24   |   20  |   24  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 16 | 16 |  20  |  20   |   20  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 12 | 12 |  16  |  16   |   16  |   20  |     24   |   20  |   24  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 16 | 16 |  20  |  20   |   20  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 12 | 12 |  16  |  16   |   16  |   20  |     24   |   20  |   24  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 16 | 16 |  20  |  20   |   20  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 |  8 |  12  |  12   |   12  |   16  |     20   |   16  |   20  |
 ------------------------------------------------------------------------------ 

				MOVE (LONG WORD)


 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | (An)+ | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  4 |  12  |  12   |   12  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  4 |  4 |  12  |  12   |   12  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)     | 12 | 12 |  20  |  20   |   20  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    | 12 | 12 |  20  |  20   |   20  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 16 | 16 |  24  |  24   |   24  |   28  |     32   |   28  |   32  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 16 | 16 |  24  |  24   |   24  |   28  |     32   |   28  |   32  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 20 | 20 |  28  |  28   |   28  |   32  |     36   |   32  |   36  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 16 | 16 |  24  |  24   |   24  |   28  |     32   |   28  |   32  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 20 | 20 |  28  |  28   |   28  |   32  |     36   |   32  |   36  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 16 | 16 |  24  |  24   |   24  |   28  |     32   |   28  |   32  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 20 | 20 |  28  |  28   |   28  |   32  |     36   |   32  |   36  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 12 | 12 |  20  |  20   |   20  |   24  |     28   |   24  |   28  |
 ------------------------------------------------------------------------------ 

			USUAL INSTRUCTIONS (BYTE AND WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Add      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  8 |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  4 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  8 | 12 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 | 12 |  16  |  24   |   20  |   20  |     24   |   16  |   24  |
 ------------------------------------------------------------------------------ 

			USUAL INSTRUCTIONS (BYTE AND WORD)


 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Sub      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  8 |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  4 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  8 | 12 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 | 12 |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
 ------------------------------------------------------------------------------ 


                             USUAL INSTRUCTIONS (LONG WORD)


 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Add      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  8 |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  8 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    | 16 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 16 | 16 |  28  |  36   |   32  |   32  |     36   |   32  |   36  |
 ------------------------------------------------------------------------------ 


                             USUAL INSTRUCTIONS (LONG WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Sub      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  8 |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  8 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    | 16 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 16 | 16 |  28  |  36   |   32  |   32  |     36   |   32  |   36  |
 ------------------------------------------------------------------------------ 


			USUAL INSTRUCTIONS (BYTE AND WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| And      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  8 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 |  * |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
 ------------------------------------------------------------------------------ 


			USUAL INSTRUCTIONS (BYTE AND WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Or       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  8 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 12 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 |  * |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
 ------------------------------------------------------------------------------ 


				USUAL INSTRUCTIONS (LONG WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| And      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  * |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 24 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 24 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 24 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 16 |  * |  28  |  36   |   32  |   32  |     36   |   32  |   36  |
 ------------------------------------------------------------------------------ 


			USUAL INSTRUCTIONS (LONG WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Or       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  * |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 24 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 24 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 20 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 24 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 16 |  * |  28  |  36   |   32  |   32  |     36   |   32  |   36  |
 ------------------------------------------------------------------------------ 


			USUAL INSTRUCTIONS (BYTE AND WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An)+| xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Cmp      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  4 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  8 | 12 |  12  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 12 | 16 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 16 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 | 12 |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
 ------------------------------------------------------------------------------ 


			USUAL INSTRUCTIONS (LONG WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An)+| xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Cmp      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  8 |  8 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    | 16 | 16 |  20  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    | 20 | 20 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) | 24 | 24 |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 16 | 16 |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
 ------------------------------------------------------------------------------ 


			USUAL INSTRUCTIONS (BYTE AND WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Eor      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 |  * |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
 ------------------------------------------------------------------------------ 


			USUAL INSTRUCTIONS (LONG WORD)

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Eor      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  * |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| An       |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)+    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| -(An)    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An)    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(An,Dn) |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.W    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| xxx.L    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc)    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| d(Pc,Dn) |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 16 |  * |  28  |  36   |   32  |   32  |     36   |   32  |   36  |
 ------------------------------------------------------------------------------ 

				FAST INSTRUCTIONS

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Addq.w   |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  4 |  8 |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Subq.w   |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  4 |  8 |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Moveq    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  4 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Movep.w  |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  * |  * |  16  |   *   |    *  |   16  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)     | 16 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Addq.l   |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 |  8 |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Subq.l   |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  8 |  8 |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Moveq    |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     |  4 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Movep.l  |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  * |  * |  24  |   *   |    *  |   24  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| (An)     | 24 |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
 ------------------------------------------------------------------------------


				INSTRUCTIONS

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Clr.w    |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Nbcd.b   |  8 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Neg.w    |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Negx.w   |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Not.w    |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Tas.b    |  4 |  * |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Tst.w    |  4 |  * |   8  |  16   |   12  |   12  |     16   |   12  |   16  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Scc      |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| True     |  8 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| False    |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
 ------------------------------------------------------------------------------ 
   likewise for:
           -Scs    -Smi    -Seq    -Shi    -Sls    -Spl    -Svs    -Svc 
           -Sge    -Slt    -Sgt    -Sne    -Sle    -Slo    -Shs        



				INSTRUCTIONS

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Clr.l    |  8 |  * |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Neg.l    |  8 |  * |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Negx.l   |  8 |  * |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Not.l    |  8 |  * |  20  |  28   |   24  |   24  |     28   |   24  |   28  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Tst.l    |  4 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
 ------------------------------------------------------------------------------ 

				INSTRUCTIONS

 ------------------------     		          ------------------------
| Source   | Destination |   		         | Source   | Destination |
|----------|-------------|   		         |----------|-------------|
|          | Dn | -(An)  |   		         |          | Dn | -(An)  |
|----------|----|--------|   		         |----------|----|--------|
| Addx.w   |  * |     *  |   		         | Addx.l   |  * |     *  |
|----------|----|--------|   		         |----------|----|--------|
| Dn       |  4 |     *  |   		         | Dn       |  8 |     *  |
|----------|----|--------|   		         |----------|----|--------|
| -(An)    |  * |    20  |   		         | -(An)    |  * |    32  |
|----------|----|--------|   		         |----------|----|--------|
| Subx.w   |  * |     *  |                       | Subx.l   |  * |     *  |
|----------|----|--------|  		         |----------|----|--------|
| Dn       |  4 |     *  |  		         | Dn       |  8 |     *  |
|----------|----|--------|   		         |----------|----|--------|
| -(An)    |  * |    20  |   		         | -(An)    |  * |    32  |
|----------|----|--------|                       |----------|----|--------|
| Abcd.b   |  * |     *  |       	         | Sbcd.b   |  * |     *  |
|----------|----|--------|		         |----------|----|--------|
| Dn       |  8 |     *  |		         | Dn       |  8 |     *  |
|----------|----|--------|		         |----------|----|--------|
| -(An)    |  * |    20  |		         | -(An)    |  * |    20  |
 ------------------------	                  ------------------------


				INSTRUCTIONS 

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          | Dn | An | (An) | xxx.L | -(An) | d(An) | d(An,Dn) | xxx.W | xxx.L |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Bchg     |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 12 |  * |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Btst     |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  * |   8  |  16   |   12  |   12  |     16   |   12  |   16  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 12 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Bset     |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       |  8 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | 12 |  * |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Bclr     |  * |  * |   *  |   *   |    *  |    *  |      *   |    *  |    *  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| Dn       | X1 |  * |  12  |  20   |   16  |   16  |     20   |   16  |   20  |
|----------|----|----|------|-------|-------|-------|----------|-------|-------|
| #xxx     | X2 |  * |  16  |  24   |   20  |   20  |     24   |   20  |   24  |
 ------------------------------------------------------------------------------ 
     X1: if 0<=|Dn|<16 [32]  => 8  cycles
         if 16<=|Dn|<32 [32] => 12 cycles
     X2: if 0<=|xx|<16 [32]  => 12 cycles
         if 16<=|xx|<32 [32] => 16 cycles  [ ] means modulo.


			JMP,JSR,BSR,LEA,PEA AND MOVEM

     ---------------------------------------------------------------------
    | Source   |                          Destination                     |
    |----------|----------------------------------------------------------|
    |          | (An)|(An)+|-(An)|d(An)|d(An,Dn)|xxx.W|xxx.L|d(Pc)|d(Pc,Dn|
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Jmp      |   8 |   * |   * |  12 |   16   |   8 |  12 |  12 |   16  |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Jsr      |  16 |   * |   * |  20 |   24   |  16 |  20 |  20 |   24  |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Lea      |  12 |   * |   * |   8 |   16   |   8 |  12 |   8 |   16  |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Pea      |  12 |   * |   * |  16 |   24   |  16 |  20 |  16 |   24  |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Mem->Reg |   * |   * |   * |   * |    *   |   * |   * |   * |    *  |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Movem.w  |12+4n|12+4n|   * |16+4n| 20+4n  |16+4n|20+4n|16+4n| 20+4n |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Movem.l  |12+8n|12+8n|   * |16+8n| 20+8n  |16+8n|20+8n|16+8n| 20+8n |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Reg->Mem |   * |   * |   * |   * |    *   |   * |   * |   * |    *  |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Movem.w  | 8+4n|   * | 8+4n|12+4n| 16+4n  |12+4n|16+4n|   * |    *  |
    |----------|-----|-----|-----|-----|--------|-----|-----|-----|-------|
    | Movem.l  | 8+8n|   * | 8+8n|12+8n| 16+8n  |12+8n|16+8n|   * |    *  |
    |---------------------------------------------------------------------|
    | Bsr label -> 20 cycles                                              |
     ---------------------------------------------------------------------


				ROTATIONS

 ------------------------------------------------------------------------------
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          |                              Dn                                   |
|----------|-------------------------------------------------------------------|
| Asl.w    |                               *                                   |
|----------|-------------------------------------------------------------------|
| Dn       |  if n is even => 8+2n [64].   if n is uneven => 8+2(n-1) [64].    |
|----------|-------------------------------------------------------------------|
| Asl.l    |                               *                                   |
|----------|-------------------------------------------------------------------|
| Dn       |  if n is even => 8+2n [64].   if n is uneven => 8+2(n+1) [64].    |
|----------|-------------------------------------------------------------------|
| Asl.w    |                               *                                   |
|----------|-------------------------------------------------------------------|
| #xxx     |  if n is even => 8+2n.        if n is uneven => 8+2(n-1).         |
|----------|-------------------------------------------------------------------|
| Asl.l    |                               *                                   |
|----------|-------------------------------------------------------------------|
| #xxx     |  if n is even => 8+2n.        if n is uneven => 8+2(n+1).         |
|----------|-------------------------------------------------------------------|
| Source   |                          Destination                              |
|----------|-------------------------------------------------------------------|
|          |   (An) |  (An)+ |  -(An) |  d(An) |  d(An,Dn) |   xxx.w |   xxx.l |
|----------|--------|--------|--------|--------|-----------|---------|---------|
| Asl      |   12   |   12   |    16  |    16  |     20    |    16   |    20   |
 ------------------------------------------------------------------------------
     likewise for Asr,Lsl,Lsr,Rol,Ror,Roxl,Roxr

 ------------------------------------------------------------------------------
| Roxl #1,Dn |  8   |
 ------------------------------------------------------------------------------




				INSTRUCTIONS 

   ---------------------------------------------------------------------------
  | Destination     |                      Source                             |
  |-----------------|---------------------------------------------------------|
  |                 |Dn|(An)|d(An)|-(An)|d(An,Dn)|x.w|x.l|d(Pc)|d(Pc,Dn)| #xxx|
  | ----------------|--|----|-----|-----|--------|---|---|-----|--------|-----|
  | Move to sr      |12| 16 |  20 |  20 |   24   | 20| 24|  20 |   24   |  16 |
  | ----------------|--|----|-----|-----|--------|---|---|-----|--------|-----|
  | Move to ccr     |12| 16 |  20 |  20 |   24   | 20| 24|  20 |   24   |  16 |
  |-----------------|---------------------------------------------------------|
  | Source          |                    Destination                          |
  |-----------------|---------------------------------------------------------|
  |                 |  Dn  | (An) | -(An) | d(An) | d(An,Dn) | xxx.w | xxx.l  |
  |-----------------|------|------|-------|-------|----------|-------|--------|
  | Move from sr to |   8  |  12  |   16  |   16  |     20   |   16  |   20   |
  |-----------------|------|------|-------|-------|----------|-------|--------|
  | St              |   8  |  12  |   16  |   16  |     20   |   16  |   20   |
  |-----------------|------|------|-------|-------|----------|-------|--------|
  | Sf              |   4  |  12  |   16  |   16  |     20   |   16  |   20   |
   ---------------------------------------------------------------------------


				INSTRUCTIONS

 ---------------------------------------------------------------------------
| Eor #xxx,ccr     | 20               | Move usp,An      |  4               |
|------------------|------------------|------------------|------------------|
| Eor #xxx,sr      | 20               | Move An,usp      |  4               |
|------------------|------------------|------------------|------------------|
| Reset            |                  | Link An,#xxx     |                  |
|------------------|------------------|------------------|------------------|
| Rte              | 20               | And #xxx,ccr     | 20               |
|------------------|------------------|------------------|------------------|
| Rtr              | 20               | And #xxx,sr      | 20               |
|------------------|------------------|------------------|------------------|
| Rts              | 16               | Exg Dn,Dn        |  8               |
|------------------|------------------|------------------|------------------|
| Stop #xxx        |                  | Exg An,An        |  8               |
|------------------|------------------|------------------|------------------|
| Swap             |  4               | Exg Dn,An        |  8               |
|------------------|------------------|------------------|------------------|
| Trap #xx         |                  | Exg An,Dn        |  8               |
|------------------|------------------|------------------|------------------|
| Trapv            |  4               | Ext.w Dn         |  4               |
|------------------|------------------|------------------|------------------|
| Unlk An          |                  | Ext.l Dn         |  4               |
|------------------|------------------|------------------|------------------|
| Nop              |  4               | Illegal          |                  |
|------------------|------------------|------------------|------------------|
| Or #xxx,ccr      | 20               | Bus error        | 116              |
|------------------|------------------|------------------|------------------|
| Or #xxx,sr       | 20               |                  |                  |
 --------------------------------------------------------------------------- 

				INSTRUCTIONS

 ---------------------------------------------------------------------------
| Instruction       | Taken | Not taken | Taken (short) | Not taken (short) |
|-------------------|-------|-----------|---------------|-------------------|
| Bra               |   12  |      *    |       12      |        *          |
|-------------------|-------|-----------|---------------|-------------------|
| Bcs               |   12  |     12    |       12      |        8          |
|-------------------|-------------------------------------------------------|
|                   | likewise for Bcc,Bmi,Bhi,Bls,Bpl,Beq,Bgt,Bvs,Bvc,Bge  |
|                   |              Blt,Blo,Ble,Bhs,Bne                      |
|-------------------|-------------------------------------------------------|
| Instruction       |       Taken             |         Not taken           |
|-------------------|-------------------------|-----------------------------|
| Dbra              |       16+12n            |           *                 |
|-------------------|-------------------------|-----------------------------|
| Dbf               |       16+12n            |           *                 |
|-------------------|-------------------------|-----------------------------|
| Dbeq              |       16+12n            |          12                 |
|-------------------|-------------------------------------------------------|
|                   | likewise for Dbcc,Dbmi,Dbhi,Dbls,Dbpl,Dbgt,Dbvs,Dbvc  |
|                   |              Dblt,Dblo,Dble,Dbhs,Dbne,Dbge,Dbcs       |
 ---------------------------------------------------------------------------

 SOME CYCLES CAN CHANGE,IT DEPENDS OF THE DESTINATION'S ADDRESS.
