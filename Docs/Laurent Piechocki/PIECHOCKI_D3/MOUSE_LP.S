* DEMO BY LAURENT PIECHOCKI

           SECTION TEXT
 
DONNE	SET	1

           move.l     a7,a5	
           lea        pile,a7
           move.l     4(a5),a5     
           move.l     $c(a5),d0    
           add.l      $14(a5),d0
           add.l      $1c(a5),d0
           add.l      #$100,d0
           move.l     d0,-(sp)
           move.l     a5,-(sp)
           move       #0,-(sp)
           move       #$4a,-(sp)
           trap       #1
           add.l      #12,sp
	
	dc.w	$a00a

	move	#0,-(sp)
	move.l	#-1,-(sp)	
	move.l	#-1,-(sp)	
	move	#5,-(sp)
	trap	#14
	add.l	#12,sp
	
	clr.l	-(sp)
	move	#$20,-(sp)
	trap	#1
	add.l	#6,sp
	move.l	d0,SSP
	

	
	movem.l	$ff8240,d0-d7
	movem.l	d0-d7,PALETTE

	move.l	#NOIR,$45a
	
	move.l	#PARLE,-(sp)
	move	#9,-(sp)
	trap	#1	
	add.l	#6,sp
	
	move	#7,-(sp)
	trap	#1
	add.l	#2,sp
	
	move.l	#EFFACE,-(sp)
	move	#9,-(sp)
	trap	#1	
	add.l	#6,sp
	
	move.l	#PAL,$45a
	move.b	#2,$ffff820a	
		

	
	move.l	$44e,a0
	add.l	#160*80,a0
	add.l	#32,a0
	move	#48,d0
	move.l	#COLONNE,a1
	
_0_BOUCLE  move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#152,a0
	dbf	d0,_0_BOUCLE


		
	move.l	$44e,a0
	add.l	#160*160,a0
	add.l	#8,a0
	move	#$e,d0
	move.l	#DAT,a1
	
_1_BOUCLE	REPT	17
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           ENDR
           add.l	#24,a0
	dbf	d0,_1_BOUCLE


	
	move.l	#0,CA
ENCORE	move.l	$44e,a0
	add.l	#160*123,a0
	add.l	CA,a0
	move	#$c,d0
	move.l	#PLANCHE,a1
	
_2_BOUCLE	
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#144,a0
	dbf	d0,_2_BOUCLE
	add.l	#8,CA
	cmpi.l	#8*18,CA
	bls	ENCORE


		

	move.l	$44e,a0
	add.l	#160*78,a0
	add.l	#56,a0
	move	#$2c,d0
	move.l	#TABLE,a1
	
_3_BOUCLE	
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#144,a0
	dbf	d0,_3_BOUCLE


	
	move.l	$44e,a0
	add.l	#160*61,a0
	add.l	#96,a0
	move	#$3d,d0
	move.l	#ARBRE1,a1
	
_4_BOUCLE	
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#144,a0
	dbf	d0,_4_BOUCLE

	
	move.l	$44e,a0
	add.l	#160*61,a0
	add.l	#112,a0
	move	#$1a,d0
	move.l	#ARBRE2,a1
	
_5_BOUCLE	
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#144,a0
	dbf	d0,_5_BOUCLE
	
			

	
	move.l	$44e,a0
	add.l	#160*107,a0
	add.l	#16,a0
	move	#$f,d0
	move.l	#HERBE,a1
	
_6_BOUCLE	
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#144,a0
	dbf	d0,_6_BOUCLE
	

	
	move.l	$44e,a0
	add.l	#8,a0
	move	#$26,d0
	move.l	#POULIE,a1
	
_7_BOUCLE	
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#144,a0
	dbf	d0,_7_BOUCLE
	

	
	move.l	$44e,a0
	add.l	#128,a0
	add.l	#160*106,a0
	move.l	#FLEUR,a1
	move	#$10,d0
	
_8_BOUCLE	
           move.l	(a1)+,(a0)+
           move.l	(a1)+,(a0)+
           add.l	#152,a0		
	dbf	d0,_8_BOUCLE
	

	
	move	#$26,d0
	move	#8,d1
	move	#$10,d2
	move.l	#SAUSSICE,a2
	move.l	#WURSHT,a0
	jsr	AFF_SPRIT



	
	move	#256,VALEUR
	move.l	#TAMPON,a2
	move.l	#A8,a0
	move	#24,d2
	move	#100,d0
	move	VALEUR,d1
	jsr	AFF_SPRIT


	
	move	#50,INC
	move.l	#EAU,a2
	move.l	#B1,a0
	move	#$13,d2
	move	#158,d0
	move	INC,d1
	jsr	AFF_SPRIT
	
	move.l	#VECTEUR,a6	
	move.l	#ADRESSES,a5
	
	move	#0,BON		
	move.b	#0,FLAG
	
PRINCIPAL	move	#37,-(sp)
	trap	#14
	add.l	#2,sp
	
	move	#$ff,-(sp)
	move	#6,-(sp)
	trap	#1
	add.l	#4,sp
	tst	d0
	beq	ALLONS_Y
	cmpi	#'A',d0
	beq	MET_PAL2
	cmpi	#'a',d0
	beq	MET_PAL2
	cmpi	#'B',d0
	beq	MET_PAL1
	cmpi	#'b',d0
	beq	MET_PAL1
	jmp	FIN
	     
MET_PAL2	move.l	#PAL2,$45a
	jmp	ALLONS_Y
MET_PAL1   move.l     #PAL,$45a
	

	
ALLONS_Y   move.l    #TAMPON,a0	
           move.l    (a0)+,a1
           move.w    #23,d2		

EFF_1      move.l    (a0)+,(a1)+		
           move.l    (a0)+,(a1)+
           
           move.l    (a0)+,(a1)+
           move.l    (a0)+,(a1)+
           
           move.l    (a0)+,(a1)+
           move.l    (a0)+,(a1)+

           add.l     #136,a1
           dbf       d2,EFF_1


	; Efface SAUSSICE
		
           move.l    #SAUSSICE,a0
           move.l    (a0)+,a1           
           move.w    #$f,d2		

EFF_2      move.l    (a0)+,(a1)+		
           move.l    (a0)+,(a1)+
           
           move.l    (a0)+,(a1)+
           move.l    (a0)+,(a1)+
           
           move.l    (a0)+,(a1)+
           move.l    (a0)+,(a1)+

           add.l     #136,a1
           dbf       d2,EFF_2

           
	; Efface PAPIER
		
           move.l    #EAU,a0
           move.l    (a0)+,a1           
           move.w    #$12,d2		

EFF_3      move.l    (a0)+,(a1)+		
           move.l    (a0)+,(a1)+
           
           move.l    (a0)+,(a1)+
           move.l    (a0)+,(a1)+
           
           move.l    (a0)+,(a1)+
           move.l    (a0)+,(a1)+

           add.l     #136,a1
           dbf       d2,EFF_3
           
 	
	move.l	#EAU,a2
	move	#$13,d2
	move	#158,d0
	move	INC,d1
	move.l	(a5)+,a0
	cmpi.l	#-1,(a5)
	beq	RE_AD
	jsr	AFF_SPRIT
	jmp	CONTINUE
RE_AD	move.l	#ADRESSES,a5
	jsr	AFF_SPRIT
CONTINUE	add	#8,INC
           cmpi	#260,INC
           blt	SAUS
	move	#0,INC


	
SAUS	tst.b	FLAG
	bne	MONTE		
	
	tst.b	TESTONS		
	bne	DESSINE		
				
				
	move.l	#SAUSSICE,a0
	move.l	(a0)+,a1
	move.l	#0,(a1)+
	move.l	#0,(a1)+
	move.l	#%1001000000,(a1)+
	move.l	#%1001000000,(a1)+	
	move	#$26,d0		
	add	BON,d0
	cmpi	#107,d0		
	bgt	MONTE
	
	move	#$26,d0
	add	BON,d0
	move	#8,d1
	move	#$10,d2
	move.l	#SAUSSICE,a2
	move.l	#WURSHT,a0
	add	#1,BON
	jsr	AFF_SPRIT
	move.b	#1,TESTONS		
	jmp	PLUSLOIN
	
MONTE	move.b	#1,FLAG		
	move	#$26,d0		
	sub	#3,BON
	add	BON,d0	
	tst	BON		
	blt 	DESCEND
		
	;enleve pixels de descente
	
	move.l	#SAUSSICE,a2	
	move.l	(a2)+,a0

	REPT	3		
	move.l	#0,(a0)+		
	move.l	#0,(a0)+		
	move.l	#0,(a0)+		
	move.l	#0,(a0)+
	add.l	#144,a0		
	ENDR
	
	move	#8,d1
	move	#$10,d2
	move.l	#SAUSSICE,a2
	move.l	#WURSHT,a0
 	jsr	AFF_SPRIT
	jmp	PLUSLOIN
	
DESCEND 	move.b	#0,FLAG		
	move	#8,d1		
	move	#$10,d2		
	move.l	#SAUSSICE,a2
	move.l	#WURSHT,a0
 	jsr	AFF_SPRIT
 	jmp	PLUSLOIN
 	
DESSINE	move.b	#0,TESTONS		
	move	#8,d1		
	move	#$10,d2		
	move.l	#SAUSSICE,a2
	move	#$26,d0
	add	BON,d0
	move.l	#WURSHT,a0
 	jsr	AFF_SPRIT
 	
PLUSLOIN	move.l	#TAMPON,a2
	move	#24,d2
	move	#100,d0
	move	VALEUR,d1
	move.l	(a6)+,a0
	cmpi.l	#-1,(a6)
	beq	DODO
	jsr	AFF_SPRIT
	jmp	SUITE
DODO	move.l	#VECTEUR,a6
	jsr	AFF_SPRIT
SUITE	sub	#DONNE,VALEUR
           tst	VALEUR
           bmi	REMET
	jmp	PRINCIPAL
REMET	move	#270,VALEUR
	jmp	PRINCIPAL
	
	
AFF_SPRIT mulu      #160,d0
          move      d1,d7
          lsr       #1,d1
          add       d1,d0
          add.l     $44e,d0		
          and.l     #-8,d0
          move.l    d0,a1
          move.l    a1,(a2)+
          and.l     #15,d7
          subq      #1,d2
          move      d2,d6

          **** affichage d'un sprite de 32*32 :Laurent P,  4/2/89 ****
 
_SP1      moveq     #0,d0
          moveq     #0,d1
          moveq     #0,d2
          moveq     #0,d3

          move      (a0)+,d0
          move      (a0)+,d1
          move      (a0)+,d2
          move      (a0)+,d3

          move.l    d0,d4
          or.l      d1,d4
          or.l      d2,d4
          or.l      d3,d4
          not.l     d4

          ror.l     d7,d0
          ror.l     d7,d1
          ror.l     d7,d2
          ror.l     d7,d3
          ror.l     d7,d4

          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d0,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d1,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d2,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d3,(a1)+

          swap      d0
          swap      d1
          swap      d2
          swap      d3
          swap      d4

          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d0,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d1,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d2,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d3,(a1)+          
          sub.l      #8,a1	
          			
                    	   
          moveq     #0,d0
          moveq     #0,d1
          moveq     #0,d2
          moveq     #0,d3

          move      (a0)+,d0
          move      (a0)+,d1
          move      (a0)+,d2
          move      (a0)+,d3

          move.l    d0,d4
          or.l      d1,d4
          or.l      d2,d4
          or.l      d3,d4
          not.l     d4
	
          ror.l     d7,d0
          ror.l     d7,d1
          ror.l     d7,d2
          ror.l     d7,d3
          ror.l     d7,d4
	          
          and       d4,(a1)
          or        d0,(a1)+
          and       d4,(a1)
          or        d1,(a1)+
          and       d4,(a1)
          or        d2,(a1)+
          and       d4,(a1)
          or        d3,(a1)+

          swap      d0
          swap      d1
          swap      d2
          swap      d3
          swap      d4

          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d0,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d1,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d2,(a1)+
          move.w    (a1),(a2)+
          and       d4,(a1)
          or        d3,(a1)+

          add.l     #136,a1		
          dbf       d6,_SP1
          rts
	
FIN        move	#7,-(sp)
	trap	#1
	add.l	#2,sp

           movem.l	PALETTE,d0-d7
	movem.l	d0-d7,$ff8240	
	
           move.l	SSP,-(sp)
	move	#$20,-(sp)
	trap	#1
	add.l	#6,sp

	dc.w	$a009
		
	clr.w	-(sp)
	trap	#1

	SECTION	 DATA

NOIR	dc.w      $777,0,0,0,0,0,0,0
	dc.w      0,0,0,0,0,0,0,0
	
PAL  	dc.w      $0000,$0036,$0775,$0555,$0760,$0630,$0500,$0130
  	dc.w      $0463,$0650,$0310,$0333,$0222,$0050,$0027,$0776
  	
PAL2  	dc.w      $0777,$0036,$0775,$0555,$0760,$0630,$0500,$0130
  	dc.w      $0463,$0650,$0310,$0333,$0222,$0050,$0027,$0776
      

*    pixels/scanline    = $0110 (bytes/scanline: $0088)
*  # scanlines (height) = $0010

DAT	dc.w	$0000,$0000,$0000,$0000,$0000,$1E00,$0000,$1E00
	dc.w	$0000,$03F0,$0000,$03F0,$0000,$1E1E,$0000,$1E1E
	dc.w	$0000,$1FF8,$0000,$1FF8,$0000,$1FFC,$0000,$1FFC
	dc.w	$0000,$1C1E,$0000,$1C1E,$0000,$3FFC,$0000,$3FFC
	dc.w	$0000,$1F03,$0000,$1F03,$0000,$FF00,$0000,$FF00
	dc.w	$0000,$01E1,$0000,$01E1,$0000,$E03F,$0000,$E03F
	dc.w	$0000,$01E1,$0000,$01E1,$0000,$E07F,$0000,$E07F
	dc.w	$0000,$E1FF,$0000,$E1FF,$0000,$C000,$0000,$C000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$3F00,$0000,$3100,$0000,$0FFC,$0000,$0E1C
	dc.w	$0000,$3F3F,$0000,$3333,$0000,$3FFE,$0000,$300E
	dc.w	$0000,$3FFE,$0000,$3002,$0000,$3E3F,$0000,$3223
	dc.w	$0000,$7FFE,$0000,$4002,$0000,$3F8F,$0000,$318C
	dc.w	$0000,$FF80,$0000,$0080,$0000,$03F3,$0000,$0312
	dc.w	$0000,$F0FF,$0000,$30E1,$0000,$C3F3,$0000,$C333
	dc.w	$0000,$F1FF,$0000,$3180,$0000,$F3FF,$0000,$1300
	dc.w	$0000,$E000,$0000,$2000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$3F00,$0000,$2100
	dc.w	$0000,$1FFE,$0000,$1806,$0000,$3F3F,$0000,$2121
	dc.w	$0000,$3FFF,$0000,$2003,$0000,$3FFE,$0000,$2002
	dc.w	$0000,$3F3F,$0000,$2121,$0000,$7FFE,$0000,$4002
	dc.w	$0000,$3F9F,$0000,$2098,$0000,$FF80,$0000,$0080
	dc.w	$0000,$03F3,$0000,$0212,$0000,$F1FF,$0000,$1180
	dc.w	$0000,$E3F3,$0000,$6212,$0000,$F3FF,$0000,$1300
	dc.w	$0000,$F3FF,$0000,$1200,$0000,$E002,$0000,$2002
	dc.w	$0000,$0000,$0000,$0000,$0000,$0200,$0000,$0200
	dc.w	$0000,$3F00,$0000,$2100,$0000,$1FFE,$0000,$1002
	dc.w	$0000,$3F3F,$0000,$2121,$0000,$3FFF,$0000,$23E1
	dc.w	$0000,$3FFC,$0000,$21FC,$0000,$3F9F,$0000,$2091
	dc.w	$0000,$7FFE,$0000,$4002,$0000,$3F9F,$0000,$2090
	dc.w	$0000,$FF80,$0000,$F880,$0000,$03FF,$0000,$020C
	dc.w	$0000,$F1FF,$0000,$1100,$0000,$E3F3,$0000,$2212
	dc.w	$0000,$F3FF,$0000,$121F,$0000,$F3FF,$0000,$121F
	dc.w	$0000,$C007,$0000,$C007,$0000,$0000,$0000,$0000
	dc.w	$0000,$0700,$0000,$0700,$0000,$3600,$0800,$2200
	dc.w	$0000,$3DF7,$0208,$31E3,$0000,$373D,$0802,$2331
	dc.w	$0000,$361D,$0802,$2211,$0000,$3600,$0800,$2200
	dc.w	$0000,$3ADB,$0504,$2051,$0000,$3EFC,$0100,$3C7C
	dc.w	$0000,$3B9B,$0404,$3191,$0000,$8780,$0000,$8780
	dc.w	$0000,$03AE,$0051,$0200,$0000,$B3BE,$4041,$131E
	dc.w	$0000,$B373,$4080,$3233,$0000,$D370,$2080,$1230
	dc.w	$0000,$F360,$0080,$F220,$0000,$000F,$0000,$000D
	dc.w	$0000,$8000,$0000,$8000,$0000,$0F80,$0000,$0D80
	dc.w	$0000,$3200,$0C00,$2200,$0000,$3219,$0C06,$2211
	dc.w	$0000,$3219,$0C06,$2211,$0000,$3219,$0C06,$2211
	dc.w	$0000,$31F0,$0E00,$21F0,$0000,$3079,$0F86,$2031
	dc.w	$0000,$0640,$0180,$0440,$0000,$1318,$0C07,$1310
	dc.w	$0000,$F800,$0000,$F800,$0000,$0321,$00DE,$0221
	dc.w	$0000,$1333,$E0C0,$1233,$0000,$1321,$E0C0,$1221
	dc.w	$0000,$931F,$60E0,$121F,$0000,$031F,$00E0,$021F
	dc.w	$0000,$00F8,$0007,$00F8,$0000,$F800,$0000,$F800
	dc.w	$0000,$F8F8,$0700,$F8F8,$0400,$3200,$0800,$2600
	dc.w	$0404,$33F9,$0802,$27F5,$0404,$3219,$0802,$2615
	dc.w	$0404,$33F1,$080A,$27E5,$0400,$31F8,$0A00,$2408
	dc.w	$0A82,$3039,$0544,$2A93,$0080,$0640,$0100,$04C0
	dc.w	$0002,$3E18,$0005,$3E12,$0000,$FF00,$0000,$0700
	dc.w	$0088,$0333,$0044,$02BB,$A080,$1321,$4040,$B2A1
	dc.w	$A040,$1321,$4080,$B261,$4040,$931F,$20A0,$5240
	dc.w	$0040,$E31F,$00A0,$E240,$0015,$8060,$000A,$8075
	dc.w	$4000,$3000,$8000,$7000,$1540,$6030,$0A80,$7570
	dc.w	$0C00,$3200,$0000,$2E00,$0C0E,$33F1,$0000,$2C0F
	dc.w	$0C06,$3219,$0000,$2E17,$0FFC,$3002,$0000,$2FFE
	dc.w	$0FF0,$3008,$0000,$2FF8,$0FE6,$3019,$0000,$2FE7
	dc.w	$0180,$0640,$0000,$05C0,$0003,$000C,$0000,$000F
	dc.w	$FD00,$0280,$0000,$FD80,$00C0,$032D,$0000,$02ED
	dc.w	$E0C0,$1321,$0000,$F2E1,$E0C0,$1321,$0000,$F2E1
	dc.w	$607F,$9180,$0000,$71FF,$A0FF,$5300,$0000,$B2FF
	dc.w	$000F,$8030,$0000,$803F,$8000,$6000,$0000,$E000
	dc.w	$0F80,$3060,$0000,$3FE0,$0C00,$3200,$0800,$2600
	dc.w	$0FFE,$3001,$0AAA,$2555,$0C06,$3219,$0802,$2615
	dc.w	$0FF0,$300C,$0AA0,$255C,$0E00,$31F0,$0A00,$25F0
	dc.w	$0DF6,$3209,$0554,$2AA3,$0180,$0640,$0100,$04C0
	dc.w	$0000,$0003,$0000,$0003,$1F00,$E080,$1500,$EA80
	dc.w	$00C0,$0321,$0040,$02A1,$E0C0,$1321,$4040,$B2A1
	dc.w	$E0C0,$1321,$4080,$B261,$6003,$907C,$2002,$507D
	dc.w	$E0E0,$131F,$A0A0,$525F,$000F,$0030,$000A,$0035
	dc.w	$8000,$6000,$8000,$6000,$0F80,$3060,$0A80,$3560
	dc.w	$0C00,$330E,$0C00,$230E,$0E1E,$31E1,$0E1E,$21E1
	dc.w	$0E16,$3129,$0E16,$2121,$0C18,$33E4,$0C18,$23C4
	dc.w	$0C00,$320E,$0C00,$220E,$0CFE,$3301,$0CFE,$2301
	dc.w	$0180,$0640,$0180,$0440,$0000,$0000,$0000,$0000
	dc.w	$0700,$1880,$0700,$1880,$00C0,$0321,$00C0,$0221
	dc.w	$60C0,$9333,$60C0,$1233,$E0E1,$1312,$E0E1,$1212
	dc.w	$6000,$9003,$6000,$1003,$E0C0,$1320,$E0C0,$1220
	dc.w	$001F,$E060,$001F,$E060,$C000,$3000,$C000,$3000
	dc.w	$1FC0,$6030,$1FC0,$6030,$0A00,$35FF,$0E00,$21F3
	dc.w	$0802,$361D,$0C06,$2211,$0208,$3DF7,$061C,$31E3
	dc.w	$0808,$3636,$0C0C,$2222,$0800,$37FF,$0C00,$23F3
	dc.w	$0454,$3AAB,$0C7E,$2281,$0100,$06C0,$0180,$0440
	dc.w	$0000,$000E,$0000,$000E,$0500,$0A80,$0700,$0880
	dc.w	$0040,$03A1,$00C0,$0221,$4040,$B3BF,$6060,$131E
	dc.w	$4020,$B3DF,$C061,$331E,$8000,$71C1,$C000,$31C1
	dc.w	$A080,$537F,$E0C0,$123F,$0002,$F0FD,$0007,$30F8
	dc.w	$0000,$F800,$0000,$F800,$0200,$FDF8,$0700,$F8F8
	dc.w	$0000,$3FFF,$0E0E,$2001,$0000,$3E1F,$0C06,$2211
	dc.w	$0000,$1FFE,$061C,$1002,$0000,$3F1F,$0C06,$2311
	dc.w	$0000,$3FFF,$0C0E,$2001,$0000,$3F7F,$0E3E,$2141
	dc.w	$0000,$07E0,$01C0,$0420,$0000,$001F,$0000,$0011
	dc.w	$0000,$FF80,$0F00,$F080,$0000,$03F3,$00E0,$0212
	dc.w	$0000,$F1FF,$E061,$1100,$0000,$E1FF,$C061,$2100
	dc.w	$0000,$E3FF,$C001,$223E,$0000,$F3FF,$E0C0,$1200
	dc.w	$0000,$F00F,$E002,$100D,$0000,$8000,$0000,$8000
	dc.w	$0000,$0F80,$0200,$0D80,$0000,$3FFF,$0FFE,$2001
	dc.w	$0000,$3F3F,$0E0E,$2121,$0000,$1FFE,$07F8,$1806
	dc.w	$0000,$3F3F,$0E0E,$2121,$0000,$3FFF,$0FFE,$2001
	dc.w	$0000,$3F3F,$0E1E,$2121,$0000,$07E0,$01C0,$0420
	dc.w	$0000,$001F,$0006,$0010,$0000,$FF80,$1F00,$0080
	dc.w	$0000,$03F3,$00E0,$0212,$0000,$F1FF,$E03F,$1180
	dc.w	$0000,$E1FF,$807F,$6180,$0000,$E3FF,$80C3,$6200
	dc.w	$0000,$F3FF,$E0FF,$1200,$0000,$F007,$E000,$1007
	dc.w	$0000,$0000,$0000,$0000,$0000,$0700,$0000,$0700
	dc.w	$0000,$3FFF,$07FC,$3003,$0000,$3F3F,$060E,$2121
	dc.w	$0000,$0FFC,$01E0,$0E1C,$0000,$3F3F,$0E0E,$2121
	dc.w	$0000,$3FFF,$07FC,$3003,$0000,$3F1F,$040E,$3311
	dc.w	$0000,$07E0,$00C0,$0620,$0000,$001F,$0007,$0018
	dc.w	$0000,$FF00,$FC00,$0300,$0000,$03F3,$0040,$0333
	dc.w	$0000,$F0FF,$C01E,$30E1,$0000,$C0FF,$001E,$C0E1
	dc.w	$0000,$C3FF,$00FF,$C300,$0000,$E3FF,$807F,$6300
	dc.w	$0000,$F002,$C000,$3002,$0000,$0000,$0000,$0000
	dc.w	$0000,$0200,$0000,$0200,$0000,$1FFE,$0000,$1FFE
	dc.w	$0000,$1E1E,$0000,$1E1E,$0000,$03F0,$0000,$03F0
	dc.w	$0000,$1E1E,$0000,$1E1E,$0000,$1FFE,$0000,$1FFE
	dc.w	$0000,$1E0E,$0000,$1E0E,$0000,$03C0,$0000,$03C0
	dc.w	$0000,$000F,$0000,$000F,$0000,$FC00,$0000,$FC00
	dc.w	$0000,$01E1,$0000,$01E1,$0000,$E03F,$0000,$E03F
	dc.w	$0000,$003F,$0000,$003F,$0000,$01FF,$0000,$01FF
	dc.w	$0000,$81FF,$0000,$81FF,$0000,$E000,$0000,$E000
	dc.w	$0000,$0000,$0000,$0000

	

A1	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$0798,$0268,$0797,$0000,$8000,$0000,$8000
	dc.w	$03BE,$7DC1,$03F9,$7D86,$0000,$8000,$0000,$8000
	dc.w	$4F78,$F087,$4FFC,$F003,$0000,$0000,$0000,$0000
	dc.w	$0170,$FE8C,$0F78,$F084,$0000,$0000,$0000,$0000
	dc.w	$00E0,$7F18,$00F0,$7F08,$0000,$0000,$0000,$0000
	dc.w	$0040,$00B8,$0070,$0088,$0000,$7000,$0000,$7000
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$D800,$0000,$D800
	dc.w	$0020,$0349,$0090,$0369,$0000,$8C00,$0000,$8C00
	dc.w	$0110,$0625,$00C8,$0735,$0000,$0400,$0000,$0400
	dc.w	$0204,$041B,$01E4,$061B,$0000,$0640,$0000,$0640
	dc.w	$0384,$041B,$0064,$079B,$0000,$0340,$0000,$0340
	dc.w	$002C,$07D2,$002C,$07D2,$0000,$01C0,$0000,$01C0
	dc.w	$0030,$044C,$0030,$044C,$0000,$0000,$0000,$0000
	dc.w	$0000,$0238,$0000,$0238,$0000,$0000,$0000,$0000
	dc.w	$0200,$05BC,$0200,$05BC,$0000,$0000,$0000,$0000
	dc.w	$0400,$0B1E,$040C,$0B12,$0000,$0000,$0000,$0000
	dc.w	$0400,$0A0F,$0402,$0A0D,$0000,$0000,$0000,$0000
	dc.w	$0C00,$320F,$0C06,$3209,$0000,$8000,$0000,$8000
	dc.w	$3C00,$421F,$3C0C,$4213,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	

A2	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$7798,$0268,$7797,$0000,$8000,$0000,$8000
	dc.w	$43BE,$FDC1,$43F9,$FD86,$0000,$8000,$0000,$8000
	dc.w	$0F78,$F087,$0FFC,$F003,$0000,$0000,$0000,$0000
	dc.w	$0170,$7E8C,$0F78,$7084,$0000,$0000,$0000,$0000
	dc.w	$00E0,$0F18,$00F0,$0F08,$0000,$0000,$0000,$0000
	dc.w	$0040,$00B8,$0070,$0088,$0000,$0000,$0000,$0000
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$0000,$0000,$0000
	dc.w	$0020,$0348,$0090,$0368,$0000,$F040,$0000,$F040
	dc.w	$0110,$0625,$00C8,$0735,$0000,$9840,$0000,$9840
	dc.w	$0204,$041B,$01E4,$061B,$0000,$0840,$0000,$0840
	dc.w	$0384,$041B,$0064,$079B,$0000,$0C40,$0000,$0C40
	dc.w	$000C,$07F2,$000C,$07F2,$0000,$06C0,$0000,$06C0
	dc.w	$0170,$068C,$0170,$068C,$0000,$0380,$0000,$0380
	dc.w	$0240,$0DB8,$0240,$0DB8,$0000,$0000,$0000,$0000
	dc.w	$0400,$0BF0,$0400,$0BF0,$0000,$0000,$0000,$0000
	dc.w	$0200,$0578,$0220,$0558,$0000,$0000,$0000,$0000
	dc.w	$0600,$0938,$0610,$0928,$0000,$0000,$0000,$0000
	dc.w	$0800,$1638,$0810,$1628,$0000,$0000,$0000,$0000
	dc.w	$0000,$1C78,$0010,$1C68,$0000,$0000,$0000,$0000
	dc.w	$0000,$00F8,$0070,$0088,$0000,$0000,$0000,$0000
	dc.w	$0000,$00F8,$0000,$00F8,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	

A3	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$0798,$0268,$0797,$0000,$8000,$0000,$8000
	dc.w	$03BE,$7DC1,$03F9,$7D86,$0000,$8000,$0000,$8000
	dc.w	$4F78,$F087,$4FFC,$F003,$0000,$0000,$0000,$0000
	dc.w	$0170,$FE8C,$0F78,$F084,$0000,$0000,$0000,$0000
	dc.w	$00E0,$7F18,$00F0,$7F08,$0000,$0000,$0000,$0000
	dc.w	$0040,$00B8,$0070,$0088,$0000,$0040,$0000,$0040
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$0040,$0000,$0040
	dc.w	$0020,$0308,$00D0,$0328,$0000,$00C0,$0000,$00C0
	dc.w	$0100,$0624,$00D8,$0724,$0000,$0080,$0000,$0080
	dc.w	$0200,$0475,$0188,$0675,$0000,$E080,$0000,$E080
	dc.w	$0370,$048F,$0070,$078F,$0000,$3080,$0000,$3080
	dc.w	$00C0,$073C,$00C0,$073C,$0000,$1080,$0000,$1080
	dc.w	$0000,$07FC,$0000,$07FC,$0000,$1980,$0000,$1980
	dc.w	$0000,$03F0,$0000,$03F0,$0000,$0F00,$0000,$0F00
	dc.w	$0300,$04E0,$0300,$04E0,$0000,$0000,$0000,$0000
	dc.w	$00C0,$0338,$00C0,$0338,$0000,$0000,$0000,$0000
	dc.w	$0020,$00D8,$0020,$00D8,$0000,$0000,$0000,$0000
	dc.w	$0040,$01B0,$0040,$01B0,$0000,$0000,$0000,$0000
	dc.w	$0080,$0170,$0080,$0170,$0000,$0000,$0000,$0000
	dc.w	$0100,$02E0,$0160,$0280,$0000,$0000,$0000,$0000
	dc.w	$0000,$03E0,$0000,$03E0,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	

A4	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$7798,$0268,$7797,$0000,$8000,$0000,$8000
	dc.w	$43BE,$FDC1,$43F9,$FD86,$0000,$8000,$0000,$8000
	dc.w	$0F78,$F087,$0FFC,$F003,$0000,$0100,$0000,$0100
	dc.w	$0170,$7E8C,$0F78,$7084,$0000,$0200,$0000,$0200
	dc.w	$00E0,$0F18,$00F0,$0F08,$0000,$0200,$0000,$0200
	dc.w	$0040,$00B8,$0070,$0088,$0000,$0200,$0000,$0200
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$0200,$0000,$0200
	dc.w	$0020,$0348,$0090,$0368,$0000,$0600,$0000,$0600
	dc.w	$0110,$064C,$00A0,$075C,$0000,$0400,$0000,$0400
	dc.w	$0200,$05F6,$0008,$07F6,$0000,$0400,$0000,$0400
	dc.w	$01F0,$0607,$01F8,$0607,$0000,$C400,$0000,$C400
	dc.w	$0100,$06FE,$0100,$06FE,$0000,$6C00,$0000,$6C00
	dc.w	$0000,$07DC,$0020,$07FC,$0000,$3800,$0000,$3800
	dc.w	$0000,$07F8,$0000,$07F8,$0000,$0000,$0000,$0000
	dc.w	$0010,$0728,$0010,$0728,$0000,$0000,$0000,$0000
	dc.w	$0010,$0728,$0310,$0428,$0000,$0000,$0000,$0000
	dc.w	$0008,$0396,$0108,$0296,$0000,$0000,$0000,$0000
	dc.w	$0004,$0F8B,$0104,$0E8B,$0000,$0000,$0000,$0000
	dc.w	$000E,$1F91,$0F0E,$1091,$0000,$0000,$0000,$0000
	dc.w	$0000,$1F1E,$0000,$1F1E,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	

	
A5	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$0798,$0268,$0797,$0000,$8000,$0000,$8000
	dc.w	$03BE,$7DC1,$03F9,$7D86,$0000,$8000,$0000,$8000
	dc.w	$4F78,$F087,$4FFC,$F003,$0000,$0000,$0000,$0000
	dc.w	$0170,$FE8C,$0F78,$F084,$0000,$0000,$0000,$0000
	dc.w	$00E0,$7F18,$00F0,$7F08,$0000,$0200,$0000,$0200
	dc.w	$0040,$00B8,$0070,$0088,$0000,$0200,$0000,$0200
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$0600,$0000,$0600
	dc.w	$0000,$0308,$00F0,$0308,$0000,$0400,$0000,$0400
	dc.w	$0100,$0654,$00A8,$0754,$0000,$0400,$0000,$0400
	dc.w	$0040,$07B4,$0048,$07B4,$0000,$0400,$0000,$0400
	dc.w	$03C0,$0424,$03D8,$0424,$0000,$0400,$0000,$0400
	dc.w	$0200,$05FF,$0200,$05FF,$0000,$8C00,$0000,$8C00
	dc.w	$0000,$07DC,$0020,$07FC,$0000,$D800,$0000,$D800
	dc.w	$0000,$03F8,$0000,$03F8,$0000,$7000,$0000,$7000
	dc.w	$0000,$07FC,$0200,$05FC,$0000,$0000,$0000,$0000
	dc.w	$000C,$0F12,$040C,$0B12,$0000,$0000,$0000,$0000
	dc.w	$0002,$0E0D,$0402,$0A0D,$0000,$0000,$0000,$0000
	dc.w	$0006,$3E09,$0C06,$3209,$0000,$8000,$0000,$8000
	dc.w	$000C,$7E13,$3C0C,$4213,$0000,$0000,$0000,$0000
	dc.w	$0000,$7C1E,$0000,$7C1E,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	

A6	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$7798,$0268,$7797,$0000,$8000,$0000,$8000
	dc.w	$43BE,$FDC1,$43F9,$FD86,$0000,$8000,$0000,$8000
	dc.w	$0F78,$F087,$0FFC,$F003,$0000,$0000,$0000,$0000
	dc.w	$0170,$7E8C,$0F78,$7084,$0000,$0000,$0000,$0000
	dc.w	$00E0,$0F18,$00F0,$0F08,$0000,$0000,$0000,$0000
	dc.w	$0040,$00B8,$0070,$0088,$0000,$0180,$0000,$0180
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$0700,$0000,$0700
	dc.w	$0020,$0348,$0090,$0368,$0000,$0C00,$0000,$0C00
	dc.w	$0110,$064C,$00A0,$075C,$0000,$1800,$0000,$1800
	dc.w	$0200,$05F4,$0008,$07F4,$0000,$1000,$0000,$1000
	dc.w	$01F0,$0606,$01F8,$0606,$0000,$1000,$0000,$1000
	dc.w	$0100,$06FF,$0100,$06FF,$0000,$B000,$0000,$B000
	dc.w	$0000,$07BC,$0040,$07FC,$0000,$E000,$0000,$E000
	dc.w	$0000,$0FF8,$0000,$0FF8,$0000,$0000,$0000,$0000
	dc.w	$0000,$0FF0,$0400,$0BF0,$0000,$0000,$0000,$0000
	dc.w	$0020,$0758,$0220,$0558,$0000,$0000,$0000,$0000
	dc.w	$0010,$0F28,$0610,$0928,$0000,$0000,$0000,$0000
	dc.w	$0010,$1E28,$0810,$1628,$0000,$0000,$0000,$0000
	dc.w	$0010,$1C68,$0010,$1C68,$0000,$0000,$0000,$0000
	dc.w	$0070,$0088,$0070,$0088,$0000,$0000,$0000,$0000
	dc.w	$0000,$00F8,$0000,$00F8,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	

A7	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$7798,$0268,$7797,$0000,$8000,$0000,$8000
	dc.w	$43BE,$FDC1,$43F9,$FD86,$0000,$8000,$0000,$8000
	dc.w	$0F78,$F087,$0FFC,$F003,$0000,$0000,$0000,$0000
	dc.w	$0170,$7E8C,$0F78,$7084,$0000,$0780,$0000,$0780
	dc.w	$00E0,$0F18,$00F0,$0F08,$0000,$0CE0,$0000,$0CE0
	dc.w	$0040,$00B8,$0070,$0088,$0000,$1820,$0000,$1820
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$3030,$0000,$3030
	dc.w	$0020,$0348,$0090,$0368,$0000,$2000,$0000,$2000
	dc.w	$0110,$0624,$00C8,$0734,$0000,$6000,$0000,$6000
	dc.w	$0204,$041A,$01E4,$061A,$0000,$4000,$0000,$4000
	dc.w	$0384,$041A,$0064,$079A,$0000,$C000,$0000,$C000
	dc.w	$000C,$07F3,$000C,$07F3,$0000,$8000,$0000,$8000
	dc.w	$0030,$044C,$0030,$044C,$0000,$0000,$0000,$0000
	dc.w	$0000,$0278,$0000,$0278,$0000,$0000,$0000,$0000
	dc.w	$0000,$0738,$0010,$0728,$0000,$0000,$0000,$0000
	dc.w	$0300,$0438,$0310,$0428,$0000,$0000,$0000,$0000
	dc.w	$0100,$029E,$0108,$0296,$0000,$0000,$0000,$0000
	dc.w	$0100,$0E8F,$0106,$0E89,$0000,$0000,$0000,$0000
	dc.w	$0F00,$109F,$0F0E,$1091,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	

A8	dc.w	$0000,$0067,$0000,$0067,$0000,$0000,$0000,$0000
	dc.w	$0082,$017D,$00E5,$011A,$0000,$8000,$0000,$8000
	dc.w	$01E7,$0398,$01E8,$0397,$0000,$8000,$0000,$8000
	dc.w	$0267,$0798,$0268,$0797,$0000,$8000,$0000,$8000
	dc.w	$03BE,$7DC1,$03F9,$7D86,$0000,$8000,$0000,$8000
	dc.w	$4F78,$F087,$4FFC,$F003,$0000,$0000,$0000,$0000
	dc.w	$0170,$FE8C,$0F78,$F084,$0000,$0000,$0000,$0000
	dc.w	$00E0,$7F18,$00F0,$7F08,$0000,$0000,$0000,$0000
	dc.w	$0040,$00B8,$0070,$0088,$0000,$1E00,$0000,$1E00
	dc.w	$0000,$01F8,$0000,$01F8,$0000,$3300,$0000,$3300
	dc.w	$0020,$0308,$00D0,$0328,$0000,$6000,$0000,$6000
	dc.w	$0100,$0624,$00D8,$0724,$0000,$4000,$0000,$4000
	dc.w	$0200,$0474,$0188,$0674,$0000,$4000,$0000,$4000
	dc.w	$0370,$048C,$0070,$078C,$0000,$C000,$0000,$C000
	dc.w	$02D0,$073F,$00C0,$073F,$0000,$8000,$0000,$8000
	dc.w	$00A0,$077C,$0080,$077C,$0000,$0000,$0000,$0000
	dc.w	$0000,$03F8,$0000,$03F8,$0000,$0000,$0000,$0000
	dc.w	$0060,$0390,$0260,$0190,$0000,$0000,$0000,$0000
	dc.w	$0060,$0398,$0160,$0298,$0000,$0000,$0000,$0000
	dc.w	$0020,$0058,$0020,$0058,$0000,$0000,$0000,$0000
	dc.w	$0020,$0050,$0020,$0050,$0000,$0000,$0000,$0000
	dc.w	$0020,$01D0,$0020,$01D0,$0000,$0000,$0000,$0000
	dc.w	$01E0,$0210,$01E0,$0210,$0000,$0000,$0000,$0000
	dc.w	$0000,$03F0,$0000,$03F0,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000	


PLANCHE	dc.w	$4002,$7FFE,$0000,$7FFE,$0000,$0000,$0000,$0000
	dc.w	$FFFF,$FFFF,$0000,$C003,$0000,$0000,$0000,$0000
	dc.w	$7FFE,$FFFF,$0000,$A801,$0000,$0000,$0000,$0000
	dc.w	$7FFE,$FFFF,$0000,$8481,$0000,$0000,$0000,$0000
	dc.w	$FFFF,$FFFF,$0000,$D021,$0000,$0000,$0000,$0000
	dc.w	$00EA,$7FFE,$0000,$7FFE,$0000,$0000,$0000,$0000
	dc.w	$FFFF,$FFFF,$0000,$8203,$0000,$0000,$0000,$0000
	dc.w	$7FFE,$FFFF,$0000,$9201,$0000,$0000,$0000,$0000
	dc.w	$7DFE,$FFFF,$0000,$C281,$0000,$0000,$0000,$0000
	dc.w	$7DFE,$FFFF,$0000,$A201,$0000,$0000,$0000,$0000
	dc.w	$7FFE,$FFFF,$0000,$9341,$0000,$0000,$0000,$0000
	dc.w	$3FFF,$FFFF,$0000,$C211,$0000,$0000,$0000,$0000
	dc.w	$00A6,$7FFE,$0000,$7FFE,$0000,$0000,$0000,$0000

TABLE	dc.w	$0080,$0080,$0080,$0000,$0C00,$0C00,$0C00,$0000
	dc.w	$00E0,$00E0,$00E0,$0000,$3800,$3800,$3800,$0000
	dc.w	$0078,$0078,$0078,$0000,$C800,$C800,$C800,$3000
	dc.w	$002C,$002C,$002C,$0050,$D800,$D800,$D800,$2000
	dc.w	$007C,$007C,$007C,$0000,$F000,$F000,$F000,$0000
	dc.w	$003C,$003D,$003C,$0001,$E000,$E000,$E000,$0000
	dc.w	$0180,$0187,$0180,$0007,$0000,$0000,$0000,$0000
	dc.w	$00F0,$00F2,$00F0,$0002,$0800,$0800,$0800,$0000
	dc.w	$00D8,$00DA,$00D8,$0022,$F800,$F800,$F800,$0000
	dc.w	$00EA,$00EA,$00EA,$0010,$E000,$E000,$E000,$1000
	dc.w	$005C,$005E,$005C,$0022,$B000,$B000,$B000,$4000
	dc.w	$007C,$007E,$007C,$0002,$F000,$F000,$F000,$0000
	dc.w	$0030,$0033,$0030,$0003,$C000,$C000,$C000,$0000
	dc.w	$0000,$0002,$0000,$0002,$0000,$0000,$0000,$0000
	dc.w	$0000,$0002,$0000,$0002,$0000,$0000,$0000,$0000
	dc.w	$0000,$0002,$0000,$0002,$0000,$7C60,$0000,$7C60
	dc.w	$0000,$0000,$007E,$007E,$0000,$47EE,$B800,$C7EE
	dc.w	$0001,$0001,$00C2,$00C3,$0040,$3FFE,$8000,$B03A
	dc.w	$0001,$0101,$0086,$0087,$01C6,$0FFF,$C000,$C821
	dc.w	$0001,$0001,$018E,$0189,$00C0,$0FFF,$E000,$283F
	dc.w	$0001,$0001,$019E,$0197,$0060,$19F3,$E600,$D013
	dc.w	$0001,$0001,$001E,$0017,$0070,$33FB,$CC00,$E00B
	dc.w	$0001,$0001,$001E,$0017,$0070,$37FB,$C800,$E00B
	dc.w	$0001,$0001,$000E,$000F,$01F0,$37FB,$C800,$E00B
	dc.w	$0000,$0001,$0033,$003E,$03F0,$3FFF,$8000,$E00F
	dc.w	$0000,$0003,$0045,$007C,$03EE,$9FFF,$C000,$7011
	dc.w	$0000,$0003,$007F,$0044,$03E0,$9FFE,$E000,$501E
	dc.w	$0000,$0000,$007F,$0043,$01C0,$0FE0,$F000,$8820
	dc.w	$0000,$0000,$0020,$003F,$03C0,$0FE0,$0000,$F820
	dc.w	$0000,$3FE0,$001F,$3FFF,$0000,$0FFC,$F000,$FFFC
	dc.w	$0000,$7FFF,$0000,$4000,$0000,$FFFE,$0000,$0002
	dc.w	$0000,$7FFF,$0000,$4000,$0000,$FFFE,$0000,$0002
	dc.w	$1000,$FFFF,$0000,$8000,$0008,$FFFF,$0000,$0001
	dc.w	$1000,$FFFF,$0000,$8000,$0008,$FFFF,$0000,$0001
	dc.w	$1800,$FFFF,$0000,$9000,$0018,$FFFF,$0000,$0009
	dc.w	$1800,$FFFF,$0000,$9000,$0018,$FFFF,$0000,$0009
	dc.w	$1000,$FFFF,$0000,$9FFF,$0008,$FFFF,$0000,$FFF9
	dc.w	$0000,$F700,$0200,$9500,$0000,$00EF,$0040,$00A9
	dc.w	$0000,$6700,$0200,$6500,$0000,$00E6,$0040,$00A6
	dc.w	$0000,$0700,$0200,$0500,$0000,$00E0,$0040,$00A0
	dc.w	$0000,$0700,$0200,$0500,$0000,$00E0,$0040,$00A0
	dc.w	$0000,$0700,$0200,$0500,$0000,$00E0,$0040,$00A0
	dc.w	$0000,$0700,$0200,$0500,$0000,$00E0,$0040,$00A0
	dc.w	$0000,$0700,$0200,$0500,$0000,$00E0,$0040,$00A0
	dc.w	$0000,$0700,$0000,$0700,$0000,$00E0,$0000,$00E0
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

ARBRE1	dc.w	$0000,$4004,$0000,$4004,$0000,$0000,$0000,$0000
	dc.w	$0000,$7E7C,$0000,$7E7C,$0000,$0000,$0000,$0000
	dc.w	$0000,$3398,$0C60,$3398,$0000,$0000,$0000,$0000
	dc.w	$0000,$2108,$1EF0,$2108,$0000,$0000,$0000,$0000
	dc.w	$0000,$2C68,$1390,$2C68,$0000,$0000,$0000,$0000
	dc.w	$0000,$2C68,$1390,$2C68,$0000,$0000,$0000,$0000
	dc.w	$0000,$2C68,$1390,$2C68,$0000,$0000,$0000,$0000
	dc.w	$0000,$3118,$1FE0,$2018,$0000,$0000,$0000,$0000
	dc.w	$0380,$3C70,$0BA0,$3450,$0000,$0000,$0000,$0000
	dc.w	$0100,$1EF8,$0D60,$1298,$0000,$0000,$0000,$0000
	dc.w	$0000,$37D8,$16D0,$2928,$0000,$0000,$0000,$0000
	dc.w	$0000,$3BB8,$1BB0,$2448,$0090,$0090,$0000,$0090
	dc.w	$0000,$36D8,$16D0,$2928,$00D0,$00D0,$0000,$00D0
	dc.w	$0000,$3D78,$1D70,$2288,$0060,$0060,$0000,$0060
	dc.w	$0000,$3FF8,$1010,$2FE8,$0038,$0038,$0000,$0038
	dc.w	$0000,$1FF0,$0000,$1750,$0008,$0008,$0000,$0008
	dc.w	$6602,$FBFF,$1D80,$E27F,$0018,$0018,$0000,$0018
	dc.w	$3606,$FFFF,$49F8,$B607,$0030,$0030,$0000,$0030
	dc.w	$4006,$FFFF,$33C8,$CC37,$0070,$0070,$0000,$0070
	dc.w	$6006,$DFFF,$2180,$DE7F,$0078,$0078,$0000,$0078
	dc.w	$6823,$D7DF,$2185,$DE7A,$01AE,$01FE,$0000,$01FE
	dc.w	$6006,$DFFF,$2184,$DE7B,$03C3,$03CF,$0000,$03CF
	dc.w	$6006,$DFFF,$2184,$DE7B,$0F80,$0F82,$0000,$0F82
	dc.w	$4007,$FFFF,$33CC,$CC33,$1E00,$1F01,$0000,$1F01
	dc.w	$0201,$FFFF,$7DFC,$8203,$F000,$FE01,$0000,$FE01
	dc.w	$0014,$FFFF,$5FEC,$A013,$4000,$F000,$0000,$F000
	dc.w	$0001,$FFFF,$5FFA,$A005,$0000,$0000,$0000,$0000
	dc.w	$0001,$FFFF,$4BD2,$B42D,$0000,$0000,$0000,$0000
	dc.w	$8001,$FFFF,$4002,$BFFD,$0000,$0000,$0000,$0000
	dc.w	$A000,$DFFF,$7016,$8FE9,$0000,$0000,$0000,$0000
	dc.w	$C800,$FFFF,$3A7E,$C581,$0000,$0000,$0000,$0000
	dc.w	$0080,$FF7F,$37D4,$C82B,$0000,$0000,$0000,$0000
	dc.w	$0300,$FCFE,$5FF8,$A006,$0000,$0000,$0000,$0000
	dc.w	$0000,$FFFF,$2BD4,$D42B,$0000,$0000,$0000,$0000
	dc.w	$0080,$7F7F,$3BF8,$4407,$0000,$0000,$0000,$0000
	dc.w	$0200,$FDFE,$1FBC,$E042,$0000,$0000,$0000,$0000
	dc.w	$00A0,$FF5E,$47F0,$B80E,$0000,$0000,$0000,$0000
	dc.w	$0200,$FDFF,$4FE8,$B017,$0000,$0000,$0000,$0000
	dc.w	$0080,$FF7F,$3FBE,$C041,$0000,$0000,$0000,$0000
	dc.w	$0200,$7DFF,$17F4,$680B,$0000,$0000,$0000,$0000
	dc.w	$0020,$FFDE,$0FF8,$F006,$0000,$0000,$0000,$0000
	dc.w	$0000,$FFFF,$7FF8,$8007,$0000,$0000,$0000,$0000
	dc.w	$0200,$FDFF,$1FEE,$E011,$0000,$0000,$0000,$0000
	dc.w	$0080,$7F7F,$2FF4,$500B,$0000,$0000,$0000,$0000
	dc.w	$0010,$FFEE,$1FBC,$E042,$0000,$0000,$0000,$0000
	dc.w	$0280,$FD7F,$2FD0,$D02F,$0000,$0000,$0000,$0000
	dc.w	$0080,$7F7F,$37D4,$482B,$0000,$0000,$0000,$0000
	dc.w	$0300,$FCFF,$5FF8,$A007,$0000,$0000,$0000,$0000
	dc.w	$0000,$FFFF,$2BD4,$D42B,$0000,$0000,$0000,$0000
	dc.w	$0080,$7F7F,$3BF8,$4407,$0000,$0000,$0000,$0000
	dc.w	$0200,$FDFE,$1FBC,$E042,$0000,$0000,$0000,$0000
	dc.w	$00A0,$FF5E,$47F0,$B80E,$0000,$0000,$0000,$0000
	dc.w	$0200,$FDFF,$4FE8,$B017,$0000,$0000,$0000,$0000
	dc.w	$0080,$FF7F,$3FBE,$C041,$0000,$0000,$0000,$0000
	dc.w	$0200,$7DFF,$17F4,$680B,$0000,$0000,$0000,$0000
	dc.w	$0020,$FFDE,$0FF8,$F006,$0000,$0000,$0000,$0000
	dc.w	$0000,$FFFF,$7FF8,$8007,$0000,$0000,$0000,$0000
	dc.w	$0200,$FDFF,$1FEE,$E011,$0000,$0000,$0000,$0000
	dc.w	$0080,$7F7F,$2FF4,$500B,$0000,$0000,$0000,$0000
	dc.w	$0010,$FFEE,$1FBC,$E042,$0000,$0000,$0000,$0000
	dc.w	$0280,$FD7F,$2FD0,$D02F,$0000,$0000,$0000,$0000
	dc.w	$0410,$7BEF,$1FFA,$6005,$0000,$0000,$0000,$0000

ARBRE2	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0008,$0008,$0000,$0008,$0000,$0000,$0000,$0000
	dc.w	$1118,$1118,$0000,$1118,$0000,$0000,$0000,$0000
	dc.w	$1F10,$1F10,$0000,$1F10,$0000,$0000,$0000,$0000
	dc.w	$0630,$0630,$0000,$0630,$0000,$0000,$0000,$0000
	dc.w	$0220,$0220,$0000,$0220,$0000,$0000,$0000,$0000
	dc.w	$0220,$0220,$0000,$0220,$0000,$0000,$0000,$0000
	dc.w	$0170,$0170,$0000,$0170,$0000,$0000,$0000,$0000
	dc.w	$0388,$03C8,$0000,$03C8,$0000,$0000,$0000,$0000
	dc.w	$0500,$0700,$0000,$0700,$0000,$0000,$0000,$0000
	dc.w	$0600,$0600,$0000,$0600,$0000,$0000,$0000,$0000
	dc.w	$7C00,$FC00,$0000,$FC00,$0000,$0000,$0000,$0000
	dc.w	$0640,$1E40,$0000,$1E40,$0000,$0000,$0000,$0000
	dc.w	$0180,$0180,$0000,$0180,$0000,$0000,$0000,$0000
	dc.w	$0100,$0100,$0000,$0100,$0000,$0000,$0000,$0000
	dc.w	$0080,$0080,$0000,$0080,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


HERBE	dc.w	$0850,$0850,$0C70,$0420,$0000,$0000,$0000,$0000
	dc.w	$0670,$0770,$0E70,$0900,$0000,$0000,$0000,$0000
	dc.w	$0660,$09E0,$0660,$0F80,$0000,$0000,$0000,$0000
	dc.w	$0740,$0DC0,$0740,$0A80,$0000,$0000,$0000,$0000
	dc.w	$0780,$0CC0,$0780,$0B40,$0000,$0000,$0000,$0000
	dc.w	$1384,$76CC,$1384,$6548,$0000,$0000,$0000,$0000
	dc.w	$618C,$72CA,$E19C,$9356,$0000,$0000,$0000,$0000
	dc.w	$718E,$7ADA,$F18F,$8B55,$0000,$0000,$0000,$0000
	dc.w	$BB8C,$FEDF,$BB8C,$4553,$0000,$0000,$0000,$0000
	dc.w	$1B8C,$3EFE,$1B8C,$2572,$0000,$0000,$0000,$0000
	dc.w	$0F18,$32BE,$0F18,$3DA6,$0000,$0000,$0000,$0000
	dc.w	$0F30,$1AC8,$0F34,$15FC,$0000,$0000,$0000,$0000
	dc.w	$0370,$0E98,$1370,$1DE8,$0000,$0000,$0000,$0000
	dc.w	$03F0,$0630,$03F0,$05C0,$0000,$0000,$0000,$0000
	dc.w	$01F0,$0220,$01F0,$03D0,$0000,$0000,$0000,$0000
	dc.w	$0180,$0240,$0180,$03C0,$0000,$0000,$0000,$0000


POULIE	dc.w	$0000,$3FFC,$0000,$3FFC,$0000,$0000,$0000,$0000
	dc.w	$0018,$6006,$1FE0,$601E,$0000,$0000,$0000,$0000
	dc.w	$00FC,$C003,$3F00,$C0FF,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6002,$9FFD,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6002,$9FFD,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$1FFE,$8001,$6006,$9FF9,$0000,$0000,$0000,$0000
	dc.w	$3FFC,$C003,$07FC,$F803,$0000,$0000,$0000,$0000
	dc.w	$1FF8,$6006,$1FF8,$6006,$0000,$0000,$0000,$0000
	dc.w	$0000,$3FFC,$0000,$3FFC,$0000,$0000,$0000,$0000
	dc.w	$0000,$03C0,$0000,$03C0,$0000,$0000,$0000,$0000
	dc.w	$03C0,$07E0,$0000,$04E0,$0000,$0000,$0000,$0000
	dc.w	$07E0,$0FF0,$0000,$08B0,$0000,$0000,$0000,$0000
	dc.w	$07E0,$0FF0,$0000,$0A30,$0000,$0000,$0000,$0000
	dc.w	$07E0,$0FF0,$0000,$08F0,$0000,$0000,$0000,$0000
	dc.w	$07E0,$0FF0,$0000,$0FF0,$0000,$0000,$0000,$0000
	dc.w	$0100,$07E0,$0000,$07E0,$0000,$0000,$0000,$0000
	dc.w	$0100,$0100,$0080,$0180,$0000,$0000,$0000,$0000
	dc.w	$0100,$0100,$0080,$0180,$0000,$0000,$0000,$0000
	dc.w	$0140,$0140,$0080,$01C0,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$00C0,$00C0,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0060,$0060,$0000,$0000,$0000,$0000
	dc.w	$0040,$0040,$0420,$0460,$0000,$0000,$0000,$0000
	dc.w	$0040,$0040,$0420,$0460,$0000,$0000,$0000,$0000
	dc.w	$0000,$0040,$0620,$0660,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$03C0,$03C0,$0000,$0000,$0000,$0000
	dc.w	$0000,$0240,$0000,$0240,$0000,$0000,$0000,$0000
	dc.w	$0000,$0240,$0000,$0240,$0000,$0000,$0000,$0000
	dc.w	$0000,$0240,$0000,$0240,$0000,$0000,$0000,$0000
	dc.w	$0000,$0240,$0000,$0240,$0000,$0000,$0000,$0000
	dc.w	$0000,$0240,$0000,$0240,$0000,$0000,$0000,$0000
	dc.w	$0000,$0240,$0000,$0240,$0000,$0000,$0000,$0000
	dc.w	$0000,$0240,$0000,$0240,$0000,$0000,$0000,$0000


WURSHT	dc.w	$0000,$0002,$0000,$0002,$0000,$4000,$0000,$4000
	dc.w	$0000,$0002,$0000,$0002,$0000,$4000,$0000,$4000
	dc.w	$0000,$0002,$0000,$0002,$0000,$4000,$0000,$4000
	dc.w	$0000,$0002,$0000,$0002,$0000,$4000,$0000,$4000
	dc.w	$0000,$0002,$0000,$0002,$0000,$4000,$0000,$4000
	dc.w	$0000,$0002,$0000,$0002,$0000,$4000,$0000,$4000
	dc.w	$0000,$3F82,$0000,$3F82,$0000,$41FC,$0000,$41FC
	dc.w	$0C00,$73F2,$1F00,$60F2,$00C0,$4F0E,$00F8,$4F06
	dc.w	$0400,$E1FF,$3FE0,$C01F,$0080,$FF7F,$07FC,$F803
	dc.w	$2F70,$C00F,$7FFF,$8000,$04C0,$F83F,$FFFE,$0001
	dc.w	$201C,$DF20,$7FFF,$8000,$CF80,$007F,$FFFE,$0001
	dc.w	$0000,$FFFF,$3FFF,$C000,$0000,$FFFF,$FFFC,$0003
	dc.w	$0000,$7FFF,$1FFF,$6000,$0000,$FFFE,$FFF0,$000E
	dc.w	$0000,$3FFF,$01FF,$3E00,$0000,$FFF8,$FF80,$0078
	dc.w	$0000,$03FF,$000F,$03F0,$0000,$FFC0,$FC00,$03C0
	dc.w	$0000,$001F,$0000,$001F,$0000,$FC00,$0000,$FC00


COLONNE	dc.w	$0000,$3FFC,$0000,$3FFC,$0000,$1008,$0000,$1008
	dc.w	$0000,$2804,$0000,$2004,$0000,$5002,$0000,$4002
	dc.w	$2FFC,$5002,$0000,$4002,$5FFE,$A001,$0000,$8001
	dc.w	$5FFE,$A001,$0000,$8001,$7FFE,$8001,$0000,$80D1
	dc.w	$6F1E,$8081,$00E0,$9111,$2FBC,$4003,$0040,$5093
	dc.w	$27FC,$4002,$0000,$5802,$1778,$2004,$0000,$2884
	dc.w	$0000,$1818,$0000,$1FF8,$8001,$FFFF,$0000,$FFFF
	dc.w	$8007,$8001,$7FF8,$8007,$807F,$8001,$7F80,$807F
	dc.w	$9FFF,$8001,$6000,$9FFF,$9FFF,$8001,$6000,$9FFF
	dc.w	$9FFF,$8001,$6002,$9FFD,$9FFF,$8001,$6002,$9FFD
	dc.w	$9FFF,$8001,$6002,$9FFD,$9FFF,$8001,$6002,$9FFD
	dc.w	$9FFF,$8001,$6002,$9FFD,$9FFF,$8001,$6002,$9FFD
	dc.w	$9FFF,$8001,$6006,$9FF9,$9FFF,$8001,$6006,$9FF9
	dc.w	$FFFF,$8001,$07FE,$F801,$FFFF,$8001,$7FFE,$8001
	dc.w	$FFFF,$FFFF,$0000,$FFFF,$8007,$8001,$7FF8,$8007
	dc.w	$807F,$8001,$7F80,$807F,$9FFF,$8001,$6000,$9FFF
	dc.w	$9FFF,$8001,$6000,$9FFF,$9FFF,$8001,$6002,$9FFD
	dc.w	$9FFF,$8001,$6002,$9FFD,$9FFF,$8001,$6002,$9FFD
	dc.w	$9FFF,$8001,$6002,$9FFD,$9FFF,$8001,$6002,$9FFD
	dc.w	$9FFF,$8001,$6002,$9FFD,$9FFF,$8001,$6006,$9FF9
	dc.w	$9FFF,$8001,$6006,$9FF9,$FFFF,$8001,$07FE,$F801
	dc.w	$FFFF,$8001,$7FFE,$8001,$FFFF,$FFFF,$0000,$FFFF

FLEUR	dc.w	$0000,$0000,$1F00,$1F00,$0000,$1100,$2E80,$3180
	dc.w	$0000,$2000,$1F80,$2080,$0000,$2800,$1780,$2880
	dc.w	$0000,$2100,$1E80,$2180,$0000,$2200,$1D80,$2280
	dc.w	$0300,$1C00,$8080,$9F80,$0100,$0600,$4082,$4782
	dc.w	$0000,$1380,$200E,$338E,$0620,$1F38,$C620,$D918
	dc.w	$06E0,$0FF8,$76E6,$791E,$07C0,$0FF0,$17C0,$1830
	dc.w	$0100,$07C0,$0100,$06C0,$0000,$0400,$0380,$0780
	dc.w	$0000,$0000,$0780,$0780,$0000,$0000,$0700,$0700
	dc.w	$0000,$0000,$0F00,$0F00


B1	dc.w	$0000,$0000,$03E0,$03E0,$0000,$0000,$01F0,$01F0
	dc.w	$03E0,$03E0,$0FF8,$0FF8,$01F0,$0110,$0F1E,$0FFE
	dc.w	$0FF8,$03F8,$73FC,$7FFC,$0E0E,$0E0E,$1FFF,$1FFF
	dc.w	$3FFC,$27FC,$E7FF,$FFFF,$13F8,$03F8,$0FFF,$1FFF
	dc.w	$FFFF,$C7FF,$C7FF,$FFFF,$0006,$0000,$FFF9,$FFFF
	dc.w	$FFFF,$C7FF,$C7FF,$7FFF,$FFFE,$EFE0,$EFE1,$FFFF
	dc.w	$FFFF,$C3FF,$C3FF,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$C3FF,$C3FF,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$83FF,$83FF,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$83FF,$83FF,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$87FF,$87FF,$FFFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$FFFF,$C3FF,$C3FF,$7FFF,$FFFE,$FF80,$FF81,$FFFF
	dc.w	$FFFF,$C3FF,$C3FF,$FFFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$FC0F,$800F,$83FF,$7FFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$F003,$0003,$0E0F,$FE0F,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$C001,$8001,$B003,$7003,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$8000,$0000,$6001,$E001,$7FFC,$7F80,$FF82,$FFFE
	dc.w	$0000,$0000,$8000,$8000,$01F0,$0180,$7F8C,$7FFC
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$01F0,$01F0

B2	dc.w	$0000,$0000,$000E,$000E,$0000,$0000,$01F0,$01F0
	dc.w	$000E,$000E,$003F,$003F,$01F0,$0110,$8F1E,$8FFE
	dc.w	$003F,$000F,$81CF,$81FF,$8E0E,$8E0E,$FFFF,$FFFF
	dc.w	$80FF,$809F,$E39F,$E3FF,$E3F8,$E3F8,$FFFF,$FFFF
	dc.w	$E3FF,$E31F,$FF1F,$7FFF,$FC06,$EC00,$EFF9,$FFFF
	dc.w	$FFFF,$FF1F,$FF1F,$FFFF,$FFFE,$EFE0,$EFE1,$FFFF
	dc.w	$FFFF,$FF0F,$FF0F,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FF0F,$FF0F,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FE0F,$FE0F,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FE0F,$FE0F,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FE1F,$FE1F,$7FFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$FFFF,$FF0F,$FF0F,$FFFF,$FFFE,$EF80,$EF81,$FFFF
	dc.w	$FFFF,$FF0F,$FF0F,$7FFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$FFF0,$FE00,$FE0F,$FFFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$7FC0,$7C00,$FC39,$FFF9,$3FFE,$3FC0,$FFC1,$FFFF
	dc.w	$3F00,$3C00,$7CC0,$7FC0,$1FFE,$1FC0,$3FC1,$3FFF
	dc.w	$0E00,$0C00,$3D80,$3F80,$07FC,$0780,$0F82,$0FFE
	dc.w	$0000,$0000,$0E00,$0E00,$01F0,$0180,$078C,$07FC
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$01F0,$01F0

B3	dc.w	$0000,$0000,$C000,$C000,$0000,$0000,$01F0,$01F0
	dc.w	$C000,$C000,$F003,$F003,$01F0,$0110,$CF1E,$CFFE
	dc.w	$F003,$F001,$F805,$7807,$CE0E,$CE0E,$FFFF,$FFFF
	dc.w	$F807,$F800,$FE38,$FE3F,$E3F8,$E3F8,$FFFF,$FFFF
	dc.w	$FE1F,$FE10,$FFF0,$7FFF,$FC06,$FC00,$FFF9,$FFFF
	dc.w	$FFFF,$FFF0,$FFF0,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FFF1,$FFF1,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FFF1,$FFF1,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FFE3,$FFE3,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$7FE3,$7FE3,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$FFE3,$FFE3,$7FFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$FFFF,$7FF1,$7FF1,$FFFF,$FFFE,$FF80,$FF81,$FFFF
	dc.w	$FFFF,$FFF1,$FFF1,$7FFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$1FFF,$1FE1,$FFE1,$FFFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$07FC,$07C0,$1FC3,$1FFF,$3FFE,$3FC0,$FFC1,$FFFF
	dc.w	$03F0,$03C0,$07CC,$07FC,$0FFE,$0FC0,$3FC1,$3FFF
	dc.w	$00E0,$00C0,$03D8,$03F8,$07FC,$0780,$0F82,$0FFE
	dc.w	$0000,$0000,$00E0,$00E0,$01F0,$0180,$078C,$07FC
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$01F0,$01F0

B4	dc.w	$0000,$0600,$1800,$1E00,$01F0,$01F0,$01F0,$0000
	dc.w	$1E00,$0600,$6780,$7F80,$1FFE,$1F1E,$1F1E,$01F0
	dc.w	$7F80,$0380,$83C0,$FFC0,$1E0F,$1E0F,$FFFF,$EFFE
	dc.w	$FFC0,$07C0,$07F1,$FFF1,$7FFE,$5FFE,$DFFF,$E3F9
	dc.w	$FFF1,$87F1,$87FF,$7FFF,$FFFE,$DFF8,$DFF9,$FC07
	dc.w	$FFFF,$0FFF,$0FFF,$FFFF,$FFFE,$DFE0,$DFE1,$FFFF
	dc.w	$FFFF,$87FF,$87FF,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$07FF,$07FF,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$87FF,$87FF,$7FFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$03FF,$03FF,$FFFF,$FFFE,$FFE0,$FFE1,$FFFF
	dc.w	$FFFF,$83FF,$83FF,$7FFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$FFFF,$03FF,$03FF,$FFFF,$FFFE,$FF80,$FF81,$FFFF
	dc.w	$FFFF,$87FF,$87FF,$7FFF,$FFFE,$DFC0,$DFC1,$FFFF
	dc.w	$F0FF,$00FF,$0FFF,$FFFF,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$C03F,$803F,$B0FF,$70FF,$FFFE,$9FC0,$9FC1,$FFFF
	dc.w	$801F,$001F,$403F,$C03F,$FFFE,$FFC0,$FFC1,$FFFF
	dc.w	$0007,$0007,$801F,$801F,$07FC,$0780,$FF82,$FFFE
	dc.w	$0000,$0000,$0007,$0007,$01F8,$0188,$078C,$07F4
	dc.w	$0000,$0000,$0000,$0000,$01F0,$01F0,$01F0,$0000

PARLE      dc.b	27,'E','[A] et [B] pour changer les couleurs .',13,10
	dc.b	13,10,13,10,'(C) Laurent PIECHOCKI, 6/2/89 , GENST2',7,0

EFFACE	dc.b	27,'E',0

VECTEUR	dc.l	A8,A8,A8,A8,A7,A7,A7,A7,A6,A6,A6,A6,A5,A5,A5,A5
	dc.l       A4,A4,A4,A4,A3,A3,A3,A3,A2,A2,A2,A2,A1,A1,A1,A1,-1

ADRESSES   dc.l       B4,B4,B3,B3,B2,B2,B1,B1,-1

	SECTION	BSS
	
          ds.b      500
PILE
          EVEN
TAMPON    ds.W      12*24+2	
          EVEN
SAUSSICE  ds.W      12*17+2	
          EVEN
EAU       ds.W      12*19+2	
          EVEN
SSP       ds.l      1
VALEUR    ds.w      1
INC       ds.w      1
BON       ds.w      1
CA        ds.l      1
PALETTE   ds.w      16
FLAG      ds.b      1
TESTONS   ds.b      1

	END
