/* resource set indicies for ESSAI */

#define LEMENU   0	/* menu tree */
#define TITRE1   3	/* TITLE in tree LEMENU */
#define TITRE2   4	/* TITLE in tree LEMENU */
#define TITRE3   5	/* TITLE in tree LEMENU */
#define COPYRIGH 8	/* STRING in tree LEMENU */
#define PETESSAI 17	/* STRING in tree LEMENU */
#define QUITTER  19	/* STRING in tree LEMENU */
#define ICHECK   21	/* STRING in tree LEMENU */
#define TEXTE    22	/* STRING in tree LEMENU */

#define COPYFORM 1	/* form/dialog */
#define OUTCOPY  4	/* BUTTON in tree COPYFORM */

#define CHOIX    2	/* form/dialog */
#define OKFORM   13	/* BUTTON in tree CHOIX */
#define ANULFORM 14	/* BUTTON in tree CHOIX */
