/* Resource Datei Indizes f�r JUTILITY */

#define FORM1    0   /* Formular/Dialog */
#define F_CREATE 2   /* BUTTON in Baum FORM1 */
#define D_INFO   4   /* BUTTON in Baum FORM1 */
#define EXIT1    5   /* BUTTON in Baum FORM1 */
#define INFO     6   /* BUTTON in Baum FORM1 */
#define DELETE   7   /* BUTTON in Baum FORM1 */
#define CALC     8   /* BUTTON in Baum FORM1 */
#define FREERAM  9   /* BUTTON in Baum FORM1 */

#define FORM2    1   /* Formular/Dialog */
#define FNAME    2   /* FTEXT in Baum FORM2 */
#define F_LEN    3   /* TEXT in Baum FORM2 */
#define EXIT2    4   /* BUTTON in Baum FORM2 */
#define LAENGE   5   /* TEXT in Baum FORM2 */
#define ONLY_R   6   /* BUTTON in Baum FORM2 */
#define F_DATE   10  /* TEXT in Baum FORM2 */
#define F_TIME   11  /* TEXT in Baum FORM2 */
#define R_AND_W  12  /* BUTTON in Baum FORM2 */

#define FORM3    2   /* Formular/Dialog */
#define EXIT3    6   /* BUTTON in Baum FORM3 */

#define FORM4    3   /* Formular/Dialog */
#define RECHNE   2   /* BUTTON in Baum FORM4 */
#define AND_EN   4   /* BUTTON in Baum FORM4 */
#define EXIT4    5   /* BUTTON in Baum FORM4 */
#define RESULT   6   /* FTEXT in Baum FORM4 */
#define OR_EN    7   /* BUTTON in Baum FORM4 */
#define PLUS     8   /* BUTTON in Baum FORM4 */
#define MINUS    9   /* BUTTON in Baum FORM4 */
#define MAL      10  /* BUTTON in Baum FORM4 */
#define GETEILT  11  /* BUTTON in Baum FORM4 */
#define ZAHL1    13  /* FTEXT in Baum FORM4 */
#define ZAHL2    14  /* FTEXT in Baum FORM4 */
#define DIV_EN   15  /* BUTTON in Baum FORM4 */
#define MOD_EN   16  /* BUTTON in Baum FORM4 */
#define DEZIS    17  /* FTEXT in Baum FORM4 */
