FUNCTION Add(x, y : INTEGER) : INTEGER;
EXTERNAL;
