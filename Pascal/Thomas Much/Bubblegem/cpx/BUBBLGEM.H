/* Resource Datei Indizes f�r BUBBLGEM */

#define BGMAIN           0   /* Formular/Dialog */
#define BGMFRAME         1   /* BUTTON in Baum BGMAIN */
#define BGMBUBBLES       3   /* BUTTON in Baum BGMAIN */
#define BGMOPEN          4   /* FTEXT in Baum BGMAIN */
#define BGMWINSTYLE      5   /* BUTTON in Baum BGMAIN */
#define BGMCLOSE         6   /* FTEXT in Baum BGMAIN */
#define BGMFONTCHANGED   7   /* BUTTON in Baum BGMAIN */
#define BGMSENDKEY       8   /* BUTTON in Baum BGMAIN */
#define BGMDEMON         9   /* BUTTON in Baum BGMAIN */
#define BGMTOPONLY       10  /* BUTTON in Baum BGMAIN */
#define BGMSAVE          11  /* BUTTON in Baum BGMAIN */
#define BGMCANCEL        12  /* BUTTON in Baum BGMAIN */
#define BGMOK            13  /* BUTTON in Baum BGMAIN */

#define IMAGE_DIALOG     1   /* Formular/Dialog */
#define RADIO_SLCT       1   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_DESLCT     2   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_DESLCT   3   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_SLCT     4   /* IMAGE in Baum IMAGE_DIALOG */
