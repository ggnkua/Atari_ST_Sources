CONST
  MAINMENU = 0 ;
    DESK_T = 3 ;
  EXAMPL_T = 4 ;
    FILE_T = 5 ;
   ABOUT_I = 8 ;
     ITEM2 = 18 ;
     ITEM1 = 17 ;
     ITEM3 = 20 ;
     ITEM4 = 21 ;
      QUIT = 23 ;
