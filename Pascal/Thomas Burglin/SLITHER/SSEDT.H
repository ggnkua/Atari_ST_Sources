#define D_SYM 4
#define DY_B2 4
#define DY_B1 3
#define MENU1 0
#define DY_CAN 10
#define DY_OK 11
#define MD_INFO 10
#define MF_LOAD 20
#define MF_NEW 19
#define MF_SAVE 21
#define MF_CLOSE 22
#define MF_QUIT 24
#define ME_COPY 26
#define ME_ERASE 28
#define ME_CUT 27
#define ME_EX 30
#define ME_PASTE 32
#define ME_AND 33
#define ME_OR 34
#define ME_XOR 35
#define MO_GOTO 37
#define MO_PSET 40
#define MO_CSET 39
#define MO_SYM 42
#define MR_UP 44
#define MR_DOWN 45
#define MR_LEFT 46
#define MR_RIGHT 47
#define D_SAVE 1
#define DS_FROM 4
#define DS_TO 2
#define DS_CAN 3
#define DS_AT 5
#define DS_OK 6
#define D_INFO 2
#define DI_OK 3
#define D_GOTO 3
#define DG_CAN 2
#define DG_SET 3
#define DG_OK 5
#define DG_LEVEL 4
extern unsigned char SSEDTRSC[];
