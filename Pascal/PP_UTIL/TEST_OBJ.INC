CONST

	AUSWERTUNG=    0; { Tree Number     0 }

	BESTOK=    1;
	NEXTTEXT=    4;
	PROFTEXT=    5;
	BUTTMENU=    8;
	MENUKNAPP=    9;

	USERIMG=    1; { Tree Number     1 }

	RBLNORM=    1;
	RBHNORM=    2;
	RBHSEL=    3;
	RBLSEL=    4;
	CBLNORM=    5;
	CBHNORM=    6;
	CBHSEL=    7;
	CBLSEL=    8;

	SMILE=    0; { Tree Number     0 }


	SUN=    1; { Tree Number     1 }


	OOH=    2; { Tree Number     2 }


	BLUB=    3; { Tree Number     3 }


	STEIN=    4; { Tree Number     4 }


	MINE=    5; { Tree Number     5 }


	FAHNE=    6; { Tree Number     6 }


	LEER=    7; { Tree Number     7 }


	INFO=    8; { Tree Number     8 }


	SMILE2=    9; { Tree Number     9 }


	SUN2=   10; { Tree Number    10 }


	OOH2=   11; { Tree Number    11 }


	BLUB2=   12; { Tree Number    12 }


	STEIN2=   13; { Tree Number    13 }


	MINE2=   14; { Tree Number    14 }


	FAHNE2=   15; { Tree Number    15 }


	LEER2=   16; { Tree Number    16 }


	INFO2=   17; { Tree Number    17 }

