CONST  imgBreite =         18;
       imgHoehe  =         76;
VAR BitStart : POINTER;

PROCEDURE BitData; 
ASSEMBLER;
  ASM 
  LEA @start,A0 
  MOVE.L A0,BitStart 
  BRA  @fertig 
  @start:
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$1FC0,$0000
  DC.W $0000,$0000,$0000,$0071,$8000,$0000,$0000,$6FF0
  DC.W $0000,$0000,$0000,$0000,$0008,$4000,$0000,$0001
  DC.W $D7F8,$0000,$0000,$0000,$0000,$0004,$2000,$0000
  DC.W $000F,$CD84,$0000,$000C,$0000,$0000,$0F02,$2000
  DC.W $0000,$0011,$8302,$0000,$01C6,$0000,$0004,$11C1
  DC.W $2000,$0000,$0071,$8A03,$0000,$0062,$0000,$0208
  DC.W $2221,$2000,$0000,$00C1,$0E03,$8000,$FC22,$0000
  DC.W $0410,$30B0,$8000,$0000,$0181,$1203,$8003,$FE32
  DC.W $0000,$0810,$2410,$8000,$0000,$0100,$0601,$807F
  DC.W $FF10,$0000,$1020,$5048,$8003,$FF00,$0100,$0B03
  DC.W $9F83,$FF10,$0000,$1020,$6428,$807C,$00F0,$0340
  DC.W $D503,$8003,$FF10,$0000,$1020,$4048,$01C0,$000F
  DC.W $8328,$4B83,$0001,$FF00,$0000,$1020,$5814,$0E00
  DC.W $0000,$7E80,$3EC2,$0001,$FE00,$0000,$0820,$6404
  DC.W $3000,$0000,$0354,$0FE0,$0000,$FE00,$0000,$0810
  DC.W $3024,$C000,$0000,$01A1,$0800,$0000,$7C00,$0000
  DC.W $0410,$1405,$0000,$0000,$01EC,$8800,$0000,$3800
  DC.W $0000,$0208,$1003,$0000,$0000,$0073,$3800,$0000
  DC.W $3000,$0000,$0004,$0A08,$0003,$C000,$001D,$E000
  DC.W $0000,$2000,$0000,$0004,$0400,$001C,$3000,$0006
  DC.W $01C0,$0000,$4000,$0000,$0002,$0200,$0020,$0800
  DC.W $0000,$0220,$0000,$4000,$0000,$0000,$0300,$00C0
  DC.W $0800,$0000,$0220,$0000,$4000,$0000,$0000,$0100
  DC.W $0300,$0800,$0000,$0330,$0000,$8000,$0000,$0000
  DC.W $0080,$0400,$0400,$0000,$1F48,$0000,$8000,$0000
  DC.W $0000,$0080,$0000,$0400,$0000,$60C4,$0001,$0000
  DC.W $0000,$0000,$0040,$0000,$0400,$0000,$8026,$0001
  DC.W $0000,$0000,$0000,$0040,$0000,$04F0,$0019,$0015
  DC.W $8002,$0000,$0000,$0000,$0040,$0000,$0718,$0006
  DC.W $0018,$6004,$0000,$0000,$0000,$0040,$0010,$0404
  DC.W $000C,$0010,$5C78,$0000,$0000,$0000,$0040,$0010
  DC.W $0402,$8010,$0008,$4390,$0000,$0000,$0000,$0020
  DC.W $0008,$0012,$0000,$0008,$8220,$0000,$0000,$0000
  DC.W $0020,$0018,$000A,$0000,$0045,$0420,$0000,$0000
  DC.W $0000,$0010,$0068,$008A,$0000,$0027,$0840,$0000
  DC.W $0000,$0000,$0008,$0088,$0086,$0000,$0128,$E880
  DC.W $1E00,$0000,$0000,$0018,$0110,$0044,$0000,$0090
  DC.W $1F00,$0900,$0000,$0000,$0026,$0010,$0048,$0000
  DC.W $009E,$0200,$0480,$0000,$0000,$0021,$0018,$03F0
  DC.W $0000,$1921,$FC00,$0240,$0000,$0000,$0045,$800E
  DC.W $1C00,$0000,$2540,$0000,$0240,$0000,$0000,$00C0
  DC.W $7003,$E000,$0000,$2380,$0000,$0240,$0000,$0000
  DC.W $0100,$9800,$0000,$0000,$4000,$003C,$0180,$0000
  DC.W $0000,$0300,$AFE0,$0000,$2000,$8000,$0013,$0000
  DC.W $0000,$0000,$0E00,$0B1C,$0000,$7000,$8000,$0008
  DC.W $8000,$0000,$0000,$3000,$2C03,$F007,$F801,$0000
  DC.W $0004,$4000,$0000,$0000,$C000,$1000,$0FFA,$AC02
  DC.W $0000,$0004,$4000,$0000,$0001,$0000,$6000,$0625
  DC.W $420C,$0000,$0008,$4000,$0000,$0002,$0001,$8000
  DC.W $0410,$81F0,$0000,$0008,$4000,$0000,$0004,$0002
  DC.W $0000,$0801,$0000,$0000,$0008,$8000,$0000,$0008
  DC.W $000F,$8000,$1002,$0000,$0000,$0007,$0000,$0000
  DC.W $0010,$0030,$4000,$2006,$0000,$0000,$0000,$0000
  DC.W $0000,$0010,$01C1,$E200,$2009,$C000,$0000,$0000
  DC.W $0000,$0000,$0010,$0000,$1008,$4018,$2000,$0000
  DC.W $0000,$0000,$0000,$0008,$0001,$D000,$4000,$F000
  DC.W $0200,$0000,$0000,$0000,$0224,$0000,$3866,$4001
  DC.W $1218,$0110,$0000,$0000,$0000,$0003,$8000,$2302
  DC.W $4000,$1514,$8802,$1000,$0001,$0800,$0008,$7FFF
  DC.W $C000,$3000,$2004,$4303,$0000,$0000,$0008,$021D
  DC.W $0000,$009A,$8EF7,$D0FD,$5A10,$8D10,$0608,$8080
  DC.W $0000,$0200,$120E,$5217,$0535,$C008,$1040,$2208
  DC.W $0000,$0000,$8840,$40C4,$20A8,$6440,$30CC,$9043
  DC.W $0000,$0040,$0000,$8010,$0062,$CB69,$2504,$FE2A
  DC.W $8000,$2380,$0404,$0000,$0000,$0840,$2263,$2030
  DC.W $240C,$0800,$0000,$0000,$0002,$0000,$0408,$090B
  DC.W $1B56,$4080,$0800,$0000,$4000,$0000,$4220,$001A
  DC.W $0000,$6604,$0000,$0000,$1000,$0000,$0000,$0026
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0404,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
  DC.W $0000,$0000,$0000,$0000,$0000
  @fertig:
   END;
