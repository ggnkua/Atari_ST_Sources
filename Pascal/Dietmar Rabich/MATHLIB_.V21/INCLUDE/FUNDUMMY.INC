{Diese Deklarationen k”nnen eingef�gt werden, falls keine Prozeduren
 und Funktionen aufgerufen werden, die Funktionen verwenden.
 Entwickelt mit ST PASCAL PLUS.                                               }

function F1(x:real;fkt:fktnnummer):real; begin end;
function F2(x:real;fkt:fktnnummer):real; begin end;
function F3(x:real;fkt:fktnnummer):real; begin end;
function F4(x:real;fkt:fktnnummer):real; begin end;
function F5(x:real;fkt:fktnnummer):real; begin end;

