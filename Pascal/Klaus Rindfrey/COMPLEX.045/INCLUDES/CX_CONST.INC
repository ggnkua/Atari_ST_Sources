{ Diese Konstanten bestimmen die Gr”že der Vektor- u. Matrixtypen.    }
{ Sie d�rfen beliebig ver„ndert werden, es muž aber immer j1=i2 sein! }
 i1 = 3; j1 = 2; i2 = 2; j2 = 4;

