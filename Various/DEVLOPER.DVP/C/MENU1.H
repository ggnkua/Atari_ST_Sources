/* resource set indicies for MENU1 */

#define MENU1    0	/* menu tree */
#define INFO     7	/* STRING in tree MENU1 */
#define FIN      16	/* STRING in tree MENU1 */

