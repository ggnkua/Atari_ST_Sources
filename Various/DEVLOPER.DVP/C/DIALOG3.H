/* resource set indicies for DIALOG3 */

#define FORM1    0	/* form/dialog */
#define FM       2	/* BUTTON in tree FORM1 */
#define OM       3	/* BUTTON in tree FORM1 */
#define OC       4	/* BUTTON in tree FORM1 */
#define GO       5	/* BUTTON in tree FORM1 */

