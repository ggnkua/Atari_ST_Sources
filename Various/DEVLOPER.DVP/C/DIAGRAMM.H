/* resource set indicies for DIAGRAMM */

#define MENU1    0	/* menu tree */

#define FORM2    1	/* form/dialog */

#define FORM3    2	/* form/dialog */

