/* resource set indicies for DIALOG1 */

#define FORM1    0	/* form/dialog */
#define BOUTON3  4	/* BUTTON in tree FORM1 */
#define BOUTON1  5	/* BUTTON in tree FORM1 */
#define BOUTON2  6	/* BUTTON in tree FORM1 */

