/* resource set indicies for DIALOG4 */

#define FORM1    0	/* form/dialog */
#define ACTUEL   5	/* TEXT in tree FORM1 */
#define HAUT     6	/* BUTTON in tree FORM1 */
#define BAS      7	/* BUTTON in tree FORM1 */
#define FIN      8	/* BUTTON in tree FORM1 */

