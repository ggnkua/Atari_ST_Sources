/* resource set indicies for MENU2 */

#define MENU1    0	/* menu tree */
#define DESK     3	/* TITLE in tree MENU1 */
#define FONCTION 4	/* TITLE in tree MENU1 */
#define INFO     7	/* STRING in tree MENU1 */
#define FIN      16	/* STRING in tree MENU1 */

