;
;  Affichage d'une chaŒne par la fonction GEMDOS Cconws
;  Assembleur     	STROUT.S
;

gemdos         = 1

cconin         = 1
cconws         = 9


               SECTION TEXT
                
               pea        affichage     ;Fonction d'affichage de la chaŒne
               move.w     #cconws,-(sp) ;(La chaŒne doit ˆtre termin‚e
               trap       #gemdos       ;par un octet nul)
               addq.l     #6,sp

               move.w     #cconin,-(sp) ;Attend appui touche...
               trap       #gemdos
               addq.l     #2,sp

               clr.w      -(sp)         ;Quitte le programme
               trap       #gemdos


               SECTION DATA
                
affichage:     DC.b 27,'p','Affichage en vid‚o inverse?',27,'q'
               DC.b 'Pas de problŠme avec GEMDOS!',0

               END 
