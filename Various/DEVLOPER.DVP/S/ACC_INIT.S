;
; Fichier include pour dВclaration Е l'AES/VDI d'un accessoire
; Assembleur		ACC_INIT.S
;

;Ce fichier peut Иtre utilisВ dans vos applications avec
;Include, qui devra Иtre la premiКre instruction du texte
;source en assembleur

;DiffВrences avec GEM_INIT et GEM_INEX:
;Un accessoire ne doit pas libВrer de mВmoire par
;Setblock/Mshrink. Une seule pile de taille suffisante (4 Ko)
;est crВe.


               SECTION TEXT 

               lea.l      stackend,sp   ;CrВer pile
               jmp        main          ;Saut dans l'application

; Sous-programmes aes et vdi

aes:           move.l     #aespb,d1     ;Bloc de paramКtres AES
               move.w     #$c8,d0       ;Nombre "magique" pour l'AES
               trap       #2            ;Appel GEM
               rts        

vdi:           move.l     #vdipb,d1     ;Bloc de paramКtres VDI
               move.w     #$73,d0       ;Code pour la VDI
               trap       #2            ;Appel GEM
               rts        

gem_init:                 ;appel avant le premier call GEM

;DВclaration Е l'AES (appl_init):

               move.w     #10,control   ;appl_init (AES)
               clr.w      control+2
               move.w     #1,control+4
               clr.w      control+6
               clr.w      control+8
               jsr        aes
               move.w     int_out,ap_id ;Stocker l'identification

;DВclarer l'Вcran comme station de travail (VDI):

               moveq.l    #18,d0        ;prВparer intin
               lea.l      intin,a0
gi_lp:         move.w     #1,0(a0,d0.w) ;Mettre РlВment Е 1
               subq.w     #2,d0         ;РlВment
               bpl.s      gi_lp         ;Fin?
               move.w     #2,20(a0)     ;Drapeau de coordonnВes (toujours 2)

               move.w     #100,contrl   ;v_opnvwk (VDI)
               clr.w      contrl+2
               move.w     #12,contrl+4
               move.w     #11,contrl+6
               move.w     #45,contrl+8
               jsr        vdi
               move.w     contrl+12,handle        ;Handle graphique VDI

               move.w     intout,x_max  ;Stockage de la rВsolution
               move.w     intout+2,y_max
               rts        


gem_exit:                 ;Appeler avant de quitter le programme

               move.w     #101,contrl   ;v_clsvwk (VDI)
               clr.w      contrl+2
               clr.w      contrl+4
               clr.w      contrl+6
               clr.w      contrl+8
               move.w     handle,contrl+12
               jsr        vdi

               move.w     #19,control   ;appl_exit (AES)
               clr.w      control+2
               move.w     #1,control+4
               clr.w      control+6
               clr.w      control+8
               jsr        aes
               rts        

; Les blocs de paramКtres suivent:


               SECTION DATA 

aespb:         DC.l control
               DC.l global
               DC.l int_in             ;DiffВrence entre les tableaux
               DC.l int_out            ;d'entiers AES et VDI: _
               DC.l addr_in
               DC.l addr_out

vdipb:         DC.l contrl
               DC.l intin
               DC.l ptsin
               DC.l intout
               DC.l ptsout

; Voici les tableaux proprement dits:


               SECTION BSS 

global:        DS.w 15   ;AES
control:       DS.w 5
int_in:        DS.w 16
int_out:       DS.w 7
addr_in:       DS.l 2
addr_out:      DS.l 1

contrl:        DS.w 12   ;VDI
intin:         DS.w 128
ptsin:         DS.w 128
intout:        DS.w 128
ptsout:        DS.w 128

stack:         DS.w 2000
stackend:      

ap_id:         DS.w 1    ;ap_id, fourni par appl_init

handle:        DS.w 1    ;Handle graphique VDI

x_max:         DS.w 1    ;RВsolution de l'Вcran, obtenue
y_max:         DS.w 1	тгц v_opnvwk
