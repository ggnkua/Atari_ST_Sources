CONST
  HELPTRE1 = 5 ;
  HELP1EXI = 3 ;
  HELP1MOR = 2 ;
  HELPTRE2 = 6 ;
  HELP2MOR = 10 ;
  HELP2EXI = 11 ;
  HELPTRE4 = 4 ;
  HELP4EXI = 3 ;
  HELP4MOR = 2 ;
  HELPTRE3 = 7 ;
  HELP3MOR = 13 ;
  HELP3EXI = 12 ;
  BLOKTXT1 = 1 ;
  BLCKTREE = 1 ;
  BLOKTXT2 = 2 ;
  BLOKTX2A = 3 ;
  DECBLOCK = 5 ;
  BLOKTXT3 = 4 ;
    BIGDEC = 6 ;
  MENUTREE = 0 ;
  BLOCKNUM = 7 ;
  INCBLOCK = 9 ;
    BIGINC = 8 ;
   BLOCKOK = 10 ;
  DESKMENU = 3 ;
  BLOCKCAN = 11 ;
    ABOUT1 = 6 ;
  TEXTTREE = 2 ;
     TEXT1 = 1 ;
     TEXT2 = 2 ;
    TEXTOK = 4 ;
  TEXTSTRG = 3 ;
    TXTBTN = 5 ;
  TEXTCANC = 6 ;
    DECBTN = 8 ;
    HEXBTN = 7 ;
  FSELTITL = 8 ;
  FSELSTRG = 1 ;
  HELPTRE0 = 9 ;
  HELP0MOR = 13 ;
  HELP0EXI = 14 ;
  INSERTBT = 1 ;
      CFG1 = 3 ;
  PRNTINIT = 2 ;
    SHOWCR = 3 ;
  MARGINSB = 5 ;
  AUTOLOAD = 4 ;
  SAVEWBAK = 6 ;
      TABS = 7 ;
    USDATE = 9 ;
   HEXHACK = 8 ;
    INDENT = 10 ;
  AUTOWRAP = 11 ;
   SETFONT = 13 ;
  BUFFSIZE = 12 ;
   CLIPBRD = 14 ;
  CFG1CANC = 17 ;
  CFG1SAVE = 16 ;
    CFG1OK = 15 ;
