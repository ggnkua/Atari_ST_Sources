CONST
  HELPTRE1 = 5 ;
  HELP1EXI = 3 ;
  HELP1MOR = 2 ;
  BLCKTREE = 1 ;
  BLOKTXT1 = 1 ;
  BLOKTX2A = 3 ;
  BLOKTXT2 = 2 ;
  BLOKTXT3 = 4 ;
  DECBLOCK = 5 ;
  BLOCKNUM = 7 ;
    BIGDEC = 6 ;
    BIGINC = 8 ;
  INCBLOCK = 9 ;
  BLOCKCAN = 11 ;
   BLOCKOK = 10 ;
  FSELTITL = 8 ;
  FSELSTRG = 1 ;
     TEXT1 = 1 ;
  TEXTTREE = 2 ;
     TEXT2 = 2 ;
  TEXTSTRG = 3 ;
    TXTBTN = 5 ;
    TEXTOK = 4 ;
  TEXTCANC = 6 ;
    HEXBTN = 7 ;
    DECBTN = 8 ;
  HELPTRE0 = 9 ;
  HELP0MOR = 13 ;
  HELP0EXI = 14 ;
  MENUTREE = 0 ;
  DESKMENU = 3 ;
    ABOUT1 = 6 ;
  HELPTRE4 = 4 ;
  HELPTRE2 = 6 ;
  HELP4EXI = 3 ;
  HELP4MOR = 2 ;
  HELPTRE3 = 7 ;
  HELP2EXI = 11 ;
  HELP2MOR = 10 ;
  HELP3EXI = 12 ;
  HELP3MOR = 13 ;
      CFG1 = 3 ;
  INSERTBT = 1 ;
    SHOWCR = 3 ;
  PRNTINIT = 2 ;
  AUTOLOAD = 4 ;
  MARGINSB = 5 ;
      TABS = 7 ;
  SAVEWBAK = 6 ;
   HEXHACK = 8 ;
    USDATE = 9 ;
  AUTOWRAP = 11 ;
    INDENT = 10 ;
  BUFFSIZE = 12 ;
   SETFONT = 13 ;
  CFG1CANC = 17 ;
   CLIPBRD = 14 ;
    CFG1OK = 15 ;
  CFG1SAVE = 16 ;
