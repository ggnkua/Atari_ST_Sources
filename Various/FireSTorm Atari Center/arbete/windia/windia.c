static short BBDATA0[] = {
0x0180,0x0180,0x0240,0x0240,
0x0420,0x0420,0x0810,0x0810,
0x1008,0x1008,0x2004,0x2004,
0x4002,0x4002,0x8001,0xffff,
};

static short BBDATA1[] = {
0xffff,0x8001,0x4002,0x4002,
0x2004,0x2004,0x1008,0x1008,
0x0810,0x0810,0x0420,0x0420,
0x0240,0x0240,0x0180,0x0180,
};

static short BBDATA2[] = {
0x0180,0x0180,0x0240,0x0240,
0x0420,0x0420,0x0810,0x0810,
0x1008,0x1008,0x2004,0x2004,
0x4002,0x4002,0x8001,0xffff,
};

static short BBDATA3[] = {
0xffff,0x8001,0x4002,0x4002,
0x2004,0x2004,0x1008,0x1008,
0x0810,0x0810,0x0420,0x0420,
0x0240,0x0240,0x0180,0x0180,
};

BITBLK BBOB0 = {BBDATA0,2,16,0,0,1};
BITBLK BBOB1 = {BBDATA1,2,16,0,0,1};
BITBLK BBOB2 = {BBDATA2,2,16,0,0,1};
BITBLK BBOB3 = {BBDATA3,2,16,0,0,1};

static short CI0DATA0[] = {
0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x7fff,0xfff8,
0x4080,0x0104,0x4080,0xf902,
0x4080,0x8903,0x4080,0x8903,
0x4080,0x8903,0x4080,0x8903,
0x4080,0x8903,0x4080,0xf903,
0x4080,0x0103,0x407f,0xfe03,
0x4000,0x0003,0x4000,0x0003,
0x41ff,0xffc3,0x4100,0x0043,
0x4100,0x0043,0x4100,0x0043,
0x4100,0x0043,0x4100,0x0043,
0x4100,0x0043,0x4100,0x0043,
0x4100,0x0043,0x4100,0x0043,
0x5d00,0x0043,0x5500,0x0043,
0x5d00,0x0043,0x4100,0x0043,
0x7fff,0xffff,0x3fff,0xffff,
};

static short CI0MASK0[] = {
0x0000,0x0000,0x0000,0x0000,
0x0000,0x0000,0x7fff,0xfff8,
0x7fff,0xfffc,0x7fff,0xfffe,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x7fff,0xffff,
0x7fff,0xffff,0x3fff,0xffff,
};

static short CI0CDATA0[] = {
0xffff,0xfff8,0x8080,0x0044,
0x8880,0x3c42,0x8880,0x2041,
0x8880,0x2043,0x88ff,0xe3c3,
0x8880,0x2043,0x88aa,0xa143,
0x88ff,0xe343,0x8880,0x0043,
0x88ff,0xffc3,0x8000,0x0003,
0x8000,0x0003,0x8000,0x0003,
0x8000,0x0003,0x8000,0x0003,
0x8000,0x0003,0x8000,0x0003,
0x8000,0x0023,0x81ff,0xffc3,
0x81ff,0xffc3,0x81ff,0xffc3,
0x81ff,0xffc3,0x81ff,0xffc3,
0x81ff,0xffc3,0x81ff,0xffc3,
0x81ff,0xffc3,0x99ff,0xffc3,
0x99ff,0xffc3,0x81ff,0xffc3,
0xbe00,0x001f,0x7fff,0xffff,
0xffff,0xfff8,0xb080,0x005c,
0xc880,0x3c62,0xc880,0x2061,
0xc880,0x2063,0xc8ff,0xe3e3,
0xc880,0x2063,0xc8aa,0xa163,
0xc8ff,0xe363,0xc880,0x0063,
0xc8ff,0xffe3,0xc7ff,0xffe3,
0xc000,0x0003,0xc000,0x0003,
0xc000,0x0003,0xc000,0x0003,
0xc000,0x0003,0xc000,0x0003,
0xc000,0x0023,0xc1ff,0xffc3,
0xc1ff,0xffc3,0xc1ff,0xffc3,
0xc1ff,0xffc3,0xc1ff,0xffc3,
0xc1ff,0xffc3,0xc1ff,0xffc3,
0xc1ff,0xffc3,0xd9ff,0xffc3,
0xd9ff,0xffc3,0xc1ff,0xffc3,
0xbe00,0x001f,0x7fff,0xffff,
0xffff,0xfff8,0xbf80,0x005c,
0xff80,0x3c7e,0xff80,0x3c7f,
0xff80,0x3c7f,0xffff,0xffff,
0xff80,0x3c7f,0xffaa,0xbd7f,
0xffff,0xff7f,0xff80,0x007f,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xfc00,0x003f,0xfdff,0xffdf,
0xfdff,0xffdf,0xfdff,0xffdf,
0xfdff,0xffdf,0xfdff,0xffdf,
0xfdff,0xffdf,0xfdff,0xffdf,
0xfdff,0xffdf,0xfdff,0xffdf,
0xfdff,0xffdf,0xfdff,0xffdf,
0xfe00,0x001f,0x7fff,0xffff,
0xffff,0xfff8,0x98ff,0xffcc,
0x8880,0x3cc6,0xc880,0x20e3,
0xc880,0x20e3,0xc8ff,0xe3e3,
0xc8ff,0xe3e3,0xc8d5,0x62e3,
0xc880,0x20e3,0xc880,0x00e3,
0xc8ff,0xffe3,0xcfff,0xffc3,
0xc000,0x0003,0xc000,0x0003,
0xc000,0x0003,0xc000,0x0003,
0xc000,0x0003,0xc000,0x0003,
0xc000,0x0003,0xc000,0x0023,
0xc000,0x0023,0xc000,0x0023,
0xc000,0x0023,0xc000,0x0023,
0xc000,0x0023,0xc000,0x0023,
0xc000,0x0023,0xd800,0x0023,
0xd800,0x0023,0xc000,0x0023,
0xfdff,0xffff,0x7fff,0xffff,
};

static short CI0CMASK0[] = {
0xffff,0xfff8,0xffff,0xfffc,
0xffff,0xfffe,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0x7fff,0xffff,
};

static CICON rs_cicon0[1] = {
	{4,CI0CDATA0,CI0CMASK0,NULL,NULL,NULL},
};

static short CI0DATA1[] = {
0x000f,0xf000,0x007f,0xfe00,
0x01f8,0x1f80,0x03c0,0x03c0,
0x0700,0x00e0,0x0f00,0x0070,
0x1f80,0x0038,0x3fc0,0x001c,
0x33e0,0x000c,0x71f0,0x000e,
0x60f8,0x0006,0x607c,0x0006,
0xe03e,0x0007,0xc01f,0x0003,
0xc00f,0x8003,0xc007,0xc003,
0xc003,0xe003,0xc001,0xf003,
0xc000,0xf803,0xe000,0x7c07,
0x6000,0x3e06,0x6000,0x1f06,
0x7000,0x0f8e,0x3000,0x07cc,
0x3800,0x03fc,0x1c00,0x01f8,
0x0e00,0x00f0,0x0700,0x00e0,
0x03c0,0x03c0,0x01f8,0x1f80,
0x007f,0xfe00,0x000f,0xf000,
};

static short CI0MASK1[] = {
0x000f,0xf000,0x007f,0xfe00,
0x01f8,0x1f80,0x03c0,0x03c0,
0x0700,0x00e0,0x0f00,0x0070,
0x1f80,0x0038,0x3fc0,0x001c,
0x33e0,0x000c,0x71f0,0x000e,
0x60f8,0x0006,0x607c,0x0006,
0xe03e,0x0007,0xc01f,0x0003,
0xc00f,0x8003,0xc007,0xc003,
0xc003,0xe003,0xc001,0xf003,
0xc000,0xf803,0xe000,0x7c07,
0x6000,0x3e06,0x6000,0x1f06,
0x7000,0x0f8e,0x3000,0x07cc,
0x3800,0x03fc,0x1c00,0x01f8,
0x0e00,0x00f0,0x0700,0x00e0,
0x03c0,0x03c0,0x01f8,0x1f80,
0x007f,0xfe00,0x000f,0xf000,
};

static short CI0CDATA1[] = {
0x000f,0xf000,0x007f,0xfe00,
0x01ff,0xff80,0x03ff,0xffc0,
0x07ff,0xffe0,0x0fff,0xfff0,
0x1fff,0xfff8,0x3fff,0xfffc,
0x3fff,0xfffc,0x7fff,0xfffe,
0x7fff,0xfffe,0x7fff,0xfffe,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0x7fff,0xfffe,0x7fff,0xfffe,
0x7fff,0xfffe,0x3fff,0xfffc,
0x3fff,0xfffc,0x1fff,0xfff8,
0x0fff,0xfff0,0x07ff,0xffe0,
0x03ff,0xffc0,0x01ff,0xff80,
0x007f,0xfe00,0x000f,0xf000,
0x000f,0xf000,0x007f,0xfe00,
0x01f8,0x1f80,0x03c0,0x03c0,
0x0700,0x00e0,0x0f00,0x0070,
0x1f80,0x0038,0x3fc0,0x001c,
0x33e0,0x000c,0x71f0,0x000e,
0x60f8,0x0006,0x607c,0x0006,
0xe03e,0x0007,0xc01f,0x0003,
0xc00f,0x8003,0xc007,0xc003,
0xc003,0xe003,0xc001,0xf003,
0xc000,0xf803,0xe000,0x7c07,
0x6000,0x3e06,0x6000,0x1f06,
0x7000,0x0f8e,0x3000,0x07cc,
0x3800,0x03fc,0x1c00,0x01f8,
0x0e00,0x00f0,0x0700,0x00e0,
0x03c0,0x03c0,0x01f8,0x1f80,
0x007f,0xfe00,0x000f,0xf000,
0x000f,0xf000,0x007f,0xfe00,
0x01f8,0x1f80,0x03c0,0x03c0,
0x0700,0x00e0,0x0f00,0x0070,
0x1f80,0x0038,0x3fc0,0x001c,
0x33e0,0x000c,0x71f0,0x000e,
0x60f8,0x0006,0x607c,0x0006,
0xe03e,0x0007,0xc01f,0x0003,
0xc00f,0x8003,0xc007,0xc003,
0xc003,0xe003,0xc001,0xf003,
0xc000,0xf803,0xe000,0x7c07,
0x6000,0x3e06,0x6000,0x1f06,
0x7000,0x0f8e,0x3000,0x07cc,
0x3800,0x03fc,0x1c00,0x01f8,
0x0e00,0x00f0,0x0700,0x00e0,
0x03c0,0x03c0,0x01f8,0x1f80,
0x007f,0xfe00,0x000f,0xf000,
0x000f,0xf000,0x007f,0xfe00,
0x01f8,0x1f80,0x03c0,0x03c0,
0x0700,0x00e0,0x0f00,0x0070,
0x1f80,0x0038,0x3fc0,0x001c,
0x33e0,0x000c,0x71f0,0x000e,
0x60f8,0x0006,0x607c,0x0006,
0xe03e,0x0007,0xc01f,0x0003,
0xc00f,0x8003,0xc007,0xc003,
0xc003,0xe003,0xc001,0xf003,
0xc000,0xf803,0xe000,0x7c07,
0x6000,0x3e06,0x6000,0x1f06,
0x7000,0x0f8e,0x3000,0x07cc,
0x3800,0x03fc,0x1c00,0x01f8,
0x0e00,0x00f0,0x0700,0x00e0,
0x03c0,0x03c0,0x01f8,0x1f80,
0x007f,0xfe00,0x000f,0xf000,
};

static short CI0CMASK1[] = {
0x000f,0xf000,0x007f,0xfe00,
0x01ff,0xff80,0x03ff,0xffc0,
0x07ff,0xffe0,0x0fff,0xfff0,
0x1fff,0xfff8,0x3fff,0xfffc,
0x3fff,0xfffc,0x7fff,0xfffe,
0x7fff,0xfffe,0x7fff,0xfffe,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0x7fff,0xfffe,0x7fff,0xfffe,
0x7fff,0xfffe,0x3fff,0xfffc,
0x3fff,0xfffc,0x1fff,0xfff8,
0x0fff,0xfff0,0x07ff,0xffe0,
0x03ff,0xffc0,0x01ff,0xff80,
0x007f,0xfe00,0x000f,0xf000,
};

static CICON rs_cicon1[1] = {
	{4,CI0CDATA1,CI0CMASK1,NULL,NULL,NULL},
};

static short CI0DATA2[] = {
0x7fff,0xfffe,0xffff,0xffff,
0xc000,0x0003,0xc000,0x0003,
0x6001,0x8006,0x6003,0xc006,
0x3003,0xc00c,0x3003,0xc00c,
0x1803,0xc018,0x1803,0xc018,
0x0c03,0xc030,0x0c03,0xc030,
0x0603,0xc060,0x0603,0xc060,
0x0303,0xc0c0,0x0303,0xc0c0,
0x0181,0x8180,0x0181,0x8180,
0x00c1,0x8300,0x00c1,0x8300,
0x0061,0x8600,0x0061,0x8600,
0x0030,0x0c00,0x0030,0x0c00,
0x0019,0x9800,0x0019,0x9800,
0x000c,0x3000,0x000c,0x3000,
0x0006,0x6000,0x0006,0x6000,
0x0003,0xc000,0x0001,0x8000,
};

static short CI0MASK2[] = {
0x7fff,0xfffe,0xffff,0xffff,
0xc000,0x0003,0xc000,0x0003,
0x6001,0x8006,0x6003,0xc006,
0x3003,0xc00c,0x3003,0xc00c,
0x1803,0xc018,0x1803,0xc018,
0x0c03,0xc030,0x0c03,0xc030,
0x0603,0xc060,0x0603,0xc060,
0x0303,0xc0c0,0x0303,0xc0c0,
0x0181,0x8180,0x0181,0x8180,
0x00c1,0x8300,0x00c1,0x8300,
0x0061,0x8600,0x0061,0x8600,
0x0030,0x0c00,0x0030,0x0c00,
0x0019,0x9800,0x0019,0x9800,
0x000c,0x3000,0x000c,0x3000,
0x0006,0x6000,0x0006,0x6000,
0x0003,0xc000,0x0001,0x8000,
};

static short CI0CDATA2[] = {
0x7fff,0xfffe,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0x7fff,0xfffe,0x7fff,0xfffe,
0x3fff,0xfffc,0x3fff,0xfffc,
0x1fff,0xfff8,0x1fff,0xfff8,
0x0fff,0xfff0,0x0fff,0xfff0,
0x07ff,0xffe0,0x07ff,0xffe0,
0x03ff,0xffc0,0x03ff,0xffc0,
0x01ff,0xff80,0x01ff,0xff80,
0x00ff,0xff00,0x00ff,0xff00,
0x007f,0xfe00,0x007f,0xfe00,
0x003f,0xfc00,0x003f,0xfc00,
0x001f,0xf800,0x001f,0xf800,
0x000f,0xf000,0x000f,0xf000,
0x0007,0xe000,0x0007,0xe000,
0x0003,0xc000,0x0001,0x8000,
0x7fff,0xfffe,0xffff,0xffff,
0xc000,0x0003,0xc000,0x0003,
0x6001,0x8006,0x6003,0xc006,
0x3003,0xc00c,0x3003,0xc00c,
0x1803,0xc018,0x1803,0xc018,
0x0c03,0xc030,0x0c03,0xc030,
0x0603,0xc060,0x0603,0xc060,
0x0303,0xc0c0,0x0303,0xc0c0,
0x0181,0x8180,0x0181,0x8180,
0x00c1,0x8300,0x00c1,0x8300,
0x0061,0x8600,0x0061,0x8600,
0x0030,0x0c00,0x0030,0x0c00,
0x0019,0x9800,0x0019,0x9800,
0x000c,0x3000,0x000c,0x3000,
0x0006,0x6000,0x0006,0x6000,
0x0003,0xc000,0x0001,0x8000,
0x7fff,0xfffe,0xffff,0xffff,
0xc000,0x0003,0xc000,0x0003,
0x6001,0x8006,0x6003,0xc006,
0x3003,0xc00c,0x3003,0xc00c,
0x1803,0xc018,0x1803,0xc018,
0x0c03,0xc030,0x0c03,0xc030,
0x0603,0xc060,0x0603,0xc060,
0x0303,0xc0c0,0x0303,0xc0c0,
0x0181,0x8180,0x0181,0x8180,
0x00c1,0x8300,0x00c1,0x8300,
0x0061,0x8600,0x0061,0x8600,
0x0030,0x0c00,0x0030,0x0c00,
0x0019,0x9800,0x0019,0x9800,
0x000c,0x3000,0x000c,0x3000,
0x0006,0x6000,0x0006,0x6000,
0x0003,0xc000,0x0001,0x8000,
0x7fff,0xfffe,0xffff,0xffff,
0xc000,0x0003,0xc000,0x0003,
0x6001,0x8006,0x6003,0xc006,
0x3003,0xc00c,0x3003,0xc00c,
0x1803,0xc018,0x1803,0xc018,
0x0c03,0xc030,0x0c03,0xc030,
0x0603,0xc060,0x0603,0xc060,
0x0303,0xc0c0,0x0303,0xc0c0,
0x0181,0x8180,0x0181,0x8180,
0x00c1,0x8300,0x00c1,0x8300,
0x0061,0x8600,0x0061,0x8600,
0x0030,0x0c00,0x0030,0x0c00,
0x0019,0x9800,0x0019,0x9800,
0x000c,0x3000,0x000c,0x3000,
0x0006,0x6000,0x0006,0x6000,
0x0003,0xc000,0x0001,0x8000,
};

static short CI0CMASK2[] = {
0x7fff,0xfffe,0xffff,0xffff,
0xffff,0xffff,0xffff,0xffff,
0x7fff,0xfffe,0x7fff,0xfffe,
0x3fff,0xfffc,0x3fff,0xfffc,
0x1fff,0xfff8,0x1fff,0xfff8,
0x0fff,0xfff0,0x0fff,0xfff0,
0x07ff,0xffe0,0x07ff,0xffe0,
0x03ff,0xffc0,0x03ff,0xffc0,
0x01ff,0xff80,0x01ff,0xff80,
0x00ff,0xff00,0x00ff,0xff00,
0x007f,0xfe00,0x007f,0xfe00,
0x003f,0xfc00,0x003f,0xfc00,
0x001f,0xf800,0x001f,0xf800,
0x000f,0xf000,0x000f,0xf000,
0x0007,0xe000,0x0007,0xe000,
0x0003,0xc000,0x0001,0x8000,
};

static CICON rs_cicon2[1] = {
	{4,CI0CDATA2,CI0CMASK2,NULL,NULL,NULL},
};

static CICONBLK rs_ciconblk[] = {
/*0*/	{{CI0MASK0,CI0DATA0,"",0x1000|'\000',14,21,0,0,32,32,13,13,6,8},rs_cicon0},
/*1*/	{{CI0MASK1,CI0DATA1,"",0x1000|'\000',0,0,0,0,32,32,0,-1,6,8},rs_cicon1},
/*2*/	{{CI0MASK2,CI0DATA2,"",0x1000|'\000',0,0,0,0,32,32,0,-1,6,8},rs_cicon2},
};

#define OB_SPEC
OBJECT POPUP_3D[] = {
/*0*/	{-1,1,28,G_BOX,0x600,0x0,(void *)0x1100,0,0,1057,2071},
/*1*/	{3,2,2,G_BOX,0x600,0x0,(void *)0x1100,0,256,1057,1},
/*2*/	{1,-1,-1,G_STRING,0x0,0x0,(char *)"1234567890", 0,0,1057,1},
/*3*/	{5,4,4,G_BOX,0x605,0x0,(void *)0xff1100,799,1025,2,1},
/*4*/	{3,-1,-1,G_IMAGE,0x4,0x0,&BBOB0,0,0,2,1},
/*5*/	{7,6,6,G_BOX,0x604,0x1,(void *)0xff1100,799,2050,2,520},
/*6*/	{5,-1,-1,G_BOX,0x605,0x0,(void *)0xff1100,0,256,2,1799},
/*7*/	{9,8,8,G_BOX,0x605,0x0,(void *)0xff1100,799,3850,2,1},
/*8*/	{7,-1,-1,G_IMAGE,0x4,0x0,&BBOB1,0,0,2,1},
/*9*/	{10,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2049,31,1},
/*10*/	{11,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2050,31,1},
/*11*/	{12,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2051,31,1},
/*12*/	{13,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2052,31,1},
/*13*/	{14,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2053,31,1},
/*14*/	{15,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2054,31,1},
/*15*/	{16,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2055,31,1},
/*16*/	{17,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2056,31,1},
/*17*/	{18,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2057,31,1},
/*18*/	{19,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2058,31,1},
/*19*/	{20,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2059,31,1},
/*20*/	{21,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2060,31,1},
/*21*/	{22,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2061,31,1},
/*22*/	{23,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2062,31,1},
/*23*/	{24,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2063,31,1},
/*24*/	{25,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2064,31,1},
/*25*/	{26,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2065,31,1},
/*26*/	{27,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2066,31,1},
/*27*/	{28,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2067,31,1},
/*28*/	{0,-1,-1,G_STRING,0x31,0x0,"1234567890", 0,2068,31,1},
};

OBJECT ALERTBOX[] = {
/*0*/	{-1,1,11,G_BOX,0x600,0x0,(void *)0xff1100,0,0,60,264},
/*1*/	{11,2,10,G_BOX,0x600,0x0,(void *)0xff1100,1024,1024,59,2055},
/*2*/	{3,-1,-1,G_STRING,0x0,0x0,"12345678901234567890123456789012345678901234567890", 7,2048,50,1},
/*3*/	{4,-1,-1,G_CICON,0x0,0x0,&rs_ciconblk[0],1025,2048,4,2},
/*4*/	{5,-1,-1,G_BUTTON,0x605,0x0,"Button", 1025,6,8,1},
/*5*/	{6,-1,-1,G_BUTTON,0x605,0x0,"Button", 11,6,8,1},
/*6*/	{7,-1,-1,G_BUTTON,0x605,0x0,"Button", 1044,6,8,1},
/*7*/	{8,-1,-1,G_STRING,0x0,0x0,"12345678901234567890123456789012345678901234567890", 7,2049,50,1},
/*8*/	{9,-1,-1,G_STRING,0x0,0x0,"12345678901234567890123456789012345678901234567890", 7,2050,50,1},
/*9*/	{10,-1,-1,G_STRING,0x0,0x0,"12345678901234567890123456789012345678901234567890", 7,2051,50,1},
/*10*/	{1,-1,-1,G_STRING,0x0,0x0,"12345678901234567890123456789012345678901234567890", 7,2052,50,1},
/*11*/	{0,-1,-1,G_BOX,0x660,0x2,(void *)0xff1100,1082,0,1025,3072},
};

OBJECT ALERT_CICONS[] = {
/*0*/	{-1,1,2,G_BOX,0x600,0x0,(void *)0x1100,0,0,52,9},
/*1*/	{2,-1,-1,G_CICON,0x0,0x0,&rs_ciconblk[1],1025,2048,4,2},
/*2*/	{0,-1,-1,G_CICON,0x20,0x0,&rs_ciconblk[2],7,2048,4,2},
};

OBJECT POPUP_MONO[] = {
/*0*/	{-1,1,28,G_BOX,0x0,0x0,(void *)0xff1100,0,0,1057,2071},
/*1*/	{3,2,2,G_BOX,0x0,0x20,(void *)0xff1100,0,256,1057,1},
/*2*/	{1,-1,-1,G_STRING,0x0,0x0,"1234567890", 0,0,1057,1},
/*3*/	{5,4,4,G_BOX,0x5,0x20,(void *)0xff1100,799,1025,2,1},
/*4*/	{3,-1,-1,G_IMAGE,0x4,0x0,&BBOB2,0,0,2,1},
/*5*/	{7,6,6,G_BOX,0x4,0x20,(void *)0xff1100,799,2050,2,520},
/*6*/	{5,-1,-1,G_BOX,0x5,0x0,(void *)0xff1171,0,256,2,1799},
/*7*/	{9,8,8,G_BOX,0x5,0x20,(void *)0xff1100,799,3850,2,1},
/*8*/	{7,-1,-1,G_IMAGE,0x4,0x0,&BBOB3,0,0,2,1},
/*9*/	{10,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2049,31,1},
/*10*/	{11,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2050,31,1},
/*11*/	{12,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2051,31,1},
/*12*/	{13,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2052,31,1},
/*13*/	{14,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2053,31,1},
/*14*/	{15,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2054,31,1},
/*15*/	{16,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2055,31,1},
/*16*/	{17,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2056,31,1},
/*17*/	{18,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2057,31,1},
/*18*/	{19,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2058,31,1},
/*19*/	{20,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2059,31,1},
/*20*/	{21,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2060,31,1},
/*21*/	{22,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2061,31,1},
/*22*/	{23,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2062,31,1},
/*23*/	{24,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2063,31,1},
/*24*/	{25,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2064,31,1},
/*25*/	{26,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2065,31,1},
/*26*/	{27,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2066,31,1},
/*27*/	{28,-1,-1,G_STRING,0x11,0x0,"1234567890", 0,2067,31,1},
/*28*/	{0,-1,-1,G_STRING,0x31,0x0,"1234567890", 0,2068,31,1},
};



static void fix_tree(OBJECT *s,int max)
{
	int i;

	for(i=0; i<=max; i++)
		rsrc_obfix(s,i);
}

void rsrc_init(void)
{
	fix_tree(POPUP_3D,28);
	fix_tree(ALERTBOX,11);
	fix_tree(ALERT_CICONS,2);
	fix_tree(POPUP_MONO,28);
}
