CONST
  MOPTIONS = 0 ;
  ADDBUTON = 2 ;
  EXTRACTB = 3 ;
  MOVEBUTN = 4 ;
  FRESHENB = 6 ;
  UPDATEBU = 5 ;
  DELETEBU = 7 ;
  VERBOSEB = 8 ;
  COPYBUTN = 10 ;
  LISTBUTN = 9 ;
  RUNBUTON = 11 ;
  TESTARCI = 12 ;
  CNVTONPM = 13 ;
  SUPPCOMP = 18 ;
  KEEPBACK = 17 ;
  SUPPWARN = 19 ;
  SUPPNOTE = 20 ;
  CRYPTBUT = 22 ;
  HOLDBUTN = 21 ;
  CANBUTON = 23 ;
  OKBUTTON = 24 ;
  ABOUTBOX = 1 ;
  ABOUTOKB = 4 ;
  ABOUTCAN = 5 ;
