/* resource set indices for DICIHYP */

#define DIALTREE   0 /* form/dialog */
#define MOVER      1 /* IBOX in tree DIALTREE */
#define KPARENT    2 /* BOXTEXT in tree DIALTREE */
#define KEYNUM     3 /* FBOXTEXT in tree DIALTREE */
#define KEYPOR     4 /* FBOXTEXT in tree DIALTREE */
#define KEYGER     5 /* FBOXTEXT in tree DIALTREE */
#define PORTUG     7 /* FBOXTEXT in tree DIALTREE */
#define VOKABEL    8 /* BUTTON in tree DIALTREE */
#define NUMGENUS   9 /* BUTTON in tree DIALTREE */
#define SONSTIGS  10 /* BUTTON in tree DIALTREE */
#define MARK      11 /* BUTTON in tree DIALTREE */
#define UEPARENT  13 /* BOXTEXT in tree DIALTREE */
#define GERM1     14 /* FBOXTEXT in tree DIALTREE */
#define GERM2     15 /* FBOXTEXT in tree DIALTREE */
#define GERM3     16 /* FBOXTEXT in tree DIALTREE */
#define GERM4     17 /* FBOXTEXT in tree DIALTREE */
#define FIND      19 /* BUTTON in tree DIALTREE */
#define NEXT      20 /* BUTTON in tree DIALTREE */
#define PREV      21 /* BUTTON in tree DIALTREE */
#define FIRST     22 /* BUTTON in tree DIALTREE */
#define LAST      23 /* BUTTON in tree DIALTREE */
#define CHANGE    24 /* BUTTON in tree DIALTREE */
#define NEW       25 /* BUTTON in tree DIALTREE */
#define DEL       26 /* BUTTON in tree DIALTREE */
#define HELP      27 /* BUTTON in tree DIALTREE */
#define CLIP      28 /* BUTTON in tree DIALTREE */
#define OKDIAL    29 /* BUTTON in tree DIALTREE */
#define CLIPREAD  30 /* BUTTON in tree DIALTREE */

