/* Resource file indices for TABLE. */

#define FORM_ALERTBOX    0   /* Form/Dialog-box */
#define WALERT_BACKDROP  0   /* BOX in tree FORM_ALERTBOX */
#define WALERT_ICON      1   /* IMAGE in tree FORM_ALERTBOX */
#define WALERT_TEXT1     2   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT2     3   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT3     4   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT4     5   /* STRING in tree FORM_ALERTBOX */
#define WALERT_BUT1      6   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT2      7   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT3      8   /* BUTTON in tree FORM_ALERTBOX */

#define ICONS            1   /* Form/Dialog-box */
#define ICON_BACKDROP    0   /* BOX in tree ICONS */
#define ICON_ALERT0      1   /* IMAGE in tree ICONS */
#define ICON_ALERT2      2   /* IMAGE in tree ICONS */
#define ICON_PRADIO      3   /* IMAGE in tree ICONS */
#define ICON_ALERT1      4   /* IMAGE in tree ICONS */
#define ICON_ALERT3      5   /* IMAGE in tree ICONS */
#define ICON_PRAD_SM     6   /* IMAGE in tree ICONS */
#define ICON_RAD_1       7   /* ICON in tree ICONS */
#define ICON_RAD_1S      8   /* ICON in tree ICONS */
#define ICON_RAD_1SM     9   /* ICON in tree ICONS */
#define ICON_RAD_1SMS    10  /* ICON in tree ICONS */
#define ICON_RAD_4       11  /* USERDEF in tree ICONS */
#define ICON_RAD_4S      12  /* USERDEF in tree ICONS */
#define ICON_RAD_4SM     13  /* USERDEF in tree ICONS */
#define ICON_RAD_4SMS    14  /* USERDEF in tree ICONS */
#define ICON_BX_1        15  /* ICON in tree ICONS */
#define ICON_BX_1S       16  /* ICON in tree ICONS */
#define ICON_BX_1SM      17  /* ICON in tree ICONS */
#define ICON_BX_1SMS     18  /* ICON in tree ICONS */
#define ICON_BX_4        19  /* USERDEF in tree ICONS */
#define ICON_BX_4S       20  /* USERDEF in tree ICONS */
#define ICON_BX_4SM      21  /* USERDEF in tree ICONS */
#define ICON_BX_4SMS     22  /* USERDEF in tree ICONS */

#define FORM_ICONIFY     2   /* Form/Dialog-box */

#define FORM_MENU        3   /* Menu-tree */
#define MENU_PROGRAM     3   /* TITLE in tree FORM_MENU */
#define MENU_FILE        4   /* TITLE in tree FORM_MENU */
#define MENU_WINDOW      5   /* TITLE in tree FORM_MENU */
#define MENU_THELP       6   /* TITLE in tree FORM_MENU */
#define MENU_ABOUT       9   /* STRING in tree FORM_MENU */
#define MENU_NEW         18  /* STRING in tree FORM_MENU */
#define MENU_OPEN        20  /* STRING in tree FORM_MENU */
#define MENU_SAVE        22  /* STRING in tree FORM_MENU */
#define MENU_SAVEAS      23  /* STRING in tree FORM_MENU */
#define MENU_EXPORT      25  /* STRING in tree FORM_MENU */
#define MENU_QUIT        27  /* STRING in tree FORM_MENU */
#define MENU_TABLEPROP   29  /* STRING in tree FORM_MENU */
#define MENU_CELLPROP    30  /* STRING in tree FORM_MENU */
#define MENU_ABOUTHELP   32  /* STRING in tree FORM_MENU */
#define MENU_HELP        33  /* STRING in tree FORM_MENU */
#define MENU_CYBER       35  /* STRING in tree FORM_MENU */

#define FORM_TABLE       4   /* Form/Dialog-box */
#define TBL_THEADER      1   /* STRING in tree FORM_TABLE */
#define TBL_HEADER       2   /* FTEXT in tree FORM_TABLE */
#define TBL_HLEFT        4   /* IMAGE in tree FORM_TABLE */
#define TBL_HRIGHT       5   /* IMAGE in tree FORM_TABLE */
#define TBL_TFOOTER      6   /* STRING in tree FORM_TABLE */
#define TBL_FOOTER       7   /* FTEXT in tree FORM_TABLE */
#define TBL_FLEFT        9   /* IMAGE in tree FORM_TABLE */
#define TBL_FRIGHT       10  /* IMAGE in tree FORM_TABLE */
#define TBL_TALIGN       11  /* STRING in tree FORM_TABLE */
#define TBL_ALIGNL       14  /* IMAGE in tree FORM_TABLE */
#define TBL_ALIGNC       15  /* IMAGE in tree FORM_TABLE */
#define TBL_ALIGNR       16  /* IMAGE in tree FORM_TABLE */
#define TBL_FLOW         17  /* IBOX in tree FORM_TABLE */
#define TBL_FLOW2        18  /* STRING in tree FORM_TABLE */
#define TBL_TBORDER      19  /* STRING in tree FORM_TABLE */
#define TBL_BORDER       20  /* FTEXT in tree FORM_TABLE */
#define TBL_PIXEL1       21  /* STRING in tree FORM_TABLE */
#define TBL_B1           23  /* IMAGE in tree FORM_TABLE */
#define TBL_B2           24  /* IMAGE in tree FORM_TABLE */
#define TBL_B3           25  /* IMAGE in tree FORM_TABLE */
#define TBL_B4           26  /* IMAGE in tree FORM_TABLE */
#define TBL_B5           27  /* IMAGE in tree FORM_TABLE */
#define TBL_B6           28  /* IMAGE in tree FORM_TABLE */
#define TBL_B7           29  /* IMAGE in tree FORM_TABLE */
#define TBL_B8           30  /* IMAGE in tree FORM_TABLE */
#define TBL_TCELLPAD     31  /* STRING in tree FORM_TABLE */
#define TBL_CELLPADDING  32  /* FTEXT in tree FORM_TABLE */
#define TBL_PIXEL2       33  /* STRING in tree FORM_TABLE */
#define TBL_TCELLSPAC    34  /* STRING in tree FORM_TABLE */
#define TBL_CELLSPACING  35  /* FTEXT in tree FORM_TABLE */
#define TBL_PIXEL3       36  /* STRING in tree FORM_TABLE */
#define TBL_TWIDTH       37  /* STRING in tree FORM_TABLE */
#define TBL_WIDTH        38  /* FTEXT in tree FORM_TABLE */
#define TBL_PERCENT      40  /* IBOX in tree FORM_TABLE */
#define TBL_PERCENT2     41  /* STRING in tree FORM_TABLE */
#define TBL_PIXELS       42  /* IBOX in tree FORM_TABLE */
#define TBL_PIXELS2      43  /* STRING in tree FORM_TABLE */
#define TBL_OK           44  /* BUTTON in tree FORM_TABLE */
#define TBL_CANCEL       45  /* BUTTON in tree FORM_TABLE */

#define FORM_CELL        5   /* Form/Dialog-box */
#define CELL_BACK        1   /* BOX in tree FORM_CELL */
#define C1               2   /* BOX in tree FORM_CELL */
#define C2               3   /* BOX in tree FORM_CELL */
#define C3               4   /* BOX in tree FORM_CELL */
#define C4               5   /* BOX in tree FORM_CELL */
#define C5               6   /* BOX in tree FORM_CELL */
#define C6               7   /* BOX in tree FORM_CELL */
#define C7               8   /* BOX in tree FORM_CELL */
#define C8               9   /* BOX in tree FORM_CELL */
#define C9               10  /* BOX in tree FORM_CELL */
#define C10              11  /* BOX in tree FORM_CELL */
#define C11              12  /* BOX in tree FORM_CELL */
#define C12              13  /* BOX in tree FORM_CELL */
#define C13              14  /* BOX in tree FORM_CELL */
#define C14              15  /* BOX in tree FORM_CELL */
#define C15              16  /* BOX in tree FORM_CELL */
#define C16              17  /* BOX in tree FORM_CELL */
#define C17              18  /* BOX in tree FORM_CELL */
#define C18              19  /* BOX in tree FORM_CELL */
#define C19              20  /* BOX in tree FORM_CELL */
#define C20              21  /* BOX in tree FORM_CELL */
#define C21              22  /* BOX in tree FORM_CELL */
#define C22              23  /* BOX in tree FORM_CELL */
#define C23              24  /* BOX in tree FORM_CELL */
#define C24              25  /* BOX in tree FORM_CELL */
#define C25              26  /* BOX in tree FORM_CELL */
#define C26              27  /* BOX in tree FORM_CELL */
#define C27              28  /* BOX in tree FORM_CELL */
#define C28              29  /* BOX in tree FORM_CELL */
#define C29              30  /* BOX in tree FORM_CELL */
#define C30              31  /* BOX in tree FORM_CELL */
#define C31              32  /* BOX in tree FORM_CELL */
#define C32              33  /* BOX in tree FORM_CELL */
#define C33              34  /* BOX in tree FORM_CELL */
#define C34              35  /* BOX in tree FORM_CELL */
#define C35              36  /* BOX in tree FORM_CELL */
#define C36              37  /* BOX in tree FORM_CELL */
#define C37              38  /* BOX in tree FORM_CELL */
#define C38              39  /* BOX in tree FORM_CELL */
#define C39              40  /* BOX in tree FORM_CELL */
#define C40              41  /* BOX in tree FORM_CELL */
#define C41              42  /* BOX in tree FORM_CELL */
#define C42              43  /* BOX in tree FORM_CELL */
#define C43              44  /* BOX in tree FORM_CELL */
#define C44              45  /* BOX in tree FORM_CELL */
#define C45              46  /* BOX in tree FORM_CELL */
#define C46              47  /* BOX in tree FORM_CELL */
#define C47              48  /* BOX in tree FORM_CELL */
#define C48              49  /* BOX in tree FORM_CELL */
#define C49              50  /* BOX in tree FORM_CELL */
#define C50              51  /* BOX in tree FORM_CELL */
#define C51              52  /* BOX in tree FORM_CELL */
#define C52              53  /* BOX in tree FORM_CELL */
#define C53              54  /* BOX in tree FORM_CELL */
#define C54              55  /* BOX in tree FORM_CELL */
#define C55              56  /* BOX in tree FORM_CELL */
#define C56              57  /* BOX in tree FORM_CELL */
#define C57              58  /* BOX in tree FORM_CELL */
#define C58              59  /* BOX in tree FORM_CELL */
#define C59              60  /* BOX in tree FORM_CELL */
#define C60              61  /* BOX in tree FORM_CELL */
#define C61              62  /* BOX in tree FORM_CELL */
#define C62              63  /* BOX in tree FORM_CELL */
#define C63              64  /* BOX in tree FORM_CELL */
#define C64              65  /* BOX in tree FORM_CELL */
#define C65              66  /* BOX in tree FORM_CELL */
#define C66              67  /* BOX in tree FORM_CELL */
#define C67              68  /* BOX in tree FORM_CELL */
#define C68              69  /* BOX in tree FORM_CELL */
#define C69              70  /* BOX in tree FORM_CELL */
#define C70              71  /* BOX in tree FORM_CELL */
#define C71              72  /* BOX in tree FORM_CELL */
#define C72              73  /* BOX in tree FORM_CELL */
#define C73              74  /* BOX in tree FORM_CELL */
#define C74              75  /* BOX in tree FORM_CELL */
#define C75              76  /* BOX in tree FORM_CELL */
#define C76              77  /* BOX in tree FORM_CELL */
#define C77              78  /* BOX in tree FORM_CELL */
#define C78              79  /* BOX in tree FORM_CELL */
#define C79              80  /* BOX in tree FORM_CELL */
#define C80              81  /* BOX in tree FORM_CELL */
#define C81              82  /* BOX in tree FORM_CELL */
#define C82              83  /* BOX in tree FORM_CELL */
#define C83              84  /* BOX in tree FORM_CELL */
#define C84              85  /* BOX in tree FORM_CELL */
#define C85              86  /* BOX in tree FORM_CELL */
#define C86              87  /* BOX in tree FORM_CELL */
#define C87              88  /* BOX in tree FORM_CELL */
#define C88              89  /* BOX in tree FORM_CELL */
#define C89              90  /* BOX in tree FORM_CELL */
#define C90              91  /* BOX in tree FORM_CELL */
#define C91              92  /* BOX in tree FORM_CELL */
#define C92              93  /* BOX in tree FORM_CELL */
#define C93              94  /* BOX in tree FORM_CELL */
#define C94              95  /* BOX in tree FORM_CELL */
#define C95              96  /* BOX in tree FORM_CELL */
#define C96              97  /* BOX in tree FORM_CELL */
#define C97              98  /* BOX in tree FORM_CELL */
#define C98              99  /* BOX in tree FORM_CELL */
#define C99              100 /* BOX in tree FORM_CELL */
#define C100             101 /* BOX in tree FORM_CELL */
#define C101             102 /* BOX in tree FORM_CELL */
#define C102             103 /* BOX in tree FORM_CELL */
#define C103             104 /* BOX in tree FORM_CELL */
#define C104             105 /* BOX in tree FORM_CELL */
#define C105             106 /* BOX in tree FORM_CELL */
#define C106             107 /* BOX in tree FORM_CELL */
#define C107             108 /* BOX in tree FORM_CELL */
#define C108             109 /* BOX in tree FORM_CELL */
#define C109             110 /* BOX in tree FORM_CELL */
#define C110             111 /* BOX in tree FORM_CELL */
#define C111             112 /* BOX in tree FORM_CELL */
#define C112             113 /* BOX in tree FORM_CELL */
#define C113             114 /* BOX in tree FORM_CELL */
#define C114             115 /* BOX in tree FORM_CELL */
#define C115             116 /* BOX in tree FORM_CELL */
#define C116             117 /* BOX in tree FORM_CELL */
#define C117             118 /* BOX in tree FORM_CELL */
#define C118             119 /* BOX in tree FORM_CELL */
#define C119             120 /* BOX in tree FORM_CELL */
#define C120             121 /* BOX in tree FORM_CELL */
#define C121             122 /* BOX in tree FORM_CELL */
#define C122             123 /* BOX in tree FORM_CELL */
#define C123             124 /* BOX in tree FORM_CELL */
#define C124             125 /* BOX in tree FORM_CELL */
#define C125             126 /* BOX in tree FORM_CELL */
#define C126             127 /* BOX in tree FORM_CELL */
#define C127             128 /* BOX in tree FORM_CELL */
#define C128             129 /* BOX in tree FORM_CELL */
#define C129             130 /* BOX in tree FORM_CELL */
#define C130             131 /* BOX in tree FORM_CELL */
#define C131             132 /* BOX in tree FORM_CELL */
#define C132             133 /* BOX in tree FORM_CELL */
#define C133             134 /* BOX in tree FORM_CELL */
#define C134             135 /* BOX in tree FORM_CELL */
#define C135             136 /* BOX in tree FORM_CELL */
#define C136             137 /* BOX in tree FORM_CELL */
#define C137             138 /* BOX in tree FORM_CELL */
#define C138             139 /* BOX in tree FORM_CELL */
#define C139             140 /* BOX in tree FORM_CELL */
#define C140             141 /* BOX in tree FORM_CELL */
#define C141             142 /* BOX in tree FORM_CELL */
#define C142             143 /* BOX in tree FORM_CELL */
#define C143             144 /* BOX in tree FORM_CELL */
#define C144             145 /* BOX in tree FORM_CELL */
#define CELL_TCOLS       146 /* TEXT in tree FORM_CELL */
#define CELL_ACROSS      147 /* BOXTEXT in tree FORM_CELL */
#define CELL_TROWS       148 /* TEXT in tree FORM_CELL */
#define CELL_DOWN        149 /* BOXTEXT in tree FORM_CELL */
#define CELL_PROPERTIES  150 /* BOX in tree FORM_CELL */
#define CELL_TEXT1       151 /* FTEXT in tree FORM_CELL */
#define CELL_TEXT2       152 /* FTEXT in tree FORM_CELL */
#define CELL_TEXT3       153 /* FTEXT in tree FORM_CELL */
#define CELL_TCOLOUR     154 /* STRING in tree FORM_CELL */
#define CELL_COLOUR      155 /* FTEXT in tree FORM_CELL */
#define CELL_COLOUR2     156 /* BOXTEXT in tree FORM_CELL */
#define CELL_TALIGN      157 /* STRING in tree FORM_CELL */
#define CELL_ALIGNL      159 /* IMAGE in tree FORM_CELL */
#define CELL_ALIGNC      160 /* IMAGE in tree FORM_CELL */
#define CELL_ALIGNR      161 /* IMAGE in tree FORM_CELL */
#define CELL_NOWRAP      162 /* IBOX in tree FORM_CELL */
#define CELL_NOWRAP2     163 /* STRING in tree FORM_CELL */
#define CELL_TVALIGN     164 /* STRING in tree FORM_CELL */
#define CELL_VALIGNT     166 /* IMAGE in tree FORM_CELL */
#define CELL_VALIGNM     167 /* IMAGE in tree FORM_CELL */
#define CELL_VALIGNB     168 /* IMAGE in tree FORM_CELL */
#define CELL_VALIGNBASE  169 /* IMAGE in tree FORM_CELL */
#define CELL_BIMAGE      170 /* IBOX in tree FORM_CELL */
#define CELL_BIMAGE2     171 /* STRING in tree FORM_CELL */
#define CELL_BIMAGE3     172 /* FTEXT in tree FORM_CELL */
#define CELL_BCOLOUR     173 /* IBOX in tree FORM_CELL */
#define CELL_BCOLOUR3    174 /* FTEXT in tree FORM_CELL */
#define CELL_BCOLOUR4    175 /* BOXTEXT in tree FORM_CELL */
#define TBL_SELECTCELL   176 /* BUTTON in tree FORM_CELL */
#define CELL_CUTX        177 /* BUTTON in tree FORM_CELL */
#define CELL_CUTY        178 /* BUTTON in tree FORM_CELL */
#define CELL_GLUE        179 /* BUTTON in tree FORM_CELL */

#define FORM_ABOUT       6   /* Form/Dialog-box */
#define ABOUT_TEXT1      7   /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT2      9   /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT3      13  /* TEXT in tree FORM_ABOUT */
#define ABOUT_LANGUAGE   14  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT4      15  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TRANSLATOR 16  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT5      17  /* TEXT in tree FORM_ABOUT */
#define ABOUT_KEYCODE    18  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT6      19  /* TEXT in tree FORM_ABOUT */
#define ABOUT_USER       20  /* TEXT in tree FORM_ABOUT */
#define ABOUT_OK         22  /* BUTTON in tree FORM_ABOUT */

#define FORM_COLOURS     7   /* Form/Dialog-box */
#define COL_PREVIEW      1   /* BOX in tree FORM_COLOURS */
#define RGB_RED          2   /* TEXT in tree FORM_COLOURS */
#define COL_RED          3   /* BOX in tree FORM_COLOURS */
#define COL_RED2         4   /* BOXTEXT in tree FORM_COLOURS */
#define COL_RED3         5   /* BUTTON in tree FORM_COLOURS */
#define COL_RED4         6   /* BUTTON in tree FORM_COLOURS */
#define RGB_GREEN        7   /* TEXT in tree FORM_COLOURS */
#define COL_GREEN        8   /* BOX in tree FORM_COLOURS */
#define COL_GREEN2       9   /* BOXTEXT in tree FORM_COLOURS */
#define COL_GREEN3       10  /* BUTTON in tree FORM_COLOURS */
#define COL_GREEN4       11  /* BUTTON in tree FORM_COLOURS */
#define RGB_BLUE         12  /* TEXT in tree FORM_COLOURS */
#define COL_BLUE         13  /* BOX in tree FORM_COLOURS */
#define COL_BLUE2        14  /* BOXTEXT in tree FORM_COLOURS */
#define COL_BLUE3        15  /* BUTTON in tree FORM_COLOURS */
#define COL_BLUE4        16  /* BUTTON in tree FORM_COLOURS */
#define COL_RGB          17  /* FTEXT in tree FORM_COLOURS */
#define COL_OK           18  /* BUTTON in tree FORM_COLOURS */
#define COL_CANCEL       19  /* BUTTON in tree FORM_COLOURS */

#define FORM_POPUPS      8   /* Form/Dialog-box */
#define POP_CELLS        1   /* BOX in tree FORM_POPUPS */
#define POP_COLOUR       14  /* BOX in tree FORM_POPUPS */
#define P_COL1           16  /* STRING in tree FORM_POPUPS */
#define P_COL2           18  /* STRING in tree FORM_POPUPS */
#define P_COL3           20  /* STRING in tree FORM_POPUPS */
#define P_COL4           22  /* STRING in tree FORM_POPUPS */
#define P_COL5           24  /* STRING in tree FORM_POPUPS */
#define P_COL6           26  /* STRING in tree FORM_POPUPS */
#define P_COL7           28  /* STRING in tree FORM_POPUPS */
#define P_COL8           30  /* STRING in tree FORM_POPUPS */
#define P_COL9           32  /* STRING in tree FORM_POPUPS */
#define P_COL10          34  /* STRING in tree FORM_POPUPS */
#define P_COL11          36  /* STRING in tree FORM_POPUPS */
#define P_COL12          38  /* STRING in tree FORM_POPUPS */
#define P_COL13          40  /* STRING in tree FORM_POPUPS */
#define P_COL14          42  /* STRING in tree FORM_POPUPS */
#define P_COL15          44  /* STRING in tree FORM_POPUPS */
#define P_COL16          46  /* STRING in tree FORM_POPUPS */
#define P_COLOTHER       48  /* STRING in tree FORM_POPUPS */

#define FORM_INSTALL     9   /* Form/Dialog-box */
#define INSTALL_WW       1   /* STRING in tree FORM_INSTALL */
#define INSTALL_USER     3   /* TEXT in tree FORM_INSTALL */
#define INSTALL_NAME     4   /* FTEXT in tree FORM_INSTALL */
#define INSTALL_KEY      5   /* TEXT in tree FORM_INSTALL */
#define INSTALL_KEYCODE  6   /* FTEXT in tree FORM_INSTALL */
#define INSTALL_OK       7   /* BUTTON in tree FORM_INSTALL */
