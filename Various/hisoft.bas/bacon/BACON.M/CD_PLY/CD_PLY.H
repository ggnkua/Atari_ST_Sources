/* Resource file indices for CD_PLY. */

#define FORM_ALERTBOX    0   /* Form/Dialog-box */
#define WALERT_BACKDROP  0   /* BOX in tree FORM_ALERTBOX */
#define WALERT_ICON      1   /* IMAGE in tree FORM_ALERTBOX */
#define WALERT_TEXT1     2   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT2     3   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT3     4   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT4     5   /* STRING in tree FORM_ALERTBOX */
#define WALERT_BUT1      6   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT2      7   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT3      8   /* BUTTON in tree FORM_ALERTBOX */

#define ICONS            1   /* Form/Dialog-box */
#define ICON_BACKDROP    0   /* BOX in tree ICONS */
#define ICON_ALERT0      1   /* IMAGE in tree ICONS */
#define ICON_ALERT2      2   /* IMAGE in tree ICONS */
#define ICON_PRADIO      3   /* IMAGE in tree ICONS */
#define ICON_ALERT1      4   /* IMAGE in tree ICONS */
#define ICON_ALERT3      5   /* IMAGE in tree ICONS */
#define ICON_PRAD_SM     6   /* IMAGE in tree ICONS */
#define ICON_RAD_1       7   /* ICON in tree ICONS */
#define ICON_RAD_1S      8   /* ICON in tree ICONS */
#define ICON_RAD_1SM     9   /* ICON in tree ICONS */
#define ICON_RAD_1SMS    10  /* ICON in tree ICONS */
#define ICON_RAD_4       11  /* USERDEF in tree ICONS */
#define ICON_RAD_4S      12  /* USERDEF in tree ICONS */
#define ICON_RAD_4SM     13  /* USERDEF in tree ICONS */
#define ICON_RAD_4SMS    14  /* USERDEF in tree ICONS */
#define ICON_BX_1        15  /* ICON in tree ICONS */
#define ICON_BX_1S       16  /* ICON in tree ICONS */
#define ICON_BX_1SM      17  /* ICON in tree ICONS */
#define ICON_BX_1SMS     18  /* ICON in tree ICONS */
#define ICON_BX_4        19  /* USERDEF in tree ICONS */
#define ICON_BX_4S       20  /* USERDEF in tree ICONS */
#define ICON_BX_4SM      21  /* USERDEF in tree ICONS */
#define ICON_BX_4SMS     22  /* USERDEF in tree ICONS */

#define FORM_ICONIFY     2   /* Form/Dialog-box */

#define FORM_MAIN        3   /* Form/Dialog-box */
#define MAIN_VOLUME      1   /* BOX in tree FORM_MAIN */
#define MAIN_VOLUME2     2   /* BOX in tree FORM_MAIN */
#define MAIN_QUIT        3   /* IMAGE in tree FORM_MAIN */
#define MAIN_PLAY        4   /* BUTTON in tree FORM_MAIN */
#define MAIN_PLAY2       5   /* IMAGE in tree FORM_MAIN */
#define MAIN_STOP        6   /* BUTTON in tree FORM_MAIN */
#define MAIN_STOP2       7   /* IMAGE in tree FORM_MAIN */
#define MAIN_PAUSE       8   /* BUTTON in tree FORM_MAIN */
#define MAIN_PAUSE2      9   /* IMAGE in tree FORM_MAIN */
#define MAIN_BACK        10  /* BUTTON in tree FORM_MAIN */
#define MAIN_BACK2       11  /* IMAGE in tree FORM_MAIN */
#define MAIN_FORWARD     12  /* BUTTON in tree FORM_MAIN */
#define MAIN_FORWARD2    13  /* IMAGE in tree FORM_MAIN */
#define MAIN_INFO        14  /* BUTTON in tree FORM_MAIN */
#define MAIN_INFO2       15  /* IMAGE in tree FORM_MAIN */
#define MAIN_EJECT       16  /* BUTTON in tree FORM_MAIN */
#define MAIN_EJECT2      17  /* IMAGE in tree FORM_MAIN */

#define FORM_ABOUT       4   /* Form/Dialog-box */
#define ABOUT_OK         12  /* BUTTON in tree FORM_ABOUT */
