/*
* Lattice C header file for D:\KP_SACK.100\GLOBAL.SAA.
*
* Automatically generated by KP SACK at 23:22 on 21/4/1997
*
* Kosmik Phish Philosophy:
* Let me in! I've got a gigabyte on my back and it's heavy 
* - Xav with a bag full of hard drives.
*
* For more info, go to: 
*                http://www.cs.man.ac.uk/~jacquesa/kpp/
*/

/* SAA cookie. */
#define	GLOB	0x474c4f42

/* Application Macros */
#define	START_APP		0
#define	WIND_CYCLE		1
#define	WIND_ARRANGE	2
#define	CON_HELP		3
#define	ICONISE			4
#define	ICONISE_ALL		5
#define	UNICONISE		6
#define	INFO			7
#define	SELECT_ALL		8
#define	DESELECT_ALL	9
#define	TOGGLE			10
#define	CALL_FONTSEL	11
#define	CALL_ASCII		12
#define	CALL_COLOUR		13