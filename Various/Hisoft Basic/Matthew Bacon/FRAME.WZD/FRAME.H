/* Resource file indices for FRMWIZRD. */

#define FORM_ALERTBOX    0   /* Form/Dialog-box */
#define WALERT_BACKDROP  0   /* BOX in tree FORM_ALERTBOX */
#define WALERT_ICON      1   /* IMAGE in tree FORM_ALERTBOX */
#define WALERT_TEXT1     2   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT2     3   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT3     4   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT4     5   /* STRING in tree FORM_ALERTBOX */
#define WALERT_BUT1      6   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT2      7   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT3      8   /* BUTTON in tree FORM_ALERTBOX */

#define ICONS            1   /* Form/Dialog-box */
#define ICON_BACKDROP    0   /* BOX in tree ICONS */
#define ICON_ALERT0      1   /* IMAGE in tree ICONS */
#define ICON_ALERT2      2   /* IMAGE in tree ICONS */
#define ICON_PRADIO      3   /* IMAGE in tree ICONS */
#define ICON_ALERT1      4   /* IMAGE in tree ICONS */
#define ICON_ALERT3      5   /* IMAGE in tree ICONS */
#define ICON_PRAD_SM     6   /* IMAGE in tree ICONS */
#define ICON_RAD_1       7   /* ICON in tree ICONS */
#define ICON_RAD_1S      8   /* ICON in tree ICONS */
#define ICON_RAD_1SM     9   /* ICON in tree ICONS */
#define ICON_RAD_1SMS    10  /* ICON in tree ICONS */
#define ICON_RAD_4       11  /* USERDEF in tree ICONS */
#define ICON_RAD_4S      12  /* USERDEF in tree ICONS */
#define ICON_RAD_4SM     13  /* USERDEF in tree ICONS */
#define ICON_RAD_4SMS    14  /* USERDEF in tree ICONS */
#define ICON_BX_1        15  /* ICON in tree ICONS */
#define ICON_BX_1S       16  /* ICON in tree ICONS */
#define ICON_BX_1SM      17  /* ICON in tree ICONS */
#define ICON_BX_1SMS     18  /* ICON in tree ICONS */
#define ICON_BX_4        19  /* USERDEF in tree ICONS */
#define ICON_BX_4S       20  /* USERDEF in tree ICONS */
#define ICON_BX_4SM      21  /* USERDEF in tree ICONS */
#define ICON_BX_4SMS     22  /* USERDEF in tree ICONS */

#define FORM_ICONIFY     2   /* Form/Dialog-box */

#define FORM_MENU        3   /* Menu-tree */
#define MENU_PROGRAM     3   /* TITLE in tree FORM_MENU */
#define MENU_FILE        4   /* TITLE in tree FORM_MENU */
#define MENU_WINDOW      5   /* TITLE in tree FORM_MENU */
#define MENU_THELP       6   /* TITLE in tree FORM_MENU */
#define MENU_ABOUT       9   /* STRING in tree FORM_MENU */
#define MENU_NEW         18  /* STRING in tree FORM_MENU */
#define MENU_OPENFRM     20  /* STRING in tree FORM_MENU */
#define MENU_SAVE        22  /* STRING in tree FORM_MENU */
#define MENU_SAVEAS      23  /* STRING in tree FORM_MENU */
#define MENU_QUIT        25  /* STRING in tree FORM_MENU */
#define MENU_PAGE        27  /* STRING in tree FORM_MENU */
#define MENU_FRAME       28  /* STRING in tree FORM_MENU */
#define MENU_ABOUTHELP   30  /* STRING in tree FORM_MENU */
#define MENU_HELP        31  /* STRING in tree FORM_MENU */
#define MENU_CYBER       33  /* STRING in tree FORM_MENU */

#define FORM_FRAME       4   /* Form/Dialog-box */
#define FRAME_BACK       1   /* BOX in tree FORM_FRAME */
#define FRM_FRM1         2   /* BOX in tree FORM_FRAME */
#define FRM_FRM2         3   /* BOX in tree FORM_FRAME */
#define FRM_FRM3         4   /* BOX in tree FORM_FRAME */
#define FRM_FRM4         5   /* BOX in tree FORM_FRAME */
#define FRM_FRM5         6   /* BOX in tree FORM_FRAME */
#define FRM_FRM6         7   /* BOX in tree FORM_FRAME */
#define FRM_TEMPLATE     8   /* BOXTEXT in tree FORM_FRAME */
#define FRM_CUTX         9   /* BUTTON in tree FORM_FRAME */
#define FRM_CUTY         10  /* BUTTON in tree FORM_FRAME */
#define FRM_GLUE         11  /* BUTTON in tree FORM_FRAME */
#define FRM_PROPERTIES   12  /* BOX in tree FORM_FRAME */
#define FRM_TNAME        13  /* TEXT in tree FORM_FRAME */
#define FRM_NAME         14  /* FTEXT in tree FORM_FRAME */
#define FRM_TURL         15  /* TEXT in tree FORM_FRAME */
#define FRM_URL          16  /* FTEXT in tree FORM_FRAME */
#define FRM_TBORDER      17  /* TEXT in tree FORM_FRAME */
#define FRM_BORDERYES    18  /* IBOX in tree FORM_FRAME */
#define FRM_BORDERYES2   19  /* TEXT in tree FORM_FRAME */
#define FRM_BORDERNO     20  /* IBOX in tree FORM_FRAME */
#define FRM_BORDERNO2    21  /* TEXT in tree FORM_FRAME */
#define FRM_THEIGHT      22  /* TEXT in tree FORM_FRAME */
#define FRM_MARGINH      23  /* FTEXT in tree FORM_FRAME */
#define FRM_TSCROLL      24  /* TEXT in tree FORM_FRAME */
#define FRM_SCROLL       25  /* BOXTEXT in tree FORM_FRAME */
#define FRM_TWIDTH       26  /* TEXT in tree FORM_FRAME */
#define FRM_MARGINW      27  /* FTEXT in tree FORM_FRAME */
#define FRM_SELECTFRM    28  /* BUTTON in tree FORM_FRAME */

#define FORM_PAGE        5   /* Form/Dialog-box */
#define FRM_TEXT1        2   /* TEXT in tree FORM_PAGE */
#define FRM_TEXT2        3   /* TEXT in tree FORM_PAGE */
#define FRM_TEXT3        4   /* TEXT in tree FORM_PAGE */
#define FRM_TTITLE       5   /* STRING in tree FORM_PAGE */
#define FRM_TITLE        6   /* FTEXT in tree FORM_PAGE */
#define FRM_TEXT4        8   /* TEXT in tree FORM_PAGE */
#define FRM_TEXT5        9   /* TEXT in tree FORM_PAGE */
#define FRM_TEXT6        10  /* TEXT in tree FORM_PAGE */
#define FRM_TALTURL      11  /* STRING in tree FORM_PAGE */
#define FRM_ALTURL       12  /* FTEXT in tree FORM_PAGE */
#define FRM_BACKGRND     13  /* TEXT in tree FORM_PAGE */
#define FRM_IMAGE        14  /* IBOX in tree FORM_PAGE */
#define FRM_IMAGE2       15  /* STRING in tree FORM_PAGE */
#define FRM_IMAGE3       16  /* FTEXT in tree FORM_PAGE */
#define FRM_COLOUR       17  /* IBOX in tree FORM_PAGE */
#define FRM_COLOUR2      18  /* STRING in tree FORM_PAGE */
#define FRM_COLOUR3      19  /* FTEXT in tree FORM_PAGE */
#define FRM_COLOUR4      20  /* BOXTEXT in tree FORM_PAGE */
#define FRM_OK           21  /* BUTTON in tree FORM_PAGE */
#define FRM_CANCEL       22  /* BUTTON in tree FORM_PAGE */

#define FORM_ABOUT       6   /* Form/Dialog-box */
#define ABOUT_TEXT1      7   /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT2      9   /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT3      13  /* TEXT in tree FORM_ABOUT */
#define ABOUT_LANGUAGE   14  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT4      15  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TRANSLATOR 16  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT5      17  /* TEXT in tree FORM_ABOUT */
#define ABOUT_KEYCODE    18  /* TEXT in tree FORM_ABOUT */
#define ABOUT_TEXT6      19  /* TEXT in tree FORM_ABOUT */
#define ABOUT_USER       20  /* TEXT in tree FORM_ABOUT */
#define ABOUT_OK         22  /* BUTTON in tree FORM_ABOUT */

#define FORM_POPUPS      7   /* Form/Dialog-box */
#define POP_COLOUR       1   /* BOX in tree FORM_POPUPS */
#define P_COL1           3   /* TEXT in tree FORM_POPUPS */
#define P_COL2           5   /* TEXT in tree FORM_POPUPS */
#define P_COL3           7   /* TEXT in tree FORM_POPUPS */
#define P_COL4           9   /* TEXT in tree FORM_POPUPS */
#define P_COL5           11  /* TEXT in tree FORM_POPUPS */
#define P_COL6           13  /* TEXT in tree FORM_POPUPS */
#define P_COL7           15  /* TEXT in tree FORM_POPUPS */
#define P_COL8           17  /* TEXT in tree FORM_POPUPS */
#define P_COL9           19  /* TEXT in tree FORM_POPUPS */
#define P_COL10          21  /* TEXT in tree FORM_POPUPS */
#define P_COL11          23  /* TEXT in tree FORM_POPUPS */
#define P_COL12          25  /* TEXT in tree FORM_POPUPS */
#define P_COL13          27  /* TEXT in tree FORM_POPUPS */
#define P_COL14          29  /* TEXT in tree FORM_POPUPS */
#define P_COL15          31  /* TEXT in tree FORM_POPUPS */
#define P_COL16          33  /* TEXT in tree FORM_POPUPS */
#define P_COLOTHER       35  /* TEXT in tree FORM_POPUPS */
#define POP_TEMPLATE     36  /* BOX in tree FORM_POPUPS */
#define P_TMP1           37  /* TEXT in tree FORM_POPUPS */
#define P_TMP2           38  /* TEXT in tree FORM_POPUPS */
#define P_TMP3           39  /* TEXT in tree FORM_POPUPS */
#define P_TMP4           40  /* TEXT in tree FORM_POPUPS */
#define P_TMP5           41  /* TEXT in tree FORM_POPUPS */
#define P_TMP6           42  /* TEXT in tree FORM_POPUPS */
#define P_TMP7           43  /* TEXT in tree FORM_POPUPS */
#define P_TMP8           44  /* TEXT in tree FORM_POPUPS */
#define P_TMP9           45  /* TEXT in tree FORM_POPUPS */
#define P_TMP10          46  /* TEXT in tree FORM_POPUPS */
#define P_TMP11          47  /* TEXT in tree FORM_POPUPS */
#define P_TMP12          48  /* TEXT in tree FORM_POPUPS */
#define P_TMP13          49  /* TEXT in tree FORM_POPUPS */
#define P_TMP14          50  /* TEXT in tree FORM_POPUPS */
#define P_TMP15          51  /* TEXT in tree FORM_POPUPS */
#define P_TMP16          52  /* TEXT in tree FORM_POPUPS */
#define P_TMP17          53  /* TEXT in tree FORM_POPUPS */
#define P_TMP18          54  /* TEXT in tree FORM_POPUPS */
#define P_TMP19          55  /* TEXT in tree FORM_POPUPS */
#define P_TMP20          56  /* TEXT in tree FORM_POPUPS */
#define POP_SCROLL       57  /* BOX in tree FORM_POPUPS */
#define P_SCROLL1        58  /* TEXT in tree FORM_POPUPS */
#define P_SCROLL2        59  /* TEXT in tree FORM_POPUPS */
#define P_SCROLL3        60  /* TEXT in tree FORM_POPUPS */

#define FORM_COLOURS     8   /* Form/Dialog-box */
#define COL_PREVIEW      1   /* BOX in tree FORM_COLOURS */
#define RGB_RED          2   /* TEXT in tree FORM_COLOURS */
#define COL_RED          3   /* BOX in tree FORM_COLOURS */
#define COL_RED2         4   /* BOXTEXT in tree FORM_COLOURS */
#define COL_RED3         5   /* BUTTON in tree FORM_COLOURS */
#define COL_RED4         6   /* BUTTON in tree FORM_COLOURS */
#define RGB_GREEN        7   /* TEXT in tree FORM_COLOURS */
#define COL_GREEN        8   /* BOX in tree FORM_COLOURS */
#define COL_GREEN2       9   /* BOXTEXT in tree FORM_COLOURS */
#define COL_GREEN3       10  /* BUTTON in tree FORM_COLOURS */
#define COL_GREEN4       11  /* BUTTON in tree FORM_COLOURS */
#define RGB_BLUE         12  /* TEXT in tree FORM_COLOURS */
#define COL_BLUE         13  /* BOX in tree FORM_COLOURS */
#define COL_BLUE2        14  /* BOXTEXT in tree FORM_COLOURS */
#define COL_BLUE3        15  /* BUTTON in tree FORM_COLOURS */
#define COL_BLUE4        16  /* BUTTON in tree FORM_COLOURS */
#define COL_RGB          17  /* FTEXT in tree FORM_COLOURS */
#define COL_OK           18  /* BUTTON in tree FORM_COLOURS */
#define COL_CANCEL       19  /* BUTTON in tree FORM_COLOURS */

#define FORM_INSTALL     9   /* Form/Dialog-box */
#define INSTALL_WW       1   /* STRING in tree FORM_INSTALL */
#define INSTALL_USER     3   /* TEXT in tree FORM_INSTALL */
#define INSTALL_NAME     4   /* FTEXT in tree FORM_INSTALL */
#define INSTALL_KEY      5   /* TEXT in tree FORM_INSTALL */
#define INSTALL_KEYCODE  6   /* FTEXT in tree FORM_INSTALL */
#define INSTALL_OK       7   /* BUTTON in tree FORM_INSTALL */
