/* Resource file indices for FORMAT. */

#define FORM_ALERTBOX    0   /* Form/Dialog-box */
#define WALERT_BACKDROP  0   /* BOX in tree FORM_ALERTBOX */
#define WALERT_ICON      1   /* IMAGE in tree FORM_ALERTBOX */
#define WALERT_TEXT1     2   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT2     3   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT3     4   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT4     5   /* STRING in tree FORM_ALERTBOX */
#define WALERT_BUT1      6   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT2      7   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT3      8   /* BUTTON in tree FORM_ALERTBOX */

#define ICONS            1   /* Form/Dialog-box */
#define ICON_BACKDROP    0   /* BOX in tree ICONS */
#define ICON_ALERT0      1   /* IMAGE in tree ICONS */
#define ICON_ALERT2      2   /* IMAGE in tree ICONS */
#define ICON_PRADIO      3   /* IMAGE in tree ICONS */
#define ICON_ALERT1      4   /* IMAGE in tree ICONS */
#define ICON_ALERT3      5   /* IMAGE in tree ICONS */
#define ICON_PRAD_SM     6   /* IMAGE in tree ICONS */
#define ICON_RAD_1       7   /* ICON in tree ICONS */
#define ICON_RAD_1S      8   /* ICON in tree ICONS */
#define ICON_RAD_1SM     9   /* ICON in tree ICONS */
#define ICON_RAD_1SMS    10  /* ICON in tree ICONS */
#define ICON_RAD_4       11  /* USERDEF in tree ICONS */
#define ICON_RAD_4S      12  /* USERDEF in tree ICONS */
#define ICON_RAD_4SM     13  /* USERDEF in tree ICONS */
#define ICON_RAD_4SMS    14  /* USERDEF in tree ICONS */
#define ICON_BX_1        15  /* ICON in tree ICONS */
#define ICON_BX_1S       16  /* ICON in tree ICONS */
#define ICON_BX_1SM      17  /* ICON in tree ICONS */
#define ICON_BX_1SMS     18  /* ICON in tree ICONS */
#define ICON_BX_4        19  /* USERDEF in tree ICONS */
#define ICON_BX_4S       20  /* USERDEF in tree ICONS */
#define ICON_BX_4SM      21  /* USERDEF in tree ICONS */
#define ICON_BX_4SMS     22  /* USERDEF in tree ICONS */

#define FORM_ICONIFY     2   /* Form/Dialog-box */

#define FORM_ABOUT       3   /* Form/Dialog-box */
#define ABOUT_OK         12  /* BUTTON in tree FORM_ABOUT */

#define FORM_MAIN        4   /* Form/Dialog-box */
#define MAIN_A           5   /* BUTTON in tree FORM_MAIN */
#define MAIN_B           6   /* BUTTON in tree FORM_MAIN */
#define MAIN_2SIDES      9   /* STRING in tree FORM_MAIN */
#define MAIN_2           10  /* IBOX in tree FORM_MAIN */
#define MAIN_1SIDE       11  /* STRING in tree FORM_MAIN */
#define MAIN_1           12  /* IBOX in tree FORM_MAIN */
#define MAIN_80          15  /* IBOX in tree FORM_MAIN */
#define MAIN_80TRACKS    16  /* STRING in tree FORM_MAIN */
#define MAIN_81          17  /* IBOX in tree FORM_MAIN */
#define MAIN_81TRACKS    18  /* STRING in tree FORM_MAIN */
#define MAIN_10SECTORS   21  /* STRING in tree FORM_MAIN */
#define MAIN_10          22  /* IBOX in tree FORM_MAIN */
#define MAIN_9SECTORS    23  /* STRING in tree FORM_MAIN */
#define MAIN_9           24  /* IBOX in tree FORM_MAIN */
#define MAIN_VERIFY      25  /* IBOX in tree FORM_MAIN */
#define MAIN_VERIFY1     26  /* STRING in tree FORM_MAIN */
#define MAIN_FORMAT      27  /* BUTTON in tree FORM_MAIN */
#define MAIN_QUIT        28  /* BUTTON in tree FORM_MAIN */
