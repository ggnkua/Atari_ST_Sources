/* Resource file indices for MIDIMATE. */

#define FORM_ALERTBOX    0   /* Form/Dialog-box */
#define WALERT_BACKDROP  0   /* BOX in tree FORM_ALERTBOX */
#define WALERT_ICON      1   /* IMAGE in tree FORM_ALERTBOX */
#define WALERT_TEXT1     2   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT2     3   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT3     4   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT4     5   /* STRING in tree FORM_ALERTBOX */
#define WALERT_BUT1      6   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT2      7   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT3      8   /* BUTTON in tree FORM_ALERTBOX */

#define ICONS            1   /* Form/Dialog-box */
#define ICON_BACKDROP    0   /* BOX in tree ICONS */
#define ICON_ALERT0      1   /* IMAGE in tree ICONS */
#define ICON_ALERT2      2   /* IMAGE in tree ICONS */
#define ICON_PRADIO      3   /* IMAGE in tree ICONS */
#define ICON_ALERT1      4   /* IMAGE in tree ICONS */
#define ICON_ALERT3      5   /* IMAGE in tree ICONS */
#define ICON_PRAD_SM     6   /* IMAGE in tree ICONS */
#define ICON_RAD_1       7   /* ICON in tree ICONS */
#define ICON_RAD_1S      8   /* ICON in tree ICONS */
#define ICON_RAD_1SM     9   /* ICON in tree ICONS */
#define ICON_RAD_1SMS    10  /* ICON in tree ICONS */
#define ICON_RAD_4       11  /* USERDEF in tree ICONS */
#define ICON_RAD_4S      12  /* USERDEF in tree ICONS */
#define ICON_RAD_4SM     13  /* USERDEF in tree ICONS */
#define ICON_RAD_4SMS    14  /* USERDEF in tree ICONS */
#define ICON_BX_1        15  /* ICON in tree ICONS */
#define ICON_BX_1S       16  /* ICON in tree ICONS */
#define ICON_BX_1SM      17  /* ICON in tree ICONS */
#define ICON_BX_1SMS     18  /* ICON in tree ICONS */
#define ICON_BX_4        19  /* USERDEF in tree ICONS */
#define ICON_BX_4S       20  /* USERDEF in tree ICONS */
#define ICON_BX_4SM      21  /* USERDEF in tree ICONS */
#define ICON_BX_4SMS     22  /* USERDEF in tree ICONS */

#define FORM_ICONIFY     2   /* Form/Dialog-box */

#define FORM_MENU        3   /* Menu-tree */
#define MENU_ABOUT       8   /* STRING in tree FORM_MENU */
#define MENU_OPEN        17  /* STRING in tree FORM_MENU */
#define MENU_QUIT        19  /* STRING in tree FORM_MENU */
#define MENU_STG_TITLE   22  /* STRING in tree FORM_MENU */
#define MENU_STG_CONTENT 23  /* STRING in tree FORM_MENU */
#define MENU_STG_INDEX   24  /* STRING in tree FORM_MENU */

#define FORM_ABOUT       4   /* Form/Dialog-box */
#define ABOUT_OK         13  /* BUTTON in tree FORM_ABOUT */

#define FORM_MAIN        5   /* Form/Dialog-box */
#define MAIN_C           2   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_D           3   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_E           4   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_F           5   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_G           6   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_A           7   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_B           8   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_C_SHARP     9   /* BOXCHAR in tree FORM_MAIN */
#define MAIN_E_FLAT      10  /* BOXCHAR in tree FORM_MAIN */
#define MAIN_F_SHARP     11  /* BOXCHAR in tree FORM_MAIN */
#define MAIN_A_FLAT      12  /* BOXCHAR in tree FORM_MAIN */
#define MAIN_B_FLAT      13  /* BOXCHAR in tree FORM_MAIN */
#define MAIN_OCTAVE      14  /* BOXTEXT in tree FORM_MAIN */
#define MAIN_OCTAVE1     16  /* BOXCHAR in tree FORM_MAIN */
#define MAIN_CHANNEL     17  /* BOXTEXT in tree FORM_MAIN */
#define MAIN_CHANNEL1    19  /* BOXCHAR in tree FORM_MAIN */
#define MAIN_VUP         21  /* BUTTON in tree FORM_MAIN */
#define MAIN_VELOCITY    22  /* TEXT in tree FORM_MAIN */
#define MAIN_VDOWN       23  /* BUTTON in tree FORM_MAIN */
#define MAIN_INSTRUP     25  /* BUTTON in tree FORM_MAIN */
#define MAIN_INSTR       26  /* TEXT in tree FORM_MAIN */
#define MAIN_INSTRDOWN   27  /* BUTTON in tree FORM_MAIN */
#define MAIN_ALLNOTESOFF 28  /* BUTTON in tree FORM_MAIN */

#define FORM_POPUPS      6   /* Form/Dialog-box */
#define POP_OCTAVE       1   /* BOX in tree FORM_POPUPS */
#define POP_O1           2   /* STRING in tree FORM_POPUPS */
#define POP_O2           3   /* STRING in tree FORM_POPUPS */
#define POP_O3           4   /* STRING in tree FORM_POPUPS */
#define POP_O4           5   /* STRING in tree FORM_POPUPS */
#define POP_O5           6   /* STRING in tree FORM_POPUPS */
#define POP_CHANNEL      7   /* BOX in tree FORM_POPUPS */
#define POP_C1           8   /* STRING in tree FORM_POPUPS */
#define POP_C2           9   /* STRING in tree FORM_POPUPS */
#define POP_C3           10  /* STRING in tree FORM_POPUPS */
#define POP_C4           11  /* STRING in tree FORM_POPUPS */
#define POP_C5           12  /* STRING in tree FORM_POPUPS */
#define POP_C6           13  /* STRING in tree FORM_POPUPS */
#define POP_C7           14  /* STRING in tree FORM_POPUPS */
#define POP_C8           15  /* STRING in tree FORM_POPUPS */
#define POP_C9           16  /* STRING in tree FORM_POPUPS */
#define POP_C10          17  /* STRING in tree FORM_POPUPS */
#define POP_C11          18  /* STRING in tree FORM_POPUPS */
#define POP_C12          19  /* STRING in tree FORM_POPUPS */
#define POP_C13          20  /* STRING in tree FORM_POPUPS */
#define POP_C14          21  /* STRING in tree FORM_POPUPS */
#define POP_C15          22  /* STRING in tree FORM_POPUPS */
#define POP_16           23  /* STRING in tree FORM_POPUPS */
