/* Resource file indices for ENCHANT. */

#define FORM_ALERTBOX    0   /* Form/Dialog-box */
#define WALERT_BACKDROP  0   /* BOX in tree FORM_ALERTBOX */
#define WALERT_ICON      1   /* IMAGE in tree FORM_ALERTBOX */
#define WALERT_TEXT1     2   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT2     3   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT3     4   /* STRING in tree FORM_ALERTBOX */
#define WALERT_TEXT4     5   /* STRING in tree FORM_ALERTBOX */
#define WALERT_BUT1      6   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT2      7   /* BUTTON in tree FORM_ALERTBOX */
#define WALERT_BUT3      8   /* BUTTON in tree FORM_ALERTBOX */

#define ICONS            1   /* Form/Dialog-box */
#define ICON_BACKDROP    0   /* BOX in tree ICONS */
#define ICON_ALERT0      1   /* IMAGE in tree ICONS */
#define ICON_ALERT2      2   /* IMAGE in tree ICONS */
#define ICON_PRADIO      3   /* IMAGE in tree ICONS */
#define ICON_ALERT1      4   /* IMAGE in tree ICONS */
#define ICON_ALERT3      5   /* IMAGE in tree ICONS */
#define ICON_PRAD_SM     6   /* IMAGE in tree ICONS */
#define ICON_RAD_1       7   /* ICON in tree ICONS */
#define ICON_RAD_1S      8   /* ICON in tree ICONS */
#define ICON_RAD_1SM     9   /* ICON in tree ICONS */
#define ICON_RAD_1SMS    10  /* ICON in tree ICONS */
#define ICON_RAD_4       11  /* USERDEF in tree ICONS */
#define ICON_RAD_4S      12  /* USERDEF in tree ICONS */
#define ICON_RAD_4SM     13  /* USERDEF in tree ICONS */
#define ICON_RAD_4SMS    14  /* USERDEF in tree ICONS */
#define ICON_BX_1        15  /* ICON in tree ICONS */
#define ICON_BX_1S       16  /* ICON in tree ICONS */
#define ICON_BX_1SM      17  /* ICON in tree ICONS */
#define ICON_BX_1SMS     18  /* ICON in tree ICONS */
#define ICON_BX_4        19  /* USERDEF in tree ICONS */
#define ICON_BX_4S       20  /* USERDEF in tree ICONS */
#define ICON_BX_4SM      21  /* USERDEF in tree ICONS */
#define ICON_BX_4SMS     22  /* USERDEF in tree ICONS */

#define FORM_ICONIFY     2   /* Form/Dialog-box */
#define ICONIFY_ICON     1   /* USERDEF in tree FORM_ICONIFY */

#define FORM_MENU        3   /* Menu-tree */
#define MENU_ABOUT       9   /* STRING in tree FORM_MENU */
#define MENU_FSELECTOR   18  /* STRING in tree FORM_MENU */
#define MENU_TESTDIALOG  20  /* STRING in tree FORM_MENU */
#define MENU_TESTWINDOW  21  /* STRING in tree FORM_MENU */
#define MENU_TESTFORM    22  /* STRING in tree FORM_MENU */
#define MENU_EXECUTE     24  /* STRING in tree FORM_MENU */
#define MENU_QUIT        26  /* STRING in tree FORM_MENU */
#define MENU_CHECKME     28  /* STRING in tree FORM_MENU */
#define MENU_DISABLEME   29  /* STRING in tree FORM_MENU */
#define MENU_DESKTOP     31  /* STRING in tree FORM_MENU */
#define MENU_CTRL        33  /* STRING in tree FORM_MENU */
#define MENU_SCTRL       34  /* STRING in tree FORM_MENU */
#define MENU_ALT         36  /* STRING in tree FORM_MENU */
#define MENU_SALT        37  /* STRING in tree FORM_MENU */
#define MENU_README      39  /* STRING in tree FORM_MENU */
#define MENU_STG_TITLE   41  /* STRING in tree FORM_MENU */
#define MENU_STG_CONTENT 42  /* STRING in tree FORM_MENU */
#define MENU_STG_INDEX   43  /* STRING in tree FORM_MENU */

#define FORM_ABOUT       4   /* Form/Dialog-box */
#define ABOUT_OK         7   /* BUTTON in tree FORM_ABOUT */

#define FORM_TOOLBAR     5   /* Form/Dialog-box */
#define TOOL_NEW         2   /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_LOAD        4   /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_SAVE        6   /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_PRINT       8   /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_SEARCH      10  /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_INFO        12  /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_CUT         14  /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_COPY        16  /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_PASTE       18  /* IMAGE in tree FORM_TOOLBAR */
#define TOOL_QUIT        20  /* IMAGE in tree FORM_TOOLBAR */

#define FORM_WINDOW      6   /* Form/Dialog-box */
#define WIND_FTEXT       1   /* FTEXT in tree FORM_WINDOW */
#define WIND_RADIOIMAGE  2   /* BOX in tree FORM_WINDOW */
#define WIND_RI          4   /* BOXCHAR in tree FORM_WINDOW */
#define WIND_FTEXT2      5   /* FTEXT in tree FORM_WINDOW */
#define WIND_RADIOTEXT   6   /* BOXTEXT in tree FORM_WINDOW */
#define WIND_RT          8   /* BOXCHAR in tree FORM_WINDOW */
#define WIND_RAD1        9   /* IBOX in tree FORM_WINDOW */
#define WIND_RADIO1      10  /* STRING in tree FORM_WINDOW */
#define WIND_CHECKLIST   11  /* BOXTEXT in tree FORM_WINDOW */
#define WIND_CL          13  /* BOXCHAR in tree FORM_WINDOW */
#define WIND_RAD2        14  /* IBOX in tree FORM_WINDOW */
#define WIND_RADIO2      15  /* STRING in tree FORM_WINDOW */
#define WIND_CHKBX1      16  /* IBOX in tree FORM_WINDOW */
#define WIND_CHKBOX      17  /* STRING in tree FORM_WINDOW */
#define WIND_RADIO3      18  /* BUTTON in tree FORM_WINDOW */
#define WIND_CHKBX2      19  /* IBOX in tree FORM_WINDOW */
#define WIND_CHKBOX2     20  /* STRING in tree FORM_WINDOW */
#define WIND_HELP        21  /* BUTTON in tree FORM_WINDOW */
#define WIND_OK          22  /* BUTTON in tree FORM_WINDOW */
#define WIND_CANCEL      23  /* BUTTON in tree FORM_WINDOW */

#define FORM_DESKTOP     7   /* Form/Dialog-box */
#define DESK_LOGO        1   /* IMAGE in tree FORM_DESKTOP */
#define DESK_ICON        2   /* USERDEF in tree FORM_DESKTOP */

#define FORM_POPUPS      8   /* Form/Dialog-box */
#define POP_TEXT1        1   /* BOX in tree FORM_POPUPS */
#define POPUP1           2   /* STRING in tree FORM_POPUPS */
#define POPUP2           3   /* STRING in tree FORM_POPUPS */
#define POPUP3           5   /* STRING in tree FORM_POPUPS */
#define POP_IMAGES       6   /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE1     7   /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE2     8   /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE3     9   /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE4     10  /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE5     11  /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE6     12  /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE7     13  /* BOX in tree FORM_POPUPS */
#define POPUP_IMAGE8     14  /* BOX in tree FORM_POPUPS */
#define POP_TEXT2        15  /* BOX in tree FORM_POPUPS */
#define POPUP4           16  /* STRING in tree FORM_POPUPS */
#define POPUP5           17  /* STRING in tree FORM_POPUPS */
#define POPUP6           19  /* STRING in tree FORM_POPUPS */

#define FORM_PROCESS     9   /* Form/Dialog-box */
#define PROC_FTEXT       1   /* FTEXT in tree FORM_PROCESS */
#define PROC_FTEXT2      2   /* FTEXT in tree FORM_PROCESS */
#define PROC_RAD1        3   /* IBOX in tree FORM_PROCESS */
#define PROC_RADIO1      4   /* STRING in tree FORM_PROCESS */
#define PROC_RADIO2      5   /* BUTTON in tree FORM_PROCESS */
#define PROC_CHKBX1      6   /* IBOX in tree FORM_PROCESS */
#define PROC_CHKBOX1     7   /* STRING in tree FORM_PROCESS */
#define PROC_OK          8   /* BUTTON in tree FORM_PROCESS */
