/* Resource file indices for SHAREWAR. */

#define SHAREDIAL        0   /* Form/Dialog-box */
#define WHITEBACK        2   /* BOX in tree SHAREDIAL */
#define SLIDEBAR         3   /* BOX in tree SHAREDIAL */
