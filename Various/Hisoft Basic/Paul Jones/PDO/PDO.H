/* Resource file indices for PDO. */

#define Info             0   /* Form/Dialog-box */
#define Okbut1           1   /* BUTTON in tree INFO */
#define Ver              5   /* TEXT in tree INFO */

#define Menu             1   /* Menu-tree */
#define About            8   /* STRING in tree MENU */
#define Quit             17  /* STRING in tree MENU */
#define View             18  /* STRING in tree MENU */
#define Prin             19  /* STRING in tree MENU */
#define Opts             22  /* STRING in tree MENU */
#define Reg              23  /* STRING in tree MENU */
#define Loads            25  /* STRING in tree MENU */
#define Saves            26  /* STRING in tree MENU */

#define Regist           2   /* Form/Dialog-box */
#define Oform            16  /* BUTTON in tree REGIST */
#define Regbut           17  /* BUTTON in tree REGIST */
#define Cancel1          18  /* BUTTON in tree REGIST */
#define Regcode          20  /* FTEXT in tree REGIST */
