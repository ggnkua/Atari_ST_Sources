/*
* Lattice C header file for F:\HBASIC\PAUL\WAVE.2\GLOBAL.SAA.
*
* Automatically generated by KP SACK at 12:07 on 18/10/1998
*
* Kosmik Phish Philosophy:
* KP-SACK has scanned your hard drive - Bill Gates's henchmen are on their way.
*
* For more info, go to: 
*                http://www.cs.man.ac.uk/~jacquesa/kpp/
*/

/* SAA cookie. */
#define	GLOB	0x474c4f42

/* Application Macros */
#define	SAA_START_APPLICATION	0
#define	SAA_CYCLE_WINDOWS__LOCAL_	1
#define	SAA_TILE_ARRANGE_WINDOWS	2
#define	SAA_CONTEXT_HELP	3
#define	SAA_ICONISE_A_WINDOW	4
#define	SAA_ICONISE_ALL	5
#define	SAA_UN_ICONISE	6
#define	SAA_SHOW_INFO	7
#define	SAA_SELECT_ALL	8
#define	SAA_DESELECT_ALL	9
#define	SAA_TOGGLE_SELECTION	10
#define	SAA_CALL_FONT_SELECTOR	11
#define	SAA_CALL_ASCII_TABLE	12
#define	SAA_CALL_COLOUR_PICKER	13
