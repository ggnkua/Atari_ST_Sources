/* Resource file indices for TEST. */

#define NEW              0   /* Form/Dialog-box */
