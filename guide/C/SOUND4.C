/****************************************************/
/*  Musique sous interruption avec fonction Dosound  */
/*    Laser C            SOUND4.C    */
/****************************************************/

#include <osbind.h>

char data[] = {

   0,0,1,0,2,0,3,0,4,0,5,0,        /* A, B et C Е 0 */
   8,16,9,16,10,0,                 /* Volume: enveloppes A et B */
   13,1,11,64,12,31,               /* linВaire descendante, pВriode: 8000 */
   7,252,                          /* ParamВtrer A et B */

   0,222,1,1,255,16,               /* Musique... */
   0,170,13,1,255,16,
   0,123,2,222,3,1,13,1,255,32,
   13,1,255,46,
   0,102,2,170,13,1,255,16,
   0,28,2,123,13,1,255,24,
   0,63,13,1,255,8,
   13,1,255,32,
   0,123,2,222,13,1,255,16,
   0,63,2,123,13,1,255,16,
   2,170,13,1,255,24,
   0,102,13,1,255,8,
   13,1,255,32,
   0,63,2,250,13,1,255,16,
   0,102,2,0,3,0,13,1,255,16,
   0,123,2,222,3,1,13,1,255,64,

   0,0,1,0,2,0,3,0,4,0,5,0,7,255,8,15,9,15,10,15,  /* ArrИter tout */
   255,0                           /* ArrИt traitement du son */
};

main()
{
  Dosound (data);
}
