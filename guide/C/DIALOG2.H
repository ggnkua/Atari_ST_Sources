/* resource set indicies for DIALOG2 */

#define FORM1    0	/* form/dialog */
#define TEXT     3	/* FTEXT in tree FORM1 */
#define TEXTP    5	/* TEXT in tree FORM1 */
#define OK       6	/* BUTTON in tree FORM1 */
#define FIN      7	/* BUTTON in tree FORM1 */

