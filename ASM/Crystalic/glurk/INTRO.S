	SECTION	TEXT

	JSR	SETSUPER
	JSR	SETSCREEN
	JSR	CLEARSCREEN
	MOVE.B	#0,$FFFFF8260.W
	JSR	PUTINTROLOGO
	MOVE.B	#%11111100,$FFFF820A.W
	MOVE.B	#1,$FFFF8260.W
	NOP
	NOP
	NOP
	NOP
	MOVE.B	#%11111110,$FFFF820A.W
	MOVE.B	#0,$FFFF8260.W
	JSR	CLEARSCREEN
	JSR	COPYFONT
	JSR	MAKEBLOCK
	JSR	SETPAL
	JSR	SETLOGO
	JSR	SETVAR
	MOVE.L	#$68000-26,A5
	MOVE.L	#BACKBLOCKBUFF+128*16,BACKBLOCKBUFFADD
	JSR	MAKEXPOS
	JSR	MAKEYPOS
	MOVE.L	#BLOCKCOL+18*2,BLOCKCOLADD
	MOVE.L	OLDVBL,$70.W
	JSR	INIT
LOOP:
	JSR	WAITVBL
	CMP.B	#185,$FFFFFC02.W
	BNE.S	LOOP
	JSR	RETINIT
	JSR 	MUSIC+4
*	move.b	#15,$484.w
	JSR	ENDSUPER
	CLR.W	-(SP)
	TRAP	#1
*******************************
*         SUB - ROUTS         *
*******************************
SETSUPER:
	CLR.L	-(SP)
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
	MOVE.L	D0,SAVESUPER
	RTS
ENDSUPER:
	MOVE.L	SAVESUPER,-(SP)
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
	RTS
*******************************
SETSCREEN:
	MOVE.L	#$68000,D0
	LSR.L	#8,D0
	MOVE.B	D0,$FFFFF8203.W
	LSR.W	#8,D0
	MOVE.B	D0,$FFFFF8201.W
	MOVE.B	#0,$FFFFF8260.W
	RTS
*******************************
INIT:
	MOVE	#$2700,SR
	MOVE.L	$68.W,OLDPHBL
	MOVE.L	$70.W,OLDVBL
	MOVE.L	$120.W,OLDHBL
	MOVE.L	$134.W,OLDVBL2
	MOVE.B	$FFFFFA07.W,OLD07
	MOVE.B	$FFFFFA09.W,OLD09
	MOVE.B	$FFFFFA13.W,OLD13
	MOVE.B	$FFFFFA15.W,OLD15
	MOVE.B	$FFFFFA17.W,OLD17
	MOVE.B	$FFFFFA19.W,OLD19
	MOVE.B	$FFFFFA1B.W,OLD1B
	MOVE.B	$FFFFFA1F.W,OLD1F
	MOVE.B	$FFFFFA21.W,OLD21

	MOVE.B	#$21,$FFFFFA07.W
	CLR.B	$FFFFFA09.W
	MOVE.B	#$21,$FFFFFA13.W
	CLR.B	$FFFFFA15.W
	CLR.B	$FFFFFA19.W
	CLR.B	$FFFFFA1B.W
	MOVE.L	#PHBL,$68.W
	MOVE.L	#VBL,$70.W
	MOVE.L	#VBL2,$134.W
	MOVE.L	#HBL,$120.W
	BCLR.B	#3,$FFFFFA17.W
	MOVE 	#$2300,SR	
	RTS
*******************************
RETINIT:
	MOVE	#$2700,SR
	MOVE.L	OLDPHBL,$68.W
	MOVE.L	OLDVBL,$70.W
	MOVE.L	OLDHBL,$120.W
	MOVE.L	OLDVBL2,$134.W
	MOVE.B	OLD07,$FFFFFA07.W
	MOVE.B	OLD09,$FFFFFA09.W
	MOVE.B	OLD13,$FFFFFA13.W
	MOVE.B	OLD15,$FFFFFA15.W
	MOVE.B	OLD17,$FFFFFA17.W
	MOVE.B	OLD19,$FFFFFA19.W
	MOVE.B	OLD1B,$FFFFFA1B.W
	MOVE.B	OLD1F,$FFFFFA1F.W
	MOVE.B	OLD21,$FFFFFA21.W
	MOVE 	#$2300,SR	
	RTS
*******************************
*        MAIN - ROUTS         *
*******************************
CLEARSCREEN:
	MOVE.L	#$68000-26,A0
	MOVE.W	#275,D0
CLEARSCRLOOP:
	REPT	56
	CLR.L	(A0)+
	ENDR
	ADD.W	#6,A0
	DBF.W	D0,CLEARSCRLOOP
	RTS	
*******************************
SETPAL:
	MOVE.L	#PALETTE,A0
	MOVE.L	#$FF8240,A1
	REPT	8
	MOVE.L	(A0)+,(A1)+
	ENDR
	RTS
*******************************
SETVAR:
	MOVE.B	#0,D3
	MOVE.B	#2,D4
	MOVE.L	#$FF820A,A2
	MOVE.L	#$FF8260,A3
	RTS
*******************************
SETLOGO:
	MOVE.L	#LOGO,A0
	MOVE.L	#$68000-26+230*4+68,A1
	MOVE.W	#29,D0
SETLOGOLOOP:
	MOVE.L	(A0)+,(A1)
	MOVE.L	(A0)+,8(A1)
	MOVE.L	(A0)+,16(A1)
	MOVE.L	(A0)+,24(A1)
	MOVE.L	(A0)+,32(A1)
	MOVE.L	(A0)+,40(A1)
	MOVE.L	(A0)+,48(A1)
	MOVE.L	(A0)+,56(A1)
	MOVE.L	(A0)+,64(A1)
	MOVE.L	(A0)+,72(A1)
	ADD.W	#230,A1
	DBF.W	D0,SETLOGOLOOP	
	RTS
*******************************
*         INTRO LOGO          *
*******************************
PUTINTROLOGO:
	JSR	MUSIC
	JSR	SETCIRCLEPIC
	JSR	SETCIRCLEPAL
	JSR	SETLOGOCIRCPAL
	MOVE.L	$70,OLDVBL
	MOVE.L	#NEWVBL,$70
	JSR	LOGOCIRCWAIT
	JSR	SETLOGOCIRCPIC
	JSR	FADELOGO
DEMOLOOP2:
	JSR	WAITVBL

	ADDQ.W	#1,MUSCOUNT
	CMP.W	#200,MUSCOUNT
	BNE	DEMOLOOP2
	JSR	FADEUPLOGO
	JSR	FADEDOWNALL
	RTS
*******************************
WAITVBL:
	CMP.W	#1,WFNC
	BNE.S	WAITVBL
	MOVE.W	#0,WFNC
	RTS
*******************************
LOGOCIRCWAIT:
	MOVE.W	#49,D0
LOGOCIRCWAITLOOP:
	REPT	5
	JSR	WAITVBL
	ENDR
	DBF.W	D0,LOGOCIRCWAITLOOP
	RTS
*******************************
SETCIRCLEPAL:
	MOVE.L	#CIRCELPAL,A0
	MOVE.L	#$FF8240,A1
	REPT	5
	MOVE.W	(A0)+,(A1)+
	ENDR
	RTS
*******************************
SETLOGOCIRCPAL:
	MOVE.L	#LOGOCIRCPAL,A0
	MOVE.L	#$FF824A,A1
	REPT	11
	MOVE.W	(A0)+,(A1)+
	ENDR
	RTS
*******************************
SETCIRCLEPIC:
	MOVE.L	#CIRCLEPIC,A0
	MOVE.L	#$68000+24,A1
	MOVE.W	#199,D0
SETCIRCLEPICLOOP:
	REPT	14
	MOVE.L	(A0)+,(A1)+
	MOVE.W	(A0)+,(A1)+
	CLR.W	(A1)+
	ENDR
	ADD.W	#48,A1
	DBF.W	D0,SETCIRCLEPICLOOP	
	RTS
*******************************
SETLOGOCIRCPIC:
	MOVE.L	#LOGOCIRCPIC,A0
	MOVE.L	#$68000+160*48+40,A1
	MOVE.W	#100,D0
SETLOGOCIRCPICLOOP:
	REPT	10
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	ENDR
	ADD.W	#80,A1
	DBF.W	D0,SETLOGOCIRCPICLOOP	
	RTS
*******************************
*    FADE DOWN FROM WHITE     * 
*******************************
FADELOGO:
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL,A0
	JSR	FADESETPAL
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL2,A0
	JSR	FADESETPAL
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL3,A0
	JSR	FADESETPAL
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL4,A0
	JSR	FADESETPAL
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL5,A0
	JSR	FADESETPAL
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL6,A0
	JSR	FADESETPAL
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL7,A0
	JSR	FADESETPAL
	JSR	FADEWAIT
	MOVE.L	#LOGOCIRCPAL8,A0
	JSR	FADESETPAL
	RTS
*******************************
FADESETPAL:
	MOVE.L	#$FF824A,A1
	REPT	11
	MOVE.W	(A0)+,(A1)+
	ENDR
	RTS
*******************************
FADEWAIT:
	REPT	7
	JSR	WAITVBL
	ENDR
	RTS
*******************************
*      FADE UP TO WHITE       * 
*******************************
FADEUPLOGO:
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL8,A0
	MOVE.L	#CIRCELPAL,A1
	JSR	FADESETPAL2
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL7,A0
	MOVE.L	#CIRCELPAL2,A1
	JSR	FADESETPAL2
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL6,A0
	MOVE.L	#CIRCELPAL3,A1
	JSR	FADESETPAL2
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL5,A0
	MOVE.L	#CIRCELPAL4,A1
	JSR	FADESETPAL2
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL4,A0
	MOVE.L	#CIRCELPAL5,A1
	JSR	FADESETPAL2
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL3,A0
	MOVE.L	#CIRCELPAL6,A1
	JSR	FADESETPAL2
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL2,A0
	MOVE.L	#CIRCELPAL7,A1
	JSR	FADESETPAL2
	JSR	FADEWAIT2
	MOVE.L	#LOGOCIRCPAL,A0
	MOVE.L	#CIRCELPAL8,A1
	JSR	FADESETPAL2
	RTS
*******************************
FADESETPAL2:
	MOVE.L	#$FF8240,A2
	REPT	5
	MOVE.W	(A0)+,(A2)+
	ENDR
	REPT	11
	MOVE.W	(A1)+,(A2)+
	ENDR
	RTS
*******************************
FADEWAIT2:
	REPT	3
	JSR	WAITVBL
	ENDR
	RTS
*******************************
*        FADE DOWN ALL        *
*******************************
FADEDOWNALL:
	JSR	FADEWAIT3
	MOVE.L	#FADEALLCOLS,A0
	JSR	SETFADEALL
	JSR	FADEWAIT3
	MOVE.L	#FADEALLCOLS2,A0
	JSR	SETFADEALL
	JSR	FADEWAIT3
	MOVE.L	#FADEALLCOLS3,A0
	JSR	SETFADEALL
	JSR	FADEWAIT3
	MOVE.L	#FADEALLCOLS4,A0
	JSR	SETFADEALL
	JSR	FADEWAIT3
	MOVE.L	#FADEALLCOLS5,A0
	JSR	SETFADEALL
	JSR	FADEWAIT3
	MOVE.L	#FADEALLCOLS6,A0
	JSR	SETFADEALL
	JSR	FADEWAIT3
	MOVE.L	#FADEALLCOLS7,A0
	JSR	SETFADEALL
	JSR	FADEWAIT3
*******************************
SETFADEALL:
	MOVE.L	#$FF8240,A1
	REPT	8
	MOVE.L	(A0),(A1)+
	ENDR
	RTS
*******************************
FADEWAIT3:
	REPT	5
	JSR	WAITVBL
	ENDR
	RTS
*******************************
NEWVBL:
	JSR	MUSIC+8
	MOVE.W	#1,WFNC
	RTE
*******************************
*         COPY FONT           *
*******************************
COPYFONT:
	CLR.L	D0
	MOVE.L	#230*40,D1
	CLR.L	D2
	LEA	$68000-26+4+8+230,A1
	LEA	TEXT,A3
COPYFONTLOOP:
	MOVE.L	A1,A2
	ADD.W	D0,A2
	ADD.L	D1,A2
	CLR.L	D2
	MOVE.B	(A3)+,D2
	CMP.B	#$FE,D2
	BEQ	CFENDOFLINE
	CMP.B	#$FF,D2
	BEQ	CFWRAP
	SUB.W	#32,D2	
	MULS.W	#64,D2	
	LEA	FONT+34,A0
	ADD.W	D2,A0
	REPT	8
	MOVE.B	(A0),(A2)
	MOVE.B	2(A0),2(A2)
	ADDQ.W	#4,A0
	ADD.L	#230,A2
	ENDR
	ADDQ.W	#1,D0
	MOVE.L	A1,A2
	ADD.W	D0,A2
	ADD.L	D1,A2
	CLR.L	D2
	MOVE.B	(A3)+,D2
	CMP.B	#$FE,D2
	BEQ	CFENDOFLINE
	CMP.B	#$FF,D2
	BEQ	CFWRAP
	SUB.W	#32,D2	
	MULS	#64,D2	
	LEA	FONT+34,A0
	ADD.W	D2,A0
	REPT	8
	MOVE.B	(A0),(A2)
	MOVE.B	2(A0),2(A2)
	ADDQ.W	#4,A0
	ADD.W	#230,A2
	ENDR
	ADDQ.W	#7,D0
	BRA	COPYFONTLOOP
CFENDOFLINE:
	CLR.L	D0
	ADD.L	#230*9,D1
	BRA	COPYFONTLOOP		
CFWRAP:
	RTS
*******************************
*         MAKE BLOCK          *
*******************************
MAKEBLOCK:
	MOVE.L	#BACKBLOCK,BACKBLOCKADD
	MOVE.L	#BACKBLOCKBUFF,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	ADD.L 	#64,BACKBLOCKADD
	ADD.L	#128*16,BACKBLOCKBUFFADD
	JSR	PREROTATEBLOCK
	RTS
*******************************
PREROTATEBLOCK:
	MOVE.L	BACKBLOCKADD,A0
	MOVE.L	BACKBLOCKBUFFADD,A1
	MOVE.L	BACKBLOCKBUFFADD,A2
	ADD.L	#64,A2
	MOVE.W	#15,D0
PREROTBLOCKLOOP:
	REPT	16
	MOVE.W	(A0),(A1)+
	MOVE.W	2(A0),(A1)+
	MOVE.W	(A0),(A2)+
	MOVE.W	2(A0),(A2)+
	ROR.W	(A0)	
	ROR.W	2(A0)
	ADDQ.W	#4,A0
	ENDR			
	ADD.W	#64,A1
	ADD.W	#64,A2
	MOVE.L	BACKBLOCKADD,A0
	DBF.W	D0,PREROTBLOCKLOOP
	RTS
*******************************
*      SET BLOCK COLORS       *
*******************************
SETBLOCKCOLORS:
	MOVE.L	BLOCKCOLADD,A0
	MOVE.W	(A0)+,$FF8242
	MOVE.L	(A0)+,$FF8244
	MOVE.L	A0,BLOCKCOLADD
	ADDQ.W	#1,COLCOUNT
	CMP.W	#6,COLCOUNT
	BNE	NOCHANGEBLOCK
	ADD.L	#128*16,BACKBLOCKBUFFADD
	CMP.L	#BACKBLOCKBUFFEND-1,BACKBLOCKBUFFADD
	BLE	NOCHANGEBLOCK
	MOVE.L	#BACKBLOCKBUFF,BACKBLOCKBUFFADD
NOCHANGEBLOCK:
	CMP.W	#12,COLCOUNT
	BNE	SETBLCOLNOT
	CLR.W	COLCOUNT
	CLR.W	WAITCOUNT
	CLR.W	COLMODE
SETBLCOLNOT:
	RTS
*******************************
*    MAKE BACKGROUND MOVING   *
*******************************
MAKEXPOS:
	CLR.L	D0
	MOVE.L	#SINTAB+720,A0
	ADD.W	XGRAD,A0
	MOVE.W	(A0),D0	
	MULS.W	#310,D0
	DIVS.W	#512,D0
	ADD.W	#310,D0
	AND.W	#$000F,D0
	MULS	#128,D0
	MOVE.L	BACKBLOCKBUFFADD,A6
	ADD.W	D0,A6
	RTS
*******************************
MAKEYPOS:
	CLR.L	D0
	MOVE.L	#SINTAB,A0
	ADD.W	YGRAD,A0
	MOVE.W	(A0),D0	
	MULS.W	#140,D0
	DIVS.W	#512,D0
	ADD.W	#140,D0
	AND.W	#$000F,D0
	MULS	#4,D0
	ADD.W	D0,A6
	RTS
*******************************
*         INTERRUPPTS         *
*******************************
VBL:
	CLR.L	D5
	MOVE.L	(A6),D5

	CLR.B	$FFFFFA19.W
	MOVE.B	#99,$FFFFFA1F.W
	MOVE.B	#4,$FFFFFA19.W

	MOVE.L	#HBL,$120.W
	CLR.B	$FFFFFA1B.W
	MOVE.B	#1,$FFFFFA21.W
	MOVE.B	#8,$FFFFFA1B.W
	
	JSR	MAKEXPOS
	JSR	MAKEYPOS
	MOVE.L	#$68000-26+230,A5

	ADDQ.W	#2,XGRAD
	CMP.W	#720,XGRAD
	BNE	NORESTOREXGRAD
	CLR.W	XGRAD
NORESTOREXGRAD:
	ADDQ.W	#2,YGRAD
	CMP.W	#718,YGRAD
	BLE	NORESTOREYGRAD
	CLR.W	YGRAD
NORESTOREYGRAD:
	CMP.W	#0,COLMODE
	BNE	NOCOLMODE
	ADDQ.W	#1,WAITCOUNT
	CMP.W	#200,WAITCOUNT
	BNE	NOCOLMODE
	CLR.W	WAITCOUNT
	MOVE.W	#1,COLMODE
NOCOLMODE:
	CMP.W	#1,COLMODE
	BNE	NONEWCOLOR
	ADDQ.W	#1,WAITCOUNT
	CMP.W	#5,WAITCOUNT
	BNE	NONEWCOLOR
	CLR.W	WAITCOUNT
	JSR	SETBLOCKCOLORS
	CMP.L	#BLOCKCOLEND,BLOCKCOLADD
	BNE	NONEWCOLOR
	MOVE.L	#BLOCKCOL,BLOCKCOLADD
NONEWCOLOR:
	MOVEM.L	D0-D7/A0-A6,-(SP)
	JSR	MUSIC+8
	MOVEM.L	(SP)+,D0-D7/A0-A6
	MOVE.W	#1,WFNC
	RTE
*******************************
VBL2:
	MOVE	#$2100,SR
	STOP	#$2100
	MOVE	#$2700,SR
	CLR.B	$FFFFFA19.W	
	MOVEM.L	D0-D7/A0-A1,-(SP)
	DCB.W	60,$4E71
	MOVE.B	#0,$FFFF820A.W
	DCB.W	7,$4E71
	CLR	D1
	MOVE	#$8209,A0
	MOVE.B	#2,$FFFF820A.W
	MOVEM.L	(SP)+,D0-D7/A0-A1
	MOVEM.L	D0/D1,-(SP)
SYNCWAIT:
	MOVE.B	$FFFF8209.W,D0
	BEQ	SYNCWAIT
	AND.B	#$3F,D0
	MOVEQ	#63,D1
	SUB.B	D0,D1
	LSR.W	D1,D0
	MOVE.B	#0,$FFFFFA19.W
	MOVEM.L	(SP)+,D0/D1
	MOVE.L	#13,D2         *227,D2
	REPT	19
	NOP
	ENDR
NOPS2:				* BREAK SIDEBORDERS
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	4(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	8(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	12(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	16(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	20(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	24(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	28(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	32(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	36(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	40(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	44(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	48(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	52(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	56(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	60(A6),D5
		DCB.W	4,$4E71
********
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	0(A6),D5
		DCB.W	1,$4E71
*****
	DBF.W	D2,NOPS2
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	4(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	8(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
	DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	12(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
	DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	16(A6),D5
		DCB.W	1,$4E71
		MOVE.L	D5,8(A5)
*****
* * * * * * * * * * * * * * * * * * * * * 
				* BREAK DOWNBORDER+SIDEBORDER
	NOP
	MOVE.B	D3,(A2)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		MOVE.L	D5,32(A5)
		DCB.W	3,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
		MOVE.L	D5,56(A5)
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
	MOVE.L	#2,D2
	MOVE.B	D4,(A2)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	20(A6),D5
	DCB.W	3,$4E71
NOPS3:				* BREAK SIDEBORDER
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	24(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	28(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	32(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	36(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	40(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	44(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	48(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	52(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	56(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	60(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	0(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	4(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	8(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	12(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	16(A6),D5
		DCB.W	4,$4E71
*****
	NOP
	NOP
	MOVE.B	D3,(A2)
	MOVE.B	D4,(A2)
		MOVE.L	D5,8(A5)
		MOVE.L	D5,16(A5)
		MOVE.L	D5,24(A5)
		DCB.W	1,$4E71
	MOVE.B	D4,(A3)
	NOP
	MOVE.B	D3,(A3)
		MOVE.L	D5,32(A5)
		MOVE.L	D5,40(A5)
		MOVE.L	D5,48(A5)
*		DCB.W	12,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
		MOVE.L	D5,56(A5)
		MOVE.L	D5,64(A5)
		MOVE.L	D5,72(A5)
		MOVE.L	D5,80(A5)
		MOVE.L	D5,88(A5)
		MOVE.L	D5,96(A5)
		MOVE.L	D5,104(A5)
		MOVE.L	D5,112(A5)
		MOVE.L	D5,120(A5)
		MOVE.L	D5,128(A5)
		MOVE.L	D5,136(A5)
		MOVE.L	D5,144(A5)
		MOVE.L	D5,152(A5)
		MOVE.L	D5,160(A5)
		MOVE.L	D5,168(A5)
		MOVE.L	D5,176(A5)
		MOVE.L	D5,184(A5)
		MOVE.L	D5,192(A5)
		MOVE.L	D5,200(A5)
		ADD.L	#230,A5
		MOVE.L	20(A6),D5
		DCB.W	1,$4E71
*****
	DBF.W	D2,NOPS3
PHBL:
	RTE
*******************************
HBL:
	CLR.B	$FFFFFA1B.W
	BCLR 	#0,$FFFFFA0F.W	
	RTE			
*******************************
*         VARIABLES           *
*******************************

	SECTION	DATA

SAVESUPER:		DC.L	0
OLDPHBL:		DC.L	0
OLDVBL:			DC.L	0
OLDHBL:			DC.L	0
OLDVBL2:		DC.L	0
OLD07:			DC.B	0
OLD09:			DC.B	0
OLD13:			DC.B	0
OLD15:			DC.B	0
OLD17:			DC.B	0
OLD19:			DC.B	0
OLD1B:			DC.B	0
OLD1F:			DC.B	0
OLD21:			DC.B	0
WFNC:			DC.W	0
XGRAD:			DC.W	0
YGRAD:			DC.W	0
COLMODE:		DC.W	0
COLCOUNT:		DC.W	0
WAITCOUNT:		DC.W	0
MUSCOUNT:		DC.W	0
BACKBLOCKADD:		DC.L	0
BACKBLOCKBUFFADD:	DC.L	0
BLOCKCOLADD:		DC.L	0
TEXT:			DC.B	'  WELCOME TO THE WEIRD "GNURK" DEMO,CREATED IN',$FE
			DC.B	' THE YEAR OF 1993 BY CRYSTALIC AND ANATOMICA ON',$FE
			DC.B	'  THE PARTY THAT WE HAD TOGETHER IN A SCHOOL IN',$FE
			DC.B	'      HUDIKSVALL RIGHT AFTER NEW YEARS EVE.',$FE
			DC.B	'  SOME OTHER CREWS WERE INVITED BUT THEY COULD',$FE
			DC.B	'   NOT COME FOR VARIOUS REASONS,TOUGH LUCK...',$FE
			DC.B	'  THIS DEMO IS A MULTI PART OF VARIOUS SCREENS',$FE
			DC.B	'   BY CRYSTALIC AND ANATOMICA.THERE WILL BE A',$FE
			DC.B	'   GREAT DEAL OF MIND BLOWING TRACKS AND SOME',$FE
			DC.B	'   BORING HOURS OF SCROLL READING.',$FE
			DC.B	'   NOW OVER TO SOME RAW FACTS ABOUT THIS DEMO:',$FE,$FE
			DC.B	'   THIS INTRO: CODE BY FEAR OF CRYSTALIC. ',$FE
			DC.B	'               GFX BY LORD OF CRYSTALIC.',$FE
			DC.B	'               SCREEN LOGO BY ACE OF ANATOMICA.',$FE
			DC.B	'               MUSIC BY BLUE NUN OF ANATOMICA. ',$FE
			DC.B	'   LOADER SCREEN:',$FE
			DC.B	'               CODE BY OB OF ANATOMICA.',$FE
                        DC.B    '           GFX BY ACE AND ZAQE OF ANATOMICA.',$FE,$FE
                        DC.B    '   PUT TOGETHER BY:                    ',$FE
                        DC.B    '            FEAR AND CORNY OF CRYSTALIC.',$FE,$FE
                        DC.B    '            HIT SPACE TO START BLEEDING! ',$FE  
			DC.B	$FF
PALETTE:		DC.W	$000,$210,$321,$432,$545,$545,$545,$545
			DC.W	$767,$767,$767,$767,$777,$777,$777,$777
CIRCELPAL:		DC.W	$000,$102,$103,$204,$304
CIRCELPAL2:		DC.W	$111,$213,$214,$315,$415
CIRCELPAL3:		DC.W	$222,$324,$325,$426,$526
CIRCELPAL4:		DC.W	$333,$435,$436,$537,$637
CIRCELPAL5:		DC.W	$444,$546,$547,$647,$747
CIRCELPAL6:		DC.W	$555,$657,$657,$757,$757
CIRCELPAL7:		DC.W	$666,$767,$767,$767,$767
CIRCELPAL8:		DC.W	$777,$777,$777,$777,$777
LOGOCIRCPAL:		DC.W	$777,$777,$777,$777,$777,$777,$777,$777,$777,$777,$777
LOGOCIRCPAL2:		DC.W	$776,$776,$776,$776,$766,$777,$777,$777,$777,$777,$777
LOGOCIRCPAL3:		DC.W	$775,$775,$775,$765,$755,$777,$777,$777,$767,$777,$777
LOGOCIRCPAL4:		DC.W	$774,$774,$764,$754,$744,$777,$777,$777,$656,$767,$777
LOGOCIRCPAL5:		DC.W	$773,$763,$753,$743,$633,$777,$777,$777,$545,$656,$767
LOGOCIRCPAL6:		DC.W	$762,$752,$742,$632,$522,$777,$777,$767,$434,$545,$656
LOGOCIRCPAL7:		DC.W	$751,$741,$631,$521,$411,$777,$767,$656,$323,$434,$545
LOGOCIRCPAL8:		DC.W	$740,$630,$520,$410,$300,$767,$656,$545,$212,$323,$434
FADEALLCOLS:		DC.L	$7770777
FADEALLCOLS2:		DC.L	$6660666
FADEALLCOLS3:		DC.L	$5550555
FADEALLCOLS4:		DC.L	$4440444
FADEALLCOLS5:		DC.L	$3330333
FADEALLCOLS6:		DC.L	$2220222
FADEALLCOLS7:		DC.L	$1110111
FADEALLCOLS8:		DC.L	$0000000
CIRCLEPIC:		INCBIN	A:\CIRC.DAT
LOGOCIRCPIC:		INCBIN	A:\CIRCLOGO.DAT
BLOCKCOL:		INCLUDE	A:\COLORS2.DAT
BLOCKCOLEND:
SINTAB:			INCBIN 	A:\COSIN.DAT
FONT:			INCBIN	A:\INTROFNT.DAT
LOGO:			INCBIN	A:\LOGO1.DAT
MUSIC:			INCBIN	A:\SVEN.THK	
BACKBLOCK:		DC.W	$FFFF,$0000,$FFFF,$0004,$FFF3,$000E,$FFE3,$001C
			DC.W	$FF07,$00F8,$FECF,$01F0,$FD0F,$03F0,$F80F,$07F0
			DC.W	$F01F,$0FE0,$E03F,$1FC0,$C07F,$3F80,$C0FF,$3F00
			DC.W	$EDFF,$1E00,$F3FF,$0C00,$FFFF,$0000,$FFFF,$0000
*****
			DC.W	$8004,$FFFF,$5004,$BFFF,$108E,$FFFF,$384E,$FFBF
			DC.W	$3885,$FFFE,$7CC2,$FFBD,$7650,$FDBF,$6610,$FDFF
			DC.W	$3E38,$F9FF,$1C38,$E3FF,$007C,$FFFF,$1076,$FFFD
			DC.W	$0866,$F7FD,$123E,$FFF9,$191C,$F6E3,$0800,$F7FF
*****
			DC.W	$7FFE,$8001,$FF1F,$FFFF,$00A0,$FFFF,$06E0,$FFBF
			DC.W	$02E0,$FFBF,$00E0,$FFBF,$00E0,$FFBF,$FFBF,$FF5F
			DC.W	$FF1F,$00E0,$7FFC,$FFFF,$8002,$FFFF,$801B,$FFFE
			DC.W	$800B,$FFFE,$8003,$FFFE,$8003,$FFFE,$FFFE,$7FFD
***** 1
			DC.W	$00C0,$0080,$00C0,$0080,$0240,$0180,$0B90,$07E0
			DC.W	$14F8,$0F00,$0BF0,$1C08,$F7FF,$F80F,$F7EF,$1818
			DC.W	$2FF4,$1018,$0FD8,$1030,$1F68,$00F0,$09B0,$07C0
			DC.W	$0240,$0180,$00C0,$0080,$00C0,$0080,$00C0,$0080
*****
			DC.W	$FFFE,$FFFF,$FFFD,$FFFE,$C003,$FFFC,$C003,$FFFC
			DC.W	$C003,$FFFC,$C003,$FFFC,$C003,$FFFC,$C003,$FFFC
			DC.W	$C003,$FFFC,$C003,$FFFC,$C003,$FFFC,$C003,$FFFC
			DC.W	$C003,$FFFC,$C003,$FFFC,$BFFF,$C000,$7FFF,$8000
*****
			DC.W	$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$3BC7,$FFFF
			DC.W	$4428,$E47C,$9D93,$C438,$A444,$9D93,$8400,$BC17
			DC.W	$85C0,$BC17,$0000,$85D0,$7A2F,$85D0,$0000,$FFFF
			DC.W	$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF
*****
			DC.W	$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$73DC,$FFFF
			DC.W	$8C22,$8C23,$B5AC,$8421,$8420,$B5AD,$8420,$85A1
			DC.W	$B42C,$85A1,$8420,$B5AD,$0A50,$B5AD,$0000,$BFFD
			DC.W	$4002,$BFFD,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF
*****
			DC.W	$00C0,$7F00,$8040,$7F00,$80C0,$7F00,$80C0,$7F00
			DC.W	$80C0,$7F00,$FFC0,$0000,$DEC0,$3D00,$DAC0,$2700
			DC.W	$DAC0,$2700,$DEC0,$3F00,$0000,$0000,$0000,$0000
			DC.W	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*****
			DC.W	$FFFF,$0000,$EEFB,$310C,$C7F3,$780C,$C7BF,$78C0
			DC.W	$CF1F,$31E0,$FF1B,$01E4,$BF3F,$40C0,$F7FF,$1800
			DC.W	$E3BB,$3CCC,$E331,$3CDE,$E7F1,$181E,$FF73,$018C
			DC.W	$EE3F,$33C0,$CE3D,$33C6,$FE79,$0186,$FFFF,$0000
*****
			DC.W	$E000,$4000,$8000,$8000,$A000,$A000,$E000,$5800
			DC.W	$4880,$1400,$0280,$1680,$1680,$0280,$0380,$01E0
			DC.W	$0180,$0050,$0010,$0060,$002A,$005A,$005E,$000C
			DC.W	$000E,$000A,$000A,$0000,$0000,$0000,$0000,$0000
*****
			DC.W	$0240,$0380,$0240,$0380,$0240,$0380,$0240,$0380
			DC.W	$0240,$0380,$0240,$0380,$FE3F,$FFFF,$0000,$FFFF
			DC.W	$0000,$FFFF,$FC7F,$0380,$0240,$0380,$0240,$0380
			DC.W	$0240,$0380,$0240,$0380,$0240,$0380,$0240,$0380
*****
			DC.W	$0000,$FFFF,$0000,$FFFF,$3BA0,$FFFF,$3BA0,$FFFF
			DC.W	$3778,$FFE7,$07F8,$FFE7,$39D8,$FFE7,$3E38,$FFE7
			DC.W	$36F8,$FFE7,$2EF8,$FFE7,$0FF8,$F007,$0FF8,$F007
			DC.W	$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF

	SECTION	BSS

BACKBLOCKBUFF:		DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
			DS.B	16*128
BACKBLOCKBUFFEND:	

	END	 
