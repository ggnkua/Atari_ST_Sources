                       HELLO...             THIS SCREEN HAS NO REAL SCROLLTEXT SO IF YOU WANT TO READ SOMETHING BY OB YOU MUST READ HIS SCROLL IN THE NEW SCREEN IN THIS AMBITION DEMO AND NOT IN THIS OLDIE...
     CREDITS ARE          CODE BY OB OF ANATOMICA         MUSIC BY MANIACS OF NOISE          OB LOGO BY LORD OF CAC    HEADS BY ACE...                    NOW YOU WILL WHITNESS THE RETURN OF THE NEW YEAR SCROLLTEXT THAT CORNY HAD IN HIS PART IN THE
  ..GNURK DEMO...        BUT THAT ONE WAS PRETTY UNREADABLE SO HERE IT COMES....                   NEW YEARS EVE 1992
                           HELLV ETE FAN& VAD GOR ALLA ANATOMICAMEMBERS AND CAC MEMBERS PA NYARSFANSJEVLA-AFTONA? JA DE JAN MAN UDRA. SUPER TILL SEERE UTSOM & JA JA TROR DWE. FEAR E FULLASTEN .-    
A DET TROR JAG MED. OB OCH JAGCORNY SKREVADE DENTA  TXTEN &  JOO , KLOCKA N $R NU 20.2+0....FAN VASKIT SDOM SKRIVER I DEN HERE I AM AND WRITING THIS SCROLL......NOW OVER TO FEAR WHOE ISSS PRETY STRUNK..THEIRE HITTING IT...FERAR:....TJENA FAN ... FEAR
IS HEERE WITYH THIS SCROLLER AND I WILL WRITE A LITTRLE BBITT... THIS IS REALY FUN THEN I AM DRUNK... SOON WE WILL LEAVE FOR HOGLIDEN... A PLACE WHERE CAN RAVE AND WE WILL RAVE AS HELL..... OB IS CARRINGH A VIDEO-CAMERA AND IT WILL TAPE ALL OF USS TH
N WE ARE DRUNK... KNOW CORNY WILLL TAKE OVERWR.... CORNY: FUCK YOPU LORDAIER DUFAN BYTTE BITT MANDPAN, BANDFAN, MENA JA,SKIIT. HJATA , MENA HATA DEVPACK. KAG, MEN AJAFG KAN INTE SKRIVA. OBE E$R  FULL-L=FUL  . LORD BYTTE MITT PAND FAST DET VAR EN ELPE
MOT ETT FL%TBAND MED J$VLA SKIIT TEKNO P##- SKITTTR##KIGTT ATT SKIRV A L#TA LORDELKLER OBE G%T TYCKEJAVISST, M#DTE HA EN TILL DRINK FAN VA LORD SKRATTAR VILL OCJS# SE BY#LA NUUUUUUU, SKRIV VEM SOM VILL. ...FAANSS  FER O JEJ VAR UTE OCH SMELLDE EN SME
LARE UTANFEAR CORNIS WINDOW FAAN....LORD SIGNING STOFF....      YO HERE'S OB TYPIN SOME SHIT, WELL THE TIME IS NOW 80:30 AND I'M DRUNK. FUCK, WERE ALL SITTING AND LOOKING AND LOOKING AT RONNY AND RAGGE AND IT'S VERRRRY FUNNY FEAR AND LORD DID JUST CA
L BREAST AND TOLD HIM SOME SHIT. OHH, THIS IS FUNNY.......      INGERN SP OM SKRIVVER P#SCROLLEN FRUTOM CORNY=JAG. JAG INTE VILLA LYSSNA LODBAND VILLA BYTA. FEARSKRIKA, RAAH   NU BYTA YEEEAHH. NU JAG TROR ATT LORD LORD KOMMA FAN& OB S$GDE #T LORD ATT
KOMMA FO SKRIVA , FAST NU KOM OBE TILL HIT IGEN OCH SAFAN ATT LORD SOVA & LORD FA INTE SOVA JAG DERTYFOER SOJKA HEJ DA. NU KRILLFEAR SLRIFFA&    FEARRR IS HERRE ... KNOW LORD WILL WRITE A SUPEEER SCVVB NU E JAG RETT TIRED ..SO I TROR THAT I MUST TA
E  EASY..THE MUSIC IS REALLY BLASTING OUT OFF CORNIS STREREO RIGHT NOW..LETS PARTY AND STOP THIS INFRENAL LORD WRITING..BYE&.......   HI OB AGAIN, FEAR TRIED TO CALL A TAXI BUT IT DIDN'T WORK LORD WAS SO DRUNK SO HE FELL ASLEEP ON THE FLOOR AND THEN 
IT HIS HEAD ON THE WALL, WHAT A PARTY. NOW I'M TIRED, FUXCK I HAD TO RETYPE THAT SENTENCE FOUR TIMES, I MUST BE DRUNK. AND WITH THIS MUSIC IN THE BACKGROUND...    I FEEL SO TIRED... WELL, SOON WE'LL GO UP TO A DISCO SOMWHERE IN HUDDIK.....  LORD DRIN
ED TO MUCH AND GOT OUT... BUT HE STOMP UP TWENTY MINUTES LATER....KRTIIIVA KLROLLL& CORNU GEN.& FAN VA KUUUUOL& LORD SOMNA FAN& TOTTAT ASBAXKAD , BVI FEAR OJA G M #STA VATTNAN F%FAAAN& LOPRD RAVEA NU IMITT RUM & YEEAH NUN FAAN BUTTE TILLL AXID ROCK&
 TROSDDE JA MEN DE VA INT DA. DE VA NGE DEMO LOOT DE VA ACID I PANDEMONIUM&       YO, SOON WE'LL GO TO THE PARY HERE, YES THIS IS OB OF ANATOMICA AND WE'LL MAKE A PARTY DEMO AT THE PARTY WE'LL HAVE IN THE NEXT DAYS....   WE'LL MAKE A PARY DEMO AND T
ATS WEILL BE A GREAT DEMO....       THAT WAS THAT       THE DEMO WE MADE AFTER THIS NIGHT OUT WAS GNURK         HOW DID WE MANAGE...      I DONT KNOW...              ANYWAY,HERE COMES       WRAPOLISICUM.........                      