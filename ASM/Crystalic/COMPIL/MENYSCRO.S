

 dc.b   "              USE CURSUR KEYS AND SPACE!...                     WELCOME TO CRYSTALICS LITTLE DEMO COMPILATION.THIS LITTLE PARTY DEMO WAS PUT TOGETHER BY FEAR OF CRYSTALIC,WHO IS IN THE SWEDISH ARMY AT THE MOMENT.THAT SHOULD "
 DC.B   "AMAZE ALL THOSE YOU EXCUSE THEMSELVES BY SAYING..I CAN NOT DO ANY DEMO COZ I AM IN THE ARMY...WELL!.. IF FEAR CAN..   SO CAN YOU?...        CORNY IS ALSO IN THE ARMY BUT HE ALSO DID FINISH HIS SCREEN (WELL DONE CORNY!).AND AS "
 DC.B   "BOTH CODERS ARE IN THE ARMY LORD GOT BORED AND DID A DEMO WITH OB OF ANATOMICA,ALONG WITH A BUNCH OF MUSICIANS FROM THEIR CREWS CALLED..TRACK MANIA II...  COMING SOON FROM OB!.     FEAR DID TRY TO PUT THIS DEMO TOGETHER THE "
 DC.B   "DAYS BEFORE HE STARTED THE ARMY.AT LORDS PLACE WE STAYED UP ALMOST THE HOLE NIGHT AND WORKED BUT AS THERE WAS MUCH TO DEBUGG WE DID NOT MAKE IT.THE ONLY THING LEFT WAS TO PUT IT TOGETHER,AND THAT TAKES TIME TOO!."
 DC.B   "I THINK THIS MENU CAN HAVE SOME LITTLE BUGS BUT AS WE HAD SO LITTLE TIME WE JUST MADE IT WORK (NO TIME FOR PERFECTION!).THIS MENU SCROLLER IS "
 DC.B   "PROBABLY THE LAST WRITTEN SCROLL IN THIS WHOLE COMPILATION.SOME OF THE SCREENS IN HERE ARE VERY OUT OF DATE,BUT WHO CARES..I GUESS WE ARE ALL IN IT FOR THE FUN.IF THE GLORY COMES WITH IT..GREAT!.YOU MUST MOVE UP AND DOWN AND SELECT A "
 DC.B   "SCREEN WITH SPACE TO LOAD IT.. GO AHEAD!... THERE IS NOTHING WORTH READING IN HERE ANYWAY.HOW ABOUT THIS NICE LOOKING FONT.. DONE BY LORD OF CRYSTALIC   AS WELL AS EVERY SINGLE ONE OF THE LOGOS ABOVE.THE MUSIC AND LITTLE FONT IS "
 DC.B   "ALSO BY HIM.OVERSCAN,SCROLLCODE,LOGO SCROLLING,STARFIELD,WRITER,LOADERCODE,SOME SCREENS AND PUTTING THIS AMBITION DEMO TOGETHER BY:          FEAR OF CRYSTALIC...  NOT BAD FOR AN ARMY MAN HUH!.NOW LET ME SEND "
 DC.B   "YOU SOME GREETINGS FROM US IN CRYSTALIC.GREETINGS AND GOOD LUCK IN THE FUTURE TO: OB OF ANATOMICA (WE DID IT MAN!,YEEAH!).. THE FINAL SPACECODERS (HEY THERE MR.FLETCH,SEND US THE REST OF THE SCREENS.).. DAG OF ANA (WE WILL COME "
 DC.B   "AND VISIT YOU IN STOCKHOLM AND LOOK AT THE FALCON.).. BLUE NUN (PROJECT?).. WILDFIRE.. UNIQUE.. EMLING OF DEFLECT.. OSK OF HEMOROIDS (THE GUESTSCROLLER IS IN MIXTURE!).. THE SYNDICATE.. RIPPED OFF (HEY BILBO AND STICK,KEEP "
 DC.B   "GOING!).. ANIMAL MINE (VERY NICE MENUS!)... TAO OF A.C.F.. I.C.E (WHAT ARE YOU DOING NOW?).. ACE OF ANA (BEAT THIS MASSIVE BUNCH OF GFX ACE!).. OMEGA (ZEAL HAVE USED XOPE IN THEIR SCREEN,HAVE A LOOK GUYS.).. JEDI OF SECTOR ONE"
 DC.B   " (LORD USES MEGATIZER!,IT IS GOOD MAN!).. WOLF (HEY THERE GUSTAV DUDE!).. S.O.T.E (WEIRD PIC AT TCC LOBO!).. SILENTS (THANX FOR THE SCROLLTXT!)... KRUZ (SO YOU ARE TO GOOD TO ANSWER LETTERS HUH?).."
 DC.B   " TERRY (HEY CAC MEMBER!,THIS DEMO HAS NO MODULES,BUT WE NEED SOME MORE FROM YOU WHEN WE MAKE TRACK MANIA II!!)..  ROGZ (NICE TO EAT PIZZAZ TOGETHER AT THAT SLOW RESTURANT!).. POWERSONIC (CORNY SAYS HI!).. EAGLE (ARMY MAN!).."
 DC.B   "  AND NOW SOME HELLO TO GIRLS I HAVE DANCED,TOUCHED,GOT SLAPPED BY,LOOKED AT,SMILED AT,DREAMED ABOUT AND HATED.....HI FEMALES...I LOVE U ALL....  BY THE WAY OB!.YOU WROTE IN ..EXTREAM RAGE.. THAT I SHOULD GET A GIRL COZ"
 DC.B   " ONE BITCH HIT ME WHEN WE HAD THE NEW YEAR PARTY.I DONT HAVE ANY NOW,BUT I HAVE HAD SOME...AT LEAST I HAVE HAD SOME OB!.. MORE THAN U CAN SAY HUH? (HI! HI!).. DRINK MORE TEA AND THE GIRLS COME RUNNING!...           IF SOME OF "
 DC.B   "U OUT THERE WANT TO CONTACT CRYSTALIC,JUST WRITE TO CORNY.YOU CAN FIND HIS ADDRESS IN MIXTURE OR PROBABLY IN HIS OWN PART,CHROME CORNY TOO!.IF YOU WANT TO WRITE TO LORD YOU JUST WRITE LORD IN THE UPPER LEFT CORNER!...   "
 DC.B   "NOW A FAST WARP IN TIME TO A NIGHT OUT...              "
 dc.b "HOWDYU DFAN DET WAS A QUITY L;ONG TIME AGO AND IM TRYING TOP WRITE A PRETTY READAABLLY FOR U ALL ... YUPP!.. FERAR AND I (LOOORS*...WHEERE OUT ON A DISCKO FOR AWWWILE AND BOY DID WE SEE SOONET FOXEX ON TEGHW WAY   ..PUUUH!.."
 DC.B "  JIIIHAAAA EVRYBEDY....IN THER OVERMORNING WE WILL ALSO FEST ALL AEROND.....SSEE U ALL LEJTER HUH!"
 DC.B " ...WELL,THAT WAS A VERY SHORT TEXT THAT WE TRYED TO WRITE SOME WEEKS AGO,RIGHT AFTER CRYSTALIC HAD BEEN OUT ALL NIGHT.FEAR HAD HIS STE AT MY PLACE AND WE HAD BEEN WORKING HARD ALL DAY SO WE DECIDED TO TREAT OURSELVES... "
 DC.B " ..OF TO A PLACE CALLED 'PROJECT',THAT IS THE MOST POPULAR PLACE IN HUDIKSVALL (THE NEAREST TOWN FOR ME AND FEAR,CORNY LIVES THERE) WITH ONE DANCEFLOOR,SOME TABLES AND EAR KILLING BEATS..BUT MOST IMPORTENT,THERE IS ALWAYS "
 DC.B "PLENTY OF DRINKS AND BEER...AND GIRLS...ABE'S AS AN EX C.A.C MEMBER SAYS (HIYA BENGAN,BOUGHT AN ST AGAIN?)..ANYWAY!,FEAR HAD CALLED A CLASSMATE AND ASKED HIM TO BE THE DRIVER FOR FEAR AND ME,AS WE WANTED TO CRUISE A BIT "
 DC.B "BEFORE WE ENTERED 'PROJECT' AND OF COURSE WE NEEDED A RIDE HOME TOO.TO MAKE A LONG STORY SHORT I CAN SAY THAT AFTER WE HAD BEEN THERE FOR MANY HOURS,WE CRAWLED TO THE CAR AND DROVE HOME.I SAT WITH MY HEAD OUT THE WINDOW "
 DC.B "ALL THE WAY JUST TO FEEL THE WIND AND MABY IF SOME NICE BABE WENT BY,GIVE HER A WEEEEHHOOOO!.THE NEXT DAY MY LEFT EAR AND HOLE THE LEFT SIDE OF MY HEAD HURT LIKE HELL.I COULD HARDLY OPEN MY MOUTH TO SPEAK WITHOUT "
 DC.B "FEELING A TREMENDOUS PAIN IN MY EAR (ONE MEAN MEMBER OF C.A.C,WOULD PROBABLY SMILE NOW,HAPPY THAT I KEEP MY MOUTH SHUT FOR ONES!)..WELL,LATER I REMEMBERED THAT MY HEAD HAD BEEN OUT THE WINDOW ALL THE WAY HOME AND "
 DC.B "AS THE DRIVER DROVE FAST THE WIND,BLOWING ON ME FROM THE LEFT MUST BE THE REASON FOR THE PAIN..EEH?..YES,WELL THE RUNES AT THE BEGINNING WAS WRITTEN BY ME AFTER WE CAME TO MY PLACE AND FEAR TRYED TO PLAY 'TREX WARRIOR' "
 DC.B "STILL PRETTY DRUNK,I THINK HE ALSO TRYED 'NO SECOND PRIZE'...WITH NO LUCK (HAW HAW!).NOW TELL ME,WAS THIS NOT A VERY THRILLING STORY FOR U?...NAAAAH!,BUT A GOOD SCROLL FILLER THOUGH!....I THINK I WILL THROW SOME FAST "
 DC.B "GREETS NOW.GREETINGS TO THE FOLLOWING PEOPLE,CREWS:  OB (EXTREME RAGE WAS NICE,THE LOGO WAS VERY NICE INDEED!)..T.F.S OF G.R.C (THANX GUYS FOR YOUR SCREEN!)..OSK OF HEMOROIDS (I FOUND NO ONE TO BUY YOU'RE "
 DC.B "MODEM!)..EMLING....THE SYNDICATE (KEEP IT UP!)...RIPPED OFF (WE ARE VERY HONORED!)..ICE (YOU SPOKE TO FEAR ABOUT THE SPRITES IN THE 'CRYSTALIC GOES PARTY' SCREEN AT STENUNGSUND IN GOTHENBURG,ANYWAY! NICE ECSTASY!) "
 DC.B "TAO OF ACF (GOOD MUSIC MAN)...GUSTAV (I KNOW YOU READ THIS SO,NICE TO ALWAYS MEET YOU AT 'PROJECT'..HAVE YOU SENT ME THE DISCS YET?)..ZAAAGOOOO! (MANY MANY WEEKENDS AT 'PROJECT',LOST MORE MONEY LATELY?)..BLUE NUN "
 DC.B "(THAT TEQUILA WAS BAD HUH!,BUY ABSOLUTE PEACH INSTEAD!)..AND GREETS ALSO GO TO PEOPLE WHO ARE SUPPORTIVE AND DOESN'T WRITE CRAP ALL THE TIME.NOW IT IS TIME TO GET SOME TEA AND DRAW SOME GRAFIX AGAIN,AFTER THIS LITTLE "
 DC.B "BREAK...    "
 DC.B   "NOW I THINK IT IS TIME TO ALTER SILENS....SLAY YOU LATER DUDES!!         CRYSTALIC              CRYSTALIC       CRYSTALIC          CRYSTALIC        C.A.C         C.A.C        LORD             FEAR          CORNY         TERRY"
 DC.B   "            C R Y S T A L I C                       WRAP!                                                                                                                                                                     ",$FF

           