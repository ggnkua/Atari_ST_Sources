INIT:
	MOVE.L	USP,A0
	MOVE.L	A0,SAVEUSP
	MOVE.B	$fffffA07.W,OLD07
	MOVE.B	$fffffA09.W,OLD09
	MOVE.B	$fffffA13.W,OLD13
	MOVE.B	$fffffA15.W,OLD15
	MOVE.B	$fffffA19.W,OLD19
	MOVE.B	$fffffA1F.W,OLD1f
	MOVE.L	$134,OLD134
	MOVE.L	$70.W,OLDVBL

	CLR.B	$fffffA09.W
	CLR.B	$fffffA15.W
	MOVE.W	MODULE+$90,D0
	LEA	MFP_FREQS,a0
	MOVE.B	(A0,D0.W),$fffffA1F.W
	MOVE.B	#2,$fffffA19.W
	MOVE.B	#32,$fffffA07.W
	MOVE.B	#32,$fffffA13.W
	BCLR	#3,$fffffA17.W
	MOVE.L	#REPLAY_ROT+$8918,$134
	MOVE.L	#NEWVBL,$70.W
	RTS
RETINIT:	
	MOVE.B	OLD07,$fffffA07.W
	MOVE.B	OLD09,$fffffA09.W
	MOVE.B	OLD13,$fffffA13.W
	MOVE.B	OLD15,$fffffA15.W
	MOVE.B	OLD19,$fffffA19.W
	MOVE.B	OLD1f,$fffffA1f.W
	MOVE.L	OLD134,$134
	MOVE.L	OLDVBL,$70.W

	MOVE.L	SAVEUSP,A0
	MOVE.L	A0,USP
	RTS
*******************************
