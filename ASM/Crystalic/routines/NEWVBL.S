NEWVBL:
	MOVE.W	#1,WFNC
	RTE
*******************************
