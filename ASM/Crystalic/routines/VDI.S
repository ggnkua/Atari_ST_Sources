VDI:
	MOVE.L	#VDI_PB,D1
	MOVE.W	#$73,D0
	TRAP	#2
	RTS
*******************************
