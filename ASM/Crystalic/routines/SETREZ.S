SETLOWREZ:
	MOVE.B	#0,$FF8260
	RTS
SETMIDREZ:
	MOVE.B	#1,$FF8260
	RTS
*******************************
