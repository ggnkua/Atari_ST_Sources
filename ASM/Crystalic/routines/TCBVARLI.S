MFP_FREQS:	DC.B	24	
		DC.B	29
SAVEUSP:	DC.L	0
OLD07:		DC.B	0
OLD09:		DC.B	0
OLD13:		DC.B	0
OLD15:		DC.B	0
OLD19:		DC.B	0
OLD1f:		DC.B	0
OLD134:		DC.L	0
OLDVBL:		DC.L	0
*******************************
REPLAY_ROT:	INCBIN	A:\REPLAY\TRACKER.ROT
	EVEN
MODULE:		INCBIN 	A:\MODULES.MOD\COMPLICA.MOD
	EVEN
