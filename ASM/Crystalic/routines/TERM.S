TERM:
	CLR.W	-(SP)
	TRAP	#1
*******************************
