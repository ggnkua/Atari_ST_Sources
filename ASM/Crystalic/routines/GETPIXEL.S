* GET PIXEL!!  USES D0-D2/A0  *
* IN: X>D0 , Y>D1 UT: D2=COL  *
*******************************
GETPIXEL:
	CLR.W	D2
	MOVE.L	#$78000,A0
	MULS	#160,D1
	ADD.L	D1,A0
	MOVE.W	D0,D1
	AND.W	#$FFF0,D0
	DIVU.W	#2,D0
	ADD.W	D0,A0
	AND.W	#$000F,D1
	MOVE.W	#15,D0
	SUB.W	D1,D0
	CLR.W	D1
	BSET	D0,D1

	MOVE.W	(A0),D0
	AND.W	D1,D0
	CMP.W	D1,D0
	BNE	GNOBITPL1	
	ADDQ.W	#1,D2
GNOBITPL1:
	MOVE.W	2(A0),D0
	AND.W	D1,D0
	CMP.W	D1,D0
	BNE	GNOBITPL2	
	ADDQ.W	#2,D2
GNOBITPL2:
	MOVE.W	4(A0),D0
	AND.W	D1,D0
	CMP.W	D1,D0
	BNE	GNOBITPL3	
	ADDQ.W	#4,D2
GNOBITPL3:
	MOVE.W	6(A0),D0
	AND.W	D1,D0
	CMP.W	D1,D0
	BNE	GNOBITPL4	
	ADDQ.W	#8,D2
GNOBITPL4:
	RTS
*******************************
