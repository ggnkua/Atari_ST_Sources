VDI_PB:
	DC.L	CONTRL,INTIN,PTSIN,INTOUT,PTSOUT
CONTRL:	DS.W	12
INTIN:	DS.W	30
PTSIN:	DS.W	30
INTOUT:	DS.W	45
PTSOUT:	DS.W	12
*******************************
