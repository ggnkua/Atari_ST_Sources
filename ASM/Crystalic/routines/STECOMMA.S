SETSTEREGISTER:
	MOVE.W	#$7FF,$FF8924
	RTS
SETMASTERVOL:
	MOVE.W	#%10011000000+V * V ŽR MELLAN 0-40
	RTS
SETBASS:
	MOVE.W	#%10001000000+B * B ŽR MELLAN 0-12
	RTS
SETTREBLE:
	MOVE.W	#%10010000000+T * T ŽR MELLAN 0-12
	RTS
SETLEFTVOL:
	MOVE.W	#%10101000000+L * L ŽR MELLAN 0-20
	RTS
SETRIGHTVOL:
	MOVE.W	#%10100000000+R * R ŽR MELLAN 0-20
	RTS
*******************************
