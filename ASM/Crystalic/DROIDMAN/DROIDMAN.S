*****************************
*       DROIDMAN BY:        *
*           FEAR            *
*****************************
	CLR.L -(A7)
	MOVE.W #32,-(A7)
	TRAP #1
	ADDQ.L #6,A7
	MOVE.L D0,STACK

	MOVE.W	#0,-(SP)
	MOVE.L	#$30000,-(SP)
	MOVE.L	#$30000,-(SP)
	MOVE.W	#$5,-(SP)
	TRAP	#14
	ADD.L	#12,SP
	
	LEA	$30000,A0
	MOVE.W	#8000,D0
CLEARSCR:
	CLR.L	(A0)+
	DBF.W	D0,CLEARSCR

	JSR	SETPIC
	MOVE.W	#1,D7

	LEA STORAGE,A0
	MOVE.L $70.W,(A0)+
	MOVE.L $120.W,(A0)+
	MOVE.B $FFFFFA1B.W,(A0)+
	MOVE.B $FFFFFA21.W,(A0)+
	MOVE.B $FFFFFA07.W,(A0)+
	MOVE.B $FFFFFA09.W,(A0)+
	MOVE.B $FFFFFA13.W,(A0)+
	ADDQ.L #1,A0			MAKE ADDRESS EVEN

	MOVE.W #$2700,SR		STOP INTERRUPTS
	MOVE.L #CHANGE,$70.W		NEW VBL VECTOR
	MOVE.L #TIMER_B,$120.W		NEW TIMER B INTERRUPT HANDLER
	CLR.B $FFFFFA07.W		MFP RESET
	CLR.B $FFFFFA09.W
	ORI.B #1,$FFFFFA07.W		ENABLE TIMER B
	ORI.B #1,$FFFFFA13.W
	CLR.B $FFFFFA1B.W		STOP TIMER B
	MOVE.W #$2300,SR		ENABLE INTERRUPTS

	JSR SETMUS
	JSR SETVAR
	move.w	#0,charcnt
	move.w	#2,d6
WAIT:
	CMP.W	#1,WFNC
	BNE.S	WAIT
	MOVE.W	#0,WFNC

*	cmp.b	#$01,$fffc02
*	bne		tan

*	MOVE.W	#$707,$FF8240		
	jsr		scroll1
	jsr		scroll1
	MOVE.W	#$000,$FF8240		
	JSR		SETTEXT
*	MOVE.W	#$700,$FF8240	
	JSR		SINSCREEN
	
	DBF.W	D6,NEXT
	MOVE.W	#2,D6
	ADD.W	#1,TEXTPOS
	CMP.W	#195,TEXTPOS
	BNE		NEXT
	MOVE.W	#0,TEXTPOS
NEXT:
	add.w	#1,charcnt
	cmp.w	#16,charcnt
	bne		tan
	move.w	#0,charcnt
	jmp		newchar
tan:
	CMPI.B #57,$FFFFFC02.W	;SPACE BAR
	BNE WAIT

	MOVE.W #$2700,SR
	LEA STORAGE,A0
	MOVE.L (A0)+,$70.W
	MOVE.L (A0)+,$120.W
	MOVE.B (A0)+,$FFFFFA1B.W
	MOVE.B (A0)+,$FFFFFA21.W
	MOVE.B (A0)+,$FFFFFA07.W
	MOVE.B (A0)+,$FFFFFA09.W
	MOVE.B (A0)+,$FFFFFA13.W
	ADDQ.L #1,A0
	MOVE.W #$2300,SR

	JSR	ENDMUS 
	MOVE.L STACK,-(A7)
	MOVE.W #32,-(A7)
	TRAP #1
	ADDQ.L #6,A7
	CLR.L -(A7)
	TRAP #1

CHANGE:
	CLR.B $FFFFFA1B.W		STOP TIMER B
	MOVE.W PAL3,$FFFF8240.W		SET COLOUR 1 FOR TOP SCANLINE
	MOVE.W PAL1,$FFFF8242.W		SET COLOUR 1 FOR TOP SCANLINE
	MOVE.B #1,$FFFFFA21		OCCUR EVERY SCANLINE
	MOVE.L #PAL3+2,PAL2		SET PALETTE POINTER
	MOVE.L #PAL1+2,PAL		SET PALETTE POINTER
	MOVE.B #8,$FFFFFA1B.W		START TIMER B

	LEA	COLBUFF,A0
	LEA	PAL3+2,A1
	REPT	14
	MOVE.W	(A0)+,(A1)+
	ENDR

	LEA	COLBUFF,A0
	LEA	PAL3+24,A1
	REPT	14
	MOVE.W	(A0)+,(A1)+
	ENDR

	LEA	COLBUFF,A0
	LEA	PAL3+46,A1
	REPT	14
	MOVE.W	(A0)+,(A1)+
	ENDR

	LEA	COLBUFF,A0
	LEA	PAL3+70,A1
	REPT	14
	MOVE.W	(A0)+,(A1)+
	ENDR

	LEA	COLBUFF2,A0
	LEA	PAL3+326,A1
	REPT	14
	MOVE.W	(A0)+,(A1)+
	ENDR

	LEA	COLBUFF2,A0
	LEA	PAL3+348,A1
	REPT	14
	MOVE.W	(A0)+,(A1)+
	ENDR

	LEA	COLBUFF2,A0
	LEA	PAL3+370,A1
	REPT	14
	MOVE.W	(A0)+,(A1)+
	ENDR

	MOVE.W	COLBUFF2,COLSAVE2
	LEA	COLBUFF2+2,A0
	LEA	COLBUFF2,A1
	REPT	42
	MOVE.W	(A0)+,(A1)+
	ENDR
	MOVE.L	COLSAVE2,COLBUFF2+80

	DBF.W	D7,CONT
	MOVE.W	#1,D7

	MOVE.W	COLBUFF,COLSAVE
	LEA	COLBUFF+2,A0
	LEA	COLBUFF,A1
	REPT	42
	MOVE.W	(A0)+,(A1)+
	ENDR
	MOVE.L	COLSAVE,COLBUFF+80

CONT:	
	MOVEQ.W #0,D0
	MOVEQ.W #0,D1
	MOVEQ.W #0,D2
	MOVE.B #8,$FFFF8800.W  	;CHANNEL A
	MOVE.B $FFFF8800.W,D0
	MOVE.B #9,$FFFF8800.W   ;CHANNEL B
	MOVE.B $FFFF8800.W,D1
	MOVE.B #10,$FFFF8800.W  ;CHANNEL C
	MOVE.B $FFFF8800.W,D2
	BTST #4,D0              ;IS CHANNEL A AN ENVELOPE?
	BEQ .L1
	MOVE.B #10,D0           ;SET VOLUME IF IT IS
.L1	BTST #4,D1    		;IS CHANNEL B AN ENVELOPE?
       	BEQ .L2
	MOVE.B #10,D1
.L2	BTST #4,D2		;IS CHANNEL C AN ENVELOPE?
	BEQ .L3
	MOVE.B #10,D2
.L3	ADD.B D0,D0		;WORD ALIGNMENT
	ADD.B D1,D1
	ADD.B D2,D2

	LEA		$30000+32+160*103+24,A0
	MOVE.W	#31,D3

CLLOOP1:
	MOVE.B	#$00,(A0)
	SUB.L	#160,A0
	DBF.W	D3,CLLOOP1	

	LEA		$30000+32+160*82+40,A0
	MOVE.W	#31,D3

CLLOOP2:
	MOVE.W	#$0000,(A0)
	SUB.L	#160,A0
	DBF.W	D3,CLLOOP2	

	LEA		$30000+32+160*103+64,A0
	MOVE.W	#31,D3

CLLOOP3:
	MOVE.B	#$00,(A0)
	SUB.L	#160,A0
	DBF.W	D3,CLLOOP3	

	MOVE.W	D0,D3

	LEA		$30000+32+160*103+24,A0

LOOP:
	MOVE.B	#$FF,(A0)
	SUB.L	#160,A0
	DBF.W	D3,LOOP	

	MOVE.W	D2,D3


	LEA		$30000+32+160*82+40,A0

LOOP2:
	MOVE.W	#$00FF,(A0)
	SUB.L	#160,A0
	DBF.W	D3,LOOP2	

	MOVE.W	D1,D3


	LEA		$30000+32+160*103+64,A0

LOOP3:
	MOVE.B	#$FF,(A0)
	SUB.L	#160,A0
	DBF.W	D3,LOOP3	
	MOVE.W	#1,WFNC
	RTE
TIMER_B
	MOVE.L A0,-(A7)
	MOVEA.L PAL2,A0			ADDRESS OF NEXT COLOUR IN TABLE
	MOVE.W (A0)+,$FFFF8240.W	SET COLOUR 1 AND INCREMENT POINTER 
	MOVE.L A0,PAL2			REPLACE NEW POINTER ADDRESS
	MOVEA.L PAL,A0			ADDRESS OF NEXT COLOUR IN TABLE
	MOVE.W (A0)+,$FFFF8242.W	SET COLOUR 1 AND INCREMENT POINTER 
	MOVE.L A0,PAL			REPLACE NEW POINTER ADDRESS
	MOVEA.L (A7)+,A0
	BCLR #0,$FFFFFA0F.W		ACKNOWLEDGE
	RTE				BUGGER OFF
SETPIC:
	LEA	BILD+2,A0
	LEA	$FF8240,A1
	REPT	8
	MOVE.L	(A0)+,(A1)+
	ENDR
	LEA	$30000,A1
	MOVE.L	#8000,D0
SETPICL:
	MOVE.L	(A0)+,(A1)+
	DBF.W	D0,SETPICL
	RTS
scroll1:
	jsr		showscr1
	lea		$30000+160*163,a0
	lea		$76000,a1
	move.l	#37,d0
scrloop1:

	roxl.w	152(a0)
	roxl.w	144(a0)
	roxl.w	136(a0)
	roxl.w	128(a0)
	roxl.w	120(a0)
	roxl.w	112(a0)
	roxl.w	104(a0)
	roxl.w	96(a0)
	roxl.w	88(a0)
	roxl.w	80(a0)
	roxl.w	72(a0)
	roxl.w	64(a0)
	roxl.w	56(a0)
	roxl.w	48(a0)
	roxl.w	40(a0)
	roxl.w	32(a0)
	roxl.w	24(a0)
	roxl.w	16(a0)    * tre extra
	roxl.w	8(a0)
*	roxl.w	(a0)

	roxl.w	8(a1)
	roxl.w	(a1)

	add.l	#160,a0
	add.l	#160,a1
	dbf.w	d0,scrloop1

	lea		$30000+160*163,a0
	move.w	#37,d0
clloop1:
	move.w	#0,152(a0)
	add.l	#160,a0
	dbf.w	d0,clloop1

	rts
showscr1:
	lea		$76000,a0
	lea		$30000+160*163,a1
	move.w	#37,d0
showloop1:
*	or.w	#$0fff,152(a1)
*	or.w	#$ff00,(a1)
	move.w	(a0),152(a1)
	add.l	#160,a0
	add.l	#160,a1
	dbf.w	d0,showloop1

	rts
copyfont1:
	lea		$76000,a1
	rept	37
	move.w	(a0),(a1)
	move.w	8(a0),8(a1)
	add.l	#160,a0
	add.l	#160,a1
	endr

	jmp		WAIT
newchar:
	lea		scrtext,a0
	add.l	scrpos,a0
	move.b	(a0),d0
	ADD.L	#1,scrpos
	cmp.b	#$ff,d0
	bne		cont
	move.l	#0,scrpos
	lea		scrtext,a0
	move.b	(a0),d0
	ADD.L	#1,scrpos
cont:
	cmp.b	#65,d0
	bne		b
	lea		font+34,a0
	jmp		copyfont1
b:
	cmp.b	#66,d0
	bne		c
	lea		font+34+16,a0
	jmp		copyfont1
c:
	cmp.b	#67,d0
	bne		d
	lea		font+34+32,a0
	jmp		copyfont1
d:
	cmp.b	#68,d0
	bne		e
	lea		font+34+48,a0
	jmp		copyfont1
e:
	cmp.b	#69,d0
	bne		f
	lea		font+34+64,a0
	jmp		copyfont1
f:
	cmp.b	#70,d0
	bne		g
	lea		font+34+80,a0
	jmp		copyfont1
g:
	cmp.b	#71,d0
	bne		h
	lea		font+34+96,a0
	jmp		copyfont1
h:
	cmp.b	#72,d0
	bne		i
	lea		font+34+112,a0
	jmp		copyfont1
i:
	cmp.b	#73,d0
	bne		j
	lea		font+34+128,a0
	jmp		copyfont1
j:
	cmp.b	#74,d0
	bne		k
	lea		font+34+144,a0
	jmp		copyfont1
k:
	cmp.b	#75,d0
	bne		l
	lea		font+34+160*37,a0
	jmp		copyfont1
l:
	cmp.b	#76,d0
	bne		m
	lea		font+34+160*37+16,a0
	jmp		copyfont1
m:
	cmp.b	#77,d0
	bne		n
	lea		font+34+160*37+32,a0
	jmp		copyfont1
n:
	cmp.b	#78,d0
	bne		o
	lea		font+34+160*37+48,a0
	jmp		copyfont1
o:
	cmp.b	#79,d0
	bne		p
	lea		font+34+160*37+64,a0
	jmp		copyfont1
p:
	cmp.b	#80,d0
	bne		q
	lea		font+34+160*37+80,a0
	jmp		copyfont1
q:
	cmp.b	#81,d0
	bne		r
	lea		font+34+160*37+96,a0
	jmp		copyfont1
r:
	cmp.b	#82,d0
	bne		s
	lea		font+34+160*37+112,a0
	jmp		copyfont1
s:
	cmp.b	#83,d0
	bne		t
	lea		font+34+160*37+128,a0
	jmp		copyfont1
t:
	cmp.b	#84,d0
	bne		u
	lea		font+34+160*37+144,a0
	jmp		copyfont1
u:
	cmp.b	#85,d0
	bne		v
	lea		font+34+160*74,a0
	jmp		copyfont1
v:
	cmp.b	#86,d0
	bne		w
	lea		font+34+160*74+16,a0
	jmp		copyfont1
w:
	cmp.b	#87,d0
	bne		x
	lea		font+34+160*74+32,a0
	jmp		copyfont1
x:
	cmp.b	#88,d0
	bne		y
	lea		font+34+160*74+48,a0
	jmp		copyfont1
y:
	cmp.b	#89,d0
	bne		z
	lea		font+34+160*74+64,a0
	jmp		copyfont1
z:
	cmp.b	#90,d0
	bne		kom
	lea		font+34+160*74+80,a0
	jmp		copyfont1
kom:
	cmp.b	#44,d0
	bne		pun
	lea		font+34+160*111+112,a0
	jmp		copyfont1
pun:
	cmp.b	#46,d0
	bne		vbage
	lea		font+34+160*111+96,a0
	jmp		copyfont1
vbage:
	cmp.b	#40,d0
	bne		hbage
	lea		font+34+160*111+128,a0
	jmp		copyfont1
hbage:
	cmp.b	#41,d0
	bne		utrop
	lea		font+34+160*111+144,a0
	jmp		copyfont1
utrop:
	cmp.b	#33,d0
	bne		kolon
	lea		font+34+160*148+32,a0
	jmp		copyfont1
kolon:
	cmp.b	#58,d0
	bne		sp
	lea		font+34+160*148,a0
	jmp		copyfont1
sp:
	cmp.b	#32,d0
	bne		b
	lea		font+34+160*148+144,a0
	jmp		copyfont1
newvbl:	movem.l d0-a6,-(sp)			save registers
	bsr (music+8)				call playback
	movem.l (sp)+,d0-a6			restore registers
	MOVE.L	OLD,-(SP)	
	rts					call old vbl
SETMUS:	
	MOVE.L	$70,OLD
	moveq  	#1,d0				music #1
	bsr    	music				call init
	move.l 	#newvbl,$70			install new vbl
	rts
ENDMUS:
	MOVE.L #$700FF00,$FFFF8800.W
	MOVE.L #$8000000,$FFFF8800.W
	MOVE.L #$9000000,$FFFF8800.W
	MOVE.L #$A000000,$FFFF8800.W
	RTS
SINSCREEN:
	MOVE.L	SCRYPTR,A0
	CLR.L	D0	
	MOVE.W 	(A0)+,D0
	CMP.W	#-1,D0
	BNE		NOEND

	LEA		SCRYTAB,A0
	MOVE.W	(A0)+,D0
NOEND: 
	MOVE.L 	A0,SCRYPTR

	LEA		FIRSTC,A0
	LEA		FIRSTC,A3
	LEA		$30000,A1
	LEA		$30000+112,A2
	MULS	#160,D0
	ADD.L	D0,A1
	ADD.L	D0,A2
	SUB.L	#60*160,A1
	SUB.L	#60*160,A2
	MOVE.W	#29,D0
C1LOOP:
	REPT	4
	MOVE.L	(A3)+,(A2)+
	MOVE.L	(A0)+,(A1)+
	ENDR
	ADD.L	#144,A1
	ADD.L	#144,A2
	DBF.W	D0,C1LOOP	

	MOVE.L	SCRYPTR2,A0
	CLR.L	D0	
	MOVE.W 	(A0)+,D0
	CMP.W	#-1,D0
	BNE		NOEND2

	LEA		SCRYTAB,A0
	MOVE.W	(A0)+,D0
NOEND2: 
	MOVE.L 	A0,SCRYPTR2

	LEA		FIRSTA,A0
	LEA		FIRSTA,A3
	LEA		$30000+16,A1
	LEA		$30000+128,A2
	MULS	#160,D0
	ADD.L	D0,A1
	ADD.L	D0,A2
	SUB.L	#60*160,A1
	SUB.L	#60*160,A2
	MOVE.W	#29,D0
A1LOOP:
	REPT	4
	MOVE.L	(A3)+,(A2)+
	MOVE.L	(A0)+,(A1)+
	ENDR
	ADD.L	#144,A1
	ADD.L	#144,A2
	DBF.W	D0,A1LOOP	

	MOVE.L	SCRYPTR3,A0
	CLR.L	D0	
	MOVE.W 	(A0)+,D0
	CMP.W	#-1,D0
	BNE		NOEND3

	LEA		SCRYTAB,A0
	MOVE.W	(A0)+,D0
NOEND3: 
	MOVE.L 	A0,SCRYPTR3

	LEA		SECONDC,A0
	LEA		SECONDC,A3
	LEA		$30000+32,A1
	LEA		$30000+144,A2
	MULS	#160,D0
	ADD.L	D0,A1
	ADD.L	D0,A2
	SUB.L	#60*160,A1
	SUB.L	#60*160,A2
	MOVE.W	#29,D0
C2LOOP:
	REPT	4
	MOVE.L	(A3)+,(A2)+
	MOVE.L	(A0)+,(A1)+
	ENDR
	ADD.L	#144,A1
	ADD.L	#144,A2
	DBF.W	D0,C2LOOP	
	RTS
SETTEXT:
	MOVE.L	#$30000+160*55,A0
	MOVE.L	#15,D0
CLLOOP4:
	REPT	18
	CLR.L	(A0)+
	ENDR
	ADD.L	#88,A0
	DBF.W	D0,CLLOOP4 
	
	LEA		BILD2+34+160*5,A0
	MOVE.W	TEXTPOS,D0
	MULS	#160,D0
	ADD.L	D0,A0
	MOVE.L	#$30000+160*55,A1
	MOVE.L	#14,D0
SETTEXTLOOP:
	REPT	18
	MOVE.L	(A0)+,D1
	OR.L	D1,(A1)+
	ENDR
	ADD.L	#88,A0
	ADD.L	#88,A1
	DBF.W	D0,SETTEXTLOOP
	RTS
SETVAR:
	LEA		SCRYTAB,A0
	MOVE.L	A0,SCRYPTR
	LEA		SCRYTAB+16,A0
	MOVE.L	A0,SCRYPTR2
	LEA		SCRYTAB+32,A0
	MOVE.L	A0,SCRYPTR3

	MOVE.W	#0,TEXTPOS
	RTS
STORAGE:
	DS.B 18
	DS.L 63
STACK:	
	DS.L 	1
WFNC:
	DS.W	1
OLDVBL:
	DS.L	1
OLD:
	DS.L	1
scrpos:
	ds.l	1
charcnt:
	ds.w	1
WAITCRNT:
	DC.W	0
YPOS:
	DS.W	1
TEXTPOS:
	DS.W	1
SCRYPTR:
	DS.L	1
SCRYPTR2:
	DS.L	1
SCRYPTR3:
	DS.L	1
COLSAVE:
	DC.W	0
COLSAVE2:
	DC.W	0
COLBUFF:
	DC.W	$101,$202,$303,$404,$505,$606,$707
	DC.W	$707,$606,$505,$404,$303,$202,$101
	DC.W	$000,$000,$000,$000,$000,$000,$000
	DC.W	$000,$000,$000,$000,$000,$000,$000
	DC.W	$000,$000,$000,$000,$000,$000,$000
	DC.W	$000,$000,$000,$000,$000,$000,$000
COLBUFF2:
	DC.W	$001,$002,$003,$004,$005,$006,$007
	DC.W	$007,$006,$005,$004,$003,$002,$001
	DC.W	$000,$000,$000,$000,$000,$000,$000
	DC.W	$000,$000,$000,$000,$000,$000,$000
	DC.W	$000,$000,$000,$000,$000,$000,$000
	DC.W	$000,$000,$000,$000,$000,$000,$000
PAL:
	DC.L PAL1+2
PAL1:
	DC.W $000,$000,$700,$700,$700,$700,$711,$711,$711,$711
	DC.W $722,$722,$722,$722,$733,$733,$733,$733,$744,$744
	DC.W $744,$744,$755,$755,$766,$777,$777,$777,$777,$676
	DC.W $676,$575,$575,$474,$474,$373,$373,$272,$272,$171
	DC.W $171,$070,$070,$060,$060,$050,$050,$040,$040,$744
	DC.W $777,$776,$775,$774,$773,$772,$771,$770,$760,$750
	DC.W $740,$730,$720,$710,$700,$600,$600,$600,$700,$710
	DC.W $720,$730,$740,$750,$760,$770,$771,$772,$773,$774
	DC.W $775,$776,$777,$776,$775,$774,$773,$772,$771,$770
	DC.W $760,$750,$740,$730,$720,$710,$700,$600,$600,$600
	DC.W $600,$600,$600,$600,$700,$710,$720,$730,$740,$750
	DC.W $760,$770,$771,$772,$773,$774,$775,$776,$777,$776
	DC.W $775,$774,$773,$772,$771,$770,$670,$570,$470,$370
	DC.W $270,$170,$070,$060,$060,$060,$060,$060,$060,$060
	DC.W $003,$004,$005,$006,$007,$007,$006,$005,$004,$003
	DC.W $333,$444,$555,$666,$777,$777,$666,$555,$444,$333
	DC.W $030,$040,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $0,$0,$0,$0,$0,$0,$0,$0,$0,$0
	DC.W $0,$0,$0,$0,$0,$0,$0,$0,$0,$0
	DC.W $0,$0,$0,$0,$0,$0,$0,$0,$0,$0
PAL2:
	DC.L PAL3+2
PAL3:
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	DC.W $000
FIRSTC:
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$07FF,$07FF,$0000,$0000,$FFE0,$FFE0,$0000
		dc.w	$03FF,$1C00,$1C00,$0000,$FFC0,$0038,$0038,$0000
		dc.w	$07FF,$1800,$1800,$0000,$FFE0,$0018,$0018,$0000
		dc.w	$0FFF,$3000,$3000,$0000,$FFF0,$000C,$000C,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFE,$2001,$2001,$0000,$EFF8,$1004,$1004,$0000
		dc.w	$1FFC,$2002,$2002,$0000,$47F8,$A804,$A804,$0000
		dc.w	$1FF8,$2004,$2004,$0000,$03F0,$440C,$440C,$0000
		dc.w	$1F90,$2068,$2068,$0000,$0000,$03F8,$03F8,$0000
		dc.w	$1A00,$2591,$2591,$0000,$0000,$1000,$1000,$0000
		dc.w	$1001,$2A02,$2A02,$0000,$1000,$AC00,$AC00,$0000
		dc.w	$1A03,$2584,$2584,$0000,$BC00,$43F8,$43F8,$0000
		dc.w	$1F87,$2068,$2068,$0000,$FFE0,$001C,$001C,$0000
		dc.w	$1FEF,$2010,$2010,$0000,$FFF0,$000C,$000C,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFF8,$0004,$0004,$0000
		dc.w	$0FFF,$3000,$3000,$0000,$FFF0,$000C,$000C,$0000
		dc.w	$07FF,$1800,$1800,$0000,$FFE0,$0018,$0018,$0000
		dc.w	$03FF,$1C00,$1C00,$0000,$FFC0,$0038,$0038,$0000
		dc.w	$0000,$07FF,$07FF,$0000,$0000,$FFE0,$FFE0,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
FIRSTA:
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0FFF,$0FFF,$0000,$0000,$FFC0,$FFC0,$0000
		dc.w	$0FFF,$3000,$3000,$0000,$FFC0,$0030,$0030,$0000
		dc.w	$1FFF,$2000,$2000,$0000,$FFE0,$0010,$0010,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFA,$4005,$4005,$0000,$F7F0,$0808,$0808,$0000
		dc.w	$3FB0,$404A,$404A,$0000,$22F0,$D508,$D508,$0000
		dc.w	$3D00,$42B0,$42B0,$0000,$0050,$22A8,$22A8,$0000
		dc.w	$3400,$4904,$4904,$0000,$0000,$0858,$0858,$0000
		dc.w	$2004,$564B,$564B,$0000,$0850,$55A8,$55A8,$0000
		dc.w	$364C,$49B2,$49B2,$0000,$5DF0,$A208,$A208,$0000
		dc.w	$3FF8,$4005,$4005,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FF0,$400B,$400B,$0000,$7FF0,$8008,$8008,$0000
		dc.w	$3FF8,$4004,$4004,$0000,$3FF0,$4008,$4008,$0000
		dc.w	$3FFC,$4002,$4002,$0000,$1FF0,$2008,$2008,$0000
		dc.w	$3FF8,$4004,$4004,$0000,$3FF0,$4008,$4008,$0000
		dc.w	$3FF0,$4008,$4008,$0000,$7FF0,$8008,$8008,$0000
		dc.w	$3FE0,$4011,$4011,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FF0,$4008,$4008,$0000,$7FF0,$8008,$8008,$0000
		dc.w	$3FF8,$4004,$4004,$0000,$3FF0,$4008,$4008,$0000
		dc.w	$3FFC,$4002,$4002,$0000,$1FF0,$2008,$2008,$0000
		dc.w	$3FF8,$4004,$4004,$0000,$1FF0,$2008,$2008,$0000
		dc.w	$3FF0,$4008,$4008,$0000,$3FF0,$4008,$4008,$0000
		dc.w	$1FE0,$2010,$2010,$0000,$3FE0,$4010,$4010,$0000
		dc.w	$0FC0,$3030,$3030,$0000,$1FC0,$6030,$6030,$0000
		dc.w	$0000,$0FE0,$0FE0,$0000,$0000,$3FC0,$3FC0,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
SECONDC:
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0FFF,$0FFF,$0000,$0000,$FFC0,$FFC0,$0000
		dc.w	$07FF,$3800,$3800,$0000,$FF80,$0070,$0070,$0000
		dc.w	$0FFF,$3000,$3000,$0000,$FFC0,$0030,$0030,$0000
		dc.w	$1FFF,$6000,$6000,$0000,$FFE0,$0018,$0018,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FEE,$4011,$4011,$0000,$FFE0,$0018,$0018,$0000
		dc.w	$3FC4,$402A,$402A,$0000,$7000,$8FF0,$8FF0,$0000
		dc.w	$3E80,$4144,$4144,$0000,$2000,$5000,$5000,$0000
		dc.w	$3C00,$4280,$4280,$0000,$0000,$2000,$2000,$0000
		dc.w	$3E80,$4151,$4151,$0000,$0000,$07F0,$07F0,$0000
		dc.w	$3FD1,$402A,$402A,$0000,$07C0,$8838,$8838,$0000
		dc.w	$3FFB,$4004,$4004,$0000,$8FE0,$5018,$5018,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$DFF0,$2008,$2008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$3FFF,$4000,$4000,$0000,$FFF0,$0008,$0008,$0000
		dc.w	$1FFF,$6000,$6000,$0000,$FFE0,$0018,$0018,$0000
		dc.w	$0FFF,$3000,$3000,$0000,$FFC0,$0030,$0030,$0000
		dc.w	$07FF,$3800,$3800,$0000,$FF80,$0070,$0070,$0000
		dc.w	$0000,$0FFF,$0FFF,$0000,$0000,$FFC0,$FFC0,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
music:
	incbin	A:\DROIDMAN\MAX_15.MUS
font:
	incbin	A:\DROIDMAN\FONTSET1.PI1
BILD:
	INCBIN	A:\DROIDMAN\DROIDMAN.PI1
SCRYTAB:
	INCLUDE	A:\DROIDMAN\SCROLLY.DAT
scrtext:
	dc.b	'    YEEAH!,AND WAUUU...THE GUYS IN BLACK YET AGAIN FILLS THE SCREEN WITH THEIR STUFF....THIS SCREEN WAS FINISHED AT T.R.R HEADQUARTERS SOMEWHERE IN SWEDEN...THE GUYS IN TRR ARE ALL PLAYING WITH THEIR DIGITIZER,AND ACTING LIKE SMALL'
	DC.B    ' CHILDREN AT THEIR FIRST DAY IN SCHOOL!     ..WELL,IF YOU WANT CREDITS THEN READ THE MINI SCROLLER IN THE UPPER LEFT CORNER..COZ HERE COMES THE GREETINGS:  ONIXON OF AWESOME (FOR ALL THE GREAT MUSAX HE SENT US!,REALLY NEW STUFF TOO!)'
	DC.B    ' ..DARK SHADOW FROM THE INVIZIBLES (WHERE IS THE DEMOS!)..PAULSSON (HOPE YOU DID NOT FLUNK THE BIOLOGI TEST!)..ME SO CORNY OF T.R.R (STOP DIGITIZING MY UGLY FRACTURE FACE!...FEAR (VEM SKET..)....AND NOW SOME BIG HELLOS TO SOME BIG'
	DC.B    ' GROUPS AROUND THE WORLD: LOST BOYS (MY PERSONAL FAVORITE GROUP!)...TCB (WHY THE HELL DID YOURE SCREEN IN LOST BOYS..CRIKEY WHAT A SCORCHER..DEMO HAVE TO BE THE HIDDEN ONE)..FLEXICHRON (ARE YOU LIVING OR ARE YOU LAME..)....ENOUGH...'
	DC.B    '   LETS LISTEN TO THIS GREAT MUSIC AND MABY ENJOY THE GRAPHICS AND CODING FOR AWILE......UNTIL I DECIDE TO PUT MY EVIL FINGERS ON THE KEYBOARD AND WRITE...W  R  A  P!...SEE YA DUDES...                                                ',$FF
	
	even
BILD2:
	INCBIN	A:\DROIDMAN\TEXT.PI1                                             