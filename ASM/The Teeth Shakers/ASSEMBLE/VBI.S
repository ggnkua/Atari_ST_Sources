

	
			HALLO!
	 TO JA MARCHEW Z THE TEETH SHAKERS
	 TO CO MAM CI DZIS DO POWIEDZENIA TO:
	 JAK ZAINSTALOWAC NAJPROSTRZE PRZERWANIE  CZYLI
	
	         INICJACJA PRZERWANIA VBL
                 ========================

	UFFFF! MAMY PECHA WLASNIE GDZIES PODZIALEM TEN ARTYKUL...
 DLATEGO TEZ JESTEM ZMUSZONY NAPISAC GO JESZCZE RAZ....
        CHOLERA! NIE CHCE MI SIE ZNOWU KLEPAC TEJ KLAWIATURY...
 DOBRA! VBL TO NAJPROSTRZE DO REALIZACJI PRZERWANIE
        (O ILE PAMIETAM TO IPL 4) PRZERWANIE TO NIE JEST MASKOWALNE
 (ALE BZDURY) JEST NIEMASKOWALNE TO ZNACZY (TZ.) ZE NIE MUSIMY
 BAWIC SIE MASKA REJESTRU STATUSOWEGO....
        ABY ZAINICJOWC PRZERWANIE TRZEBA PO PRSTU  WPISAC ADRES 
 SWOJEJ PROCEDURY POD VEKTOR PRZERWAN ($70)
        CZESTOTLIWOSC TEGO PRZERWANIA W PROSTEJ LINI (???) ZALEZY
 OD PODLACZONEGO MONITORA (50/60HZ LUB 70HZ-MONO) POJAWIA SIE CO JEDNO 
 ZOBRAZOWANIE EKRANU. JEST TO SUPER PRZERWANIE DLA OPERACJI GRAFICZNYCH
        O VBL MOZNA NAPISAC JESZCZE TROCHE RZECZY TYLKO,ZE NIE 
 BEDA ONE CI RACZEJ POTRZEBNE (JAK CHCESZ COS WIECEJ TO NAPISZ DO MNIE!)
 I W TYM ARTYKULE OGRANICZYMY SIE DO PRZEDSTAWIENIA NAJBARDZIEJ 
 ORDYNARNEGO (ALE SKUTECZNEGO) SPOSOBU INICJACJI TEGO PRZERWANIA

	CZYLI 
			
		3--------------2-----------1------------0
				

START:

* INICJUJEMY SUPERVISOR

	CLR.L	-(SP)
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADD.L	#6,SP

*CZYSCIMY EKRAN

	MOVE.L $44E,A0
*W $44E JEST ADRES EKRANU
*I PETLA
	MOVE.L #40*200,D0
CZYSCIMY_EKRAN
	MOVE.L #0,(A0)+
	DBF D0,CZYSCIMY_EKRAN

*W TYM MIEJSCU ZAPAMIETAMY ADRES STAREGO PRZERWANIA VBL
*JEST ON POD $70 I ZAPAMIETAMY GO W 'OLD70'

	MOVE.L	$70.W,OLD70

*TU PODKLADAMY SWOJA PROCEDURE POD VEKTOR VBL'S

	MOVE.L	#VBI,$70.W

*STARY NUMER - CZEKAMY NA ESC

ESCAPE	CMP.B	#1,$FFFC02
	BNE	ESCAPE

*ZWRACAMY ADRES STEREGO (ZAPAMIETANEGO) VBL
 
	MOVE.L	OLD70,$70.W
	
*JAKIES SENSOWNE KOLORKI

	MOVE.W #000,$FF8246
	MOVE.W #$777,$FF8240

*GOOD BYE WICKED WORLD......
	
	CLR.L	-(SP)
	TRAP	#1

*VBI TO DUMNA NAZWA NASZEJ PROCEDURY VBL'A
* I PEWNIE JEST TO SKROT OD
* VBL INTERRUPS

VBI

*MUSIMY ZAPAMIETAC WSZYSTKIE REJESTRY Z KTORYCH
*BEDZIEMY KOZYSTAC (CO NINIEJSZYM CZYNIE...)

	MOVEM.L	D0-D7/A0-A6,-(SP)

*I TU ROBIMY SWOJA PROCEDURE
*JA UPARLEM SIE NA PRZEDSTAWIENIU CI NAJPROSTRZEGO SPOSOBU
*UZYSKANIA BARDZO KOLOROWYCH PASKOW (BEZ UZYCIA FLAMASTRA) NA EKRANIE
*Z MIEJSCA ZAZNACZAM,ZE ZNAM KILKA BARDZIEJ ELEGANCKICH 
*SPOSOBOW NA UZYSKANIE PODOBNEGO EFEKTU ALE TEN JEST NAJPROSTRZY
*I OD NIEGO ZACZYNALEM.....

*ADRES TABELI KOLOROW DO A1

	MOVE.L #KOLORY,A1

*PETLA (ILE PASKOW) 240 OBROTOW (PASKOW)

	MOVE.L #240,D1
LOOP

*WRZUC DO REJESTRU KOLORU TLA KOLEJNE DANE Z TABLICY

	MOVE.W (A1)+,$FF8240

*SKOCZ GDZIES PO PAUZE ABY TROCHE VBL PRZESZLO TAK 
*GDZIES W OKOLICE NASTEPNYCH LINI
*PO PROSTU TRACIMY CZAS ABY ZOBRAZOWALA SIE LINIA
*TA PAUZA JEST 'NA OKO' NIE JEST DOKLADNIE ZMIERZONA
*TAK,ZE NIE TRWA DOKLADNIE TYLE ILE OBRAZUJE SIE JEDNA LINIA

	JSR PAUSE

	DBF D1,LOOP

*ZWRACAMY REJESTRY
	MOVEM.L	(SP)+,D0-D7/A0-A6
	RTE

*TU TA SLYNNA WARIACKA PAUZA NA OKO...

PAUSE
	MOVE.L #24,D2
LOOPM
	NOP
	NOP
	DBF D2,LOOPM
	RTS

*TABLICA KOLOROW

KOLORY
  DC.W	$f00,$f80,$f10,$f90,$f20,$fa0,$f30,$fb0,$f40,$fc0,$f50
  DC.W  $FD0,$FE0,$F70,$FF0,$EF0,$DF0,$CF0,$AF0,$9F0,$8F0,$0F8
  DC.W  $0F9,$0FA,$0FB,$0FC,$0FD,$0FE,$0FF
  DC.W  $0EF,$0DF,$0CF,$0BF,$0AF,$09F,$08F,$80F
  DC.W  $90F,$A0F,$B0F,$C0F,$D0F,$E0F,$F0F
  DC.W  $F0F,$F07,$F0E,$F06,$F0D,$F05,$F0C,$F04,$F0B,$F03,$F0A,$F01,$F08  
*
  DC.W	$f00,$f80,$f10,$f90,$f20,$fa0,$f30,$fb0,$f40,$fc0,$f50
  DC.W  $FD0,$FE0,$F70,$FF0,$EF0,$DF0,$CF0,$AF0,$9F0,$8F0,$0F8
  DC.W  $0F9,$0FA,$0FB,$0FC,$0FD,$0FE,$0FF
  DC.W  $0EF,$0DF,$0CF,$0BF,$0AF,$09F,$08F,$80F
  DC.W  $90F,$A0F,$B0F,$C0F,$D0F,$E0F,$F0F
  DC.W  $F0F,$F07,$F0E,$F06,$F0D,$F05,$F0C,$F04,$F0B,$F03,$F0A,$F01,$F08  
*
  DC.W	$f00,$f80,$f10,$f90,$f20,$fa0,$f30,$fb0,$f40,$fc0,$f50
  DC.W  $FD0,$FE0,$F70,$FF0,$EF0,$DF0,$CF0,$AF0,$9F0,$8F0,$0F8
  DC.W  $0F9,$0FA,$0FB,$0FC,$0FD,$0FE,$0FF
  DC.W  $0EF,$0DF,$0CF,$0BF,$0AF,$09F,$08F,$80F
  DC.W  $90F,$A0F,$B0F,$C0F,$D0F,$E0F,$F0F
  DC.W  $F0F,$F07,$F0E,$F06,$F0D,$F05,$F0C,$F04,$F0B,$F03,$F0A,$F01,$F08  
*
  DC.W	$f00,$f80,$f10,$f90,$f20,$fa0,$f30,$fb0,$f40,$fc0,$f50
  DC.W  $FD0,$FE0,$F70,$FF0,$EF0,$DF0,$CF0,$AF0,$9F0,$8F0,$0F8
  DC.W  $0F9,$0FA,$0FB,$0FC,$0FD,$0FE,$0FF
  DC.W  $0EF,$0DF,$0CF,$0BF,$0AF,$09F,$08F,$80F
  DC.W  $90F,$A0F,$B0F,$C0F,$D0F,$E0F,$F0F
  DC.W  $F0F,$F07,$F0E,$F06,$F0D,$F05,$F0C,$F04,$F0B,$F03,$F0A,$F01,$F08  
*
  DC.W	$f00,$f80,$f10,$f90,$f20,$fa0,$f30,$fb0,$f40,$fc0,$f50
  DC.W  $FD0,$FE0,$F70,$FF0,$EF0,$DF0,$CF0,$AF0,$9F0,$8F0,$0F8
  DC.W  $0F9,$0FA,$0FB,$0FC,$0FD,$0FE,$0FF
  DC.W  $0EF,$0DF,$0CF,$0BF,$0AF,$09F,$08F,$80F
  DC.W  $90F,$A0F,$B0F,$C0F,$D0F,$E0F,$F0F
  DC.W  $F0F,$F07,$F0E,$F06,$F0D,$F05,$F0C,$F04,$F0B,$F03,$F0A,$F01,$F08  

*TU ZAPAMIETAMY STARE VBL	

OLD70		DC.L	0	

*	*	*	*	*	*	*	*
	I TYM OTO OPTYMISTYCZNYM AKCENTEM ZAKONCZYLISMY 
 NASZA PROCEDURE....

        MAM NADZIEJE,ZE ZROZUMIALES WSZYSTKO......

        WIEM,WIEM POWIESZ,ZE TO WSZYSTKO JEST ZBYT  PROSTE
     -JESLI TAK TO O.K. POWIEM CI GDZIE ZNALESC COS DLA
     BARDZIEJ WPRAWIONYCH PROGRAMISTOW....  ZOBACZ 

       THE HIDDEN SCREEN IN MY CONTRIBUTION TO QUAST IV  
       ================================================

    I AM SURE YOU CAN FIND IT MORE INTERESTING THAN THIS ARTICLE....
 

	DOBRA! MAM NADZIEJE,ZE NIE WKRADLY SIE DO PROCEDURY JAKIES
  BLEDY....  DO ZOBACZENIA W NASTEPNYCH ODCINKACH NASZEGO CYKLU 
  Z CYKLU  (???) 
                    'ASSEMBLER PELEN NIESPODZIANEK'

     						    MARCHEW
						       OF
				 		THE TEETH SHAKERS

P.S. GUYS!   NIE WIEM CZY WIECIE ALE TTS WYDALA JUZ NOWE DEMO
                       *RADEMENES DEMO BLUES*
P.S2  W RAZIE JAKBY CO TO PISZCIE 
P.S3  W RAZIE JAKBY CO INNE TO TEZ PISZCIE...
P.S4  A JAK ZNALEZLISCIE COS NIEZROZUMIALEGO W PROCEDURCE
      LUB JAK CHCECIE WIEDZIEC COS INNEGO TO...   TEZ PISZCIE      
P.S5  JAK ZDECYDUJECIE SIE NAPISAC TO PAMIETAJCIE,ZE LUBIE 
      DLUGIE LISTY...........
P.S6  I STRASZNIE BAZGROLE... (STAWIAM BRZYDKIE LITERKI) 
P.S7  PLEASE O SUGESTIE CO DO TEMATYKI TYCH ARTYKULOW BO JA NIE 
      WYROBIE Z KONCEPCJAMI... (Z ANTY_ TEZ- A ZCHN CZUWA I ZABRANIA!)
P.S8 POZDROWIENIA DLA KOLEGOW,KOLOZANEK I SZANOWNYCH KOLOEGOW I
     KOLE-RZ-ANEK (MOICHiMOICHzNAJOMYCH) ORAZ DLA WSZYSTKICH I CALOSCI...


