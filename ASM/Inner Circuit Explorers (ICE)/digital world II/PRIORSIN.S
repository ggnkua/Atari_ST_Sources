startsin:
sin8:	blk.b	189,0
sin16:	blk.b	189,0
sin24:	blk.b	189,0
sin32:	blk.b	189,0
sin40:	blk.b	189,0
sin48:	blk.b	189,0
sin56:	blk.b	189,0
sin64:	blk.b	189,0
sin64_2:blk.b	189,0
sin64_3:blk.b	189,0
sin56_2:blk.b	189,0
sin48_2:blk.b	189,0
sin40_2:blk.b	189,0
sin32_2:blk.b	189,0
sin24_2:blk.b	189,0
sin16_2:blk.b	189,0
sin8_2:	blk.b	189,0

endsin:
