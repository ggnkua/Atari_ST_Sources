dc.b "YO! ZAK IZ HERE!"
DC.B " DO YOU KNOW ABOUT ME , THE NEW MEMBER OF I.C.E ? "
DC.B "WELL ,MOSTLY ,I'M A GRAPHICS ARTIST ( DIG MY GFX IN "
DC.B "'ELECTRONIC PERCUSSION' ) , AND DOES A LITTLE SWAPPING ."
DC.B "WELL ,TIME FOR SOME BULLSHIT ABOUT THIS DEMO...        "
DC.B "THIS DEMO WAS "
DC.B "RELEASED AT THE TCB PARTY 91-11-03 ( THAT'S "
DC.B "AFTER 12 O'CLOCK , WHEN WE HOPEFULLY ARE FINISHED )   "
DC.B "    SO FAR , IT HAS BEEN A GOOD PARTY , EXCEPT THAT ANGELRIPPER"
DC.B " POURED A COKE OVER MY TABLE ... WERE MY MOUSE WAS!!! "
DC.B "LET ME PUT IT THIS WAY ... IT TOOK SOME TIME JUST TO PULL "
DC.B "IT OFF THE TABLE!   ANYWAY , IT'S WORKING ALMOST O.K. NOW ."
DC.B " BY THE WAY , I MET A COOL GUY HERE I WANT TO GREET -"
DC.B " DUCKIE OF TRANSACTION !  HI DUDE!  ,AND AS I'M COMPLETELY "
DC.B "OUT OF INSPIRATION AND BRAINCELLS ,I LEAVE YOU WITH SOME WISE"
DC.B " WORDS ,ONCE SAID BY A GREAT PHILOSOPHER ... PEPSI RULES!!! "   
