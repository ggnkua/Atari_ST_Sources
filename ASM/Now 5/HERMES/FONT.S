***************************************************************************
*                 TERMINATOR 8*8 Font for small scrollers                 *
***************************************************************************

	dc.b	%00000000	space
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00011000	!
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00011000
	
	dc.b	%11000110	"
	dc.b	%11000110
	dc.b	%01000010
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00100100	#
	dc.b	%00100100
	dc.b	%11111111
	dc.b	%00100100
	dc.b	%00100100
	dc.b	%11111111
	dc.b	%00100100
	dc.b	%00100100
	
	dc.b	%00000000	$
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%11000110	%
	dc.b	%11001100
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01100000
	dc.b	%01100110
	dc.b	%11000110
	
	dc.b	%00000000	&
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00111000	'
	dc.b	%00111000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00011000	(
	dc.b	%00110000
	dc.b	%01100000
	dc.b	%01100000
	dc.b	%01100000
	dc.b	%01100000
	dc.b	%00110000
	dc.b	%00011000
	
	dc.b	%00011000	)
	dc.b	%00001100
	dc.b	%00000110
	dc.b	%00000110
	dc.b	%00000110
	dc.b	%00000110
	dc.b	%00001100
	dc.b	%00011000
	
	dc.b	%00000000	*
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	+
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%01111110
	dc.b	%01111110
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	
	dc.b	%00000000	,
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00111000
	dc.b	%00011000
	dc.b	%00110000
	
	dc.b	%00000000	-
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%01111110
	dc.b	%01111110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	.
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00011000
	
	dc.b	%00000010	/
	dc.b	%00000110
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01100000
	dc.b	%11000000
	dc.b	%10000000
	
	dc.b	%01111100	0
	dc.b	%11000110
	dc.b	%10001010
	dc.b	%10010010
	dc.b	%10010010
	dc.b	%10100010
	dc.b	%11000110
	dc.b	%01111100
	
	dc.b	%00011000	1
	dc.b	%00111000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	
	dc.b	%01111100	2
	dc.b	%11000110
	dc.b	%00000110
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01100000
	dc.b	%11111110
	
	dc.b	%11111110	3
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00111000
	dc.b	%00001100
	dc.b	%00000110
	dc.b	%11000110
	dc.b	%01111100
	
	dc.b	%00000100	4
	dc.b	%00001100
	dc.b	%00010100
	dc.b	%00100100
	dc.b	%01000100
	dc.b	%11111110
	dc.b	%00000100
	dc.b	%00000100
	
	dc.b	%11111110	5
	dc.b	%11000000
	dc.b	%01100000
	dc.b	%00111100
	dc.b	%00000110
	dc.b	%00000110
	dc.b	%11000110
	dc.b	%01111100
	
	dc.b	%01111100	6
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11111100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01111100
	
	dc.b	%11111110	7
	dc.b	%00000110
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	
	dc.b	%01111100	8
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01111100
	dc.b	%01101100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01111100
	
	dc.b	%01111100	9
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	
	dc.b	%00000000	:
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	
	dc.b	%00000000	;
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00001000
	
	dc.b	%00000110	<
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%00110000
	dc.b	%00011000
	dc.b	%00001100
	dc.b	%00000110
	
	dc.b	%00000000	=
	dc.b	%00000000
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%11000000	>
	dc.b	%01100000
	dc.b	%00110000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01100000
	dc.b	%11000000
	
	dc.b	%01111100	?
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00011000
	
	dc.b	%00000000	@
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00111000	A
	dc.b	%01101100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11111110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	
	dc.b	%11111000	B
	dc.b	%11001100
	dc.b	%11001100
	dc.b	%11011000
	dc.b	%11001100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11111100
	
	dc.b	%00111100	C
	dc.b	%01100110
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%01100110
	dc.b	%00111100
	
	dc.b	%11110000	D
	dc.b	%11011000
	dc.b	%11001100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11001100
	dc.b	%11111000
	
	dc.b	%11111110	E
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11111000
	dc.b	%11111000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11111110
	
	dc.b	%11111110	F
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11111000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11000000
	
	dc.b	%01111100	G
	dc.b	%11000110
	dc.b	%11000000
	dc.b	%11001110
	dc.b	%11001110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01111100
	
	dc.b	%11000110	H
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11111110
	dc.b	%11111110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	
	dc.b	%01111100	I
	dc.b	%01111100
	dc.b	%00010000
	dc.b	%00010000
	dc.b	%00010000
	dc.b	%00010000
	dc.b	%01111100
	dc.b	%01111100
	
	dc.b	%11111110	J
	dc.b	%11111110
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%11001100
	dc.b	%01111000
	
	dc.b	%11001100	K
	dc.b	%11011000
	dc.b	%11110000
	dc.b	%11100000
	dc.b	%11110000
	dc.b	%11011000
	dc.b	%11001100
	dc.b	%11000110
	
	dc.b	%11000000	L
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11000000
	dc.b	%11111110
	dc.b	%11111110
	
	dc.b	%11000110	M
	dc.b	%11111110
	dc.b	%11111110
	dc.b	%11010110
	dc.b	%11010110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	
	dc.b	%10000110	N
	dc.b	%11000110
	dc.b	%11100110
	dc.b	%11110110
	dc.b	%11011110
	dc.b	%11001110
	dc.b	%11000110
	dc.b	%11000010
	
	dc.b	%00111000	O
	dc.b	%01111100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01111100
	dc.b	%00111000
	
	dc.b	%11111000	P
	dc.b	%11001100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11001100
	dc.b	%11111000
	dc.b	%11000000
	dc.b	%11000000
	
	dc.b	%00111000	Q
	dc.b	%01111100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11010110
	dc.b	%11001110
	dc.b	%01111100
	dc.b	%00111010
	
	dc.b	%11111000	R
	dc.b	%11001100
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11001100
	dc.b	%11111000
	dc.b	%11001100
	dc.b	%11000110
	
	dc.b	%00111100	S
	dc.b	%01100110
	dc.b	%11000110
	dc.b	%01110000
	dc.b	%00011100
	dc.b	%11000110
	dc.b	%01100110
	dc.b	%00111100
	
	dc.b	%11111110	T
	dc.b	%11111110
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	
	dc.b	%11000110	U
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11001110
	dc.b	%01111010
	
	dc.b	%11000110	V
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01101100
	dc.b	%00111000
	dc.b	%00010000
	
	dc.b	%11000110	W
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%11010110
	dc.b	%11010110
	dc.b	%11101110
	dc.b	%11000110
	dc.b	%10000010
	
	dc.b	%10000010	X
	dc.b	%11000110
	dc.b	%01101100
	dc.b	%00111000
	dc.b	%00111000
	dc.b	%01101100
	dc.b	%11000110
	dc.b	%10000010
	
	dc.b	%11000110	Y
	dc.b	%11000110
	dc.b	%11000110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01100000
	
	dc.b	%11111110	Z
	dc.b	%11111110
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01100000
	dc.b	%11111110
	dc.b	%11111110
	
	dc.b	%00000000	[
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	\
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	]
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	^
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	_
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	`
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	a
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	b
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	c
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	d
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	e
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	f
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	g
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	h
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	i
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	j
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	k
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	l
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	m
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	n
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	o
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	p
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	q
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	r
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	s
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	t
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	u
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	v
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	w
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	x
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	y
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	z
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	y
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	z
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000	y
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	
	dc.b	%00000000	z
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000