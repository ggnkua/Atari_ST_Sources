metaTrackSize1 dc.l 900
metaTrack1 dc.l 14014,14012,14412,14812,15212,15610,16010,16410,16410,16810,17208,17208,17608,18008,18006,18406,18406,18806,18804,18804,19204,19202,19202,19202,19602,19600,19600,19600,19600,19600,19600,19600,19598,19598,19198,19198,19196,18796,18796,18796,18394,18394,17994,17994,17592,17592,17192,16792,16790,16390,15990,15590,15188,15188,14788,14388,13988,13586,13186,12786,12386,11986,11184,10784,10384,9984,9584,9184,8384,7982,7582,7182,6382,5982,5582,4782,4382,3982,3182,2782,2382,1582,1182,382,-18,-18,-818,-1218,-2018,-2418,-2818,-3618,-4018,-4418,-5218,-5618,-6018,-6818,-7218,-7618,-8016,-8816,-9216,-9616,-10016,-10416,-11216,-11614,-12014,-12414,-12814,-13214,-13614,-14012,-14412,-14812,-15212,-15612,-15610,-16010,-16410,-16810,-16808,-17208,-17608,-17608,-18006,-18006,-18406,-18406,-18804,-18804,-19204,-19204,-19202,-19202,-19602,-19602,-19600,-19600,-19600,-19600,-19600,-19600,-19600,-19598,-19198,-19198,-19196,-19196,-18796,-18796,-18794,-18394,-18394,-17994,-17992,-17592,-17192,-17192,-16790,-16390,-15990,-15990,-15588,-15188,-14788,-14388,-13988,-13586,-13186,-12786,-12386,-11986,-11586,-11184,-10784,-10384,-9584,-9184,-8784,-8384,-7582,-7182,-6782,-6382,-5582,-5182,-4782,-3982,-3582,-3182,-2382,-1982,-1182,-782,-382,18,418,818,1618,2018,2818,3218,3618,4418,4818,5218,6018,6418,6818,7618,8018,8416,8816,9216,10016,10416,10816,11216,11614,12014,12414,12814,13614,-1
metaTrackSize2 dc.l 700
metaTrack2 dc.l 6870,6472,6474,6076,5678,5680,5282,4884,4486,4488,4090,3690,3292,2894,2494,2494,2096,1696,1298,898,498,98,98,98,-302,-702,-1104,-1504,-1904,-2306,-2706,-2708,-3108,-3510,-3912,-4312,-4714,-4716,-5118,-5520,-5522,-5924,-6326,-6730,-6732,-7134,-7136,-7540,-7542,-7946,-7948,-8352,-8354,-8758,-8760,-8764,-9168,-9170,-9174,-9578,-9582,-9584,-9588,-9592,-9596,-9598,-9600,-9604,-9608,-9610,-9614,-9618,-9622,-9224,-9228,-9232,-9236,-8838,-8842,-8444,-8448,-8450,-8054,-8056,-7660,-7262,-7266,-6868,-6870,-6472,-6074,-6078,-5680,-5282,-4884,-4886,-4486,-4088,-3690,-3692,-3292,-2894,-2494,-2096,-1696,-1296,-898,-898,-498,-98,-98,302,702,1102,1504,1504,1904,2306,2706,3108,3510,3910,3912,4314,4716,5118,5120,5522,5924,6326,6328,6730,6732,7136,7538,7542,7944,7946,8350,8352,8756,8760,8762,9166,9170,9172,9176,9580,9582,9586,9590,9594,9598,9600,9602,9606,9610,9612,9616,9620,9224,9226,9230,9234,8836,8840,8844,8446,8450,8052,8056,7658,7662,7264,7266,-1
metaTrackSize3 dc.l 800
metaTrack3 dc.l 10050,10048,10446,10844,10842,11240,11638,11636,12034,12034,12432,12430,12828,12826,13222,13220,13218,13616,13614,13612,13610,14008,14006,14004,14002,14000,13998,13996,13994,13992,13590,13588,13586,13584,13182,13180,13178,12774,12772,12370,12368,11966,11966,11564,11562,11160,10758,10756,10354,9952,9550,9550,9148,8746,8346,7944,7542,7142,6740,6740,6338,5938,5536,5136,4334,3934,3534,3132,2732,2332,1932,1530,1130,730,330,-70,-470,-870,-1270,-1670,-2068,-2468,-2868,-3268,-3666,-4066,-4466,-5264,-5664,-6062,-6462,-6860,-6860,-7258,-7658,-8056,-8454,-8854,-9252,-9650,-9650,-10048,-10446,-10844,-10842,-11240,-11638,-11636,-12034,-12034,-12432,-12430,-12828,-12826,-13222,-13220,-13218,-13616,-13614,-13612,-13610,-14008,-14006,-14004,-14002,-14000,-13998,-13996,-13994,-13992,-13590,-13588,-13586,-13584,-13182,-13180,-13178,-12774,-12772,-12370,-12368,-11966,-11966,-11564,-11562,-11160,-10758,-10756,-10354,-9952,-9952,-9550,-9148,-8746,-8346,-7944,-7542,-7142,-6740,-6740,-6338,-5938,-5536,-5136,-4334,-3934,-3534,-3132,-2732,-2332,-1932,-1530,-1130,-730,-330,70,470,870,1270,1670,2068,2468,2868,3268,3666,4066,4466,5264,5664,6062,6462,6860,6860,7258,7658,8056,8454,8854,9252,9650,-1
