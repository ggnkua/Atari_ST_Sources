		cnop 0,4
points3d_tex	
		dc.w -50,-50,50	;0
		dc.w 50,-50,50	;1
		dc.w 0,-50,-50	;2
		dc.w 0,90,0		;3
		cnop 0,4

texFaces3d
		dc.w  2,3,0	;0
		dc.w  0,3,1	;1
		dc.w  1,3,2	;2
		dc.w  0,1,2	;3
		cnop 0,4

texUV3d
		dc.w  60<<8,0,0,120<<8,120<<8,120<<8,0,0
		dc.w  60<<8,0,0,120<<8,120<<8,120<<8,0,0
		dc.w  60<<8,0,0,120<<8,120<<8,120<<8,0,0
		dc.w  60<<8,0,0,120<<8,120<<8,120<<8,0,0

;		 (128,0)
;	(0,255)		(255,255)

texPoints3dCnt	dc.l	4-1
texFaces3dCnt	dc.l	4-1

