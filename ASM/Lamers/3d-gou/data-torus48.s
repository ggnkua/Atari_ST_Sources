      cnop 0,4
points3d_gou
      dc.w -88,0,0
      dc.w -63,-25,0
      dc.w -63,25,0
      dc.w -44,0,76
      dc.w -44,0,-76
      dc.w -37,0,0
      dc.w -31,-25,54
      dc.w -31,-25,-54
      dc.w -31,25,54
      dc.w -31,25,-54
      dc.w -18,0,32
      dc.w -18,0,-32
      dc.w 18,0,32
      dc.w 18,0,-32
      dc.w 31,-25,54
      dc.w 31,-25,-54
      dc.w 31,25,54
      dc.w 31,25,-54
      dc.w 37,0,0
      dc.w 44,0,76
      dc.w 44,0,-76
      dc.w 63,-25,0
      dc.w 63,25,0
      dc.w 88,0,0
      cnop 0,4
gouFaces3d
      dc.w 23,16,19,0
      dc.w 22,16,23,0
      dc.w 22,18,12,0
      dc.w 16,22,12,0
      dc.w 12,21,14,0
      dc.w 12,18,21,0
      dc.w 23,19,14,0
      dc.w 21,23,14,0
      dc.w 8,3,19,0
      dc.w 16,8,19,0
      dc.w 8,12,10,0
      dc.w 8,16,12,0
      dc.w 10,14,6,0
      dc.w 10,12,14,0
      dc.w 3,6,14,0
      dc.w 19,3,14,0
      dc.w 8,0,3,0
      dc.w 8,2,0,0
      dc.w 2,8,10,0
      dc.w 5,2,10,0
      dc.w 1,10,6,0
      dc.w 5,10,1,0
      dc.w 0,1,6,0
      dc.w 3,0,6,0
      dc.w 9,4,0,0
      dc.w 2,9,0,0
      dc.w 11,2,5,0
      dc.w 9,2,11,0
      dc.w 11,5,1,0
      dc.w 7,11,1,0
      dc.w 0,7,1,0
      dc.w 0,4,7,0
      dc.w 17,20,4,0
      dc.w 9,17,4,0
      dc.w 17,11,13,0
      dc.w 17,9,11,0
      dc.w 13,7,15,0
      dc.w 13,11,7,0
      dc.w 20,15,7,0
      dc.w 4,20,7,0
      dc.w 17,22,23,0
      dc.w 20,17,23,0
      dc.w 22,13,18,0
      dc.w 22,17,13,0
      dc.w 13,15,21,0
      dc.w 18,13,21,0
      dc.w 15,23,21,0
      dc.w 20,23,15,0
      cnop 0,4
gouPointsColor3d ds.w 24
      cnop 0,4
gouColor3d incbin '3d-gou/color2bw.dat'
gouPoints3dCnt dc.l 24-1
gouFaces3dCnt dc.l 48
gouCoordShift dc.w 88
      cnop 0,4
gouColorMap
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w  0
      dc.w 0
      dc.w 2
      dc.w 4
      dc.w 6
      dc.w 8
      dc.w 9
      dc.w 11
      dc.w 13
      dc.w 15
      dc.w 17
      dc.w 19
      dc.w 21
      dc.w 23
      dc.w 24
      dc.w 26
      dc.w 28
      dc.w 30
      dc.w 32
      dc.w 34
      dc.w 36
      dc.w 38
      dc.w 40
      dc.w 41
      dc.w 43
      dc.w 45
      dc.w 47
      dc.w 49
      dc.w 51
      dc.w 53
      dc.w 55
      dc.w 56
      dc.w 58
      dc.w 60
      dc.w 62
      dc.w 64
      dc.w 66
      dc.w 68
      dc.w 70
      dc.w 72
      dc.w 73
      dc.w 75
      dc.w 77
      dc.w 79
      dc.w 81
      dc.w 83
      dc.w 85
      dc.w 87
      dc.w 88
      dc.w 90
      dc.w 92
      dc.w 94
      dc.w 96
      dc.w 98
      dc.w 100
      dc.w 102
      dc.w 104
      dc.w 105
      dc.w 107
      dc.w 109
      dc.w 111
      dc.w 113
      dc.w 115
      dc.w 117
      dc.w 119
      dc.w 120
      dc.w 122
      dc.w 124
      dc.w 126
      dc.w 128
      dc.w 130
      dc.w 132
      dc.w 134
      dc.w 136
      dc.w 137
      dc.w 139
      dc.w 141
      dc.w 143
      dc.w 145
      dc.w 147
      dc.w 149
      dc.w 151
      dc.w 152
      dc.w 154
      dc.w 156
      dc.w 158
      dc.w 160
      dc.w 162
      dc.w 164
      dc.w 166
      dc.w 168
      dc.w 169
      dc.w 171
      dc.w 173
      dc.w 175
      dc.w 177
      dc.w 179
      dc.w 181
      dc.w 183
      dc.w 184
      dc.w 186
      dc.w 188
      dc.w 190
      dc.w 192
      dc.w 194
      dc.w 196
      dc.w 198
      dc.w 200
      dc.w 201
      dc.w 203
      dc.w 205
      dc.w 207
      dc.w 209
      dc.w 211
      dc.w 213
      dc.w 215
      dc.w 216
      dc.w 218
      dc.w 220
      dc.w 222
      dc.w 224
      dc.w 226
      dc.w 228
      dc.w 230
      dc.w 232
      dc.w 233
      dc.w 235
      dc.w 237
      dc.w 239
      dc.w 241
      dc.w 243
      dc.w 245
      dc.w 247
      dc.w 248
      dc.w 250
      dc.w 252
      dc.w 254
      dc.w  255
      dc.w  255
      dc.w  255
      dc.w  255
      dc.w  255
      dc.w  255
      dc.w  255
      dc.w  255
      dc.w  255
      dc.w  255
      cnop 0,4
