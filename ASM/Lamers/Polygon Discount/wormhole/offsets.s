  dc.w    1234,1234,1106,1106,1106,1106,1106,1104,1104,976,976,976,976,974,974,974,846,846,844,844,844,844,842,714,714,714,714,712,584,584,584,584,582,454,454,454,452,452,452,324,322,322,322,322,192,192,192,192,190,62,62,60,60,60,188,186,186,186,312,312,312,310,310,436,436,436,436,562,562,562,560,560,686,686,686,684,812,810,810,810,936,936,934,934,1062,1060,1060,1058,1058,1184,1184,1182,1182,1180,1180,1306,1306,1304,1304,1302,1302,1428,1428,1426,1426,1424,1424,1422,1550,1548,1548,1546,1544,1544,1542,1542,1540,1540,1538,1538,1536,1536,1662,1662,1660,1658,1658,1656,1656,1654,1652,1652,1652,1522,1522,1520,1518,1518,1516,1516,1386,1386,1384,1384,1382,1382,1252,1252,1250,1250,1250,1248,1120,1118,1116,1116,988,986,986,984,984,856,854,854,852,724,724,722,722,592,592,592,590,590,462,460,460,460,330,330,330,328,328,200,198,198,198,68,68,68,68,66,194,194,194,192,192,320,318,318,318,318,444,444,444,444,442,570,570,570,568,568,568,696,694,694,694,694,694,820,820,820,820,820,818,946,946,946,946,944,944,944,1072,1072,1072,1070,1070,1070,1198,1198
  dc.w    1236,1236,1106,1106,1106,1106,1106,1106,976,976,976,976,976,976,974,974,846,846,846,846,844,844,716,716,714,714,714,586,584,584,584,584,584,454,454,454,454,452,324,324,324,322,322,194,194,194,192,192,62,62,62,62,60,188,188,186,186,314,314,312,312,312,438,438,436,436,564,564,562,562,688,688,688,686,814,812,812,812,810,938,936,936,934,1062,1062,1060,1188,1186,1186,1184,1184,1182,1310,1308,1308,1306,1306,1434,1432,1432,1430,1428,1428,1554,1554,1552,1552,1550,1550,1548,1548,1546,1546,1544,1670,1670,1668,1668,1666,1666,1664,1664,1790,1788,1788,1786,1786,1656,1656,1654,1652,1652,1650,1650,1650,1648,1646,1646,1516,1516,1514,1512,1512,1512,1382,1382,1380,1380,1378,1250,1248,1248,1246,1246,1116,1116,1116,1114,984,984,984,984,854,854,852,852,850,722,720,720,592,590,590,590,588,460,460,458,458,330,328,328,328,326,198,198,196,196,196,66,66,66,66,192,192,192,192,190,318,318,316,316,316,444,442,442,442,442,568,568,568,568,568,566,694,694,694,692,692,820,820,820,820,818,818,946,946,946,944,944,944,944,944,1070,1070,1070,1070,1070,1070,1196
  dc.w    1236,1108,1108,1108,1106,1106,1106,1106,978,976,976,976,976,976,976,848,846,846,846,846,846,716,716,716,716,716,586,586,586,586,584,584,456,456,454,454,454,326,326,324,324,324,194,194,194,194,192,64,64,64,62,62,190,188,188,188,314,314,314,314,440,440,438,438,566,564,564,564,562,690,690,688,688,814,814,814,812,940,938,938,938,1064,1064,1062,1062,1188,1188,1188,1186,1186,1312,1312,1310,1310,1436,1436,1434,1434,1432,1432,1558,1558,1556,1556,1554,1554,1552,1680,1678,1676,1676,1674,1674,1672,1672,1670,1798,1796,1794,1794,1792,1792,1918,1918,1788,1786,1786,1784,1784,1782,1782,1780,1778,1778,1648,1648,1646,1644,1644,1644,1642,1512,1512,1512,1510,1510,1508,1378,1378,1378,1376,1246,1246,1244,1244,1244,1114,1114,1114,1112,984,982,982,980,852,852,850,850,720,720,720,718,590,590,588,588,586,458,458,456,456,328,326,326,326,196,196,196,196,194,66,66,64,64,192,192,190,190,190,316,316,316,316,442,442,442,442,442,440,568,568,568,566,566,566,694,692,692,692,692,820,818,818,818,818,818,944,944,944,944,944,942,942,1070,1070,1070,1070,1070,1068,1068
  dc.w    1236,1108,1108,1108,1108,1108,1106,978,978,978,978,976,976,976,848,848,848,846,846,846,718,718,716,716,716,588,588,586,586,586,586,456,456,456,456,454,454,326,326,324,324,196,196,196,194,194,66,64,64,64,192,190,190,190,188,316,316,314,314,314,440,440,440,566,566,566,564,564,692,690,690,818,816,816,814,942,940,940,940,1066,1066,1064,1064,1192,1190,1190,1188,1316,1314,1314,1312,1440,1438,1438,1436,1436,1434,1562,1560,1560,1558,1558,1684,1684,1682,1682,1680,1808,1806,1804,1804,1802,1802,1800,1800,1798,1798,1796,1794,1794,1792,1792,1918,1918,1916,1914,1914,1912,1912,1910,1910,1908,1906,1778,1776,1776,1774,1772,1772,1644,1642,1640,1640,1638,1510,1508,1508,1506,1506,1376,1376,1374,1374,1372,1244,1242,1242,1242,1112,1112,1112,1110,982,980,980,978,850,848,848,848,718,718,718,588,588,586,586,586,458,456,456,454,326,326,324,324,196,194,194,194,66,64,64,64,62,190,190,190,188,188,316,316,314,314,442,442,440,440,440,440,568,566,566,566,566,564,692,692,692,692,692,818,818,818,818,816,816,944,944,944,942,942,942,942,1070,1070,1070,1068,1068,1068
  dc.w    1110,1108,1108,1108,1108,1108,1108,978,978,978,978,978,976,976,848,848,848,848,846,846,718,718,718,716,716,588,588,586,586,586,458,458,456,456,456,456,328,326,326,326,324,196,196,196,194,66,66,66,64,192,192,190,190,190,318,316,316,316,442,442,442,440,568,568,566,566,694,692,692,692,818,818,816,816,944,942,942,1068,1068,1066,1066,1194,1192,1192,1190,1318,1318,1316,1316,1442,1442,1440,1440,1438,1566,1564,1564,1562,1562,1688,1688,1686,1684,1812,1810,1810,1808,1808,1806,1804,1804,1802,1930,1928,1928,1926,1926,1924,1922,1922,1920,1920,2046,2044,2044,2042,2040,2040,2040,2038,1908,1906,1906,1904,1904,1904,1902,1900,1772,1770,1770,1768,1638,1638,1636,1636,1634,1506,1506,1504,1504,1502,1374,1372,1372,1370,1242,1242,1240,1240,1110,1110,1108,1108,980,978,978,848,848,846,846,718,716,716,716,586,586,586,584,456,456,454,454,326,324,324,322,194,194,194,192,192,64,64,62,62,190,188,188,188,188,314,314,314,314,440,440,440,440,438,438,566,566,566,564,564,692,692,692,690,690,818,818,816,816,816,816,944,944,942,942,942,942,942,1070,1068,1068,1068,1068,1068
  dc.w    1110,1110,1110,1108,1108,1108,980,980,978,978,978,978,978,850,848,848,848,848,848,718,718,718,718,718,588,588,588,588,588,460,458,458,458,458,456,328,328,328,326,198,198,198,196,196,68,68,66,66,66,192,192,192,190,318,318,318,316,444,444,442,442,570,568,568,568,694,694,694,692,820,820,818,946,944,944,942,1070,1070,1068,1196,1194,1194,1192,1320,1320,1318,1318,1444,1444,1442,1442,1568,1568,1566,1566,1564,1692,1690,1690,1688,1816,1814,1814,1940,1810,1810,1936,1936,1934,1934,1932,1932,1930,2056,2056,2054,2054,2052,2050,2050,2048,2048,2174,2172,2170,2170,2170,2168,2040,2038,2036,2036,2034,2034,2032,1902,1900,1900,1900,1898,1898,1768,1766,1766,1764,1636,1634,1634,1632,1632,1502,1502,1500,1500,1372,1370,1368,1368,1240,1238,1238,1236,1108,1108,1106,978,976,976,974,846,846,844,844,716,714,714,586,584,584,582,454,454,454,452,324,322,322,322,194,192,192,192,192,62,62,62,60,188,188,188,186,186,314,314,312,312,440,440,438,438,438,566,566,564,564,564,564,690,690,690,690,690,816,816,816,816,816,814,942,942,942,942,942,940,940,1068,1068,1068,1068,1068
  dc.w    1110,1110,1110,1110,1108,980,980,980,980,980,978,978,850,850,850,850,848,848,720,720,720,718,718,590,590,588,588,588,588,460,460,458,458,458,330,328,328,328,328,198,198,198,198,68,68,68,66,194,194,194,192,192,320,318,318,318,446,444,444,572,570,570,570,568,696,694,694,822,820,820,820,948,946,946,1072,1072,1070,1198,1196,1196,1196,1194,1322,1320,1320,1446,1446,1446,1444,1570,1570,1570,1568,1696,1694,1694,1692,1818,1818,1816,1816,1814,1942,1940,1940,1938,1938,2064,2062,2062,2060,2060,2186,2056,2056,2182,2182,2180,2178,2178,2176,2176,2302,2300,2300,2298,2168,2168,2166,2166,2164,2162,2162,2162,2032,2030,2030,2028,2026,1898,1896,1896,1894,1894,1764,1764,1762,1762,1632,1632,1630,1630,1500,1500,1498,1498,1368,1368,1368,1238,1236,1236,1236,1106,1106,1106,1104,976,974,974,844,844,844,842,714,714,712,584,584,582,582,582,452,452,450,322,322,322,320,192,192,190,190,62,62,60,60,60,188,186,186,186,312,312,312,312,312,438,438,438,438,438,564,564,564,564,562,562,690,690,690,688,688,816,816,816,814,814,814,942,942,942,940,940,940,940,1068,1068,1066,1066
  dc.w    1110,1110,1110,1110,1110,980,980,980,980,980,980,980,850,850,850,850,850,848,720,720,720,720,590,590,590,590,590,588,460,460,460,460,458,330,330,328,328,328,200,200,198,198,70,70,68,68,196,196,194,194,194,320,320,320,318,446,446,446,572,572,572,570,570,698,696,696,822,822,822,948,948,948,946,1074,1072,1072,1200,1198,1198,1196,1324,1324,1322,1450,1448,1448,1446,1574,1572,1572,1570,1698,1696,1696,1822,1822,1820,1820,1946,1946,1944,1944,1942,2068,2068,2066,2066,2064,2190,2190,2188,2188,2186,2184,2184,2182,2182,2180,2178,2178,2176,2176,2302,2300,2300,2298,2298,2296,2294,2294,2292,2290,2290,2288,2160,2158,2156,2156,2026,2026,2024,2022,2022,1892,1892,1890,1890,1760,1760,1758,1630,1630,1628,1626,1498,1498,1496,1496,1366,1366,1364,1236,1234,1234,1232,1104,1104,1102,974,974,972,972,842,842,842,712,712,712,582,582,582,580,452,450,450,450,322,320,320,320,190,190,190,190,190,60,60,58,58,186,186,186,184,312,312,310,310,310,438,438,436,436,436,564,564,562,562,562,690,690,688,688,688,688,814,814,814,814,814,942,940,940,940,940,940,940,1066,1066,1066,1066
  dc.w    1112,1110,1110,1110,982,982,982,980,980,980,980,852,852,850,850,850,850,722,720,720,720,720,592,592,590,590,590,462,460,460,460,460,460,330,330,330,330,200,200,200,200,70,70,70,70,68,196,196,194,194,322,322,320,320,448,446,446,574,574,572,572,700,698,698,698,824,824,824,950,950,948,1076,1076,1074,1074,1200,1200,1200,1326,1326,1324,1324,1450,1450,1448,1576,1576,1574,1574,1700,1700,1698,1826,1824,1824,1822,1948,1948,1946,2074,2072,2072,2070,2196,2196,2194,2194,2192,2192,2190,2316,2316,2314,2312,2312,2310,2310,2308,2306,2306,2304,2304,2430,2428,2428,2426,2426,2424,2422,2420,2420,2290,2288,2288,2286,2286,2284,2284,2154,2154,2152,2152,2022,2020,2020,1890,1890,1888,1886,1758,1758,1756,1626,1626,1626,1624,1496,1496,1494,1364,1364,1362,1362,1234,1232,1232,1102,1102,1102,1100,972,970,970,842,840,840,840,710,710,710,580,580,578,578,450,450,448,320,320,318,318,190,190,188,188,60,58,58,58,58,184,184,184,184,312,310,310,310,438,436,436,436,436,434,562,562,562,562,560,688,688,688,688,686,814,814,814,814,812,812,940,940,940,940,938,938,938,1066,1066,1066
  dc.w    1112,1112,1112,1110,982,982,982,982,980,980,980,852,852,852,850,850,722,722,722,720,720,592,592,592,592,590,462,462,462,460,460,460,332,332,330,330,202,202,200,200,200,72,70,70,70,198,196,196,196,322,322,322,322,448,448,448,574,574,574,574,700,700,698,698,826,826,824,952,950,950,1078,1076,1076,1204,1202,1202,1200,1328,1326,1326,1454,1452,1452,1578,1578,1576,1576,1702,1702,1700,1828,1826,1826,1952,1952,1950,2078,2076,2074,2074,2202,2200,2198,2198,2196,2324,2322,2320,2320,2318,2446,2444,2442,2442,2440,2438,2438,2436,2434,2434,2432,2432,2558,2556,2556,2554,2552,2552,2550,2548,2548,2418,2416,2416,2414,2414,2284,2284,2282,2280,2280,2150,2150,2148,2018,2018,2018,2016,1886,1886,1884,1884,1754,1754,1624,1624,1624,1622,1492,1492,1492,1362,1362,1360,1232,1230,1230,1230,1100,1100,1098,970,970,968,840,840,838,838,710,708,708,578,578,578,578,448,448,448,318,318,318,318,188,188,188,188,58,58,58,56,184,184,184,182,182,310,310,310,308,436,436,436,434,434,562,562,562,560,560,560,688,686,686,686,686,814,814,812,812,812,940,940,940,938,938,938,938,1066,1066,1064
  dc.w    1112,1112,1112,984,984,982,982,982,982,982,854,852,852,852,852,852,722,722,722,722,594,592,592,592,592,592,462,462,462,462,462,332,332,332,332,204,202,202,202,200,72,72,72,70,198,198,198,196,324,324,322,322,450,450,448,576,576,574,574,702,702,700,828,826,826,826,952,952,952,1078,1078,1078,1204,1204,1202,1330,1330,1328,1456,1454,1454,1452,1580,1580,1578,1706,1704,1832,1830,1830,1828,1956,1954,1952,2080,2080,2078,2204,2204,2202,2202,2200,2326,2326,2324,2452,2450,2448,2448,2446,2446,2572,2570,2570,2568,2568,2566,2564,2562,2562,2560,2560,2686,2684,2684,2682,2680,2680,2678,2676,2546,2546,2544,2544,2542,2412,2412,2410,2410,2408,2280,2278,2276,2276,2146,2146,2144,2016,2014,2014,1884,1884,1882,1752,1752,1752,1622,1622,1620,1492,1490,1490,1488,1360,1360,1358,1230,1228,1228,1100,1098,1098,968,968,968,838,838,838,708,708,708,706,578,578,578,576,448,446,446,318,318,316,316,188,186,186,186,58,56,56,56,184,182,182,182,182,308,308,308,308,436,434,434,434,434,560,560,560,560,560,558,686,686,686,686,814,812,812,812,812,812,938,938,938,938,938,938,936,1064,1064
  dc.w    1112,1112,1112,984,984,984,982,982,982,854,854,854,852,852,852,724,724,722,722,722,594,594,594,592,592,464,464,464,462,462,334,334,332,332,332,204,204,202,202,74,74,72,72,200,200,198,198,326,324,324,324,452,450,450,578,576,576,576,702,702,702,830,828,828,826,954,954,952,1080,1080,1078,1206,1206,1204,1332,1330,1330,1458,1456,1456,1582,1582,1580,1708,1706,1706,1832,1832,1830,1958,1956,1956,2082,2082,2080,2208,2206,2206,2332,2332,2330,2328,2456,2454,2452,2452,2578,2578,2576,2574,2574,2700,2698,2698,2696,2696,2694,2692,2692,2690,2688,2814,2814,2812,2810,2810,2808,2806,2806,2804,2804,2674,2672,2670,2670,2540,2540,2538,2536,2408,2406,2406,2404,2274,2274,2274,2144,2142,2142,2012,2012,2010,1882,1880,1880,1880,1750,1748,1620,1618,1618,1490,1488,1488,1358,1358,1356,1228,1228,1226,1098,1096,1096,1096,966,966,838,836,836,836,706,706,706,576,576,576,574,446,446,446,316,316,316,314,186,186,186,184,56,56,56,54,182,182,182,180,308,308,308,306,306,434,434,434,432,432,560,560,560,558,558,686,686,686,684,684,812,812,812,812,810,810,938,938,938,938,936,936,1064,1064
  dc.w    1114,1112,984,984,984,984,984,984,982,854,854,854,854,852,724,724,724,724,724,596,594,594,594,594,592,464,464,464,464,462,334,334,334,334,204,204,204,204,74,74,74,74,200,200,200,200,326,326,326,326,452,452,452,578,578,578,576,704,704,702,830,830,830,956,956,956,1082,1082,1080,1208,1208,1206,1206,1332,1332,1332,1458,1458,1456,1584,1582,1582,1708,1708,1836,1834,1834,1960,1960,1958,2086,2084,2212,2210,2210,2208,2334,2334,2332,2460,2458,2456,2584,2582,2582,2708,2706,2706,2704,2704,2830,2828,2828,2954,2824,2824,2822,2820,2820,2818,2816,2942,2942,2940,2938,2938,2936,2934,2934,2932,2932,2802,2800,2798,2798,2668,2668,2666,2664,2536,2534,2532,2404,2402,2402,2272,2272,2270,2270,2140,2140,2010,2008,2008,1880,1878,1878,1748,1746,1618,1618,1616,1488,1486,1486,1356,1356,1356,1226,1226,1224,1096,1096,1094,1094,966,964,964,836,834,834,706,704,704,576,574,574,574,444,444,444,316,314,314,314,186,184,184,184,54,54,54,54,182,180,180,180,308,306,306,306,434,434,432,432,432,560,558,558,558,558,558,686,684,684,684,812,812,810,810,810,810,938,938,936,936,936,936,936,1064
  dc.w    1114,1114,986,984,984,984,984,984,856,856,854,854,854,854,726,724,724,724,724,596,596,594,594,594,466,466,464,464,464,336,336,334,334,206,206,206,204,76,76,74,74,74,202,200,200,200,328,326,326,454,454,452,580,580,578,578,706,704,704,832,830,830,958,956,956,1084,1084,1082,1210,1208,1208,1334,1334,1334,1460,1460,1460,1586,1586,1584,1712,1710,1838,1836,1836,1964,1962,1960,2088,2088,2214,2212,2212,2338,2338,2336,2464,2462,2462,2588,2586,2586,2712,2710,2710,2708,2836,2834,2832,2832,2958,2956,2956,2954,2952,2952,2950,2948,3076,3074,3072,3072,3198,3068,3066,3066,3064,3062,3060,3060,3058,2930,2928,2926,2924,2796,2794,2794,2792,2662,2662,2660,2532,2530,2530,2400,2398,2270,2268,2268,2266,2136,2136,2008,2006,2006,1876,1876,1874,1746,1744,1616,1614,1614,1486,1484,1484,1354,1354,1352,1224,1224,1222,1094,1094,1092,964,964,962,834,834,832,704,704,702,574,574,572,572,444,444,442,314,314,314,184,184,184,182,54,54,54,52,52,180,180,180,178,306,306,306,304,432,432,432,432,430,558,558,558,558,556,684,684,684,684,682,810,810,810,810,810,808,936,936,936,936,936,936,934
  dc.w    1114,986,986,986,986,984,984,984,856,856,856,854,854,726,726,726,724,724,596,596,596,596,594,466,466,466,466,464,336,336,336,336,208,206,206,206,204,76,76,76,76,202,202,202,330,328,328,328,456,454,454,454,580,580,580,706,706,706,832,832,832,958,958,958,1086,1084,1084,1210,1210,1210,1336,1336,1334,1462,1462,1460,1588,1588,1586,1714,1712,1840,1838,1966,1964,1964,2090,2090,2216,2216,2214,2342,2340,2468,2466,2466,2464,2590,2590,2716,2716,2714,2842,2840,2838,2836,2964,2962,2962,2960,3086,3084,3084,3082,3208,3208,3206,3204,3204,3202,3200,3200,3326,3324,3322,3320,3320,3190,3190,3188,3186,3186,3054,3054,3054,3052,2922,2920,2920,2790,2788,2788,2658,2658,2528,2528,2526,2398,2396,2394,2266,2264,2264,2136,2134,2004,2004,1874,1874,1872,1744,1742,1614,1614,1612,1484,1482,1482,1354,1352,1352,1224,1222,1222,1092,1092,1092,962,962,962,832,832,832,702,702,702,572,572,572,442,442,442,442,312,312,312,182,182,182,182,54,52,52,52,180,178,178,178,306,304,304,304,304,432,432,430,430,430,558,556,556,556,556,684,684,682,682,682,810,810,810,808,808,936,936,936,936,934,934,934
  dc.w    1114,986,986,986,986,986,986,856,856,856,856,856,856,726,726,726,726,598,598,596,596,596,596,468,466,466,466,466,338,336,336,336,208,208,206,206,78,78,76,76,204,204,204,202,330,330,328,328,456,454,454,582,582,580,708,708,706,834,834,832,960,960,958,1086,1086,1214,1212,1212,1210,1338,1338,1336,1464,1464,1590,1590,1588,1716,1716,1842,1842,1840,1966,1966,2094,2092,2092,2218,2218,2344,2344,2342,2470,2468,2594,2594,2592,2720,2846,2846,2844,2842,2970,2968,2966,3094,3092,3092,3218,3216,3214,3214,3340,3338,3336,3336,3334,3462,3332,3330,3328,3328,3454,3452,3450,3448,3448,3446,3316,3316,3314,3312,3310,3182,3180,3180,3050,3048,3046,3046,2916,2916,2786,2786,2656,2654,2654,2524,2524,2394,2392,2392,2264,2262,2132,2132,2130,2002,2000,1872,1872,1870,1742,1740,1612,1610,1610,1482,1480,1352,1352,1350,1222,1220,1220,1092,1090,1090,962,960,960,830,830,830,702,700,700,572,570,570,442,442,440,440,312,312,310,182,182,182,180,52,52,52,50,178,178,178,176,304,304,304,304,430,430,430,430,430,556,556,556,556,556,556,682,682,682,682,810,808,808,808,808,808,936,934,934,934,934,934
  dc.w    988,986,986,986,986,986,986,858,858,856,856,856,728,728,728,726,726,598,598,598,596,596,468,468,468,466,466,338,338,338,336,208,208,208,208,78,78,78,78,204,204,204,204,330,330,330,330,458,456,456,584,582,582,710,708,708,836,834,834,962,962,960,1088,1088,1086,1214,1214,1212,1340,1338,1466,1466,1464,1592,1590,1590,1718,1716,1844,1844,1842,1968,1968,2094,2094,2222,2220,2218,2346,2344,2472,2470,2598,2596,2724,2722,2722,2848,2846,2974,2972,2972,3098,3096,3224,3222,3220,3348,3346,3344,3472,3470,3468,3466,3466,3464,3462,3462,3588,3586,3584,3710,3710,3580,3578,3576,3576,3574,3572,3572,3442,3440,3438,3438,3308,3306,3306,3176,3174,3046,3044,3042,2914,2912,2784,2782,2780,2652,2650,2522,2520,2392,2390,2262,2260,2260,2130,2130,2000,2000,1870,1870,1868,1740,1740,1610,1610,1608,1480,1478,1478,1350,1348,1220,1220,1218,1090,1090,1088,960,960,958,830,830,828,700,700,698,570,570,570,440,440,440,312,310,310,310,180,180,180,180,52,50,50,50,178,176,176,176,304,304,302,302,430,430,428,428,428,556,556,556,554,554,682,682,682,680,680,808,808,808,808,808,934,934,934,934,934,934
  dc.w    988,988,988,986,986,986,858,858,858,858,858,856,728,728,728,728,600,598,598,598,598,470,468,468,468,468,340,338,338,338,338,210,208,208,80,80,78,78,78,206,204,204,332,332,330,330,458,458,456,584,584,584,582,710,710,708,836,836,964,962,962,1088,1088,1088,1216,1214,1214,1342,1340,1468,1466,1466,1594,1592,1592,1718,1718,1844,1844,1972,1970,2098,2096,2224,2224,2222,2348,2348,2474,2474,2600,2600,2726,2726,2724,2850,2850,2976,2976,3102,3102,3228,3226,3354,3352,3350,3350,3476,3474,3474,3600,3598,3596,3722,3722,3720,3718,3718,3716,3714,3712,3838,3838,3836,3834,3834,3830,3830,3700,3698,3698,3568,3566,3566,3564,3434,3432,3302,3302,3300,3170,3170,3040,3040,2910,2910,2908,2778,2778,2648,2648,2520,2518,2388,2388,2258,2258,2256,2128,2126,1998,1996,1868,1866,1866,1738,1608,1608,1606,1478,1478,1476,1348,1346,1218,1218,1218,1088,1088,1088,958,958,958,828,828,828,698,698,570,570,568,568,440,438,438,310,310,308,308,180,180,178,178,50,50,50,176,176,176,176,302,302,302,302,302,428,428,428,428,428,554,554,554,554,554,680,680,680,680,808,808,808,806,806,806,934,934,934,932,932
  dc.w    988,988,988,988,988,986,858,858,858,858,858,730,728,728,728,728,600,600,598,598,598,470,470,468,468,468,340,340,338,338,210,210,210,210,80,80,80,80,206,206,206,334,332,332,332,460,458,458,586,586,584,584,712,710,838,838,838,964,964,962,1090,1090,1090,1216,1216,1216,1342,1342,1470,1468,1468,1594,1594,1722,1720,1848,1846,1846,1974,1972,2100,2098,2226,2224,2224,2350,2478,2476,2476,2602,2602,2856,2856,2854,2852,2980,2978,3106,3104,3230,3230,3356,3356,3482,3480,3478,3606,3732,3730,3730,3728,3726,3854,3852,3850,3976,3974,3974,3972,3970,3968,4094,4094,4092,4090,3960,3958,3958,3954,3826,3826,3822,3822,3692,3692,3562,3560,3558,3430,3428,3298,3298,3168,3166,3038,3036,2908,2906,2906,2776,2776,2646,2644,2516,2386,2386,2384,2256,2254,2126,2124,1996,1996,1866,1866,1864,1736,1734,1606,1606,1476,1476,1474,1346,1346,1216,1216,1216,1088,1086,1086,956,956,956,826,826,698,698,696,568,568,568,566,438,438,436,308,308,308,308,178,178,178,50,48,48,48,176,176,174,174,302,302,302,300,428,428,428,428,426,554,554,554,554,552,680,680,680,680,680,808,806,806,806,806,934,932,932,932,932
  dc.w    988,988,988,988,988,860,860,858,858,858,858,730,730,728,728,600,600,600,600,600,470,470,470,470,470,340,340,340,340,212,210,210,210,82,82,80,80,208,208,208,206,334,334,334,460,460,460,586,586,586,586,712,712,712,840,838,838,966,964,1092,1092,1090,1218,1218,1216,1344,1344,1470,1470,1598,1596,1596,1722,1722,1850,1848,1976,1974,1974,2102,2100,2228,2226,2354,2352,2480,2478,2606,2604,2732,2730,2856,2856,2982,2982,3108,3236,3234,3360,3360,3486,3484,3484,3610,3738,3736,3734,3860,3860,3986,3984,3982,3982,4108,4106,4104,4102,4230,4228,4226,4224,4224,4350,4348,4218,4216,4214,4212,4082,4082,4080,4078,3948,3948,3818,3816,3686,3686,3556,3554,3554,3426,3424,3294,3292,3164,3034,3034,2904,2904,2774,2772,2644,2642,2514,2512,2384,2382,2254,2252,2252,2124,2122,1994,1864,1864,1862,1734,1734,1604,1604,1474,1474,1474,1344,1344,1216,1216,1214,1086,1086,1084,956,956,826,826,826,696,696,696,566,566,566,566,436,436,436,308,308,306,178,178,178,176,48,48,48,46,174,174,174,174,300,300,300,300,428,426,426,426,426,554,552,552,552,552,680,680,680,678,806,806,806,806,804,804,932,932,932,932
  dc.w    990,988,988,988,988,860,860,860,860,860,730,730,730,730,730,602,600,600,600,600,472,472,470,470,470,342,340,340,340,212,212,212,210,82,82,82,210,208,208,208,334,334,334,334,462,460,460,588,588,586,714,714,714,840,840,840,966,966,1094,1092,1092,1220,1218,1218,1346,1344,1472,1472,1598,1598,1598,1724,1724,1850,1850,1978,1976,2104,2102,2230,2230,2356,2356,2482,2480,2608,2608,2734,2732,2860,2860,2986,2984,3112,3238,3238,3364,3364,3490,3488,3616,3614,3740,3738,3866,3992,3990,3990,4244,4114,4240,4240,4238,4364,4362,4360,4358,4358,4484,4482,4480,4480,4606,4604,4474,4472,4470,4468,4338,4336,4336,4206,4204,4204,4074,4072,3942,3814,3812,3682,3682,3552,3550,3422,3420,3290,3290,3160,3032,3032,2900,2900,2770,2770,2640,2640,2512,2510,2382,2380,2252,2250,2122,2120,1992,1992,1862,1862,1732,1732,1602,1602,1602,1472,1472,1344,1342,1214,1214,1212,1084,1084,1084,954,954,826,824,824,696,694,694,566,566,564,436,436,436,306,306,306,306,176,176,176,176,48,46,46,174,174,172,172,300,300,300,298,426,426,426,426,426,424,552,552,552,552,678,678,678,678,678,806,804,804,804,804,932,932,932,932
  dc.w    990,990,990,990,862,860,860,860,860,860,732,732,730,730,602,602,602,600,600,472,472,472,472,472,342,342,342,342,212,212,212,212,84,82,82,82,210,208,208,336,336,336,334,462,462,462,588,588,588,716,716,714,842,842,840,968,968,1094,1094,1094,1220,1220,1220,1346,1346,1474,1472,1472,1600,1598,1726,1726,1852,1852,1980,1978,2106,2104,2232,2230,2358,2356,2484,2484,2610,2610,2736,2864,2862,2990,2988,3114,3242,3368,3368,3366,3492,3492,3618,3744,3744,3870,3870,3996,3994,4378,4248,4246,4372,4370,4498,4496,4494,4620,4618,4616,4744,4742,4740,4738,4736,4862,4862,4860,4858,4728,4726,4724,4594,4592,4462,4462,4460,4330,4328,4198,4198,4068,4068,3938,3938,3806,3678,3548,3548,3418,3416,3288,3288,3158,3028,3026,2898,2898,2768,2768,2638,2510,2508,2380,2378,2250,2248,2120,2120,1990,1990,1860,1860,1730,1730,1602,1600,1472,1472,1470,1342,1342,1212,1212,1212,1082,1082,1082,954,952,824,824,822,694,694,694,564,564,564,564,434,434,306,304,304,304,176,176,174,46,46,46,44,172,172,172,172,300,298,298,298,426,424,424,424,424,552,552,552,550,550,678,678,678,678,804,804,804,804,804,804,932,930,930
  dc.w    990,990,990,990,862,862,862,860,860,732,732,732,732,730,602,602,602,602,602,472,472,472,472,344,344,342,342,342,214,214,212,84,84,84,82,210,210,210,210,338,336,336,464,462,462,590,590,588,716,716,716,844,842,842,970,968,968,1096,1094,1222,1222,1222,1348,1348,1474,1474,1474,1600,1600,1728,1726,1854,1854,1980,1980,2108,2106,2234,2232,2360,2358,2486,2484,2612,2740,2738,2866,2992,2992,3118,3116,3244,3370,3370,3496,3496,3622,3748,3876,3874,4000,4000,4254,4252,4380,4378,4376,4502,4630,4628,4754,4752,4878,4876,5002,5002,5000,4998,4996,4994,5120,5118,5116,5116,5114,5112,5110,4980,4978,4976,4846,4716,4716,4586,4584,4454,4324,4324,4194,4064,4064,3934,3804,3804,3674,3546,3544,3416,3414,3284,3156,3154,3026,3024,2896,2766,2766,2636,2508,2506,2378,2376,2248,2246,2118,2118,1988,1988,1860,1858,1730,1728,1600,1600,1470,1470,1470,1340,1340,1212,1210,1210,1082,1080,1080,952,952,822,822,822,692,692,564,564,562,562,434,434,432,304,304,304,174,174,174,174,44,44,44,44,172,172,170,298,298,298,298,296,424,424,424,424,552,550,550,550,550,678,678,678,676,676,804,804,804,802,802,930,930,930
  dc.w    992,990,990,862,862,862,862,862,862,732,732,732,732,604,602,602,602,602,474,474,474,472,472,344,344,344,344,214,214,214,214,86,84,84,84,212,212,210,338,338,336,336,464,464,592,590,590,590,718,718,844,844,844,970,970,970,1096,1096,1224,1224,1222,1350,1350,1476,1476,1474,1602,1602,1730,1728,1856,1854,1982,1982,2108,2108,2236,2234,2362,2360,2488,2614,2614,2740,2740,2868,2994,2992,3120,3246,3374,3372,3500,3498,3624,3752,3750,3878,4004,4260,4130,4256,4382,4382,4508,4634,4890,4888,4886,5012,5010,5136,5136,5262,5260,5514,5384,5382,5380,5378,5504,5630,5500,5498,5498,5496,5366,5362,5234,5232,5102,5100,5100,4840,4840,4710,4580,4450,4450,4320,4190,4190,4060,3930,3802,3800,3672,3542,3540,3412,3282,3282,3152,3024,3022,2894,2892,2764,2634,2634,2504,2376,2374,2246,2246,2116,2116,1988,1986,1858,1856,1728,1728,1598,1598,1468,1468,1468,1338,1338,1210,1210,1208,1080,1080,950,950,950,822,820,692,692,692,562,562,562,432,432,432,304,304,302,302,174,174,172,44,44,44,44,170,170,170,170,298,296,296,296,424,424,424,422,422,550,550,550,550,548,676,676,676,676,804,804,802,802,802,802,930,930
  dc.w    992,992,992,862,862,862,862,862,734,734,732,732,732,604,604,604,604,602,474,474,474,474,346,344,344,344,344,216,216,214,86,86,86,86,212,212,212,210,338,338,338,466,466,464,592,592,592,718,718,718,846,844,844,972,970,1098,1098,1096,1224,1224,1352,1350,1478,1478,1476,1604,1604,1730,1858,1858,1856,1984,1984,2110,2110,2236,2236,2364,2490,2490,2616,2744,2742,2870,2868,2996,3124,3122,3248,3376,3374,3502,3628,3756,3754,3880,4008,4134,4262,4260,4386,4514,4640,4766,4764,4892,5018,5144,5142,5270,5396,5522,5520,5646,5772,5770,5896,5894,5892,5890,5888,6014,6012,6010,6008,5880,5876,5746,5616,5614,5484,5356,5226,5224,5094,4966,4836,4834,4706,4576,4446,4316,4316,4186,4056,3928,3798,3796,3668,3538,3538,3408,3280,3278,3150,3020,2892,2890,2762,2632,2632,2502,2502,2372,2244,2244,2114,2114,1986,1984,1856,1854,1726,1726,1596,1596,1468,1466,1466,1338,1338,1208,1208,1208,1078,1078,950,948,820,820,820,690,690,690,562,560,560,432,432,430,302,302,302,302,172,172,172,44,42,42,42,170,170,168,168,296,296,296,296,422,422,422,422,550,550,548,548,548,676,676,676,676,674,802,802,802,802,802,928,928
  dc.w    992,992,992,864,864,862,862,862,734,734,734,734,606,604,604,604,604,476,476,476,474,474,346,346,344,344,216,216,216,216,88,86,86,214,212,212,212,340,340,340,466,466,466,594,592,592,720,720,718,846,846,846,972,972,1100,1100,1098,1226,1226,1352,1352,1480,1478,1478,1606,1604,1732,1732,1860,1858,1986,1984,2112,2240,2238,2238,2366,2492,2492,2618,2746,2744,2872,2998,2998,3124,3252,3380,3378,3504,3504,3630,3886,3884,4012,4138,4264,4264,4390,4518,4644,4770,4896,5024,5150,5276,5274,5530,5528,5782,5908,5906,6032,6158,6284,6282,6408,6534,6534,6530,6528,6654,6650,6650,6520,6390,6388,6258,6256,5998,5996,5866,5608,5480,5478,5348,5218,5090,4960,4830,4700,4572,4442,4440,4312,4184,4052,3924,3794,3794,3664,3536,3406,3278,3276,3148,3018,3018,2888,2760,2758,2630,2502,2500,2372,2242,2242,2242,2112,1984,1982,1854,1854,1724,1724,1596,1594,1466,1466,1464,1336,1336,1206,1206,1078,1078,1076,948,948,820,818,818,690,690,688,560,560,558,430,430,430,302,300,300,172,172,170,170,42,42,42,168,168,168,168,296,296,296,294,422,422,422,422,420,548,548,548,548,548,676,674,674,674,802,802,802,800,800,800,928
  dc.w    992,992,864,864,864,864,864,736,734,734,734,734,606,606,604,604,604,476,476,476,476,346,346,346,346,218,216,216,216,88,88,88,86,214,214,214,342,342,340,340,468,468,466,594,594,594,720,720,720,848,846,974,974,972,1100,1100,1228,1226,1354,1354,1352,1480,1480,1608,1606,1734,1734,1860,1860,1988,1986,2114,2242,2240,2240,2366,2494,2494,2620,2748,2746,2874,3000,3128,3126,3254,3380,3380,3508,3634,3760,3888,3886,4014,4140,4268,4394,4520,4648,4774,4900,5156,5154,5280,5406,5534,5788,5914,6298,6166,6294,6932,6674,6800,6926,7052,7562,7304,7430,7428,7424,7550,7548,7416,7286,7286,7026,6896,6766,6638,6378,6250,6120,5990,5860,5602,5474,5344,5214,5084,5084,4826,4696,4568,4568,4308,4180,4050,4050,3920,3792,3662,3534,3532,3404,3274,3146,3016,3016,2886,2758,2756,2628,2500,2498,2370,2240,2240,2240,2110,1982,1982,1852,1852,1722,1722,1594,1594,1464,1464,1336,1334,1334,1206,1204,1076,1076,948,946,946,818,818,816,688,688,560,558,558,558,430,428,300,300,300,300,170,170,170,42,40,40,40,168,168,168,168,294,294,294,294,422,422,420,420,548,548,548,546,546,674,674,674,674,674,802,800,800,800,800,928
  dc.w    994,866,864,864,864,864,864,736,736,736,734,606,606,606,606,606,478,476,476,476,476,348,348,346,346,218,218,218,216,88,88,88,216,216,214,214,342,342,340,468,468,468,596,594,594,722,722,720,848,848,976,976,974,1102,1102,1228,1228,1228,1354,1354,1482,1482,1608,1608,1608,1734,1862,1862,1988,1988,2116,2114,2242,2370,2368,2496,2494,2622,2750,2748,2876,3002,3130,3128,3256,3382,3510,3508,3636,3764,3890,4016,4144,4270,4398,4524,4652,4778,4904,5032,5158,5284,5540,5666,5920,6046,6174,6300,6554,6808,7062,7318,7572,7954,16,526,876,1008,1014,1020,898,904,910,916,794,1010,112,7918,7662,7404,7146,6888,6758,6372,6242,6114,5856,5726,5596,5468,5210,5080,4952,4952,4694,4564,4434,4306,4176,4048,3918,3790,3788,3530,3530,3402,3272,3272,3014,3014,2884,2756,2756,2626,2498,2496,2368,2238,2238,2110,2108,1980,1980,1852,1850,1722,1592,1592,1592,1464,1462,1334,1334,1204,1204,1204,1076,1074,946,946,944,816,816,688,686,686,558,558,556,428,428,428,300,300,298,170,170,170,168,40,40,40,168,168,166,166,294,294,294,292,420,420,420,420,420,546,546,546,546,546,674,674,674,672,800,800,800,800,800,928
  dc.w    994,866,866,864,866,864,864,736,736,736,736,606,606,606,606,606,478,478,476,476,348,348,348,348,220,218,218,218,90,90,88,88,216,216,216,344,342,342,342,470,470,596,596,596,596,724,722,850,848,848,976,976,1104,1104,1102,1230,1230,1356,1356,1484,1482,1610,1610,1608,1736,1864,1864,1990,1990,2118,2116,2244,2372,2370,2498,2496,2624,2750,2878,2878,3004,3132,3258,3258,3384,3512,3512,3766,3764,4020,4020,4404,4274,4400,4526,4782,4908,5036,5162,5288,5544,5670,5924,6180,6306,6560,6816,7070,7324,7706,26,8012,8146,216,352,354,620,624,630,764,642,648,526,532,410,286,294,42,8114,7864,102,7782,7396,7138,6882,6624,6366,6108,6108,5722,5592,5336,5336,5078,4948,4818,4562,4432,4304,4174,4044,3916,3788,3786,3656,3528,3400,3270,3142,3140,3012,2882,2882,2752,2624,2496,2494,2366,2366,2236,2236,2108,1978,1978,1850,1848,1720,1592,1590,1590,1462,1460,1332,1332,1204,1202,1074,1074,1072,944,944,816,814,814,686,686,558,556,556,556,428,426,298,298,298,298,168,168,168,40,40,40,38,166,166,166,166,292,292,292,292,420,420,420,418,546,546,546,546,546,672,672,672,672,672,800,800,800,798,798
  dc.w    994,866,866,866,866,866,738,736,736,736,608,608,608,608,606,478,478,478,478,478,348,348,348,348,220,220,220,90,90,90,90,218,218,216,216,344,344,344,470,470,470,598,596,596,724,724,852,850,850,978,978,976,1104,1104,1232,1230,1358,1358,1486,1484,1484,1612,1610,1738,1866,1864,1992,1992,2118,2118,2246,2244,2372,2500,2498,2754,2752,2752,2880,3006,3134,3262,3260,3388,3514,3642,3768,4024,4022,4150,4276,4404,4530,4658,4784,5038,5166,5550,5420,5674,5928,6312,6310,6566,6948,7460,7586,8096,800,7232,7496,7628,7892,8026,8160,8160,236,240,374,380,258,264,142,148,282,8096,8100,7850,7728,7736,7358,7108,736,8032,7646,7260,7004,6618,6362,6232,5976,5718,5460,5332,5202,5074,4816,4686,4558,4428,4300,4042,4042,3912,3784,3656,3526,3396,3268,3268,3138,3010,2882,2752,2752,2622,2494,2494,2364,2236,2236,2106,2106,1976,1976,1848,1848,1718,1590,1590,1460,1460,1460,1332,1330,1202,1202,1072,1072,944,944,942,814,814,814,684,684,556,556,556,426,426,426,298,296,296,168,168,168,166,38,38,38,166,166,164,164,292,292,292,292,420,418,418,418,418,546,546,544,544,544,672,672,672,672,800,798,798,798,798
  dc.w    994,866,866,866,866,866,738,738,738,736,608,608,608,608,608,478,480,478,478,478,350,350,350,220,220,220,220,92,92,90,90,218,218,218,344,344,344,344,472,472,598,598,598,726,724,724,852,852,980,978,978,1106,1104,1232,1232,1232,1358,1358,1486,1486,1612,1612,1740,1738,1866,1866,1994,2120,2120,2248,2246,2374,2500,2500,2628,2756,2882,2882,3008,3136,3264,3262,3390,3516,3644,3770,3898,4024,4152,4278,4406,4534,4660,4916,5042,5168,5424,5678,5934,6060,6316,6570,6952,7464,7720,38,1064,6452,6586,6716,7240,7372,7508,7640,7776,7910,8044,8176,8184,8188,8066,8070,8076,7956,7960,7838,7716,7594,7472,7222,6974,6724,6476,6098,1112,90,7770,7384,7000,6872,6356,6100,5842,5714,5456,5200,5070,4942,4812,4556,4426,4298,4168,4040,3910,3782,3652,3524,3396,3394,3266,3136,3008,2878,2750,2750,2620,2492,2492,2362,2234,2234,2104,2104,1976,1846,1846,1718,1716,1588,1588,1460,1458,1330,1330,1200,1200,1200,1072,1070,942,942,942,812,812,684,684,684,554,554,554,426,424,424,296,296,296,166,166,166,38,38,38,36,164,164,164,164,292,290,290,418,418,418,418,416,544,544,544,544,544,672,672,670,670,798,798,798,798,798
  dc.w    868,868,868,868,866,738,738,738,738,738,610,608,608,608,480,480,480,480,478,350,350,350,350,222,222,220,220,92,92,92,220,220,218,218,346,346,346,472,472,472,600,600,598,726,726,854,852,852,980,980,1106,1106,1234,1234,1232,1360,1360,1488,1486,1614,1614,1740,1740,1868,1868,1994,1994,2122,2248,2248,2376,2502,2502,2630,2756,2884,2884,3010,3138,3264,3264,3392,3518,3646,3902,3900,4028,4154,4280,4408,4792,4790,4918,5172,5300,5684,5810,5936,6192,6446,6958,7470,7596,44,940,5156,5416,5940,6330,6594,6726,6988,7252,7384,7522,7654,7660,7792,7800,7804,7682,7686,7692,7572,7576,7582,7460,7336,7088,6964,6716,6466,6218,5842,5464,4962,980,84,7636,7252,6738,6482,6224,5968,5838,5582,5324,5068,4938,4810,4552,4424,4424,4166,4036,3908,3780,3650,3522,3392,3264,3264,3134,3006,3006,2748,2748,2618,2490,2490,2360,2232,2232,2102,2102,1974,1844,1844,1716,1716,1586,1586,1458,1458,1328,1328,1200,1198,1070,1070,1070,940,940,812,812,812,682,682,554,554,552,424,424,424,296,294,294,166,166,166,166,36,36,36,164,164,164,162,290,290,290,290,418,416,416,416,416,544,544,544,544,670,670,670,670,670,798,798,798,796
  dc.w    868,868,868,868,868,740,740,738,738,610,610,610,610,610,480,480,480,480,480,352,352,352,222,222,222,222,94,94,92,92,220,220,218,346,346,346,474,474,472,600,600,600,728,728,726,854,854,982,980,980,1108,1108,1234,1234,1362,1362,1488,1488,1616,1614,1614,1742,1870,1868,1996,1996,2122,2250,2250,2378,2504,2504,2632,2758,2758,2886,3012,3140,3266,3394,3394,3520,3648,3776,3902,4028,4286,4412,4538,4666,4792,5048,5174,5430,5558,5940,6068,6322,6964,7090,7472,7856,1076,3732,4120,4900,5422,5556,6078,6338,6474,6604,6736,7000,7266,7398,7404,7536,7544,7546,7426,7430,7436,7442,7320,7198,7076,6952,6704,6580,6460,6210,5832,5584,5208,4704,4074,3316,464,8016,7376,6992,6734,6350,6092,5836,5580,5450,5194,5064,4936,4678,4550,4420,4164,4034,4034,3778,3648,3520,3392,3262,3262,3132,3004,2874,2746,2746,2616,2488,2360,2358,2230,2230,2102,1972,1972,1844,1844,1714,1586,1586,1456,1456,1456,1326,1326,1198,1198,1068,1068,940,940,940,810,810,682,682,680,552,552,552,424,424,294,294,294,294,166,164,164,36,36,36,36,162,162,162,162,290,290,288,416,416,416,416,416,544,542,542,542,542,670,670,670,670,796,796,796,796
  dc.w    870,868,868,868,868,740,740,740,740,610,610,610,610,610,482,482,482,480,352,352,352,352,224,224,222,222,94,94,94,222,220,220,348,348,348,346,474,474,474,602,600,600,728,728,856,856,854,982,982,1110,1108,1236,1236,1234,1362,1362,1490,1490,1616,1616,1744,1872,1870,1870,1998,2124,2252,2252,2380,2378,2506,2634,2632,2760,2888,3014,3142,3268,3268,3396,3522,3778,3776,3904,4032,4158,4414,4542,4798,4924,5050,5178,5432,5688,6072,6198,6454,6836,7220,7604,52,950,2698,3476,4126,4776,5040,5300,5694,5954,6218,6348,6484,6748,6748,7014,7148,7154,7158,7292,7170,7174,7052,7058,6936,6814,6690,6568,6446,6324,6074,5824,5576,5198,4950,4446,3944,3314,2302,970,76,7628,7244,6858,6474,6218,5962,5704,5576,5190,5062,4932,4676,4548,4418,4162,4032,3904,3776,3646,3518,3518,3260,3260,3130,3002,2874,2744,2744,2616,2486,2358,2358,2228,2100,2100,1972,1970,1842,1714,1712,1584,1584,1454,1454,1326,1326,1198,1196,1196,1068,1068,938,938,810,810,808,680,680,552,552,552,422,422,422,294,294,292,164,164,164,164,36,34,34,162,162,162,160,288,288,288,288,416,416,416,414,414,542,542,542,542,670,670,668,668,796,796,796,796
  dc.w    870,870,870,868,740,740,740,740,612,612,612,612,610,482,482,482,482,482,354,352,352,352,224,224,224,96,94,94,94,222,222,220,348,348,348,476,474,474,602,602,602,730,728,728,856,856,984,984,1110,1110,1110,1236,1236,1364,1364,1492,1490,1618,1618,1746,1744,1872,1872,1998,2126,2126,2254,2380,2380,2508,2634,2634,2762,2888,3016,3144,3272,3270,3398,3524,3652,3780,3906,4034,4160,4416,4544,4670,4926,5054,5438,5436,5820,6074,6330,6586,6968,7352,7736,184,1854,1536,2832,3482,3742,4132,4654,5176,5438,5570,5834,5964,6360,6492,6498,6630,6766,6770,6770,6908,6786,6790,6668,6674,6680,6558,6434,6440,6190,5940,5690,5568,5318,4940,4564,4188,3684,3054,2300,906,1350,200,7752,7368,6984,6728,6214,5958,5702,5444,5188,5060,4930,4674,4544,4416,4160,4030,3902,3902,3644,3516,3386,3258,3130,3128,3000,2872,2742,2614,2614,2484,2356,2228,2228,2098,2098,1970,1840,1840,1712,1710,1582,1582,1454,1454,1324,1324,1196,1196,1066,1066,1066,938,936,808,808,680,680,678,550,550,550,422,422,420,292,292,292,164,164,162,34,34,34,34,162,160,160,288,288,288,288,416,414,414,414,414,542,542,540,540,668,668,668,668,668,796,796,796
  dc.w    870,870,870,870,742,742,740,740,612,612,612,612,612,482,482,482,482,354,354,354,354,224,224,224,224,96,96,96,222,222,222,222,350,350,348,476,476,476,604,602,602,730,730,858,856,856,984,984,1112,1112,1238,1238,1366,1364,1492,1492,1620,1620,1618,1746,1874,1872,2000,2000,2128,2256,2254,2382,2508,2508,2636,2764,2890,3018,3018,3144,3272,3400,3526,3654,3782,3908,4036,4164,4418,4546,4802,4928,5056,5310,5438,5694,6078,6332,6846,6972,7742,62,316,1472,7660,1542,2708,2836,3750,4008,4660,4920,5054,5314,5578,5842,5976,6108,6242,6376,6510,6512,6520,6524,6402,6406,6412,6418,6422,6302,6178,6056,6062,5556,5560,5184,4934,4682,4308,3930,3426,2922,2168,1028,7194,1346,324,8004,7492,6980,6596,6340,5956,5698,5570,5314,5056,4928,4670,4542,4414,4286,4028,3900,3770,3642,3514,3384,3256,3128,2998,2998,2870,2740,2612,2484,2484,2354,2226,2226,2096,1968,1968,1838,1838,1710,1582,1582,1452,1452,1452,1324,1322,1194,1194,1066,1064,1064,936,808,808,806,678,678,550,550,548,420,420,420,420,292,290,162,162,162,162,34,34,32,160,160,160,160,288,288,286,414,414,414,414,414,540,540,540,540,540,668,668,668,668,794,794,794
  dc.w    870,870,870,870,742,742,742,742,614,612,612,612,612,484,484,484,484,354,354,354,354,226,226,226,96,96,96,96,224,222,222,350,350,350,350,476,476,604,604,604,732,730,730,858,858,986,986,1112,1112,1112,1240,1240,1366,1366,1494,1492,1620,1620,1748,1746,1874,2002,2002,2128,2256,2256,2384,2382,2510,2638,2764,2892,3020,3020,3146,3274,3402,3528,3656,3784,4040,4038,4166,4420,4548,4676,4930,5058,5442,5698,5696,6080,6336,6590,6974,7488,322,834,1604,4436,378,1674,2452,2714,3364,3752,4014,4538,4798,4930,5324,5456,5592,5724,5858,5990,6126,6258,6264,6268,6146,6150,6156,6034,6038,5916,5792,5672,5548,5426,5176,4926,4676,4298,4050,3674,3168,2666,2034,1024,7950,4270,1468,448,8000,7362,6978,6594,6336,6080,5824,5568,5310,5054,4926,4668,4540,4284,4154,4026,3898,3768,3640,3512,3382,3254,3126,2996,2868,2740,2740,2610,2482,2354,2352,2224,2224,2094,1966,1966,1838,1838,1708,1580,1580,1452,1450,1322,1322,1194,1192,1064,1064,1064,936,934,806,806,678,678,676,548,548,548,420,418,418,290,290,290,162,162,160,32,32,32,32,160,160,158,286,286,286,286,414,414,412,412,540,540,540,540,540,668,666,666,666,794,794,794
  dc.w    872,872,870,742,742,742,742,614,614,614,614,612,484,484,484,484,484,356,354,354,226,226,226,226,98,98,98,96,224,224,224,352,350,350,478,478,478,606,604,604,732,732,860,858,858,986,986,1114,1114,1242,1240,1368,1368,1496,1496,1622,1622,1750,1748,1876,1876,2002,2130,2130,2258,2386,2384,2512,2640,2638,2766,2894,3022,3148,3276,3404,3530,3530,3786,3912,4040,4168,4424,4552,4678,4806,5060,5188,5444,5828,6082,6338,6722,6978,7490,8002,968,1608,3538,6374,384,1680,1680,2718,2850,3630,3892,4152,4416,4936,4940,5202,5336,5466,5602,5606,5742,5874,5880,5884,5762,5766,5772,5778,5654,5532,5536,5414,5164,5042,5048,4670,4418,4170,3792,3416,2910,2534,1904,1146,8072,6424,2994,1466,444,7998,7358,6974,6590,6334,6078,5694,5436,5308,5052,4922,4666,4538,4280,4152,4024,3896,3766,3510,3510,3380,3252,3124,2996,2866,2738,2738,2610,2480,2352,2224,2222,2094,2094,1966,1836,1836,1708,1708,1578,1578,1450,1450,1320,1320,1192,1192,1064,1062,934,934,806,806,804,676,676,548,548,548,418,418,418,290,290,290,160,160,160,32,32,32,30,158,158,158,286,286,286,286,412,412,412,412,412,540,540,540,538,538,666,666,666,666,794,794
  dc.w    872,872,872,744,744,742,742,614,614,614,614,614,486,486,486,484,356,356,356,356,228,228,226,226,98,98,98,226,224,224,352,352,352,352,480,478,606,606,606,734,732,732,860,860,988,988,1114,1114,1242,1242,1242,1370,1368,1496,1496,1624,1622,1750,1878,1878,2004,2004,2132,2260,2258,2386,2514,2512,2640,2768,2896,3022,3022,3278,3278,3404,3532,3660,3788,4042,4170,4298,4424,4680,4808,5064,5320,5576,5830,5958,6212,6596,6980,7752,72,326,1096,2510,5606,7286,390,1296,1684,2462,2724,3246,3636,3768,4160,4552,4684,4948,4952,5214,5346,5480,5486,5618,5624,5628,5506,5510,5516,5522,5398,5276,5152,5030,4906,4786,4534,4542,4162,3784,3534,3158,2782,2276,1772,1014, 4,6928,4898,2482,1080,314,7994,7482,6972,6588,6204,6074,5690,5434,5178,5048,4792,4664,4408,4278,4150,4022,3764,3764,3508,3380,3380,3250,2994,2994,2864,2736,2608,2480,2478,2350,2222,2222,2092,1964,1964,1836,1834,1706,1578,1578,1448,1448,1320,1320,1192,1190,1062,1062,1062,934,932,804,804,804,676,674,546,546,546,418,418,288,288,288,288,160,160,160,30,30,30,158,158,158,158,284,284,284,284,412,412,412,412,538,538,538,538,538,666,666,666,664,792,792
  dc.w    872,872,872,744,744,744,744,616,614,614,614,486,486,486,486,486,356,358,356,356,228,228,228,100,98,98,98,226,226,226,354,352,352,480,480,480,608,608,606,734,734,862,860,860,988,988,1116,1116,1244,1242,1370,1370,1498,1498,1624,1624,1752,1752,1880,1878,2006,2134,2132,2260,2388,2388,2514,2642,2770,2898,2896,3024,3152,3278,3406,3534,3662,3788,4044,4172,4428,4426,4554,4810,5066,5192,5448,5704,5960,6216,6600,6984,7368,7752,330,1100,2776,3674,5608,7418,394,1300,1690,2468,2728,2862,3252,3774,4034,4036,4300,4564,4696,4958,4962,5096,5100,5234,5240,5372,5250,5126,5132,5138,5014,4892,4896,4774,4650,4400,4278,4028,3776,3528,3278,2900,2524,2146,1514,884,126,7178,5528,3624,2096,948,310,7864,7352,6968,6584,6200,5944,5688,5432,5176,5046,4790,4534,4406,4276,4148,3892,3764,3634,3506,3378,3248,3120,2992,2864,2862,2734,2606,2478,2348,2348,2220,2092,2090,1962,1834,1834,1704,1704,1576,1576,1448,1446,1318,1318,1190,1190,1062,1060,932,932,804,802,802,674,674,546,546,544,416,416,416,288,288,288,160,158,158,30,30,30,30,156,156,156,284,284,284,284,412,410,410,410,410,538,538,538,538,664,664,664,664,792,792
  dc.w    874,872,746,744,744,744,616,616,616,616,616,488,486,486,486,486,358,358,358,230,228,228,228,100,100,100,228,226,226,226,354,354,354,482,480,608,608,608,736,736,734,862,862,990,990,1118,1116,1244,1244,1244,1370,1370,1498,1498,1626,1626,1752,1880,1880,2008,2136,2136,2262,2262,2388,2516,2644,2644,2770,2898,3026,3154,3282,3408,3536,3664,3792,3918,4046,4174,4430,4556,4812,5068,5196,5580,5578,5962,6218,6988,6986,7500,7756,76,1106,1746,3292,4580,6518,7296,528,916,1694,1696,2344,2868,2868,3390,3650,3784,4044,4176,4312,4576,4708,4842,4844,4978,4982,4988,4866,4870,4876,4882,4758,4636,4512,4390,4266,4144,4020,3770,3520,3270,2892,2642,2266,1760,1384,754,8184,7300,6032,4382,2982,1710,818,52,7732,7222,6838,6582,6198,5942,5558,5302,5172,4916,4788,4532,4404,4274,4018,3890,3760,3632,3504,3376,3248,3118,2990,2990,2732,2604,2604,2476,2348,2218,2218,2090,1962,1960,1832,1832,1704,1576,1574,1446,1446,1318,1318,1188,1188,1188,1060,1060,930,930,802,802,674,674,672,544,544,544,416,416,288,286,286,158,158,158,158,28,28,28,156,156,156,156,284,282,282,410,410,410,410,410,538,538,536,536,664,664,664,664,664,792
  dc.w    874,874,746,746,746,746,616,616,616,616,616,488,488,488,488,358,358,358,358,230,230,230,228,100,100,100,228,228,228,356,356,354,482,482,482,608,610,608,736,736,864,864,862,990,990,1118,1118,1244,1244,1372,1372,1500,1500,1626,1626,1754,1754,1882,2010,2008,2136,2264,2264,2392,2520,2518,2646,2772,2900,3028,3028,3282,3282,3410,3666,3794,3920,4048,4176,4304,4558,4686,4942,5070,5326,5582,5836,6092,6348,6732,7246,7630,210,722,1752,2652,3552,5488,6522,7558,144,532,1310,1700,2350,2612,2874,3134,3266,3528,3788,3924,4056,4188,4324,4458,4460,4594,4728,4732,4610,4614,4492,4496,4372,4378,4254,4132,4008,3886,3764,3514,3264,3014,2762,2512,2136,1630,1126,622,8182,7296,6282,5014,3616,2342,1452,558,8112,7602,7218,6708,6452,6068,5812,5556,5298,5042,4914,4658,4530,4402,4144,4016,3888,3760,3502,3374,3374,3246,2988,2988,2860,2732,2602,2474,2474,2346,2216,2216,2088,1960,1832,1830,1702,1702,1574,1574,1446,1444,1316,1316,1188,1188,1058,1058,930,930,802,802,800,672,672,544,544,544,414,414,414,286,286,286,158,156,156,28,28,28,156,156,154,154,282,282,282,282,410,410,408,408,536,536,536,536,536,664,664,664,662,790
  dc.w    874,874,746,746,746,746,618,618,616,616,616,488,488,488,488,360,360,360,358,230,230,230,102,102,102,100,228,228,228,356,356,356,482,482,482,610,610,738,738,738,864,864,992,992,1120,1118,1118,1246,1246,1374,1374,1500,1500,1628,1628,1756,1882,1882,2010,2138,2136,2264,2264,2392,2520,2648,2776,2774,2902,3030,3156,3284,3412,3540,3668,3794,3922,4178,4306,4562,4818,4944,5072,5200,5456,5840,6096,6352,6866,7120,7634,8018,338,982,2010,3686,4460,5622,6526,7562,148,406,1054,1704,1706,2228,2488,2878,3010,3272,3404,3668,3800,3936,4068,4202,4202,4340,4344,4348,4226,4230,4236,4240,4118,4122,3998,3876,3752,3630,3380,3256,3006,2756,2506,2128,1750,1372,996,490,8050,7420,6406,5264,4120,3356,1830,1066,302,7982,7472,6960,6704,6320,6064,5808,5424,5296,5040,4784,4656,4400,4270,4142,3886,3758,3628,3500,3372,3244,3116,2988,2858,2730,2730,2600,2472,2344,2344,2216,2088,2086,1958,1830,1830,1702,1572,1572,1444,1444,1316,1314,1186,1186,1058,1058,1058,928,928,800,800,672,672,672,542,542,414,414,414,286,284,284,156,156,156,28,28,26,26,154,154,154,282,282,282,280,408,408,408,408,536,536,536,536,534,662,662,662,662,790
  dc.w    876,748,746,746,746,746,618,618,618,618,490,488,488,488,488,360,360,360,232,232,232,230,102,102,102,230,230,230,358,356,356,356,484,484,612,610,610,738,738,866,866,866,992,992,1120,1120,1248,1248,1374,1374,1502,1502,1630,1630,1756,1756,1884,2012,2012,2138,2266,2266,2394,2520,2520,2648,2776,2904,3032,3160,3288,3414,3542,3540,3796,3924,4052,4308,4436,4562,4818,4946,5202,5458,5714,5970,6226,6610,6994,7378,7764,344,728,1628,2530,3558,4592,5624,6402,7178,8084,282,1060,1320,1710,1972,2232,2494,2754,2888,3148,3284,3416,3680,3812,3818,3950,3956,4088,4092,3970,3974,3980,3856,3860,3738,3742,3620,3368,3246,3124,2872,2750,2498,2250,2000,1620,1244,736,232,7922,7288,6526,5514,4370,3354,2336,1446,680,42,7724,7340,6958,6574,6190,5934,5678,5422,5166,4910,4910,4526,4398,4268,4012,3884,3756,3628,3498,3370,3242,3114,2984,2856,2728,2600,2472,2472,2342,2214,2214,2086,1958,1828,1828,1700,1700,1572,1570,1442,1442,1314,1314,1186,1184,1056,1056,928,928,800,800,798,670,670,542,542,542,412,412,284,284,284,284,156,154,154,26,26,26,154,154,154,152,280,280,280,408,408,408,408,408,534,534,534,534,662,662,662,662,790
  dc.w    876,748,748,748,748,618,618,618,618,618,490,490,490,490,362,360,360,360,232,232,232,232,104,104,102,230,230,230,358,358,358,486,484,484,612,612,612,740,738,866,866,994,994,994,1122,1120,1248,1248,1376,1376,1504,1504,1630,1630,1758,1886,1886,2014,2140,2140,2268,2266,2394,2522,2650,2778,2778,2906,3032,3160,3288,3416,3542,3800,3928,4056,4182,4308,4564,4692,4948,5076,5332,5588,5844,6100,6356,7000,7384,7640,8152,732,1116,2018,2788,3690,5370,5760,6406,7312,8090,286,546,1064,1328,1716,2110,2498,2632,2892,2894,3160,3292,3296,3428,3562,3694,3698,3832,3836,3714,3718,3722,3600,3604,3482,3358,3364,3112,2990,2866,2744,2622,2242,1992,1742,1364,984,480,102,7788,7158,6526,5636,4622,3606,2716,1824,1060,422,7976,7594,7210,6700,6444,6060,5804,5548,5292,5036,4908,4652,4396,4266,4138,4010,3754,3626,3498,3368,3368,3112,2984,2856,2854,2726,2598,2470,2342,2214,2212,2084,2084,1956,1828,1826,1698,1570,1570,1442,1442,1312,1312,1184,1184,1056,1056,926,926,926,798,798,670,668,540,540,540,412,412,412,284,282,282,154,154,154,26,26,26,152,152,152,152,280,280,280,280,406,406,406,406,534,534,534,534,534,662,662,660,660
  dc.w    876,748,748,748,748,620,620,620,618,618,490,490,490,490,362,362,360,362,232,232,232,104,104,104,104,232,232,232,358,358,358,486,486,614,614,612,740,740,740,868,866,996,994,1122,1122,1250,1250,1248,1376,1504,1504,1632,1632,1760,1760,1886,1886,2014,2142,2270,2268,2396,2524,2524,2650,2780,2906,3034,3162,3290,3418,3544,3672,3800,3928,4056,4312,4440,4566,4824,5080,5336,5592,5718,6104,6360,6616,7000,7384,8028,220,1122,1506,2278,3696,4342,5376,6022,6410,7316,7574,30,420,1070,1332,1592,1722,2114,2376,2508,2770,2904,2908,3170,3172,3306,3310,3314,3448,3452,3330,3334,3338,3216,3220,3226,3102,2978,2854,2732,2482,2486,2108,1984,1734,1356,1106,728,350,8164,7658,7024,6392,5632,4744,3856,2966,2456,1440,802,164,7846,7336,6952,6568,6314,6058,5802,5418,5162,5034,4778,4522,4392,4264,4008,3880,3752,3624,3496,3368,3240,3110,2982,2854,2726,2596,2468,2468,2340,2212,2212,2082,1954,1826,1826,1698,1698,1568,1568,1440,1312,1312,1184,1182,1182,1054,1054,926,926,798,796,668,668,668,540,540,540,412,410,282,282,282,154,154,154,24,24,24,24,152,152,152,280,280,278,278,406,406,406,406,534,534,534,534,532,660,660,660,660
  dc.w    878,748,748,748,748,620,620,620,620,492,492,492,490,490,362,362,362,234,234,234,234,106,104,104,232,232,232,360,360,358,358,486,486,614,614,614,740,742,870,868,868,996,996,1124,1122,1250,1250,1378,1378,1506,1506,1634,1632,1760,1888,1888,2014,2014,2142,2270,2270,2398,2526,2654,2780,2908,2908,3036,3292,3292,3418,3546,3674,3802,4058,4184,4440,4568,4696,4952,5208,5336,5592,5976,6232,6490,7132,7388,7644,8156,610,994,1894,2540,3440,4602,4992,6154,6156,7060,7450,36,424,426,1076,1336,1598,1730,1992,2254,2386,2520,2652,2914,2918,2922,3054,3058,3192,3196,3074,3078,3082,2960,2964,2842,2844,2722,2598,2476,2226,2102,1980,1728,1350,1098,848,470,220,7906,7400,6896,6262,5758,4868,3980,3218,2454,1692,926,418,8098,7588,7206,6822,6438,6184,5928,5544,5288,5032,4904,4648,4520,4264,4134,4006,3750,3750,3494,3366,3238,3108,2980,2852,2852,2724,2596,2468,2338,2210,2210,2082,1954,1952,1824,1824,1696,1568,1568,1440,1438,1310,1310,1182,1182,1054,1054,924,924,796,796,796,668,668,538,538,538,410,410,282,282,280,280,152,152,152,24,24,24,152,152,150,150,278,278,278,406,406,406,406,404,532,532,532,532,660,660,660,660
  dc.w    750,750,748,750,748,622,620,620,620,492,492,492,492,364,364,364,362,234,234,234,234,106,106,106,232,232,232,360,360,360,488,488,488,616,614,614,742,742,870,870,998,996,1124,1124,1124,1252,1252,1380,1378,1506,1506,1634,1634,1762,1890,2018,2016,2144,2144,2270,2400,2528,2526,2654,2782,2910,3038,3164,3292,3420,3548,3676,3804,4060,4188,4314,4442,4570,4826,5082,5210,5596,5850,6108,6364,6748,7004,7390,7774,226,998,2028,2026,2800,3574,4348,5254,5512,6160,7066,7582,7584,40,430,560,952,1214,1474,1736,1868,2130,2264,2396,2530,2662,2796,2800,2802,2936,2940,2818,2822,2826,2704,2836,2584,2460,2466,2342,2090,2096,1844,1722,1342,1092,970,590,212,8154,7648,7270,6764,6258,5624,4864,4104,3342,2578,1944,1940,670,32,7714,7330,6948,6564,6308,6054,5798,5414,5158,5030,4774,4518,4390,4262,4006,3876,3748,3620,3492,3364,3236,3108,2978,2850,2722,2594,2466,2466,2338,2210,2080,2080,1952,1824,1824,1696,1566,1566,1438,1438,1310,1310,1180,1180,1052,1052,1052,924,924,796,794,666,666,538,538,538,410,410,408,280,280,280,152,152,152,24,22,22,150,150,150,150,278,278,278,404,404,404,404,404,532,532,532,532,660,660,658,658
  dc.w    750,750,750,750,622,622,622,622,622,492,492,492,492,364,364,364,364,234,234,234,106,106,106,106,234,234,234,362,360,360,488,488,616,616,616,744,744,742,870,870,998,998,1126,1126,1252,1252,1380,1380,1508,1508,1634,1636,1764,1762,1890,2018,2018,2146,2274,2402,2400,2528,2656,2784,2784,2912,3038,3166,3294,3422,3550,3678,3804,4062,4188,4316,4572,4700,4956,5084,5340,5596,5980,6236,6494,6878,7394,7650,8034,356,1000,1644,2288,2802,3576,4224,5386,5516,6420,6550,7198,7588,7848,46,436,696,958,1220,1352,1612,1746,2008,2140,2274,2406,2540,2544,2546,2552,2556,2434,2438,2442,2448,2452,2328,2204,2082,2086,1834,1712,1588,1336,1214,962,712,334,82,7896,7518,7140,6634,6128,5624,4988,4228,3464,2702,2066,1684,922,284,7966,7584,7202,6818,6434,6180,5796,5540,5284,5028,4900,4644,4516,4260,4132,4004,3748,3618,3490,3362,3234,3106,2978,2850,2722,2720,2592,2464,2336,2208,2208,2080,1950,1950,1822,1694,1694,1566,1566,1436,1436,1308,1308,1180,1180,1052,1050,922,922,794,794,666,666,664,536,536,408,408,408,280,280,280,150,150,150,22,22,22,22,150,150,150,276,276,276,276,404,404,404,404,532,530,530,530,530,658,658,658
  dc.w    750,752,750,750,622,622,622,622,622,494,494,494,494,364,364,364,364,236,236,236,108,108,108,234,234,234,234,362,362,362,490,490,616,616,616,744,744,872,872,872,1000,998,1126,1126,1254,1254,1382,1382,1510,1508,1636,1636,1764,1892,1892,2020,2146,2146,2274,2402,2402,2530,2658,2786,2914,3040,3168,3296,3424,3552,3678,3806,3934,4062,4318,4446,4574,4830,5086,5214,5470,5856,6242,6370,6754,7010,7394,7780,102,1004,1132,1904,2678,3450,3710,4486,5002,5520,6036,6426,7204,7332,7592,52,312,574,702,834,1098,1358,1492,1752,1756,2018,2150,2156,2160,2162,2296,2300,2178,2182,2186,2064,2068,2072,1948,1824,1702,1578,1454,1332,1080,830,706,456,204,8018,7638,7388,6882,6502,5998,5490,4986,4224,3590,2826,2190,1556,918,408,26,7708,7326,6942,6560,6304,6048,5666,5410,5154,5026,4770,4514,4386,4258,4002,3874,3746,3616,3488,3360,3232,3104,2976,2848,2720,2592,2464,2334,2334,2206,2078,2078,1950,1822,1820,1692,1564,1564,1436,1436,1308,1306,1178,1178,1050,1050,922,922,794,794,792,664,664,536,536,536,408,406,278,278,278,150,150,150,150,22,22,20,148,148,148,276,276,276,276,404,404,404,402,530,530,530,530,530,658,658,658
  dc.w    752,752,752,752,622,622,622,622,622,494,494,494,494,366,366,366,238,236,236,236,108,108,108,236,236,236,364,362,362,490,490,490,618,618,618,746,744,872,872,1000,1000,1000,1128,1126,1256,1254,1382,1510,1510,1638,1638,1766,1766,1892,1892,2020,2148,2276,2276,2402,2532,2658,2658,2786,2914,3042,3170,3298,3426,3554,3810,3938,4066,4194,4450,4578,4834,4962,5218,5346,5602,5858,6114,6370,6754,7140,7656,7910,232,748,1392,1906,2422,3456,3584,4230,5264,5264,6170,6558,6948,7336,7598,7988,56,318,578,580,842,1102,1236,1370,1502,1634,1768,1772,1904,1906,2040,2044,1922,1926,1930,2064,1810,1688,1692,1568,1446,1320,1198,1076,1080,572,448,198,8138,7888,7508,7130,6752,6246,5866,5360,4856,4348,3586,2950,2316,1808,1170,1040,152,7834,7452,7068,6686,6430,6046,5790,5536,5280,5024,4896,4640,4512,4256,4128,4000,3744,3616,3488,3360,3232,3102,2974,2974,2718,2590,2590,2462,2332,2204,2204,2076,1948,1820,1820,1692,1692,1562,1562,1434,1306,1306,1178,1178,1050,1048,920,920,920,792,792,664,664,536,536,534,406,406,406,278,278,278,150,148,148,20,20,20,148,148,148,148,276,274,274,402,402,402,402,402,530,530,530,530,658,656,656
  dc.w    752,752,752,752,624,624,624,624,496,494,494,494,494,366,366,366,238,238,238,238,110,108,108,236,236,236,364,364,364,492,492,490,618,618,618,746,746,874,874,1002,1002,1128,1128,1256,1256,1384,1384,1512,1512,1638,1638,1766,1894,1894,2022,2022,2148,2276,2276,2404,2532,2660,2788,2916,2914,3044,3300,3298,3426,3554,3810,3938,4066,4194,4450,4578,4834,5090,5218,5476,5730,5988,6244,6630,7014,7270,7656,8172,364,1008,1782,2038,2554,3200,3588,4362,4880,5268,5786,6174,6434,6952,7342,7604,7864,62,194,456,586,850,980,1112,1246,1378,1382,1516,1648,1652,1784,1790,1666,1670,1674,1550,1554,1432,1308,1312,1188,1064,1070,690,566,444,192,8134,7882,7630,7252,6872,6494,6114,5738,5360,4852,4216,3584,2948,2312,1804,1294,912,276,7958,7576,7194,6810,6556,6172,5918,5662,5406,5150,5022,4766,4510,4382,4126,3998,3870,3742,3486,3358,3358,3230,2974,2846,2844,2716,2588,2460,2332,2204,2204,2076,1946,1946,1818,1690,1690,1562,1562,1434,1434,1306,1304,1176,1176,1048,1048,920,920,792,790,662,662,534,534,534,406,406,406,276,276,276,148,148,148,20,20,20,148,146,146,146,274,274,274,402,402,402,402,402,530,528,528,528,656,656,656
  dc.w    752,752,752,624,624,624,624,624,496,496,496,496,368,366,368,366,238,238,238,110,110,110,110,238,238,236,364,364,364,492,492,620,620,620,748,746,746,874,874,1002,1002,1130,1130,1258,1256,1384,1384,1512,1512,1640,1640,1768,1894,1894,2022,2150,2278,2278,2406,2406,2534,2662,2790,2916,3044,3172,3300,3428,3556,3684,3812,3940,4196,4324,4452,4708,4964,5092,5348,5734,5860,6118,6374,6760,7016,7532,7788,8172,496,1010,1526,2040,2688,3334,3590,4496,4496,5402,5530,5918,6308,6696,6958,7348,7608,7870,8130,202,460,594,728,858,990,1122,1126,1260,1392,1396,1400,1406,1282,1286,1290,1294,1298,1176,1052,1054,932,936,686,432,310,186,8126,7876,7624,7372,7122,6742,6364,5986,5606,5100,4592,4086,3708,2944,2436,1928,1292,910,526,8084,7702,7318,6936,6552,6298,6042,5786,5404,5276,5020,4892,4636,4380,4252,3996,3868,3740,3612,3484,3356,3228,3100,2972,2844,2716,2588,2460,2458,2330,2202,2074,2074,1946,1818,1818,1688,1560,1560,1432,1432,1304,1304,1176,1176,1046,1046,918,918,790,790,790,662,662,534,532,532,404,404,276,276,276,148,148,148,20,18,18,18,146,146,146,274,274,274,274,400,400,400,400,528,528,528,528,528,656,656
  dc.w    754,754,754,626,624,624,624,624,496,496,496,496,368,368,368,368,240,240,238,110,110,110,238,238,238,238,366,366,366,492,492,620,620,620,748,748,876,876,1004,1004,1002,1130,1130,1258,1258,1386,1386,1514,1512,1640,1770,1768,1896,1896,2024,2152,2280,2278,2406,2534,2662,2662,2790,2918,3046,3174,3302,3430,3558,3814,3942,4070,4198,4454,4582,4838,4966,5222,5350,5606,5864,6248,6506,6892,7146,7404,8176,114,886,1014,1786,2044,2434,2950,3594,4112,4498,5146,5534,6052,6312,6442,7092,7352,7354,7614,7876,8136,206,338,472,472,734,738,870,1004,1136,1140,1144,1150,1026,1030,1034,1038,1042,918,796,670,676,424,428,176,52,8122,7870,7618,7368,7116,6864,6486,6234,5856,5476,4970,4590,4082,3576,3068,2432,1926,1416,908,398,16,7826,7316,7062,6678,6424,6168,5912,5530,5274,5018,4890,4762,4506,4378,4122,3994,3738,3610,3482,3354,3226,3098,2970,2842,2714,2586,2586,2458,2330,2202,2200,2072,1944,1816,1816,1688,1688,1560,1432,1432,1302,1302,1174,1174,1046,1046,918,918,918,788,788,660,660,660,532,532,404,404,276,276,274,146,146,146,146,18,18,18,146,146,146,272,272,272,272,400,400,400,400,528,528,528,528,528,654,654
  dc.w    754,754,754,626,626,626,626,626,498,496,496,496,368,368,368,368,240,240,240,112,112,112,240,238,238,366,366,366,494,494,494,622,622,622,748,748,876,876,1004,1004,1132,1132,1260,1260,1388,1386,1514,1514,1642,1642,1770,1770,1898,2026,2026,2154,2280,2280,2408,2536,2664,2792,2920,3048,3048,3304,3432,3430,3688,3816,3944,4070,4328,4456,4584,4840,5096,5224,5482,5738,6124,6252,6636,6894,7278,7664,8050,114,630,1016,1660,1920,2566,3210,3468,3856,4372,4762,5278,5538,6056,6446,6576,7096,7358,7618,7620,7880,8142,84,216,348,478,482,616,748,752,756,758,894,770,774,650,654,658,662,538,414,418,294,172,8112,7988,7864,7614,7618,7110,6858,6608,6228,5976,5598,5346,4838,4460,3954,3574,3066,2556,1922,1542,904,524,140,7952,7442,7186,6804,6550,6166,5910,5656,5400,5144,5016,4760,4504,4376,4250,3994,3866,3736,3608,3480,3352,3224,2968,2968,2840,2712,2584,2456,2328,2200,2200,2072,1944,1944,1814,1686,1686,1558,1558,1430,1430,1302,1302,1174,1172,1044,1044,916,916,788,788,660,660,532,532,530,402,402,402,274,274,274,146,146,146,18,18,18,144,144,144,272,272,272,272,400,400,400,400,528,526,526,526,526,654,654
  dc.w    754,754,754,626,626,626,626,498,498,498,498,498,370,368,368,240,240,240,240,112,112,112,240,240,240,368,368,368,496,494,494,622,622,750,750,750,878,878,1006,1006,1132,1132,1260,1260,1388,1388,1516,1516,1644,1644,1770,1898,1898,2026,2154,2154,2282,2410,2410,2538,2666,2792,2922,3048,3178,3306,3434,3562,3690,3818,3944,4202,4328,4458,4712,4840,5098,5356,5612,5868,6124,6380,6638,7024,7280,7666,8182,246,890,1148,1536,2182,2438,2826,3472,3988,4506,4894,5284,5414,5672,6062,6452,6712,7102,7362,7624,7624,7756,7890,8152,92,224,228,360,492,496,502,504,638,514,518,394,398,402,406,282,158,162,8102,8106,7856,7732,7608,7356,7104,6854,6728,6350,6098,5848,5468,5088,4710,4330,3822,3442,2934,2556,2046,1538,1030,520,138,8074,7566,7184,6930,6546,6292,6036,5782,5398,5270,5014,4760,4630,4376,4248,4120,3864,3736,3608,3480,3352,3224,3096,2968,2840,2710,2582,2454,2326,2326,2198,2070,2070,1942,1814,1814,1686,1558,1556,1428,1428,1300,1300,1172,1172,1044,1044,916,916,788,786,658,658,658,530,530,402,402,402,274,274,274,144,144,144,16,16,16,144,144,144,144,272,272,270,398,398,398,398,398,526,526,526,526,654,654
  dc.w    756,756,756,628,628,628,628,498,498,498,498,498,370,370,370,242,242,242,114,112,112,112,240,240,240,368,368,368,496,496,624,624,624,750,750,750,878,878,1006,1006,1134,1134,1262,1260,1390,1388,1516,1516,1644,1644,1772,1900,1900,2028,2156,2284,2284,2412,2540,2538,2666,2794,2922,3050,3178,3306,3434,3562,3690,3818,4074,4204,4460,4588,4716,4972,5100,5356,5614,5868,6126,6382,6768,7024,7670,7798,8054,248,764,1148,1926,1926,2442,3088,3604,3732,4122,4508,5028,5416,5546,5808,6196,6456,6718,6978,7240,7500,7502,7634,7896,8030,8162,8164,106,236,240,246,248,382,258,262,138,140,146,150,26,8094,8098,7846,7850,7598,7604,7352,7098,6976,6724,6472,6220,5842,5590,5338,4958,4578,4200,3820,3440,2932,2424,2044,1536,1026,646,264,7946,7564,7310,6928,6672,6290,6034,5778,5524,5268,5012,4886,4630,4502,4246,4118,3990,3734,3606,3478,3350,3222,3094,2966,2838,2710,2582,2454,2454,2326,2198,2196,2068,1940,1812,1812,1684,1556,1556,1428,1428,1300,1300,1172,1170,1042,1042,914,914,786,786,658,658,658,530,530,530,400,400,272,272,272,144,144,144,16,16,16,16,144,142,142,270,270,270,398,398,398,398,398,526,526,526,526,652,652
  dc.w    756,756,756,628,628,628,628,500,500,500,500,370,370,370,370,242,242,242,114,114,114,114,242,242,242,368,368,368,496,496,624,624,624,752,752,880,880,878,1008,1006,1134,1134,1262,1262,1390,1390,1518,1518,1646,1774,1774,1902,1900,2028,2156,2284,2284,2412,2540,2668,2796,2796,2924,3052,3180,3308,3436,3564,3820,3948,4076,4204,4462,4588,4844,4974,5230,5488,5614,6000,6258,6384,6770,7158,7414,7800,122,380,768,1026,1542,1928,2316,2704,3348,3606,4254,4384,4772,5032,5422,5812,6200,6202,6462,6722,6984,7116,7246,7380,7640,7642,7906,7910,8042,8172,8178,8182,8186,8186, 2,8070,8074,8076,8080,7958,7962,7838,7842,7590,7592,7342,7218,7094,6842,6718,6466,6216,5964,5712,5460,5082,4828,4450,4070,3688,3310,2802,2422,2042,1662,1024,642,262,8072,7688,7560,6924,6670,6414,6160,5904,5522,5394,5138,4884,4756,4500,4372,4116,3988,3860,3732,3476,3348,3220,3092,2964,2836,2708,2708,2580,2452,2324,2196,2196,2068,1940,1940,1812,1684,1684,1554,1426,1426,1298,1298,1170,1170,1042,1042,914,914,786,786,784,656,656,528,528,528,400,400,272,272,272,144,144,142,14,14,14,14,142,142,142,270,270,270,270,398,398,398,396,524,524,524,524,652,652
  dc.w    758,756,628,628,628,628,628,500,500,500,500,372,372,372,372,244,242,242,114,114,114,242,242,242,242,370,370,370,496,496,624,626,626,752,752,880,880,1008,1008,1136,1136,1264,1264,1262,1392,1520,1518,1646,1646,1774,1774,1902,2030,2030,2158,2286,2414,2414,2542,2668,2798,2926,3054,3182,3310,3438,3566,3694,3822,3950,4078,4334,4464,4590,4846,5104,5232,5490,5744,6002,6260,6774,6774,7158,7416,7802,8188,256,642,1028,1802,1930,2448,2706,3094,3482,3998,4388,4518,4904,5166,5556,5816,6206,6206,6466,6728,6860,7122,7124,7384,7518,7650,7654,7654,7918,7920,7926,7930,7934,7810,7814,7818,7820,7824,7828,7578,7582,7458,7334,7336,7084,6960,6838,6714,6462,6338,6086,5706,5454,5202,4950,4570,4318,3940,3560,3180,2800,2290,2038,1530,1148,766,258,8070,7686,7304,7050,6668,6412,6158,5902,5648,5392,5136,5010,4754,4498,4370,4242,3986,3858,3730,3602,3476,3348,3220,2964,2962,2834,2706,2578,2450,2322,2194,2194,2066,1938,1938,1810,1682,1682,1554,1554,1426,1426,1298,1170,1168,1040,1040,1040,912,912,784,784,656,656,528,528,528,400,398,270,270,270,142,142,142,142,14,14,14,142,142,142,270,270,268,268,396,396,396,396,524,524,524,524,524,652
  dc.w    758,758,630,630,630,628,628,500,500,500,500,372,372,372,372,244,244,244,116,116,116,244,244,244,370,370,370,498,498,498,626,626,626,754,754,882,882,1008,1010,1138,1138,1264,1264,1392,1392,1520,1520,1648,1648,1776,1904,1904,2032,2160,2160,2288,2414,2414,2544,2670,2800,2928,3054,3182,3310,3440,3568,3696,3824,3950,4336,4336,4464,4722,4848,5104,5234,5492,5746,6262,6262,6648,6904,7418,7548,7806, 0,258,774,1030,1418,1806,2192,2580,3226,3614,3742,4132,4520,4910,5040,5300,5560,5822,6210,6214,6472,6604,6866,7000,7130,7132,7394,7398,7530,7532,7666,7670,7674,7678,7554,7558,7562,7564,7568,7444,7448,7324,7200,7076,7080,6828,6704,6580,6456,6334,6082,5828,5448,5326,4944,4694,4442,4062,3810,3430,3048,2668,2288,1908,1526,1148,766,256,8066,7684,7430,7174,6792,6538,6156,5900,5644,5390,5134,5008,4752,4624,4368,4240,3986,3858,3730,3602,3474,3346,3218,3090,2962,2834,2706,2578,2450,2450,2322,2194,2066,2066,1938,1810,1810,1680,1552,1552,1424,1424,1296,1296,1168,1168,1040,1040,912,912,784,784,656,654,526,526,526,398,398,398,270,270,270,142,142,142,14,12,12,140,140,140,268,268,268,268,396,396,396,396,524,524,524,524,524,650
  dc.w    758,758,630,630,630,630,630,502,502,502,502,374,374,372,244,244,244,244,116,116,116,244,244,244,372,372,372,500,500,500,626,626,754,754,754,882,882,1010,1010,1138,1138,1266,1266,1394,1394,1522,1520,1650,1650,1778,1906,1904,2032,2160,2288,2288,2416,2544,2544,2672,2800,2928,3056,3184,3312,3440,3570,3698,3826,4082,4208,4338,4594,4722,4978,5108,5364,5622,5878,6136,6262,6648,6906,7292,7550,7680,8066,260,646,904,1420,1808,2324,2454,2842,3358,3616,3876,4264,4526,4916,5044,5304,5566,5826,6088,6216,6348,6612,6744,6874,6878,7138,7142,7144,7276,7410,7414,7418,7422,7298,7302,7306,7308,7312,7188,7064,7068,6944,6820,6824,6700,6448,6324,6200,5948,5824,5572,5320,5068,4816,4564,4312,3932,3680,3300,2920,2538,2158,1906,1526,1016,762,380,8064,7682,7428,7174,6916,6536,6154,6026,5770,5516,5260,5006,4878,4622,4494,4240,4112,3984,3728,3600,3472,3344,3216,3088,2960,2832,2704,2576,2448,2448,2320,2192,2064,2064,1936,1808,1808,1680,1552,1552,1424,1424,1296,1296,1168,1168,1038,1038,910,910,782,782,654,654,654,526,526,398,398,398,270,270,268,140,140,140,12,12,12,140,140,140,140,268,268,268,396,396,394,394,522,522,522,522,522,650
  dc.w    758,758,630,630,630,630,630,502,502,502,502,374,374,374,246,246,246,246,118,116,118,244,244,244,372,372,372,500,500,628,628,628,756,756,754,884,884,1010,1010,1140,1138,1266,1266,1394,1394,1522,1522,1650,1650,1778,1906,1906,2034,2162,2290,2290,2418,2546,2674,2802,2802,2930,3058,3186,3314,3442,3570,3826,3954,4082,4210,4468,4596,4724,5110,5110,5366,5622,5880,6136,6394,6652,6910,7296,7424,7682, 6,262,778,908,1424,1682,1940,2586,2716,2974,3492,3880,4010,4270,4530,5048,5050,5310,5570,5832,5962,6094,6226,6488,6488,6750,6754,6886,6888,7022,7154,7158,7162,7166,7042,7046,7048,7052,7056,6932,6808,6812,6688,6692,6440,6444,6192,6068,5942,5690,5566,5314,5320,4938,4558,4434,4054,3802,3550,3170,2790,2408,2028,1776,1396,1012,632,380,8190,7680,7426,7172,6788,6660,6280,6024,5770,5514,5258,5004,4876,4620,4492,4366,4110,3982,3854,3726,3470,3342,3214,3086,2958,2830,2702,2576,2576,2448,2320,2190,2190,2062,1934,1806,1806,1678,1550,1550,1422,1422,1294,1294,1166,1166,1038,1038,910,910,782,782,654,652,652,524,524,524,396,396,268,268,268,140,140,140,12,12,12,140,140,138,138,266,266,266,394,394,394,394,522,522,522,522,522,650
  dc.w    760,760,632,632,630,632,502,502,502,502,502,374,374,374,246,246,246,246,118,118,118,246,246,246,374,374,374,500,500,628,628,628,756,756,884,884,884,1012,1012,1140,1140,1268,1268,1396,1396,1524,1522,1652,1780,1780,1908,2036,2034,2162,2290,2292,2420,2546,2676,2804,2932,2932,3060,3316,3316,3444,3572,3828,3956,4084,4470,4470,4598,4854,4984,5240,5368,5626,6010,6138,6394,6654,6912,7168,7426,7684,8070,136,524,1040,1168,1684,1942,2202,2718,2848,3236,3624,4014,4144,4404,4792,5054,5054,5314,5576,5836,5838,6098,6232,6364,6494,6498,6630,6764,6768,6898,6902,6904,6910,6786,6790,6792,6796,6672,6804,6678,6554,6430,6564,6182,6186,6062,5810,5686,5562,5310,5314,4932,4680,4430,4176,3924,3672,3292,2912,2658,2278,2026,1644,1394,1012,630,248,8186,7806,7424,7170,6786,6530,6278,6022,5768,5512,5256,5130,4874,4746,4490,4364,4108,3980,3852,3724,3470,3340,3214,3086,2958,2830,2702,2702,2574,2446,2318,2190,2190,2062,1934,1934,1806,1678,1678,1550,1422,1422,1294,1294,1166,1164,1036,1036,908,908,780,780,780,652,652,524,524,524,396,396,268,268,268,138,138,138,10,10,10,138,138,138,138,266,266,266,394,394,394,394,394,522,522,522,520,648
  dc.w    760,760,632,632,632,632,504,504,504,504,504,376,376,374,248,248,246,118,118,118,118,246,246,246,374,374,374,502,502,630,630,630,758,758,886,884,1014,1012,1012,1140,1140,1268,1268,1396,1396,1524,1652,1652,1780,1780,1908,2036,2036,2164,2292,2292,2420,2548,2676,2804,2932,3060,3060,3316,3444,3574,3702,3830,3958,4086,4342,4472,4600,4856,4984,5242,5498,5628,5884,6142,6398,6528,6784,7170,7430,7686,10,140,784,912,1428,1558,1946,2462,2464,2722,3368,3498,3630,4148,4276,4408,4798,5058,5060,5320,5582,5712,5844,5976,6108,6110,6242,6374,6508,6512,6512,6646,6650,6650,6658,6534,6536,6540,6416,6420,6422,6298,6174,6178,6054,5802,5806,5682,5430,5306,5182,4928,4804,4424,4300,3920,3666,3414,3162,2782,2530,2278,1896,1644,1262,1010,628,246,8184,7804,7550,7294,6784,6530,6274,6274,5766,5510,5256,5128,4872,4744,4490,4362,4234,3978,3850,3724,3596,3468,3340,3212,2956,2956,2828,2700,2572,2444,2316,2188,2188,2060,1932,1932,1804,1676,1676,1548,1548,1420,1420,1292,1164,1164,1036,1036,908,908,908,780,780,650,650,522,522,522,394,394,266,266,266,138,138,138,10,10,10,10,138,138,138,266,266,266,392,392,392,392,392,520,520,520,520,648
  dc.w    762,762,632,632,632,632,504,504,504,504,504,376,376,376,248,248,248,120,120,120,120,248,248,248,376,374,374,502,502,630,630,630,758,758,886,886,1014,1014,1142,1142,1270,1270,1398,1398,1526,1526,1654,1654,1782,1910,1908,2036,2166,2166,2294,2422,2422,2550,2678,2806,2934,3062,3190,3318,3446,3574,3702,3830,3960,4088,4344,4472,4602,4986,5114,5244,5500,5628,5886,6144,6272,6530,6788,7174,7302,7688,7946,140,400,1044,1044,1690,1690,2078,2336,2596,2984,3502,3504,3892,4152,4282,4542,4804,4932,5064,5324,5458,5588,5720,5854,5986,5986,6120,6252,6256,6258,6390,6394,6398,6274,6278,6280,6284,6160,6164,6166,6042,5918,5794,5798,5672,5548,5424,5300,5048,4924,4672,4548,4424,4042,3790,3538,3286,3034,2652,2400,2146,1894,1514,1132,878,498,244,8054,7800,7546,7292,6910,6528,6274,6016,5762,5508,5382,5126,4998,4744,4488,4360,4232,3976,3850,3722,3594,3466,3338,3210,3082,2954,2826,2698,2572,2444,2316,2316,2188,2060,1932,1932,1804,1804,1676,1548,1548,1420,1420,1292,1292,1162,1162,1034,1034,906,906,778,778,650,650,522,522,522,394,394,266,266,266,138,138,138,10,10,10, 8,136,136,136,264,264,264,264,392,392,392,392,520,520,520,520,648
  dc.w    762,762,634,634,634,632,506,506,506,504,376,376,376,376,248,248,248,120,120,120,248,248,248,248,376,376,376,504,504,632,632,632,760,758,888,888,1014,1014,1142,1142,1270,1270,1398,1398,1526,1526,1654,1654,1782,1910,1910,2038,2166,2166,2294,2422,2550,2552,2680,2808,2936,3064,3192,3320,3448,3576,3704,3834,3962,4090,4474,4474,4602,4860,5116,5246,5502,5760,5760,6018,6274,6662,6790,7046,7562,7692,7948,16,402,788,918,1306,1822,1952,2340,2470,2728,3246,3376,3636,3898,4286,4286,4546,4808,4808,5070,5332,5334,5464,5596,5730,5860,5864,5996,5998,6132,6134,6138,6142,6018,6022,6024,6028,6032,5906,5782,5786,5790,5666,5542,5416,5292,5168,5044,4918,4666,4414,4290,4038,3914,3662,3408,3156,2774,2522,2270,2016,1764,1384,1132,748,494,114,8052,7798,7416,7162,6908,6654,6398,6016,5888,5506,5380,5124,4996,4742,4486,4358,4230,3976,3848,3720,3592,3464,3336,3208,3082,2954,2826,2698,2570,2442,2314,2314,2186,2058,2058,1930,1802,1802,1674,1546,1546,1418,1418,1290,1290,1162,1162,1034,1034,906,906,778,778,650,650,522,522,522,394,394,264,264,264,136,136,136,136, 8, 8, 8,136,136,136,264,264,264,264,392,392,392,392,520,518,518,518,646
  dc.w    762,762,634,634,634,634,506,506,506,506,378,378,378,378,250,250,250,122,122,122,248,248,248,376,376,376,504,504,504,632,632,632,760,760,888,888,1016,1016,1144,1144,1272,1272,1400,1400,1528,1528,1656,1656,1784,1912,1912,2040,2168,2168,2296,2424,2552,2552,2680,2808,2936,3064,3192,3320,3450,3578,3706,3834,3962,4220,4348,4476,4732,4860,5118,5248,5376,5504,5762,6018,6278,6534,6792,7178,7308,7564,7952,18,274,662,1050,1180,1566,1826,2084,2472,2602,2862,3380,3510,3640,3902,4032,4290,4552,4554,4814,4946,5208,5208,5342,5474,5474,5606,5740,5744,5876,5878,5882,5886,5762,5766,5768,5772,5776,5650,5654,5530,5406,5410,5286,5160,5036,4912,4788,4534,4410,4286,4032,3908,3656,3532,3278,2898,2646,2392,2140,1888,1634,1254,1000,748,364,112,8050,7668,7414,7160,6904,6652,6396,6142,5760,5758,5378,5122,4994,4740,4612,4356,4230,4102,3846,3718,3590,3464,3336,3208,3080,2952,2824,2696,2568,2440,2440,2312,2184,2056,2056,1928,1800,1802,1674,1546,1544,1416,1416,1288,1288,1160,1160,1032,1032,904,904,776,776,648,648,520,520,520,392,392,392,264,264,264,136,136,136, 8, 8, 8,136,136,136,264,264,264,262,390,390,390,390,518,518,518,518,646
  dc.w    762,634,634,634,634,634,506,506,506,506,378,378,378,378,250,250,250,122,122,122,250,250,250,378,378,378,506,506,506,634,634,634,762,762,890,888,1016,1016,1144,1144,1272,1274,1402,1400,1528,1528,1656,1656,1784,1912,1912,2040,2168,2298,2298,2426,2554,2552,2682,2810,2938,3066,3322,3322,3450,3578,3708,3836,4092,4222,4350,4476,4734,4864,4992,5120,5378,5506,6022,6022,6278,6536,6922,7052,7308,7568,7826,148,278,666,794,1054,1440,1828,1958,2216,2606,2736,2996,3384,3514,3646,4034,4036,4296,4556,4558,4820,4952,4954,5086,5218,5348,5352,5484,5488,5488,5622,5626,5758,5634,5638,5512,5516,5392,5394,5398,5274,5278,5152,5028,4904,4780,4782,4530,4406,4280,4028,3904,3652,3528,3274,3022,2768,2516,2264,2010,1758,1504,1124,870,616,364,110,7920,7666,7412,7158,6904,6650,6396,6140,5886,5630,5502,5120,4994,4738,4610,4356,4228,4100,3972,3718,3590,3462,3334,3206,3078,2950,2822,2696,2568,2440,2440,2312,2184,2184,2056,1928,1800,1800,1672,1544,1544,1416,1416,1288,1288,1160,1160,1032,1032,904,904,776,776,648,648,520,520,520,392,392,392,262,262,262,134,134,134, 6, 6, 6,134,134,134,262,262,262,262,390,390,390,390,518,518,518,518,646
  dc.w    764,636,636,636,636,636,508,508,508,508,380,378,378,378,250,250,250,122,122,122,250,250,250,378,378,378,506,506,506,634,634,762,762,762,890,890,1018,1018,1146,1146,1274,1274,1402,1402,1530,1530,1658,1658,1786,1914,1914,2042,2170,2298,2298,2426,2554,2682,2682,2812,2940,3068,3196,3324,3452,3582,3710,3838,4094,4222,4224,4352,4608,4738,4994,5122,5380,5638,5766,6024,6280,6538,6666,6924,7312,7568,7956,8084,152,410,668,926,1444,1572,1960,2090,2350,2740,2740,3128,3258,3518,3650,3910,4040,4300,4304,4434,4566,4826,4828,4962,5092,5096,5228,5360,5362,5366,5370,5374,5250,5382,5256,5260,5264,5266,5142,5018,5022,4896,4772,4776,4522,4398,4274,4148,4024,3772,3646,3522,3270,3016,2764,2640,2386,2134,1880,1628,1374,994,740,488,232,8172,7918,7664,7282,7028,6774,6648,6392,6138,5884,5628,5502,5372,4992,4736,4608,4354,4226,4098,3970,3716,3588,3460,3332,3204,3078,2950,2822,2694,2566,2566,2438,2310,2182,2182,2054,1926,1798,1798,1670,1542,1542,1414,1414,1286,1286,1158,1158,1030,1030,902,902,774,774,646,646,646,518,518,390,390,390,262,262,262,134,134,134, 6, 6, 6,134,134,134,262,262,262,262,390,390,390,390,518,516,516,516,516
  dc.w    764,636,636,636,636,636,508,508,508,508,380,380,380,380,252,252,252,124,124,124,252,252,252,380,380,380,508,508,508,634,634,762,762,762,890,890,1018,1018,1146,1146,1274,1274,1402,1402,1530,1530,1658,1658,1788,1916,1916,2044,2172,2300,2300,2428,2556,2684,2684,2812,2940,3068,3196,3326,3454,3582,3710,3712,3968,4096,4224,4354,4610,4740,4996,5254,5382,5510,5768,6154,6154,6412,6670,6928,7184,7700,7700,7958,154,412,670,928,1060,1446,1704,1964,2096,2484,2614,2872,3262,3262,3522,3654,3784,4046,4306,4308,4440,4572,4574,4834,4838,4970,4972,5104,5108,5110,5114,5118,4994,4996,5000,5004,5006,4882,4886,4890,4764,4640,4516,4518,4394,4270,4016,4020,3768,3642,3518,3264,3012,2888,2634,2382,2258,2004,1752,1498,1244,992,610,486,104,8042,7788,7534,7280,7024,6772,6516,6262,6136,5882,5626,5500,5244,5116,4862,4608,4352,4224,4096,3970,3714,3586,3458,3330,3204,3076,2948,2820,2692,2564,2564,2436,2310,2182,2182,2054,1926,1798,1798,1670,1542,1542,1414,1414,1286,1286,1158,1158,1030,1030,902,902,774,774,646,646,646,518,518,390,390,390,262,262,262,134,134,134, 6, 6, 6,132,132,132,260,260,260,260,388,388,388,388,516,516,516,516,516
  dc.w    764,636,636,636,636,636,508,508,508,508,380,380,380,380,252,252,252,124,124,124,252,252,252,380,380,380,508,508,508,636,636,764,764,764,892,892,1020,1020,1148,1148,1276,1276,1404,1404,1532,1532,1660,1788,1788,1916,1916,2044,2172,2300,2300,2430,2558,2686,2684,2814,2942,3070,3198,3200,3456,3456,3584,3712,3970,4098,4226,4356,4612,4870,4998,5126,5256,5512,5898,6026,6156,6414,6672,6928,7186,7316,7702,7962,26,286,416,932,932,1448,1578,1838,1968,2228,2616,2618,2878,3266,3268,3528,3658,3788,3922,4052,4184,4316,4446,4450,4582,4584,4716,4848,4852,4854,4986,4990,4866,4868,4872,4748,4750,4754,4628,4504,4508,4382,4386,4262,4136,4012,3888,3764,3638,3514,3390,3136,2884,2760,2506,2252,2000,1876,1622,1368,1116,862,610,356,102,8040,7658,7534,7278,7024,6768,6516,6262,6134,5880,5626,5370,5242,5114,4986,4734,4478,4350,4222,3968,3712,3584,3458,3330,3202,3074,2946,2818,2692,2562,2564,2436,2308,2180,2180,2052,1924,1796,1796,1668,1668,1540,1412,1412,1284,1284,1156,1156,1028,1028,900,900,772,772,644,644,644,516,516,388,388,388,260,260,260,132,132,132, 4, 4, 4,132,132,132,260,260,260,260,388,388,388,388,516,516,516,516,516
  dc.w    766,638,638,638,638,638,510,510,510,510,382,382,382,254,254,254,254,126,124,124,252,252,252,380,380,380,510,510,636,636,636,764,764,764,892,892,1020,1020,1148,1148,1276,1276,1404,1404,1532,1534,1662,1790,1790,1918,1918,2046,2174,2302,2302,2430,2558,2686,2814,2688,2944,2944,3072,3200,3330,3458,3586,3714,3970,4100,4228,4486,4614,4742,5000,5128,5258,5514,5770,5900,6288,6416,6544,6802,7060,7318,7706,7834,8092,158,418,676,1064,1066,1582,1712,1972,2102,2360,2622,2750,2882,3012,3272,3532,3534,3666,3928,3930,4062,4192,4322,4454,4456,4460,4592,4594,4598,4602,4604,4610,4484,4488,4492,4494,4498,4372,4376,4252,4254,4130,4004,3880,3756,3632,3506,3382,3256,3004,2880,2754,2502,2248,2124,1870,1618,1492,1110,986,732,480,226,8164,7910,7656,7402,7148,6894,6640,6384,6260,6004,5878,5622,5368,5242,4984,4858,4858,4476,4350,4222,4094,3838,3584,3456,3328,3200,3072,2946,2818,2690,2690,2562,2434,2306,2178,2178,2050,1922,1796,1796,1668,1668,1540,1412,1412,1284,1284,1156,1156,1028,1028,900,900,772,772,644,644,644,516,516,516,388,388,260,260,260,132,132,132, 4, 4, 4,132,132,132,132,260,260,260,388,388,388,388,516,514,514,514,514
  dc.w    766,638,638,638,638,638,510,510,510,510,382,382,382,254,254,254,254,126,126,126,254,254,254,382,382,382,510,510,638,638,638,766,766,894,894,894,1022,1022,1150,1150,1278,1278,1406,1406,1534,1534,1662,1790,1790,1918,1918,2046,2048,2176,2176,2432,2432,2560,2688,2688,2818,2946,3074,3202,3330,3458,3588,3716,3972,4102,4230,4358,4486,4744,4872,5130,5258,5516,5644,6032,6160,6290,6548,6804,7062,7450,7578,7708,7966,32,292,550,936,938,1326,1456,1716,1974,2106,2366,2496,2754,3016,3018,3278,3406,3538,3672,3672,3804,4066,4068,4070,4202,4334,4336,4340,4470,4474,4478,4354,4356,4360,4362,4238,4242,4244,4120,3994,3998,3872,3748,3624,3628,3502,3378,3252,3000,2874,2750,2498,2372,2120,1994,1742,1488,1234,982,856,602,350,96,8034,7780,7526,7400,7146,6892,6638,6384,6258,6002,5746,5622,5366,5240,4984,4858,4600,4474,4348,4220,4092,3838,3710,3582,3454,3200,3072,2944,2816,2688,2688,2560,2432,2304,2178,2178,2050,1922,1794,1794,1666,1666,1538,1410,1410,1282,1282,1154,1154,1026,1026,898,898,770,770,770,642,642,514,514,514,386,386,258,258,258,130,130,130, 2, 2, 2,130,130,130,130,258,258,258,386,386,386,386,514,514,514,514,514
  dc.w    640,512,512,512,638,638,510,510,510,510,382,382,382,254,254,254,254,126,126,126,254,254,254,382,382,382,510,510,638,638,638,766,766,894,894,894,1022,1022,1150,1150,1278,1278,1406,1280,1408,1408,1536,1664,1792,1792,1792,1920,2048,2176,2176,2304,2432,2562,2690,2690,2818,2946,3076,3204,3332,3460,3718,3718,3846,3974,4232,4360,4488,4874,4874,5004,5260,5390,5776,5904,6034,6290,6548,6678,6936,7194,7452,7710,7968,36,164,552,682,1070,1070,1460,1588,1848,1978,2110,2498,2500,2760,2762,3020,3282,3282,3416,3546,3678,3680,3812,3944,3946,3948,4080,4084,4086,4218,4222,4098,4100,4104,3978,3982,3984,3860,3864,3866,3742,3616,3620,3496,3370,3374,3122,2996,2744,2618,2494,2368,2116,1990,1736,1612,1360,1106,980,726,474,220,94,8032,7650,7526,7270,7016,6762,6636,6382,6128,6000,5746,5492,5364,5110,4982,4856,4600,4472,4472,4090,3962,3836,3708,3580,3454,3326,3198,3070,2942,2814,2688,2560,2432,2304,2176,2176,2048,1920,1792,1792,1664,1664,1538,1410,1410,1282,1282,1154,1154,1026,1026,898,898,770,770,770,642,642,514,514,514,386,386,258,258,258,130,130,130, 2, 2, 2,130,130,130,130,258,258,258,386,386,386,386,514,514,514,514,514
  dc.w    640,512,512,512,512,512,384,384,384,384,256,256,256,128,128,128,128, 0, 0, 0,128,128,128,256,256,256,510,384,512,512,512,640,640,768,768,768,896,896,1024,1024,1152,1152,1280,1280,1408,1408,1536,1664,1664,1792,1792,1922,2050,2178,2178,2306,2434,2562,2562,2692,2820,2948,3076,3206,3334,3462,3590,3718,3848,3976,4232,4490,4490,4748,4876,5004,5262,5392,5648,5778,6164,6164,6422,6680,6938,7196,7454,7584,7842,7972,38,296,556,814,944,1204,1462,1592,1982,1982,2242,2372,2504,2634,2764,3026,3026,3288,3290,3420,3554,3556,3688,3688,3820,3826,3956,3960,3962,3966,3842,3844,3848,3850,3854,3728,3860,3606,3610,3484,3488,3364,3238,3114,2990,2864,2740,2614,2490,2236,2112,1986,1860,1608,1354,1230,976,852,598,344,90,8028,7902,7648,7394,7270,7014,6762,6506,6252,6126,5870,5744,5490,5364,5106,4980,4854,4598,4472,4344,4090,3962,3834,3706,3578,3452,3324,3196,3068,2942,2814,2684,2686,2558,2430,2302,2176,2048,1920,1792,1792,1664,1664,1536,1408,1408,1280,1280,1152,1152,1024,1024,896,896,768,768,768,642,642,514,514,514,386,386,258,258,258,130,130,130, 2, 2, 0,128,128,128,128,256,256,256,384,384,384,384,512,512,512,512,512
  dc.w    640,512,512,512,512,512,384,384,384,384,256,256,256,128,128,128,128, 0, 0, 0,128,128,128,256,256,256,384,384,512,512,512,640,640,768,768,768,896,896,1024,1024,1152,1154,1282,1282,1410,1410,1538,1666,1666,1794,1794,1922,2050,2178,2180,2308,2436,2564,2564,2692,2822,2950,3078,3206,3334,3464,3592,3720,3850,4106,4234,4362,4492,4620,4878,5136,5136,5392,5522,5908,6038,6166,6296,6554,6812,7068,7328,7458,7716,7974,40,170,558,558,948,948,1336,1466,1726,1856,1986,2118,2248,2508,2510,2770,2772,2904,3164,3166,3298,3428,3432,3564,3566,3698,3700,3704,3706,3710,3586,3588,3592,3594,3598,3600,3476,3478,3354,3356,3232,3106,2982,2856,2732,2736,2482,2358,2232,2108,1982,1858,1604,1478,1226,972,846,594,468,214,8152,8026,7772,7520,7394,7140,6886,6630,6506,6250,6124,5870,5616,5488,5234,5106,4978,4724,4598,4470,4342,4086,3960,3832,3706,3578,3450,3322,3196,3068,2940,2812,2684,2684,2558,2430,2300,2302,2174,2046,1918,1918,1790,1790,1536,1408,1408,1280,1280,1152,1152,1024,1024,896,896,768,768,768,640,640,512,512,512,384,384,256,256,256,128,128,128, 0, 0, 0,128,128,128,128,256,256,256,384,384,384,384,512,512,512,512,512
  dc.w    642,514,514,512,512,512,384,384,384,384,256,256,256,128,128,128,128, 0, 2, 2,130,130,130,258,258,258,386,386,514,514,514,642,642,770,770,770,898,898,1026,1026,1154,1154,1282,1282,1410,1410,1538,1668,1668,1796,1796,1924,2052,2180,2180,2308,2438,2566,2566,2694,2822,2950,3080,3208,3336,3464,3594,3722,3850,3978,4108,4364,4494,4622,4752,5008,5138,5266,5652,5782,5910,6168,6298,6556,6684,6942,7202,7460,7588,7848,7976,44,302,432,692,950,1080,1212,1470,1730,1860,1990,2122,2252,2382,2514,2776,2776,2908,2910,3042,3174,3304,3308,3438,3440,3444,3446,3578,3582,3458,3460,3464,3338,3342,3344,3348,3222,3226,3100,2976,2850,2726,2728,2604,2478,2354,2228,2232,1978,1854,1600,1474,1222,1096,972,716,464,338,84,8022,7896,7644,7390,7264,7010,6756,6630,6374,6248,5994,5868,5612,5358,5230,5104,4848,4722,4596,4468,4214,4086,3958,3830,3702,3576,3448,3320,3194,3066,2938,2810,2684,2684,2556,2428,2300,2300,2172,2046,1918,1918,1790,1790,1662,1534,1534,1406,1406,1278,1278,1150,1150,1022,1022,768,768,768,766,640,512,512,512,384,510,256,256,256,128,128,128, 0, 0, 0,128,128,128,128,256,256,256,384,384,384,384,512,512,512,512,512
  dc.w    642,514,514,514,514,514,386,386,386,386,258,258,258,130,130,130,130, 2, 2, 2,130,130,130,258,258,258,386,386,514,514,514,642,642,770,770,770,898,898,1026,1026,1156,1156,1284,1284,1412,1412,1540,1668,1668,1796,1796,1926,2054,2182,2182,2310,2438,2566,2566,2696,2824,2952,3080,3208,3338,3466,3594,3724,3852,3980,4110,4366,4496,4624,4752,5010,5138,5268,5526,5654,5912,6042,6300,6428,6686,6816,7204,7332,7462,7720,7978,46,46,306,436,824,954,1084,1214,1474,1604,1864,1994,1996,2128,2258,2520,2522,2654,2784,2786,2918,3050,3052,3054,3186,3186,3320,3322,3326,3202,3204,3208,3210,3086,3088,2964,2966,2970,2844,2718,2722,2596,2472,2346,2222,2098,1972,1974,1722,1596,1470,1346,1092,968,714,460,334,82,8148,8022,7768,7514,7388,7134,7008,6754,6500,6374,6120,5992,5738,5612,5356,5230,5102,4848,4722,4466,4466,4210,4084,3956,3828,3702,3574,3448,3320,3192,3064,2938,2810,2682,2682,2554,2426,2300,2300,2172,2044,1916,1916,1788,1788,1660,1534,1532,1406,1406,1278,1278,1150,1150,1022,1022,894,894,894,766,766,638,638,638,510,510,382,382,382,254,254,254,126,126,126,254,254,254,254,382,382,382,510,510,510,510,638,638,638,638,638
  dc.w    642,514,514,514,514,514,386,386,386,386,258,258,258,130,130,130,130, 2, 2, 2,130,130,130,258,258,258,386,386,514,514,516,644,644,772,772,772,900,900,1028,1028,1156,1156,1284,1284,1412,1412,1542,1542,1670,1798,1798,1926,2054,2182,2184,2312,2440,2440,2568,2696,2824,2954,3082,3210,3338,3468,3596,3724,3854,3982,4240,4240,4368,4626,4754,5012,5012,5270,5400,5656,5786,6044,6172,6430,6560,6818,6948,7206,7464,7594,7724,7982,48,180,436,568,698,958,1088,1218,1478,1608,1868,1870,2000,2130,2264,2394,2396,2528,2658,2790,2792,2796,2928,2930,2932,3064,3066,3070,2946,2948,2952,2954,2830,2832,2834,2710,2712,2588,2590,2466,2340,2344,2218,2092,1968,1972,1718,1592,1468,1214,1090,964,838,584,460,206,80,8018,7764,7638,7384,7258,7004,6878,6624,6370,6244,6118,5862,5608,5482,5354,5100,4974,4846,4720,4464,4338,4210,4084,3956,3828,3572,3574,3446,3318,3192,3064,2936,2808,2680,2552,2554,2426,2298,2298,2170,2042,1914,1916,1788,1658,1660,1532,1532,1404,1404,1276,1276,1148,1148,1020,1020,894,894,894,766,766,638,638,638,510,510,382,382,382,254,254,254,126,126,126,254,254,254,254,382,382,382,510,510,510,510,638,638,638,638,638
  dc.w    644,514,514,516,516,516,388,388,388,388,260,260,260,132,132,132,132, 4, 4, 4,132,132,132,260,260,260,388,388,388,516,516,644,644,644,772,772,900,900,1028,1030,1158,1158,1286,1286,1414,1414,1542,1542,1670,1798,1798,1928,2056,2184,2184,2312,2440,2442,2570,2826,2826,2954,3084,3212,3340,3340,3470,3726,3856,3984,4112,4242,4370,4500,4756,4886,5014,5144,5530,5530,5786,5918,6174,6304,6562,6692,6950,7208,7336,7468,7726,7856,52,52,182,442,702,830,962,1092,1352,1352,1612,1742,1874,2004,2006,2136,2270,2402,2404,2534,2538,2668,2672,2674,2806,2808,2810,2814,2690,2692,2696,2698,2700,2576,2578,2582,2456,2460,2462,2208,2212,2086,1962,1964,1840,1714,1590,1464,1210,1086,960,834,580,456,202,76,8014,7888,7636,7510,7384,7130,7002,6748,6622,6368,6242,5988,5860,5606,5480,5226,5098,4972,4846,4590,4464,4336,4208,4082,3826,3826,3572,3444,3444,3316,3190,3062,2934,2806,2680,2552,2552,2424,2296,2298,2170,2042,1914,1914,1786,1658,1658,1530,1530,1404,1404,1276,1276,1148,1148,1020,1020,892,892,764,764,764,636,636,508,508,508,380,380,380,252,252,252,124,124,126,254,254,254,254,382,382,382,510,510,510,510,638,638,638,638,638
  dc.w    644,516,516,516,516,516,388,388,388,388,260,260,260,260,132,132,132, 4, 4, 4,132,132,132,260,260,260,388,388,388,516,518,646,646,646,774,774,902,902,1030,1030,1158,1158,1286,1286,1414,1414,1544,1544,1672,1800,1800,1928,2056,2056,2186,2314,2442,2442,2570,2700,2828,2956,2956,3212,3214,3342,3470,3600,3728,3858,3986,4242,4500,4500,4630,4886,5016,5274,5274,5532,5662,5918,6048,6178,6564,6564,6822,6952,7210,7470,7598,7730,7988,8118,56,314,446,576,836,964,1096,1226,1356,1486,1618,1748,1880,2012,2012,2146,2146,2280,2410,2412,2414,2546,2550,2552,2554,2556,2562,2436,2440,2442,2444,2448,2322,2326,2328,2202,2078,2080,1956,1958,1832,1708,1582,1456,1332,1206,1082,956,830,576,452,326,72,8140,8012,7760,7634,7380,7254,7000,6874,6620,6492,6238,6112,5986,5732,5606,5350,5224,5098,4970,4716,4588,4462,4334,4078,4080,3824,3698,3570,3442,3314,3316,3060,3060,2932,2806,2678,2550,2550,2422,2296,2168,2168,2040,1912,1912,1786,1658,1658,1530,1530,1402,1402,1274,1274,1146,1146,1018,1018,892,892,764,764,764,636,636,508,508,508,380,380,380,252,252,252,124,124,124,252,252,252,380,380,380,380,508,508,508,508,636,636,636,636,636
  dc.w    644,516,516,516,516,516,388,388,388,388,260,260,260,260,132,132,132, 6, 6, 6,134,134,134,262,262,262,390,390,390,518,518,646,646,646,774,774,902,902,1030,1030,1160,1160,1288,1288,1416,1416,1544,1544,1672,1800,1802,1930,2058,2058,2186,2314,2316,2444,2572,2700,2828,2830,2958,3086,3344,3344,3472,3602,3730,3858,3986,4244,4374,4502,4630,4760,5018,5018,5276,5404,5662,5792,6050,6180,6308,6566,6824,6954,7084,7214,7472,7732,7732,8120,8122,58,318,448,580,710,968,970,1100,1362,1490,1624,1624,1884,1886,2018,2020,2022,2154,2156,2288,2288,2294,2424,2426,2430,2304,2308,2310,2314,2188,2192,2194,2068,2072,1946,1950,1952,1826,1702,1704,1578,1454,1328,1076,950,952,698,574,448,322,70,72,8010,7756,7630,7504,7250,7124,6870,6744,6618,6364,6238,5982,5858,5730,5476,5350,5222,4966,4842,4714,4588,4460,4204,4076,3950,3824,3696,3568,3442,3314,3186,3186,2932,2932,2804,2676,2550,2422,2422,2294,2166,2168,2040,1912,1912,1784,1656,1656,1528,1528,1402,1402,1274,1274,1146,1146,1018,1018,890,890,762,762,762,634,634,506,506,506,380,380,380,252,252,252,124,124,124,252,252,252,380,380,380,380,508,508,508,508,636,636,636,636,636
  dc.w    646,518,518,518,518,518,390,390,390,390,262,262,262,262,134,134,134, 6, 6, 6,134,134,134,262,262,262,390,390,390,518,518,518,646,648,776,776,904,904,1032,1032,1160,1160,1288,1288,1416,1416,1546,1546,1674,1802,1802,1930,2060,2060,2188,2316,2316,2444,2574,2702,2702,2830,2958,3088,3216,3344,3474,3602,3730,3988,3988,4118,4246,4376,4504,4762,4890,5020,5148,5406,5536,5794,6052,6052,6182,6568,6570,6700,7086,7216,7346,7476,7606,7864,7994,62,192,320,452,712,712,972,974,1104,1234,1368,1496,1628,1630,1762,1894,1896,2026,2030,2030,2034,2166,2168,2170,2174,2048,2052,2054,2058,2060,2064,1938,1940,1944,1818,1820,1696,1570,1572,1448,1322,1196,1072,946,820,824,570,574,320,194,68,8006,7880,7626,7502,7374,7250,6996,6870,6614,6488,6234,6108,5982,5856,5600,5474,5220,5092,4966,4840,4584,4458,4330,4204,4076,3950,3822,3694,3568,3440,3312,3186,3058,3056,2802,2804,2676,2548,2420,2292,2292,2166,2166,2038,1910,1910,1784,1656,1656,1528,1528,1400,1400,1272,1272,1144,1144,1016,1018,890,890,762,762,634,634,634,506,506,506,378,378,378,250,250,250,122,122,122,250,250,250,378,378,378,378,506,508,508,508,636,636,636,636,636
  dc.w    646,646,518,518,518,518,390,390,390,390,262,262,262,262,134,134,134, 6, 6, 6,134,134,134,262,264,264,392,392,392,520,520,520,648,648,776,776,904,904,1032,1034,1162,1162,1290,1290,1418,1418,1546,1546,1674,1804,1804,1932,1932,2060,2188,2190,2318,2446,2574,2704,2704,2832,2960,3088,3218,3346,3474,3604,3732,3862,3990,4118,4248,4506,4506,4634,4892,5022,5150,5280,5410,5666,5796,6054,6184,6312,6572,6830,6830,6960,7220,7348,7608,7738,7868,7998,64,194,326,456,586,718,846,978,980,1112,1242,1374,1502,1506,1638,1638,1772,1772,1904,1908,2038,2040,2044,2046,1920,1924,1926,1928,1804,1808,1810,1684,1688,1562,1564,1438,1442,1316,1190,1066,940,942,818,692,566,442,316,190,64,8002,7878,7752,7498,7372,7246,6992,6866,6740,6614,6358,6232,6106,5852,5726,5472,5344,5218,5092,4964,4710,4582,4456,4330,4202,4076,3948,3820,3694,3566,3438,3310,3184,3056,2928,2928,2802,2674,2546,2420,2292,2292,2164,2036,2036,1908,1910,1782,1654,1654,1526,1526,1400,1400,1272,1272,1144,1144,1016,1016,888,888,760,760,632,634,634,504,506,506,378,378,378,250,250,250,122,122,122,250,250,250,378,378,378,378,506,506,506,506,634,634,634,634,762
  dc.w    646,646,518,518,518,518,390,390,390,390,264,264,264,264,136,136,136, 8, 8, 8,136,136,136,264,264,264,392,392,392,520,520,520,648,648,776,778,906,906,1034,1034,1162,1162,1290,1290,1420,1420,1548,1548,1676,1676,1804,1932,1934,2062,2190,2190,2318,2448,2576,2576,2704,2832,2962,3090,3220,3348,3476,3478,3606,3734,3864,3992,4250,4378,4508,4636,4766,4894,5024,5282,5540,5540,5798,5928,6056,6186,6444,6574,6704,6964,7092,7222,7352,7610,7742,7872,8130,68,70,200,330,460,592,722,852,984,1114,1116,1248,1378,1380,1512,1644,1646,1648,1650,1782,1784,1788,1790,1664,1668,1670,1672,1676,1550,1554,1556,1430,1434,1308,1310,1186,1060,934,936,812,686,560,436,310,184,58,62,8000,7874,7748,7622,7368,7242,7116,6990,6736,6610,6356,6230,6104,5978,5850,5596,5470,5344,5088,4962,4834,4708,4582,4454,4328,4072,3944,3818,3690,3564,3436,3438,3310,3182,3054,2926,2800,2800,2674,2546,2418,2290,2290,2162,2036,2036,1908,1780,1780,1652,1654,1524,1526,1398,1398,1270,1270,1142,1142,1014,1016,888,888,760,760,632,632,632,504,504,504,376,376,376,248,248,248,122,122,122,250,248,250,378,378,376,378,506,506,506,506,634,634,634,634,762
  dc.w    648,648,520,520,520,520,392,392,392,392,264,264,264,264,136,136,136, 8, 8, 8,136,136,136,136,264,264,266,394,394,522,522,522,650,650,778,778,906,906,1034,1036,1164,1164,1164,1292,1420,1420,1548,1548,1676,1678,1806,1806,1934,2062,2192,2192,2320,2448,2448,2578,2706,2834,2962,2964,3220,3222,3350,3478,3606,3736,3994,3994,4122,4252,4380,4510,4766,4896,5026,5284,5284,5414,5670,5928,6058,6188,6318,6448,6578,6836,6964,7224,7226,7484,7614,7744,8002,8004,72,72,332,334,466,594,728,856,988,990,1122,1124,1254,1256,1388,1390,1520,1524,1526,1528,1532,1532,1536,1412,1414,1416,1420,1422,1298,1300,1302,1178,1180,1054,928,932,806,808,682,558,432,306,180,56,8122,7996,7870,7744,7618,7364,7368,7114,6988,6860,6608,6482,6354,6228,6102,5848,5722,5466,5340,5214,5086,4960,4834,4578,4452,4326,4198,4072,3944,3818,3690,3562,3434,3308,3308,3052,3054,2926,2798,2670,2544,2544,2418,2290,2290,2162,2034,1906,1906,1780,1780,1652,1652,1524,1396,1396,1268,1270,1270,1142,1142,1014,1014,886,886,758,758,630,632,632,502,504,376,376,376,248,248,248,248,120,120,120,248,248,248,376,376,376,376,504,504,504,506,632,634,634,634,762
  dc.w    648,648,520,520,520,520,392,392,392,392,264,264,264,264,136,136,136, 8,10,10,10,138,138,138,266,266,266,394,394,522,522,522,650,650,778,780,908,908,908,1036,1036,1164,1164,1292,1294,1422,1422,1550,1678,1678,1806,1936,1936,2064,2064,2192,2322,2450,2450,2578,2706,2836,2964,2964,3094,3222,3350,3480,3608,3738,3866,3994,4124,4254,4382,4512,4640,4770,5026,5028,5286,5416,5672,5802,5932,6190,6190,6320,6580,6708,6838,6968,7226,7358,7358,7616,7746,7878,8008,8138,76,206,338,468,600,600,732,734,994,994,998,1000,1132,1134,1264,1268,1270,1400,1404,1406,1280,1284,1286,1288,1164,1166,1168,1044,1046,1048,924,926,800,804,678,552,426,428,302,178,52,8118,7992,7866,7742,7616,7490,7364,7238,6984,6858,6732,6606,6352,6226,6100,5972,5846,5592,5466,5338,5212,5086,4832,4704,4578,4450,4324,4196,4070,3942,3816,3688,3562,3434,3306,3180,3052,2924,2926,2798,2670,2542,2542,2414,2288,2288,2162,2034,1906,1906,1778,1778,1650,1522,1524,1396,1396,1268,1268,1140,1140,1012,1014,1014,884,886,758,758,630,630,630,502,502,374,374,374,248,248,248,120,120,120,120,248,248,248,376,376,376,504,504,504,504,504,632,632,632,632,760
  dc.w    648,648,520,520,520,520,392,392,392,394,394,266,266,266,138,138,138,10,10,10,10,138,138,138,266,266,266,394,394,522,524,524,652,652,780,780,780,908,908,1036,1038,1166,1166,1294,1294,1422,1422,1550,1552,1680,1808,1808,1936,2064,2066,2194,2322,2322,2452,2580,2708,2708,2838,2966,3094,3224,3352,3482,3482,3738,3740,3996,3998,4254,4384,4512,4642,4900,4900,5030,5158,5416,5418,5676,5934,5934,6064,6324,6452,6582,6712,6842,6972,7230,7360,7492,7620,7752,7880,8010,8012,80,82,212,344,472,476,606,738,740,870,872,1004,1008,1010,1012,1142,1146,1148,1150,1024,1028,1030,1032,1036,910,912,914,918,792,794,670,672,546,420,424,298,172,46,48,7988,7990,7864,7738,7612,7488,7360,7234,6980,6984,6730,6602,6348,6222,6096,5970,5844,5718,5462,5336,5210,5084,4956,4830,4702,4576,4448,4194,4068,3940,3814,3814,3558,3560,3432,3306,3178,3050,2922,2796,2796,2670,2542,2414,2414,2286,2160,2160,2032,1904,1904,1778,1650,1650,1522,1522,1394,1394,1268,1268,1140,1140,1012,1012,884,884,884,756,758,630,630,630,502,502,374,374,374,246,246,246,118,118,118,118,246,248,248,374,376,376,504,504,504,504,504,632,632,632,632,760
  dc.w    650,650,522,522,522,522,394,394,394,394,394,266,266,266,138,138,138,138,10,10,10,138,138,140,268,268,268,396,396,524,524,524,652,652,652,780,782,910,910,1038,1038,1166,1166,1294,1424,1424,1424,1552,1552,1680,1810,1810,1938,1938,2066,2196,2196,2324,2452,2580,2582,2710,2838,2968,3096,3224,3354,3354,3482,3612,3740,3870,3998,4128,4256,4386,4516,4644,4774,5030,5032,5290,5418,5548,5678,5808,6066,6196,6324,6454,6584,6714,6974,6974,7232,7234,7364,7624,7626,7756,7886,8146,8146,84,88,218,350,478,482,484,616,746,748,750,880,884,886,1018,1020,1022,896,900,902,904,780,782,784,658,662,664,538,542,416,418,292,166,40,44,8110,7984,7986,7732,7608,7610,7356,7230,7232,6978,6980,6726,6600,6474,6348,6222,6096,5840,5714,5588,5462,5334,5080,5082,4826,4700,4574,4446,4320,4192,4066,3938,3812,3684,3558,3430,3302,3304,3176,3048,2922,2794,2666,2668,2540,2412,2286,2286,2158,2030,2030,1904,1904,1776,1648,1648,1520,1522,1394,1394,1266,1266,1138,1140,1010,1010,884,884,884,756,756,628,628,628,500,500,372,374,374,246,246,246,118,118,118,246,246,246,246,374,374,374,502,502,502,502,502,630,630,630,632,760
  dc.w    650,650,522,522,522,522,522,394,394,394,394,266,266,266,138,138,140,140,12,12,12,140,140,140,268,268,268,396,396,396,526,526,654,654,654,782,782,910,910,1038,1040,1168,1168,1296,1296,1424,1424,1554,1554,1682,1682,1810,1938,1940,2068,2196,2196,2324,2454,2454,2582,2712,2840,2968,3098,3098,3226,3356,3484,3612,3742,3870,4000,4130,4258,4388,4516,4646,4774,5032,5034,5162,5292,5422,5552,5808,5940,6068,6198,6328,6458,6588,6718,6976,7106,7108,7238,7368,7498,7628,7758,8018,8018,8152,8152,92,92,224,354,356,486,490,492,622,626,626,758,760,764,766,640,644,646,648,652,526,528,530,404,408,410,284,286,162,36,38,40,7978,7982,7856,7730,7604,7478,7352,7226,7228,6974,6848,6722,6596,6470,6344,6218,6092,5966,5840,5586,5458,5332,5206,5080,4952,4826,4698,4572,4446,4318,4064,4064,3938,3810,3684,3556,3430,3302,3174,3048,3048,2920,2792,2666,2538,2538,2410,2284,2284,2156,2156,2030,1902,1774,1776,1648,1646,1520,1520,1392,1392,1266,1266,1138,1138,1010,1010,882,882,754,756,756,628,628,500,500,500,372,372,372,244,244,244,118,116,118,246,246,246,246,374,374,374,502,502,502,502,630,630,630,630,630,758
  dc.w    650,650,522,522,522,522,522,396,396,396,396,268,268,268,140,140,140,140,12,12,12,140,140,140,270,270,270,398,398,398,526,526,526,654,654,782,782,912,912,1040,1040,1168,1168,1296,1298,1426,1426,1554,1554,1682,1684,1812,1812,1940,2068,2198,2198,2326,2326,2456,2584,2712,2842,2842,2970,3100,3228,3356,3486,3614,3616,3744,3874,4002,4260,4260,4390,4518,4776,4776,5034,5036,5294,5294,5552,5812,5812,5942,6200,6202,6330,6590,6590,6720,6850,6980,7240,7240,7370,7500,7632,7762,7764,8024,8024,8156,8158,98,98,228,232,362,364,496,498,500,502,506,508,510,384,388,390,392,396,396,400,402,276,280,154,156,158,32,8098,7974,7976,7850,7724,7598,7602,7476,7350,7352,7226,6972,6846,6720,6722,6468,6342,6216,6090,5962,5836,5710,5584,5458,5202,5076,5078,4822,4696,4570,4442,4316,4188,4062,3936,3808,3680,3554,3556,3428,3300,3174,3046,2918,2790,2792,2664,2536,2410,2410,2282,2284,2156,2028,2028,1900,1774,1774,1646,1646,1518,1520,1392,1392,1264,1264,1136,1138,1010,1010,882,882,754,754,626,626,626,498,500,500,372,372,372,244,244,244,116,116,116,244,244,244,244,372,374,374,502,502,502,502,630,630,630,630,630,758
  dc.w    652,652,524,524,524,524,524,396,396,396,396,268,268,268,268,140,140,140,12,12,14,142,142,142,270,270,270,398,398,398,526,526,528,656,656,784,784,912,912,1040,1040,1040,1170,1170,1298,1298,1426,1428,1556,1556,1684,1812,1812,1942,2070,2070,2198,2328,2328,2456,2584,2586,2714,2844,2972,3100,3230,3230,3358,3488,3616,3746,3874,4004,4132,4262,4390,4520,4648,4778,4908,5038,5166,5296,5426,5556,5684,5814,5944,6074,6204,6334,6464,6722,6724,6854,6984,7114,7244,7374,7376,7506,7636,7768,7768,8028,8030,8162,8162,102,104,106,108,238,242,372,374,376,380,382,256,260,262,264,266,268,144,146,20,24,26,28,8094,7968,7970,7844,7720,7722,7596,7470,7472,7346,7220,7094,6970,6842,6846,6590,6464,6338,6212,6086,5960,5834,5708,5582,5456,5328,5202,5076,4948,4822,4696,4568,4442,4314,4188,4062,3934,3806,3680,3552,3426,3298,3300,3172,3046,2918,2790,2662,2664,2536,2408,2410,2282,2154,2154,2026,1898,1900,1772,1644,1646,1518,1518,1390,1390,1262,1264,1134,1136,1136,1008,1008,880,882,752,754,626,626,626,498,498,498,370,370,370,244,244,244,116,116,116,244,244,244,372,372,372,372,500,500,500,500,628,628,628,630,630,758
  dc.w    652,652,652,524,524,524,524,396,396,396,396,268,270,270,270,142,142,142,14,14,14,142,142,142,142,270,270,270,400,400,528,528,528,656,656,784,784,914,914,914,1042,1042,1170,1170,1300,1300,1428,1428,1556,1556,1686,1814,1814,1942,1942,2072,2200,2200,2330,2458,2458,2588,2716,2844,2972,2974,3230,3232,3360,3488,3618,3618,3748,3876,4006,4134,4392,4392,4522,4652,4910,4910,5040,5170,5300,5428,5558,5688,5818,5948,6206,6206,6336,6466,6596,6856,6856,6986,7116,7246,7378,7378,7510,7640,7642,7772,7774,7906,8034,8038,8040,8172,8172,112,114,116,120,122,124,254,128,132, 6, 8,10,12,16,18,20,8086,7960,7964,7966,7840,7714,7716,7590,7592,7468,7340,7216,7218,7092,6966,6968,6714,6588,6462,6336,6210,6084,5958,5960,5704,5578,5452,5326,5198,5072,4946,4820,4692,4566,4438,4312,4186,4058,3932,3804,3806,3550,3552,3424,3298,3170,3042,3044,2916,2790,2662,2534,2536,2408,2280,2280,2152,2024,2026,1898,1898,1770,1644,1644,1516,1516,1390,1390,1262,1262,1134,1134,1006,1008,1008,880,880,752,752,624,624,624,496,496,370,370,370,242,242,242,242,114,114,114,242,242,244,372,372,372,372,500,500,500,500,628,628,628,628,756,756
  dc.w    652,652,652,524,524,524,524,398,398,398,398,270,270,270,270,142,142,142,14,14,14,14,142,144,144,272,272,272,400,400,528,528,528,656,658,786,786,786,914,914,1042,1042,1172,1172,1300,1300,1428,1428,1558,1558,1686,1686,1816,1944,1944,2072,2202,2202,2330,2458,2460,2588,2716,2718,2846,2974,3104,3232,3362,3362,3492,3620,3748,3878,4008,4136,4264,4394,4396,4524,4782,4912,5040,5042,5172,5302,5560,5560,5818,5950,6078,6080,6338,6340,6470,6600,6730,6988,6990,6992,7250,7252,7384,7384,7514,7644,7646,7778,7780,7910,7912,8044,8046,8048,8050,8180,8182,8186,8188,8190,8064,8068,8070,8072,8074,8076,8080,7954,7956,7958,7832,7834,7708,7712,7586,7588,7462,7464,7338,7212,7086,6960,6964,6836,6710,6586,6460,6332,6206,6080,6082,5956,5830,5576,5450,5324,5196,5070,5072,4944,4818,4564,4436,4438,4312,4184,4058,3930,3804,3676,3550,3422,3424,3296,3170,3042,2914,2786,2788,2660,2534,2534,2406,2280,2280,2152,2024,2026,1898,1770,1770,1642,1644,1516,1516,1388,1388,1260,1262,1134,1134,1006,1006,878,878,878,752,752,624,624,624,496,496,368,368,368,242,242,242,114,114,114,114,242,242,242,370,370,370,370,498,500,500,500,628,628,628,628,756,756
  dc.w    654,654,654,526,526,526,526,398,398,398,398,398,270,270,270,142,142,144,16,16,16,16,144,144,144,272,272,272,400,402,530,530,530,658,658,658,786,786,916,916,1044,1044,1172,1172,1300,1302,1430,1430,1558,1560,1688,1688,1816,1816,1946,2074,2074,2202,2332,2332,2460,2590,2590,2718,2848,2976,2976,3106,3234,3364,3492,3620,3750,3752,4008,4008,4138,4268,4398,4526,4656,4784,5044,5044,5174,5302,5432,5434,5692,5822,5950,6080,6082,6212,6342,6472,6602,6732,6734,6864,6994,7124,7256,7256,7388,7390,7520,7522,7654,7656,7786,7788,7788,7920,7924,8052,8056,8058,8060,8062,7936,7940,7942,7944,7946,7820,7822,7824,7700,7702,7704,7578,7580,7454,7458,7460,7334,7208,7210,7084,6958,6832,6706,6708,6582,6456,6330,6204,6078,5952,5954,5828,5572,5574,5448,5322,5194,5068,4942,4816,4688,4562,4436,4308,4182,4054,3928,3802,3802,3676,3548,3420,3294,3166,3040,3040,2914,2786,2658,2660,2532,2404,2406,2278,2150,2150,2024,1896,1896,1770,1770,1642,1642,1514,1514,1386,1388,1260,1260,1132,1132,1006,1006,878,878,750,750,750,622,624,624,496,496,368,368,368,240,240,240,112,112,112,114,242,242,242,370,370,370,498,498,498,498,498,626,626,626,626,756,754
  dc.w    654,654,654,526,526,526,526,526,398,398,398,398,272,272,272,144,144,144,144,16,16,16,144,144,146,274,274,274,402,402,402,530,530,530,660,660,788,788,916,916,1044,1044,1046,1174,1174,1302,1302,1432,1432,1560,1560,1688,1818,1818,1946,2074,2074,2204,2204,2332,2462,2462,2590,2720,2848,2850,2978,3106,3236,3364,3366,3494,3624,3752,3882,4010,4140,4270,4398,4400,4528,4658,4788,4918,5046,5176,5304,5434,5566,5694,5824,5954,5956,6086,6216,6346,6476,6604,6608,6738,6868,6996,7000,7130,7260,7262,7394,7394,7396,7526,7658,7660,7662,7664,7666,7798,7798,7802,7804,7806,7680,7684,7686,7688,7690,7692,7694,7568,7572,7574,7448,7450,7324,7326,7328,7202,7204,7078,6952,6956,6830,6704,6578,6580,6454,6328,6202,6076,6078,5950,5824,5698,5572,5446,5320,5192,5066,4940,4814,4686,4560,4434,4434,4308,4052,4054,3926,3800,3672,3546,3418,3420,3292,3166,3038,2912,2912,2784,2658,2530,2532,2404,2276,2276,2148,2022,2022,1894,1896,1768,1640,1640,1512,1514,1514,1386,1258,1258,1260,1132,1132,1004,1004,876,878,750,750,622,622,622,494,494,494,368,368,368,240,240,240,112,112,112,240,240,240,240,368,368,370,498,498,498,498,626,626,626,626,626,754,754
  dc.w    654,654,654,526,528,528,528,528,400,400,400,400,272,272,272,272,144,144,144,18,18,18,146,146,146,274,274,274,402,402,402,532,532,532,660,660,788,788,918,918,918,1046,1046,1174,1174,1304,1304,1432,1432,1560,1562,1690,1818,1818,1948,1948,2076,2204,2206,2334,2334,2464,2592,2720,2722,2850,2978,2980,3236,3238,3366,3496,3624,3754,3754,3884,4014,4142,4272,4400,4530,4530,4788,4790,5048,5048,5178,5308,5438,5566,5696,5826,5956,5958,6088,6218,6348,6350,6480,6610,6740,6872,6872,7002,7004,7134,7266,7268,7270,7400,7402,7404,7534,7536,7540,7670,7672,7672,7676,7678,7552,7556,7558,7560,7562,7564,7438,7440,7442,7318,7318,7322,7196,7198,7200,7074,6948,6950,6952,6698,6700,6574,6448,6322,6324,6198,6072,5946,5948,5822,5568,5568,5442,5316,5190,5064,4936,4810,4812,4558,4430,4432,4306,4178,4052,3924,3798,3798,3544,3544,3418,3290,3292,3164,3038,2910,2782,2784,2656,2528,2530,2402,2276,2276,2148,2020,2022,1894,1894,1766,1638,1640,1512,1512,1384,1384,1258,1258,1130,1130,1002,1004,1004,876,876,748,748,620,620,622,494,494,494,366,366,366,238,238,240,112,112,112,240,240,240,368,368,368,368,496,496,496,496,626,626,626,626,626,754,754
  dc.w    656,656,656,528,528,528,528,528,400,400,400,400,272,272,272,272,146,146,146,18,18,18,146,146,146,146,274,276,276,404,404,532,532,532,660,662,790,790,790,918,918,1046,1048,1176,1176,1304,1304,1434,1434,1562,1562,1690,1692,1820,1820,1948,2078,2078,2206,2208,2336,2464,2594,2594,2722,2852,2852,2980,3110,3238,3368,3496,3498,3626,3756,3884,4014,4016,4144,4274,4404,4532,4662,4790,4920,4922,5052,5182,5310,5440,5570,5572,5830,5960,5962,6090,6220,6222,6352,6482,6612,6616,6746,6746,6876,7008,7010,7140,7140,7272,7274,7278,7406,7408,7412,7414,7416,7418,7420,7550,7424,7300,7302,7304,7306,7308,7310,7312,7186,7188,7190,7194,7068,6942,6944,6946,6820,6694,6696,6570,6572,6446,6320,6194,6196,6070,5944,5818,5820,5694,5566,5440,5314,5188,5062,4934,4936,4810,4682,4556,4430,4302,4176,4050,4050,3924,3796,3670,3542,3416,3416,3290,3162,3036,2908,2910,2782,2654,2656,2528,2400,2272,2274,2146,2146,2020,1892,1892,1766,1766,1638,1638,1510,1512,1384,1384,1256,1256,1130,1130,1002,1002,874,874,876,748,748,620,620,620,492,492,366,366,366,238,238,238,238,110,110,110,238,240,240,368,368,368,368,496,496,496,496,624,624,624,624,624,752,752
  dc.w    656,656,656,656,528,528,528,528,400,400,400,402,274,274,274,274,146,146,146,18,18,18,20,148,148,148,276,276,404,404,404,532,534,534,662,662,662,790,790,920,920,1048,1048,1176,1176,1178,1306,1306,1434,1434,1564,1564,1692,1820,1822,1950,2078,2080,2208,2208,2336,2466,2466,2596,2724,2724,2854,2982,2982,3240,3240,3370,3498,3500,3628,3758,3888,4016,4146,4276,4276,4406,4534,4664,4794,4922,5054,5054,5184,5314,5442,5572,5574,5704,5834,6092,6094,6094,6226,6356,6358,6488,6618,6748,6748,6752,6882,6884,7014,7016,7018,7148,7150,7282,7282,7286,7288,7290,7292,7294,7168,7172,7174,7176,7178,7180,7182,7184,7058,7060,6934,6938,6940,6812,6814,6688,6692,6566,6566,6440,6316,6318,6190,6064,6068,5940,5814,5688,5562,5564,5438,5312,5184,5058,5060,4934,4808,4680,4554,4426,4428,4174,4046,4048,3922,3794,3668,3540,3542,3414,3288,3288,3162,3034,2908,2780,2780,2654,2526,2526,2400,2272,2272,2146,2018,2018,1890,1892,1764,1636,1638,1510,1510,1382,1384,1254,1256,1256,1128,1128,1002,1002,874,874,746,746,746,620,620,620,492,492,364,364,364,236,238,238,110,110,110,110,238,238,238,366,366,366,366,496,496,496,496,624,624,624,624,752,752,752
  dc.w    656,656,656,656,530,530,530,530,402,402,402,402,402,274,274,274,146,146,146,148,20,20,20,148,148,148,276,276,278,406,406,406,534,534,534,662,664,792,792,920,920,920,1050,1050,1178,1178,1306,1308,1436,1436,1564,1564,1694,1822,1822,1952,1952,2080,2080,2210,2338,2338,2468,2596,2596,2726,2854,2854,2984,3112,3242,3372,3372,3500,3630,3758,3760,3890,4018,4148,4276,4406,4536,4536,4666,4796,4926,5054,5056,5186,5316,5446,5576,5578,5706,5838,5966,5968,6098,6228,6360,6360,6362,6492,6622,6624,6754,6756,6758,6888,7020,7022,7024,7026,7028,7158,7160,7162,7164,7166,7040,7044,7046,7048,7048,6924,6926,6928,6930,6932,6806,6808,6682,6684,6686,6560,6562,6436,6310,6312,6186,6188,6062,5936,5938,5812,5686,5560,5432,5434,5308,5182,5056,5058,4932,4804,4678,4552,4424,4426,4300,4172,4046,3920,3792,3794,3666,3540,3412,3414,3286,3160,3032,2906,2906,2780,2652,2652,2524,2398,2398,2272,2144,2144,2016,2018,1890,1762,1764,1636,1636,1508,1510,1382,1382,1254,1254,1126,1128,1128,1000,1000,872,874,746,746,618,618,618,490,492,492,364,364,364,236,236,236,108,108,110,238,238,238,238,366,366,366,494,494,494,494,494,624,624,624,624,752,752,752
  dc.w    658,658,658,658,530,530,530,530,530,402,402,402,402,274,276,276,148,148,148,148,20,20,20,148,148,150,278,278,278,406,406,406,534,536,536,664,664,792,792,794,922,922,1050,1050,1178,1180,1308,1308,1436,1436,1566,1566,1694,1694,1824,1824,1952,2082,2082,2210,2210,2340,2468,2470,2598,2726,2728,2984,2986,2986,3116,3244,3372,3502,3504,3632,3760,3892,4020,4020,4150,4408,4408,4538,4540,4798,4798,4928,5058,5060,5188,5318,5320,5450,5580,5708,5838,5970,5970,6100,6104,6232,6234,6364,6366,6498,6498,6628,6632,6762,6764,6766,6766,6898,6900,6902,7032,7034,7036,7038,6912,6916,6918,6920,6920,6794,6798,6800,6674,6676,6678,6680,6554,6556,6558,6432,6306,6308,6182,6184,6058,6060,5934,5808,5810,5684,5556,5430,5304,5306,5180,5054,5054,4928,4802,4676,4550,4422,4424,4296,4170,4044,4044,3918,3792,3664,3538,3538,3412,3284,3158,3158,3032,2904,2776,2778,2650,2524,2524,2398,2270,2270,2142,2144,2016,1888,1888,1762,1762,1634,1634,1508,1508,1380,1380,1254,1254,1126,1126,1000,998,872,872,872,744,746,616,618,618,490,490,490,362,362,364,236,236,236,108,108,108,236,236,236,238,366,366,366,494,494,494,494,622,622,622,622,622,750,752,752
  dc.w    658,658,658,658,530,530,530,530,532,404,404,404,404,276,276,276,276,148,148,148,20,22,22,150,150,150,150,278,278,278,408,408,536,536,536,664,664,664,794,794,922,922,1050,1052,1180,1180,1180,1308,1310,1438,1566,1566,1568,1696,1824,1824,1954,1954,2082,2212,2212,2340,2342,2470,2598,2600,2728,2858,2858,2988,3116,3246,3246,3376,3504,3504,3764,3764,3892,4022,4022,4152,4282,4410,4540,4542,4672,4800,4930,5060,5062,5190,5320,5322,5452,5582,5584,5842,5844,5974,5976,6104,6236,6236,6240,6370,6370,6372,6502,6634,6636,6638,6640,6770,6770,6774,6776,6776,6780,6782,6656,6660,6662,6662,6664,6666,6670,6672,6546,6548,6550,6552,6426,6300,6302,6304,6178,6180,6054,6056,5930,5932,5806,5678,5552,5554,5428,5302,5304,5178,5050,5052,4926,4800,4674,4546,4420,4420,4294,4168,4042,4042,3916,3788,3662,3534,3536,3410,3282,3284,3156,3030,2902,2902,2776,2648,2650,2522,2394,2396,2268,2270,2142,2014,2014,1888,1888,1760,1634,1634,1506,1506,1378,1380,1252,1252,1252,1124,1126,998,998,870,870,742,744,744,616,616,616,490,490,362,362,362,234,234,234,234,108,108,108,236,236,236,364,364,364,364,492,494,494,494,622,622,622,622,622,750,750,750
  dc.w    658,658,658,658,530,532,532,532,532,404,404,404,404,276,276,276,276,150,150,150,22,22,22,22,150,150,150,280,280,280,408,408,408,536,538,666,666,666,794,794,924,924,1052,1052,1052,1180,1182,1310,1438,1438,1440,1568,1568,1696,1698,1826,1826,1956,2084,2084,2214,2214,2342,2472,2472,2600,2730,2730,2860,2988,2990,3118,3248,3376,3378,3506,3636,3764,3766,3894,4024,4154,4154,4284,4414,4542,4544,4802,4804,4932,5062,5064,5194,5194,5324,5456,5456,5586,5716,5846,5848,5978,5980,6110,6110,6242,6244,6374,6376,6378,6380,6510,6512,6512,6644,6646,6648,6650,6652,6654,6528,6530,6534,6534,6536,6538,6542,6416,6416,6420,6294,6296,6298,6172,6174,6176,6048,6050,5926,5926,5800,5802,5676,5550,5424,5426,5300,5174,5174,5048,5050,4924,4798,4670,4544,4546,4418,4292,4166,4168,4040,3914,3786,3788,3660,3534,3408,3408,3282,3154,3028,3028,2900,2774,2774,2648,2520,2522,2394,2266,2268,2140,2140,2012,1886,1886,1758,1760,1632,1632,1506,1506,1378,1378,1250,1252,1124,1124,1124,996,998,870,870,742,742,744,614,616,488,488,488,360,360,362,234,234,234,106,106,106,106,234,234,234,364,364,364,364,492,492,492,492,620,622,622,622,748,750,750,750
  dc.w    788,660,660,660,660,532,532,532,532,404,404,404,404,406,278,278,278,150,150,150,150,22,22,24,152,152,152,280,280,280,408,410,410,538,538,538,666,668,796,796,796,924,924,1054,1054,1182,1182,1310,1312,1440,1440,1440,1570,1570,1698,1826,1828,1956,1956,2086,2214,2214,2344,2344,2472,2602,2602,2732,2860,2862,2990,3120,3248,3248,3378,3380,3508,3638,3766,3896,3896,4026,4156,4286,4286,4416,4546,4546,4676,4806,4936,4936,5066,5068,5198,5328,5458,5458,5588,5720,5720,5850,5852,5982,5984,6114,6116,6246,6248,6250,6252,6382,6384,6386,6388,6390,6392,6522,6524,6526,6400,6402,6534,6406,6280,6282,6286,6286,6288,6290,6166,6166,6168,6044,6044,6046,5920,5922,5796,5798,5672,5546,5548,5550,5424,5296,5300,5172,5046,5048,4920,4794,4668,4542,4544,4416,4418,4164,4164,4038,4040,3784,3786,3660,3532,3534,3406,3280,3152,3154,3026,2898,2900,2772,2646,2646,2520,2392,2392,2266,2266,2138,2012,2012,1886,1886,1758,1630,1632,1632,1504,1504,1376,1378,1250,1250,1122,1124,996,996,868,868,870,742,742,614,614,614,488,488,488,360,360,360,232,232,232,106,106,106,234,234,234,234,362,362,364,492,492,492,492,492,620,620,620,620,748,748,748,750
  dc.w    788,660,660,660,660,532,532,532,534,534,406,406,406,406,278,278,278,150,150,152,152,24,24,24,152,152,152,280,280,282,282,410,410,538,538,540,668,668,668,796,798,926,926,1054,1054,1184,1184,1184,1312,1312,1442,1442,1570,1570,1700,1700,1828,1830,1958,2086,2088,2216,2344,2344,2474,2474,2604,2604,2862,2862,2864,2992,3122,3250,3252,3380,3510,3510,3768,3768,3898,3900,4028,4158,4288,4288,4418,4420,4550,4678,4808,4938,4938,5068,5070,5200,5330,5332,5462,5464,5592,5596,5724,5854,5858,5858,5988,5992,6120,6122,6124,6126,6256,6258,6260,6262,6264,6394,6396,6398,6272,6274,6276,6150,6152,6154,6156,6158,6160,6162,6036,6038,6040,5914,5916,5918,5792,5794,5668,5542,5544,5416,5418,5292,5294,5168,5042,5044,4918,4918,4792,4666,4540,4542,4414,4288,4160,4162,4036,3908,3910,3784,3656,3530,3530,3404,3278,3278,3150,3024,2896,2898,2770,2644,2644,2518,2518,2390,2264,2264,2138,2138,2010,1882,1884,1756,1758,1630,1630,1504,1504,1376,1376,1248,1250,1250,1122,1122,994,996,868,868,740,740,740,614,612,614,486,486,358,358,360,232,232,232,232,104,104,106,234,234,234,234,362,362,362,490,490,492,492,618,620,620,620,620,748,748,748,748
  dc.w    788,660,660,660,662,534,534,534,534,534,406,406,406,406,278,280,280,280,152,152,152,24,24,24,24,154,154,154,282,282,282,410,412,412,540,540,540,668,668,798,798,926,926,926,1056,1056,1184,1184,1314,1314,1442,1442,1572,1572,1572,1700,1830,1830,1958,1960,2088,2216,2218,2346,2346,2476,2476,2734,2734,2736,2864,2994,2994,3124,3252,3382,3382,3512,3512,3642,3772,3900,3902,4030,4160,4290,4292,4420,4422,4552,4680,4810,4940,4942,5072,5074,5202,5204,5336,5336,5466,5596,5596,5600,5730,5730,5860,5864,5864,5994,5996,5998,6128,6130,6132,6134,6136,6138,6142,6270,6144,6018,6020,6022,6024,6026,6028,6030,6032,5906,5908,5910,5912,5786,5788,5662,5664,5538,5540,5414,5416,5288,5290,5164,5166,5040,5042,4916,4788,4790,4664,4536,4538,4412,4286,4158,4160,4034,3906,3908,3782,3654,3528,3528,3402,3274,3276,3148,3022,3022,2896,2768,2770,2642,2516,2516,2390,2390,2262,2264,2136,2010,2010,1882,1882,1756,1628,1628,1630,1502,1502,1374,1376,1248,1248,1120,1120,994,994,994,866,868,740,740,612,612,612,612,484,486,358,358,358,230,232,232,104,104,104,104,232,232,232,362,360,362,362,490,490,490,490,618,618,618,618,620,748,748,748,748
  dc.w    790,662,662,662,662,534,534,534,534,534,406,406,406,408,280,280,280,280,152,152,152,152,26,26,26,154,154,154,282,282,284,412,412,412,540,540,542,670,670,798,798,800,928,928,1056,1056,1186,1186,1186,1314,1314,1444,1444,1572,1574,1702,1702,1832,1832,1960,2088,2090,2218,2220,2348,2348,2478,2606,2608,2736,2866,2866,2996,3124,3124,3254,3382,3384,3514,3514,3644,3774,3902,3904,4032,4162,4164,4292,4424,4424,4554,4682,4684,4814,4944,5074,5076,5076,5206,5208,5338,5340,5470,5470,5602,5604,5604,5734,5736,5866,5868,5870,6002,6002,6004,6008,6008,6010,6012,6014,5888,5890,5892,5894,5896,5898,5900,5902,5904,5778,5780,5782,5656,5658,5532,5532,5536,5408,5410,5284,5286,5160,5162,5036,5038,4910,4912,4786,4660,4662,4534,4408,4410,4284,4156,4158,4032,3904,3906,3780,3652,3654,3526,3400,3400,3274,3146,3148,3020,2894,2896,2768,2642,2642,2514,2388,2388,2260,2262,2134,2136,2008,1880,1880,1754,1754,1626,1628,1500,1500,1374,1374,1246,1246,1248,1120,1120,992,992,866,866,866,738,740,612,612,612,484,484,484,358,358,358,230,230,230,102,104,104,232,232,232,232,360,360,360,360,490,490,490,490,618,618,618,618,746,746,746,748,748
  dc.w    790,790,662,662,662,662,534,534,534,536,408,408,408,408,408,280,280,280,152,154,154,154,26,26,26,154,154,156,284,284,284,284,412,412,542,542,542,670,670,672,800,800,928,928,1058,1058,1058,1186,1188,1316,1316,1444,1446,1574,1574,1574,1704,1832,1832,1962,1962,2090,2092,2220,2220,2350,2478,2480,2608,2738,2738,2868,2868,2998,3126,3256,3256,3386,3386,3516,3646,3646,3776,3904,4034,4036,4164,4166,4296,4424,4426,4556,4558,4686,4816,4818,4948,4950,5080,5080,5210,5212,5342,5344,5474,5476,5606,5608,5610,5612,5742,5744,5744,5876,5876,5880,5882,5882,5884,5886,5760,5762,5764,5766,5768,5770,5772,5774,5648,5650,5652,5526,5528,5530,5402,5404,5406,5280,5282,5156,5158,5032,5032,4906,4908,4782,4784,4658,4532,4532,4406,4408,4280,4154,4156,4028,4030,3904,3776,3778,3652,3524,3398,3400,3272,3274,3146,3020,2892,2894,2766,2768,2640,2512,2514,2386,2260,2260,2132,2134,2006,2006,1880,1880,1752,1626,1626,1626,1500,1500,1372,1374,1246,1246,1118,1120,1120,992,992,864,864,738,738,738,610,610,612,484,484,356,356,356,358,230,230,230,102,102,102,230,232,230,232,360,360,360,488,488,488,488,490,618,618,618,618,746,746,746,746,874
  dc.w    790,790,662,662,662,664,536,536,536,536,536,408,408,408,408,280,282,282,282,154,154,154,26,26,28,28,156,156,156,284,286,286,414,414,414,542,542,544,672,672,800,800,802,930,930,1058,1060,1188,1188,1188,1318,1318,1446,1446,1576,1576,1704,1704,1834,1834,1962,1964,2092,2222,2222,2350,2352,2480,2482,2610,2740,2740,2870,2998,2998,3128,3256,3258,3388,3518,3518,3648,3648,3778,3906,3908,4038,4168,4168,4298,4428,4428,4558,4560,4690,4690,4820,4952,4952,5082,5084,5086,5214,5218,5346,5348,5350,5480,5482,5484,5614,5614,5618,5618,5622,5622,5754,5754,5756,5758,5632,5634,5636,5638,5640,5514,5516,5518,5520,5522,5524,5398,5400,5402,5274,5276,5278,5152,5154,5156,5030,5032,4904,4778,4780,4782,4656,4528,4530,4404,4406,4278,4152,4026,4026,3900,3902,3776,3776,3650,3522,3396,3396,3270,3272,3144,3018,3018,2892,2764,2766,2638,2510,2512,2384,2386,2258,2258,2132,2132,2006,1878,1878,1752,1752,1624,1626,1498,1498,1370,1372,1244,1244,1244,1118,1118,990,990,862,864,864,736,736,610,610,610,482,482,482,356,356,356,228,228,228,100,102,102,102,230,230,230,358,360,360,360,488,488,488,488,616,616,616,616,618,746,746,746,746,874
  dc.w    792,792,664,664,664,664,536,536,536,536,536,408,410,410,410,282,282,282,282,154,154,156,156,28,28,28,156,156,158,286,286,286,414,414,416,544,544,544,672,672,802,802,802,930,932,1060,1060,1060,1188,1190,1318,1318,1446,1448,1576,1576,1578,1706,1834,1836,1964,1964,2094,2094,2224,2224,2352,2482,2482,2612,2612,2740,2870,2870,3000,3000,3130,3258,3260,3390,3390,3520,3648,3778,3780,3908,3910,4040,4040,4170,4300,4302,4432,4432,4562,4564,4694,4824,4824,4954,4956,5086,5088,5090,5220,5220,5224,5354,5354,5356,5356,5488,5490,5490,5494,5496,5626,5626,5628,5630,5504,5506,5508,5510,5512,5514,5388,5390,5392,5394,5268,5270,5270,5272,5146,5148,5150,5024,5026,5028,4900,4902,4776,4778,4652,4524,4526,4400,4402,4404,4276,4150,4024,4024,3898,3900,3772,3646,3648,3520,3522,3394,3268,3270,3142,3016,3016,2890,2762,2764,2636,2638,2510,2512,2384,2256,2258,2130,2130,2004,2004,1878,1878,1750,1622,1624,1624,1496,1498,1370,1370,1242,1244,1116,1116,1118,990,990,862,862,734,736,736,608,608,608,482,482,482,354,354,356,228,228,228,100,100,100,228,230,230,230,358,358,358,358,488,486,488,488,616,616,616,616,616,744,744,744,746,872
  dc.w    792,792,792,664,664,664,664,536,536,538,538,410,410,410,410,410,282,282,284,156,156,156,156,28,28,28,158,158,158,158,286,286,288,416,416,416,544,544,546,674,674,802,802,932,932,932,1060,1062,1190,1190,1190,1320,1320,1448,1448,1578,1578,1706,1708,1836,1836,1966,1966,2094,2224,2224,2226,2354,2484,2484,2614,2614,2744,2872,2872,3002,3002,3132,3262,3262,3392,3520,3522,3652,3652,3782,3912,3912,4042,4042,4172,4174,4304,4434,4434,4436,4566,4696,4696,4826,4828,4830,4960,4962,5090,5094,5096,5096,5226,5228,5230,5360,5360,5364,5366,5368,5370,5498,5500,5502,5376,5378,5380,5382,5256,5258,5260,5262,5264,5264,5138,5140,5142,5144,5018,5020,5022,4894,4896,4770,4772,4774,4648,4648,4522,4396,4398,4400,4272,4146,4148,4020,4022,4024,3768,3770,3644,3646,3518,3520,3392,3394,3268,3140,3014,3014,2888,2888,2762,2634,2636,2508,2508,2382,2254,2256,2256,2128,2002,2002,1876,1876,1748,1750,1622,1624,1496,1496,1368,1370,1242,1242,1242,1116,1116,988,988,860,862,862,734,734,736,608,608,608,480,482,354,354,354,226,226,226,226,100,100,100,228,228,228,230,358,358,358,486,486,486,486,486,614,616,616,616,744,744,744,744,872,872
  dc.w    792,792,792,664,664,666,666,538,538,538,538,538,410,410,410,412,284,284,284,284,156,156,156,30,30,30,30,158,158,160,288,288,288,416,416,416,546,546,546,674,674,804,804,804,932,934,1062,1062,1062,1192,1192,1320,1320,1450,1450,1578,1580,1580,1708,1838,1838,1838,1968,2096,2096,2226,2226,2356,2356,2486,2486,2614,2744,2744,2874,2874,3004,3134,3134,3264,3264,3394,3394,3524,3654,3654,3784,3786,3914,4044,4046,4046,4176,4306,4308,4436,4440,4568,4570,4700,4700,4830,4832,4834,4964,4966,4966,5096,5098,5100,5102,5232,5234,5236,5238,5240,5242,5242,5244,5374,5248,5250,5252,5126,5128,5130,5132,5134,5134,5136,5010,5012,5014,5016,4890,4892,4892,4766,4768,4770,4644,4646,4518,4520,4394,4396,4270,4270,4144,4146,4020,4020,3894,3768,3768,3642,3644,3516,3390,3390,3264,3266,3138,3012,3012,2886,2886,2760,2760,2634,2506,2508,2380,2380,2254,2256,2128,2128,2000,1874,1874,1876,1748,1620,1622,1622,1494,1496,1368,1368,1242,1240,1114,1114,1114,988,988,860,860,862,734,734,606,606,608,480,480,480,352,352,352,226,226,226,98,98,98,100,228,228,228,356,356,356,356,486,486,486,486,614,614,614,614,614,742,742,744,744,872,872
  dc.w    792,794,794,666,666,666,666,538,538,538,538,538,412,412,412,412,284,284,284,284,158,158,158,158,30,30,30,160,160,160,288,288,288,288,418,418,546,546,546,676,676,676,804,804,934,934,934,1062,1064,1192,1192,1192,1322,1322,1450,1452,1580,1580,1710,1710,1838,1840,1968,1968,2098,2098,2228,2228,2358,2358,2486,2488,2616,2746,2746,2876,3006,3006,3136,3136,3266,3266,3396,3396,3526,3656,3656,3786,3788,3918,3918,4048,4178,4180,4180,4310,4440,4440,4442,4572,4572,4574,4706,4706,4836,4838,4840,4968,4972,4972,5102,5104,5106,5108,5110,5110,5114,5116,5116,5118,4992,4994,4996,4998,5000,5002,5004,5004,5006,5008,5010,4884,4886,4888,4890,4762,4764,4766,4640,4514,4516,4516,4390,4392,4394,4266,4140,4142,4016,4016,3890,3892,3764,3766,3768,3512,3514,3388,3388,3262,3264,3136,3010,3010,2884,2884,2758,2758,2632,2504,2506,2378,2380,2252,2252,2126,2128,2000,2000,1874,1874,1746,1746,1620,1620,1492,1494,1366,1366,1238,1240,1240,1112,1114,986,986,986,860,860,732,732,734,606,606,606,478,480,352,352,352,352,224,226,226,98,98,98,98,226,228,228,356,356,356,356,484,484,484,484,614,614,614,614,614,742,742,742,742,872,872
  dc.w    794,794,794,666,666,666,666,666,540,540,540,540,412,412,412,412,412,286,286,286,286,158,158,158,30,32,32,32,160,160,160,290,290,290,418,418,420,548,548,548,676,676,806,806,806,934,936,1064,1064,1064,1194,1194,1322,1324,1452,1452,1452,1582,1582,1710,1712,1840,1842,1970,1970,2100,2100,2230,2230,2358,2488,2488,2618,2618,2748,2748,2878,2878,3008,3008,3266,3268,3268,3398,3528,3528,3530,3660,3788,3790,3790,3920,4050,4052,4052,4184,4312,4312,4444,4444,4446,4576,4578,4578,4708,4710,4712,4842,4844,4846,4976,4976,4978,4980,4982,4984,5114,5116,5116,5118,4992,4994,4996,4998,5000,4874,4874,4876,4878,4880,4882,4756,4758,4758,4632,4634,4636,4510,4512,4514,4386,4388,4390,4264,4264,4138,4012,4014,4014,3888,3762,3764,3764,3638,3512,3512,3386,3386,3260,3262,3134,3136,3008,2882,2882,2756,2756,2630,2630,2504,2504,2378,2250,2252,2124,2124,1998,1998,1872,1872,1744,1746,1618,1618,1492,1492,1492,1366,1366,1238,1238,1112,1112,1112,986,986,858,858,860,732,732,604,604,606,478,478,478,350,352,352,224,224,224,96,98,98,98,226,226,226,226,354,354,356,484,484,484,484,484,612,612,614,614,742,742,742,742,742,870,870
  dc.w    794,794,794,794,666,668,668,668,540,540,540,540,540,412,412,414,414,286,286,286,286,158,160,160,32,32,32,32,160,162,162,290,290,290,290,420,420,548,548,548,678,678,678,806,808,936,936,1064,1064,1066,1194,1194,1196,1324,1324,1454,1454,1582,1582,1584,1712,1714,1842,1972,1972,1972,2102,2230,2230,2360,2360,2490,2490,2620,2620,2750,2750,2880,2880,3010,3010,3140,3270,3270,3400,3400,3530,3532,3660,3662,3792,3794,3922,3924,4052,4054,4184,4186,4316,4316,4318,4448,4450,4452,4580,4582,4584,4714,4716,4718,4848,4850,4850,4852,4854,4856,4856,4988,4988,4990,4864,4866,4868,4870,4744,4744,4746,4748,4750,4752,4626,4628,4630,4630,4504,4506,4508,4382,4382,4384,4386,4260,4262,4134,4136,4010,4012,3884,3886,3760,3760,3634,3636,3508,3510,3384,3384,3258,3258,3132,3006,3006,2880,2880,2754,2756,2628,2628,2502,2502,2376,2376,2250,2250,2124,1996,1996,1870,1870,1872,1744,1616,1618,1618,1490,1490,1364,1364,1236,1238,1238,1110,1112,984,984,986,858,858,730,730,732,604,604,604,476,478,350,350,350,350,222,222,224,96,96,96,96,226,226,226,354,354,354,354,482,484,484,484,612,612,612,612,612,740,740,742,742,870,870,870
  dc.w    794,796,796,796,668,668,668,668,540,540,540,540,542,414,414,414,414,414,286,288,288,160,160,160,160,32,34,34,162,162,162,162,290,292,292,420,420,420,550,550,550,678,680,808,808,808,936,938,1066,1066,1066,1196,1196,1324,1326,1326,1454,1456,1584,1584,1714,1714,1844,1844,1972,1974,2102,2102,2232,2232,2362,2362,2492,2492,2622,2622,2752,2752,2882,2882,3012,3012,3142,3272,3272,3402,3402,3532,3534,3534,3664,3794,3796,3796,3926,3928,4056,4058,4188,4190,4190,4320,4322,4452,4452,4456,4456,4586,4588,4588,4590,4722,4722,4724,4726,4728,4730,4730,4862,4862,4736,4738,4740,4614,4616,4616,4618,4620,4622,4624,4498,4500,4500,4502,4376,4378,4380,4380,4254,4256,4130,4130,4132,4006,4008,3880,3882,3756,3758,3758,3632,3506,3508,3508,3382,3382,3256,3256,3130,3004,3004,2878,2878,2752,2752,2754,2628,2500,2500,2374,2374,2248,2248,2122,2122,1996,1868,1868,1870,1742,1744,1616,1616,1490,1490,1362,1362,1364,1236,1236,1110,1110,1110,984,984,856,856,858,730,730,602,602,602,476,476,476,348,350,350,222,222,222,222,96,96,96,224,224,224,226,352,354,354,482,482,482,482,482,612,612,612,612,612,740,740,740,742,868,870,870
  dc.w    796,796,796,796,668,668,668,668,668,542,542,542,542,414,414,414,414,416,288,288,288,288,160,160,162,34,34,34,34,162,164,164,292,292,292,292,422,422,550,550,550,680,680,680,808,810,810,938,938,1068,1068,1196,1196,1198,1326,1326,1456,1456,1456,1586,1586,1716,1716,1844,1844,1974,1974,2104,2104,2234,2234,2364,2364,2494,2494,2622,2624,2754,2754,2884,2884,3014,3014,3144,3274,3274,3276,3404,3406,3536,3536,3666,3668,3796,3800,3928,3930,3930,4060,4062,4192,4194,4194,4324,4326,4326,4456,4458,4460,4462,4464,4594,4594,4596,4598,4600,4602,4604,4606,4734,4608,4610,4484,4486,4486,4488,4490,4492,4494,4496,4370,4370,4372,4374,4376,4378,4250,4252,4126,4128,4002,4002,4004,3878,3880,3880,3754,3756,3628,3630,3504,3504,3378,3380,3380,3254,3256,3128,3002,3002,2876,2878,2750,2750,2624,2626,2498,2500,2372,2372,2246,2246,2120,2122,1994,1994,1866,1868,1740,1742,1614,1614,1488,1488,1488,1362,1362,1234,1236,1236,1108,1110,982,982,854,856,856,728,728,730,602,602,602,474,474,476,348,348,348,220,222,222,94,94,94,96,224,224,224,352,352,352,352,482,482,482,482,482,610,610,612,612,740,740,740,740,868,868,868,868
  dc.w    796,796,796,796,796,668,670,670,670,542,542,542,542,542,416,416,416,416,288,288,288,288,160,162,162,162,34,34,36,164,164,164,164,292,294,294,422,422,422,552,552,552,680,682,810,810,810,938,940,940,1068,1070,1198,1198,1198,1328,1328,1458,1458,1586,1588,1588,1716,1716,1846,1846,1976,1976,2106,2106,2236,2236,2366,2366,2494,2496,2624,2754,2756,2756,2886,2886,3016,3016,3146,3146,3276,3278,3406,3408,3538,3538,3540,3670,3800,3800,3802,3932,3932,3934,4064,4066,4068,4196,4198,4200,4330,4332,4332,4334,4464,4466,4468,4468,4470,4470,4474,4476,4478,4352,4352,4354,4356,4358,4358,4360,4362,4364,4366,4368,4370,4242,4244,4246,4248,4120,4122,4124,3998,4000,4000,3874,3876,3876,3750,3752,3626,3626,3500,3502,3502,3376,3378,3380,3252,3126,3126,3000,3000,2874,2876,2748,2750,2622,2624,2496,2498,2370,2372,2244,2244,2118,2120,1992,1992,1866,1866,1738,1740,1612,1614,1614,1486,1488,1360,1360,1234,1234,1234,1106,1108,980,980,982,854,854,856,726,728,600,600,602,474,474,474,348,348,348,220,220,220,220,94,94,94,222,222,224,224,352,352,352,352,480,480,482,482,610,610,610,610,610,738,740,740,740,868,868,868,868
  dc.w    796,796,798,798,798,670,670,670,670,542,542,544,544,544,416,416,416,416,416,288,290,290,290,162,162,162,36,36,36,36,164,164,166,294,294,294,294,424,424,552,552,552,682,682,682,810,812,812,940,940,1070,1070,1070,1200,1200,1328,1328,1330,1458,1460,1588,1588,1590,1718,1848,1848,1848,1978,1978,2108,2108,2238,2238,2366,2368,2496,2498,2626,2628,2756,2758,2888,2888,3018,3018,3148,3148,3278,3280,3410,3410,3412,3542,3542,3672,3672,3802,3804,3806,3806,3936,3938,4068,4068,4070,4072,4202,4204,4206,4206,4336,4336,4340,4340,4342,4344,4474,4476,4478,4352,4352,4354,4356,4358,4358,4232,4234,4236,4238,4240,4240,4114,4116,4118,4118,3992,3994,3996,3998,3870,3872,3746,3748,3748,3622,3624,3624,3498,3500,3372,3374,3376,3248,3250,3124,3124,2998,2998,2872,2874,2746,2748,2620,2622,2494,2496,2368,2370,2242,2244,2116,2118,1990,1992,1864,1864,1866,1738,1610,1612,1612,1486,1486,1358,1360,1360,1232,1232,1106,1106,1106,980,980,852,852,854,726,726,728,600,600,600,472,472,346,346,346,346,218,220,220,92,92,92,94,222,222,222,350,350,350,352,480,480,480,480,480,608,610,610,610,738,738,738,738,738,866,868,868,868
  dc.w    798,798,798,798,798,798,670,670,672,672,544,544,544,544,544,416,416,418,418,290,290,290,290,162,164,164,164,36,36,36,166,166,166,166,294,294,296,424,424,424,554,554,554,682,684,684,812,812,942,942,942,1070,1072,1200,1200,1202,1330,1332,1460,1460,1460,1590,1590,1718,1720,1848,1850,1850,1980,2108,2108,2110,2238,2240,2368,2370,2498,2500,2628,2630,2758,2760,2890,2890,3020,3020,3022,3150,3152,3282,3282,3412,3414,3544,3544,3546,3676,3676,3678,3808,3810,3810,3940,3942,3942,4072,4074,4076,4076,4078,4208,4210,4212,4212,4214,4216,4346,4348,4350,4224,4224,4226,4228,4230,4230,4104,4106,4108,4110,4110,4112,3986,3988,3990,3990,3992,3866,3868,3868,3870,3744,3744,3618,3620,3622,3494,3496,3370,3372,3372,3374,3246,3120,3122,2994,2996,2998,2870,2872,2744,2746,2618,2620,2492,2494,2366,2368,2240,2242,2114,2116,1988,1990,1862,1864,1864,1736,1738,1610,1610,1484,1484,1486,1358,1358,1232,1232,1232,1104,1106,978,978,980,852,852,724,726,726,598,598,600,472,472,472,344,346,346,218,218,220,220,92,92,92,220,220,222,222,350,350,350,350,478,480,480,480,608,608,608,608,608,738,738,738,738,866,866,866,866,866
  dc.w    926,798,798,798,798,798,672,672,672,672,544,544,544,544,546,418,418,418,418,418,290,290,292,164,164,164,164,36,38,38,38,166,166,166,296,296,296,424,424,426,554,554,556,684,684,684,812,814,814,942,944,944,1072,1072,1202,1202,1202,1332,1332,1460,1462,1462,1592,1592,1720,1722,1850,1852,1980,1980,1982,2110,2112,2240,2242,2370,2372,2500,2500,2630,2632,2760,2762,2762,2892,2894,3022,3024,3152,3154,3282,3286,3286,3416,3416,3546,3548,3548,3550,3680,3682,3810,3812,3814,3814,3944,3946,3948,3948,4078,4080,4082,4084,4084,4086,4088,4090,4220,4222,4222,4096,4098,4100,4102,3974,3976,3978,3980,3982,3982,3984,3986,3860,3862,3862,3864,3738,3738,3740,3742,3616,3616,3618,3492,3492,3494,3368,3368,3242,3244,3244,3118,3120,2992,2994,2868,2868,2742,2742,2744,2616,2618,2490,2492,2366,2366,2238,2240,2112,2114,1986,1988,1860,1862,1862,1734,1736,1608,1610,1482,1482,1484,1356,1356,1230,1230,1230,1104,1104,1104,978,978,850,852,852,724,724,596,598,598,598,470,470,472,344,344,344,218,218,218,90,90,92,92,220,220,220,220,350,350,350,478,478,478,478,478,608,608,608,608,608,736,736,738,738,866,866,866,866,866
  dc.w    926,798,798,800,800,800,672,672,672,672,672,544,546,546,546,418,418,418,418,420,292,292,292,292,164,164,166,166,38,38,38,166,168,168,168,296,296,298,426,426,426,556,556,556,684,686,814,814,814,816,944,944,1072,1074,1074,1204,1204,1332,1332,1334,1462,1464,1592,1592,1594,1722,1722,1852,1852,1982,1982,2112,2112,2242,2242,2244,2372,2372,2502,2504,2504,2634,2634,2764,2764,2894,2894,3024,3026,3026,3156,3158,3288,3288,3418,3418,3420,3550,3550,3552,3554,3682,3684,3814,3816,3818,3818,3820,3950,3950,3954,3954,3956,4086,4086,4088,4090,4092,4094,4094,3968,3970,3972,3974,3974,3976,3978,3852,3854,3854,3856,3858,3860,3732,3734,3736,3736,3610,3612,3614,3486,3488,3490,3364,3364,3366,3240,3368,3242,3116,3116,3118,2992,2992,2866,2866,2740,2740,2614,2616,2488,2490,2490,2364,2364,2238,2238,2240,2112,2114,1986,1988,1860,1860,1734,1734,1606,1608,1608,1482,1482,1354,1356,1356,1228,1230,1102,1102,1104,976,976,848,850,850,722,724,724,596,596,596,470,470,470,344,344,344,216,216,218,218,90,90,90,218,220,220,220,348,348,348,350,478,478,478,478,478,606,606,608,608,736,736,736,736,736,864,866,864,866,866
  dc.w    926,928,800,800,800,800,800,672,672,674,674,546,546,546,546,546,418,420,420,420,292,292,292,292,166,166,166,166,38,40,40,40,168,168,168,298,298,298,298,428,428,556,556,556,558,686,686,816,816,816,944,946,946,1074,1076,1076,1204,1204,1334,1334,1334,1464,1464,1594,1594,1594,1724,1724,1854,1854,1984,1984,2114,2114,2114,2244,2244,2374,2374,2376,2504,2506,2636,2764,2766,2766,2896,2898,2898,3026,3028,3030,3160,3160,3290,3290,3292,3422,3424,3554,3554,3554,3556,3686,3688,3690,3690,3820,3822,3824,3826,3826,3828,3958,3960,3960,3962,3962,3966,3966,3840,3842,3844,3846,3846,3848,3850,3724,3724,3726,3728,3730,3730,3732,3606,3608,3608,3482,3484,3484,3486,3360,3362,3362,3236,3238,3238,3240,3112,2986,2988,2990,2862,2864,2864,2738,2740,2612,2614,2486,2488,2360,2362,2362,2236,2236,2110,2110,1984,1984,1986,1858,1860,1732,1732,1606,1606,1606,1480,1480,1352,1354,1354,1228,1228,1228,1102,1102,974,976,976,848,848,722,722,722,594,596,596,596,468,470,342,342,342,342,216,216,216,88,88,90,90,218,218,218,220,348,348,348,476,476,476,478,478,606,606,606,606,606,736,736,736,736,864,864,864,864,864,994
  dc.w    928,928,800,800,800,800,800,674,674,674,674,674,546,546,546,548,420,420,420,420,420,292,294,294,294,166,166,168,168,40,40,40,168,170,170,170,298,300,300,428,428,428,558,558,558,686,688,688,816,816,818,946,946,948,1076,1076,1206,1206,1206,1336,1336,1464,1466,1466,1594,1596,1596,1726,1726,1854,1856,1856,1986,2116,2116,2116,2246,2246,2376,2376,2378,2506,2508,2636,2638,2768,2768,2898,2898,2900,3030,3032,3032,3162,3162,3292,3294,3294,3296,3426,3426,3428,3558,3558,3560,3562,3692,3694,3694,3696,3698,3698,3828,3830,3832,3834,3834,3836,3838,3838,3712,3714,3716,3718,3718,3720,3722,3722,3724,3598,3600,3602,3602,3604,3478,3478,3480,3482,3356,3356,3358,3360,3232,3234,3236,3108,3110,3112,2984,2986,2988,2860,2862,2734,2736,2738,2610,2612,2484,2486,2358,2360,2360,2234,2234,2108,2108,2110,1982,1984,1856,1858,1858,1730,1604,1604,1606,1478,1478,1480,1352,1354,1226,1226,1226,1100,1100,972,974,974,846,848,848,720,722,722,594,594,594,468,468,468,340,342,342,214,214,216,216,88,88,88,216,218,218,218,346,346,348,348,476,476,476,476,478,604,606,606,606,734,734,734,734,734,864,864,864,864,864,992
  dc.w    928,928,800,800,800,802,802,802,674,674,674,674,546,548,548,548,548,420,420,422,422,294,294,294,294,168,168,168,168,40,40,40,42,170,170,170,300,300,300,300,430,430,430,558,560,560,688,688,690,818,818,818,948,948,1076,1078,1078,1206,1208,1208,1336,1338,1466,1466,1468,1596,1598,1598,1726,1728,1856,1858,1986,1988,1988,2118,2118,2248,2248,2250,2378,2380,2508,2510,2638,2640,2640,2770,2772,2900,2902,2904,3032,3034,3034,3164,3166,3166,3296,3298,3298,3428,3430,3432,3432,3434,3564,3566,3566,3568,3570,3570,3700,3702,3704,3706,3706,3708,3710,3710,3584,3586,3588,3590,3590,3592,3594,3594,3596,3470,3472,3474,3474,3476,3478,3350,3352,3354,3354,3356,3230,3232,3232,3106,3106,3108,2982,2982,2984,2858,2858,2860,2732,2734,2608,2608,2610,2484,2484,2358,2358,2230,2232,2234,2106,2108,1980,1982,1982,1854,1856,1728,1730,1602,1602,1604,1476,1478,1478,1350,1352,1224,1224,1226,1098,1100,1100,972,972,846,846,846,720,720,720,594,594,594,466,466,468,340,340,340,342,214,214,214,86,88,88,88,216,216,216,218,346,346,346,474,474,476,476,476,604,604,604,606,606,734,734,734,734,862,862,862,864,864,992,992
  dc.w    928,928,930,802,802,802,802,802,674,674,676,676,548,548,548,548,548,422,422,422,422,422,294,296,296,296,168,168,168,168,42,42,42,170,170,172,172,300,300,302,430,430,430,560,560,560,560,690,690,690,820,820,948,948,950,1078,1078,1080,1208,1208,1210,1338,1338,1468,1468,1598,1598,1600,1600,1728,1730,1858,1860,1860,1988,1990,2120,2120,2248,2250,2250,2380,2380,2510,2512,2512,2642,2642,2772,2772,2774,2904,2904,2906,3036,3036,3038,3038,3168,3170,3300,3300,3302,3304,3434,3434,3436,3438,3438,3440,3570,3570,3572,3574,3576,3578,3578,3580,3582,3582,3456,3458,3460,3462,3462,3464,3466,3466,3468,3470,3472,3344,3346,3348,3350,3350,3352,3226,3226,3228,3230,3102,3104,2978,2978,2980,2980,2854,2856,2856,2730,2732,2604,2606,2608,2480,2480,2482,2356,2356,2230,2230,2232,2104,2106,1978,1980,1980,1854,1854,1726,1728,1600,1602,1602,1474,1476,1476,1350,1350,1222,1224,1224,1096,1098,1098,970,972,972,844,846,718,718,720,592,592,592,594,466,466,338,340,340,340,212,212,212,214,86,86,86,216,216,216,216,344,344,346,346,474,474,474,474,476,604,604,604,604,732,732,734,734,734,862,862,862,862,862,992,992
  dc.w    930,930,930,802,802,802,802,804,804,676,676,676,676,548,550,550,550,550,422,422,422,422,424,296,296,296,296,168,170,170,42,42,42,44,172,172,172,174,302,302,302,430,432,432,560,560,562,690,690,692,820,820,820,950,950,950,1080,1080,1080,1210,1210,1338,1340,1340,1470,1470,1470,1600,1600,1600,1730,1730,1860,1860,1862,1990,1992,2120,2122,2250,2252,2254,2382,2382,2384,2512,2514,2514,2644,2646,2776,2776,2778,2906,2908,2908,3038,3040,3042,3042,3172,3172,3174,3304,3306,3308,3308,3310,3440,3440,3442,3442,3444,3446,3448,3450,3450,3452,3582,3456,3456,3458,3460,3462,3334,3336,3336,3338,3340,3342,3344,3344,3346,3220,3220,3222,3224,3224,3098,3100,3100,2974,2976,2976,2978,2852,2852,2854,2726,2728,2730,2602,2604,2604,2478,2480,2352,2354,2354,2228,2228,2230,2102,2104,1976,1978,1850,1852,1852,1726,1726,1598,1600,1600,1474,1474,1474,1348,1348,1350,1222,1222,1224,1096,1096,970,970,970,844,844,844,716,718,718,592,592,592,464,464,466,338,338,338,212,212,212,212,86,86,86,86,214,214,216,344,344,344,344,344,474,474,474,474,602,604,604,604,604,732,732,732,732,860,862,862,862,862,862,990,990
  dc.w    930,930,930,930,802,804,804,804,804,676,676,676,676,550,550,550,550,550,422,422,424,424,424,296,296,296,298,170,170,170,170,44,44,44,44,174,174,174,302,302,304,304,432,432,432,562,562,562,692,692,692,822,822,822,952,952,1080,1080,1082,1210,1210,1212,1340,1342,1342,1470,1472,1472,1602,1602,1602,1732,1732,1862,1862,1992,1992,1994,2122,2122,2252,2254,2254,2256,2384,2386,2386,2516,2518,2646,2648,2650,2778,2778,2780,2910,2910,2912,2914,3042,3044,3044,3046,3176,3178,3180,3180,3310,3312,3312,3314,3314,3316,3318,3448,3450,3450,3452,3454,3328,3328,3330,3332,3332,3334,3336,3336,3210,3212,3214,3214,3216,3218,3220,3092,3094,3096,3096,2970,2972,2972,2974,2846,2848,2850,2850,2724,2726,2726,2600,2600,2602,2476,2476,2478,2350,2352,2224,2226,2228,2100,2102,2102,1974,1976,1848,1850,1850,1724,1724,1598,1598,1600,1472,1472,1474,1346,1348,1348,1220,1222,1222,1094,1096,968,968,970,842,842,844,716,716,716,590,590,590,462,464,464,336,338,338,338,210,212,212,212,84,84,86,214,214,214,214,344,344,344,344,472,472,474,474,474,602,602,602,604,604,732,732,732,732,860,860,862,862,862,990,990,990
  dc.w    930,930,930,932,804,804,804,804,804,804,678,678,678,678,550,550,550,552,552,424,424,424,424,424,298,298,298,298,170,172,172,44,44,44,44,174,174,174,174,304,304,304,432,434,434,562,564,564,564,692,694,694,822,824,824,952,954,954,1082,1082,1212,1212,1214,1342,1342,1344,1472,1472,1474,1602,1604,1604,1734,1734,1862,1864,1866,1994,1994,2124,2124,2126,2254,2256,2258,2386,2386,2388,2518,2520,2520,2650,2650,2780,2780,2782,2784,2784,2914,2916,2916,3046,3048,3048,3050,3052,3182,3182,3184,3186,3186,3186,3318,3318,3320,3322,3322,3324,3326,3200,3200,3202,3204,3204,3206,3208,3208,3210,3212,3212,3086,3088,3090,3090,3092,2966,2966,2968,2970,2970,2844,2846,2846,2720,2722,2722,2724,2596,2598,2600,2472,2474,2474,2348,2348,2350,2224,2224,2226,2098,2100,2100,1974,1974,1848,1848,1850,1722,1722,1596,1596,1598,1470,1472,1472,1346,1346,1346,1218,1220,1220,1094,1094,1094,968,968,840,842,842,714,716,716,588,588,590,590,462,462,464,336,336,336,210,210,210,210,84,84,84,84,212,212,214,342,342,342,344,472,472,472,472,472,602,602,602,602,602,730,730,730,732,860,860,860,860,860,862,988,990,990
  dc.w    932,932,932,932,932,804,804,804,804,806,678,678,678,678,550,552,552,552,552,424,424,424,426,426,298,298,298,300,172,172,172,172,44,46,46,46,174,176,176,304,304,306,306,434,434,436,564,564,564,566,694,694,694,824,824,824,954,954,1084,1084,1084,1214,1214,1214,1344,1344,1344,1474,1474,1476,1604,1604,1606,1734,1736,1864,1866,1866,1996,1996,1998,2126,2128,2256,2258,2258,2260,2388,2390,2392,2520,2522,2522,2652,2654,2656,2784,2786,2786,2788,2918,2918,2920,2920,2922,3052,3054,3054,3056,3058,3058,3188,3190,3190,3192,3194,3194,3196,3198,3072,3072,3074,3076,3076,3078,3080,3080,3082,3084,3084,2958,2960,2960,2962,2964,2964,2838,2840,2842,2842,2844,2718,2718,2720,2720,2594,2596,2596,2470,2470,2472,2344,2346,2348,2220,2222,2222,2224,2096,2098,2100,1972,1974,1846,1846,1848,1720,1722,1594,1596,1596,1598,1470,1470,1344,1344,1344,1218,1218,1220,1092,1092,1094,966,966,840,840,840,714,714,714,586,588,588,588,462,462,462,336,336,336,208,208,208,210,82,82,82,84,212,212,212,212,342,342,342,342,470,472,472,472,472,600,600,600,602,602,730,730,730,730,860,860,860,860,860,988,988,988,988
  dc.w    932,932,932,932,932,804,804,806,806,806,806,678,678,680,680,552,552,552,552,552,426,426,426,426,426,300,300,300,300,172,172,174,174,46,46,48,176,176,176,176,306,306,306,306,436,436,436,564,566,566,566,694,696,824,826,826,954,956,956,1084,1086,1086,1214,1216,1216,1344,1346,1346,1474,1476,1478,1606,1606,1608,1736,1738,1866,1868,1868,1868,1998,2000,2128,2128,2130,2260,2260,2262,2392,2392,2392,2394,2522,2524,2526,2656,2656,2658,2658,2788,2790,2790,2792,2922,2922,2924,2926,2926,2928,3058,3058,3060,3062,3062,3064,3066,3066,3068,3070,2944,2944,2946,2948,2948,2950,2952,2952,2954,2956,2956,2958,2960,2832,2834,2836,2836,2838,2840,2712,2714,2716,2716,2590,2592,2592,2594,2466,2468,2470,2342,2344,2344,2218,2218,2220,2220,2094,2094,2096,1970,1970,1844,1844,1844,1846,1720,1720,1592,1594,1594,1468,1468,1470,1342,1342,1344,1216,1218,1218,1090,1092,1092,964,966,966,838,840,840,712,712,586,586,586,588,460,460,462,334,334,334,334,208,208,208,210,82,82,82,210,212,212,212,340,340,340,342,470,470,470,470,470,600,600,600,600,600,730,728,730,730,858,858,858,858,860,860,988,988,988,988
  dc.w    932,932,932,932,934,934,806,806,806,806,806,680,680,680,680,552,552,552,554,554,426,426,426,426,428,300,300,300,300,174,174,174,174,46,48,48,48,176,178,178,178,306,308,308,308,436,436,438,566,566,568,696,696,698,826,826,826,956,956,956,1086,1086,1088,1216,1216,1218,1346,1346,1348,1476,1478,1478,1608,1608,1608,1738,1738,1740,1868,1870,1872,2000,2000,2002,2132,2132,2132,2262,2264,2264,2394,2394,2396,2396,2526,2528,2528,2530,2660,2660,2662,2662,2792,2794,2794,2796,2798,2928,2928,2930,2930,2932,2934,2934,2936,2938,3066,3068,3070,3070,2944,2946,2948,2948,2950,2824,2824,2954,2828,2828,2830,2832,2832,2834,2708,2708,2710,2710,2712,2586,2588,2588,2590,2462,2464,2466,2466,2468,2340,2342,2344,2216,2216,2218,2092,2092,2094,1966,1968,1968,1842,1842,1844,1716,1718,1718,1592,1592,1594,1466,1466,1468,1340,1342,1342,1214,1216,1216,1090,1090,1090,964,964,964,838,838,838,712,712,712,584,586,586,458,460,460,332,332,334,334,206,206,208,208,80,80,80,82,210,210,210,212,340,340,340,340,468,470,470,470,470,598,600,600,600,600,728,728,728,730,858,858,858,858,858,986,988,988,988,988
  dc.w    932,932,934,934,934,934,806,806,806,808,808,808,680,680,680,680,554,554,554,554,554,426,428,428,428,428,300,302,302,302,174,174,176,176,48,48,48,50,178,178,178,308,308,308,308,438,438,438,566,568,568,568,698,698,698,826,828,828,958,958,958,1088,1088,1088,1218,1218,1218,1348,1348,1350,1478,1478,1480,1608,1610,1610,1612,1740,1742,1870,1872,1872,2002,2002,2004,2004,2134,2136,2264,2264,2266,2266,2396,2398,2400,2400,2530,2530,2532,2532,2662,2664,2664,2666,2666,2796,2798,2800,2800,2802,2804,2804,2934,2936,2936,2936,2938,2940,2942,2942,2816,2818,2820,2820,2822,2824,2824,2826,2700,2700,2702,2704,2704,2706,2706,2708,2582,2582,2584,2586,2586,2460,2462,2462,2464,2336,2338,2340,2340,2214,2214,2216,2216,2090,2090,2092,1966,1966,1838,1840,1842,1842,1716,1716,1588,1590,1590,1592,1464,1466,1466,1338,1340,1340,1214,1214,1216,1088,1088,1088,962,962,964,836,836,838,710,710,712,584,584,584,586,458,458,460,332,332,332,334,206,206,206,80,80,80,80,208,210,210,210,338,338,340,340,468,468,468,468,470,598,598,598,598,600,728,728,728,728,856,856,858,858,858,858,986,986,986,988,988
  dc.w    934,934,934,934,934,934,934,808,808,808,808,808,680,680,682,682,554,554,554,554,556,556,428,428,428,428,302,302,302,302,302,176,176,176,176,50,50,50,178,178,180,180,308,308,310,310,438,440,440,568,568,570,570,698,698,700,828,830,830,958,958,960,1088,1090,1090,1218,1220,1220,1350,1350,1350,1480,1480,1482,1482,1612,1612,1614,1742,1742,1744,1874,1874,1876,2004,2004,2006,2136,2136,2136,2266,2268,2268,2270,2270,2400,2402,2402,2404,2532,2534,2536,2538,2538,2668,2668,2670,2670,2672,2674,2804,2804,2806,2808,2808,2810,2810,2812,2814,2814,2688,2690,2692,2692,2694,2696,2696,2698,2698,2700,2702,2574,2576,2578,2578,2580,2580,2582,2456,2456,2458,2460,2332,2334,2336,2336,2210,2210,2212,2212,2214,2088,2088,2090,1962,1964,1964,1838,1838,1840,1712,1714,1714,1588,1588,1590,1462,1464,1464,1464,1338,1338,1340,1212,1212,1214,1086,1088,1088,960,962,962,834,836,836,708,710,710,582,582,584,584,456,458,458,330,330,332,332,204,204,206,78,78,78,80,208,208,208,210,338,338,338,338,340,468,468,468,468,596,598,598,598,598,598,726,728,728,728,856,856,856,858,856,986,986,986,986,986,986
  dc.w    1062,934,934,934,934,936,936,808,808,808,808,808,808,682,682,682,682,554,556,556,556,556,428,428,430,430,430,302,302,304,304,176,176,176,178,50,50,50,52,180,180,180,180,310,310,310,312,440,440,440,570,570,570,570,700,700,830,830,830,830,960,960,962,1090,1090,1092,1220,1222,1222,1222,1352,1352,1352,1482,1482,1484,1614,1614,1614,1744,1744,1746,1874,1876,1876,1878,2008,2008,2008,2138,2138,2140,2270,2270,2272,2272,2274,2404,2404,2406,2406,2408,2536,2538,2540,2540,2542,2672,2672,2674,2676,2676,2678,2680,2680,2682,2684,2684,2686,2560,2560,2562,2562,2564,2566,2568,2568,2570,2570,2572,2574,2574,2576,2450,2450,2452,2452,2454,2456,2328,2330,2332,2332,2334,2206,2208,2210,2210,2212,2084,2086,2086,1960,1960,1962,1834,1836,1836,1838,1710,1712,1712,1586,1588,1588,1460,1462,1462,1334,1336,1336,1210,1210,1212,1212,1084,1086,1086,958,960,960,834,834,834,708,708,708,582,582,582,582,456,456,458,330,330,330,330,204,204,204,204,78,78,78,78,206,208,208,208,336,338,338,338,466,466,468,468,468,596,596,598,598,598,726,726,726,726,854,856,856,856,856,856,984,984,986,986,986,986
  dc.w    1062,934,934,936,936,936,936,936,808,808,810,810,810,682,682,682,684,684,556,556,556,556,556,430,430,430,430,430,304,304,304,304,176,178,178,178,50,52,52,52,180,182,182,182,310,312,312,312,442,442,442,570,572,572,572,702,702,702,832,832,832,960,962,962,1092,1092,1092,1222,1222,1224,1224,1352,1354,1354,1484,1484,1486,1614,1614,1616,1618,1746,1748,1748,1878,1878,1880,1880,2008,2010,2012,2140,2142,2142,2144,2274,2274,2276,2276,2278,2408,2408,2408,2410,2412,2542,2542,2544,2546,2546,2548,2550,2550,2550,2680,2682,2684,2684,2686,2560,2560,2562,2562,2564,2566,2566,2568,2442,2442,2444,2446,2446,2448,2448,2450,2452,2324,2326,2328,2328,2330,2202,2204,2204,2206,2208,2080,2082,2082,2084,1958,1958,1960,1832,1834,1834,1836,1708,1710,1710,1584,1584,1586,1586,1460,1460,1460,1334,1334,1336,1208,1210,1210,1210,1084,1084,1086,958,958,958,832,832,834,706,706,708,580,580,582,582,454,454,456,328,328,330,330,202,202,204,204,76,76,78,78,206,206,208,208,336,336,336,336,466,466,466,466,466,596,596,596,596,596,724,726,726,726,726,854,854,856,856,856,984,984,984,984,986,986,986
  dc.w    1064,1064,936,936,936,936,936,936,810,810,810,810,810,810,682,684,684,684,556,556,556,558,558,430,430,430,432,432,304,304,304,306,306,178,178,178,180,52,52,52,54,182,182,182,182,312,312,314,314,442,442,444,572,572,574,574,702,702,704,832,832,834,962,964,964,1092,1094,1094,1094,1224,1224,1226,1354,1356,1356,1486,1486,1486,1488,1618,1618,1618,1620,1748,1750,1880,1880,1880,1882,1882,2012,2014,2014,2144,2144,2146,2146,2276,2278,2278,2278,2280,2282,2412,2412,2414,2414,2416,2418,2418,2548,2548,2550,2552,2552,2554,2556,2556,2558,2432,2432,2434,2434,2436,2438,2438,2440,2442,2442,2444,2446,2318,2320,2320,2322,2324,2324,2326,2198,2200,2202,2202,2204,2204,2078,2080,2080,2082,1954,1956,1956,1830,1830,1832,1832,1706,1706,1708,1580,1582,1582,1584,1456,1458,1458,1460,1332,1334,1334,1206,1208,1208,1082,1082,1082,1084,956,958,958,830,830,832,704,706,706,578,580,580,580,454,454,454,456,328,328,328,200,202,202,202,76,76,76,76,204,206,206,206,334,336,336,336,464,464,466,466,466,594,594,596,596,596,596,724,724,726,726,854,854,854,854,854,856,984,984,984,984,984,984,1114
  dc.w    1064,1064,936,936,936,936,938,938,938,810,810,810,810,810,684,684,684,684,684,558,558,558,558,558,430,432,432,432,432,304,306,306,306,178,180,180,180,52,52,54,54,54,182,184,184,184,314,314,314,442,444,444,444,574,574,574,574,704,704,704,834,834,834,964,964,966,1094,1094,1096,1096,1226,1226,1228,1356,1356,1358,1358,1488,1488,1490,1618,1620,1620,1622,1750,1752,1752,1882,1882,1884,1884,1886,2014,2016,2016,2018,2146,2148,2148,2150,2280,2282,2282,2284,2284,2286,2286,2288,2418,2418,2420,2420,2422,2424,2424,2426,2428,2428,2430,2304,2304,2306,2306,2308,2310,2310,2312,2312,2314,2316,2318,2318,2320,2320,2194,2196,2196,2198,2198,2200,2202,2074,2074,2076,2078,1950,1952,1952,1954,1826,1828,1830,1830,1832,1704,1706,1706,1580,1580,1582,1582,1454,1456,1458,1330,1332,1332,1332,1206,1206,1208,1080,1080,1082,1082,956,956,956,830,830,830,704,704,704,578,578,578,580,452,452,454,454,326,326,328,200,200,200,202,74,74,74,76,76,204,204,206,206,334,334,334,336,464,464,464,464,466,594,594,594,596,594,724,724,724,724,726,852,854,854,854,854,982,984,982,984,984,984,984,1112
  dc.w    1064,1064,1064,936,936,938,938,938,938,810,810,812,812,812,812,684,684,686,686,686,558,558,558,560,560,432,432,432,434,434,306,306,306,308,180,180,180,182,54,54,54,54,184,184,184,186,314,314,314,316,444,444,444,446,574,574,576,576,704,706,834,834,836,836,966,966,966,1096,1096,1096,1098,1226,1228,1228,1228,1358,1358,1360,1488,1490,1490,1492,1620,1622,1622,1624,1752,1754,1754,1884,1886,1886,1886,1888,2018,2018,2020,2020,2150,2150,2152,2154,2154,2284,2284,2286,2286,2288,2290,2290,2292,2294,2294,2296,2426,2426,2428,2428,2430,2304,2304,2306,2306,2308,2310,2310,2312,2184,2186,2188,2188,2190,2192,2192,2194,2194,2196,2068,2070,2072,2072,2074,1946,1948,1950,1950,1952,1824,1826,1826,1828,1828,1702,1702,1704,1576,1578,1578,1580,1452,1454,1454,1456,1328,1330,1330,1202,1204,1204,1206,1078,1080,1080,952,954,954,956,828,828,830,702,702,704,704,576,578,578,450,452,452,452,324,326,326,326,200,200,200,200,74,74,74,74,204,204,204,204,334,334,334,334,462,464,464,464,464,592,594,594,594,594,722,722,724,724,724,852,852,852,854,854,854,982,982,982,982,984,984,1112,1112
  dc.w    1064,1064,1064,938,938,938,938,938,938,940,812,812,812,812,812,814,686,686,686,686,558,558,560,560,560,560,432,434,434,434,434,308,308,308,308,180,182,182,182,54,56,56,56,184,186,186,186,314,316,316,316,446,446,446,446,576,576,576,578,706,708,708,836,838,838,966,968,968,968,1098,1098,1100,1228,1228,1230,1230,1360,1360,1362,1362,1492,1492,1492,1494,1624,1624,1626,1626,1754,1756,1758,1758,1886,1888,1890,1890,2020,2020,2022,2024,2024,2154,2154,2156,2156,2158,2160,2288,2290,2290,2292,2294,2294,2296,2298,2298,2300,2300,2302,2176,2176,2178,2178,2180,2182,2182,2184,2184,2186,2188,2188,2190,2190,2064,2066,2066,2068,2068,2070,1944,1944,1946,1946,1948,1820,1822,1824,1824,1826,1698,1700,1700,1702,1574,1576,1576,1578,1450,1452,1452,1454,1326,1326,1328,1328,1202,1202,1204,1204,1076,1078,1078,952,952,952,954,826,828,828,700,702,702,574,576,576,576,578,450,450,452,324,324,324,326,198,198,200,200,72,72,74,74,202,202,204,204,332,332,332,334,334,462,462,462,464,464,592,592,592,594,594,722,722,722,724,724,852,852,852,852,852,982,982,982,982,982,982,1110,1112,1112
  dc.w    1064,1066,1066,1066,938,938,938,940,940,940,940,812,812,812,814,814,686,686,686,686,688,560,560,560,560,562,434,434,434,434,436,308,308,308,308,182,182,182,182,184,56,56,56,58,186,186,186,188,316,316,318,318,446,446,448,576,576,578,578,578,708,708,710,838,838,840,840,968,970,970,1098,1100,1100,1102,1230,1232,1232,1362,1362,1362,1364,1492,1494,1496,1496,1624,1626,1626,1628,1628,1758,1758,1760,1760,1890,1892,1892,1894,1894,1894,2024,2026,2026,2028,2030,2158,2160,2160,2162,2162,2164,2166,2166,2168,2170,2170,2300,2300,2302,2176,2176,2178,2178,2180,2182,2054,2056,2056,2186,2060,2060,2062,2062,2064,2066,2066,1940,1940,1942,1942,1944,1816,1818,1820,1820,1822,1822,1696,1696,1698,1698,1572,1572,1574,1574,1576,1448,1450,1450,1452,1324,1326,1326,1200,1200,1200,1202,1074,1076,1076,1078,950,950,952,824,826,826,826,700,700,700,574,574,574,576,448,448,450,450,322,322,324,324,196,198,198,198,70,72,72,72,200,202,202,202,204,332,332,332,332,460,462,462,462,462,592,592,592,592,592,722,722,722,722,722,850,850,852,852,852,980,980,982,982,982,982,982,1110,1110,1110
  dc.w    1066,1066,1066,1066,1066,940,940,940,940,940,940,812,814,814,814,814,814,686,688,688,688,688,560,560,562,562,562,434,436,436,436,436,308,310,310,310,182,182,184,184,184,56,58,58,58,188,188,188,188,318,318,318,318,448,448,448,450,578,578,580,580,710,710,710,840,840,840,842,970,970,972,1100,1102,1102,1104,1232,1232,1234,1234,1364,1364,1364,1366,1496,1496,1496,1498,1628,1628,1630,1630,1632,1760,1762,1762,1764,1764,1894,1894,1896,1898,1898,1898,2028,2028,2030,2032,2034,2034,2036,2036,2166,2166,2168,2170,2170,2172,2172,2174,2048,2048,2050,2050,2052,2054,2054,2056,2056,2058,2060,1932,1934,1934,1936,1936,1938,1938,1940,1814,1814,1816,1816,1818,1818,1820,1694,1694,1696,1696,1570,1570,1572,1572,1574,1446,1448,1448,1450,1322,1324,1324,1326,1198,1198,1200,1200,1074,1074,1076,1076,948,950,950,824,824,824,826,698,698,700,572,572,574,574,574,448,448,448,322,322,322,322,196,196,196,198,70,70,70,72,200,200,200,202,202,330,330,332,332,460,460,460,462,462,590,590,590,592,592,592,720,720,722,722,850,850,850,850,852,852,980,980,980,980,982,982,1110,1110,1110,1110
  dc.w    1066,1066,1066,1068,1068,940,940,940,940,940,942,942,814,814,814,814,814,688,688,688,688,688,562,562,562,562,562,436,436,436,436,436,438,310,310,310,312,184,184,184,184,58,58,58,58,60,188,188,190,190,318,320,320,320,448,450,450,450,580,580,580,582,710,712,712,840,842,842,842,972,972,974,974,1102,1104,1104,1104,1234,1236,1236,1236,1366,1366,1368,1368,1498,1498,1500,1500,1502,1630,1632,1632,1634,1634,1764,1764,1766,1768,1896,1898,1898,1900,1900,1902,1902,1904,2034,2034,2034,2036,2038,2038,2040,2042,2042,2044,2044,2046,2046,1920,1922,1922,1924,1926,1926,1928,1928,1930,1930,1932,1934,1934,1936,1808,1810,1810,1812,1814,1814,1816,1688,1690,1690,1692,1692,1566,1568,1568,1568,1570,1442,1444,1446,1446,1446,1320,1320,1322,1322,1196,1196,1198,1198,1200,1072,1072,1074,946,948,948,948,822,822,824,824,696,698,698,570,572,572,574,446,446,446,448,320,320,322,322,194,194,196,196,68,70,70,70,70,200,200,200,200,330,330,330,330,460,460,460,460,460,462,590,590,590,590,592,720,720,720,720,720,850,850,850,850,850,978,980,980,980,980,980,980,1110,1110,1110,1110
  dc.w    1066,1068,1068,1068,1068,1068,940,940,942,942,942,942,814,814,814,816,816,816,688,688,690,690,690,562,562,562,564,564,436,436,438,438,438,310,310,310,312,312,184,186,186,186,58,58,60,60,60,190,190,190,190,320,320,320,322,450,450,452,452,580,582,582,582,712,712,712,714,842,844,844,972,974,974,976,1104,1104,1106,1106,1236,1236,1238,1238,1238,1368,1370,1370,1370,1500,1500,1502,1502,1504,1634,1634,1634,1636,1638,1638,1766,1768,1770,1770,1772,1900,1902,1904,1904,1906,1906,1908,1908,1910,1912,1912,1912,2042,2044,2044,2046,1920,1920,1922,1922,1924,1926,1926,1800,1800,1802,1802,1804,1804,1806,1808,1808,1810,1810,1812,1684,1686,1688,1688,1690,1562,1564,1564,1566,1566,1568,1440,1442,1442,1444,1444,1318,1318,1320,1320,1194,1194,1194,1196,1196,1198,1070,1072,1072,946,946,948,948,820,822,822,694,696,696,696,570,570,570,572,444,444,446,446,318,320,320,320,194,194,194,196,196,68,68,70,70,198,198,200,200,328,328,328,330,458,458,460,460,460,460,588,588,590,590,590,718,720,720,720,720,848,848,850,850,850,978,978,978,980,980,980,980,1108,1108,1108,1110,1110
  dc.w    1068,1068,1068,1068,1068,1068,942,942,942,942,942,942,942,816,816,816,816,816,816,688,690,690,690,690,564,564,564,564,564,438,438,438,438,438,312,312,312,312,312,186,186,186,188,60,60,60,62,62,190,190,192,192,320,322,322,322,452,452,452,454,582,582,584,584,712,714,714,716,844,844,846,846,974,976,976,978,1106,1108,1108,1108,1238,1240,1240,1240,1370,1370,1372,1372,1372,1502,1504,1504,1506,1506,1636,1636,1638,1638,1640,1640,1642,1770,1772,1772,1774,1774,1776,1906,1906,1908,1910,1910,1910,1912,1914,1914,1916,1918,1918,1792,1792,1794,1794,1796,1798,1798,1800,1800,1802,1802,1804,1804,1806,1808,1680,1682,1682,1684,1684,1686,1558,1560,1560,1562,1562,1564,1566,1438,1440,1440,1442,1442,1316,1316,1318,1318,1320,1192,1192,1194,1194,1068,1068,1070,1070,942,944,944,946,818,820,820,820,694,694,694,696,568,570,570,570,442,444,444,444,318,318,318,320,192,192,194,194,194,66,68,68,68,198,198,198,198,328,328,328,328,330,458,458,458,460,460,588,588,588,588,590,718,718,718,718,718,848,848,848,848,848,850,978,978,978,978,978,980,980,1108,1108,1108,1108,1110
  dc.w    1196,1068,1068,1068,1070,1070,1070,942,942,942,942,944,944,944,816,816,816,816,818,690,690,690,690,692,564,564,564,566,566,566,438,438,438,440,440,312,312,314,314,314,186,188,188,188,60,62,62,62,192,192,192,192,194,322,322,324,324,452,454,454,454,582,584,584,586,714,714,716,716,846,846,846,848,976,978,978,980,1108,1108,1110,1110,1240,1240,1242,1242,1244,1372,1372,1374,1374,1376,1504,1506,1506,1508,1508,1510,1638,1640,1640,1642,1644,1644,1646,1646,1776,1776,1778,1778,1780,1782,1782,1784,1784,1786,1914,1916,1918,1918,1792,1792,1794,1794,1796,1798,1798,1672,1672,1674,1674,1676,1676,1678,1680,1680,1682,1554,1556,1556,1558,1558,1560,1560,1562,1434,1436,1436,1438,1438,1440,1312,1314,1314,1316,1316,1190,1190,1192,1192,1066,1066,1066,1068,1068,942,942,944,944,818,818,818,820,692,692,694,566,566,568,568,570,442,442,444,444,316,318,318,318,190,192,192,192,66,66,66,68,68,196,196,198,198,326,326,328,328,328,456,456,458,458,458,586,588,588,588,588,588,718,718,718,718,846,846,848,848,848,848,976,976,978,978,978,978,978,1106,1108,1108,1108,1108,1108
  dc.w    1196,1068,1068,1070,1070,1070,1070,1070,942,942,944,944,944,944,816,816,818,818,818,818,690,692,692,692,692,564,564,566,566,566,566,440,440,440,440,440,314,314,314,314,316,188,188,188,190,62,62,64,64,192,192,194,194,194,322,324,324,326,454,454,454,456,584,584,586,586,586,716,716,718,718,848,848,848,850,978,980,980,982,1110,1112,1112,1112,1114,1242,1244,1244,1246,1374,1376,1376,1378,1378,1378,1508,1510,1510,1512,1512,1514,1642,1644,1644,1644,1646,1646,1648,1650,1650,1652,1780,1782,1784,1784,1786,1786,1788,1790,1790,1664,1664,1666,1666,1668,1668,1670,1670,1672,1674,1674,1676,1548,1550,1552,1552,1554,1554,1556,1556,1558,1558,1432,1432,1434,1434,1436,1436,1310,1310,1312,1312,1314,1314,1188,1188,1190,1190,1064,1064,1064,1066,1066,940,940,942,942,814,816,816,818,690,692,692,692,566,566,566,568,568,440,442,442,442,316,316,316,318,190,190,190,192,192,64,66,66,66,194,196,196,196,324,326,326,326,326,456,456,456,456,458,586,586,586,586,588,588,716,716,716,718,718,846,846,846,848,848,976,976,976,976,978,978,978,1106,1106,1106,1106,1108,1108,1108
  dc.w    1196,1198,1070,1070,1070,1070,1070,1070,944,944,944,944,944,944,946,818,818,818,818,818,820,692,692,692,692,692,566,566,566,566,568,440,440,440,440,442,442,314,314,316,316,188,188,190,190,190,62,64,64,64,66,194,194,194,196,324,326,326,326,326,456,456,456,586,586,586,588,588,718,718,718,720,848,848,850,852,980,980,982,982,984,1112,1112,1114,1116,1244,1244,1246,1246,1248,1248,1378,1378,1380,1380,1382,1510,1512,1512,1512,1514,1516,1516,1518,1518,1648,1650,1650,1650,1652,1654,1654,1656,1656,1658,1658,1660,1662,1662,1536,1536,1538,1538,1540,1540,1542,1542,1544,1544,1546,1548,1548,1550,1550,1552,1552,1426,1426,1428,1428,1430,1432,1432,1434,1306,1308,1308,1310,1310,1312,1184,1186,1186,1188,1188,1188,1062,1062,1064,1064,938,938,938,940,812,814,814,816,816,688,690,690,692,564,564,566,566,566,440,440,440,314,314,314,316,316,188,190,190,190,192,64,64,64,66,194,194,194,196,196,324,324,326,326,454,454,456,456,456,456,584,586,586,586,586,716,716,716,716,716,846,846,846,846,846,848,976,976,976,976,976,976,978,1106,1106,1106,1106,1106,1108,1236
  dc.w    1198,1198,1198,1070,1070,1070,1072,1072,1072,944,944,944,946,946,946,946,818,818,820,820,820,820,692,692,694,694,566,566,568,568,568,568,440,440,442,442,442,442,316,316,316,316,190,190,190,192,192,64,64,66,66,194,196,196,196,196,326,326,328,328,328,458,458,458,458,588,588,590,590,590,720,720,720,850,850,852,852,852,982,984,984,984,984,1114,1116,1116,1116,1246,1246,1248,1248,1250,1250,1380,1380,1382,1382,1384,1384,1386,1514,1516,1516,1518,1518,1520,1522,1522,1524,1524,1654,1654,1656,1656,1658,1658,1660,1662,1662,1536,1536,1538,1538,1540,1540,1542,1542,1544,1544,1546,1548,1420,1422,1422,1424,1424,1426,1426,1428,1428,1430,1302,1304,1304,1306,1306,1308,1308,1182,1182,1184,1184,1186,1058,1060,1060,1062,1062,934,936,936,938,938,812,812,814,814,686,688,688,690,690,562,564,564,564,438,438,438,440,440,314,314,314,314,188,188,188,190,62,62,64,64,64,192,194,194,194,194,324,324,324,326,454,454,454,454,456,456,584,584,584,586,586,714,714,714,716,716,844,844,846,846,846,846,974,974,976,976,976,976,976,1104,1106,1106,1106,1106,1106,1234,1234
  dc.w    1198,1198,1198,1070,1072,1072,1072,1072,1072,1072,944,946,946,946,946,946,946,820,820,820,820,820,694,694,694,694,694,568,568,568,568,568,570,442,442,442,444,444,316,316,318,318,318,190,192,192,192,192,66,66,66,66,196,196,196,198,198,326,328,328,328,330,458,458,460,460,588,590,590,592,592,720,722,722,722,852,852,854,854,856,984,984,986,986,988,1116,1116,1118,1118,1120,1250,1250,1252,1252,1252,1254,1384,1384,1384,1386,1386,1388,1390,1390,1520,1520,1522,1522,1524,1524,1526,1526,1528,1528,1530,1530,1532,1534,1534,1408,1408,1410,1410,1412,1412,1414,1414,1416,1416,1418,1420,1420,1422,1422,1424,1424,1426,1298,1300,1300,1302,1302,1304,1304,1306,1178,1180,1180,1182,1182,1184,1056,1058,1058,1060,1060,1062,934,934,936,936,810,810,810,812,812,686,686,686,688,560,562,562,562,564,436,436,438,438,312,312,312,314,314,186,186,188,188,60,62,62,62,62,192,192,194,194,194,322,322,324,324,452,452,454,454,454,454,584,584,584,584,584,586,714,714,714,714,716,844,844,844,844,846,974,974,974,974,974,976,976,1104,1104,1104,1104,1106,1106,1106,1234,1234
