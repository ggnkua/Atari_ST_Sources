  dc.w    1882,1882,1884,1884,1884,1886,2014,2014,2016,2016,2016,2018,2018,2018,2020,2020,2020,2150,2150,2152,2152,2152,2154,2154,2156,2156,2284,2286,2286,2288,2288,2290,2290,2290,2292,2420,2422,2422,2424,2424,2426,2426,2428,2556,2558,2432,2432,2434,2434,2436,2436,2566,2566,2568,2570,2570,2572,2574,2702,2704,2706,2706,2708,2710,2710,2840,2842,2842,2844,2846,2848,2848,2850,2980,2982,2982,2984,2986,2988,2990,3120,3120,3122,3124,3126,3128,3130,3132,3262,3264,3264,3266,3268,3270,3272,3274,3404,3406,3408,3410,3412,3414,3416,3418,3420,3422,3424,3428,3430,3560,3562,3564,3566,3568,3570,3572,3574,3576,3578,3580,3456,3458,3460,3462,3464,3466,3468,3470,3472,3474,3476,3478,3352,3354,3358,3360,3362,3364,3366,3368,3370,3372,3374,3376,3378,3252,3254,3256,3258,3260,3262,3262,3264,3138,3140,3142,3144,3146,3148,3150,3150,3024,3026,3028,3030,3032,3032,3034,2908,2910,2910,2912,2914,2916,2916,2918,2792,2792,2794,2796,2796,2798,2800,2672,2674,2676,2676,2678,2680,2680,2554,2554,2556,2556,2558,2432,2432,2434,2306,2308,2308,2310,2310,2312,2312,2314,2186,2188,2188,2188,2190,2190,2192,2192,2194,2066,2066,2068,2068,2070,2070,2070,2072,2072,1946,1946,1946,1948,1948,1948,1950,1950,1950,1952,1952,1824,1826,1826,1826,1828
  dc.w    1882,1882,1882,1882,1884,1884,2012,2014,2014,2014,2016,2016,2016,2018,2018,2020,2148,2148,2150,2150,2150,2152,2152,2154,2154,2282,2284,2284,2286,2286,2288,2288,2288,2290,2418,2420,2420,2422,2422,2424,2424,2426,2554,2556,2556,2558,2432,2432,2434,2434,2564,2564,2566,2568,2568,2570,2570,2700,2702,2702,2704,2706,2706,2708,2838,2838,2840,2842,2844,2844,2846,2976,2978,2978,2980,2982,2984,2986,3114,3116,3118,3120,3122,3124,3126,3254,3256,3258,3260,3262,3264,3266,3268,3270,3400,3402,3404,3406,3408,3410,3412,3414,3416,3418,3548,3550,3552,3554,3556,3558,3562,3564,3566,3568,3570,3572,3574,3576,3578,3580,3456,3458,3460,3462,3464,3466,3468,3470,3472,3474,3476,3480,3482,3484,3486,3488,3490,3364,3366,3368,3370,3372,3374,3376,3378,3380,3382,3256,3258,3260,3262,3264,3266,3268,3270,3272,3144,3146,3148,3150,3152,3154,3156,3028,3030,3032,3034,3036,3036,3038,2912,2914,2914,2916,2918,2920,2920,2794,2796,2796,2798,2800,2800,2802,2676,2676,2678,2678,2680,2682,2682,2556,2556,2558,2432,2432,2434,2434,2436,2308,2310,2310,2312,2312,2314,2314,2316,2188,2190,2190,2190,2192,2192,2194,2194,2196,2068,2068,2070,2070,2072,2072,2072,2074,2074,1946,1948,1948,1950,1950,1950,1952,1952,1952,1954,1826,1826,1828,1828,1828
  dc.w    1880,1880,1882,1882,1882,2012,2012,2012,2014,2014,2014,2016,2016,2016,2018,2146,2146,2148,2148,2148,2150,2150,2152,2152,2152,2282,2282,2284,2284,2286,2286,2286,2288,2416,2418,2418,2420,2420,2422,2422,2424,2552,2554,2554,2556,2556,2558,2432,2432,2562,2562,2564,2564,2566,2568,2568,2698,2698,2700,2702,2702,2704,2706,2834,2836,2838,2840,2840,2842,2844,2974,2974,2976,2978,2980,2980,3110,3112,3114,3116,3118,3120,3120,3250,3252,3254,3256,3258,3260,3262,3264,3394,3396,3398,3400,3402,3404,3406,3408,3410,3540,3542,3544,3546,3548,3550,3552,3554,3556,3558,3560,3564,3566,3568,3570,3572,3702,3704,3706,3708,3584,3586,3588,3590,3592,3466,3468,3470,3472,3474,3478,3480,3482,3484,3486,3488,3490,3492,3494,3496,3498,3372,3374,3376,3378,3380,3382,3384,3386,3388,3262,3264,3266,3268,3270,3272,3274,3276,3150,3150,3152,3154,3156,3158,3160,3034,3034,3036,3038,3040,3040,2914,2916,2918,2918,2920,2922,2924,2796,2798,2800,2800,2802,2804,2804,2678,2678,2680,2682,2682,2684,2684,2558,2432,2432,2434,2434,2436,2436,2438,2310,2312,2312,2314,2314,2316,2316,2318,2190,2192,2192,2192,2194,2194,2196,2196,2070,2070,2070,2072,2072,2074,2074,2074,2076,2076,1948,1950,1950,1950,1952,1952,1952,1954,1954,1954,1828,1828,1828,1830
  dc.w    1880,1880,1880,1880,2010,2010,2010,2012,2012,2012,2014,2014,2014,2016,2016,2144,2146,2146,2148,2148,2148,2150,2150,2152,2280,2280,2282,2282,2284,2284,2284,2286,2414,2416,2416,2418,2418,2420,2420,2422,2550,2552,2552,2554,2554,2556,2556,2558,2560,2560,2562,2562,2564,2564,2566,2696,2696,2698,2700,2700,2702,2832,2832,2834,2836,2836,2838,2840,2970,2970,2972,2974,2976,2976,2978,3108,3110,3112,3112,3114,3116,3246,3248,3250,3252,3254,3256,3256,3258,3388,3390,3392,3394,3396,3398,3400,3402,3532,3534,3536,3538,3540,3544,3546,3548,3550,3552,3554,3684,3686,3688,3690,3692,3696,3698,3700,3702,3704,3706,3708,3584,3586,3588,3590,3592,3594,3596,3598,3602,3604,3606,3608,3610,3484,3486,3488,3490,3492,3494,3498,3500,3502,3504,3506,3380,3382,3384,3386,3388,3390,3392,3394,3268,3270,3270,3272,3274,3276,3278,3280,3154,3156,3158,3158,3160,3162,3036,3038,3038,3040,3042,3044,3044,2918,2920,2922,2922,2924,2926,2926,2800,2802,2802,2804,2806,2806,2680,2682,2682,2684,2684,2686,2560,2432,2434,2434,2436,2436,2438,2438,2440,2312,2314,2314,2316,2316,2318,2318,2320,2192,2194,2194,2194,2196,2196,2198,2198,2070,2072,2072,2074,2074,2074,2076,2076,2078,1950,1950,1952,1952,1952,1954,1954,1954,1956,1956,1956,1830,1830,1830
  dc.w    1878,1878,1880,1880,2008,2010,2010,2010,2012,2012,2012,2014,2014,2014,2144,2144,2144,2146,2146,2146,2148,2148,2150,2278,2278,2280,2280,2282,2282,2282,2284,2284,2414,2414,2416,2416,2418,2418,2420,2548,2550,2550,2552,2552,2554,2554,2556,2684,2686,2560,2560,2562,2562,2564,2692,2694,2696,2696,2698,2700,2828,2830,2832,2832,2834,2836,2838,2966,2968,2970,2972,2972,2974,3104,3106,3106,3108,3110,3112,3114,3244,3246,3246,3248,3250,3252,3382,3384,3386,3388,3390,3392,3394,3396,3526,3528,3530,3532,3534,3536,3538,3540,3542,3672,3674,3678,3680,3682,3684,3686,3688,3690,3692,3694,3698,3700,3702,3704,3706,3708,3584,3586,3588,3590,3592,3594,3596,3600,3602,3604,3606,3608,3610,3612,3614,3616,3620,3622,3496,3498,3500,3502,3504,3506,3508,3510,3512,3386,3388,3390,3392,3394,3396,3398,3400,3274,3276,3278,3280,3280,3282,3156,3158,3160,3162,3164,3164,3166,3040,3042,3042,3044,3046,3048,2920,2922,2924,2926,2926,2928,2930,2802,2804,2806,2806,2808,2810,2682,2684,2684,2686,2560,2560,2562,2434,2436,2436,2438,2438,2440,2440,2442,2314,2316,2316,2318,2318,2320,2320,2194,2194,2196,2196,2196,2198,2198,2200,2200,2072,2074,2074,2076,2076,2076,2078,2078,2078,1952,1952,1952,1954,1954,1954,1956,1956,1956,1958,1830,1830,1832
  dc.w    1878,1878,1878,2006,2008,2008,2008,2010,2010,2010,2012,2012,2012,2142,2142,2142,2144,2144,2146,2146,2146,2148,2276,2276,2278,2278,2280,2280,2282,2282,2282,2412,2412,2414,2414,2416,2416,2418,2418,2548,2548,2550,2550,2552,2552,2554,2682,2684,2684,2686,2560,2560,2562,2690,2692,2694,2694,2696,2696,2826,2828,2828,2830,2832,2834,2962,2964,2966,2966,2968,2970,2972,3102,3102,3104,3106,3108,3110,3238,3240,3242,3244,3246,3248,3378,3380,3382,3384,3386,3388,3390,3518,3520,3524,3526,3528,3530,3532,3534,3664,3666,3668,3670,3672,3674,3676,3678,3682,3684,3686,3688,3818,3820,3822,3826,3828,3830,3832,3834,3836,3712,3714,3716,3718,3720,3722,3724,3728,3730,3732,3606,3608,3610,3612,3616,3618,3620,3622,3624,3626,3628,3630,3504,3506,3508,3510,3512,3514,3518,3520,3392,3394,3396,3398,3400,3402,3404,3278,3280,3282,3284,3286,3288,3160,3162,3164,3166,3168,3168,3042,3044,3046,3048,3048,3050,3052,2924,2926,2928,2930,2930,2932,2806,2806,2808,2808,2810,2812,2684,2686,2560,2560,2562,2562,2564,2436,2438,2438,2440,2440,2442,2442,2316,2316,2318,2318,2320,2320,2322,2322,2196,2196,2196,2198,2198,2200,2200,2202,2202,2074,2076,2076,2076,2078,2078,2080,2080,2080,1954,1954,1954,1956,1956,1956,1958,1958,1958,1960,1832,1832
  dc.w    1876,1876,1878,2006,2006,2008,2008,2008,2008,2010,2010,2010,2012,2140,2142,2142,2142,2144,2144,2144,2146,2146,2274,2276,2276,2278,2278,2280,2280,2280,2410,2410,2412,2412,2414,2414,2416,2416,2546,2546,2546,2548,2550,2550,2552,2680,2682,2682,2684,2684,2686,2560,2688,2690,2690,2692,2694,2694,2824,2826,2826,2828,2830,2830,2960,2962,2962,2964,2966,2968,3096,3098,3100,3102,3104,3104,3234,3236,3238,3240,3242,3244,3244,3374,3376,3378,3380,3382,3384,3514,3516,3518,3520,3522,3524,3526,3656,3658,3660,3662,3666,3668,3670,3672,3674,3804,3806,3808,3810,3814,3816,3818,3820,3822,3824,3828,3830,3832,3834,3836,3712,3714,3716,3718,3720,3722,3726,3728,3730,3732,3734,3736,3740,3742,3744,3746,3620,3622,3624,3626,3628,3632,3634,3636,3638,3512,3514,3516,3518,3520,3522,3524,3398,3400,3402,3404,3406,3408,3282,3282,3284,3286,3288,3290,3292,3166,3166,3168,3170,3172,3174,3046,3048,3050,3052,3052,3054,2928,2928,2930,2932,2932,2934,2808,2808,2810,2812,2812,2814,2560,2560,2562,2562,2564,2564,2566,2438,2440,2440,2442,2444,2444,2444,2318,2318,2320,2320,2322,2322,2324,2324,2198,2198,2198,2200,2200,2202,2202,2204,2076,2076,2078,2078,2078,2080,2080,2080,2082,1954,1956,1956,1956,1958,1958,1958,1958,1960,1960,1832,1834
  dc.w    1876,1876,2004,2004,2006,2006,2006,2008,2008,2008,2010,2010,2138,2140,2140,2140,2142,2142,2142,2144,2144,2274,2274,2274,2276,2276,2278,2278,2278,2408,2408,2410,2410,2412,2412,2412,2414,2542,2544,2544,2546,2546,2548,2548,2678,2680,2680,2682,2682,2684,2684,2814,2688,2688,2690,2690,2692,2822,2822,2824,2826,2826,2828,2958,2958,2960,2962,2964,2964,3094,3096,3098,3098,3100,3102,3232,3234,3236,3236,3238,3240,3370,3372,3374,3376,3378,3380,3510,3512,3514,3516,3518,3520,3522,3652,3654,3656,3658,3660,3662,3664,3794,3796,3800,3802,3804,3806,3808,3810,3812,3816,3818,3820,3822,3952,3956,3958,3960,3962,3964,3840,3842,3844,3846,3848,3850,3854,3728,3730,3732,3734,3738,3740,3742,3744,3746,3748,3750,3754,3756,3630,3632,3634,3636,3638,3640,3642,3516,3518,3520,3522,3524,3526,3528,3402,3404,3406,3408,3410,3412,3286,3288,3290,3290,3292,3294,3168,3170,3172,3172,3174,3176,3050,3050,3052,3054,3056,3056,2930,2932,2932,2934,2936,2936,2810,2812,2812,2814,2688,2688,2562,2562,2564,2564,2566,2566,2568,2442,2442,2444,2444,2446,2446,2448,2320,2322,2322,2322,2324,2324,2326,2326,2200,2200,2200,2202,2202,2204,2204,2204,2078,2078,2080,2080,2080,2082,2082,2082,2084,1956,1956,1958,1958,1958,1960,1960,1960,1962,1962,1834
  dc.w    1874,1874,2004,2004,2004,2004,2006,2006,2006,2008,2008,2136,2138,2138,2138,2140,2140,2140,2142,2142,2272,2272,2272,2274,2274,2276,2276,2276,2278,2406,2408,2408,2410,2410,2410,2412,2540,2542,2542,2544,2544,2546,2546,2676,2676,2678,2678,2680,2682,2682,2812,2812,2814,2688,2688,2690,2818,2820,2822,2822,2824,2826,2954,2956,2958,2958,2960,2962,3092,3092,3094,3096,3098,3228,3228,3230,3232,3234,3236,3366,3368,3370,3370,3372,3374,3504,3506,3508,3510,3512,3514,3644,3646,3648,3650,3652,3654,3658,3788,3790,3792,3794,3796,3798,3800,3804,3806,3936,3938,3940,3942,3946,3948,3950,3952,3954,3958,3960,3962,3964,3840,3842,3844,3846,3848,3852,3854,3856,3858,3860,3864,3866,3868,3870,3744,3746,3750,3752,3754,3756,3758,3760,3762,3636,3640,3642,3644,3646,3648,3650,3524,3526,3528,3530,3532,3534,3408,3410,3412,3412,3414,3416,3290,3292,3294,3296,3298,3298,3172,3174,3176,3178,3178,3052,3054,3056,3056,3058,3060,2932,2934,2936,2936,2938,2940,2812,2814,2688,2688,2690,2690,2564,2564,2566,2568,2568,2570,2570,2444,2444,2446,2446,2448,2448,2450,2322,2324,2324,2324,2326,2326,2328,2200,2202,2202,2202,2204,2204,2206,2206,2206,2080,2080,2082,2082,2082,2084,2084,2084,2086,1958,1958,1960,1960,1960,1962,1962,1962,1962,1836
  dc.w    1872,2002,2002,2002,2004,2004,2004,2006,2006,2006,2008,2136,2136,2138,2138,2138,2140,2140,2140,2142,2270,2270,2272,2272,2274,2274,2274,2276,2404,2406,2406,2406,2408,2408,2410,2538,2540,2540,2542,2542,2544,2544,2674,2674,2676,2676,2678,2678,2680,2810,2810,2812,2812,2814,2688,2816,2818,2818,2820,2822,2822,2952,2954,2954,2956,2958,3088,3088,3090,3092,3094,3094,3224,3226,3228,3230,3232,3232,3362,3364,3366,3368,3370,3500,3502,3504,3506,3508,3510,3640,3642,3644,3646,3648,3650,3780,3782,3784,3786,3788,3792,3794,3796,3926,3928,3930,3932,3936,3938,3940,3942,3944,3948,3950,3952,3954,3958,3960,4090,4092,3968,3970,3972,3846,3848,3852,3854,3856,3858,3862,3864,3866,3868,3870,3874,3876,3878,3880,3754,3756,3758,3762,3764,3766,3768,3770,3644,3646,3648,3650,3652,3654,3528,3530,3532,3534,3536,3538,3412,3414,3416,3418,3420,3294,3294,3296,3298,3300,3302,3176,3176,3178,3180,3182,3182,3056,3058,3060,3060,3062,2936,2936,2938,2940,2940,2942,2688,2688,2690,2690,2692,2692,2566,2568,2568,2570,2570,2572,2572,2446,2446,2448,2448,2450,2450,2452,2324,2326,2326,2328,2328,2328,2330,2202,2204,2204,2204,2206,2206,2208,2208,2080,2082,2082,2082,2084,2084,2084,2086,2086,1958,1960,1960,1960,1962,1962,1962,1964,1964,1964
  dc.w    2000,2000,2002,2002,2002,2002,2004,2004,2004,2006,2134,2134,2136,2136,2136,2138,2138,2138,2140,2268,2268,2270,2270,2272,2272,2272,2274,2402,2404,2404,2404,2406,2406,2408,2408,2538,2538,2540,2540,2542,2542,2672,2672,2674,2674,2676,2676,2678,2806,2808,2808,2810,2812,2812,2942,2816,2816,2818,2818,2820,2950,2950,2952,2954,2956,3084,3086,3088,3090,3090,3092,3222,3224,3224,3226,3228,3358,3360,3362,3364,3366,3494,3496,3498,3500,3502,3504,3634,3636,3638,3640,3642,3644,3774,3776,3780,3782,3784,3786,3788,3918,3920,3922,3926,3928,3930,3932,3934,3938,4068,4070,4072,4076,4078,4080,4082,4084,4088,4090,4092,3968,3970,3972,3974,3978,3980,3982,3984,3986,3990,3992,3994,3868,3872,3874,3876,3878,3880,3884,3886,3888,3762,3764,3766,3768,3770,3774,3776,3650,3652,3654,3656,3658,3660,3534,3536,3538,3540,3542,3544,3416,3418,3420,3422,3424,3298,3300,3302,3302,3304,3178,3180,3180,3182,3184,3186,3058,3060,3062,3064,3064,2938,2940,2940,2942,2816,2816,2690,2690,2692,2694,2694,2696,2568,2570,2570,2572,2572,2574,2574,2448,2448,2450,2450,2452,2452,2326,2326,2328,2328,2330,2330,2330,2332,2204,2206,2206,2206,2208,2208,2210,2210,2082,2084,2084,2084,2086,2086,2086,2088,2088,1960,1962,1962,1962,1964,1964,1964,1964,1966
  dc.w    1998,2000,2000,2000,2002,2002,2002,2002,2004,2004,2132,2134,2134,2134,2136,2136,2136,2138,2266,2268,2268,2268,2270,2270,2270,2272,2400,2402,2402,2402,2404,2404,2406,2406,2536,2536,2538,2538,2540,2540,2540,2670,2670,2672,2674,2674,2676,2804,2806,2806,2808,2808,2810,2940,2940,2942,2816,2816,2818,2946,2948,2950,2952,2952,3082,3084,3084,3086,3088,3218,3218,3220,3222,3224,3226,3356,3356,3358,3360,3362,3492,3494,3496,3498,3500,3630,3632,3634,3636,3638,3640,3770,3772,3774,3776,3778,3780,3910,3914,3916,3918,3920,3922,3924,4056,4058,4060,4062,4064,4068,4070,4072,4074,4078,4080,4082,4084,4088,4090,4092,4096,3970,3972,3974,3978,3980,3982,3984,3988,3990,3992,3994,3998,4000,4002,4004,4006,3882,3884,3886,3888,3890,3892,3896,3770,3772,3774,3776,3778,3780,3654,3656,3658,3660,3662,3664,3538,3540,3542,3544,3546,3420,3422,3424,3426,3426,3300,3302,3304,3306,3308,3308,3182,3184,3186,3186,3188,3062,3062,3064,3066,3068,2940,2942,2816,2816,2818,2818,2692,2694,2694,2696,2696,2698,2570,2572,2572,2574,2576,2576,2450,2450,2450,2452,2452,2454,2454,2328,2328,2330,2330,2332,2332,2332,2334,2206,2208,2208,2208,2210,2210,2210,2212,2084,2086,2086,2086,2088,2088,2088,2090,1962,1962,1964,1964,1964,1964,1966,1966,1966
  dc.w    1998,1998,1998,2000,2000,2000,2002,2002,2002,2132,2132,2132,2134,2134,2134,2136,2136,2136,2266,2266,2266,2268,2268,2268,2270,2270,2400,2400,2400,2402,2402,2404,2404,2534,2534,2534,2536,2536,2538,2538,2668,2668,2670,2670,2672,2672,2802,2804,2804,2806,2806,2808,2936,2938,2940,2940,2942,2816,2944,2946,2946,2948,2950,3080,3080,3082,3084,3086,3214,3216,3218,3220,3220,3350,3352,3354,3356,3358,3488,3488,3490,3492,3494,3624,3626,3628,3630,3632,3634,3764,3766,3768,3770,3774,3904,3906,3908,3910,3912,3914,3916,4048,4050,4052,4054,4056,4060,4062,4064,4194,4198,4200,4202,4204,4208,4210,4212,4216,4218,4220,4096,4098,4100,4102,4106,4108,4110,4114,4116,4118,4120,4124,3998,4000,4002,4006,4008,4010,4012,4014,3890,3892,3894,3896,3898,3900,3902,3776,3780,3782,3784,3786,3660,3662,3664,3666,3668,3670,3544,3546,3548,3550,3550,3424,3426,3428,3430,3432,3306,3306,3308,3310,3312,3184,3186,3188,3190,3190,3064,3066,3068,3068,3070,2816,2816,2818,2818,2820,2822,2694,2696,2696,2698,2698,2700,2574,2574,2576,2576,2578,2578,2452,2452,2454,2454,2456,2456,2456,2330,2330,2332,2332,2334,2334,2334,2208,2208,2210,2210,2210,2212,2212,2212,2086,2086,2086,2088,2088,2088,2090,2090,2090,1964,1964,1964,1966,1966,1966,1968,1968
  dc.w    1996,1998,1998,1998,1998,2000,2000,2000,2002,2130,2130,2132,2132,2132,2134,2134,2134,2264,2264,2264,2266,2266,2266,2268,2268,2398,2398,2398,2400,2400,2402,2402,2532,2532,2532,2534,2534,2536,2536,2666,2666,2668,2668,2670,2670,2800,2800,2802,2802,2804,2806,2934,2936,2936,2938,2940,2940,3070,2944,2944,2946,2948,3076,3078,3080,3080,3082,3212,3214,3214,3216,3218,3348,3350,3350,3352,3354,3484,3486,3488,3490,3492,3622,3624,3626,3628,3630,3760,3762,3764,3766,3768,3898,3900,3902,3904,3906,3910,4040,4042,4044,4046,4048,4052,4054,4184,4186,4190,4192,4194,4196,4200,4202,4204,4208,4210,4212,4216,4346,4348,4224,4226,4228,4102,4106,4108,4110,4114,4116,4118,4122,4124,4126,4128,4132,4134,4008,4010,4014,4016,4018,4020,4022,3896,3900,3902,3904,3906,3908,3782,3784,3786,3788,3790,3664,3666,3668,3670,3672,3546,3548,3550,3552,3554,3428,3430,3432,3432,3434,3308,3310,3312,3312,3314,3188,3190,3190,3192,3194,3066,3068,3070,2944,2944,2818,2818,2820,2822,2822,2824,2696,2698,2700,2700,2702,2702,2576,2576,2578,2578,2580,2580,2454,2454,2456,2456,2458,2458,2458,2332,2332,2334,2334,2336,2336,2336,2210,2210,2212,2212,2212,2214,2214,2214,2088,2088,2088,2090,2090,2090,2092,2092,1964,1966,1966,1966,1968,1968,1968,1968
  dc.w    1996,1996,1996,1998,1998,1998,2000,2000,2128,2128,2130,2130,2130,2132,2132,2132,2134,2262,2262,2264,2264,2264,2266,2266,2396,2396,2396,2398,2398,2400,2400,2400,2530,2530,2532,2532,2534,2534,2664,2664,2666,2666,2668,2668,2798,2798,2800,2800,2802,2802,2932,2932,2934,2936,2936,2938,3068,3068,3070,2944,2944,3074,3076,3076,3078,3080,3208,3210,3212,3214,3216,3344,3346,3348,3350,3480,3482,3482,3484,3486,3616,3618,3620,3622,3624,3754,3756,3758,3760,3762,3892,3894,3896,3900,3902,4032,4034,4036,4038,4040,4044,4174,4176,4178,4182,4184,4186,4188,4192,4322,4324,4328,4330,4332,4336,4338,4340,4342,4346,4348,4224,4226,4228,4232,4234,4236,4238,4242,4244,4246,4250,4252,4126,4130,4132,4134,4136,4140,4142,4144,4018,4022,4024,4026,4028,4030,3904,3906,3910,3912,3914,3788,3790,3792,3794,3796,3670,3672,3674,3676,3678,3552,3554,3556,3556,3558,3432,3434,3436,3438,3310,3312,3314,3316,3318,3190,3192,3194,3194,3196,3070,2944,2944,2946,2946,2820,2822,2822,2824,2826,2826,2700,2700,2702,2702,2704,2704,2578,2578,2580,2580,2582,2582,2456,2456,2458,2458,2460,2460,2334,2334,2334,2336,2336,2338,2338,2338,2212,2212,2214,2214,2214,2216,2216,2088,2090,2090,2090,2092,2092,2092,2094,2094,1966,1966,1968,1968,1968,1970,1970
  dc.w    1994,1996,1996,1996,1996,1998,1998,2126,2128,2128,2128,2130,2130,2130,2130,2132,2260,2260,2262,2262,2264,2264,2264,2266,2394,2394,2396,2396,2398,2398,2398,2528,2528,2530,2530,2532,2532,2534,2662,2662,2664,2664,2666,2666,2796,2796,2798,2800,2800,2930,2930,2932,2932,2934,2936,3064,3066,3068,3068,3070,3072,3072,3074,3076,3076,3206,3208,3210,3210,3340,3342,3344,3346,3346,3476,3478,3480,3482,3484,3614,3616,3618,3618,3748,3750,3752,3754,3758,3888,3890,3892,3894,3896,4026,4028,4030,4032,4036,4166,4168,4170,4174,4176,4178,4180,4312,4314,4316,4318,4322,4324,4326,4330,4332,4334,4466,4468,4470,4474,4476,4352,4354,4356,4360,4362,4364,4240,4242,4244,4248,4250,4252,4256,4258,4260,4262,4138,4140,4142,4144,4148,4150,4152,4026,4030,4032,4034,4036,3910,3912,3914,3916,3918,3792,3796,3798,3800,3802,3676,3676,3678,3680,3554,3556,3558,3560,3562,3436,3436,3438,3440,3442,3316,3316,3318,3320,3194,3194,3196,3198,3072,2944,2946,2946,2948,2950,2822,2824,2826,2826,2828,2828,2702,2702,2704,2706,2706,2580,2580,2582,2582,2584,2584,2456,2458,2458,2460,2460,2462,2462,2336,2336,2336,2338,2338,2340,2340,2212,2214,2214,2214,2216,2216,2218,2218,2090,2092,2092,2092,2092,2094,2094,2094,2096,1968,1968,1970,1970,1970,1970
  dc.w    1994,1994,1994,1996,1996,1996,1996,2126,2126,2126,2128,2128,2128,2130,2130,2258,2260,2260,2260,2262,2262,2262,2264,2392,2392,2394,2394,2396,2396,2396,2526,2526,2528,2528,2528,2530,2530,2660,2660,2662,2662,2664,2664,2794,2794,2796,2796,2798,2926,2928,2930,2930,2932,2932,3062,3064,3064,3066,3066,3196,3198,3072,3072,3074,3204,3204,3206,3208,3338,3338,3340,3342,3344,3474,3476,3476,3478,3608,3610,3612,3614,3616,3746,3748,3750,3752,3882,3884,3886,3888,3890,4020,4022,4026,4028,4030,4160,4162,4164,4168,4170,4300,4302,4306,4308,4310,4314,4316,4446,4448,4452,4454,4458,4460,4462,4466,4468,4470,4474,4476,4352,4354,4356,4360,4362,4364,4368,4370,4372,4376,4378,4382,4384,4258,4260,4264,4266,4268,4272,4274,4148,4150,4154,4156,4158,4032,4034,4036,4040,4042,3916,3918,3920,3922,3924,3798,3800,3802,3804,3678,3680,3682,3684,3686,3560,3562,3562,3564,3438,3440,3442,3444,3444,3318,3320,3322,3322,3196,3198,3072,3072,3074,2948,2948,2950,2950,2952,2826,2826,2828,2828,2830,2832,2704,2706,2706,2708,2708,2582,2582,2584,2584,2586,2586,2460,2460,2462,2462,2462,2464,2464,2338,2338,2338,2340,2340,2342,2342,2214,2216,2216,2216,2218,2218,2218,2220,2092,2092,2094,2094,2094,2096,2096,2096,1970,1970,1970,1970,1972,1972
  dc.w    1992,1992,1994,1994,1994,1996,2124,2124,2124,2126,2126,2126,2128,2128,2128,2258,2258,2258,2260,2260,2260,2262,2262,2390,2392,2392,2394,2394,2394,2396,2524,2526,2526,2526,2528,2528,2658,2658,2660,2660,2662,2662,2792,2792,2794,2794,2796,2796,2926,2926,2928,2928,2930,3060,3060,3062,3062,3064,3194,3194,3196,3198,3072,3200,3202,3204,3204,3334,3336,3338,3340,3340,3470,3472,3474,3476,3606,3608,3608,3610,3740,3742,3744,3746,3876,3878,3880,3882,3884,4016,4018,4020,4022,4152,4154,4156,4160,4162,4292,4294,4296,4300,4302,4304,4436,4438,4440,4444,4446,4448,4452,4454,4456,4588,4590,4592,4596,4598,4602,4604,4480,4482,4484,4488,4490,4494,4496,4498,4374,4376,4378,4382,4384,4386,4390,4392,4394,4270,4272,4274,4278,4280,4282,4156,4158,4162,4164,4166,4040,4042,4044,4046,3922,3924,3926,3928,3930,3804,3806,3808,3810,3684,3686,3686,3688,3562,3564,3566,3568,3442,3442,3444,3446,3448,3322,3322,3324,3326,3072,3072,3074,3076,3076,2950,2952,2952,2954,2954,2828,2830,2830,2832,2832,2706,2706,2708,2708,2710,2710,2584,2584,2586,2586,2588,2588,2462,2462,2464,2464,2464,2466,2338,2340,2340,2340,2342,2342,2344,2216,2216,2218,2218,2218,2220,2220,2220,2094,2094,2094,2096,2096,2096,2098,2098,2098,1970,1972,1972,1972,1974
  dc.w    1992,1992,1992,1992,1994,1994,2122,2124,2124,2124,2124,2126,2126,2126,2256,2256,2256,2258,2258,2258,2260,2260,2388,2390,2390,2392,2392,2392,2394,2522,2524,2524,2524,2526,2526,2656,2656,2658,2658,2658,2660,2788,2790,2790,2792,2792,2794,2924,2924,2926,2926,2928,3056,3058,3060,3060,3062,3190,3192,3194,3194,3196,3326,3200,3200,3202,3332,3332,3334,3336,3466,3468,3468,3470,3472,3602,3604,3606,3608,3738,3740,3742,3744,3874,3876,3878,3880,4010,4012,4014,4016,4146,4148,4150,4154,4156,4286,4288,4290,4294,4296,4426,4430,4432,4434,4438,4440,4570,4574,4576,4578,4582,4584,4588,4590,4592,4596,4598,4602,4604,4480,4482,4484,4488,4490,4494,4496,4498,4502,4504,4508,4510,4512,4516,4390,4392,4396,4398,4400,4404,4278,4280,4284,4286,4288,4162,4164,4168,4170,4172,4046,4048,4050,4052,3926,3928,3930,3932,3806,3808,3810,3812,3686,3688,3690,3692,3566,3568,3570,3570,3572,3446,3448,3450,3450,3324,3326,3200,3200,3074,3076,3076,3078,3080,2952,2954,2954,2956,2958,2830,2832,2832,2834,2834,2708,2710,2710,2712,2712,2714,2586,2588,2588,2588,2590,2590,2464,2464,2466,2466,2466,2468,2340,2342,2342,2342,2344,2344,2346,2218,2218,2220,2220,2220,2222,2222,2222,2096,2096,2096,2098,2098,2098,2098,2100,1972,1972,1974,1974,1974
  dc.w    1990,1990,1992,1992,1992,2120,2122,2122,2122,2124,2124,2124,2124,2126,2254,2254,2256,2256,2256,2258,2258,2386,2388,2388,2390,2390,2390,2392,2520,2520,2522,2522,2524,2524,2526,2654,2654,2656,2656,2658,2658,2788,2788,2790,2790,2792,2920,2922,2922,2924,2924,3054,3056,3056,3058,3058,3188,3190,3190,3192,3194,3322,3324,3326,3200,3328,3330,3332,3334,3462,3464,3466,3468,3598,3598,3600,3602,3732,3734,3736,3738,3868,3870,3872,3874,4004,4006,4008,4010,4012,4142,4146,4148,4150,4280,4282,4286,4288,4418,4420,4424,4426,4428,4430,4562,4564,4568,4570,4572,4576,4706,4710,4712,4714,4718,4720,4724,4726,4730,4732,4608,4610,4612,4616,4618,4622,4624,4628,4630,4632,4636,4510,4514,4516,4518,4522,4524,4400,4402,4404,4406,4410,4412,4286,4288,4292,4294,4168,4170,4172,4176,4050,4052,4054,4056,4058,3932,3934,3936,3938,3812,3814,3816,3818,3692,3694,3696,3696,3570,3572,3574,3576,3448,3450,3452,3454,3200,3200,3202,3204,3076,3078,3080,3080,3082,2956,2956,2958,2958,2960,2834,2834,2836,2836,2838,2710,2712,2712,2714,2714,2588,2588,2590,2590,2592,2592,2464,2466,2466,2468,2468,2470,2470,2342,2344,2344,2344,2346,2346,2348,2220,2220,2222,2222,2222,2224,2224,2096,2098,2098,2098,2098,2100,2100,2100,2102,1974,1974,1974,1976
  dc.w    1990,1990,1990,1990,1992,2120,2120,2120,2122,2122,2122,2124,2124,2252,2254,2254,2254,2254,2256,2256,2256,2386,2386,2388,2388,2388,2390,2390,2518,2520,2520,2522,2522,2522,2652,2652,2654,2654,2656,2656,2786,2786,2788,2788,2790,2918,2920,2920,2922,2922,3052,3052,3054,3056,3056,3186,3186,3188,3190,3190,3320,3322,3322,3324,3454,3328,3328,3330,3460,3462,3462,3464,3594,3596,3598,3600,3730,3730,3732,3734,3864,3866,3868,3870,4000,4002,4004,4006,4138,4140,4142,4144,4274,4276,4280,4282,4412,4414,4416,4420,4422,4552,4556,4558,4560,4564,4694,4698,4700,4702,4706,4708,4712,4714,4846,4848,4852,4854,4858,4860,4736,4738,4740,4744,4746,4750,4752,4628,4630,4634,4636,4640,4642,4644,4648,4522,4526,4528,4530,4534,4408,4410,4414,4416,4418,4292,4294,4298,4300,4174,4176,4178,4180,4056,4058,4060,4062,3936,3938,3940,3942,3816,3818,3820,3820,3694,3696,3698,3700,3574,3576,3576,3578,3452,3454,3328,3328,3202,3204,3204,3206,3080,3080,3082,3084,3084,2958,2958,2960,2962,2962,2836,2836,2838,2838,2840,2712,2714,2714,2716,2716,2590,2590,2592,2592,2594,2594,2468,2468,2468,2470,2470,2472,2344,2344,2346,2346,2346,2348,2348,2222,2222,2222,2224,2224,2224,2224,2226,2098,2098,2100,2100,2100,2102,2102,2102,1974,1976,1976,1976
  dc.w    1988,1988,1988,1990,2118,2118,2120,2120,2120,2120,2122,2122,2122,2252,2252,2252,2254,2254,2254,2256,2384,2384,2386,2386,2386,2388,2388,2516,2518,2518,2520,2520,2520,2650,2650,2652,2652,2654,2654,2782,2784,2784,2786,2786,2788,2916,2918,2918,2920,2920,3050,3052,3052,3054,3182,3184,3186,3186,3188,3318,3318,3320,3322,3450,3452,3454,3328,3456,3458,3460,3462,3590,3592,3594,3596,3726,3728,3730,3732,3862,3864,3866,3996,3998,4000,4002,4132,4134,4136,4138,4268,4270,4274,4276,4406,4408,4410,4414,4544,4546,4550,4552,4554,4686,4688,4690,4694,4696,4828,4830,4834,4836,4840,4842,4844,4848,4850,4854,4856,4860,4736,4738,4742,4744,4748,4750,4754,4756,4758,4762,4764,4768,4770,4646,4648,4652,4654,4656,4532,4534,4536,4540,4542,4416,4420,4422,4424,4298,4300,4304,4306,4180,4182,4184,4186,4060,4062,4064,4066,3940,3942,3944,3818,3820,3822,3824,3698,3700,3702,3704,3576,3578,3580,3582,3328,3328,3330,3332,3204,3206,3208,3208,3082,3084,3084,3086,3088,2960,2962,2962,2964,2838,2838,2840,2840,2842,2714,2716,2716,2718,2718,2720,2592,2592,2594,2594,2596,2596,2470,2470,2470,2472,2472,2474,2346,2346,2348,2348,2348,2350,2350,2222,2224,2224,2224,2226,2226,2226,2100,2100,2100,2102,2102,2102,2102,2104,2104,1976,1978,1978
  dc.w    1986,1988,1988,1988,2116,2118,2118,2118,2120,2120,2120,2120,2250,2250,2250,2252,2252,2252,2254,2254,2382,2384,2384,2384,2386,2386,2386,2516,2516,2516,2518,2518,2520,2648,2650,2650,2650,2652,2652,2782,2782,2784,2784,2786,2914,2916,2916,2918,2918,3048,3048,3050,3050,3052,3182,3182,3184,3184,3314,3316,3316,3318,3448,3450,3450,3452,3582,3456,3456,3458,3588,3590,3592,3592,3722,3724,3726,3856,3858,3860,3862,3992,3994,3996,3998,4128,4130,4132,4262,4264,4268,4270,4400,4402,4404,4408,4538,4540,4542,4546,4676,4678,4682,4684,4688,4818,4820,4824,4826,4830,4832,4964,4966,4970,4972,4976,4978,4982,4984,4988,4864,4866,4870,4872,4876,4878,4882,4884,4888,4890,4766,4768,4772,4774,4778,4780,4654,4658,4660,4664,4666,4540,4544,4546,4548,4422,4426,4428,4430,4304,4306,4310,4312,4186,4188,4190,4064,4066,4068,4070,3944,3946,3948,3950,3824,3826,3828,3702,3702,3704,3706,3580,3582,3456,3456,3330,3332,3332,3334,3208,3210,3210,3212,3086,3086,3088,3088,2962,2964,2964,2966,2966,2840,2840,2842,2842,2844,2716,2718,2718,2720,2720,2594,2594,2596,2596,2596,2598,2470,2472,2472,2474,2474,2474,2348,2348,2348,2350,2350,2350,2352,2224,2224,2226,2226,2226,2228,2228,2228,2102,2102,2102,2102,2104,2104,2104,2106,1978,1978,1978
  dc.w    1986,1986,1986,1988,2116,2116,2116,2118,2118,2118,2118,2120,2248,2248,2250,2250,2250,2252,2252,2380,2382,2382,2382,2384,2384,2384,2514,2514,2514,2516,2516,2518,2646,2646,2648,2648,2650,2650,2780,2780,2780,2782,2782,2912,2912,2914,2914,2916,3044,3046,3048,3048,3050,3178,3180,3180,3182,3312,3312,3314,3316,3444,3446,3448,3448,3578,3580,3582,3456,3584,3586,3588,3590,3720,3720,3722,3852,3854,3856,3858,3988,3990,3992,4122,4124,4126,4128,4258,4262,4264,4394,4396,4398,4400,4532,4534,4536,4668,4670,4672,4676,4678,4808,4812,4814,4818,4948,4952,4954,4958,4960,4964,4966,5098,5100,5104,5106,5110,5112,5116,4992,4994,4998,5000,5004,5006,5010,5012,4888,4890,4894,4896,4900,4902,4906,4780,4784,4786,4790,4664,4666,4670,4672,4674,4550,4552,4554,4430,4432,4434,4436,4310,4312,4316,4190,4192,4194,4196,4070,4072,4074,3948,3950,3952,3954,3828,3830,3830,3704,3706,3708,3710,3456,3456,3458,3460,3334,3334,3336,3338,3210,3212,3214,3214,3088,3090,3090,3092,2964,2966,2966,2968,2970,2842,2844,2844,2846,2846,2720,2720,2722,2722,2722,2596,2596,2598,2598,2600,2600,2472,2474,2474,2476,2476,2476,2350,2350,2350,2352,2352,2352,2354,2226,2226,2228,2228,2228,2230,2230,2102,2104,2104,2104,2104,2106,2106,2106,1978,1980,1980
  dc.w    1984,1984,1986,2114,2114,2116,2116,2116,2116,2118,2118,2246,2246,2248,2248,2248,2250,2250,2250,2380,2380,2380,2382,2382,2382,2384,2512,2512,2514,2514,2516,2516,2644,2646,2646,2648,2648,2776,2778,2778,2780,2780,2782,2910,2912,2912,2914,2914,3044,3044,3046,3046,3176,3178,3178,3180,3308,3310,3312,3312,3442,3444,3444,3446,3576,3576,3578,3580,3710,3584,3584,3586,3716,3718,3720,3850,3850,3852,3854,3984,3986,3988,4118,4120,4122,4252,4256,4258,4388,4390,4392,4394,4526,4528,4530,4660,4664,4666,4668,4800,4802,4804,4808,4938,4942,4944,4948,4950,5082,5084,5088,5090,5094,5096,5100,5104,5234,5238,5240,5244,5120,5122,5126,5128,5132,5006,5010,5014,5016,5020,5022,5026,5028,4904,4906,4910,4912,4916,4790,4794,4796,4798,4674,4676,4678,4682,4556,4558,4560,4436,4438,4440,4442,4316,4318,4322,4196,4198,4200,4074,4076,4078,3952,3954,3956,3956,3830,3832,3834,3708,3710,3584,3584,3458,3460,3462,3462,3336,3338,3338,3340,3214,3214,3216,3218,3090,3092,3092,3094,2968,2968,2970,2970,2844,2844,2846,2846,2848,2720,2722,2722,2724,2724,2726,2598,2598,2600,2600,2602,2474,2474,2476,2476,2478,2478,2350,2352,2352,2352,2354,2354,2354,2228,2228,2228,2230,2230,2230,2232,2232,2104,2104,2106,2106,2106,2106,2108,2108,1980,1982
  dc.w    1984,1984,1984,2112,2114,2114,2114,2114,2116,2116,2116,2246,2246,2246,2246,2248,2248,2248,2378,2378,2378,2380,2380,2380,2382,2510,2510,2512,2512,2512,2514,2642,2644,2644,2644,2646,2646,2776,2776,2778,2778,2778,2908,2908,2910,2910,2912,3040,3042,3042,3044,3174,3174,3176,3176,3178,3308,3308,3310,3310,3440,3442,3442,3572,3574,3576,3576,3706,3708,3710,3584,3712,3714,3716,3846,3848,3850,3980,3982,3984,3986,4116,4118,4120,4250,4252,4254,4384,4386,4388,4518,4522,4524,4654,4656,4660,4662,4792,4796,4798,4928,4932,4934,4938,5068,5072,5074,5078,5080,5212,5214,5218,5222,5224,5228,5230,5234,5238,5240,5244,5120,5122,5126,5128,5132,5136,5138,5142,5144,5148,5152,5154,5030,5032,5036,5038,5042,4916,4920,4922,4926,4800,4802,4806,4680,4682,4686,4688,4562,4564,4568,4442,4444,4446,4320,4322,4324,4198,4200,4202,4076,4078,4080,4082,3956,3958,3960,3834,3836,3838,3584,3584,3586,3588,3462,3462,3464,3466,3340,3340,3342,3216,3216,3218,3218,3092,3094,3094,3096,3096,2970,2972,2972,2974,2846,2848,2848,2850,2850,2724,2724,2724,2726,2726,2600,2600,2602,2602,2602,2604,2476,2478,2478,2478,2480,2480,2352,2354,2354,2354,2356,2356,2356,2230,2230,2230,2232,2232,2232,2232,2106,2106,2106,2108,2108,2108,2108,2110,1982,1982
  dc.w    1982,1982,2112,2112,2112,2112,2114,2114,2114,2114,2244,2244,2244,2244,2246,2246,2246,2248,2376,2376,2378,2378,2378,2380,2508,2508,2510,2510,2510,2512,2512,2642,2642,2642,2644,2644,2774,2774,2774,2776,2776,2906,2906,2908,2908,2910,3038,3040,3040,3042,3042,3172,3172,3174,3176,3304,3306,3306,3308,3438,3438,3440,3442,3570,3572,3574,3704,3704,3706,3708,3838,3712,3712,3842,3844,3846,3976,3978,3980,4110,4112,4114,4244,4246,4248,4378,4380,4382,4384,4516,4518,4520,4650,4652,4656,4786,4788,4792,4922,4926,4928,4930,5062,5064,5068,5070,5202,5204,5208,5212,5214,5346,5348,5352,5356,5358,5362,5366,5368,5372,5248,5250,5254,5256,5260,5264,5266,5270,5274,5276,5152,5154,5158,5162,5164,5040,5042,5046,5048,4924,4926,4928,4932,4806,4810,4812,4686,4690,4692,4566,4568,4570,4446,4448,4450,4452,4326,4328,4330,4204,4206,4208,4082,4084,4086,3960,3962,3964,3838,3712,3712,3586,3588,3590,3590,3464,3466,3468,3340,3342,3344,3344,3218,3220,3220,3222,3094,3096,3098,3098,2972,2972,2974,2974,2976,2848,2850,2850,2852,2852,2726,2726,2728,2728,2728,2602,2602,2604,2604,2604,2478,2478,2480,2480,2480,2482,2482,2354,2356,2356,2356,2358,2358,2230,2232,2232,2232,2234,2234,2234,2234,2108,2108,2108,2108,2110,2110,2110,2110,1984
  dc.w    1982,1982,2110,2110,2110,2112,2112,2112,2112,2114,2242,2242,2244,2244,2244,2244,2246,2374,2374,2376,2376,2376,2378,2378,2506,2508,2508,2508,2510,2510,2638,2640,2640,2642,2642,2642,2772,2772,2774,2774,2776,2904,2904,2906,2906,2908,3036,3038,3038,3040,3168,3170,3172,3172,3302,3302,3304,3306,3434,3436,3436,3438,3568,3570,3570,3700,3702,3702,3704,3834,3836,3838,3840,3840,3842,3972,3974,3976,4106,4108,4110,4240,4242,4244,4374,4376,4378,4508,4512,4514,4644,4646,4648,4780,4782,4784,4916,4918,4920,5052,5054,5058,5060,5192,5194,5198,5200,5332,5336,5338,5342,5344,5476,5480,5482,5486,5490,5492,5496,5500,5376,5378,5382,5386,5388,5392,5396,5398,5402,5278,5280,5284,5286,5290,5166,5168,5172,5174,5050,5052,5056,5058,4934,4936,4938,4814,4816,4818,4694,4696,4698,4572,4574,4578,4452,4454,4456,4330,4332,4334,4208,4210,4212,4086,4088,4090,3964,3966,3840,3712,3714,3716,3590,3592,3592,3594,3468,3468,3470,3344,3346,3346,3348,3220,3222,3224,3224,3098,3098,3100,3102,2974,2976,2976,2978,2850,2852,2852,2854,2854,2726,2728,2728,2730,2730,2604,2604,2604,2606,2606,2608,2480,2480,2482,2482,2482,2484,2356,2356,2358,2358,2358,2360,2360,2232,2234,2234,2234,2234,2236,2236,2108,2110,2110,2110,2110,2112,2112,2112,1984
  dc.w    1980,2108,2108,2110,2110,2110,2110,2112,2112,2112,2240,2242,2242,2242,2244,2244,2244,2372,2374,2374,2374,2376,2376,2504,2506,2506,2506,2508,2508,2508,2638,2638,2638,2640,2640,2770,2770,2770,2772,2772,2902,2902,2904,2904,2906,3034,3036,3036,3038,3166,3168,3168,3170,3298,3300,3302,3302,3432,3432,3434,3436,3564,3566,3568,3696,3698,3700,3702,3830,3832,3834,3964,3966,3840,3968,3970,3972,4102,4104,4106,4236,4238,4240,4370,4372,4374,4504,4508,4638,4640,4642,4772,4776,4778,4908,4912,4914,5044,5048,5050,5182,5184,5188,5190,5322,5324,5328,5332,5462,5466,5468,5472,5476,5606,5610,5614,5618,5620,5624,5628,5504,5506,5510,5514,5516,5520,5524,5528,5402,5406,5410,5412,5416,5290,5294,5298,5300,5176,5178,5182,5184,5060,5062,5066,4940,4942,4946,4820,4822,4826,4700,4702,4704,4578,4582,4456,4458,4460,4334,4336,4338,4212,4214,4216,4090,4092,4094,3840,3840,3842,3716,3718,3720,3592,3594,3596,3598,3470,3472,3474,3346,3348,3350,3350,3224,3224,3226,3228,3100,3102,3102,3104,2976,2978,2978,2980,2852,2854,2854,2856,2856,2730,2730,2732,2732,2732,2606,2606,2608,2608,2608,2482,2482,2482,2484,2484,2484,2486,2358,2358,2360,2360,2360,2362,2234,2234,2234,2236,2236,2236,2238,2110,2110,2110,2112,2112,2112,2112,2114,2114
  dc.w    1978,2108,2108,2108,2108,2110,2110,2110,2110,2240,2240,2240,2240,2242,2242,2242,2370,2372,2372,2372,2374,2374,2374,2504,2504,2504,2506,2506,2506,2636,2636,2636,2638,2638,2640,2768,2768,2770,2770,2772,2900,2900,2902,2902,3032,3032,3034,3034,3036,3164,3166,3166,3168,3298,3298,3300,3300,3430,3432,3432,3562,3562,3564,3566,3696,3696,3698,3828,3830,3830,3960,3962,3964,4094,3968,3968,4098,4100,4102,4232,4234,4236,4366,4368,4498,4500,4504,4634,4636,4638,4768,4772,4902,4904,4908,5038,5040,5044,5174,5178,5180,5312,5314,5318,5448,5452,5454,5458,5590,5592,5596,5600,5602,5734,5738,5742,5744,5748,5752,5756,5632,5634,5638,5642,5646,5648,5652,5656,5532,5534,5538,5542,5544,5420,5424,5426,5430,5304,5308,5310,5186,5188,5192,5066,5070,5072,4946,4950,4952,4826,4830,4704,4706,4708,4582,4586,4588,4462,4464,4338,4340,4342,4216,4218,4220,4094,3968,3968,3842,3844,3846,3720,3720,3722,3596,3598,3598,3472,3474,3476,3476,3350,3350,3352,3226,3226,3228,3228,3102,3104,3104,3106,2978,2980,2980,2982,2982,2856,2856,2858,2858,2730,2732,2732,2734,2734,2606,2608,2608,2610,2610,2610,2484,2484,2484,2486,2486,2486,2360,2360,2360,2362,2362,2362,2364,2236,2236,2236,2238,2238,2238,2238,2112,2112,2112,2112,2114,2114,2114,2114
  dc.w    1978,2106,2106,2106,2108,2108,2108,2108,2110,2238,2238,2238,2240,2240,2240,2240,2370,2370,2370,2372,2372,2372,2374,2502,2502,2504,2504,2504,2506,2634,2634,2636,2636,2636,2766,2766,2768,2768,2768,2898,2898,2900,2900,2902,3030,3032,3032,3034,3162,3164,3164,3166,3294,3296,3296,3298,3426,3428,3430,3558,3560,3562,3562,3692,3694,3694,3824,3826,3828,3956,3958,3960,4090,4092,4094,4096,4096,4098,4228,4230,4360,4362,4364,4494,4498,4500,4630,4632,4762,4764,4768,4898,4900,5030,5034,5036,5168,5170,5172,5304,5306,5310,5440,5444,5448,5578,5582,5586,5588,5720,5724,5726,5730,5734,5866,5868,5872,5876,5880,5884,5760,5762,5766,5770,5774,5778,5780,5656,5660,5664,5666,5670,5546,5548,5552,5556,5430,5434,5438,5312,5316,5318,5194,5196,5198,5074,5076,5080,4954,4956,4830,4834,4836,4710,4712,4586,4588,4592,4466,4468,4470,4344,4346,4220,4222,4096,3968,3970,3972,3846,3848,3850,3722,3724,3726,3600,3600,3602,3476,3476,3478,3480,3352,3354,3356,3228,3230,3230,3232,3104,3106,3106,3108,2980,2982,2982,2984,2856,2858,2858,2860,2860,2734,2734,2734,2736,2736,2610,2610,2610,2612,2612,2484,2486,2486,2486,2488,2488,2360,2362,2362,2362,2364,2364,2364,2238,2238,2238,2238,2240,2240,2240,2112,2114,2114,2114,2114,2116,2116,2116
  dc.w    2104,2104,2106,2106,2106,2106,2108,2108,2236,2236,2238,2238,2238,2238,2240,2240,2368,2368,2370,2370,2370,2372,2500,2500,2502,2502,2502,2504,2632,2632,2634,2634,2634,2764,2764,2764,2766,2766,2896,2896,2896,2898,2898,3028,3028,3030,3030,3160,3160,3162,3162,3292,3292,3294,3294,3424,3426,3426,3428,3556,3558,3560,3688,3690,3692,3820,3822,3824,3954,3956,3956,4086,4088,4090,4220,4222,4096,4224,4226,4356,4358,4360,4490,4494,4624,4626,4628,4758,4760,4890,4894,4896,5026,5030,5160,5162,5166,5296,5300,5430,5434,5436,5568,5570,5574,5706,5708,5712,5716,5848,5850,5854,5858,5862,5992,5996,6000,6004,6008,6012,5888,5890,5894,5898,5902,5906,5910,5784,5788,5792,5796,5798,5674,5678,5682,5684,5560,5564,5566,5442,5444,5448,5322,5326,5200,5204,5206,5080,5084,4958,4960,4964,4838,4840,4714,4716,4718,4592,4596,4470,4472,4474,4348,4350,4096,4096,4098,3972,3974,3976,3850,3850,3852,3726,3728,3730,3602,3604,3606,3478,3480,3482,3354,3356,3356,3358,3232,3232,3234,3234,3108,3108,3110,3110,2984,2984,2986,2986,2860,2860,2862,2862,2862,2736,2736,2738,2738,2738,2612,2612,2612,2614,2614,2486,2488,2488,2488,2490,2490,2362,2364,2364,2364,2366,2366,2238,2238,2240,2240,2240,2240,2242,2242,2114,2114,2116,2116,2116,2116,2118
  dc.w    2104,2104,2104,2104,2104,2106,2106,2106,2234,2236,2236,2236,2236,2238,2238,2366,2366,2368,2368,2368,2370,2370,2498,2500,2500,2500,2500,2502,2630,2630,2632,2632,2634,2762,2762,2764,2764,2764,2894,2894,2896,2896,2898,3026,3026,3028,3028,3158,3158,3160,3160,3290,3290,3292,3294,3422,3424,3424,3554,3556,3556,3686,3686,3688,3818,3820,3820,3950,3952,3954,4082,4084,4086,4216,4218,4220,4350,4224,4352,4354,4356,4486,4490,4620,4622,4624,4754,4756,4886,4890,5020,5022,5024,5156,5158,5290,5292,5294,5426,5428,5560,5564,5566,5698,5700,5704,5836,5840,5842,5974,5978,5982,5986,6116,6120,6124,6128,6132,6136,6140,6016,6018,6022,6026,6030,6034,6038,6042,5916,5920,5924,5928,5804,5806,5810,5686,5690,5692,5568,5570,5574,5450,5452,5328,5330,5332,5208,5210,5086,5088,5090,4964,4968,4842,4844,4718,4720,4722,4596,4600,4474,4476,4478,4224,4224,4098,4100,4102,3976,3978,3980,3852,3854,3856,3730,3730,3732,3606,3608,3608,3482,3482,3484,3358,3358,3360,3232,3234,3236,3236,3110,3110,3112,3112,2986,2986,2988,2988,2860,2862,2862,2864,2864,2738,2738,2738,2740,2740,2612,2614,2614,2616,2616,2488,2490,2490,2490,2490,2492,2364,2364,2366,2366,2366,2368,2368,2240,2240,2242,2242,2242,2242,2244,2116,2116,2116,2118,2118,2118,2118
  dc.w    2102,2102,2102,2104,2104,2104,2104,2104,2234,2234,2234,2234,2236,2236,2236,2366,2366,2366,2366,2368,2368,2496,2496,2498,2498,2498,2500,2628,2628,2630,2630,2630,2760,2760,2762,2762,2762,2892,2892,2892,2894,2894,3024,3024,3026,3026,3156,3156,3158,3158,3288,3288,3290,3290,3420,3420,3422,3550,3552,3554,3554,3684,3686,3686,3816,3818,3818,3948,3950,3952,4080,4082,4212,4214,4216,4346,4348,4478,4352,4352,4482,4486,4616,4618,4748,4750,4752,4882,4884,5016,5018,5148,5152,5282,5284,5288,5418,5422,5552,5556,5686,5690,5694,5824,5828,5832,5962,5966,5970,6102,6104,6108,6112,6244,6248,6252,6256,6260,6264,6268,6144,6146,6150,6154,6158,6162,6166,6170,6046,6050,6054,6056,5932,5936,5940,5814,5818,5822,5696,5700,5704,5578,5582,5456,5460,5334,5338,5340,5214,5218,5092,5094,4970,4972,4846,4848,4850,4724,4726,4600,4604,4478,4352,4352,4226,4228,4102,4104,4106,3980,3982,3854,3856,3858,3732,3732,3734,3608,3608,3610,3484,3484,3486,3488,3360,3362,3362,3236,3236,3238,3238,3112,3112,3114,3114,2988,2988,2990,2990,2864,2864,2866,2866,2866,2740,2740,2740,2742,2742,2616,2616,2616,2618,2618,2490,2492,2492,2492,2494,2494,2366,2366,2368,2368,2368,2368,2242,2242,2242,2244,2244,2244,2244,2118,2118,2118,2118,2118,2120,2120
  dc.w    2100,2102,2102,2102,2102,2102,2104,2232,2232,2232,2234,2234,2234,2234,2364,2364,2364,2364,2366,2366,2366,2494,2496,2496,2496,2498,2498,2626,2628,2628,2628,2630,2758,2758,2760,2760,2762,2890,2890,2892,2892,3022,3022,3022,3024,3024,3154,3154,3156,3156,3286,3286,3288,3416,3418,3418,3420,3550,3550,3552,3680,3682,3684,3812,3814,3816,3944,3946,3948,4078,4078,4208,4210,4212,4342,4344,4474,4476,4478,4480,4482,4612,4614,4744,4746,4748,4878,4880,5010,5014,5144,5146,5278,5280,5410,5414,5544,5548,5678,5682,5686,5816,5820,5950,5954,5958,6090,6092,6096,6228,6232,6236,6368,6372,6376,6380,6384,6388,6392,6396,6272,6274,6278,6282,6286,6290,6294,6298,6302,6178,6182,6186,6062,6066,6068,5944,5948,5952,5826,5830,5704,5708,5712,5586,5590,5464,5468,5342,5344,5220,5222,5096,5100,4974,4976,4850,4852,4854,4728,4730,4604,4480,4352,4354,4356,4230,4232,4106,4108,4110,3984,3984,3858,3860,3862,3734,3736,3738,3610,3612,3614,3486,3488,3488,3362,3364,3364,3366,3238,3240,3240,3114,3114,3116,3116,2990,2990,2992,2992,2992,2866,2866,2868,2868,2740,2742,2742,2744,2744,2616,2618,2618,2618,2620,2492,2492,2494,2494,2494,2496,2368,2368,2368,2370,2370,2370,2370,2244,2244,2244,2244,2246,2246,2246,2118,2120,2120,2120,2120,2120
  dc.w    2100,2100,2100,2100,2102,2102,2102,2230,2230,2232,2232,2232,2232,2234,2362,2362,2362,2364,2364,2364,2494,2494,2494,2494,2496,2496,2624,2626,2626,2626,2628,2628,2756,2758,2758,2758,2888,2888,2888,2890,2890,3020,3020,3022,3022,3150,3152,3152,3154,3282,3284,3284,3286,3414,3416,3416,3546,3548,3548,3678,3678,3680,3810,3810,3812,3942,3942,3944,4074,4076,4076,4206,4208,4338,4340,4470,4472,4474,4604,4604,4608,4610,4740,4742,4872,4874,5004,5006,5010,5140,5142,5272,5276,5406,5410,5540,5542,5674,5678,5808,5812,5942,5946,6078,6080,6084,6216,6220,6352,6356,6360,6362,6494,6498,6502,6506,6510,6642,6646,6650,6528,6532,6536,6540,6416,6420,6424,6428,6432,6308,6310,6314,6318,6194,6198,6074,6078,6080,5956,5960,5834,5838,5712,5716,5592,5594,5468,5472,5346,5350,5224,5226,5100,5104,5106,4980,4982,4856,4858,4732,4608,4482,4482,4356,4358,4360,4234,4236,4110,4112,3986,3986,3988,3862,3864,3864,3738,3740,3740,3614,3616,3616,3490,3490,3492,3366,3366,3368,3240,3242,3242,3244,3116,3118,3118,3120,2992,2992,2994,2994,2868,2868,2870,2870,2870,2744,2744,2744,2746,2618,2618,2620,2620,2620,2622,2494,2494,2496,2496,2496,2496,2370,2370,2370,2372,2372,2372,2244,2246,2246,2246,2246,2248,2248,2120,2120,2120,2122,2122,2122
  dc.w    2098,2098,2100,2100,2100,2100,2100,2230,2230,2230,2230,2230,2232,2232,2360,2360,2362,2362,2362,2364,2492,2492,2492,2494,2494,2494,2624,2624,2624,2624,2626,2754,2754,2756,2756,2758,2886,2886,2888,2888,3016,3018,3018,3020,3020,3150,3150,3150,3280,3280,3282,3282,3412,3412,3414,3544,3544,3546,3546,3676,3676,3678,3808,3808,3938,3940,3940,4070,4072,4074,4202,4204,4334,4336,4338,4468,4470,4600,4600,4730,4732,4736,4738,4868,4870,5000,5002,5132,5136,5266,5268,5398,5402,5532,5536,5666,5670,5800,5804,5934,5938,6070,6072,6204,6208,6340,6342,6346,6478,6482,6486,6618,6622,6626,6630,6762,6766,6770,6774,6778,6656,6660,6664,6668,6672,6676,6552,6556,6560,6564,6440,6444,6448,6324,6328,6330,6206,6210,6086,6088,5964,5968,5842,5846,5720,5724,5598,5602,5476,5480,5354,5356,5230,5234,5108,5110,4984,4986,4860,4736,4610,4612,4486,4486,4360,4362,4236,4238,4240,4114,4116,3988,3990,3992,3866,3866,3868,3742,3742,3616,3618,3618,3492,3492,3494,3494,3368,3370,3370,3244,3244,3246,3246,3120,3120,3120,2994,2994,2996,2996,2998,2870,2870,2872,2872,2744,2746,2746,2748,2748,2620,2622,2622,2622,2622,2496,2496,2496,2498,2498,2498,2370,2372,2372,2372,2374,2374,2246,2246,2248,2248,2248,2248,2248,2122,2122,2122,2122,2122,2124
  dc.w    2096,2098,2098,2098,2098,2100,2228,2228,2228,2228,2230,2230,2230,2358,2360,2360,2360,2360,2362,2362,2490,2490,2492,2492,2492,2622,2622,2622,2622,2624,2624,2752,2754,2754,2754,2756,2884,2884,2886,2886,3016,3016,3016,3018,3146,3148,3148,3150,3278,3280,3280,3282,3410,3412,3412,3542,3542,3544,3672,3674,3676,3804,3806,3806,3936,3938,4066,4068,4070,4200,4200,4330,4332,4334,4464,4466,4596,4596,4726,4728,4858,4860,4864,4866,4996,4998,5128,5130,5260,5264,5394,5396,5528,5530,5662,5792,5796,5926,5930,6060,6064,6196,6198,6330,6334,6466,6470,6474,6606,6610,6742,6746,6750,6882,6886,6890,6894,6898,6902,6906,6784,6788,6792,6796,6800,6804,6808,6812,6688,6692,6696,6572,6576,6452,6456,6460,6336,6340,6216,6218,6094,6098,5972,5976,5850,5854,5728,5604,5606,5482,5484,5358,5362,5236,5238,5112,5114,4988,4864,4738,4740,4614,4616,4490,4490,4364,4366,4240,4242,4244,4118,4118,3992,3994,3996,3868,3870,3744,3744,3746,3618,3620,3622,3494,3496,3496,3370,3370,3372,3244,3246,3246,3248,3120,3122,3122,3124,2996,2998,2998,2998,2872,2872,2874,2874,2746,2748,2748,2748,2750,2622,2622,2624,2624,2624,2624,2498,2498,2498,2500,2500,2372,2372,2374,2374,2374,2374,2376,2248,2248,2248,2250,2250,2250,2250,2122,2124,2124,2124,2124
  dc.w    2096,2096,2096,2096,2098,2098,2226,2226,2228,2228,2228,2228,2228,2358,2358,2358,2358,2360,2360,2488,2488,2490,2490,2490,2490,2620,2620,2620,2622,2622,2750,2752,2752,2752,2754,2882,2882,2884,2884,2884,3014,3014,3016,3016,3144,3146,3146,3276,3276,3278,3278,3408,3408,3410,3538,3540,3540,3670,3670,3672,3802,3802,3804,3932,3934,3936,4064,4066,4196,4198,4198,4328,4330,4460,4462,4592,4592,4722,4724,4854,4856,4986,4988,4992,4994,5124,5126,5256,5258,5390,5392,5522,5654,5656,5788,5790,5922,6052,6056,6186,6190,6322,6326,6456,6460,6592,6596,6728,6732,6864,6868,6872,7004,7008,7012,7018,7150,7154,7158,7162,7040,7044,7048,7052,7056,6932,6938,6942,6946,6822,6826,6830,6706,6710,6586,6590,6466,6470,6344,6348,6224,6228,6102,6106,5980,5856,5858,5734,5736,5612,5486,5488,5364,5366,5240,5242,5116,4992,4866,4868,4742,4744,4618,4620,4494,4494,4368,4370,4244,4246,4120,4120,4122,3996,3998,3870,3872,3874,3746,3748,3748,3622,3624,3624,3498,3498,3500,3372,3374,3374,3248,3248,3250,3250,3124,3124,3126,2998,2998,3000,3000,2874,2874,2874,2876,2876,2748,2750,2750,2750,2752,2624,2624,2626,2626,2626,2500,2500,2500,2500,2502,2502,2374,2374,2376,2376,2376,2376,2250,2250,2250,2250,2250,2252,2252,2124,2124,2126,2126,2126
  dc.w    2094,2094,2096,2096,2096,2096,2224,2226,2226,2226,2226,2226,2228,2356,2356,2356,2358,2358,2358,2486,2488,2488,2488,2488,2490,2618,2618,2620,2620,2620,2750,2750,2750,2750,2752,2880,2880,2882,2882,3012,3012,3012,3014,3142,3144,3144,3144,3274,3274,3276,3404,3406,3406,3408,3536,3538,3538,3668,3668,3670,3800,3800,3930,3930,3932,4062,4062,4064,4194,4196,4324,4326,4456,4458,4588,4588,4718,4720,4850,4852,4982,4984,5114,5116,5120,5122,5252,5254,5384,5516,5518,5648,5652,5782,5914,5916,6048,6050,6182,6312,6316,6448,6452,6584,6586,6718,6850,6854,6858,6990,6994,7128,7132,7136,7268,7272,7276,7282,7286,7290,7168,7172,7176,7180,7186,7190,7194,7070,7074,7078,6956,6960,6836,6840,6844,6720,6596,6598,6474,6478,6354,6358,6232,6108,6110,5986,5988,5864,5738,5742,5616,5618,5494,5368,5370,5244,5120,4994,4996,4870,4872,4746,4748,4622,4624,4498,4498,4372,4374,4248,4250,4122,4124,3998,4000,4000,3874,3876,3876,3750,3750,3624,3626,3626,3500,3500,3502,3374,3376,3376,3378,3250,3252,3252,3126,3126,3126,3128,3000,3002,3002,3002,2876,2876,2878,2878,2750,2752,2752,2752,2752,2626,2626,2626,2628,2628,2500,2502,2502,2502,2502,2504,2376,2376,2376,2378,2378,2378,2250,2252,2252,2252,2252,2252,2254,2126,2126,2126,2126,2128
  dc.w    2094,2094,2094,2094,2094,2224,2224,2224,2224,2224,2226,2226,2354,2354,2354,2356,2356,2356,2356,2486,2486,2486,2486,2488,2616,2616,2618,2618,2618,2746,2748,2748,2748,2750,2878,2878,2880,2880,2880,3010,3010,3010,3012,3140,3142,3142,3272,3272,3272,3274,3402,3404,3404,3534,3534,3536,3664,3666,3666,3796,3798,3798,3928,3928,4058,4060,4060,4190,4192,4322,4322,4452,4454,4456,4586,4586,4716,4718,4848,4850,4980,5110,5112,5242,5244,5248,5250,5380,5510,5512,5644,5774,5778,5908,5910,6042,6174,6176,6308,6438,6442,6574,6706,6710,6842,6846,6976,6982,7114,7118,7250,7254,7386,7390,7396,7400,7532,7538,7542,7546,7424,7428,7432,7436,7442,7318,7322,7328,7332,7208,7212,7088,7092,6968,6974,6848,6852,6728,6732,6608,6484,6488,6362,6238,6240,6116,5992,5994,5868,5872,5746,5622,5624,5498,5372,5248,5122,5124,4998,5000,4874,4748,4750,4624,4626,4500,4500,4374,4376,4378,4252,4252,4126,4128,4002,4002,4004,3878,3878,3752,3752,3754,3628,3628,3630,3502,3504,3504,3378,3378,3380,3252,3254,3254,3254,3128,3128,3130,3002,3004,3004,3004,2878,2878,2878,2880,2880,2752,2754,2754,2754,2756,2628,2628,2628,2630,2630,2502,2504,2504,2504,2504,2378,2378,2378,2378,2380,2380,2380,2252,2252,2254,2254,2254,2254,2254,2128,2128,2128,2128
  dc.w    2092,2092,2092,2094,2094,2222,2222,2222,2224,2224,2224,2224,2352,2354,2354,2354,2354,2354,2484,2484,2484,2484,2486,2486,2614,2616,2616,2616,2616,2746,2746,2746,2748,2748,2876,2878,2878,2878,3008,3008,3008,3010,3138,3138,3140,3140,3270,3270,3270,3400,3400,3402,3402,3532,3532,3534,3662,3664,3664,3794,3796,3924,3926,3926,4056,4058,4186,4188,4190,4318,4320,4450,4452,4582,4582,4712,4714,4844,4846,4976,5106,5108,5238,5240,5370,5372,5376,5506,5508,5638,5770,5772,5902,6034,6036,6168,6298,6302,6434,6564,6568,6700,6832,6836,6968,7100,7104,7236,7240,7372,7376,7508,7514,7518,7650,7656,7660,7792,7798,7802,7680,7684,7688,7694,7570,7574,7580,7456,7460,7466,7342,7346,7222,7226,7102,7106,6982,6858,6862,6738,6614,6618,6492,6368,6372,6246,6122,6124,6000,5874,5876,5752,5626,5628,5376,5250,5252,5126,5128,5002,5004,4878,4752,4754,4628,4630,4504,4504,4378,4380,4254,4256,4128,4130,4132,4004,4006,3880,3880,3882,3754,3756,3630,3630,3632,3504,3506,3506,3380,3380,3382,3382,3256,3256,3256,3130,3130,3132,3132,3004,3006,3006,3006,2880,2880,2880,2882,2754,2754,2756,2756,2756,2630,2630,2630,2630,2632,2504,2504,2506,2506,2506,2506,2380,2380,2380,2380,2380,2382,2254,2254,2254,2254,2256,2256,2256,2128,2128,2130,2130
  dc.w    2090,2092,2092,2092,2092,2220,2220,2222,2222,2222,2222,2222,2352,2352,2352,2352,2354,2354,2482,2482,2482,2484,2484,2484,2612,2614,2614,2614,2616,2744,2744,2744,2746,2874,2874,2876,2876,2876,3006,3006,3006,3008,3136,3136,3138,3138,3268,3268,3270,3398,3398,3400,3528,3530,3530,3660,3660,3662,3790,3792,3792,3922,3924,4052,4054,4056,4184,4186,4316,4316,4446,4448,4578,4578,4708,4710,4840,4842,4972,4974,5104,5234,5236,5366,5368,5498,5628,5504,5634,5764,5766,5898,6028,6160,6162,6294,6424,6428,6560,6690,6822,6826,6958,7090,7094,7226,7358,7362,7494,7498,7632,7636,7768,7772,7906,7910,7916,7920,7926,8058,7936,7940,7816,7822,7826,7832,7836,7714,7718,7594,7598,7476,7480,7356,7360,7236,7112,7116,6992,6868,6872,6748,6622,6498,6502,6376,6252,6254,6130,6004,5880,5882,5756,5504,5506,5380,5254,5256,5130,5132,5006,4880,4882,4756,4758,4632,4634,4508,4508,4382,4384,4258,4258,4132,4134,4006,4008,4010,3882,3884,3758,3758,3760,3632,3634,3634,3508,3508,3510,3382,3384,3384,3256,3258,3258,3132,3132,3134,3134,3006,3008,3008,3008,2882,2882,2882,2884,2884,2756,2758,2758,2758,2630,2632,2632,2632,2634,2506,2506,2506,2508,2508,2508,2380,2380,2382,2382,2382,2382,2256,2256,2256,2256,2256,2258,2258,2130,2130,2130,2130
  dc.w    2090,2090,2090,2090,2218,2220,2220,2220,2220,2220,2222,2350,2350,2350,2350,2352,2352,2352,2480,2482,2482,2482,2482,2610,2612,2612,2612,2614,2742,2742,2742,2744,2744,2872,2874,2874,2874,3002,3004,3004,3006,3134,3134,3136,3136,3264,3266,3266,3268,3396,3396,3398,3526,3528,3528,3658,3658,3660,3788,3790,3918,3920,3922,4050,4052,4180,4182,4312,4312,4442,4444,4446,4574,4704,4706,4836,4838,4968,4970,5100,5100,5230,5362,5364,5494,5624,5626,5756,5760,5762,5892,6024,6154,6156,6288,6418,6550,6554,6684,6816,6948,7080,7084,7216,7348,7352,7484,7616,7620,7754,7886,7890,8024,8028,8032,8166,8170,8176,8180,8186, 0,8068,8074,8078,8084,8088,7966,7970,7974,7852,7856,7732,7610,7614,7490,7366,7370,7246,7122,7126,7002,6878,6754,6628,6632,6508,6382,6258,6260,6134,6010,5884,5760,5634,5508,5510,5384,5258,5260,5136,5010,5010,4884,4886,4760,4762,4636,4638,4512,4384,4386,4388,4262,4262,4136,4138,4010,4012,3884,3886,3888,3760,3762,3634,3636,3636,3510,3510,3512,3384,3386,3386,3258,3260,3260,3262,3134,3134,3136,3136,3008,3010,3010,3012,2884,2884,2884,2886,2758,2758,2760,2760,2760,2632,2634,2634,2634,2636,2508,2508,2508,2508,2510,2382,2382,2382,2384,2384,2384,2384,2256,2258,2258,2258,2258,2258,2260,2132,2132,2132
  dc.w    2088,2088,2088,2090,2218,2218,2218,2218,2220,2220,2220,2348,2348,2348,2350,2350,2350,2478,2480,2480,2480,2480,2480,2610,2610,2610,2610,2612,2740,2740,2742,2742,2742,2870,2872,2872,2872,3002,3002,3002,3004,3132,3132,3134,3134,3262,3264,3264,3394,3394,3394,3524,3524,3526,3654,3656,3656,3786,3786,3788,3916,3918,4046,4048,4050,4178,4180,4310,4310,4440,4442,4570,4572,4702,4704,4834,4964,4964,5094,5096,5226,5356,5358,5488,5618,5622,5752,5882,5884,5888,6018,6148,6280,6282,6414,6544,6676,6806,6810,6942,7074,7206,7338,7342,7474,7606,7738,7742,7874,8008,8012,8144,8150,90,96,228,234,240,244,378,256,260,138,142,148,154,30,36,8104,8110,7986,7990,7868,7744,7748,7624,7500,7376,7380,7256,7132,7008,6884,6888,6762,6638,6512,6388,6390,6266,6140,5888,5762,5764,5638,5512,5516,5390,5264,5266,5140,5014,5016,4890,4890,4764,4638,4640,4514,4516,4388,4390,4264,4264,4138,4140,4012,4014,4016,3888,3890,3762,3764,3764,3638,3638,3640,3512,3514,3514,3388,3388,3388,3262,3262,3264,3136,3136,3138,3138,3010,3012,3012,3012,2886,2886,2886,2888,2760,2760,2760,2762,2762,2634,2636,2636,2636,2636,2510,2510,2510,2510,2510,2512,2384,2384,2384,2386,2386,2386,2258,2258,2258,2260,2260,2260,2260,2132,2134,2134
  dc.w    2086,2088,2088,2088,2216,2216,2216,2218,2218,2218,2218,2346,2348,2348,2348,2348,2348,2478,2478,2478,2478,2478,2480,2608,2608,2608,2610,2610,2738,2738,2740,2740,2868,2870,2870,2870,2870,3000,3000,3000,3002,3130,3130,3132,3260,3262,3262,3262,3392,3392,3392,3522,3522,3524,3652,3654,3654,3784,3784,3914,3914,3916,4044,4046,4176,4176,4306,4306,4436,4438,4568,4568,4698,4700,4830,4830,4960,5090,5092,5222,5224,5354,5484,5486,5616,5746,5876,5880,6010,6140,6144,6274,6276,6408,6538,6670,6802,6932,7064,7068,7200,7330,7462,7594,7728,7860,7864,7996,8128,70,74,208,212,346,350,484,490,494,628,634,512,516,522,400,404,410,288,292,170,174,52,56,8126,8002,7878,7882,7758,7636,7512,7388,7262,7138,7142,7018,6892,6768,6644,6518,6394,6396,6144,6018,5892,5766,5770,5644,5518,5392,5394,5268,5142,5144,5018,5020,4894,4768,4768,4642,4644,4518,4518,4392,4394,4268,4268,4142,4142,4016,4018,3890,3892,3892,3766,3766,3640,3640,3642,3514,3516,3516,3390,3390,3390,3264,3264,3264,3266,3138,3140,3140,3012,3014,3014,3014,2888,2888,2888,2888,2890,2762,2762,2764,2764,2636,2636,2638,2638,2638,2510,2512,2512,2512,2512,2512,2386,2386,2386,2386,2386,2388,2260,2260,2260,2260,2262,2262,2262,2134,2134,2134
  dc.w    2086,2086,2086,2086,2214,2216,2216,2216,2216,2216,2346,2346,2346,2346,2346,2346,2348,2476,2476,2476,2478,2478,2606,2606,2606,2608,2608,2736,2736,2738,2738,2738,2866,2868,2868,2868,2998,2998,2998,3000,3128,3128,3130,3130,3258,3260,3260,3388,3390,3390,3520,3520,3520,3650,3650,3652,3780,3782,3782,3912,3912,4042,4042,4172,4172,4174,4304,4304,4434,4436,4564,4566,4696,4826,4826,4956,4958,5088,5218,5220,5350,5480,5482,5612,5742,5872,5874,6004,6134,6266,6396,6272,6402,6532,6664,6796,6926,7058,7190,7320,7452,7584,7716,7720,7852,7986,8118,58,192,324,328,462,596,600,734,740,744,878,884,890,768,772,778,784,662,666,672,550,554,432,310,314,190,68,8136,8012,7890,7766,7770,7646,7522,7398,7272,7148,7024,6898,6774,6650,6524,6272,6274,6148,6024,5898,5772,5774,5648,5522,5396,5398,5272,5146,5148,5022,4896,4898,4772,4772,4646,4520,4522,4394,4396,4270,4270,4144,4146,4146,4020,4020,3894,3894,3768,3768,3770,3642,3644,3644,3518,3518,3518,3392,3392,3394,3266,3266,3268,3140,3140,3142,3142,3014,3016,3016,3016,2890,2890,2890,2892,2764,2764,2764,2766,2766,2638,2638,2640,2640,2640,2512,2512,2514,2514,2514,2386,2388,2388,2388,2388,2388,2388,2262,2262,2262,2262,2262,2264,2136,2136,2136
  dc.w    2084,2084,2084,2214,2214,2214,2214,2214,2214,2216,2344,2344,2344,2344,2346,2346,2474,2474,2474,2476,2476,2476,2604,2604,2606,2606,2606,2734,2736,2736,2736,2736,2866,2866,2866,2866,2996,2996,2996,2998,3126,3126,3128,3128,3256,3258,3258,3386,3388,3388,3518,3518,3518,3648,3648,3650,3778,3780,3908,3910,3910,4040,4040,4170,4170,4300,4300,4430,4432,4560,4562,4692,4694,4822,4952,4954,5084,5086,5214,5344,5346,5476,5606,5736,5738,5868,6000,6130,6260,6390,6394,6524,6528,6658,6790,6920,7052,7182,7314,7446,7578,7710,7842,7974,8106,46,180,312,446,578,584,716,850,856,988,1122,1128,1134,1140,1274,1152,1156,1034,1040,1046,1052,930,806,812,690,566,572,448,326,202,80,8148,8024,7900,7776,7652,7528,7404,7280,7154,7030,6904,6780,6528,6402,6276,6280,6154,6028,5902,5778,5652,5654,5528,5402,5276,5278,5152,5024,5026,4900,4902,4776,4648,4650,4524,4526,4398,4400,4274,4274,4148,4148,4022,4022,3896,3896,3898,3770,3772,3644,3646,3646,3520,3520,3520,3394,3394,3396,3268,3268,3270,3142,3142,3144,3144,3016,3018,3018,3018,2892,2892,2892,2892,2766,2766,2766,2766,2768,2640,2640,2640,2642,2642,2514,2514,2514,2516,2516,2516,2388,2388,2390,2390,2390,2390,2262,2264,2264,2264,2264,2264,2264,2138,2138
  dc.w    2084,2084,2084,2212,2212,2212,2212,2214,2214,2214,2342,2342,2342,2344,2344,2344,2472,2472,2474,2474,2474,2474,2602,2604,2604,2604,2604,2734,2734,2734,2734,2864,2864,2864,2864,2866,2994,2994,2994,2996,3124,3124,3126,3254,3254,3256,3256,3384,3386,3386,3514,3516,3516,3646,3646,3776,3776,3776,3906,3906,4036,4036,4166,4168,4168,4298,4298,4428,4430,4558,4688,4690,4818,4820,4950,5080,5080,5210,5340,5342,5472,5602,5604,5734,5864,5994,6124,6254,6258,6388,6518,6650,6780,6784,6914,7046,7176,7308,7440,7572,7704,7964,8096,36,168,300,434,566,698,832,966,970,1104,1238,1372,1378,1512,1516,1522,1528,1408,1414,1420,1426,1430,1308,1314,1192,1070,948,952,830,708,584,460,338,214,90,8158,8034,7782,7658,7534,7410,7286,7160,7036,6784,6658,6532,6408,6282,6156,6160,6034,5908,5782,5656,5530,5532,5406,5280,5282,5156,5030,5030,4904,4778,4780,4652,4654,4528,4400,4402,4276,4276,4150,4150,4152,4026,4026,3900,3900,3774,3774,3774,3648,3648,3522,3522,3524,3396,3396,3398,3270,3270,3272,3272,3144,3146,3146,3018,3020,3020,3020,2892,2894,2894,2894,2894,2768,2768,2768,2768,2642,2642,2642,2642,2644,2516,2516,2516,2516,2518,2518,2390,2390,2390,2392,2392,2392,2264,2264,2264,2266,2266,2266,2266,2138,2138
  dc.w    2082,2082,2082,2210,2210,2212,2212,2212,2212,2212,2340,2342,2342,2342,2342,2342,2470,2472,2472,2472,2472,2600,2602,2602,2602,2602,2602,2732,2732,2732,2732,2862,2862,2862,2862,2992,2992,2992,2994,3122,3122,3122,3124,3252,3252,3254,3382,3382,3384,3512,3512,3514,3642,3644,3644,3774,3774,3902,3904,3904,4034,4034,4164,4164,4294,4294,4424,4426,4554,4556,4686,4686,4816,4946,4946,5076,5206,5208,5338,5468,5468,5598,5728,5858,5988,5992,6122,6252,6382,6512,6644,6774,6904,7036,7040,7170,7302,7432,7692,7824,7956,8088,28,160,422,554,686,820,952,1086,1220,1352,1486,1620,1626,1760,1766,1900,1906,1912,1792,1798,1804,1810,1688,1694,1572,1578,1456,1334,1210,1088,966,842,720,596,472,222,98,8166,8042,7918,7794,7542,7416,7292,7040,6914,6790,6664,6538,6414,6288,6162,6036,5910,5914,5788,5662,5536,5410,5410,5284,5158,5160,5034,4908,4908,4782,4656,4656,4530,4532,4404,4406,4280,4280,4154,4154,4028,4028,3902,3902,3904,3776,3776,3650,3650,3652,3524,3526,3526,3398,3400,3400,3272,3274,3274,3146,3148,3148,3148,3020,3022,3022,3022,2896,2896,2896,2896,2770,2770,2770,2770,2644,2644,2644,2644,2644,2646,2518,2518,2518,2518,2520,2392,2392,2392,2392,2392,2394,2266,2266,2266,2266,2266,2268,2268,2140,2140
  dc.w    2080,2080,2082,2210,2210,2210,2210,2210,2210,2212,2340,2340,2340,2340,2340,2342,2470,2470,2470,2470,2470,2600,2600,2600,2600,2600,2730,2730,2730,2730,2732,2860,2860,2860,2862,2990,2990,2990,2992,3120,3120,3120,3250,3250,3250,3252,3380,3380,3382,3510,3510,3512,3640,3642,3770,3770,3772,3900,3902,4030,4032,4032,4162,4162,4292,4292,4422,4422,4552,4682,4682,4812,4814,4942,5072,5074,5204,5332,5334,5464,5594,5724,5854,5856,5986,6116,6246,6376,6508,6638,6768,6898,7030,7160,7292,7296,7554,7686,7818,7950,8082,150,282,414,546,806,940,1072,1206,1340,1600,1734,1868,1874,2008,2142,2150,2284,2290,2296,2176,2182,2188,2194,2072,2080,1958,1836,1842,1720,1598,1346,1224,1102,978,856,604,480,356,232,8172,8048,7924,7800,7676,7296,7170,7046,6920,6796,6670,6544,6418,6294,6168,6042,5916,5790,5792,5666,5540,5414,5288,5290,5162,5036,5038,4912,4784,4786,4660,4660,4534,4408,4408,4282,4282,4156,4156,4030,4030,4032,3904,3906,3778,3780,3780,3652,3654,3526,3528,3528,3400,3402,3402,3274,3276,3276,3276,3150,3150,3150,3022,3024,3024,3024,2896,2898,2898,2898,2770,2772,2772,2772,2772,2646,2646,2646,2646,2646,2520,2520,2520,2520,2520,2392,2394,2394,2394,2394,2394,2266,2268,2268,2268,2268,2268,2268,2140,2142
  dc.w    2080,2080,2208,2208,2208,2208,2208,2210,2210,2338,2338,2338,2338,2338,2340,2468,2468,2468,2468,2470,2470,2598,2598,2598,2598,2600,2728,2728,2728,2730,2730,2858,2858,2858,2860,2988,2988,2988,2990,3118,3118,3120,3248,3248,3248,3378,3378,3378,3380,3508,3508,3638,3638,3640,3768,3768,3770,3898,3900,4028,4030,4158,4158,4288,4288,4418,4420,4548,4550,4678,4680,4810,4938,4940,5070,5198,5200,5330,5460,5590,5592,5720,5850,5980,6110,6240,6372,6502,6632,6762,6892,7024,7154,7286,7416,7676,7680,7810,7942,10,142,274,534,666,928,1060,1192,1454,1588,1720,1854,1988,2122,2256,2392,2526,2660,2666,2802,2808,2688,2694,2700,2580,2586,2464,2342,2222,2100,1978,1856,1734,1610,1488,1238,1114,990,740,616,364,240,116,8056,7932,7680,7554,7302,7176,7052,6926,6802,6676,6550,6424,6298,6174,6048,5922,5796,5670,5542,5544,5418,5292,5166,5168,5040,4914,4916,4788,4662,4664,4536,4538,4410,4412,4286,4286,4160,4160,4032,4034,3906,3908,3780,3782,3782,3654,3656,3656,3530,3530,3402,3404,3404,3404,3278,3278,3278,3150,3152,3152,3024,3026,3026,3026,2898,2900,2900,2900,2772,2772,2774,2774,2774,2646,2648,2648,2648,2648,2520,2520,2522,2522,2522,2522,2394,2396,2396,2396,2396,2396,2268,2268,2270,2270,2270,2270,2270,2142
  dc.w    2078,2078,2206,2206,2206,2208,2208,2208,2208,2336,2336,2336,2338,2338,2338,2466,2466,2466,2468,2468,2468,2596,2596,2596,2598,2598,2726,2726,2726,2728,2856,2856,2856,2858,2986,2986,2986,2988,3116,3116,3116,3118,3246,3246,3246,3376,3376,3376,3506,3506,3506,3636,3636,3636,3766,3766,3896,3896,3896,4026,4026,4156,4156,4286,4286,4416,4416,4546,4674,4676,4806,4806,4936,5066,5066,5196,5326,5328,5456,5586,5716,5846,5976,6106,6108,6238,6368,6498,6628,6888,7018,7148,7280,7410,7542,7800,7932,7936, 2,134,394,526,786,920,1180,1312,1574,1708,1840,2102,2236,2370,2632,2766,2902,3036,3042,3178,3184,3192,3200,3078,3086,3092,2972,2978,2856,2736,2614,2364,2242,2120,1870,1746,1624,1374,1250,998,876,624,500,248,124,7936,7810,7686,7432,7308,7182,7058,6932,6806,6554,6428,6302,6176,6050,6052,5926,5800,5674,5548,5422,5294,5296,5170,5044,5044,4918,4792,4792,4666,4668,4540,4414,4414,4288,4288,4162,4162,4036,4036,3910,3910,3910,3784,3784,3658,3658,3658,3532,3532,3532,3406,3406,3406,3280,3280,3280,3152,3154,3154,3154,3026,3028,3028,3028,2900,2902,2902,2902,2774,2776,2776,2776,2648,2648,2650,2650,2650,2522,2522,2522,2524,2524,2524,2396,2396,2396,2398,2398,2398,2270,2270,2270,2270,2272,2272,2272,2144
  dc.w    2076,2076,2206,2206,2206,2206,2206,2206,2206,2334,2336,2336,2336,2336,2336,2464,2464,2466,2466,2466,2594,2594,2594,2596,2596,2724,2724,2724,2726,2726,2854,2854,2854,2856,2984,2984,2984,2986,3114,3114,3114,3116,3244,3244,3244,3374,3374,3374,3504,3504,3504,3634,3634,3762,3764,3764,3892,3894,4022,4024,4152,4154,4282,4284,4412,4414,4542,4544,4672,4674,4802,4932,4934,5062,5192,5194,5322,5452,5582,5712,5712,5842,5972,6102,6232,6362,6492,6622,6754,6884,7142,7272,7404,7534,7794,7924,8056,124,128,386,518,778,1040,1172,1432,1566,1826,2088,2222,2484,2618,2880,3014,3148,3284,3418,3554,3688,3696,3704,3712,3590,3598,3606,3484,3364,3242,3122,3000,2878,2628,2506,2256,2134,1884,1632,1510,1258,1134,884,632,508,128, 2,7942,7818,7692,7440,7314,7190,7064,6810,6684,6560,6434,6308,6182,6056,5930,5804,5678,5678,5552,5426,5300,5172,5174,5048,4920,4922,4796,4668,4670,4542,4544,4416,4418,4290,4292,4164,4166,4038,4040,3912,3914,3786,3786,3788,3660,3660,3534,3534,3534,3408,3408,3408,3282,3282,3282,3154,3156,3156,3156,3028,3030,3030,3030,2902,2904,2904,2904,2776,2776,2778,2778,2778,2650,2650,2652,2652,2652,2524,2524,2524,2526,2526,2398,2398,2398,2398,2398,2400,2272,2272,2272,2272,2272,2272,2272,2146
  dc.w    2076,2076,2204,2204,2204,2204,2204,2204,2206,2334,2334,2334,2334,2334,2334,2464,2464,2464,2464,2464,2592,2594,2594,2594,2594,2722,2722,2724,2724,2724,2852,2852,2854,2854,2982,2982,2982,2984,3112,3112,3112,3242,3242,3242,3242,3372,3372,3372,3502,3502,3630,3632,3632,3760,3762,3762,3890,3892,4020,4022,4150,4150,4280,4280,4410,4410,4540,4540,4670,4798,4800,4928,5058,5060,5188,5318,5448,5450,5578,5708,5838,5968,6098,6228,6358,6488,6618,6748,6878,7008,7138,7398,7528,7658,7918,8048,116,248,508,512,770,1032,1292,1424,1684,1946,2208,2340,2602,2864,3126,3262,3524,3658,3794,3928,4064,4200,4336,4344,4224,4230,4238,4118,3998,3878,3756,3636,3514,3264,3144,2894,2644,2394,2270,2020,1770,1518,1394,1142,892,512,386,134,10,7950,7824,7572,7446,7320,7068,6942,6816,6690,6564,6438,6312,6186,6060,5934,5808,5682,5556,5428,5430,5304,5178,5050,5052,4926,4798,4800,4672,4546,4546,4420,4420,4294,4294,4168,4168,4040,4042,3914,3916,3788,3788,3790,3662,3662,3664,3536,3536,3410,3410,3410,3284,3284,3284,3284,3158,3158,3158,3030,3032,3032,3032,2904,2904,2906,2906,2778,2778,2778,2780,2780,2652,2652,2652,2652,2654,2526,2526,2526,2526,2526,2400,2400,2400,2400,2400,2400,2272,2274,2274,2274,2274,2274,2274,2146
  dc.w    2074,2074,2202,2202,2202,2204,2204,2204,2332,2332,2332,2332,2332,2334,2334,2462,2462,2462,2462,2462,2592,2592,2592,2592,2592,2720,2722,2722,2722,2722,2850,2852,2852,2852,2980,2980,2982,2982,3110,3110,3110,3240,3240,3240,3368,3370,3370,3498,3500,3500,3628,3628,3630,3758,3758,3888,3888,3890,4018,4018,4148,4148,4278,4278,4406,4408,4536,4666,4666,4796,4926,4926,5056,5184,5186,5316,5444,5574,5704,5704,5834,5964,6094,6224,6354,6484,6614,6872,7002,7132,7262,7522,7652,7782,8042,8172,240,500,632,892,1024,1284,1544,1804,1938,2198,2460,2722,2982,3246,3508,3770,4032,4168,4432,4568,4702,4838,4846,4982,4864,4872,4752,4760,4640,4518,4398,4150,4030,3780,3530,3280,3032,2780,2530,2280,2028,1906,1654,1402,1024,770,518,394,142,8082,7956,7704,7578,7452,7200,7074,6948,6822,6568,6442,6316,6190,6064,5938,5812,5686,5686,5560,5434,5306,5180,5182,5054,4928,4928,4802,4676,4676,4550,4422,4424,4296,4296,4170,4170,4044,4044,3916,3918,3918,3792,3792,3664,3666,3666,3538,3538,3540,3412,3412,3414,3286,3286,3286,3160,3160,3160,3032,3032,3034,3034,2906,2906,2906,2908,2780,2780,2780,2780,2782,2654,2654,2654,2654,2654,2528,2528,2528,2528,2528,2400,2400,2402,2402,2402,2402,2402,2274,2274,2274,2276,2276,2276,2148
  dc.w    2072,2072,2202,2202,2202,2202,2202,2202,2330,2330,2330,2332,2332,2332,2460,2460,2460,2460,2462,2462,2590,2590,2590,2590,2590,2720,2720,2720,2720,2848,2848,2850,2850,2850,2978,2978,2980,3108,3108,3108,3110,3238,3238,3238,3366,3368,3368,3496,3498,3498,3626,3626,3756,3756,3756,3886,3886,4014,4016,4144,4144,4274,4274,4404,4404,4534,4534,4664,4664,4794,4922,4924,5052,5182,5310,5312,5442,5570,5700,5830,5960,6088,6218,6348,6478,6608,6738,6868,7126,7256,7388,7646,7776,8034,8166,232,364,624,884,1142,1402,1536,1796,2056,2316,2578,2840,3102,3492,3754,4016,4278,4542,4806,4942,5206,5342,5478,5614,5622,5504,5512,5520,5400,5280,5160,4912,4792,4544,4296,4046,3796,3546,3168,2918,2668,2418,2166,1914,1536,1284,1032,778,526,274,150,8088,7964,7710,7584,7330,7206,7080,6826,6700,6574,6448,6322,6196,6070,5942,5816,5690,5564,5436,5310,5312,5184,5058,4930,4932,4804,4678,4678,4552,4552,4426,4426,4300,4300,4174,4174,4046,4048,3920,3920,3794,3794,3794,3668,3668,3540,3540,3542,3414,3414,3416,3288,3288,3288,3160,3162,3162,3162,3034,3036,3036,2908,2908,2908,2910,2910,2782,2782,2782,2782,2656,2656,2656,2656,2656,2528,2528,2530,2530,2530,2530,2402,2402,2402,2404,2404,2404,2276,2276,2276,2276,2276,2276,2150
  dc.w    2072,2200,2200,2200,2200,2200,2200,2200,2328,2330,2330,2330,2330,2330,2458,2458,2458,2460,2460,2460,2588,2588,2588,2588,2590,2718,2718,2718,2718,2846,2848,2848,2848,2976,2976,2978,2978,3106,3106,3106,3108,3236,3236,3236,3364,3366,3366,3494,3494,3496,3624,3624,3754,3754,3754,3884,3884,4012,4014,4142,4142,4272,4272,4400,4402,4530,4532,4660,4790,4790,4920,5048,5050,5178,5308,5438,5566,5568,5696,5826,5956,6086,6216,6344,6474,6732,6862,6992,7122,7380,7512,7770,7900,8158,98,356,616,876,1134,1394,1654,1914,2048,2308,2696,2958,3220,3610,3872,4262,4524,4788,5050,5442,5578,5842,6108,6244,6380,6390,6272,6280,6290,6170,6050,5804,5556,5436,5060,4810,4562,4312,3934,3684,3306,3056,2806,2426,2048,1796,1544,1292,1040,786,534,282,28,8096,7842,7716,7462,7338,7084,6958,6832,6706,6452,6326,6198,6072,5946,5820,5694,5566,5568,5440,5314,5188,5060,5062,4934,4808,4808,4682,4554,4556,4428,4430,4302,4302,4176,4176,4048,4050,3922,3922,3796,3796,3796,3670,3670,3542,3544,3544,3416,3416,3418,3290,3290,3290,3162,3164,3164,3164,3036,3036,3038,3038,2910,2910,2910,2912,2784,2784,2784,2784,2656,2658,2658,2658,2658,2530,2530,2530,2532,2532,2532,2404,2404,2404,2404,2404,2406,2278,2278,2278,2278,2278,2278,2278
  dc.w    2070,2198,2198,2198,2198,2198,2200,2200,2328,2328,2328,2328,2328,2328,2456,2458,2458,2458,2458,2458,2586,2586,2586,2588,2716,2716,2716,2716,2716,2846,2846,2846,2846,2974,2974,2976,2976,3104,3104,3104,3234,3234,3234,3234,3362,3364,3364,3492,3492,3622,3622,3622,3750,3752,3880,3880,3882,4010,4010,4140,4140,4268,4270,4398,4400,4528,4656,4658,4786,4916,4916,5046,5174,5176,5304,5434,5564,5692,5822,5952,6080,6210,6340,6470,6598,6728,6858,7116,7246,7376,7636,7766,8024,90,222,480,740,998,1258,1518,1906,2166,2426,2688,2948,3338,3598,3988,4378,4770,5032,5424,5816,6080,6344,6608,6874,7010,7148,7286,7168,7176,7058,6940,6820,6574,6326,6078,5830,5454,5078,4828,4452,4074,3696,3444,3066,2688,2308,2056,1804,1424,1172,920,666,414,160,36,7974,7720,7594,7342,7216,7090,6836,6710,6584,6456,6330,6204,6078,5950,5824,5698,5570,5444,5318,5190,5192,5064,4938,4938,4812,4684,4686,4558,4430,4432,4304,4306,4178,4178,4052,4052,3924,3926,3926,3798,3800,3672,3672,3672,3546,3546,3418,3418,3420,3292,3292,3292,3292,3166,3166,3166,3038,3038,3040,3040,2912,2912,2912,2912,2786,2786,2786,2786,2786,2658,2660,2660,2660,2532,2532,2532,2532,2532,2534,2406,2406,2406,2406,2406,2406,2278,2278,2280,2280,2280,2280,2280
  dc.w    2068,2196,2196,2198,2198,2198,2198,2198,2326,2326,2326,2326,2326,2328,2456,2456,2456,2456,2456,2584,2584,2586,2586,2586,2714,2714,2714,2714,2716,2844,2844,2844,2844,2972,2972,2974,2974,3102,3102,3102,3232,3232,3232,3360,3360,3362,3490,3490,3490,3620,3620,3620,3748,3750,3878,3878,4006,4008,4008,4136,4138,4266,4394,4396,4524,4526,4654,4654,4784,4912,5042,5042,5172,5300,5430,5430,5560,5690,5818,5948,6078,6206,6336,6466,6596,6852,6982,7112,7370,7500,7758,7890,8148,214,472,604,990,1250,1510,1770,2028,2418,2806,3066,3328,3716,4106,4496,4886,5276,5668,6060,6452,6844,7108,7502,7768,7904,8170,8180, 0,8074,8084,7838,7718,7472,7098,6850,6474,6098,5722,5346,4968,4590,4212,3834,3328,2948,2696,2316,1938,1684,1432,1180,928,546,422,168,8106,7852,7728,7474,7348,7094,6968,6842,6586,6460,6334,6208,6080,5954,5828,5700,5574,5448,5448,5322,5194,5068,5068,4942,4814,4688,4688,4560,4562,4434,4436,4308,4180,4182,4054,4054,4056,3928,3928,3800,3802,3674,3674,3674,3548,3548,3548,3420,3422,3422,3294,3294,3294,3168,3168,3168,3040,3040,3042,3042,2914,2914,2914,2914,2786,2788,2788,2788,2788,2660,2660,2660,2662,2662,2534,2534,2534,2534,2534,2406,2408,2408,2408,2408,2408,2280,2280,2280,2280,2280,2282,2282
  dc.w    2068,2196,2196,2196,2196,2196,2196,2196,2324,2324,2326,2326,2326,2326,2454,2454,2454,2454,2454,2584,2584,2584,2584,2584,2712,2712,2712,2714,2714,2842,2842,2842,2842,2970,2972,2972,3100,3100,3100,3100,3230,3230,3230,3358,3358,3360,3488,3488,3488,3616,3618,3746,3746,3746,3876,3876,4004,4006,4134,4134,4262,4264,4392,4392,4522,4522,4652,4780,4780,4910,5038,5040,5168,5298,5426,5556,5684,5686,5814,5944,6074,6330,6460,6590,6720,6848,7106,7236,7366,7624,7882,8012,80,338,596,856,1114,1374,1632,2020,2280,2668,3056,3444,3834,4096,4484,5002,5394,5912,6304,6822,7216,7608,8000,202,468,734,1002,1140,1024,1034,916,672,426,180,7998,7622,7246,6872,6366,5990,5484,5108,4602,4096,3716,3338,2958,2578,2198,1946,1566,1312,1060,806,554,300,46,7986,7860,7606,7352,7226,7100,6846,6718,6592,6466,6340,6084,5958,5832,5704,5706,5578,5452,5324,5198,5070,5072,4944,4818,4818,4690,4564,4564,4438,4438,4310,4312,4184,4184,4056,4058,3930,3930,3804,3804,3804,3676,3678,3550,3550,3550,3422,3424,3424,3296,3296,3296,3170,3170,3170,3170,3042,3042,3044,2916,2916,2916,2916,2788,2788,2790,2790,2790,2662,2662,2662,2662,2662,2536,2536,2536,2536,2536,2408,2408,2408,2408,2410,2410,2282,2282,2282,2282,2282,2282,2282
  dc.w    2066,2194,2194,2194,2194,2194,2194,2196,2324,2324,2324,2324,2324,2324,2452,2452,2452,2454,2454,2582,2582,2582,2582,2582,2710,2710,2712,2712,2840,2840,2840,2840,2840,2970,2970,2970,3098,3098,3098,3098,3228,3228,3228,3356,3356,3358,3486,3486,3486,3614,3616,3744,3744,3744,3874,3874,4002,4002,4132,4132,4260,4260,4390,4390,4518,4648,4648,4778,4906,4906,5036,5164,5166,5294,5424,5552,5682,5810,5940,6068,6198,6328,6456,6586,6844,6974,7102,7360,7490,7748,7878,8136,202,460,720,978,1238,1624,1884,2270,2530,2918,3306,3696,4212,4602,4992,5510,6028,6546,7066,7586,8106,308,830,1224,1618,2012,2152,2292,2304,2186,2070,1954,1580,1206,832,330,8148,7644,7140,6636,6130,5624,4992,4484,4106,3598,3220,2840,2460,2208,1826,1574,1192,940,686,434,180,8118,7864,7738,7484,7358,7104,6976,6850,6596,6470,6342,6216,6090,5962,5836,5708,5582,5454,5328,5200,5202,5074,4948,4948,4820,4694,4694,4568,4440,4440,4314,4314,4186,4186,4060,4060,3932,3932,3806,3806,3806,3678,3680,3552,3552,3552,3424,3426,3426,3298,3298,3298,3172,3172,3172,3172,3044,3044,3044,2918,2918,2918,2918,2918,2790,2790,2792,2792,2664,2664,2664,2664,2664,2536,2536,2538,2538,2538,2410,2410,2410,2410,2410,2410,2282,2284,2284,2284,2284,2284,2284
  dc.w    2064,2192,2192,2194,2194,2194,2194,2322,2322,2322,2322,2322,2322,2450,2450,2452,2452,2452,2452,2580,2580,2580,2580,2580,2708,2710,2710,2710,2838,2838,2838,2838,2966,2968,2968,2968,3096,3096,3096,3096,3226,3226,3226,3354,3354,3354,3484,3484,3484,3612,3612,3742,3742,3870,3870,3872,4000,4000,4128,4130,4258,4258,4386,4516,4516,4644,4646,4774,4902,4904,5032,5162,5290,5290,5420,5548,5678,5806,5936,6066,6194,6324,6452,6710,6840,6968,7226,7356,7614,7744,8002,68,326,584,842,1102,1488,1746,2134,2394,2780,3168,3684,4074,4590,5108,5624,6016,6534,7180,7700,156,806,1326,1976,2500,2894,3290,3558,3826,3712,3724,3480,3236,2864,2490,1990,1360,856,226,7786,7282,6648,6016,5510,5002,4496,3988,3610,3102,2722,2340,2088,1708,1454,1072,820,566,312,58,7996,7742,7616,7362,7236,6982,6854,6728,6474,6346,6220,6092,5966,5840,5712,5586,5458,5332,5332,5204,5078,4950,4952,4824,4696,4698,4570,4570,4444,4316,4316,4188,4190,4062,4062,3934,3936,3936,3808,3808,3682,3682,3554,3554,3554,3428,3428,3428,3300,3300,3300,3174,3174,3174,3174,3046,3046,3046,3048,2920,2920,2920,2920,2792,2792,2792,2794,2666,2666,2666,2666,2666,2538,2538,2538,2538,2540,2540,2412,2412,2412,2412,2412,2412,2284,2284,2284,2284,2286,2286
  dc.w    2064,2192,2192,2192,2192,2192,2192,2320,2320,2320,2320,2320,2322,2450,2450,2450,2450,2450,2450,2578,2578,2578,2578,2580,2708,2708,2708,2708,2836,2836,2836,2836,2966,2966,2966,2966,3094,3094,3094,3222,3224,3224,3224,3352,3352,3352,3482,3482,3610,3610,3610,3740,3740,3868,3868,3868,3998,3998,4126,4126,4256,4384,4384,4512,4514,4642,4770,4772,4900,5028,5030,5158,5286,5416,5544,5546,5674,5804,5932,6062,6318,6448,6576,6706,6836,7092,7222,7480,7610,7868,8126,190,448,708,966,1224,1610,1870,2256,2644,3032,3546,3934,4452,4968,5484,6130,6648,7168,7814,398,1046,1824,2472,3124,3774,4298,4824,5220,5490,5376,5388,5146,4774,4276,3776,3146,2518,1886,1128,496,7928,7168,6534,6028,5394,4886,4378,3872,3492,2982,2602,2222,1840,1588,1206,952,698,446,192,8128,7874,7620,7494,7240,7114,6858,6732,6606,6478,6352,6096,5970,5842,5716,5588,5590,5462,5336,5208,5080,5082,4954,4826,4828,4700,4572,4574,4446,4446,4318,4192,4192,4064,4064,3938,3938,3938,3810,3810,3684,3684,3684,3556,3556,3430,3430,3430,3302,3302,3302,3304,3176,3176,3176,3048,3048,3048,3048,2922,2922,2922,2922,2794,2794,2794,2794,2666,2668,2668,2668,2668,2540,2540,2540,2540,2540,2540,2412,2414,2414,2414,2414,2414,2286,2286,2286,2286,2286,2286
  dc.w    2062,2190,2190,2190,2190,2190,2190,2318,2318,2320,2320,2320,2320,2448,2448,2448,2448,2448,2448,2576,2576,2578,2578,2578,2706,2706,2706,2706,2834,2834,2834,2836,2964,2964,2964,2964,3092,3092,3092,3220,3222,3222,3222,3350,3350,3478,3480,3480,3608,3608,3608,3736,3738,3866,3866,3994,3994,4124,4124,4252,4252,4382,4382,4510,4510,4640,4768,4768,4896,5026,5154,5154,5284,5412,5542,5670,5798,5928,6056,6186,6314,6444,6572,6830,6960,7088,7346,7476,7732,7990,56,314,572,830,1088,1346,1734,2120,2506,2894,3280,3796,4312,4828,5346,5990,6636,7282,7928,384,1158,2064,2840,3746,4526,5306,5958,6612,7138,7408,7424,7310,7068,6570,5944,5316,4560,3804,2918,2158,1272,384,7814,7180,6546,5912,5276,4770,4262,3754,3246,2864,2484,2102,1720,1340,1086,832,578,324,70,8008,7754,7498,7372,7118,6990,6864,6610,6482,6356,6228,6102,5974,5848,5720,5592,5466,5338,5212,5212,5084,4958,4830,4830,4702,4576,4576,4448,4448,4322,4322,4194,4194,4068,4068,3940,3940,3812,3814,3686,3686,3686,3558,3558,3560,3432,3432,3304,3304,3304,3306,3178,3178,3178,3050,3050,3050,3050,2922,2924,2924,2924,2796,2796,2796,2796,2668,2668,2668,2670,2670,2542,2542,2542,2542,2542,2542,2414,2414,2414,2414,2416,2416,2288,2288,2288,2288,2288,2288
  dc.w    2188,2188,2188,2188,2190,2190,2190,2318,2318,2318,2318,2318,2318,2446,2446,2446,2446,2446,2446,2576,2576,2576,2576,2704,2704,2704,2704,2704,2832,2832,2834,2834,2962,2962,2962,2962,3090,3090,3090,3220,3220,3220,3348,3348,3348,3476,3476,3478,3606,3606,3606,3734,3734,3864,3864,3992,3992,4120,4122,4250,4250,4378,4378,4508,4636,4636,4764,4766,4894,5022,5152,5152,5280,5410,5538,5666,5796,5924,6054,6182,6310,6440,6696,6826,6956,7212,7342,7598,7856,7986,52,310,566,952,1210,1598,1856,2242,2628,3144,3530,4046,4562,5078,5722,6366,7140,7786,496,1272,2048,3080,3986,5020,6054,7092,8000,592,1118,1518,1536,1424,1056,558,7998,7114,6104,5090,4076,3190,2048,1158,398,7700,7066,6304,5668,5032,4524,4016,3508,3126,2618,2236,1854,1600,1220,966,584,328,74,8012,7886,7632,7376,7250,6994,6868,6742,6486,6360,6232,6104,5978,5850,5724,5596,5468,5342,5214,5214,5088,4960,4832,4834,4706,4706,4578,4452,4452,4324,4324,4196,4198,4070,4070,3942,3942,3816,3816,3688,3688,3688,3560,3562,3562,3434,3434,3434,3306,3306,3306,3180,3180,3180,3052,3052,3052,3052,2924,2924,2926,2926,2798,2798,2798,2798,2798,2670,2670,2670,2670,2544,2544,2544,2544,2544,2544,2416,2416,2416,2416,2416,2416,2288,2288,2288,2290,2290,2290
  dc.w    2188,2188,2188,2188,2188,2188,2188,2316,2316,2316,2316,2316,2316,2444,2444,2444,2446,2446,2574,2574,2574,2574,2574,2702,2702,2702,2702,2702,2830,2832,2832,2832,2960,2960,2960,2960,3088,3088,3088,3218,3218,3218,3346,3346,3346,3474,3474,3474,3604,3604,3732,3732,3732,3860,3862,3990,3990,4118,4118,4246,4248,4376,4376,4504,4632,4634,4762,4890,4890,5020,5148,5276,5278,5406,5534,5664,5792,5920,6050,6178,6308,6564,6692,6822,7078,7208,7466,7594,7852,8110,174,432,690,948,1334,1720,1978,2364,2878,3264,3780,4296,4810,5454,6098,6872,7644,226,1128,2158,3190,4096,5384,6548,7840,812,1978,3018,3932,4460,4480,4370,3874,2996,1988,850,7902,6634,5494,4096,3080,2064,1046,156,7586,6822,6060,5424,4788,4278,3770,3262,2880,2370,1988,1734,1352,970,716,462,208,8144,7890,7636,7508,7254,7128,6872,6746,6618,6362,6236,6108,5982,5854,5726,5600,5472,5344,5346,5218,5090,4964,4964,4836,4708,4710,4582,4454,4454,4326,4328,4200,4200,4072,4072,3944,3946,3818,3818,3818,3690,3690,3564,3564,3564,3436,3436,3436,3308,3308,3308,3182,3182,3182,3054,3054,3054,3054,2926,2926,2926,2928,2800,2800,2800,2800,2800,2672,2672,2672,2672,2672,2544,2544,2546,2546,2546,2418,2418,2418,2418,2418,2418,2290,2290,2290,2290,2290,2290
  dc.w    2186,2186,2186,2186,2186,2186,2186,2314,2314,2314,2314,2314,2316,2444,2444,2444,2444,2444,2572,2572,2572,2572,2572,2700,2700,2700,2700,2700,2830,2830,2830,2830,2958,2958,2958,2958,3086,3086,3086,3216,3216,3216,3344,3344,3344,3472,3472,3472,3602,3602,3730,3730,3730,3858,3858,3986,3988,4116,4116,4244,4244,4372,4374,4502,4630,4630,4758,4888,4888,5016,5144,5274,5402,5402,5532,5660,5788,5916,6046,6302,6432,6560,6688,6946,7074,7332,7460,7718,7974,8104,170,554,812,1070,1456,1842,2100,2614,3000,3514,4030,4544,5060,5830,6474,7246,8148,856,1886,2918,4076,5494,6784,10,1558,3236,4660,6084,7256,8042, 0,7956,7206,6074,4682,3290,1640,116,6784,5384,3986,2840,1824,806,8106,7216,6452,5816,5050,4542,4032,3524,3014,2632,2122,1868,1486,1104,850,596,212,8150,8024,7768,7514,7386,7132,7004,6750,6622,6494,6368,6112,5986,5858,5730,5602,5476,5476,5348,5222,5094,4966,4966,4840,4712,4712,4584,4456,4458,4330,4330,4202,4202,4074,4076,3948,3948,3820,3820,3820,3692,3692,3566,3566,3566,3438,3438,3438,3310,3310,3310,3184,3184,3184,3056,3056,3056,3056,2928,2928,2928,2928,2802,2802,2802,2802,2802,2674,2674,2674,2674,2674,2546,2546,2546,2546,2546,2418,2420,2420,2420,2420,2420,2292,2292,2292,2292,2292,2292
  dc.w    2184,2184,2184,2184,2184,2184,2184,2314,2314,2314,2314,2314,2314,2442,2442,2442,2442,2442,2570,2570,2570,2570,2570,2698,2698,2698,2700,2700,2828,2828,2828,2828,2956,2956,2956,3084,3084,3084,3084,3214,3214,3214,3342,3342,3342,3470,3470,3470,3598,3600,3728,3728,3728,3856,3856,3984,3984,4114,4114,4242,4242,4370,4498,4498,4628,4628,4756,4884,5012,5014,5142,5270,5398,5528,5656,5656,5784,6042,6170,6298,6428,6556,6812,6942,7070,7328,7456,7714,7970,36,292,550,806,1192,1578,1836,2222,2736,3122,3636,4150,4792,5436,6078,6850,7622,330,1360,2518,3804,5090,6634,116,1792,3852,5914,7978,1598,3282,4328,4608,4246,3244,1600,8020,5988,3954,1792,10,6548,5020,3746,2472,1326,308,7608,6844,6080,5442,4806,4168,3658,3148,2766,2256,1874,1620,1238,856,600,346,90,8028,7772,7518,7390,7136,7008,6882,6626,6498,6372,6244,6116,5862,5734,5734,5606,5480,5352,5224,5096,5098,4970,4842,4714,4714,4588,4588,4460,4332,4332,4204,4204,4078,4078,3950,3950,3822,3822,3822,3694,3696,3568,3568,3568,3440,3440,3440,3312,3312,3312,3186,3186,3186,3186,3058,3058,3058,2930,2930,2930,2930,2802,2802,2804,2804,2804,2676,2676,2676,2676,2676,2548,2548,2548,2548,2548,2420,2420,2420,2420,2420,2420,2294,2294,2294,2294,2294,2294
  dc.w    2184,2184,2184,2184,2184,2184,2184,2312,2312,2312,2312,2312,2312,2440,2440,2440,2440,2440,2568,2568,2568,2568,2568,2698,2698,2698,2698,2698,2826,2826,2826,2826,2954,2954,2954,3082,3082,3082,3082,3212,3212,3212,3340,3340,3340,3468,3468,3468,3596,3596,3724,3726,3854,3854,3854,3982,3982,4110,4110,4238,4240,4368,4496,4496,4624,4752,4754,4882,5010,5010,5138,5266,5396,5524,5652,5780,5910,6038,6166,6294,6424,6552,6808,6938,7194,7322,7580,7836,7966,30,288,672,930,1314,1572,1958,2342,2856,3242,3756,4398,4912,5556,6326,7098,7998,832,1990,3146,4560,6104,7902,1640,3954,6272,782,3616,6324,458,2148,2688,2074,436,6346,3678,880,6272,3852,1558,7840,6054,4526,3124,1976,830,8000,7108,6344,5578,4942,4432,3794,3284,2902,2392,2008,1626,1372,988,734,350,96,8032,7906,7650,7396,7268,7012,6886,6630,6502,6376,6248,6120,5992,5866,5738,5610,5482,5356,5228,5100,5100,4972,4844,4846,4718,4590,4590,4462,4334,4336,4208,4208,4080,4080,3952,3952,3952,3824,3826,3698,3698,3570,3570,3570,3442,3442,3442,3314,3314,3314,3188,3188,3188,3188,3060,3060,3060,2932,2932,2932,2932,2804,2804,2804,2804,2804,2678,2678,2678,2678,2678,2550,2550,2550,2550,2550,2422,2422,2422,2422,2422,2422,2294,2294,2294,2294,2294,2294
  dc.w    2182,2182,2182,2182,2182,2182,2182,2310,2310,2310,2310,2310,2310,2438,2438,2438,2438,2438,2566,2568,2568,2568,2568,2696,2696,2696,2696,2696,2824,2824,2824,2824,2952,2952,2952,3080,3080,3080,3080,3210,3210,3210,3338,3338,3338,3466,3466,3466,3594,3594,3722,3722,3850,3852,3852,3980,3980,4108,4108,4236,4364,4364,4494,4494,4622,4750,4750,4878,5006,5006,5136,5264,5392,5520,5648,5778,5906,6034,6162,6290,6420,6676,6804,6932,7190,7318,7574,7832,8088,154,410,666,1052,1308,1694,2080,2464,2978,3364,3878,4518,5160,5804,6574,7472,180,1206,2490,3776,5316,7114,850,3290,5988,880,4224,8082,4006,7744,2270,3200,2208,7742,4056,8172,4224,782,5914,3236,812,7092,5306,3774,2500,1224,202,7502,6608,5842,5206,4568,3928,3418,3036,2526,2142,1760,1378,1122,740,484,228,8166,7910,7656,7400,7272,7018,6890,6762,6506,6380,6252,6124,5996,5868,5742,5614,5486,5358,5230,5104,5104,4976,4848,4848,4720,4592,4592,4466,4466,4338,4210,4210,4082,4082,3954,3954,3956,3828,3828,3700,3700,3572,3572,3572,3444,3444,3444,3316,3316,3316,3190,3190,3190,3190,3062,3062,3062,2934,2934,2934,2934,2806,2806,2806,2806,2806,2678,2678,2678,2678,2680,2552,2552,2552,2552,2552,2424,2424,2424,2424,2424,2424,2296,2296,2296,2296,2296,2296
  dc.w    2180,2180,2180,2180,2180,2180,2180,2308,2308,2308,2308,2308,2310,2438,2438,2438,2438,2438,2566,2566,2566,2566,2566,2694,2694,2694,2694,2822,2822,2822,2822,2822,2950,2950,2950,3078,3078,3078,3078,3208,3208,3208,3336,3336,3336,3464,3464,3592,3592,3592,3720,3720,3848,3848,3848,3978,3978,4106,4106,4234,4362,4362,4490,4490,4618,4746,4748,4876,5004,5132,5132,5260,5388,5516,5646,5774,5902,6030,6158,6286,6416,6672,6800,7056,7186,7442,7570,7826,8084,148,404,662,1046,1430,1688,2072,2586,2972,3484,3998,4640,5280,6050,6820,7718,426,1580,2864,4276,5944,7998,1988,4682,8020,3678,8172,5376,3222,1204,6232, 0,6182,1226,3304,5376,8082,3616,7978,4660,1978,8000,5958,4298,2894,1618,468,7768,6874,6108,5342,4702,4064,3554,3042,2660,2150,1766,1512,1128,744,490,234,8170,7916,7660,7532,7276,7150,6894,6766,6510,6384,6256,6128,6000,5872,5744,5618,5490,5362,5234,5234,5106,4978,4850,4852,4724,4596,4596,4468,4468,4340,4212,4212,4084,4084,3958,3958,3958,3830,3830,3702,3702,3702,3574,3574,3446,3446,3446,3318,3318,3318,3192,3192,3192,3192,3064,3064,3064,2936,2936,2936,2936,2936,2808,2808,2808,2808,2680,2680,2680,2680,2680,2552,2552,2552,2552,2552,2424,2426,2426,2426,2426,2426,2298,2298,2298,2298,2298,2298
  dc.w    2180,2180,2180,2180,2180,2180,2180,2308,2308,2308,2308,2308,2308,2436,2436,2436,2436,2436,2564,2564,2564,2564,2564,2692,2692,2692,2692,2820,2820,2820,2820,2820,2948,2948,2948,3076,3076,3076,3076,3206,3206,3206,3334,3334,3334,3462,3462,3590,3590,3590,3718,3718,3846,3846,3846,3974,3974,4102,4102,4232,4360,4360,4488,4488,4616,4744,4744,4872,5000,5128,5128,5256,5386,5514,5642,5770,5898,6026,6154,6282,6540,6668,6796,7052,7180,7436,7694,7822,8078,142,400,784,1040,1426,1810,2194,2580,3092,3606,4118,4760,5400,6170,6940,7838,672,1954,3236,4774,6570,558,2996,6074,1600,6346,4056,3304,4352,7200,970,5376,948,7262,4352,3222,4006,6324,1598,6084,3018,592,6612,4824,3290,2012,734,7904,7010,6244,5478,4838,4200,3688,3178,2666,2284,1900,1516,1134,878,494,240,8176,7920,7792,7538,7282,7154,6898,6770,6642,6388,6260,6132,6004,5876,5748,5620,5492,5366,5238,5238,5110,4982,4854,4854,4726,4598,4598,4470,4470,4342,4216,4216,4088,4088,3960,3960,3960,3832,3832,3704,3704,3704,3576,3576,3448,3448,3448,3320,3320,3320,3194,3194,3194,3194,3066,3066,3066,2938,2938,2938,2938,2938,2810,2810,2810,2810,2682,2682,2682,2682,2682,2554,2554,2554,2554,2554,2426,2426,2426,2426,2426,2426,2298,2298,2298,2298,2298,2298
  dc.w    2178,2178,2178,2178,2178,2178,2178,2306,2306,2306,2306,2306,2306,2434,2434,2434,2434,2434,2562,2562,2562,2562,2562,2690,2690,2690,2690,2818,2818,2818,2818,2946,2946,2946,2946,3074,3074,3074,3074,3204,3204,3204,3332,3332,3332,3460,3460,3588,3588,3588,3716,3716,3844,3844,3972,3972,3972,4100,4228,4228,4356,4356,4484,4484,4612,4740,4742,4870,4998,5126,5126,5254,5382,5510,5638,5766,5894,6022,6150,6278,6536,6664,6792,7048,7176,7432,7688,7816,8074,138,522,778,1034,1420,1804,2188,2700,3086,3598,4238,4752,5520,6290,7058,8084,916,2070,3480,5146,7068,1056,3874,7206,3244,436,7742,1226,7262,2560,2484, 0,2506,2560,7200,1204,7744,458,3282,7256,3932,1118,7138,5220,3558,2152,1002,8170,7148,6380,5614,4846,4336,3696,3184,2802,2290,1906,1522,1140,884,628,244,8180,7926,7798,7542,7286,7158,6902,6774,6646,6392,6264,6136,6008,5880,5752,5624,5496,5368,5240,5240,5112,4984,4856,4858,4730,4602,4602,4474,4474,4346,4346,4218,4090,4090,4090,3962,3962,3834,3834,3706,3706,3706,3578,3578,3450,3450,3450,3322,3322,3322,3196,3196,3196,3196,3068,3068,3068,3068,2940,2940,2940,2940,2812,2812,2812,2812,2684,2684,2684,2684,2684,2556,2556,2556,2556,2556,2428,2428,2428,2428,2428,2428,2300,2300,2300,2300,2300,2300
  dc.w    2176,2176,2176,2176,2176,2176,2176,2304,2304,2304,2304,2304,2304,2432,2432,2432,2432,2432,2560,2560,2560,2560,2560,2688,2688,2688,2688,2816,2816,2816,2816,2944,2944,2944,2944,3072,3072,3072,3072,3202,3202,3202,3330,3330,3330,3458,3458,3586,3586,3586,3714,3714,3842,3842,3970,3970,3970,4098,4226,4226,4354,4354,4482,4482,4610,4738,4738,4866,4994,5122,5122,5250,5378,5506,5634,5762,5890,6018,6146,6274,6532,6660,6788,7044,7172,7428,7684,7940,8068,260,516,772,1156,1414,1798,2182,2694,3078,3590,4230,4872,5512,6280,7176,8074,1034,2186,3724,5388,7310,1424,4370,7956,4246,2074,2208,6182,948,2506,5120, 0,5120,2484,970,6232,2270,2148,4328,8042,4460,1518,7408,5490,3826,2292,1140,8180,7286,6390,5622,4982,4344,3704,3192,2808,2296,1912,1528,1274,890,634,378,8186,8058,7802,7546,7290,7162,6906,6778,6650,6396,6268,6140,6012,5884,5756,5628,5500,5372,5244,5244,5116,4988,4860,4860,4732,4604,4604,4476,4476,4348,4348,4220,4092,4092,4092,3964,3964,3836,3836,3708,3708,3708,3580,3580,3452,3452,3452,3324,3324,3324,3198,3198,3198,3198,3070,3070,3070,3070,2942,2942,2942,2942,2814,2814,2814,2814,2686,2686,2686,2686,2686,2558,2558,2558,2558,2558,2430,2430,2430,2430,2430,2430,2302,2302,2302,2302,2302,2302
  dc.w    2176,2176,2176,2176,2176,2176,2176,2304,2304,2304,2304,2304,2304,2432,2432,2432,2432,2432,2560,2560,2560,2560,2560,2688,2688,2688,2688,2816,2816,2816,2816,2944,2944,2944,2944,3072,3072,3072,3072,3200,3200,3200,3328,3328,3328,3456,3456,3584,3584,3584,3712,3712,3840,3840,3968,3968,4096,4096,4224,4224,4352,4352,4480,4480,4608,4736,4736,4864,4992,5120,5120,5248,5376,5504,5632,5760,5888,6016,6144,6272,6528,6656,6784,7040,7168,7424,7680,7936, 0,256,512,768,1152,1408,1792,2176,2688,3200,3712,4224,4864,5504,6272,7168, 0,1024,2304,3712,5376,7424,1536,4480, 0,4608,2688,3200, 0,5376, 0, 0,8064, 0, 0,5376, 0,3200,2688,4608, 0,4480,1536,7424,5376,3712,2304,1024, 0,7168,6272,5504,4864,4224,3712,3200,2688,2176,1792,1408,1152,768,512,256, 0,7936,7680,7424,7168,7040,6784,6656,6528,6272,6144,6016,5888,5760,5632,5504,5376,5248,5120,5120,4992,4864,4736,4736,4608,4480,4480,4352,4352,4224,4224,4096,4096,3968,3968,3840,3840,3712,3712,3584,3584,3584,3456,3456,3328,3328,3328,3200,3200,3200,3072,3072,3072,3072,2944,2944,2944,2944,2816,2816,2816,2816,2688,2688,2688,2688,2560,2560,2560,2560,2560,2432,2432,2432,2432,2432,2304,2304,2304,2304,2304,2304,2176,2176,2176,2176,2176,2176
  dc.w    2302,2302,2302,2302,2302,2302,2302,2430,2430,2430,2430,2430,2430,2558,2558,2558,2558,2558,2686,2686,2686,2686,2686,2814,2814,2814,2814,2942,2942,2942,2942,3070,3070,3070,3070,3198,3198,3198,3198,3324,3324,3324,3452,3452,3452,3580,3580,3708,3708,3708,3836,3836,3964,3964,4092,4092,4092,4220,4348,4348,4476,4476,4604,4604,4732,4860,4860,4988,5116,5244,5244,5372,5500,5628,5756,5884,6012,6140,6268,6396,6650,6778,6906,7162,7290,7546,7802,8058,8186,378,634,890,1274,1528,1912,2296,2808,3192,3704,4344,4982,5622,6390,7286,8180,1140,2292,3826,5490,7408,1518,4460,8042,4328,2148,2270,6232,970,2484,5120, 0,5120,2506,948,6182,2208,2074,4246,7956,4370,1424,7310,5388,3724,2186,1034,8074,7176,6280,5512,4872,4230,3590,3078,2694,2182,1798,1414,1156,772,516,260,8068,7940,7684,7428,7172,7044,6788,6660,6532,6274,6146,6018,5890,5762,5634,5506,5378,5250,5122,5122,4994,4866,4738,4738,4610,4482,4482,4354,4354,4226,4226,4098,3970,3970,3970,3842,3842,3714,3714,3586,3586,3586,3458,3458,3330,3330,3330,3202,3202,3202,3072,3072,3072,3072,2944,2944,2944,2944,2816,2816,2816,2816,2688,2688,2688,2688,2560,2560,2560,2560,2560,2432,2432,2432,2432,2432,2304,2304,2304,2304,2304,2304,2176,2176,2176,2176,2176,2176
  dc.w    2300,2300,2300,2300,2300,2300,2300,2428,2428,2428,2428,2428,2428,2556,2556,2556,2556,2556,2684,2684,2684,2684,2684,2812,2812,2812,2812,2940,2940,2940,2940,3068,3068,3068,3068,3196,3196,3196,3196,3322,3322,3322,3450,3450,3450,3578,3578,3706,3706,3706,3834,3834,3962,3962,4090,4090,4090,4218,4346,4346,4474,4474,4602,4602,4730,4858,4856,4984,5112,5240,5240,5368,5496,5624,5752,5880,6008,6136,6264,6392,6646,6774,6902,7158,7286,7542,7798,7926,8180,244,628,884,1140,1522,1906,2290,2802,3184,3696,4336,4846,5614,6380,7148,8170,1002,2152,3558,5220,7138,1118,3932,7256,3282,458,7744,1204,7200,2560,2506, 0,2484,2560,7262,1226,7742,436,3244,7206,3874,1056,7068,5146,3480,2070,916,8084,7058,6290,5520,4752,4238,3598,3086,2700,2188,1804,1420,1034,778,522,138,8074,7816,7688,7432,7176,7048,6792,6664,6536,6278,6150,6022,5894,5766,5638,5510,5382,5254,5126,5126,4998,4870,4742,4740,4612,4484,4484,4356,4356,4228,4228,4100,3972,3972,3972,3844,3844,3716,3716,3588,3588,3588,3460,3460,3332,3332,3332,3204,3204,3204,3074,3074,3074,3074,2946,2946,2946,2946,2818,2818,2818,2818,2690,2690,2690,2690,2562,2562,2562,2562,2562,2434,2434,2434,2434,2434,2306,2306,2306,2306,2306,2306,2178,2178,2178,2178,2178,2178
  dc.w    2298,2298,2298,2298,2298,2298,2298,2426,2426,2426,2426,2426,2426,2554,2554,2554,2554,2554,2682,2682,2682,2682,2682,2810,2810,2810,2810,2938,2938,2938,2938,2938,3066,3066,3066,3194,3194,3194,3194,3320,3320,3320,3448,3448,3448,3576,3576,3704,3704,3704,3832,3832,3960,3960,3960,4088,4088,4216,4216,4342,4470,4470,4598,4598,4726,4854,4854,4982,5110,5238,5238,5366,5492,5620,5748,5876,6004,6132,6260,6388,6642,6770,6898,7154,7282,7538,7792,7920,8176,240,494,878,1134,1516,1900,2284,2666,3178,3688,4200,4838,5478,6244,7010,7904,734,2012,3290,4824,6612,592,3018,6084,1598,6324,4006,3222,4352,7262,948,5376,970,7200,4352,3304,4056,6346,1600,6074,2996,558,6570,4774,3236,1954,672,7838,6940,6170,5400,4760,4118,3606,3092,2580,2194,1810,1426,1040,784,400,142,8078,7822,7694,7436,7180,7052,6796,6668,6540,6282,6154,6026,5898,5770,5642,5514,5386,5256,5128,5128,5000,4872,4744,4744,4616,4488,4488,4360,4360,4232,4102,4102,3974,3974,3846,3846,3846,3718,3718,3590,3590,3590,3462,3462,3334,3334,3334,3206,3206,3206,3076,3076,3076,3076,2948,2948,2948,2820,2820,2820,2820,2820,2692,2692,2692,2692,2564,2564,2564,2564,2564,2436,2436,2436,2436,2436,2308,2308,2308,2308,2308,2308,2180,2180,2180,2180,2180,2180
  dc.w    2298,2298,2298,2298,2298,2298,2298,2426,2426,2426,2426,2426,2424,2552,2552,2552,2552,2552,2680,2680,2680,2680,2680,2808,2808,2808,2808,2936,2936,2936,2936,2936,3064,3064,3064,3192,3192,3192,3192,3318,3318,3318,3446,3446,3446,3574,3574,3702,3702,3702,3830,3830,3958,3958,3958,4084,4084,4212,4212,4340,4468,4468,4596,4596,4724,4852,4850,4978,5106,5234,5234,5362,5490,5618,5744,5872,6000,6128,6256,6384,6510,6766,6894,7150,7276,7532,7660,7916,8170,234,490,744,1128,1512,1766,2150,2660,3042,3554,4064,4702,5342,6108,6874,7768,468,1618,2894,4298,5958,8000,1978,4660,7978,3616,8082,5376,3304,1226,6182, 0,6232,1204,3222,5376,8172,3678,8020,4682,1988,7998,5944,4276,2864,1580,426,7718,6820,6050,5280,4640,3998,3484,2972,2586,2072,1688,1430,1046,662,404,148,8084,7826,7570,7442,7186,7056,6800,6672,6416,6286,6158,6030,5902,5774,5646,5516,5388,5260,5132,5132,5004,4876,4748,4746,4618,4490,4490,4362,4362,4234,4106,4106,3978,3978,3848,3848,3848,3720,3720,3592,3592,3592,3464,3464,3336,3336,3336,3208,3208,3208,3078,3078,3078,3078,2950,2950,2950,2822,2822,2822,2822,2822,2694,2694,2694,2694,2566,2566,2566,2566,2566,2438,2438,2438,2438,2438,2310,2308,2308,2308,2308,2308,2180,2180,2180,2180,2180,2180
  dc.w    2296,2296,2296,2296,2296,2296,2296,2424,2424,2424,2424,2424,2424,2552,2552,2552,2552,2552,2680,2678,2678,2678,2678,2806,2806,2806,2806,2806,2934,2934,2934,2934,3062,3062,3062,3190,3190,3190,3190,3316,3316,3316,3444,3444,3444,3572,3572,3572,3700,3700,3828,3828,3956,3954,3954,4082,4082,4210,4210,4338,4466,4466,4592,4592,4720,4848,4848,4976,5104,5104,5230,5358,5486,5614,5742,5868,5996,6124,6252,6380,6506,6762,6890,7018,7272,7400,7656,7910,8166,228,484,740,1122,1378,1760,2142,2526,3036,3418,3928,4568,5206,5842,6608,7502,202,1224,2500,3774,5306,7092,812,3236,5914,782,4224,8172,4056,7742,2208,3200,2270,7744,4006,8082,4224,880,5988,3290,850,7114,5316,3776,2490,1206,180,7472,6574,5804,5160,4518,3878,3364,2978,2464,2080,1694,1308,1052,666,410,154,8088,7832,7574,7318,7190,6932,6804,6676,6420,6290,6162,6034,5906,5778,5648,5520,5392,5264,5136,5006,5006,4878,4750,4750,4622,4494,4494,4364,4364,4236,4108,4108,3980,3980,3852,3852,3850,3722,3722,3594,3594,3466,3466,3466,3338,3338,3338,3210,3210,3210,3080,3080,3080,3080,2952,2952,2952,2824,2824,2824,2824,2696,2696,2696,2696,2696,2568,2568,2568,2568,2566,2438,2438,2438,2438,2438,2310,2310,2310,2310,2310,2310,2182,2182,2182,2182,2182,2182
  dc.w    2294,2294,2294,2294,2294,2294,2294,2422,2422,2422,2422,2422,2422,2550,2550,2550,2550,2550,2678,2678,2678,2678,2678,2804,2804,2804,2804,2804,2932,2932,2932,2932,3060,3060,3060,3188,3188,3188,3188,3314,3314,3314,3442,3442,3442,3570,3570,3570,3698,3698,3826,3824,3952,3952,3952,4080,4080,4208,4208,4336,4334,4462,4590,4590,4718,4846,4844,4972,5100,5100,5228,5356,5482,5610,5738,5866,5992,6120,6248,6376,6502,6630,6886,7012,7268,7396,7650,7906,8032,96,350,734,988,1372,1626,2008,2392,2902,3284,3794,4432,4942,5578,6344,7108,8000,830,1976,3124,4526,6054,7840,1558,3852,6272,880,3678,6346,436,2074,2688,2148,458,6324,3616,782,6272,3954,1640,7902,6104,4560,3146,1990,832,7998,7098,6326,5556,4912,4398,3756,3242,2856,2342,1958,1572,1314,930,672,288,30,7966,7836,7580,7322,7194,6938,6808,6552,6424,6294,6166,6038,5910,5780,5652,5524,5396,5266,5138,5010,5010,4882,4754,4752,4624,4496,4496,4368,4240,4238,4110,4110,3982,3982,3854,3854,3854,3726,3724,3596,3596,3468,3468,3468,3340,3340,3340,3212,3212,3212,3082,3082,3082,3082,2954,2954,2954,2826,2826,2826,2826,2698,2698,2698,2698,2698,2568,2568,2568,2568,2568,2440,2440,2440,2440,2440,2312,2312,2312,2312,2312,2312,2184,2184,2184,2184,2184,2184
  dc.w    2294,2294,2294,2294,2294,2294,2294,2420,2420,2420,2420,2420,2420,2548,2548,2548,2548,2548,2676,2676,2676,2676,2676,2804,2804,2804,2802,2802,2930,2930,2930,2930,3058,3058,3058,3186,3186,3186,3186,3312,3312,3312,3440,3440,3440,3568,3568,3568,3696,3694,3822,3822,3822,3950,3950,4078,4078,4204,4204,4332,4332,4460,4588,4588,4714,4714,4842,4970,5098,5096,5224,5352,5480,5606,5734,5734,5862,6116,6244,6372,6498,6626,6882,7008,7136,7390,7518,7772,8028,90,346,600,856,1238,1620,1874,2256,2766,3148,3658,4168,4806,5442,6080,6844,7608,308,1326,2472,3746,5020,6548,10,1792,3954,5988,8020,1600,3244,4246,4608,4328,3282,1598,7978,5914,3852,1792,116,6634,5090,3804,2518,1360,330,7622,6850,6078,5436,4792,4150,3636,3122,2736,2222,1836,1578,1192,806,550,292,36,7970,7714,7456,7328,7070,6942,6812,6556,6428,6298,6170,6042,5784,5656,5656,5528,5398,5270,5142,5014,5012,4884,4756,4628,4628,4498,4498,4370,4242,4242,4114,4114,3984,3984,3856,3856,3728,3728,3728,3600,3598,3470,3470,3470,3342,3342,3342,3214,3214,3214,3084,3084,3084,3084,2956,2956,2956,2828,2828,2828,2828,2700,2700,2698,2698,2698,2570,2570,2570,2570,2570,2442,2442,2442,2442,2442,2314,2314,2314,2314,2314,2314,2184,2184,2184,2184,2184,2184
  dc.w    2292,2292,2292,2292,2292,2292,2292,2420,2420,2420,2420,2420,2418,2546,2546,2546,2546,2546,2674,2674,2674,2674,2674,2802,2802,2802,2802,2802,2928,2928,2928,2928,3056,3056,3056,3056,3184,3184,3184,3310,3310,3310,3438,3438,3438,3566,3566,3566,3692,3692,3820,3820,3820,3948,3948,4076,4074,4202,4202,4330,4330,4458,4456,4584,4712,4712,4840,4966,4966,5094,5222,5348,5476,5476,5602,5730,5858,5986,6112,6368,6494,6622,6750,7004,7132,7386,7514,7768,8024,8150,212,596,850,1104,1486,1868,2122,2632,3014,3524,4032,4542,5050,5816,6452,7216,8106,806,1824,2840,3986,5384,6784,116,1640,3290,4682,6074,7206,7956, 0,8042,7256,6084,4660,3236,1558,10,6784,5494,4076,2918,1886,856,8148,7246,6474,5830,5060,4544,4030,3514,3000,2614,2100,1842,1456,1070,812,554,170,8104,7974,7718,7460,7332,7074,6946,6688,6560,6432,6302,6046,5916,5788,5660,5532,5402,5402,5274,5144,5016,4888,4888,4758,4630,4630,4502,4374,4372,4244,4244,4116,4116,3988,3986,3858,3858,3730,3730,3730,3602,3602,3472,3472,3472,3344,3344,3344,3216,3216,3216,3086,3086,3086,2958,2958,2958,2958,2830,2830,2830,2830,2700,2700,2700,2700,2700,2572,2572,2572,2572,2572,2444,2444,2444,2444,2444,2316,2314,2314,2314,2314,2314,2186,2186,2186,2186,2186,2186
  dc.w    2290,2290,2290,2290,2290,2290,2290,2418,2418,2418,2418,2418,2418,2546,2546,2546,2544,2544,2672,2672,2672,2672,2672,2800,2800,2800,2800,2800,2928,2926,2926,2926,3054,3054,3054,3054,3182,3182,3182,3308,3308,3308,3436,3436,3436,3564,3564,3564,3690,3690,3818,3818,3818,3946,3944,4072,4072,4200,4200,4328,4326,4454,4454,4582,4710,4708,4836,4964,4964,5090,5218,5346,5344,5472,5600,5726,5854,5982,6108,6236,6362,6618,6746,6872,7128,7254,7508,7636,7890,8144,208,462,716,970,1352,1734,1988,2370,2880,3262,3770,4278,4788,5424,6060,6822,7586,156,1046,2064,3080,4096,5494,6634,7902,850,1988,2996,3874,4370,4480,4460,3932,3018,1978,812,7840,6548,5384,4096,3190,2158,1128,226,7644,6872,6098,5454,4810,4296,3780,3264,2878,2364,1978,1720,1334,948,690,432,174,8110,7852,7594,7466,7208,7078,6822,6692,6564,6308,6178,6050,5920,5792,5664,5534,5406,5278,5276,5148,5020,4890,4890,4762,4634,4632,4504,4376,4376,4248,4246,4118,4118,3990,3990,3862,3860,3732,3732,3732,3604,3604,3474,3474,3474,3346,3346,3346,3218,3218,3218,3088,3088,3088,2960,2960,2960,2960,2832,2832,2832,2830,2702,2702,2702,2702,2702,2574,2574,2574,2574,2574,2446,2446,2444,2444,2444,2316,2316,2316,2316,2316,2316,2188,2188,2188,2188,2188,2188
  dc.w    2290,2290,2290,2290,2288,2288,2288,2416,2416,2416,2416,2416,2416,2544,2544,2544,2544,2544,2544,2670,2670,2670,2670,2798,2798,2798,2798,2798,2926,2926,2924,2924,3052,3052,3052,3052,3180,3180,3180,3306,3306,3306,3434,3434,3434,3562,3562,3560,3688,3688,3688,3816,3816,3942,3942,4070,4070,4198,4196,4324,4324,4452,4452,4578,4706,4706,4834,4832,4960,5088,5214,5214,5342,5468,5596,5724,5850,5978,6104,6232,6360,6486,6742,6868,6994,7250,7376,7632,7886,8012,74,328,584,966,1220,1600,1854,2236,2618,3126,3508,4016,4524,5032,5668,6304,7066,7700,398,1158,2048,3190,4076,5090,6104,7114,7998,558,1056,1424,1536,1518,1118,592,8000,7092,6054,5020,3986,3080,2048,1272,496,7786,7140,6366,5722,5078,4562,4046,3530,3144,2628,2242,1856,1598,1210,952,566,310,52,7986,7856,7598,7342,7212,6956,6826,6696,6440,6310,6182,6054,5924,5796,5666,5538,5410,5280,5152,5152,5022,4894,4766,4764,4636,4636,4508,4378,4378,4250,4250,4122,4120,3992,3992,3864,3864,3734,3734,3606,3606,3606,3478,3476,3476,3348,3348,3348,3220,3220,3220,3090,3090,3090,2962,2962,2962,2962,2834,2834,2832,2832,2704,2704,2704,2704,2704,2576,2576,2576,2576,2446,2446,2446,2446,2446,2446,2318,2318,2318,2318,2318,2318,2190,2190,2190,2188,2188,2188
  dc.w    2160,2288,2288,2288,2288,2288,2288,2416,2416,2414,2414,2414,2414,2542,2542,2542,2542,2542,2542,2670,2670,2668,2668,2668,2796,2796,2796,2796,2924,2924,2924,2922,3050,3050,3050,3050,3178,3178,3178,3306,3304,3304,3304,3432,3432,3560,3558,3558,3686,3686,3686,3814,3812,3940,3940,4068,4068,4194,4194,4322,4322,4448,4448,4576,4576,4702,4830,4830,4958,5084,5212,5212,5338,5466,5592,5720,5848,5974,6102,6228,6356,6482,6610,6864,6990,7118,7372,7498,7754,8008,70,324,578,832,1086,1340,1720,2102,2484,2864,3246,3754,4262,4770,5276,5912,6546,7180,7814,384,1272,2158,2918,3804,4560,5316,5944,6570,7068,7310,7424,7408,7138,6612,5958,5306,4526,3746,2840,2064,1158,384,7928,7282,6636,5990,5346,4828,4312,3796,3280,2894,2506,2120,1734,1346,1088,830,572,314,56,7990,7732,7476,7346,7088,6960,6830,6572,6444,6314,6186,6056,5928,5798,5670,5542,5412,5284,5154,5154,5026,4896,4768,4768,4640,4510,4510,4382,4382,4252,4252,4124,4124,3994,3994,3866,3866,3738,3736,3608,3608,3608,3480,3480,3478,3350,3350,3222,3222,3222,3220,3092,3092,3092,2964,2964,2964,2964,2836,2834,2834,2834,2706,2706,2706,2706,2578,2578,2578,2576,2576,2448,2448,2448,2448,2448,2448,2320,2320,2320,2320,2318,2318,2190,2190,2190,2190,2190,2190
  dc.w    2158,2286,2286,2286,2286,2286,2286,2414,2414,2414,2414,2414,2412,2540,2540,2540,2540,2540,2540,2668,2668,2668,2668,2666,2794,2794,2794,2794,2922,2922,2922,2922,3048,3048,3048,3048,3176,3176,3176,3304,3302,3302,3302,3430,3430,3430,3556,3556,3684,3684,3684,3810,3810,3938,3938,3938,4064,4064,4192,4192,4318,4446,4446,4574,4572,4700,4828,4826,4954,5082,5080,5208,5336,5462,5590,5588,5716,5842,5970,6096,6352,6478,6606,6732,6858,7114,7240,7494,7620,7874,8128,192,446,698,952,1206,1588,1840,2222,2602,2982,3492,3872,4378,4886,5394,6028,6534,7168,7928,496,1128,1886,2518,3146,3776,4276,4774,5146,5388,5376,5490,5220,4824,4298,3774,3124,2472,1824,1046,398,7814,7168,6648,6130,5484,4968,4452,3934,3546,3032,2644,2256,1870,1610,1224,966,708,448,190,8126,7868,7610,7480,7222,7092,6836,6706,6576,6448,6318,6062,5932,5804,5674,5546,5544,5416,5286,5158,5030,5028,4900,4772,4770,4642,4514,4512,4384,4384,4256,4126,4126,3998,3998,3868,3868,3868,3740,3740,3610,3610,3610,3482,3482,3352,3352,3352,3224,3224,3224,3222,3094,3094,3094,2966,2966,2966,2966,2836,2836,2836,2836,2708,2708,2708,2708,2580,2578,2578,2578,2578,2450,2450,2450,2450,2450,2450,2322,2320,2320,2320,2320,2320,2192,2192,2192,2192,2192,2192
  dc.w    2158,2286,2286,2284,2284,2284,2284,2412,2412,2412,2412,2412,2412,2540,2540,2538,2538,2538,2538,2666,2666,2666,2666,2666,2794,2792,2792,2792,2920,2920,2920,2920,3048,3046,3046,3046,3174,3174,3174,3174,3300,3300,3300,3428,3428,3428,3554,3554,3554,3682,3682,3808,3808,3936,3936,3934,4062,4062,4190,4188,4316,4316,4444,4570,4570,4698,4696,4824,4952,4950,5078,5204,5332,5332,5458,5586,5712,5840,5966,6092,6220,6346,6474,6728,6854,6982,7236,7362,7616,7742,7996,58,312,566,820,1072,1454,1708,2088,2340,2722,3102,3610,3988,4496,5002,5510,6016,6648,7282,7786,226,856,1360,1990,2490,2864,3236,3480,3724,3712,3826,3558,3290,2894,2500,1976,1326,806,156,7700,7180,6534,6016,5624,5108,4590,4074,3684,3168,2780,2394,2134,1746,1488,1102,842,584,326,68,8002,7744,7614,7356,7226,6968,6840,6710,6452,6324,6194,6066,5936,5806,5678,5548,5420,5290,5290,5162,5032,4904,4902,4774,4646,4644,4516,4516,4386,4258,4258,4130,4128,4000,4000,3872,3870,3870,3742,3742,3612,3612,3484,3484,3484,3354,3354,3354,3226,3226,3226,3096,3096,3096,3096,2968,2968,2968,2966,2838,2838,2838,2838,2710,2710,2710,2708,2580,2580,2580,2580,2580,2452,2452,2452,2452,2450,2450,2322,2322,2322,2322,2322,2322,2194,2194,2194,2194,2192,2192
  dc.w    2156,2284,2284,2284,2284,2284,2284,2282,2410,2410,2410,2410,2410,2410,2538,2538,2538,2536,2536,2664,2664,2664,2664,2664,2792,2792,2790,2790,2918,2918,2918,2918,2918,3044,3044,3044,3172,3172,3172,3172,3298,3298,3298,3426,3426,3424,3552,3552,3552,3680,3678,3806,3806,3806,3932,3932,4060,4060,4186,4186,4314,4314,4440,4440,4568,4694,4694,4820,4948,4948,5074,5202,5200,5328,5454,5582,5708,5836,5962,6090,6216,6342,6470,6596,6850,6976,7104,7358,7484,7738,7864,8118,180,434,686,940,1192,1574,1826,2208,2460,2840,3220,3598,4106,4484,4992,5624,6130,6636,7140,7644,8148,330,832,1206,1580,1954,2070,2186,2304,2292,2152,2012,1618,1224,830,308,8106,7586,7066,6546,6028,5510,4992,4602,4212,3696,3306,2918,2530,2270,1884,1624,1238,978,720,460,202,8136,7878,7748,7490,7360,7102,6974,6844,6586,6456,6328,6198,6068,5940,5810,5682,5552,5424,5294,5166,5164,5036,4906,4906,4778,4648,4648,4518,4390,4390,4260,4260,4132,4132,4002,4002,3874,3874,3744,3744,3744,3616,3614,3486,3486,3486,3358,3356,3356,3228,3228,3228,3098,3098,3098,3098,2970,2970,2970,2840,2840,2840,2840,2840,2712,2712,2710,2710,2582,2582,2582,2582,2582,2454,2454,2452,2452,2452,2324,2324,2324,2324,2324,2324,2196,2194,2194,2194,2194,2194,2194
  dc.w    2154,2282,2282,2282,2282,2282,2282,2282,2410,2410,2408,2408,2408,2408,2536,2536,2536,2536,2536,2662,2662,2662,2662,2662,2790,2790,2790,2788,2788,2916,2916,2916,2916,3044,3042,3042,3170,3170,3170,3170,3296,3296,3296,3424,3424,3422,3550,3550,3550,3678,3676,3804,3804,3804,3930,3930,4058,4056,4184,4184,4312,4310,4438,4438,4564,4564,4690,4818,4818,4944,5072,5070,5198,5324,5452,5578,5706,5704,5832,5958,6084,6340,6466,6592,6718,6846,7100,7226,7352,7606,7860,7986,46,300,554,806,1060,1312,1566,1946,2198,2578,2958,3338,3716,4096,4602,5108,5484,5990,6366,6872,7246,7622,7998,180,426,672,916,1034,1024,1140,1002,734,468,202,8000,7608,7216,6822,6304,5912,5394,5002,4484,4096,3834,3444,3056,2668,2280,2020,1632,1374,1114,856,596,338,80,8012,7882,7624,7366,7236,7106,6848,6720,6590,6460,6330,6074,5944,5814,5686,5684,5556,5426,5298,5168,5040,5038,4910,4780,4780,4652,4522,4522,4392,4392,4264,4262,4134,4134,4006,4004,3876,3876,3746,3746,3746,3618,3616,3488,3488,3488,3360,3358,3358,3230,3230,3230,3100,3100,3100,3100,2972,2972,2970,2842,2842,2842,2842,2714,2714,2712,2712,2712,2584,2584,2584,2584,2584,2454,2454,2454,2454,2454,2326,2326,2326,2326,2324,2324,2196,2196,2196,2196,2196,2196,2196
  dc.w    2154,2282,2282,2280,2280,2280,2280,2280,2408,2408,2408,2408,2408,2406,2534,2534,2534,2534,2534,2662,2662,2660,2660,2660,2788,2788,2788,2788,2786,2914,2914,2914,2914,3042,3042,3040,3040,3168,3168,3168,3294,3294,3294,3422,3422,3420,3548,3548,3548,3674,3674,3674,3802,3800,3928,3928,4056,4054,4054,4182,4180,4308,4436,4434,4562,4560,4688,4688,4814,4942,5068,5068,5194,5322,5448,5448,5574,5700,5828,5954,6080,6208,6334,6460,6586,6842,6968,7094,7348,7474,7728,7852,8106,168,422,546,928,1180,1432,1684,1938,2316,2696,2948,3328,3834,4212,4590,4968,5346,5722,6098,6474,6850,7098,7472,7718,7838,8084,8074, 0,8180,8170,7904,7768,7502,7108,6844,6452,6060,5668,5276,4886,4496,4106,3716,3328,3066,2806,2418,2028,1770,1510,1250,990,604,472,214,8148,7890,7758,7500,7370,7112,6982,6852,6596,6466,6336,6206,6078,5948,5818,5690,5560,5430,5430,5300,5172,5042,5042,4912,4784,4654,4654,4526,4524,4396,4394,4266,4138,4136,4008,4008,4006,3878,3878,3750,3748,3620,3620,3620,3490,3490,3490,3362,3360,3360,3232,3232,3232,3102,3102,3102,2974,2974,2972,2972,2844,2844,2844,2844,2716,2714,2714,2714,2714,2586,2586,2586,2584,2584,2456,2456,2456,2456,2456,2328,2326,2326,2326,2326,2326,2198,2198,2198,2198,2198,2196,2196
  dc.w    2152,2280,2280,2280,2280,2280,2278,2278,2406,2406,2406,2406,2406,2406,2534,2532,2532,2532,2532,2532,2660,2660,2660,2658,2786,2786,2786,2786,2786,2912,2912,2912,2912,3040,3040,3038,3038,3166,3166,3166,3292,3292,3292,3292,3420,3418,3418,3546,3546,3672,3672,3672,3800,3798,3926,3926,3924,4052,4052,4178,4178,4306,4304,4432,4430,4558,4686,4684,4812,4938,4938,5064,5192,5190,5318,5444,5570,5698,5824,5950,6078,6204,6330,6456,6584,6710,6836,7090,7216,7342,7594,7720,7974,36,160,414,666,920,1172,1424,1804,2056,2308,2688,3066,3444,3696,4074,4452,4828,5078,5454,5830,6078,6326,6574,6820,6940,7058,7176,7168,7286,7148,7010,6874,6608,6344,6080,5816,5424,5032,4770,4378,3988,3598,3338,2948,2688,2426,2166,1906,1518,1258,998,740,480,222,90,8024,7766,7636,7376,7246,7116,6858,6728,6598,6470,6340,6210,6080,5952,5822,5692,5564,5434,5304,5176,5174,5046,4916,4916,4786,4658,4656,4528,4400,4398,4270,4268,4140,4140,4010,4010,3882,3880,3880,3752,3750,3622,3622,3622,3492,3492,3364,3364,3362,3234,3234,3234,3234,3104,3104,3104,2976,2976,2974,2974,2846,2846,2846,2846,2716,2716,2716,2716,2716,2588,2586,2586,2586,2458,2458,2458,2458,2458,2456,2328,2328,2328,2328,2328,2328,2200,2200,2198,2198,2198,2198,2198
  dc.w    2150,2278,2278,2278,2278,2278,2278,2278,2406,2404,2404,2404,2404,2404,2532,2532,2532,2530,2530,2530,2658,2658,2658,2658,2656,2784,2784,2784,2784,2912,2910,2910,2910,3038,3038,3036,3036,3164,3164,3164,3162,3290,3290,3290,3418,3416,3416,3544,3544,3542,3670,3670,3796,3796,3796,3922,3922,4050,4048,4176,4176,4302,4302,4430,4428,4556,4554,4682,4808,4808,4934,5062,5060,5188,5314,5440,5568,5566,5694,5820,5946,6072,6198,6326,6452,6706,6832,6958,7084,7338,7462,7716,7842,8096,28,282,534,786,1040,1292,1544,1796,2048,2426,2806,3056,3306,3684,3934,4312,4562,4810,5060,5436,5556,5804,6050,6170,6290,6280,6272,6390,6380,6244,6108,5842,5578,5442,5050,4788,4524,4262,3872,3610,3220,2958,2696,2308,2048,1914,1654,1394,1134,876,616,356,98,8158,7900,7770,7512,7380,7122,6992,6862,6732,6474,6344,6216,6086,5956,5826,5696,5568,5566,5438,5308,5178,5050,5048,4920,4790,4790,4660,4532,4530,4402,4400,4272,4272,4142,4142,4014,4012,3884,3884,3754,3754,3754,3624,3624,3496,3494,3494,3366,3366,3364,3236,3236,3236,3108,3106,3106,3106,2978,2978,2976,2976,2848,2848,2848,2846,2718,2718,2718,2718,2590,2588,2588,2588,2588,2460,2460,2460,2458,2458,2458,2330,2330,2330,2330,2330,2328,2200,2200,2200,2200,2200,2200,2200
  dc.w    2150,2150,2276,2276,2276,2276,2276,2276,2404,2404,2404,2402,2402,2402,2530,2530,2530,2530,2528,2528,2656,2656,2656,2656,2656,2782,2782,2782,2782,2910,2910,2908,2908,2908,3036,3036,3034,3162,3162,3162,3160,3288,3288,3288,3416,3414,3414,3542,3540,3540,3668,3668,3794,3794,3794,3920,3920,4048,4046,4174,4174,4300,4300,4426,4426,4552,4552,4678,4678,4804,4932,4930,5058,5184,5312,5310,5436,5564,5690,5816,5942,6070,6196,6322,6448,6574,6700,6826,7080,7206,7330,7584,7710,7964,8088,150,274,526,778,1032,1284,1536,1914,2166,2418,2668,2918,3168,3546,3796,4046,4296,4544,4792,4912,5160,5280,5400,5520,5512,5504,5622,5614,5478,5342,5206,4942,4806,4542,4278,4016,3754,3492,3102,2840,2578,2316,2056,1796,1536,1402,1142,884,624,364,232,8166,8034,7776,7646,7388,7256,7126,6868,6738,6608,6478,6348,6218,6088,5960,5830,5700,5570,5442,5312,5310,5182,5052,4924,4922,4794,4664,4664,4534,4534,4404,4404,4274,4274,4144,4144,4016,4014,3886,3886,3756,3756,3756,3626,3626,3498,3498,3496,3368,3368,3366,3238,3238,3238,3110,3108,3108,3108,2980,2978,2978,2850,2850,2850,2848,2848,2720,2720,2720,2720,2590,2590,2590,2590,2590,2462,2462,2460,2460,2460,2460,2332,2332,2332,2330,2330,2330,2202,2202,2202,2202,2202,2202,2072
  dc.w    2148,2148,2276,2276,2276,2274,2274,2274,2402,2402,2402,2402,2402,2400,2400,2528,2528,2528,2528,2528,2654,2654,2654,2654,2654,2782,2780,2780,2780,2780,2908,2906,2906,2906,3034,3034,3032,3032,3160,3160,3160,3286,3286,3286,3414,3412,3412,3540,3538,3538,3666,3666,3664,3792,3792,3918,3918,3916,4044,4044,4170,4170,4296,4296,4424,4422,4550,4676,4676,4802,4928,4928,5054,5182,5180,5306,5434,5560,5686,5686,5812,5938,6064,6190,6316,6442,6568,6822,6948,7074,7200,7452,7578,7704,7956,8082,142,394,518,770,1024,1402,1654,1906,2028,2280,2530,2780,3032,3280,3530,3780,4030,4150,4398,4518,4640,4760,4752,4872,4864,4982,4846,4838,4702,4568,4432,4168,4032,3770,3508,3246,2982,2722,2460,2198,1938,1804,1544,1284,1024,892,632,500,240,8172,8042,7782,7652,7522,7262,7132,7002,6872,6614,6484,6354,6224,6094,5964,5834,5704,5704,5574,5444,5316,5186,5184,5056,4926,4926,4796,4666,4666,4536,4408,4406,4278,4278,4148,4148,4018,4018,3890,3888,3888,3758,3758,3630,3628,3628,3500,3500,3498,3370,3370,3368,3240,3240,3240,3110,3110,3110,2982,2982,2980,2980,2852,2852,2852,2850,2722,2722,2722,2722,2720,2592,2592,2592,2592,2592,2462,2462,2462,2462,2462,2334,2334,2332,2332,2332,2332,2332,2204,2204,2204,2202,2202,2202,2074
  dc.w    2146,2146,2274,2274,2274,2274,2274,2274,2272,2400,2400,2400,2400,2400,2400,2526,2526,2526,2526,2526,2654,2652,2652,2652,2652,2780,2780,2778,2778,2778,2906,2906,2904,2904,3032,3032,3032,3030,3158,3158,3158,3284,3284,3284,3284,3410,3410,3410,3536,3536,3664,3662,3662,3790,3788,3788,3916,3914,4042,4040,4168,4168,4294,4294,4420,4420,4546,4546,4672,4800,4798,4926,5052,5050,5178,5304,5430,5428,5556,5682,5808,5934,6060,6186,6312,6438,6564,6690,6816,6942,7068,7320,7446,7572,7824,7950,10,134,386,512,892,1142,1394,1518,1770,2020,2270,2394,2644,2894,3144,3264,3514,3636,3756,3878,3998,4118,4238,4230,4224,4344,4336,4200,4064,3928,3794,3658,3524,3262,3126,2864,2602,2340,2208,1946,1684,1424,1292,1032,770,512,508,248,116,8048,7918,7658,7528,7398,7138,7008,6878,6748,6618,6488,6358,6228,6098,5968,5838,5708,5578,5450,5448,5318,5188,5060,5058,4928,4800,4798,4670,4540,4540,4410,4410,4280,4280,4150,4150,4022,4020,3892,3890,3762,3762,3760,3632,3632,3630,3502,3502,3372,3372,3372,3242,3242,3242,3242,3112,3112,3112,2984,2982,2982,2982,2854,2854,2852,2852,2724,2724,2724,2722,2722,2594,2594,2594,2594,2592,2464,2464,2464,2464,2464,2334,2334,2334,2334,2334,2334,2206,2204,2204,2204,2204,2204,2204,2076
  dc.w    2146,2146,2272,2272,2272,2272,2272,2272,2272,2400,2398,2398,2398,2398,2398,2526,2526,2524,2524,2524,2652,2652,2652,2650,2650,2778,2778,2778,2776,2776,2904,2904,2904,2902,3030,3030,3030,3028,3156,3156,3156,3154,3282,3282,3282,3408,3408,3408,3534,3534,3534,3660,3660,3788,3786,3786,3914,3912,4040,4038,4166,4164,4292,4290,4418,4416,4544,4542,4670,4668,4796,4922,4920,5048,5174,5172,5300,5426,5552,5678,5678,5804,5930,6056,6182,6308,6434,6560,6684,6810,7064,7190,7314,7440,7692,7818,7942, 2,128,508,632,884,1134,1258,1510,1632,1884,2134,2256,2506,2628,2878,3000,3122,3242,3364,3484,3606,3598,3590,3712,3704,3696,3688,3554,3418,3284,3148,3014,2880,2618,2484,2222,2088,1826,1566,1432,1172,1040,778,518,386,128,124,8056,7924,7794,7534,7404,7272,7142,6884,6754,6622,6492,6362,6232,6102,5972,5842,5712,5712,5582,5452,5322,5194,5192,5062,4934,4932,4802,4674,4672,4544,4542,4414,4412,4284,4282,4154,4152,4024,4022,3894,3892,3764,3764,3762,3634,3634,3504,3504,3504,3374,3374,3374,3244,3244,3244,3116,3114,3114,3114,2986,2984,2984,2984,2856,2854,2854,2854,2726,2726,2724,2724,2724,2596,2596,2594,2594,2594,2466,2466,2466,2464,2464,2336,2336,2336,2336,2336,2334,2206,2206,2206,2206,2206,2206,2206,2076
  dc.w    2144,2144,2272,2272,2272,2270,2270,2270,2270,2398,2398,2398,2396,2396,2396,2524,2524,2524,2522,2522,2522,2650,2650,2650,2648,2648,2776,2776,2776,2774,2902,2902,2902,2900,3028,3028,3028,3026,3154,3154,3154,3152,3280,3280,3280,3406,3406,3406,3532,3532,3532,3658,3658,3658,3784,3784,3910,3910,3910,4036,4036,4162,4162,4288,4288,4414,4414,4540,4668,4666,4792,4792,4918,5044,5044,5170,5296,5294,5422,5548,5674,5800,5926,6052,6050,6176,6302,6428,6554,6806,6932,7058,7182,7308,7432,7686,7810,7936,124,248,500,624,876,998,1250,1374,1624,1746,1870,2120,2242,2364,2614,2736,2856,2978,2972,3092,3086,3078,3200,3192,3184,3178,3042,3036,2902,2766,2632,2370,2236,2102,1840,1708,1574,1312,1180,920,786,526,394,134, 2,7936,7932,7800,7542,7410,7280,7148,7018,6888,6628,6498,6368,6238,6108,6106,5976,5846,5716,5586,5456,5328,5326,5196,5066,5066,4936,4806,4806,4676,4674,4546,4416,4416,4286,4286,4156,4156,4026,4026,3896,3896,3896,3766,3766,3636,3636,3636,3506,3506,3506,3376,3376,3376,3246,3246,3246,3118,3116,3116,3116,2988,2986,2986,2986,2858,2856,2856,2856,2728,2726,2726,2726,2598,2598,2596,2596,2596,2468,2468,2468,2466,2466,2466,2338,2338,2338,2336,2336,2336,2208,2208,2208,2208,2206,2206,2206,2078
  dc.w    2142,2142,2270,2270,2270,2270,2270,2268,2268,2396,2396,2396,2396,2396,2394,2522,2522,2522,2522,2520,2520,2648,2648,2648,2648,2646,2774,2774,2774,2772,2772,2900,2900,2900,2898,3026,3026,3026,3024,3152,3152,3150,3278,3278,3278,3404,3404,3404,3402,3530,3530,3656,3656,3654,3782,3782,3780,3908,3906,4034,4032,4160,4160,4286,4286,4412,4410,4538,4536,4664,4662,4788,4916,4914,5040,5168,5166,5292,5418,5544,5542,5670,5796,5922,6048,6174,6298,6424,6550,6676,6802,6926,7052,7176,7302,7554,7680,7932,8056,116,240,364,616,740,990,1114,1238,1488,1610,1734,1856,1978,2100,2222,2342,2464,2586,2580,2700,2694,2688,2808,2802,2666,2660,2526,2392,2256,2122,1988,1854,1720,1588,1454,1192,1060,928,666,534,274,142,10,7942,7810,7680,7676,7416,7286,7154,7024,6892,6762,6632,6502,6372,6240,6110,5980,5850,5720,5592,5590,5460,5330,5200,5198,5070,4940,4938,4810,4680,4678,4550,4548,4420,4418,4288,4288,4158,4158,4030,4028,3900,3898,3770,3768,3768,3640,3638,3638,3508,3508,3380,3378,3378,3378,3248,3248,3248,3120,3118,3118,2990,2988,2988,2988,2860,2858,2858,2858,2730,2730,2728,2728,2728,2600,2598,2598,2598,2598,2470,2470,2468,2468,2468,2468,2340,2338,2338,2338,2338,2338,2210,2210,2208,2208,2208,2208,2208,2080
  dc.w    2142,2142,2140,2268,2268,2268,2268,2268,2268,2266,2394,2394,2394,2394,2394,2392,2520,2520,2520,2520,2520,2646,2646,2646,2646,2646,2772,2772,2772,2772,2770,2898,2898,2898,2896,3024,3024,3024,3022,3150,3150,3150,3276,3276,3276,3274,3402,3402,3400,3528,3528,3526,3654,3652,3780,3780,3778,3906,3904,4032,4030,4030,4156,4156,4282,4282,4408,4408,4534,4660,4660,4786,4784,4912,5038,5036,5162,5290,5288,5414,5540,5666,5792,5790,5916,6042,6168,6294,6418,6544,6670,6796,6920,7046,7170,7296,7676,7800,7924,8048,8172,232,356,480,604,856,978,1102,1224,1346,1598,1720,1842,1836,1958,2080,2072,2194,2188,2182,2176,2296,2290,2284,2150,2142,2008,1874,1868,1734,1600,1340,1206,1072,940,806,546,414,282,150,8082,7950,7818,7686,7554,7296,7292,7160,7030,6898,6768,6638,6508,6376,6246,6116,5986,5856,5854,5724,5594,5464,5334,5332,5204,5074,5072,4942,4814,4812,4682,4682,4552,4422,4422,4292,4292,4162,4162,4032,4032,4030,3902,3900,3772,3770,3770,3642,3640,3512,3510,3510,3382,3380,3380,3252,3250,3250,3250,3120,3120,3120,2992,2990,2990,2990,2862,2860,2860,2860,2732,2730,2730,2730,2730,2600,2600,2600,2600,2600,2470,2470,2470,2470,2470,2342,2340,2340,2340,2340,2340,2212,2210,2210,2210,2210,2210,2210,2082,2080
  dc.w    2140,2140,2140,2268,2268,2266,2266,2266,2266,2266,2394,2392,2392,2392,2392,2392,2520,2518,2518,2518,2518,2646,2644,2644,2644,2644,2644,2770,2770,2770,2770,2896,2896,2896,2896,3022,3022,3022,3020,3148,3148,3148,3146,3274,3274,3272,3400,3400,3398,3526,3526,3524,3652,3650,3650,3776,3776,3904,3902,3902,4028,4028,4154,4154,4280,4280,4406,4404,4532,4530,4656,4656,4782,4908,4908,5034,5160,5158,5284,5410,5410,5536,5662,5788,5914,5910,6036,6162,6288,6414,6538,6664,6790,6914,7040,7292,7416,7542,7794,7918,8042,8166,98,222,472,596,720,842,966,1088,1210,1334,1456,1578,1572,1694,1688,1810,1804,1798,1792,1912,1906,1900,1766,1760,1626,1620,1486,1352,1220,1086,952,820,686,554,422,160,28,8088,7956,7824,7692,7432,7302,7170,7040,7036,6904,6774,6644,6512,6382,6252,6122,5992,5988,5858,5728,5598,5468,5468,5338,5208,5206,5076,4946,4946,4816,4686,4686,4556,4554,4426,4424,4294,4294,4164,4164,4034,4034,3904,3904,3902,3774,3774,3644,3644,3642,3514,3512,3512,3384,3382,3382,3254,3252,3252,3124,3122,3122,3122,2994,2992,2992,2992,2862,2862,2862,2862,2732,2732,2732,2732,2602,2602,2602,2602,2602,2600,2472,2472,2472,2472,2470,2342,2342,2342,2342,2342,2340,2212,2212,2212,2212,2212,2210,2210,2082,2082
  dc.w    2138,2138,2138,2266,2266,2266,2266,2264,2264,2264,2392,2392,2392,2390,2390,2390,2518,2518,2516,2516,2516,2516,2644,2642,2642,2642,2642,2768,2768,2768,2768,2894,2894,2894,2894,2892,3020,3020,3020,3018,3146,3146,3144,3272,3272,3270,3270,3398,3396,3396,3524,3522,3522,3648,3648,3774,3774,3774,3900,3900,4026,4026,4152,4150,4150,4276,4276,4402,4400,4528,4654,4652,4780,4778,4904,5030,5030,5156,5282,5280,5406,5532,5530,5656,5782,5908,6034,6160,6156,6282,6408,6532,6658,6784,7036,7160,7286,7410,7534,7658,7782,8034,8158,90,214,338,460,584,708,830,952,948,1070,1192,1314,1308,1430,1426,1420,1414,1408,1528,1522,1516,1512,1378,1372,1238,1104,970,966,832,698,566,434,300,168,36,8096,7964,7704,7572,7440,7308,7176,7046,6914,6784,6780,6650,6518,6388,6258,6254,6124,5994,5864,5734,5604,5602,5472,5342,5340,5210,5080,5080,4950,4820,4818,4690,4688,4558,4430,4428,4298,4298,4168,4168,4166,4036,4036,3906,3906,3776,3776,3776,3646,3646,3516,3516,3514,3386,3386,3384,3256,3256,3254,3254,3126,3124,3124,2996,2994,2994,2994,2866,2864,2864,2864,2864,2734,2734,2734,2734,2604,2604,2604,2604,2602,2474,2474,2474,2474,2472,2472,2344,2344,2344,2342,2342,2342,2214,2214,2214,2212,2212,2212,2212,2084,2084
  dc.w    2138,2138,2138,2264,2264,2264,2264,2264,2264,2262,2390,2390,2390,2390,2388,2388,2516,2516,2516,2514,2514,2514,2642,2642,2640,2640,2640,2768,2766,2766,2766,2766,2892,2892,2892,2892,3018,3018,3018,3016,3144,3144,3142,3142,3270,3268,3268,3396,3394,3394,3520,3520,3520,3646,3646,3644,3772,3770,3898,3896,3896,4022,4022,4148,4148,4274,4274,4400,4398,4526,4524,4650,4648,4776,4902,4900,5026,5024,5152,5278,5276,5402,5528,5654,5652,5778,5902,6028,6154,6280,6276,6402,6528,6780,6904,7030,7154,7280,7404,7528,7652,7776,7900,8024,8148,80,202,326,448,572,566,690,812,806,930,1052,1046,1040,1034,1156,1152,1274,1140,1134,1128,1122,988,856,850,716,584,578,446,312,180,46,8106,7974,7842,7710,7578,7446,7314,7182,7052,6920,6790,6658,6528,6524,6394,6390,6260,6130,6000,5868,5738,5736,5606,5476,5346,5344,5214,5086,5084,4954,4952,4822,4694,4692,4562,4560,4432,4430,4300,4300,4170,4170,4040,4040,3910,3910,3908,3780,3778,3650,3648,3648,3518,3518,3518,3388,3388,3386,3258,3258,3256,3128,3128,3126,3126,2998,2996,2996,2996,2866,2866,2866,2866,2736,2736,2736,2736,2734,2606,2606,2606,2604,2604,2476,2476,2476,2474,2474,2474,2346,2346,2344,2344,2344,2344,2216,2214,2214,2214,2214,2214,2214,2084,2084
  dc.w    2136,2136,2136,2136,2264,2262,2262,2262,2262,2262,2388,2388,2388,2388,2388,2388,2386,2514,2514,2514,2512,2512,2640,2640,2640,2638,2638,2766,2766,2764,2764,2764,2892,2890,2890,2890,3016,3016,3016,3014,3142,3142,3140,3140,3268,3266,3266,3394,3392,3392,3518,3518,3518,3644,3644,3642,3770,3768,3768,3894,3894,4020,4020,4146,4146,4144,4270,4270,4396,4394,4522,4520,4646,4772,4772,4898,4896,5022,5148,5146,5272,5398,5396,5522,5648,5774,5772,5898,6024,6148,6274,6272,6524,6650,6774,6898,7024,7148,7272,7398,7522,7646,7770,7766,7890,8012,8136,68,190,314,310,432,554,550,672,666,662,784,778,772,768,890,884,878,744,740,734,600,596,462,328,324,192,58,8118,7986,7852,7720,7716,7584,7452,7320,7190,7058,6926,6796,6664,6532,6402,6272,6396,6266,6134,6004,5874,5872,5742,5612,5482,5480,5350,5220,5218,5088,4958,4956,4826,4826,4696,4566,4564,4436,4434,4304,4304,4174,4172,4172,4042,4042,3912,3912,3782,3782,3780,3652,3650,3650,3520,3520,3520,3390,3390,3388,3260,3260,3258,3130,3130,3128,3128,3000,2998,2998,2998,2868,2868,2868,2866,2738,2738,2738,2736,2736,2608,2608,2606,2606,2606,2478,2478,2476,2476,2476,2348,2346,2346,2346,2346,2346,2346,2216,2216,2216,2216,2216,2214,2086,2086,2086
  dc.w    2136,2134,2134,2134,2262,2262,2262,2260,2260,2260,2260,2388,2386,2386,2386,2386,2386,2512,2512,2512,2512,2512,2510,2638,2638,2638,2636,2636,2764,2764,2762,2762,2890,2888,2888,2888,2888,3014,3014,3014,3012,3140,3140,3138,3266,3264,3264,3264,3390,3390,3390,3516,3516,3514,3642,3640,3640,3766,3766,3892,3892,3890,4018,4016,4142,4142,4268,4268,4394,4392,4518,4518,4644,4642,4768,4768,4894,5020,5018,5144,5142,5268,5394,5392,5518,5644,5770,5766,5892,6018,6144,6396,6394,6518,6644,6768,6892,7018,7142,7138,7262,7388,7512,7636,7758,7882,7878,8002,8126,56,52,174,170,292,288,410,404,400,522,516,512,634,628,494,490,484,350,346,212,208,74,70,8128,7996,7864,7860,7728,7594,7462,7330,7200,7068,7064,6932,6802,6670,6538,6408,6276,6274,6144,6140,6010,5880,5876,5746,5616,5486,5484,5354,5224,5222,5092,5090,4960,4830,4830,4700,4698,4568,4568,4438,4436,4306,4306,4176,4176,4046,4044,3916,3914,3914,3784,3784,3654,3654,3652,3524,3522,3522,3392,3392,3392,3262,3262,3262,3260,3132,3130,3130,3002,3000,3000,3000,2870,2870,2870,2870,2868,2740,2740,2738,2738,2610,2610,2608,2608,2608,2480,2478,2478,2478,2478,2478,2348,2348,2348,2348,2348,2346,2218,2218,2218,2218,2216,2216,2216,2088,2088,2088
  dc.w    2134,2134,2134,2132,2260,2260,2260,2260,2258,2258,2258,2386,2386,2386,2384,2384,2384,2512,2510,2510,2510,2510,2510,2636,2636,2636,2636,2634,2762,2762,2760,2760,2760,2888,2886,2886,2886,3012,3012,3012,3010,3138,3138,3136,3136,3264,3262,3262,3388,3388,3388,3514,3514,3512,3640,3638,3638,3764,3764,3762,3890,3888,4016,4014,4012,4140,4138,4264,4264,4390,4388,4516,4514,4640,4638,4764,4890,4890,5016,5014,5140,5266,5264,5390,5516,5512,5638,5764,5762,5888,6140,6266,6390,6388,6512,6638,6762,6888,6884,7008,7132,7256,7380,7376,7500,7624,7748,7744,7868,7990,7986,8110,8104,36,30,154,148,142,138,260,256,378,244,240,234,228,96,90,8150,8144,8012,8008,7874,7742,7738,7606,7474,7342,7338,7206,7074,6942,6810,6806,6676,6544,6414,6282,6280,6148,6018,5888,5884,5882,5752,5622,5618,5488,5358,5356,5226,5096,5094,4964,4964,4834,4704,4702,4572,4570,4442,4440,4310,4310,4180,4178,4050,4048,4046,3918,3916,3788,3786,3786,3656,3656,3654,3526,3524,3524,3394,3394,3394,3264,3264,3262,3134,3134,3132,3132,3004,3002,3002,3002,2872,2872,2872,2870,2742,2742,2742,2740,2740,2612,2610,2610,2610,2610,2480,2480,2480,2480,2480,2478,2350,2350,2350,2348,2348,2348,2220,2220,2220,2218,2218,2218,2218,2090,2088,2088
  dc.w    2132,2132,2132,2132,2260,2258,2258,2258,2258,2258,2256,2384,2384,2384,2384,2382,2382,2382,2510,2508,2508,2508,2508,2636,2634,2634,2634,2632,2760,2760,2760,2758,2758,2886,2884,2884,2884,3012,3010,3010,3008,3136,3136,3134,3134,3262,3260,3260,3258,3386,3386,3384,3512,3510,3510,3636,3636,3634,3762,3760,3888,3886,3884,4012,4010,4138,4136,4262,4262,4388,4386,4384,4512,4638,4636,4762,4760,4886,4884,5010,5010,5136,5260,5258,5384,5510,5508,5634,5760,5884,6010,6134,6260,6258,6382,6508,6632,6628,6754,6878,7002,7126,7122,7246,7370,7366,7490,7614,7610,7732,7856,7852,7974,7970,7966,8088,8084,8078,8074,8068, 0,8186,8180,8176,8170,8166,8032,8028,8024,7890,7886,7754,7620,7616,7484,7352,7348,7216,7084,7080,6948,6816,6684,6554,6550,6418,6288,6156,6154,6024,5892,5762,5760,5756,5626,5624,5494,5364,5362,5230,5100,5100,4970,4968,4838,4836,4706,4704,4574,4446,4444,4442,4312,4312,4182,4180,4052,4050,3922,3920,3918,3790,3788,3660,3658,3658,3528,3528,3526,3398,3396,3396,3268,3266,3266,3264,3136,3136,3134,3134,3006,3004,3004,3002,2874,2874,2874,2872,2744,2744,2742,2742,2742,2614,2612,2612,2612,2610,2482,2482,2482,2482,2480,2352,2352,2352,2350,2350,2350,2350,2222,2220,2220,2220,2220,2220,2218,2090,2090,2090
  dc.w    2132,2130,2130,2130,2130,2258,2258,2256,2256,2256,2256,2256,2382,2382,2382,2382,2380,2380,2508,2508,2508,2506,2506,2506,2634,2632,2632,2632,2630,2758,2758,2758,2756,2884,2884,2882,2882,2882,3008,3008,3008,3006,3134,3134,3132,3132,3258,3258,3256,3384,3384,3382,3510,3508,3508,3634,3634,3632,3760,3758,3758,3884,3882,4010,4008,4006,4134,4132,4258,4258,4384,4382,4508,4508,4634,4632,4758,4756,4882,4880,5006,5132,5130,5256,5254,5380,5506,5504,5756,5882,5880,6004,6130,6254,6252,6376,6502,6498,6622,6748,6872,6868,6992,7116,7112,7236,7360,7356,7480,7476,7598,7594,7718,7714,7836,7832,7826,7822,7816,7940,7936,8058,7926,7920,7916,7910,7906,7772,7768,7636,7632,7498,7494,7362,7358,7226,7094,7090,6958,6826,6822,6690,6560,6428,6424,6294,6162,6160,6028,5898,5766,5764,5634,5504,5628,5498,5368,5366,5236,5234,5104,4974,4972,4842,4840,4710,4708,4578,4578,4448,4446,4316,4316,4186,4184,4056,4054,4052,3924,3922,3792,3792,3790,3662,3660,3660,3530,3530,3528,3400,3398,3398,3270,3268,3268,3138,3138,3136,3136,3008,3006,3006,3006,2876,2876,2876,2874,2874,2746,2744,2744,2744,2616,2614,2614,2614,2612,2484,2484,2484,2482,2482,2482,2354,2354,2352,2352,2352,2352,2222,2222,2222,2222,2222,2220,2220,2092,2092,2092,2092
  dc.w    2130,2130,2130,2128,2128,2256,2256,2256,2254,2254,2254,2254,2382,2380,2380,2380,2380,2380,2506,2506,2506,2506,2504,2504,2632,2630,2630,2630,2630,2756,2756,2756,2754,2754,2882,2880,2880,2880,3006,3006,3006,3004,3132,3132,3130,3130,3256,3256,3256,3382,3382,3380,3380,3506,3506,3504,3632,3630,3630,3756,3754,3882,3880,3880,4006,4004,4132,4130,4128,4256,4254,4380,4378,4504,4504,4630,4628,4754,4752,4878,5004,5002,5128,5126,5252,5250,5376,5628,5626,5752,5876,5874,6000,6124,6122,6246,6372,6368,6492,6618,6614,6738,6862,6858,6982,7106,7102,7226,7222,7346,7342,7466,7460,7456,7580,7574,7570,7694,7688,7684,7680,7802,7798,7792,7660,7656,7650,7518,7514,7508,7376,7372,7240,7236,7104,7100,6968,6836,6832,6700,6568,6564,6434,6302,6298,6168,6036,6034,5902,5772,5770,5638,5508,5506,5376,5372,5370,5240,5238,5108,5106,4976,4846,4844,4714,4712,4582,4582,4452,4450,4320,4318,4190,4188,4186,4058,4056,3926,3926,3924,3796,3794,3664,3664,3662,3534,3532,3532,3402,3402,3400,3400,3270,3270,3270,3140,3140,3138,3138,3010,3008,3008,3008,2878,2878,2878,2876,2748,2748,2746,2746,2746,2616,2616,2616,2616,2614,2486,2486,2484,2484,2484,2484,2354,2354,2354,2354,2354,2352,2224,2224,2224,2224,2222,2222,2222,2094,2094,2092,2092
  dc.w    2128,2128,2128,2128,2128,2254,2254,2254,2254,2254,2252,2252,2380,2380,2380,2378,2378,2378,2378,2504,2504,2504,2504,2502,2630,2630,2628,2628,2628,2756,2754,2754,2754,2752,2880,2880,2878,2878,2878,3004,3004,3004,3002,3130,3128,3128,3254,3254,3254,3252,3380,3378,3378,3504,3504,3502,3630,3628,3628,3754,3752,3752,3878,3878,4004,4002,4002,4128,4126,4252,4252,4378,4376,4374,4500,4500,4626,4624,4750,4748,4874,5000,4998,5124,5122,5248,5372,5498,5624,5622,5746,5872,5868,5994,5992,6116,6240,6238,6362,6488,6484,6608,6732,6728,6852,6848,6974,6968,7092,7088,7212,7208,7332,7328,7322,7318,7442,7436,7432,7428,7424,7546,7542,7538,7532,7400,7396,7390,7386,7254,7250,7118,7114,6982,6976,6846,6842,6710,6706,6574,6442,6438,6308,6176,6174,6042,5910,5908,5778,5774,5644,5512,5510,5380,5250,5248,5244,5242,5112,5110,4980,4850,4848,4718,4716,4586,4586,4456,4454,4452,4322,4322,4192,4190,4060,4060,4058,3928,3928,3798,3798,3796,3666,3666,3664,3536,3534,3534,3404,3404,3402,3274,3272,3272,3272,3142,3142,3140,3012,3010,3010,3010,2880,2880,2880,2878,2878,2750,2748,2748,2748,2746,2618,2618,2618,2616,2616,2488,2486,2486,2486,2486,2356,2356,2356,2356,2354,2354,2354,2226,2226,2224,2224,2224,2224,2224,2094,2094,2094,2094
  dc.w    2128,2128,2126,2126,2126,2126,2254,2252,2252,2252,2252,2252,2250,2378,2378,2378,2376,2376,2376,2504,2502,2502,2502,2502,2500,2628,2628,2626,2626,2626,2752,2752,2752,2752,2750,2878,2878,2876,2876,3002,3002,3002,3000,3128,3126,3126,3126,3252,3252,3250,3378,3376,3376,3374,3502,3500,3500,3626,3626,3624,3750,3750,3876,3876,3874,4000,4000,3998,4124,4122,4250,4248,4374,4372,4498,4498,4624,4622,4748,4746,4872,4870,4996,4994,5120,5244,5370,5368,5494,5618,5616,5742,5738,5864,5988,5986,6110,6108,6232,6358,6354,6478,6474,6598,6596,6720,6844,6840,6836,6960,6956,7078,7074,7070,7194,7190,7186,7180,7176,7172,7168,7290,7286,7282,7276,7272,7268,7136,7132,7128,6994,6990,6858,6854,6850,6718,6586,6584,6452,6448,6316,6312,6182,6050,6048,5916,5914,5782,5652,5648,5518,5516,5384,5254,5252,5122,5120,5116,5114,4984,4982,4852,4850,4720,4718,4588,4588,4458,4456,4326,4324,4196,4194,4064,4062,4062,3932,3930,3930,3800,3800,3670,3668,3668,3538,3538,3536,3408,3406,3406,3404,3276,3274,3274,3144,3144,3144,3142,3014,3012,3012,3012,2882,2882,2880,2880,2752,2750,2750,2750,2750,2620,2620,2620,2618,2618,2490,2488,2488,2488,2488,2486,2358,2358,2358,2356,2356,2356,2228,2226,2226,2226,2226,2226,2224,2096,2096,2096,2096,2094
  dc.w    2126,2126,2126,2126,2124,2124,2252,2252,2250,2250,2250,2250,2250,2376,2376,2376,2376,2374,2374,2502,2502,2500,2500,2500,2500,2626,2626,2626,2624,2624,2752,2750,2750,2750,2748,2876,2876,2874,2874,2874,3000,3000,2998,2998,3126,3124,3124,3250,3250,3248,3248,3374,3374,3372,3500,3498,3498,3624,3624,3622,3748,3748,3746,3874,3872,3870,3998,3996,4122,4120,4120,4246,4244,4370,4368,4494,4494,4620,4618,4744,4742,4868,4866,4992,5116,5242,5240,5366,5364,5488,5486,5612,5736,5734,5858,5856,5980,6106,6102,6228,6224,6348,6344,6470,6466,6590,6586,6710,6706,6830,6826,6822,6946,6942,6938,6932,7056,7052,7048,7044,7040,7162,7158,7154,7150,7018,7012,7008,7004,6872,6868,6864,6732,6728,6596,6592,6460,6456,6326,6322,6190,6186,6056,6052,5922,5790,5788,5656,5654,5522,5392,5390,5258,5256,5126,5124,4994,4992,4988,4986,4856,4854,4724,4722,4592,4592,4462,4460,4330,4328,4198,4198,4196,4066,4064,3936,3934,3932,3804,3802,3802,3672,3670,3670,3540,3540,3538,3410,3408,3408,3278,3278,3276,3276,3146,3146,3144,3016,3016,3014,3014,2884,2884,2884,2882,2882,2754,2752,2752,2752,2750,2622,2622,2620,2620,2620,2490,2490,2490,2490,2488,2488,2360,2360,2358,2358,2358,2358,2228,2228,2228,2228,2228,2226,2226,2098,2098,2096,2096,2096
  dc.w    2126,2124,2124,2124,2124,2122,2250,2250,2250,2250,2248,2248,2248,2376,2374,2374,2374,2374,2372,2372,2500,2500,2498,2498,2498,2624,2624,2624,2624,2622,2622,2750,2748,2748,2748,2746,2874,2874,2872,2872,2998,2998,2998,2996,3124,3122,3122,3120,3248,3246,3246,3244,3372,3370,3370,3496,3496,3494,3622,3620,3618,3746,3744,3744,3870,3868,3996,3994,3992,4118,4118,4244,4242,4240,4366,4364,4490,4490,4616,4614,4740,4738,4864,4988,5114,5112,5238,5236,5362,5358,5484,5482,5606,5604,5728,5854,5850,5976,5972,6098,6094,6218,6216,6340,6336,6460,6456,6452,6576,6572,6696,6692,6688,6812,6808,6804,6800,6796,6792,6788,6784,6906,6902,6898,6894,6890,6886,6882,6750,6746,6742,6610,6606,6474,6470,6466,6334,6330,6198,6196,6064,6060,5930,5926,5796,5792,5662,5530,5528,5396,5394,5264,5260,5130,5128,4998,4996,4866,4864,4860,4858,4728,4726,4596,4596,4466,4464,4334,4332,4330,4200,4200,4070,4068,4066,3938,3936,3806,3806,3804,3676,3674,3672,3544,3542,3542,3412,3412,3410,3282,3280,3280,3278,3150,3148,3148,3146,3018,3016,3016,3016,2886,2886,2884,2884,2756,2754,2754,2754,2752,2624,2624,2622,2622,2622,2622,2492,2492,2492,2490,2490,2362,2362,2360,2360,2360,2360,2358,2230,2230,2230,2228,2228,2228,2228,2100,2098,2098,2098,2098
  dc.w    2124,2124,2122,2122,2122,2122,2122,2248,2248,2248,2248,2248,2246,2246,2374,2374,2372,2372,2372,2370,2498,2498,2498,2496,2496,2496,2622,2622,2622,2622,2620,2748,2748,2746,2746,2744,2872,2872,2870,2870,2998,2996,2996,2994,2994,3120,3120,3120,3246,3246,3244,3244,3370,3370,3368,3494,3494,3492,3492,3618,3618,3616,3742,3742,3868,3866,3866,3992,3990,3988,4116,4114,4240,4238,4236,4362,4360,4486,4486,4612,4610,4736,4860,4986,4984,5110,5108,5234,5230,5356,5354,5480,5476,5602,5598,5724,5720,5846,5842,5968,5964,6088,6086,6210,6206,6330,6328,6324,6448,6444,6440,6564,6560,6556,6552,6676,6672,6668,6664,6660,6656,6778,6774,6770,6766,6762,6630,6626,6622,6618,6486,6482,6478,6346,6342,6340,6208,6204,6072,6070,5938,5934,5804,5800,5670,5666,5536,5532,5402,5398,5268,5266,5136,5132,5002,5000,4870,4868,4738,4736,4732,4730,4600,4600,4470,4468,4338,4336,4334,4204,4202,4074,4072,4070,3940,3940,3938,3808,3808,3678,3676,3676,3546,3546,3544,3544,3414,3412,3412,3282,3282,3280,3280,3150,3150,3150,3020,3020,3018,3018,3016,2888,2888,2886,2886,2758,2756,2756,2754,2754,2626,2624,2624,2624,2624,2494,2494,2494,2492,2492,2492,2364,2362,2362,2362,2360,2360,2232,2232,2230,2230,2230,2230,2230,2100,2100,2100,2100,2100,2098
  dc.w    2122,2122,2122,2122,2120,2120,2120,2248,2248,2246,2246,2246,2246,2244,2372,2372,2372,2370,2370,2370,2496,2496,2496,2496,2494,2494,2622,2620,2620,2620,2618,2618,2746,2744,2744,2744,2870,2870,2870,2868,2868,2994,2994,2992,2992,3120,3118,3118,3116,3244,3242,3242,3240,3368,3366,3366,3492,3490,3490,3616,3616,3614,3740,3740,3738,3864,3864,3862,3988,3986,3986,4112,4110,4236,4234,4360,4358,4356,4482,4482,4608,4732,4858,4856,4982,4980,5106,5104,5100,5226,5224,5350,5346,5472,5468,5594,5592,5716,5712,5838,5834,5960,5956,6080,6078,6074,6198,6194,6318,6314,6310,6308,6432,6428,6424,6420,6416,6540,6536,6532,6528,6650,6646,6642,6510,6506,6502,6498,6494,6362,6360,6356,6352,6220,6216,6084,6080,6078,5946,5942,5812,5808,5678,5674,5542,5540,5410,5406,5276,5272,5142,5140,5010,5006,5004,4874,4872,4742,4740,4610,4608,4604,4604,4474,4472,4470,4340,4338,4208,4206,4076,4076,4074,3944,3942,3942,3812,3810,3810,3680,3678,3678,3548,3548,3546,3416,3416,3414,3286,3284,3284,3282,3154,3152,3152,3150,3022,3022,3020,3020,2890,2890,2888,2888,2888,2758,2758,2758,2756,2628,2628,2626,2626,2626,2624,2496,2496,2494,2494,2494,2494,2364,2364,2364,2362,2362,2362,2234,2232,2232,2232,2232,2230,2230,2102,2102,2102,2100,2100,2100
  dc.w    2122,2120,2120,2120,2120,2120,2118,2246,2246,2246,2244,2244,2244,2244,2370,2370,2370,2370,2368,2368,2368,2496,2494,2494,2494,2492,2492,2620,2618,2618,2618,2616,2744,2744,2742,2742,2740,2868,2868,2866,2866,2992,2992,2992,2990,2990,3116,3116,3114,3114,3240,3240,3238,3366,3364,3364,3362,3488,3488,3486,3614,3612,3610,3738,3736,3734,3862,3860,3858,3984,3984,4110,4108,4106,4232,4230,4356,4354,4352,4480,4604,4730,4728,4854,4852,4850,4976,4974,5100,5096,5222,5220,5344,5342,5468,5464,5590,5586,5712,5708,5704,5830,5826,5952,5948,5944,6068,6066,6062,6186,6182,6178,6302,6298,6294,6290,6286,6282,6278,6274,6272,6396,6392,6388,6384,6380,6376,6372,6368,6236,6232,6228,6096,6092,6090,5958,5954,5950,5820,5816,5686,5682,5678,5548,5544,5414,5410,5280,5278,5146,5144,5014,5010,4880,4878,4748,4746,4744,4614,4612,4482,4480,4478,4476,4474,4344,4342,4212,4210,4208,4078,4078,3948,3946,3944,3816,3814,3812,3684,3682,3680,3552,3550,3550,3420,3418,3418,3416,3288,3286,3286,3156,3156,3154,3154,3024,3024,3022,3022,3022,2892,2892,2890,2890,2762,2760,2760,2758,2758,2630,2628,2628,2628,2626,2498,2498,2496,2496,2496,2494,2366,2366,2366,2364,2364,2364,2364,2234,2234,2234,2234,2232,2232,2232,2104,2102,2102,2102,2102,2102
  dc.w    2120,2120,2120,2118,2118,2118,2118,2118,2244,2244,2244,2244,2242,2242,2242,2368,2368,2368,2368,2366,2366,2494,2494,2492,2492,2492,2490,2618,2618,2616,2616,2616,2742,2742,2740,2740,2740,2866,2866,2866,2864,2864,2990,2990,2988,2988,3114,3114,3112,3112,3238,3238,3236,3236,3362,3362,3360,3488,3486,3484,3484,3610,3608,3608,3734,3732,3732,3858,3856,3854,3982,3980,4106,4104,4102,4228,4226,4352,4352,4478,4604,4600,4726,4724,4850,4848,4846,4972,4970,5094,5092,5218,5214,5340,5338,5334,5460,5456,5582,5578,5704,5700,5696,5822,5818,5814,5940,5936,5932,6056,6054,6050,6046,6170,6166,6162,6158,6154,6150,6146,6144,6268,6264,6260,6256,6252,6248,6244,6112,6108,6104,6102,5970,5966,5962,5832,5828,5824,5694,5690,5686,5556,5552,5422,5418,5288,5284,5282,5152,5148,5018,5016,4884,4882,4752,4750,4748,4618,4616,4486,4482,4352,4352,4478,4348,4346,4216,4214,4212,4082,4080,3952,3950,3948,3818,3818,3816,3686,3686,3684,3554,3554,3552,3550,3422,3420,3420,3290,3290,3288,3288,3158,3158,3156,3156,3026,3026,3024,3024,2894,2894,2892,2892,2892,2762,2762,2762,2760,2760,2630,2630,2630,2628,2628,2500,2498,2498,2498,2496,2496,2368,2368,2366,2366,2366,2366,2236,2236,2236,2234,2234,2234,2234,2104,2104,2104,2104,2104,2102,2102
  dc.w    2118,2118,2118,2118,2118,2116,2116,2116,2244,2242,2242,2242,2242,2240,2240,2368,2368,2366,2366,2366,2364,2364,2492,2490,2490,2490,2490,2488,2616,2616,2614,2614,2612,2740,2740,2738,2738,2738,2864,2864,2862,2862,2860,2988,2988,2986,2986,3112,3112,3110,3110,3236,3236,3234,3232,3360,3358,3358,3484,3482,3482,3608,3608,3606,3732,3730,3730,3856,3854,3852,3980,3978,3976,4102,4100,4098,4224,4224,4478,4476,4474,4600,4596,4722,4720,4718,4844,4842,4968,4964,5090,5088,5086,5210,5208,5332,5330,5328,5452,5450,5574,5570,5568,5692,5690,5686,5810,5806,5804,5928,5924,5920,5916,6042,6038,6034,6030,6026,6022,6018,6016,6140,6136,6132,6128,6124,6120,6116,5986,5982,5978,5974,5842,5840,5836,5704,5700,5698,5566,5564,5560,5428,5426,5294,5292,5290,5158,5156,5024,5022,5020,4890,4886,4756,4754,4624,4622,4620,4490,4486,4356,4354,4352,4224,4350,4220,4218,4216,4086,4084,4082,3954,3952,3950,3820,3820,3818,3688,3686,3686,3556,3556,3554,3424,3424,3422,3294,3292,3290,3290,3160,3160,3158,3158,3028,3028,3026,3026,2898,2896,2896,2894,2894,2764,2764,2764,2762,2762,2634,2632,2632,2630,2630,2502,2500,2500,2500,2500,2498,2370,2370,2368,2368,2368,2366,2366,2238,2238,2236,2236,2236,2236,2234,2106,2106,2106,2104,2104,2104,2104
  dc.w    2118,2118,2116,2116,2116,2116,2114,2114,2242,2242,2240,2240,2240,2240,2238,2238,2366,2366,2364,2364,2364,2362,2490,2490,2488,2488,2488,2486,2614,2614,2612,2612,2612,2738,2738,2738,2736,2736,2862,2862,2862,2860,2860,2986,2986,2984,2984,3110,3110,3108,3108,3234,3234,3232,3232,3358,3356,3356,3354,3482,3480,3478,3606,3604,3602,3730,3728,3726,3852,3850,3850,3976,3974,3972,4098,4096,4096,4350,4348,4474,4472,4470,4596,4592,4718,4716,4714,4840,4838,4964,4960,4958,5084,5080,5206,5204,5200,5326,5322,5448,5444,5442,5566,5564,5560,5684,5682,5678,5674,5798,5796,5792,5788,5784,5910,5906,5902,5898,5894,5890,5888,6012,6008,6004,6000,5996,5992,5862,5858,5854,5850,5848,5716,5712,5708,5706,5574,5570,5568,5436,5434,5430,5300,5296,5166,5162,5160,5030,5026,4896,4894,4890,4760,4758,4628,4626,4624,4494,4490,4360,4358,4356,4226,4224,4096,4222,4220,4090,4088,4086,3956,3956,3954,3824,3822,3820,3692,3690,3688,3560,3558,3556,3428,3426,3426,3424,3294,3294,3292,3292,3162,3162,3160,3160,3030,3030,3028,3028,2898,2898,2896,2896,2896,2766,2766,2764,2764,2764,2634,2634,2634,2632,2632,2504,2502,2502,2502,2500,2500,2372,2370,2370,2370,2368,2368,2240,2240,2238,2238,2238,2238,2236,2236,2108,2108,2106,2106,2106,2106,2104
  dc.w    1988,2116,2116,2116,2114,2114,2114,2114,2112,2240,2240,2240,2238,2238,2238,2238,2364,2364,2364,2362,2362,2362,2360,2488,2488,2486,2486,2486,2484,2612,2612,2610,2610,2610,2736,2736,2734,2734,2734,2860,2860,2858,2858,2856,2984,2982,2982,2980,3108,3106,3106,3104,3232,3230,3230,3228,3356,3354,3352,3480,3478,3476,3476,3602,3600,3600,3726,3724,3722,3850,3848,3846,3972,3970,3968,4096,4222,4220,4346,4344,4470,4468,4466,4592,4588,4586,4712,4710,4836,4834,4830,4956,4954,5080,5076,5074,5198,5196,5194,5318,5316,5312,5438,5434,5430,5556,5552,5548,5546,5670,5666,5664,5660,5656,5780,5778,5774,5770,5766,5762,5760,5884,5880,5876,5872,5868,5866,5734,5730,5726,5724,5720,5588,5586,5582,5578,5448,5444,5440,5310,5306,5304,5172,5170,5168,5036,5034,5030,4900,4898,4768,4764,4762,4632,4630,4500,4498,4494,4364,4362,4360,4230,4228,4098,4096,4096,4094,4092,4090,3960,3958,3956,3828,3826,3824,3694,3694,3692,3562,3562,3560,3558,3430,3428,3426,3298,3296,3296,3294,3166,3164,3164,3162,3034,3032,3032,3030,2902,2900,2900,2898,2898,2768,2768,2768,2766,2766,2636,2636,2636,2634,2634,2506,2504,2504,2504,2502,2502,2374,2372,2372,2372,2370,2370,2370,2240,2240,2240,2240,2238,2238,2238,2110,2108,2108,2108,2108,2106,2106,2106
  dc.w    1988,2114,2114,2114,2114,2112,2112,2112,2112,2238,2238,2238,2238,2236,2236,2236,2364,2362,2362,2362,2360,2360,2360,2486,2486,2486,2484,2484,2484,2610,2610,2610,2608,2608,2606,2734,2734,2732,2732,2730,2858,2858,2856,2856,2982,2982,2980,2980,2978,3106,3104,3104,3102,3228,3228,3226,3226,3352,3350,3350,3476,3476,3474,3472,3598,3598,3596,3722,3720,3720,3846,3844,3842,3968,3968,4094,4220,4218,4216,4342,4340,4338,4464,4462,4588,4586,4582,4708,4706,4704,4830,4826,4952,4950,4946,5072,5070,5066,5192,5188,5186,5310,5308,5304,5430,5426,5424,5420,5544,5542,5538,5534,5532,5656,5652,5648,5646,5642,5638,5634,5632,5756,5752,5748,5744,5742,5738,5734,5602,5600,5596,5592,5590,5458,5454,5452,5448,5318,5314,5312,5180,5178,5174,5044,5040,5038,4908,4904,4902,4772,4768,4638,4636,4634,4504,4500,4498,4368,4366,4236,4234,4232,4102,4100,4098,3968,3968,4094,3964,3962,3960,3830,3830,3828,3698,3696,3696,3566,3564,3562,3562,3432,3432,3430,3300,3300,3298,3298,3168,3166,3166,3164,3036,3034,3034,3032,3032,2902,2902,2900,2900,2772,2770,2770,2768,2768,2640,2638,2638,2636,2636,2636,2506,2506,2506,2504,2504,2504,2374,2374,2374,2372,2372,2372,2370,2242,2242,2242,2240,2240,2240,2240,2110,2110,2110,2110,2108,2108,2108,2108
  dc.w    1986,2114,2114,2112,2112,2112,2112,2110,2110,2110,2238,2236,2236,2236,2234,2234,2234,2362,2360,2360,2360,2358,2358,2486,2484,2484,2484,2482,2482,2482,2608,2608,2608,2606,2606,2732,2732,2732,2730,2730,2856,2856,2854,2854,2852,2980,2978,2978,2976,3104,3102,3102,3100,3228,3226,3224,3224,3350,3350,3348,3346,3474,3472,3470,3598,3596,3594,3592,3720,3718,3716,3842,3840,3840,4094,4092,4090,4216,4214,4212,4338,4336,4334,4460,4458,4456,4582,4578,4704,4702,4700,4826,4822,4820,4946,4942,4940,5066,5062,5060,5184,5182,5178,5176,5300,5298,5294,5290,5416,5412,5410,5406,5402,5528,5524,5520,5516,5514,5510,5506,5504,5628,5624,5620,5618,5614,5610,5606,5476,5472,5468,5466,5462,5332,5328,5324,5322,5190,5188,5184,5182,5050,5048,5044,4914,4912,4908,4778,4776,4772,4642,4640,4638,4508,4504,4374,4372,4370,4240,4238,4236,4106,4104,4102,3972,3970,3968,3840,3966,3964,3834,3832,3830,3702,3700,3698,3696,3568,3566,3564,3436,3434,3432,3432,3302,3302,3300,3298,3170,3168,3168,3166,3038,3036,3036,3034,2906,2904,2904,2902,2902,2772,2772,2770,2770,2770,2640,2640,2638,2638,2638,2508,2508,2508,2506,2506,2506,2504,2376,2376,2374,2374,2374,2372,2244,2244,2244,2242,2242,2242,2240,2112,2112,2112,2110,2110,2110,2110,2108,2108
  dc.w    1984,1984,2112,2112,2112,2110,2110,2110,2110,2108,2236,2236,2234,2234,2234,2234,2232,2360,2360,2358,2358,2358,2356,2356,2484,2482,2482,2482,2480,2480,2608,2606,2606,2604,2604,2604,2730,2730,2728,2728,2726,2854,2854,2852,2852,2850,2978,2976,2976,2974,3102,3100,3098,3098,3224,3224,3222,3220,3348,3346,3346,3344,3470,3468,3468,3594,3592,3592,3590,3716,3714,3712,3840,3966,3964,4090,4088,4086,4212,4210,4208,4334,4332,4330,4456,4454,4452,4578,4574,4572,4698,4696,4694,4818,4816,4814,4938,4936,4934,5058,5056,5052,5050,5174,5172,5168,5166,5290,5286,5284,5280,5278,5402,5398,5396,5392,5388,5386,5382,5378,5376,5500,5496,5492,5490,5486,5482,5480,5476,5344,5342,5338,5336,5332,5200,5198,5194,5192,5060,5058,5054,5052,4920,4918,4916,4784,4782,4780,4648,4646,4644,4514,4512,4508,4378,4376,4374,4244,4242,4240,4110,4108,4106,3976,3974,3972,3842,3840,3840,3838,3836,3834,3704,3702,3702,3700,3570,3570,3568,3438,3436,3436,3434,3306,3304,3302,3302,3172,3172,3170,3168,3040,3038,3038,3036,2908,2906,2906,2904,2904,2776,2774,2774,2772,2772,2642,2642,2642,2640,2640,2638,2510,2510,2508,2508,2508,2506,2378,2378,2376,2376,2376,2374,2374,2246,2244,2244,2244,2244,2242,2242,2114,2112,2112,2112,2112,2110,2110,2110,1982
  dc.w    1984,1984,2110,2110,2110,2110,2108,2108,2108,2108,2234,2234,2234,2234,2232,2232,2232,2230,2358,2358,2356,2356,2356,2354,2482,2482,2480,2480,2480,2478,2478,2604,2604,2604,2602,2602,2728,2728,2728,2726,2726,2852,2852,2850,2850,2848,2976,2974,2974,2972,2972,3098,3098,3096,3094,3222,3220,3220,3218,3344,3344,3342,3340,3468,3466,3464,3590,3590,3588,3586,3712,3712,3838,3964,3962,3960,4086,4084,4082,4208,4206,4204,4330,4328,4326,4452,4450,4448,4446,4570,4568,4566,4692,4690,4686,4812,4810,4806,4932,4928,4926,4924,5048,5046,5042,5040,5164,5162,5158,5154,5152,5276,5274,5270,5266,5264,5260,5256,5254,5250,5248,5372,5368,5366,5362,5358,5356,5352,5348,5346,5214,5212,5208,5204,5202,5070,5068,5064,5062,4930,4928,4926,4922,4792,4788,4786,4656,4652,4650,4520,4518,4516,4384,4382,4380,4378,4248,4246,4244,4114,4112,4110,3980,3978,3976,3846,3844,3842,3712,3712,3838,3708,3706,3704,3704,3574,3572,3570,3442,3440,3438,3438,3308,3306,3306,3304,3176,3174,3172,3172,3042,3042,3040,3040,3038,2910,2908,2908,2906,2906,2776,2776,2774,2774,2774,2644,2644,2642,2642,2642,2512,2512,2510,2510,2510,2508,2508,2380,2378,2378,2378,2376,2376,2248,2246,2246,2246,2244,2244,2244,2244,2114,2114,2114,2114,2112,2112,2112,2112,1982
  dc.w    1982,1982,1982,2110,2108,2108,2108,2108,2106,2106,2106,2232,2232,2232,2232,2230,2230,2230,2356,2356,2356,2354,2354,2354,2352,2480,2480,2478,2478,2478,2476,2604,2602,2602,2602,2600,2600,2726,2726,2724,2724,2724,2850,2850,2848,2848,2846,2974,2972,2972,2970,3096,3096,3094,3094,3092,3218,3218,3216,3216,3342,3340,3340,3466,3464,3462,3462,3588,3586,3584,3584,3838,3836,3834,3960,3958,3956,4082,4080,4078,4076,4202,4200,4198,4324,4322,4320,4446,4444,4442,4568,4564,4562,4688,4686,4682,4680,4806,4802,4800,4926,4922,4920,4916,5042,5038,5036,5032,5030,5154,5152,5148,5144,5142,5138,5136,5132,5128,5126,5122,5120,5244,5240,5238,5234,5230,5228,5224,5222,5218,5214,5212,5080,5078,5074,5072,5068,4938,4934,4932,4928,4798,4796,4792,4662,4660,4656,4654,4524,4522,4518,4388,4386,4384,4254,4252,4250,4120,4118,4116,3986,3984,3982,3980,3850,3848,3846,3716,3714,3712,3584,3710,3708,3706,3576,3576,3574,3572,3442,3442,3440,3310,3310,3308,3308,3178,3176,3176,3174,3174,3044,3042,3042,3040,2912,2910,2910,2908,2908,2778,2778,2778,2776,2776,2646,2646,2644,2644,2644,2642,2514,2512,2512,2512,2510,2510,2382,2380,2380,2380,2378,2378,2378,2248,2248,2248,2246,2246,2246,2246,2116,2116,2116,2114,2114,2114,2114,2112,1984,1984
  dc.w    1982,1982,1980,2108,2108,2106,2106,2106,2106,2104,2104,2232,2232,2230,2230,2230,2228,2228,2228,2354,2354,2354,2352,2352,2352,2350,2478,2478,2476,2476,2474,2474,2602,2600,2600,2598,2598,2726,2724,2724,2722,2722,2720,2848,2846,2846,2844,2844,2970,2970,2968,2968,3094,3092,3092,3090,3218,3216,3214,3214,3340,3338,3338,3336,3462,3462,3460,3458,3584,3584,3710,3708,3834,3832,3830,3956,3956,3954,3952,4078,4076,4074,4200,4198,4196,4322,4318,4316,4442,4440,4438,4436,4560,4558,4556,4682,4678,4676,4674,4798,4796,4794,4790,4916,4912,4910,4906,4904,5028,5026,5022,5020,5016,5014,5010,5006,5132,5128,5126,5122,5120,5244,5240,5238,5234,5104,5100,5096,5094,5090,5088,5084,5082,4950,4948,4944,4942,4938,4808,4804,4802,4800,4668,4666,4664,4660,4530,4528,4526,4394,4392,4390,4388,4258,4256,4252,4122,4120,4118,3988,3986,3984,3854,3852,3850,3850,3720,3718,3716,3586,3584,3584,3710,3580,3578,3576,3576,3446,3444,3444,3442,3312,3312,3310,3308,3180,3178,3178,3176,3046,3046,3044,3044,2914,2914,2912,2912,2910,2782,2780,2780,2778,2778,2776,2648,2648,2646,2646,2644,2516,2516,2514,2514,2512,2512,2384,2382,2382,2382,2380,2380,2380,2250,2250,2250,2248,2248,2248,2246,2246,2118,2118,2116,2116,2116,2116,2114,2114,1986,1984
  dc.w    1980,1980,1980,1978,2106,2106,2106,2104,2104,2104,2104,2102,2230,2230,2228,2228,2228,2226,2226,2354,2352,2352,2352,2350,2350,2350,2476,2476,2476,2474,2474,2472,2600,2600,2598,2598,2596,2596,2722,2722,2722,2720,2720,2846,2846,2844,2844,2842,2970,2968,2966,2966,2964,3092,3090,3090,3088,3214,3214,3212,3210,3338,3336,3334,3334,3460,3458,3456,3456,3710,3708,3706,3704,3830,3830,3828,3954,3952,3950,3948,4074,4072,4070,4196,4194,4192,4190,4316,4312,4310,4436,4434,4432,4430,4554,4552,4550,4674,4672,4670,4666,4664,4790,4786,4784,4780,4906,4902,4900,4896,4894,4890,4888,5012,5010,5006,5004,5000,4998,4994,4992,5116,5112,5110,5106,5104,5100,5098,4966,4964,4960,4958,4954,4952,4948,4818,4814,4812,4808,4678,4676,4672,4670,4668,4536,4534,4532,4400,4398,4396,4394,4264,4262,4258,4128,4126,4124,4122,3992,3990,3988,3858,3856,3854,3852,3722,3720,3720,3590,3588,3586,3584,3456,3582,3580,3578,3448,3448,3446,3444,3316,3314,3312,3312,3182,3180,3180,3178,3050,3048,3048,3046,3044,2916,2914,2914,2912,2912,2782,2782,2780,2780,2780,2650,2650,2648,2648,2646,2646,2518,2516,2516,2514,2514,2514,2384,2384,2384,2382,2382,2382,2380,2252,2252,2250,2250,2250,2248,2248,2120,2118,2118,2118,2118,2116,2116,2116,1988,1986,1986
  dc.w    1980,1978,1978,1978,2106,2104,2104,2104,2102,2102,2102,2102,2228,2228,2228,2226,2226,2226,2224,2224,2352,2350,2350,2350,2348,2348,2348,2474,2474,2474,2472,2472,2470,2598,2596,2596,2596,2594,2594,2720,2720,2718,2718,2716,2844,2842,2842,2840,2840,2966,2966,2964,2964,2962,3088,3088,3086,3086,3212,3210,3210,3208,3334,3332,3332,3330,3456,3456,3582,3580,3706,3704,3702,3702,3828,3826,3824,3950,3948,3946,3944,4070,4068,4066,4064,4190,4188,4186,4312,4310,4306,4304,4430,4428,4426,4422,4548,4546,4544,4540,4666,4664,4660,4658,4654,4780,4778,4774,4772,4768,4766,4890,4888,4884,4882,4878,4876,4872,4870,4866,4864,4988,4984,4982,4978,4976,4972,4970,4966,4964,4832,4830,4826,4824,4820,4818,4688,4684,4682,4678,4676,4546,4542,4540,4538,4408,4404,4402,4400,4270,4268,4264,4262,4132,4130,4128,3998,3996,3994,3992,3862,3860,3858,3856,3726,3724,3722,3592,3592,3590,3588,3458,3456,3456,3582,3452,3450,3450,3448,3318,3316,3316,3314,3184,3184,3182,3182,3052,3050,3050,3048,3048,2918,2918,2916,2916,2914,2786,2784,2784,2782,2782,2652,2652,2650,2650,2650,2648,2520,2518,2518,2516,2516,2516,2386,2386,2386,2384,2384,2384,2382,2254,2254,2252,2252,2252,2250,2250,2250,2120,2120,2120,2120,2118,2118,2118,2116,1988,1988,1988
  dc.w    1978,1978,1978,1976,2104,2104,2102,2102,2102,2102,2100,2100,2100,2226,2226,2226,2224,2224,2224,2222,2350,2350,2348,2348,2348,2346,2346,2474,2472,2472,2470,2470,2470,2596,2596,2594,2594,2592,2592,2720,2718,2718,2716,2716,2714,2842,2840,2840,2838,2838,2964,2962,2962,2960,3088,3086,3084,3084,3082,3208,3208,3206,3204,3332,3330,3328,3328,3582,3580,3578,3576,3704,3702,3700,3698,3824,3822,3820,3818,3944,3942,3940,4066,4064,4062,4060,4186,4184,4182,4180,4306,4304,4300,4298,4424,4422,4420,4416,4542,4540,4536,4534,4532,4656,4654,4652,4648,4646,4770,4768,4764,4762,4758,4756,4754,4750,4748,4744,4742,4738,4736,4860,4856,4854,4850,4848,4844,4842,4840,4836,4834,4830,4828,4696,4694,4690,4688,4686,4554,4552,4550,4546,4544,4414,4410,4408,4406,4276,4274,4270,4268,4138,4136,4134,4132,4002,4000,3998,3996,3866,3864,3862,3732,3730,3728,3726,3596,3594,3592,3590,3462,3460,3458,3456,3328,3454,3452,3450,3322,3320,3318,3318,3188,3186,3186,3184,3182,3054,3052,3052,3050,2920,2920,2918,2918,2916,2788,2786,2786,2784,2784,2782,2654,2654,2652,2652,2650,2650,2520,2520,2520,2518,2518,2516,2388,2388,2386,2386,2386,2384,2384,2256,2254,2254,2254,2252,2252,2252,2122,2122,2122,2120,2120,2120,2120,2118,2118,1990,1988,1988
  dc.w    1976,1976,1976,1976,1974,2102,2102,2102,2100,2100,2100,2098,2098,2226,2224,2224,2224,2224,2222,2222,2222,2348,2348,2346,2346,2346,2344,2344,2472,2470,2470,2468,2468,2468,2594,2594,2592,2592,2590,2590,2716,2716,2714,2714,2712,2840,2838,2838,2836,2836,2962,2962,2960,2958,2958,3084,3084,3082,3080,3080,3206,3204,3204,3202,3328,3328,3454,3452,3578,3576,3576,3574,3700,3698,3696,3694,3820,3820,3818,3816,3942,3940,3938,3936,4062,4060,4058,4056,4180,4178,4176,4174,4300,4298,4294,4292,4418,4416,4414,4410,4408,4534,4530,4528,4526,4522,4648,4644,4642,4640,4636,4634,4630,4628,4752,4750,4746,4744,4740,4738,4736,4860,4858,4854,4852,4848,4846,4714,4712,4708,4706,4702,4700,4698,4694,4564,4560,4558,4556,4552,4422,4420,4416,4414,4412,4282,4280,4276,4274,4144,4142,4140,4138,4006,4004,4002,4000,3870,3868,3866,3864,3734,3732,3730,3730,3600,3598,3596,3594,3464,3462,3462,3460,3330,3328,3328,3454,3324,3322,3322,3320,3190,3190,3188,3186,3186,3056,3056,3054,3052,3052,2922,2922,2920,2920,2918,2790,2788,2788,2786,2786,2656,2656,2654,2654,2652,2652,2522,2522,2522,2520,2520,2518,2390,2390,2388,2388,2388,2386,2386,2256,2256,2256,2254,2254,2254,2254,2252,2124,2124,2122,2122,2122,2120,2120,2120,1992,1990,1990,1990
  dc.w    1976,1976,1974,1974,1974,2102,2100,2100,2100,2098,2098,2098,2098,2096,2224,2224,2222,2222,2222,2220,2220,2348,2346,2346,2344,2344,2344,2342,2470,2470,2468,2468,2466,2466,2464,2592,2592,2590,2590,2588,2588,2714,2714,2712,2712,2710,2838,2836,2836,2834,2834,2960,2958,2958,2956,2956,3082,3080,3080,3078,3076,3204,3202,3200,3200,3454,3452,3450,3448,3576,3574,3572,3570,3696,3696,3694,3692,3818,3816,3814,3812,3938,3936,3934,3932,4058,4056,4054,4052,4050,4176,4172,4170,4168,4294,4292,4288,4286,4412,4410,4406,4404,4402,4400,4524,4522,4518,4516,4514,4510,4636,4632,4630,4628,4624,4622,4618,4616,4612,4610,4608,4732,4730,4726,4724,4720,4718,4714,4712,4710,4706,4576,4572,4570,4568,4564,4562,4430,4428,4426,4424,4420,4418,4288,4286,4282,4280,4150,4148,4146,4142,4012,4010,4008,4006,4004,3874,3872,3870,3868,3738,3736,3734,3732,3602,3600,3598,3598,3468,3466,3464,3462,3334,3332,3330,3328,3200,3326,3324,3322,3194,3192,3190,3190,3188,3058,3058,3056,3056,3054,2924,2924,2922,2922,2920,2792,2790,2790,2788,2788,2658,2658,2656,2656,2654,2654,2526,2524,2524,2522,2522,2520,2520,2392,2390,2390,2390,2388,2388,2386,2258,2258,2256,2256,2256,2254,2254,2126,2124,2124,2124,2124,2122,2122,2122,2120,1992,1992,1992,1990
  dc.w    1974,1974,1974,1974,1972,1972,2100,2098,2098,2098,2098,2096,2096,2096,2222,2222,2222,2220,2220,2220,2218,2218,2346,2344,2344,2342,2342,2342,2340,2468,2466,2466,2466,2464,2464,2590,2590,2588,2588,2588,2586,2714,2712,2712,2710,2710,2708,2834,2834,2832,2832,2830,2958,2956,2954,2954,2952,3080,3078,3076,3076,3074,3200,3200,3326,3324,3450,3450,3448,3446,3572,3570,3570,3568,3566,3692,3690,3688,3686,3812,3810,3808,3806,3932,3930,3928,3926,4052,4050,4048,4046,4172,4170,4168,4164,4162,4288,4286,4284,4280,4278,4404,4400,4398,4396,4392,4390,4516,4512,4510,4508,4504,4502,4498,4496,4494,4490,4488,4484,4482,4480,4604,4602,4598,4596,4592,4590,4588,4584,4582,4578,4576,4574,4570,4440,4438,4434,4432,4430,4426,4296,4294,4290,4288,4286,4156,4154,4150,4148,4146,4016,4014,4012,4010,3880,3878,3876,3874,3744,3742,3740,3738,3608,3606,3604,3602,3472,3470,3468,3468,3466,3336,3334,3332,3332,3202,3200,3200,3326,3196,3194,3194,3192,3190,3062,3060,3060,3058,3056,2928,2926,2926,2924,2924,2794,2792,2792,2790,2790,2788,2660,2658,2658,2658,2656,2656,2526,2526,2524,2524,2524,2522,2394,2392,2392,2392,2390,2390,2388,2260,2260,2258,2258,2258,2256,2256,2256,2126,2126,2126,2124,2124,2124,2124,2122,1994,1994,1992,1992,1992
  dc.w    1974,1974,1972,1972,1972,1970,2098,2098,2098,2096,2096,2096,2094,2094,2094,2220,2220,2220,2218,2218,2218,2216,2216,2344,2342,2342,2340,2340,2340,2338,2466,2464,2464,2464,2462,2462,2588,2588,2586,2586,2584,2584,2710,2710,2708,2708,2706,2706,2832,2832,2830,2830,2828,2954,2954,2952,2952,2950,3076,3076,3074,3072,3072,3326,3324,3322,3322,3448,3446,3444,3442,3442,3568,3566,3564,3562,3688,3686,3686,3684,3810,3808,3806,3804,3930,3928,3926,3924,3922,4046,4044,4042,4040,4166,4164,4162,4158,4156,4282,4280,4278,4274,4272,4270,4394,4392,4390,4386,4384,4382,4378,4376,4374,4498,4496,4494,4490,4488,4484,4482,4480,4604,4602,4598,4596,4592,4590,4588,4456,4454,4452,4448,4446,4444,4440,4438,4436,4304,4302,4300,4296,4294,4292,4162,4160,4156,4154,4152,4022,4020,4018,4016,3884,3882,3880,3878,3876,3746,3744,3742,3740,3610,3608,3608,3606,3476,3474,3472,3470,3340,3340,3338,3336,3334,3204,3204,3202,3200,3072,3198,3196,3194,3194,3064,3062,3062,3060,3060,2930,2928,2928,2926,2926,2796,2796,2794,2794,2792,2792,2662,2662,2660,2660,2658,2658,2528,2528,2526,2526,2526,2524,2396,2394,2394,2394,2392,2392,2390,2262,2262,2260,2260,2260,2258,2258,2258,2128,2128,2128,2126,2126,2126,2124,2124,2124,1996,1994,1994,1994,1992
  dc.w    1972,1972,1972,1970,1970,1970,1970,2096,2096,2096,2094,2094,2094,2092,2092,2220,2218,2218,2218,2216,2216,2216,2214,2342,2342,2340,2340,2338,2338,2338,2464,2464,2462,2462,2462,2460,2460,2586,2586,2584,2584,2582,2582,2708,2708,2706,2706,2704,2832,2830,2828,2828,2826,2826,2952,2950,2950,2948,2948,3074,3072,3072,3198,3196,3322,3322,3320,3318,3444,3444,3442,3440,3438,3564,3562,3562,3560,3686,3684,3682,3680,3678,3804,3802,3800,3798,3924,3922,3920,3918,3916,4042,4040,4036,4034,4032,4158,4156,4154,4150,4148,4274,4272,4268,4266,4264,4260,4258,4384,4382,4378,4376,4372,4370,4368,4364,4362,4360,4356,4354,4352,4476,4474,4470,4468,4466,4462,4460,4458,4454,4452,4448,4446,4316,4314,4310,4308,4306,4302,4300,4170,4168,4164,4162,4160,4030,4028,4026,4022,4020,3890,3888,3886,3884,3882,3752,3750,3748,3746,3616,3614,3612,3610,3608,3478,3476,3476,3474,3344,3342,3340,3338,3338,3208,3206,3204,3204,3074,3072,3072,3198,3196,3066,3066,3064,3064,3062,2932,2932,2930,2930,2928,2926,2798,2796,2796,2794,2794,2664,2664,2662,2662,2660,2660,2530,2530,2528,2528,2528,2526,2526,2396,2396,2396,2394,2394,2392,2392,2264,2262,2262,2262,2260,2260,2260,2258,2130,2130,2128,2128,2128,2126,2126,2126,1996,1996,1996,1996,1994,1994
  dc.w    1972,1970,1970,1970,1970,1968,1968,2096,2094,2094,2094,2092,2092,2092,2092,2090,2218,2218,2216,2216,2214,2214,2214,2212,2340,2340,2338,2338,2336,2336,2336,2462,2462,2460,2460,2458,2458,2456,2584,2584,2582,2582,2580,2580,2706,2706,2704,2702,2702,2828,2828,2826,2826,2824,2822,2950,2948,2946,2946,2944,3072,3198,3196,3194,3194,3320,3318,3316,3316,3442,3440,3438,3436,3436,3562,3560,3558,3556,3554,3680,3678,3676,3676,3802,3800,3798,3796,3792,3918,3916,3914,3912,3910,4036,4034,4032,4030,4026,4152,4150,4148,4144,4142,4140,4138,4262,4260,4258,4256,4252,4250,4248,4244,4242,4240,4364,4362,4360,4356,4354,4352,4476,4474,4470,4468,4466,4334,4332,4330,4326,4324,4322,4318,4316,4314,4312,4180,4178,4176,4174,4170,4168,4166,4036,4032,4030,4028,4026,3896,3894,3892,3890,3888,3758,3754,3752,3750,3748,3618,3618,3616,3614,3484,3482,3480,3478,3476,3346,3346,3344,3342,3340,3210,3210,3208,3206,3076,3076,3074,3072,3072,3070,3068,3068,3066,3064,2936,2934,2932,2932,2930,2930,2800,2800,2798,2796,2796,2666,2666,2664,2664,2662,2662,2534,2532,2532,2530,2530,2528,2528,2398,2398,2398,2396,2396,2394,2394,2266,2264,2264,2264,2262,2262,2260,2260,2132,2130,2130,2130,2130,2128,2128,2128,2126,1998,1998,1996,1996,1996,1996
  dc.w    1970,1970,1970,1968,1968,1968,1966,1966,2094,2094,2092,2092,2092,2090,2090,2090,2088,2216,2216,2214,2214,2214,2212,2212,2338,2338,2338,2336,2336,2334,2334,2334,2460,2460,2458,2458,2456,2456,2582,2582,2580,2580,2578,2578,2704,2704,2702,2702,2700,2700,2826,2826,2824,2822,2822,2820,2946,2946,2944,2944,3070,3196,3194,3194,3192,3190,3318,3316,3314,3312,3310,3438,3436,3434,3432,3558,3556,3556,3554,3552,3678,3676,3674,3672,3670,3796,3794,3792,3790,3788,3914,3912,3910,3906,3904,4030,4028,4026,4024,4022,4018,4144,4142,4140,4136,4134,4132,4130,4126,4252,4250,4246,4244,4242,4238,4236,4234,4232,4228,4226,4224,4348,4346,4342,4340,4338,4336,4332,4330,4328,4324,4322,4192,4188,4186,4184,4182,4178,4176,4174,4044,4040,4038,4036,4034,4032,3902,3900,3896,3894,3892,3762,3760,3758,3756,3754,3624,3622,3620,3618,3616,3486,3484,3482,3482,3480,3350,3348,3346,3344,3216,3214,3212,3210,3208,3080,3078,3076,3076,3074,2944,2944,3070,3068,3068,2938,2936,2936,2934,2932,2932,2802,2802,2800,2800,2798,2798,2668,2668,2666,2666,2664,2664,2534,2534,2532,2532,2530,2530,2400,2400,2400,2398,2398,2396,2396,2396,2266,2266,2264,2264,2264,2262,2262,2134,2132,2132,2132,2130,2130,2130,2128,2128,2000,2000,1998,1998,1998,1996,1996
  dc.w    1970,1968,1968,1968,1968,1966,1966,1966,1964,2092,2092,2090,2090,2090,2088,2088,2088,2214,2214,2214,2212,2212,2212,2210,2210,2336,2336,2336,2334,2334,2332,2332,2458,2458,2458,2456,2456,2454,2454,2580,2580,2578,2578,2576,2576,2702,2702,2700,2700,2698,2696,2824,2822,2822,2820,2818,2818,2944,2944,3070,3068,3066,3194,3192,3190,3190,3188,3314,3312,3312,3310,3308,3434,3432,3432,3430,3428,3554,3552,3550,3548,3546,3672,3670,3668,3666,3664,3790,3788,3786,3784,3782,3908,3906,3904,3902,3900,3896,4022,4020,4018,4016,4014,4010,4008,4134,4132,4128,4126,4124,4122,4118,4116,4114,4110,4108,4106,4102,4228,4226,4224,4348,4346,4216,4212,4210,4208,4204,4202,4200,4196,4194,4192,4190,4186,4184,4054,4052,4048,4046,4044,4042,4040,3910,3906,3904,3902,3900,3898,3768,3766,3764,3762,3760,3630,3628,3626,3624,3622,3492,3490,3488,3486,3484,3354,3352,3350,3350,3348,3218,3216,3214,3214,3212,3082,3080,3080,3078,3076,2948,2946,2944,2944,3070,2940,2940,2938,2936,2936,2934,2806,2804,2802,2802,2800,2800,2670,2670,2668,2668,2666,2666,2536,2536,2534,2534,2532,2532,2532,2402,2402,2400,2400,2398,2398,2398,2268,2268,2266,2266,2266,2264,2264,2264,2134,2134,2134,2132,2132,2132,2130,2130,2002,2000,2000,2000,1998,1998,1998,1998
  dc.w    1968,1968,1968,1966,1966,1966,1964,1964,1964,2090,2090,2090,2088,2088,2088,2086,2086,2086,2212,2212,2212,2210,2210,2210,2208,2208,2334,2334,2334,2332,2332,2330,2330,2456,2456,2456,2454,2454,2452,2452,2578,2578,2576,2576,2574,2574,2700,2698,2698,2696,2696,2694,2822,2820,2818,2818,2816,2816,3070,3068,3068,3066,3064,3190,3190,3188,3186,3184,3312,3310,3308,3306,3306,3432,3430,3428,3426,3424,3550,3550,3548,3546,3544,3670,3668,3666,3664,3662,3660,3786,3784,3782,3780,3776,3902,3900,3898,3896,3894,3892,3890,4014,4012,4010,4008,4006,4002,4000,3998,4124,4120,4118,4116,4114,4110,4108,4106,4102,4100,4098,4096,4220,4218,4216,4212,4210,4208,4204,4202,4200,4198,4194,4064,4062,4060,4056,4054,4052,4050,4048,3916,3914,3912,3910,3908,3906,3904,3774,3770,3768,3766,3764,3634,3632,3630,3628,3626,3624,3494,3492,3490,3488,3488,3358,3356,3354,3352,3350,3220,3220,3218,3216,3214,3086,3084,3082,3080,3080,2950,2948,2946,2946,2944,2816,2942,2940,2940,2938,2936,2808,2806,2806,2804,2804,2802,2672,2672,2670,2670,2668,2668,2538,2538,2536,2536,2534,2534,2534,2404,2404,2402,2402,2400,2400,2400,2270,2270,2268,2268,2268,2266,2266,2266,2136,2136,2136,2134,2134,2134,2132,2132,2132,2002,2002,2002,2000,2000,2000,1998,1998
  dc.w    1968,1966,1966,1966,1964,1964,1964,1964,1962,1962,2090,2088,2088,2088,2086,2086,2086,2084,2212,2210,2210,2210,2208,2208,2208,2206,2334,2332,2332,2332,2330,2330,2328,2328,2454,2454,2452,2452,2450,2450,2450,2576,2576,2574,2572,2572,2570,2698,2696,2696,2694,2694,2692,2818,2818,2816,2816,2942,2940,3068,3066,3064,3062,3062,3188,3186,3186,3184,3182,3308,3308,3306,3304,3302,3300,3426,3426,3424,3422,3420,3546,3544,3542,3540,3538,3664,3662,3660,3658,3656,3654,3780,3778,3776,3774,3772,3770,3896,3892,3890,3888,3886,3884,3882,4006,4004,4002,4000,3998,3994,3992,3990,3988,3984,3982,3980,3978,3974,3972,3970,4096,4092,4090,4088,4084,4082,4080,4078,4074,4072,4070,4068,4064,4062,4060,4058,4056,3924,3922,3920,3918,3916,3914,3910,3780,3778,3776,3774,3772,3770,3640,3638,3636,3634,3632,3630,3500,3498,3496,3494,3492,3362,3360,3358,3356,3356,3226,3224,3222,3220,3218,3218,3088,3086,3084,3084,3082,2952,2952,2950,2948,2946,2818,2816,2816,2942,2940,2940,2810,2808,2808,2806,2806,2804,2676,2674,2674,2672,2670,2670,2540,2540,2540,2538,2538,2536,2536,2406,2406,2404,2404,2402,2402,2402,2400,2272,2270,2270,2270,2268,2268,2268,2266,2138,2136,2136,2136,2134,2134,2134,2132,2004,2004,2002,2002,2002,2002,2000,2000,2000
  dc.w    1966,1966,1964,1964,1964,1964,1962,1962,1962,1960,2088,2088,2086,2086,2086,2084,2084,2084,2082,2210,2210,2208,2208,2206,2206,2206,2204,2332,2330,2330,2330,2328,2328,2326,2326,2452,2452,2450,2450,2448,2448,2574,2574,2572,2572,2570,2570,2568,2696,2694,2694,2692,2690,2690,2816,2816,2942,2940,2940,2938,3064,3064,3062,3060,3058,3186,3184,3182,3180,3180,3178,3304,3302,3302,3300,3298,3424,3422,3420,3418,3416,3544,3542,3540,3538,3536,3534,3660,3658,3656,3654,3652,3650,3776,3774,3770,3768,3766,3764,3762,3888,3886,3884,3880,3878,3876,3874,3872,3868,3994,3992,3990,3986,3984,3982,3980,3978,3974,3972,3970,3968,4092,4090,4088,4084,4082,4080,4078,4076,4072,4070,4068,3938,3934,3932,3930,3928,3926,3922,3920,3918,3788,3786,3784,3782,3780,3776,3774,3644,3642,3640,3638,3636,3634,3504,3502,3500,3498,3496,3494,3366,3364,3362,3360,3358,3228,3226,3224,3224,3222,3092,3090,3090,3088,3086,3084,2956,2954,2952,2950,2950,2820,2818,2818,2816,2816,2942,2812,2812,2810,2808,2808,2806,2678,2676,2676,2674,2674,2672,2672,2542,2542,2540,2540,2538,2538,2408,2408,2406,2406,2404,2404,2404,2402,2274,2272,2272,2272,2270,2270,2268,2268,2140,2138,2138,2138,2136,2136,2136,2134,2134,2006,2004,2004,2004,2002,2002,2002,2002,2000
  dc.w    1838,1964,1964,1964,1962,1962,1962,1960,1960,1960,1958,2086,2086,2084,2084,2084,2082,2082,2082,2080,2208,2208,2206,2206,2204,2204,2204,2202,2330,2328,2328,2328,2326,2326,2324,2452,2450,2450,2448,2448,2446,2446,2572,2572,2570,2570,2568,2568,2566,2692,2692,2690,2690,2688,2688,2942,2940,2940,2938,2936,2936,3062,3060,3060,3058,3056,3182,3182,3180,3178,3176,3176,3302,3300,3298,3296,3294,3294,3420,3418,3416,3414,3412,3538,3536,3534,3532,3530,3528,3654,3652,3650,3648,3646,3644,3770,3768,3766,3764,3762,3758,3756,3754,3880,3878,3876,3874,3870,3868,3866,3864,3862,3858,3856,3854,3852,3848,3846,3972,3970,3968,4092,4090,3960,3958,3954,3952,3950,3948,3944,3942,3940,3938,3936,3932,3930,3928,3926,3796,3794,3792,3788,3786,3784,3782,3780,3650,3648,3646,3644,3642,3640,3510,3508,3506,3504,3502,3500,3370,3368,3366,3364,3362,3232,3232,3230,3228,3226,3224,3094,3094,3092,3090,3088,3088,2958,2956,2954,2954,2952,2822,2822,2820,2818,2818,2816,2688,2814,2812,2812,2810,2810,2680,2678,2678,2676,2676,2674,2674,2544,2544,2542,2542,2540,2540,2538,2410,2408,2408,2406,2406,2406,2404,2276,2274,2274,2274,2272,2272,2270,2270,2142,2140,2140,2140,2138,2138,2138,2136,2136,2008,2006,2006,2006,2004,2004,2004,2002,2002,2002
  dc.w    1836,1836,1962,1962,1962,1962,1960,1960,1960,1958,1958,2086,2084,2084,2084,2082,2082,2082,2080,2080,2206,2206,2206,2204,2204,2202,2202,2202,2200,2328,2326,2326,2324,2324,2324,2322,2450,2448,2448,2446,2446,2444,2444,2570,2570,2568,2568,2566,2564,2564,2690,2690,2688,2688,2814,2812,2940,2938,2936,2936,2934,2932,3060,3058,3056,3056,3054,3052,3178,3178,3176,3174,3172,3298,3298,3296,3294,3292,3290,3416,3414,3412,3412,3410,3408,3534,3532,3530,3528,3526,3524,3650,3648,3646,3644,3642,3640,3636,3762,3760,3758,3756,3754,3752,3750,3746,3744,3870,3868,3866,3864,3860,3858,3856,3854,3852,3848,3846,3844,3842,3840,3964,3962,3960,3958,3954,3952,3950,3948,3946,3942,3940,3938,3936,3806,3804,3800,3798,3796,3794,3792,3790,3788,3658,3654,3652,3650,3648,3646,3644,3514,3512,3510,3508,3506,3504,3374,3372,3370,3370,3368,3366,3236,3234,3232,3230,3228,3228,3098,3096,3094,3092,3092,2962,2960,2958,2958,2956,2954,2826,2824,2822,2822,2820,2818,2690,2688,2688,2814,2812,2812,2682,2682,2680,2678,2678,2676,2676,2546,2546,2544,2544,2542,2542,2540,2412,2410,2410,2410,2408,2408,2406,2278,2276,2276,2276,2274,2274,2272,2272,2272,2142,2142,2140,2140,2140,2138,2138,2138,2136,2008,2008,2006,2006,2006,2004,2004,2004,2004,1874
  dc.w    1834,1834,1962,1962,1960,1960,1960,1958,1958,1958,1956,1956,2084,2082,2082,2082,2080,2080,2080,2078,2078,2204,2204,2204,2202,2202,2200,2200,2200,2326,2326,2324,2324,2322,2322,2322,2320,2448,2446,2446,2444,2444,2442,2442,2568,2566,2566,2564,2564,2562,2562,2688,2688,2814,2812,2812,2810,2936,2936,2934,2932,2932,2930,3056,3056,3054,3052,3050,3050,3176,3174,3172,3172,3170,3168,3294,3292,3290,3290,3288,3286,3412,3410,3408,3406,3404,3402,3528,3526,3524,3522,3520,3518,3516,3642,3640,3638,3636,3634,3632,3630,3756,3754,3750,3748,3746,3744,3742,3740,3738,3734,3732,3730,3728,3854,3850,3848,3846,3844,3842,3840,3964,3962,3960,3958,3956,3952,3822,3820,3818,3816,3812,3810,3808,3806,3804,3802,3800,3796,3794,3664,3662,3660,3658,3656,3654,3652,3522,3520,3518,3516,3514,3512,3510,3380,3378,3376,3374,3372,3370,3240,3238,3236,3236,3234,3232,3102,3100,3098,3098,3096,3094,2964,2964,2962,2960,2958,2958,2828,2826,2826,2824,2822,2822,2692,2690,2690,2688,2688,2814,2684,2684,2682,2682,2680,2680,2678,2548,2548,2546,2546,2544,2544,2542,2414,2412,2412,2412,2410,2410,2408,2408,2278,2278,2278,2276,2276,2274,2274,2274,2144,2144,2142,2142,2142,2140,2140,2140,2138,2010,2010,2008,2008,2008,2006,2006,2006,2004,2004,1876
  dc.w    1834,1834,1832,1960,1960,1958,1958,1958,1958,1956,1956,1956,1954,2082,2080,2080,2080,2078,2078,2078,2076,2076,2204,2202,2202,2200,2200,2198,2198,2198,2324,2324,2322,2322,2320,2320,2318,2318,2444,2444,2444,2442,2440,2440,2438,2566,2564,2564,2562,2562,2560,2560,2814,2812,2812,2810,2808,2808,2934,2932,2932,2930,2928,2928,3054,3052,3052,3050,3048,3046,3174,3172,3170,3168,3166,3166,3292,3290,3288,3286,3284,3282,3282,3408,3406,3404,3402,3400,3398,3524,3522,3520,3518,3516,3514,3512,3638,3636,3634,3632,3628,3626,3624,3622,3620,3746,3744,3742,3740,3736,3734,3732,3730,3728,3726,3722,3720,3718,3716,3714,3712,3836,3834,3832,3830,3828,3824,3822,3820,3818,3816,3814,3810,3808,3806,3804,3674,3672,3670,3668,3666,3662,3660,3658,3656,3526,3524,3522,3520,3518,3516,3514,3384,3382,3380,3378,3376,3374,3244,3244,3242,3240,3238,3236,3234,3104,3104,3102,3100,3098,3096,2968,2966,2964,2962,2962,2960,2830,2830,2828,2826,2826,2824,2694,2694,2692,2690,2690,2688,2560,2686,2684,2684,2682,2682,2680,2552,2550,2550,2548,2546,2546,2546,2416,2416,2414,2414,2412,2412,2410,2410,2280,2280,2280,2278,2278,2276,2276,2274,2146,2146,2144,2144,2144,2142,2142,2142,2140,2012,2010,2010,2010,2008,2008,2008,2008,2006,2006,1878,1876
  dc.w    1832,1832,1832,1960,1958,1958,1958,1956,1956,1956,1954,1954,1954,2080,2080,2080,2078,2078,2076,2076,2076,2074,2202,2202,2200,2200,2198,2198,2196,2196,2196,2322,2322,2320,2320,2318,2318,2316,2316,2442,2442,2440,2440,2438,2438,2436,2564,2562,2562,2560,2560,2686,2684,2812,2810,2808,2808,2806,2806,2932,2930,2930,2928,2926,2924,3052,3050,3048,3048,3046,3044,3042,3168,3168,3166,3164,3162,3160,3288,3286,3284,3282,3280,3278,3404,3402,3400,3398,3396,3394,3392,3520,3518,3514,3512,3510,3508,3506,3504,3630,3628,3626,3624,3622,3620,3618,3616,3612,3610,3608,3606,3732,3730,3728,3724,3722,3720,3718,3716,3714,3712,3836,3834,3832,3830,3828,3826,3822,3820,3818,3688,3686,3684,3682,3678,3676,3674,3672,3670,3668,3666,3664,3534,3532,3530,3528,3526,3524,3520,3518,3390,3388,3386,3384,3382,3380,3378,3248,3246,3244,3242,3240,3238,3110,3108,3106,3104,3102,3102,2972,2970,2968,2966,2966,2964,2962,2834,2832,2830,2828,2828,2826,2696,2696,2694,2694,2692,2690,2562,2560,2560,2686,2684,2684,2682,2554,2552,2552,2550,2550,2548,2548,2418,2418,2416,2416,2414,2414,2412,2412,2282,2282,2282,2280,2280,2278,2278,2276,2276,2148,2146,2146,2146,2144,2144,2142,2142,2142,2012,2012,2012,2010,2010,2010,2008,2008,2008,2006,1878,1878
  dc.w    1832,1832,1830,1830,1958,1956,1956,1956,1954,1954,1954,1952,1952,1952,2078,2078,2078,2076,2076,2076,2074,2074,2072,2200,2200,2198,2198,2196,2196,2196,2194,2194,2320,2320,2318,2318,2316,2316,2314,2442,2440,2440,2438,2438,2436,2436,2434,2562,2560,2560,2686,2684,2684,2682,2810,2808,2806,2806,2804,2802,2930,2928,2926,2926,2924,2922,2920,3048,3046,3044,3042,3042,3040,3166,3164,3164,3162,3160,3158,3156,3282,3280,3280,3278,3276,3274,3400,3398,3396,3394,3392,3390,3388,3386,3512,3510,3508,3506,3504,3502,3500,3498,3496,3622,3620,3616,3614,3612,3610,3608,3606,3604,3602,3600,3596,3594,3592,3590,3588,3586,3584,3708,3706,3704,3702,3700,3698,3694,3692,3690,3688,3686,3684,3682,3680,3678,3674,3672,3542,3540,3538,3536,3534,3532,3530,3528,3526,3396,3394,3392,3390,3388,3386,3384,3382,3252,3250,3248,3246,3246,3244,3114,3112,3110,3108,3106,3106,3104,2974,2972,2972,2970,2968,2966,2838,2836,2834,2832,2832,2830,2828,2700,2698,2696,2696,2694,2692,2564,2562,2562,2560,2560,2686,2684,2556,2554,2554,2552,2552,2550,2550,2548,2420,2418,2418,2416,2416,2414,2414,2284,2284,2282,2282,2282,2280,2280,2278,2278,2150,2148,2148,2146,2146,2146,2144,2144,2144,2014,2014,2014,2012,2012,2012,2010,2010,2010,2008,1880,1880,1878
  dc.w    1830,1830,1830,1830,1956,1956,1956,1954,1954,1954,1952,1952,1952,1950,1950,2078,2076,2076,2074,2074,2074,2072,2072,2070,2198,2198,2196,2196,2194,2194,2194,2192,2320,2318,2318,2316,2316,2314,2314,2312,2440,2438,2438,2436,2436,2434,2434,2432,2560,2686,2684,2684,2682,2682,2680,2806,2806,2804,2802,2802,2800,2926,2926,2924,2922,2922,2920,2918,3044,3044,3042,3040,3038,3038,3036,3162,3160,3158,3158,3156,3154,3280,3278,3276,3274,3272,3270,3270,3268,3394,3392,3390,3388,3386,3384,3382,3380,3506,3504,3502,3500,3498,3494,3492,3490,3488,3486,3484,3610,3608,3606,3604,3602,3598,3596,3594,3592,3590,3588,3586,3584,3708,3706,3704,3702,3700,3698,3696,3692,3690,3688,3686,3684,3554,3552,3550,3548,3546,3544,3540,3538,3536,3534,3532,3402,3400,3398,3396,3394,3392,3390,3388,3258,3256,3256,3254,3252,3250,3248,3246,3116,3114,3112,3112,3110,3108,2978,2976,2976,2974,2972,2970,2970,2840,2838,2836,2836,2834,2832,2832,2702,2700,2700,2698,2696,2696,2566,2564,2564,2562,2562,2560,2560,2558,2556,2556,2554,2554,2552,2552,2550,2422,2420,2420,2418,2418,2416,2416,2414,2286,2284,2284,2284,2282,2282,2280,2280,2152,2150,2150,2148,2148,2148,2146,2146,2144,2016,2016,2014,2014,2014,2012,2012,2012,2010,2010,2010,1880,1880,1880
  dc.w    1830,1830,1828,1828,1828,1954,1954,1954,1952,1952,1952,1950,1950,1950,1948,2076,2076,2074,2074,2074,2072,2072,2070,2070,2070,2196,2196,2194,2194,2192,2192,2192,2190,2318,2316,2316,2314,2314,2312,2312,2310,2438,2436,2436,2434,2434,2432,2432,2558,2684,2684,2682,2682,2680,2678,2678,2804,2804,2802,2800,2800,2798,2796,2924,2922,2920,2918,2918,2916,2914,3040,3040,3038,3036,3034,3034,3160,3158,3156,3154,3152,3150,3150,3276,3274,3272,3270,3268,3266,3264,3262,3388,3386,3384,3382,3380,3378,3376,3374,3372,3498,3496,3494,3492,3490,3488,3486,3484,3482,3480,3478,3474,3472,3470,3468,3466,3592,3590,3588,3586,3584,3708,3706,3704,3702,3572,3570,3568,3566,3564,3560,3558,3556,3554,3552,3550,3548,3546,3544,3542,3540,3410,3408,3406,3404,3402,3400,3398,3396,3394,3264,3262,3260,3258,3256,3254,3252,3250,3120,3120,3118,3116,3114,3112,3110,2980,2980,2978,2976,2974,2974,2844,2842,2840,2840,2838,2836,2834,2706,2704,2702,2702,2700,2698,2698,2568,2568,2566,2564,2564,2562,2562,2432,2432,2558,2556,2556,2554,2554,2552,2424,2422,2422,2420,2420,2418,2418,2416,2288,2286,2286,2286,2284,2284,2282,2282,2152,2152,2152,2150,2150,2148,2148,2148,2146,2146,2018,2016,2016,2016,2014,2014,2014,2012,2012,2012,1882,1882,1882,1880
  dc.w    1828,1828,1828,1828,1826,1826,1954,1952,1952,1952,1950,1950,1950,1948,1948,1946,2074,2074,2072,2072,2072,2070,2070,2068,2068,2196,2194,2194,2192,2192,2190,2190,2190,2188,2316,2314,2314,2312,2312,2310,2310,2308,2436,2434,2434,2432,2432,2558,2556,2556,2682,2682,2680,2678,2678,2676,2676,2802,2800,2800,2798,2796,2796,2794,2920,2920,2918,2916,2914,2914,2912,3038,3036,3036,3034,3032,3030,3028,3156,3154,3152,3150,3148,3146,3144,3272,3270,3268,3266,3264,3262,3260,3258,3256,3382,3380,3378,3376,3374,3372,3370,3368,3366,3364,3490,3488,3486,3484,3482,3480,3476,3474,3472,3470,3468,3466,3464,3462,3460,3458,3456,3580,3578,3576,3574,3572,3570,3568,3566,3564,3562,3558,3556,3554,3552,3550,3548,3418,3416,3414,3412,3410,3408,3406,3404,3402,3400,3270,3268,3266,3264,3262,3260,3258,3256,3254,3126,3124,3122,3120,3118,3116,3114,2986,2984,2982,2980,2978,2978,2976,2846,2844,2844,2842,2840,2838,2838,2708,2706,2706,2704,2702,2702,2700,2570,2570,2568,2568,2566,2564,2564,2434,2434,2432,2432,2558,2556,2556,2554,2426,2424,2424,2422,2422,2420,2420,2418,2290,2288,2288,2288,2286,2286,2284,2284,2282,2154,2154,2152,2152,2150,2150,2150,2148,2148,2020,2018,2018,2016,2016,2016,2014,2014,2014,2012,1884,1884,1882,1882,1882
