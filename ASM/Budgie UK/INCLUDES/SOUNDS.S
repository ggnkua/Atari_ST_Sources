soundlist
	dc.b 00,26,30,26,22,32,30,36,60,42,44,42,22,22
	dc.b 32,34,28,26,34,22,52,34,32,32,38,32,34
	dc.b 30,30,30,98 (98 end)
	even
soundoffset
	dc.w 0,26,56,82,104,136,166,202,262,304,348,390,412,434
	dc.w 466,500,528,554,588,610,662,696,728,760,798,830,864
	dc.w 894,924,954

snd0
	DC.B 2,216 \laser medium pitch, med/long repeat
	DC.B 3,4,4,219,5,5,7,254,8,16,11,223,12,118
	DC.B 13,0,128,0,129,0,22,0,255,0
	EVEN
snd1
	DC.B 0,140 \laser, low pitch  long 
	DC.B 1,1,2,216,3,4,4,219,5,5,7,254,8,16
	DC.B 11,207,12,88,13,0,128,0,129,0,41,0,255,0
	EVEN
snd2
	DC.B 2,216 \same but slower/wavy
	DC.B 3,4,4,219,5,5,7,254,8,16,11,223,12,118
	DC.B 13,0,128,0,129,0,22,0,255,0
	EVEN
snd3
	DC.B 0,0  \electronic high pitch same as 0
	DC.B 1,0,7,254,8,16,11,207,12,88,13,0,128,0
	DC.B 129,0,41,0,255,0
	EVEN
snd4 
	DC.B 0,82 \winding sound
	DC.B 1,2,2,251,3,13,4,34,5,0,7,248,8,16
	DC.B 11,0,12,86,13,0,128,0,129,0,11,0,130,0,255,0
	EVEN
snd5 	
	DC.B 0,210 \C note low octave  long  Damonoid
	DC.B 1,3,2,232,3,3,4,209,5,7,7,248,8,16
	DC.B 9,16,10,16,11,111,12,163,13,0,128,0,255,0
	EVEN
snd6
	DC.B 0,$34 	channel A 
	DC.B 1,0 	2150 hz \bell
	DC.B 2,0		channel
	DC.B 3,0		B
	DC.B 4,0		channel
	DC.B 5,0		C
 	DC.B 6,0		NOISE 
	DC.B 7,$FE	enable A only ($fe = 254)
	DC.B 8,$10	enable A envelope
	DC.B 9,0		B off
	DC.B 10,0	C off
	DC.B 11,0	single attack...
	DC.B 12,$10	  ...envelope
	DC.B 13,9	...shape  1001
	DC.B 130,100	delay
	DC.B 7,255,8,0,255,0 switch off? Not sure.
	EVEN
snd7
	DC.B 0,$FE  \ambulance long
	DC.B 1,0,2,0,3,0,4,0,5,0,6,0
	DC.B 7,$FE,8,11,9,0,10,0,11,0,12,0
	DC.B 13,0,130,20
	DC.B 0,$56,1,1,130,20
	DC.B 0,$FE,1,0,130,20
	DC.B 0,$56,1,1,130,20
	DC.B 8,0,9,0,130,50
	DC.B 7,255,8,0,255,0
	EVEN
snd8
	DC.B 0,0 \gun fire
	DC.B 1,0,2,0,3,0,4,0,5,0,6,15 
	DC.B 7,199,8,16,9,16,10,16,11,0,12,16
	DC.B 13,0,130,25
	DC.B 8,0,9,0,130,50
	DC.B 7,255,8,0,255,0
	EVEN
snd9
	DC.B 0,2 \muffled gun fire (longer duration)
	DC.B 1,15,2,2,3,15,4,0,5,0,6,10
	DC.B 7,199,8,16,9,16,10,16,11,0,12,80
	DC.B 13,0,130,20
	DC.B 8,0,9,0,10,0,13,100
	DC.B 7,255,8,0,255,0
	EVEN
snd10
	DC.B 0,0  \high pitch fire
	DC.B 1,0,2,0,3,0,4,0,5,0,6,0
	DC.B 7,254,8,15,9,0,10,0,11,0,12,0
	DC.B 13,0,128,60,129,0,-2,40,130,2
	DC.B 7,255,8,0,255,0


snd11	DC.B   0,$40,1,1,2,$38,3,1,8,16,9,16,12,20,13,0,11,20
	DC.B   7,%11111100,$FF,0 ;PEARL CAUGHT  22
snd12	DC.B   0,$40,1,0,2,$78,3,0,8,16,9,16,12,20,13,0,11,20
	DC.B   7,%11111100,$FF,0 ;ICON SELECTED  22
snd13	DC.B   0,$56,1,0,2,$56,3,0,8,16,9,15,12,1
	DC.B   13,10,11,50,7,%11111100,$80,16,$81,9,-1,0
	DC.B   $FF,0,8,0,$FF,0 ;brikhit  32
snd14	DC.B   0,2,1,15,2,2,3,15,8,16,9,16,12,20,13,10
	DC.B 11,20,7,%11111100 
	DC.B $80,240,$81,1,-16,0,$FF,10,8,0,9,0,$FF,0 ;BOUNCE
snd15	DC.B 0,2,1,0,2,2,3,16,8,13,9,13,7,%11110100 
	DC.B $80,15,$81,6,-1,0,$FF,5,8,5,9,5,$FF,0 ;ZAP
snd16	DC.B 0,0,1,15,8,15,12,0,13,4,11,20,7,%11111110
	DC.B $80,0,$81,1,1,15,$FF,1,8,0,$FF,0 ;FIRE
snd17	DC.B 0,8,1,2,2,12,3,4,8,16,9,16,12,20,13,9
	DC.B 11,20,7,%11111100 
	DC.B $80,200,$81,0,-20,0,$FF,1,8,0,9,0,$FF,0 ;BOUNCE
snd18	DC.B 0,0,1,0,8,16,12,70,13,0,11,20,7,%11111110
	DC.B $80,0,$81,1,1,255,$FF,0 ;DEAD
snd19	DC.B 0,100,1,4,2,101,3,4,8,15,9,15
	DC.B 11,0,12,30,7,%11111100
	DC.B $FF,5,1,3,3,3,$FF,5,1,2,3,2,$FF,5,1,1,3,1 
	DC.B $FF,5,1,0,3,0
	DC.B $FF,5,13,0,8,16,9,16,$FF,0 ;XTRA
snd20	DC.B 0,8,1,2,8,16,12,25,13,9,11,20,7,%11111110 
	DC.B $80,0,$81,1,1,15,$80,0,$81,1,1,15,$FF,50
	DC.B 8,0,9,0,$FF,0 ;BADHIT
snd21	DC.B  0,32,1,0,2,80,3,0,8,15,9,16,12,1
	DC.B 13,10,11,100,7,%11111100,$80,16,$81,8,-1,0
	DC.B $FF,12,9,0,$FF,0
snd22	DC.B  0,20,1,0,2,48,3,0,8,15,9,16,12,1
	DC.B 13,10,11,50,7,%11111100,$80,16,$81,8,-1,0
	DC.B $FF,10,9,0,$FF,0 ; FACEHIT 32
snd23	DC.B  0,27,1,0,2,48,3,0,8,16,9,16,12,10
	DC.B 13,10,11,0,6,30,7,%11111100,$FF,40 
	DC.B $80,15,$81,8,-1,0,7,%11110100
	DC.B $FF,10,9,0,$FF,0 ; FADER 38
snd24	DC.B  0,100,1,5,2,80,3,1,8,15,11,0,12,70,7,%11110110
	DC.B $80,0,$81,6,1,31,$FF,3,12,40,13,0,8,16,$FF,0  (32)
snd25	DC.B  0,100,1,5,2,80,3,1,8,15,11,0,12,70,7,%11110110
	DC.B $80,31,$81,6,-1,0,$FF,3,12,40,13,0,8,16,$FF,0   (34)   
snd26   dc.b 0,0,1,13,2,0,3,12,4,0,5,15,6,0  rock
	dc.b 7,$C0,8,16,9,16,10,16,11,0,12,44
	dc.b 13,2,130,160		(30)
snd27	dc.b 0,0,1,13,2,0,3,12,4,0,5,15,6,0 ship
	dc.b 7,$F8,8,16,9,16,10,16,11,200,12,200
	dc.b 13,2,130,250		(30)
snd28	dc.b	3,3,3,%100000,16
	dc.b	5,0,64,0
	dc.b	4,101
	dc.b	4,91
	dc.b	4,81
	dc.b	4,71
	dc.b	4,61
	dc.b	4,51
	dc.b	4,41
	dc.b	4,31
	dc.b	4,21
	dc.b	4,11
	dc.b	255		(s0)
silence
	DC.B 7,%00111111,0,255,0
neutral
	DC.B 0,254,1,0,2,0,3,0,4,0,5,0,6,0,7,254,8,14
	DC.B 9,0,10,0,11,0,12,0,13,0,130,20,8,0,130,0,255,0

	EVEN
  