games	dc.b 27,"E",10,13,27,"b",4

	dc.b "      BUDGIE UK are the creators of     ",10,13
	dc.b "       many fine games for the ST.      ",10,13
	dc.b "      They are distributed through      ",10,10,13
	dc.b 27,"b",15
	dc.b "        LICENSED    DISTRIBUTORS        ",10,10,13
	dc.b 27,"b",4
	dc.b "Royalties are paid to all our writers.  ",10,13    
	dc.b "A list of Licensed Distributors ",10,13
	dc.b "is available from the Budgie Office.    ",10,10,13
	dc.b "----------------------------------------",10,13
check3	dc.b "The following BUDGIE titles             ",10,13
	dc.b "               are now available:       ",10,13
	dc.b "----------------------------------------",10,13,0
games1	dc.b 27,"E"
	dc.b 27,"b",4,"Damonoid"
	dc.b 27,"b",6," by  Camy Maertens. ",10,13
	dc.b "20 planets, no less, have",10,13
	dc.b "to be protected from Damonoid and its   ",10,13
	dc.b "invading fleet. Action is fast. Time is ",10,13
	dc.b "running out.  Any enemy impact on your  ",10,13
	dc.b "planet causes havoc. You can sustain 13 ",10,13
	dc.b "direct hits. But, should the Damonoid   ",10,13
	dc.b "itself land, the result would be fatal! ",10,13
	dc.b 27,"b",4,"FOOTBALL 88"
	dc.b 27,"b",6," by Simon Rush. A complete     ",10,13
	dc.b " manager game. Very addictive           ",10,13
	dc.b "This Football Manager is extremely easy ",10,13
	dc.b "to play and contains many features that ",10,13
	dc.b "sets it apart from other offerings,     ",10,13
	dc.b "its multi-user capability being one of  ",10,13
	dc.b "them.If you are a budding soccer supremo",10,13
	dc.b "this game is undoubtedly for you!",10,13
	dc.b 27,"b",4,"BLITZ III"
	dc.b 27,"b",6," by Camy Maertens. ",10,13
	dc.b "This is a bombing raid with a different ",10,13
	dc.b "scenario: three aircraft fly in         ",10,13
	dc.b "formation, all under joystick control.  ",10,13
	dc.b "The aim of the game is to destroy the   ",10,13
	dc.b "city before too much altitude is lost.  ",10,13
	dc.b "'Challenging game..' ST Format Feb 89   ",0
games2	dc.b 27,"E"
	dc.b 27,"b",4,"OTHELLO"
	dc.b 27,"b",6," by Jim Holmwood.              ",10,13
	dc.b "Entirely mouse controlled and     ",10,13
	dc.b "playing a mean game.  You may find it    ",10,13
	dc.b "difficult to beat the computer, but this",10,13
	dc.b "will maintain its appeal.               ",10,13
	dc.b "Two versions are included on this disk: ",10,13
	dc.b "one mono and the other colour.          ",10,10,13
	dc.b 27,"b",4,"PRO DARTS"
	dc.b 27,"b",6," by Martyn Carr                ",10,13
	dc.b "This is a mouse controlled simulation,  ",10,13
	dc.b "5O1 down.            All darts addicts  ",10,13
	dc.b "will love this game and the somewhat    ",10,13
	dc.b "hesitant pointer (too much beer perhaps)",10,13
	dc.b "Speech commentary adds to the realism.  ",10,13
	dc.b 27,"b",4,"BALL ZONE"
	dc.b 27,"b",6," by Ian Grainger  an incredible",10,13
	dc.b "Arkanoid type game, only better.        ",10,13
	dc.b "Needless to say, this game is mouse     ",10,13
	dc.b "controlled and has many levels.  But the",10,13
	dc.b "main attractions are the time counter   ",10,13
	dc.b "which dramatically increases the tension",10,13
	dc.b "and, also, the reassuring presence of   ",10,13
	dc.b "base line tiles which will rescue you   ",10,13
	dc.b "in desparate situations.                ",0
games3	dc.b 27,"E",27,"b",4,"DR BORIS "
	dc.b 27,"b",6," by Alex Dewdney    ",10,13
	dc.b "a TNT maniac is on the loose, lighting  ",10,13
	dc.b "explosive devices in a maze of          ",10,13
	dc.b "increasingly dangerous alleys.  You have",10,13
	dc.b "1O seconds to defuse the bombs before   ",10,13
	dc.b "the inevitable blast.  There are many   ",10,13
	dc.b "obstructions in your path, including    ",10,13
	dc.b "walls and...skulls.                     ",10,13
	dc.b "Also on this disk, by the same author,  ",10,13
	dc.b 27,"b",4,"PUZZLER ",27,"b",6
	dc.b " a diabolical brain teaser.     ",10,10,13
	dc.b 27,"b",4,"SPECULATOR"  
 	dc.b 27,"b",6," by Camy Maertens    ",10,13
	dc.b "You start with 5OOO points and have to  ",10,13
	dc.b "correctly guess the direction of the    ",10,13
	dc.b "market.  Trends develop, reversals occur",10,13
	dc.b "and sudden panics can cause havoc with  ",10,13
	dc.b "the soundest strategies. ",10,13
	dc.b "The Index 'point and figure' chart      ",10,13
	dc.b "unfolds before your eyes and reveals    ",10,13
	dc.b "your profits or ...losses.              ",0
games4	dc.b 27,"E"
	dc.b 27,"b",4,"MONEYSPINNER"
	dc.b 27,"b",6," by Jim Holmwood",10,13
	dc.b "The slot machine is alive !             ",10,13
	dc.b "This accolade winning Budgie UK classic ",10,13
	dc.b "incorporates all the usual features :   ",10,13
	dc.b "nudges, gambles, holds, and some more.  ",10,13
	dc.b "The scrolling is smooth and once again, ",10,13
	dc.b "the game is mouse controlled.           ",10,13
	dc.b "State of the Art gambling!              ",10,13
	dc.b "'A very enjoyable game to say the least'",10,13
	dc.b "ST Action December 88.                  ",10,10,13
	dc.b 27,"b",4,"TYCOON"
	dc.b 27,"b",6," by Simon Rush.                ",10,13
	dc.b "A multi-player mineral exploring game.  ",10,13
	dc.b "The objective is to survey, test drill  ",10,13
	dc.b "and eventually exploit various sites to ",10,13
	dc.b "extract valuable minerals.   Mines have ",10,13
	dc.b "different levels of profitability.      ",10,13,0

games5	dc.b 27,"E"
	dc.b 27,"b",4,"ACE INVADERS"
	dc.b 27,"b",6," by Gary Wheaton",10,13
	dc.b "The DEFINITIVE Space Invader !          ",10,13
	dc.b "Everything the all-time classic is or   ",10,13
	dc.b "should be  is in this game: speed, sound",10,13
	dc.b "drama, excitement.                      ",10,13
	dc.b "All collectors and connoisseurs will    ",10,13
	dc.b "treasure this disk. There is nothing to ",10,13
	dc.b "touch it, even commercial.              ",10,13
	dc.b "Three Stars ST Format August 89. ",10,10,13
	dc.b 27,"b",4,"ZENITH"
	dc.b 27,"b",6," by Gary Wheaton",10,13
	dc.b "A space combat for two players.         ",10,13
	dc.b "Mouse v. Joystick.  Several convoys of  ",10,13
	dc.b "aliens fly through space, wave after    ",10,13
	dc.b "wave. Your mission is to intercept them.",10,13
	dc.b "Your opponent has the same ambition and ",10,13
	dc.b "his space ship has to be destroyed.     ",10,13
	dc.b "The ensuing battle is a delight for all ",10,13
	dc.b "arcade fanatics. Another classic!       ",0 
games6	dc.b 27,"E"
	dc.b 27,"b",4,"GOLDRUSH"
	dc.b 27,"b",6," by Mark Annetts               ",10,13
	dc.b "A multi-level platform pursuit.         ",10,13
	dc.b "The aim is to collect the gold while    ",10,13
	dc.b "avoiding your pursuer. Joystick control.",10,13
	dc.b "The puzzles are the main attraction of  ",10,13
	dc.b "this platform game. This is the thinking",10,13	
	dc.b "man's version of Loderunner.            ",10,13
	dc.b "Also on same disk:",27,"b",4,"ZERPHOD",10,13
	dc.b 27,"b",6,"by Ian Grainger",10,13
	dc.b "3D maze challenge.  Find the modules ",10,13
	dc.b "before time runs out,avoid the nasties. ",10,10,13
	dc.b 27,"b",4,"PERILS of PENFOLD"
	dc.b 27,"b",6," by Philip Bishop              ",10,13
	dc.b "A superb graphic adventure with caves to",10,13
	dc.b "explore, potions and spells to gather,  ",10,13
	dc.b "ghosts and flying knives to avoid and   ",10,13
	dc.b "puzzles to solve.",10,13
	dc.b "Also included on this disk, by the same ",10,13
	dc.b "author: LINE of FOUR a fiendish connect ",10,13
	dc.b "game that will give hours of pleasure   ",10,13
	dc.b "...or frustration! ",0
games7	dc.b 27,"E"
	dc.b 27,"b",4,"WORD FIND PUZZLE GENERATOR",10,13
	dc.b 27,"b",6," by Keith Bearman",10,13
	dc.b "Medium res and hi res monochrome.",10,13
	dc.b "You can play the puzzles on your",10,13 
	dc.b "monitor or print them on paper.",10,13
	dc.b "Because of its expandability, this",10,13
	dc.b "program will keep you busy for",10,13
	dc.b "a very long time.",10,13
	dc.b "A fantastic screen/printer font",10,13
	dc.b "manager by Jeremy Hughes is included!",10,10,13
	dc.b 27,"b",4,"MAKE A BREAK"
	dc.b 27,"b",6," by Martyn Brown",10,13 
	dc.b "of 17Bit Software",10,13
	dc.b "A extremely powerful (and colourful)",10,13
	dc.b "quizz game set in a snooker ",10,13
	dc.b "environment",10,13
	dc.b "Subjects covered are varied: arts,",10,13
	dc.b "sports, the past, music, books,",10,13 
	dc.b "the world, etc..Version 1.1",10,13
	dc.b "Five stars ST FORMAT december 89",0
games8	dc.b 27,"E"
	dc.b 27,"b",4,"PARABELLUM"
	dc.b 27,"b",6," by Alex Dewdney",10,13
	dc.b "Confined to the deepest dungeon of",10,13
	dc.b "the underworld, you must progress",10,13
	dc.b "from chamber to chamber until you",10,13
	dc.b "escape.  Evil creatures lurk in every",10,13
	dc.b "corner: the task is daunting!",10,13
	dc.b "This is a challenging platform game",10,13
	dc.b "with lasting appeal.",10,10,13
	dc.b 27,"b",4,"TRI HELI"
	dc.b 27,"b",6," by Gary Wheaton",10,13 
	dc.b "of The Shapeshifters",10,13
	dc.b "A pixel feast if ever there was one!",10,13
	dc.b "Two blindingly fast games on one disk,",10,13
	dc.b "plus several demos, all compacted to",10,13
	dc.b "give you hours of arcade entertainment.",10,13
	dc.b "TRI-HELI and COSMOS are superb examples",10,13 
	dc.b "of 8-bit classics now at last",10,13
	dc.b "gracing the Atari ST.",0
games9	dc.b 27,"E"
	dc.b 27,"b",4,"OPERATION ANGELICA"
	dc.b 27,"b",6," by Camy Maertens",10,13
	dc.b "Your mission is to rescue British troops",10,13
	dc.b "stranded on Buff Cove.",10,13
	dc.b "The island has been mined. ",10,13
	dc.b "Time is critical and enemy aircraft",10,13
	dc.b "are bombing you relentlessly...",10,13
	dc.b "Nine action-packed levels !",10,10,13 
	dc.b 27,"b",4,"IMPULSE"
	dc.b 27,"b",6," by Ian Grainger",10,13 
	dc.b "At last, a totally new concept!",10,13
	dc.b "Each scene holds a detonator,",10,13
	dc.b "strategically situated, and thoroughly",10,13
	dc.b "guarded.     First, marauding aliens",10,13
	dc.b "have to be destroyed, using your",10,13
	dc.b "rotating gun turrets. Angles are",10,13 
	dc.b "critical if the phaser ray is not to",10,13
	dc.b "rebound on you. Eventually, the",10,13
	dc.b "detonator is exposed and has to be hit",10,13
	dc.b "Eleven levels of trajectories,",10,13
	dc.b "bounces and deflections!",0
games10	dc.b 27,"E"
	dc.b 27,"b",4,"BANDIT"
	dc.b 27,"b",6," by Gary Wheaton & Shapeshifters",10,13
	dc.b "Electronic slot machine with nudges",10,13
	dc.b "up and down, holds, shoot-outs and",10,13
	dc.b "a delightful page three bonus.",10,13
	dc.b "Excellent music, superlative graphics.",10,13
	dc.b "Only the Shapeshifters could have",10,13
	dc.b "brought you this awesome arcade",10,13
	dc.b "bonanza!",10,13
	dc.b "Also on same disk, the Spartan demo.",10,10,13
	dc.b 27,"b",4,"SPACE BLOB",10,13
	dc.b 27,"b",6," by Robin Edwards",10,13
	dc.b "An immensely enjoyable platform game.",10,13
	dc.b "Fifteen levels and three bonus screens.",10,13
	dc.b "Collect the crystals and avoid the",10,13 
	dc.b "baddies. Try not to land on rugged",10,13
	dc.b "terrain: Space Blob likes his landings",10,13
	dc.b "soft and gentle.",10,13
	dc.b "Also on same disk: HAPPY the anti-virus",10,13
	dc.b "smiling face. And more goodies!",0
games11	dc.b 27,"E"
	dc.b 27,"b",4,"SLIPPERY SID",10,13
	dc.b 27,"b",6," by Neil Scrimgeour",10,13
	dc.b "Emprisoned in a set of mazes, Sid has",10,13 
	dc.b "to munch his way through large",10,13 
	dc.b "quantities of pills.  As he munches,",10,13 
	dc.b "he grows longer, shedding the odd tail",10,13 
	dc.b "just to confuse you.   Nine mazes.",10,10,13 
	dc.b 27,"b",4,"SCARY",10,13
	dc.b 27,"b",6," by Eddie Bryan",10,13
	dc.b "The haunted mansion in which your girl",10,13 
	dc.b "friend has been abducted is a den of",10,13 
	dc.b "evil and unnatural.",10,13 
	dc.b "Many rooms have to be searched before",10,13 
	dc.b "you can rescue her.",10,10,13 
	dc.b 27,"b",4,"CARRIER ATTACK",10,13
	dc.b 27,"b",6," by Keith Bearman",10,13 
	dc.b "Rediscover the drama and excitement",10,13 
	dc.b "of Battleships.",10,13 
	dc.b "Ten levels of computer intelligence.",10,13 
	dc.b "Naval strategy of the highest order.",0
games12	dc.b 27,"E"
	dc.b 27,"b",4,"PSICOTIC",10,13 
	dc.b 27,"b",6," by Philip Rankin",10,13
	dc.b "A space combat against forces",10,13 
	dc.b "attacking from the East.",10,13 
	dc.b "Extra armement can be gained",10,13 
	dc.b "during the engagements.",10,13 
	dc.b "Dare and survive!",10,10,13 
	dc.b 27,"b",4,"SUB HUNT",10,13
	dc.b 27,"b",6," by Oliver Bros",10,13
	dc.b "A two player game set in some of the",10,13 
	dc.b "globe's hot spots: Tropics, Arctic,",10,13 
	dc.b "and Persian Gulf.",10,13 
	dc.b "Busy shipping lanes are under threat",10,13 
	dc.b "Protect allied vessels and destroy",10,13 
	dc.b "enemy cargo. Helicoper v submarine.",10,13
	dc.b "Also on same disk:",10,13 
	dc.b 27,"b",4,"SEA FISHERMAN",10,13
	dc.b 27,"b",6," by Paul Dowers",10,13
	dc.b "A fishing simulator",10,13 
	dc.b "on the ST..! Prepare for exciting",10,13 
	dc.b "action, but do take a book with you,",10,13 
	dc.b "just in case...",0
games13	dc.b 27,"E"
	dc.b 27,"b",4,"DEATH CAMP",10,13
	dc.b 27,"b",6," by Dave Blower",10,13
	dc.b "The first text-based adventure from",10,13 
	dc.b "Budgie UK. Ample illustrations are",10,13 
	dc.b "nevertheless provided to convey",10,13 
	dc.b "the true atmosphere.",10,13 
	dc.b "The Japanese POW camp is your ",10,13 
	dc.b "nightmare. Your objective: to escape!",10,10,13 

	dc.b 27,"b",4,"A QUEST for GALAXIA",10,13
	dc.b 27,"b",6," by Gary Wheaton + Shapeshifters",10,13
	dc.b "Part two of Budgie's tribute to the",10,13 
	dc.b "all-time classics.",10,13 
	dc.b "Rediscover the thrill and excitement",10,13 
	dc.b "of an immortal game.",10,13 
	dc.b "10 levels of galactic chaos.",10,13 
	dc.b "High scores saved to disk.",10,13 
	dc.b "This game is without a doubt, the",10,13  
	dc.b "jewel in the Budgie collection.",10,13 
	dc.b "The Shapeshifters at their best!",0 
games14	dc.b 27,"E"
	dc.b 27,"b",4,"INFERNO",10,13
	dc.b 27,"b",6," by Simon Brown",10,13
	dc.b "Your task is to control a cunning",10,13 
	dc.b "demon in his bid to return to his cosy",10,13
	dc.b "fire in hell.",10,13
	dc.b "Your progress through a maze of",10,13 
	dc.b "tunnels is hazardous as boulders,",10,13
	dc.b "skulls and un-hatched eggs are ever",10,13
	dc.b "present.",10,13
	dc.b "A fine variation of the boulderdash",10,13
	dc.b "theme.",10,13
	dc.b 27,"b",4,"RUNAWAY",10,13
	dc.b 27,"b",6," by Chris Skellern",10,13
	dc.b "Guide a drone ship through the tunnels",10,13
	dc.b "of the moon. The ship is out of control",10,13
	dc.b "and cannot slow down!",10,13
	dc.b "There is fuel on board, but friction",10,13
	dc.b "against the tunnel walls depletes your",10,13
	dc.b "shields.",10,13
	dc.b "The pace is frantic. The journey is",10,13
	dc.b "tortuous and unforgiving.",10,13
	dc.b "From the author of Sprite Master.",10,13,0
games15	dc.b 27,"E"
	dc.b 27,"b",4,"ROTATUS",10,13
	dc.b 27,"b",6," by Simon Brown",10,13
	dc.b "A rotating experience in outer space.",10,13
	dc.b "On the edge of the galaxy, your ship",10,13
	dc.b "attempts to land on the nearest planet.",10,13
	dc.b "Asteroids and boulders continuously",10,13
	dc.b "cross your paths.",10,13
	dc.b "Space marauders also gyrate on a",10,13 
	dc.b "collision course. Avoid them or",10,13
	dc.b "shoot them!",10,13,0

games16	dc.b 27,"E"
	dc.b 27,"b",6,"DOUBLE SIDED COMPILATIONS:",10,13
	dc.b "520K memory OK but ONE MEG drive needed.",10,10,13
	dc.b 27,"b",4
	dc.b "Perils of Penfold - Line of Four",10,13
	dc.b "Goldrush  - Zerphod",10,13
	dc.b "-----------------",10,13
	dc.b "Ace Invaders /Zenith /Tri Heli - Cosmos",10,13
	dc.b "--------------------------------------",10,13
	dc.b "Football 88 /Parabellum",10,13
	dc.b "-----------------------",10,13
	dc.b "Make a Break /Blitz /Word Generator",10,13
	dc.b "-----------------------------------",10,13
	dc.b "Dr Boris - Puzzler /Pro Darts /Maelstrom",10,13
	dc.b "---------------------------------------",10,13
	dc.b "Damonoid /Speculator /Othello",10,13
	dc.b "-----------------------------",10,13
	dc.b "Ball Zone /Moneyspinner",10,13
	dc.b "-----------------------",10,13
	dc.b "Football /Moneyspinner /Tri Heli",10,13
	dc.b "--------------------------------",10,13,0
games17	dc.b 27,"E"
	dc.b "Bandit /Slippery Sid /Space Blob",10,13
	dc.b "--------------------------------",10,13
	dc.b "Angelica /Psicotic /Galaxia",10,13
	dc.b "---------------------------",10,13
	dc.b "Carrier Attack /Sub Hunt - Fisherman",10,13
	dc.b "-----------------------------------",10,13
	dc.b "Impulse /Scary",10,13,0

	EVEN


