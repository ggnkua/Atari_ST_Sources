* routines needed by a specific program
