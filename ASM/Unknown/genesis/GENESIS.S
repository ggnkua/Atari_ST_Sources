	MOVE.L	#BBS,-(SP)
	MOVE.W	#9,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP

	CLR.L	-(SP)
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
	MOVE.L	D0,SAVESP

	MOVEQ	#0,D0		(0-3)
	JSR	MUS

PLAY_MUSIC
	JSR	MUS+$106

	MOVE.L	$462.W,D0
WAIT	CMP.L	$462.W,D0
	BEQ.B	WAIT

	CMP.B	#$39,$FFFFFC02.W
	BNE.B	PLAY_MUSIC

	LEA	$FFFF8800.W,A0
	MOVE.L	#$08080000,(A0)		Shut The Music
	MOVE.L	#$09090000,(A0)
	MOVE.L	#$0A0A0000,(A0)

	MOVE.L	SAVESP(PC),-(SP)
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP

	CLR.W	-(SP)
	TRAP	#1

	SECTION	DATA
MUS	INCBIN	GENESIS.MUS
BBS		DC.B	27,"E"
		DC.B	"Call the Toxic BBS!",10,13
		DC.B	"A pure Atari ST/STE BBS.",10,13
		DC.B	"1200-9600 Bps.",10,10,13
		DC.B	"TEL. 013-128907",0
	EVEN
	SECTION	BSS
SAVESP		DS.L	1	