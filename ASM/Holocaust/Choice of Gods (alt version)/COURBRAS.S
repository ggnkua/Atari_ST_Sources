 DC.L BUF8,MASQ9,72,100*160
 DC.L BUF8,MASQ9,72,100*160
 DC.L BUF7,MASQ8,72,101*160
 DC.L BUF6,MASQ7,72,101*160
 DC.L BUF6,MASQ7,72,102*160
 DC.L BUF5,MASQ6,72,103*160
 DC.L BUF4,MASQ5,72,103*160
 DC.L BUF4,MASQ5,72,104*160
 DC.L BUF3,MASQ4,72,105*160
 DC.L BUF2,MASQ3,72,105*160
 DC.L BUF2,MASQ3,72,106*160
 DC.L BUF1,MASQ2,72,107*160
 DC.L BUF16,MASQ17,80,107*160
 DC.L BUF16,MASQ17,80,108*160
 DC.L BUF15,MASQ16,80,109*160
 DC.L BUF14,MASQ15,80,109*160
 DC.L BUF14,MASQ15,80,110*160
 DC.L BUF13,MASQ14,80,111*160
 DC.L BUF12,MASQ13,80,111*160
 DC.L BUF12,MASQ13,80,112*160
 DC.L BUF11,MASQ12,80,113*160
 DC.L BUF10,MASQ11,80,113*160
 DC.L BUF10,MASQ11,80,114*160
 DC.L BUF9,MASQ10,80,115*160
 DC.L BUF8,MASQ9,80,115*160
 DC.L BUF7,MASQ8,80,116*160
 DC.L BUF7,MASQ8,80,117*160
 DC.L BUF6,MASQ7,80,117*160
 DC.L BUF5,MASQ6,80,118*160
 DC.L BUF5,MASQ6,80,119*160
 DC.L BUF4,MASQ5,80,119*160
 DC.L BUF3,MASQ4,80,120*160
 DC.L BUF3,MASQ4,80,121*160
 DC.L BUF2,MASQ3,80,121*160
 DC.L BUF1,MASQ2,80,122*160
 DC.L BUF1,MASQ2,80,122*160
 DC.L BUF16,MASQ17,88,123*160
 DC.L BUF15,MASQ16,88,124*160
 DC.L BUF15,MASQ16,88,124*160
 DC.L BUF14,MASQ15,88,125*160
 DC.L BUF13,MASQ14,88,126*160
 DC.L BUF13,MASQ14,88,126*160
 DC.L BUF12,MASQ13,88,127*160
 DC.L BUF11,MASQ12,88,127*160
 DC.L BUF11,MASQ12,88,128*160
 DC.L BUF10,MASQ11,88,129*160
 DC.L BUF10,MASQ11,88,129*160
 DC.L BUF9,MASQ10,88,130*160
 DC.L BUF8,MASQ9,88,131*160
 DC.L BUF8,MASQ9,88,131*160
 DC.L BUF7,MASQ8,88,132*160
 DC.L BUF6,MASQ7,88,132*160
 DC.L BUF6,MASQ7,88,133*160
 DC.L BUF5,MASQ6,88,134*160
 DC.L BUF4,MASQ5,88,134*160
 DC.L BUF4,MASQ5,88,135*160
 DC.L BUF3,MASQ4,88,135*160
 DC.L BUF2,MASQ3,88,136*160
 DC.L BUF2,MASQ3,88,137*160
 DC.L BUF1,MASQ2,88,137*160
 DC.L BUF16,MASQ17,96,138*160
 DC.L BUF16,MASQ17,96,138*160
 DC.L BUF15,MASQ16,96,139*160
 DC.L BUF15,MASQ16,96,140*160
 DC.L BUF14,MASQ15,96,140*160
 DC.L BUF13,MASQ14,96,141*160
 DC.L BUF13,MASQ14,96,141*160
 DC.L BUF12,MASQ13,96,142*160
 DC.L BUF11,MASQ12,96,142*160
 DC.L BUF11,MASQ12,96,143*160
 DC.L BUF10,MASQ11,96,144*160
 DC.L BUF10,MASQ11,96,144*160
 DC.L BUF9,MASQ10,96,145*160
 DC.L BUF8,MASQ9,96,145*160
 DC.L BUF8,MASQ9,96,146*160
 DC.L BUF7,MASQ8,96,146*160
 DC.L BUF7,MASQ8,96,147*160
 DC.L BUF6,MASQ7,96,147*160
 DC.L BUF5,MASQ6,96,148*160
 DC.L BUF5,MASQ6,96,148*160
 DC.L BUF4,MASQ5,96,149*160
 DC.L BUF4,MASQ5,96,150*160
 DC.L BUF3,MASQ4,96,150*160
 DC.L BUF2,MASQ3,96,151*160
 DC.L BUF2,MASQ3,96,151*160
 DC.L BUF1,MASQ2,96,152*160
 DC.L BUF1,MASQ2,96,152*160
 DC.L BUF16,MASQ17,104,153*160
 DC.L BUF16,MASQ17,104,153*160
 DC.L BUF15,MASQ16,104,154*160
 DC.L BUF14,MASQ15,104,154*160
 DC.L BUF14,MASQ15,104,155*160
 DC.L BUF13,MASQ14,104,155*160
 DC.L BUF13,MASQ14,104,156*160
 DC.L BUF12,MASQ13,104,156*160
 DC.L BUF12,MASQ13,104,157*160
 DC.L BUF11,MASQ12,104,157*160
 DC.L BUF10,MASQ11,104,158*160
 DC.L BUF10,MASQ11,104,158*160
 DC.L BUF9,MASQ10,104,158*160
 DC.L BUF9,MASQ10,104,159*160
 DC.L BUF8,MASQ9,104,159*160
 DC.L BUF8,MASQ9,104,160*160
 DC.L BUF7,MASQ8,104,160*160
 DC.L BUF7,MASQ8,104,161*160
 DC.L BUF6,MASQ7,104,161*160
 DC.L BUF6,MASQ7,104,162*160
 DC.L BUF5,MASQ6,104,162*160
 DC.L BUF4,MASQ5,104,162*160
 DC.L BUF4,MASQ5,104,163*160
 DC.L BUF3,MASQ4,104,163*160
 DC.L BUF3,MASQ4,104,164*160
 DC.L BUF2,MASQ3,104,164*160
 DC.L BUF2,MASQ3,104,165*160
 DC.L BUF1,MASQ2,104,165*160
 DC.L BUF1,MASQ2,104,165*160
 DC.L BUF16,MASQ17,112,166*160
 DC.L BUF16,MASQ17,112,166*160
 DC.L BUF15,MASQ16,112,166*160
 DC.L BUF15,MASQ16,112,167*160
 DC.L BUF14,MASQ15,112,167*160
 DC.L BUF14,MASQ15,112,168*160
 DC.L BUF13,MASQ14,112,168*160
 DC.L BUF13,MASQ14,112,168*160
 DC.L BUF12,MASQ13,112,169*160
 DC.L BUF12,MASQ13,112,169*160
 DC.L BUF12,MASQ13,112,169*160
 DC.L BUF11,MASQ12,112,170*160
 DC.L BUF11,MASQ12,112,170*160
 DC.L BUF10,MASQ11,112,170*160
 DC.L BUF10,MASQ11,112,171*160
 DC.L BUF9,MASQ10,112,171*160
 DC.L BUF9,MASQ10,112,171*160
 DC.L BUF8,MASQ9,112,172*160
 DC.L BUF8,MASQ9,112,172*160
 DC.L BUF7,MASQ8,112,172*160
 DC.L BUF7,MASQ8,112,173*160
 DC.L BUF7,MASQ8,112,173*160
 DC.L BUF6,MASQ7,112,173*160
 DC.L BUF6,MASQ7,112,174*160
 DC.L BUF5,MASQ6,112,174*160
 DC.L BUF5,MASQ6,112,174*160
 DC.L BUF4,MASQ5,112,174*160
 DC.L BUF4,MASQ5,112,175*160
 DC.L BUF4,MASQ5,112,175*160
 DC.L BUF3,MASQ4,112,175*160
 DC.L BUF3,MASQ4,112,175*160
 DC.L BUF2,MASQ3,112,176*160
 DC.L BUF2,MASQ3,112,176*160
 DC.L BUF2,MASQ3,112,176*160
 DC.L BUF1,MASQ2,112,176*160
 DC.L BUF1,MASQ2,112,177*160
 DC.L BUF16,MASQ17,120,177*160
 DC.L BUF16,MASQ17,120,177*160
 DC.L BUF16,MASQ17,120,177*160
 DC.L BUF15,MASQ16,120,177*160
 DC.L BUF15,MASQ16,120,178*160
 DC.L BUF15,MASQ16,120,178*160
 DC.L BUF14,MASQ15,120,178*160
 DC.L BUF14,MASQ15,120,178*160
 DC.L BUF13,MASQ14,120,178*160
 DC.L BUF13,MASQ14,120,179*160
 DC.L BUF13,MASQ14,120,179*160
 DC.L BUF12,MASQ13,120,179*160
 DC.L BUF12,MASQ13,120,179*160
 DC.L BUF12,MASQ13,120,179*160
 DC.L BUF11,MASQ12,120,179*160
 DC.L BUF11,MASQ12,120,180*160
 DC.L BUF11,MASQ12,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF9,MASQ10,120,180*160
 DC.L BUF9,MASQ10,120,180*160
 DC.L BUF9,MASQ10,120,181*160
 DC.L BUF8,MASQ9,120,181*160
 DC.L BUF8,MASQ9,120,181*160
 DC.L BUF8,MASQ9,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF16,MASQ17,128,181*160
 DC.L BUF16,MASQ17,128,181*160
 DC.L BUF16,MASQ17,128,181*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF14,MASQ15,128,179*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,175*160
 DC.L BUF14,MASQ15,128,175*160
 DC.L BUF13,MASQ14,128,175*160
 DC.L BUF13,MASQ14,128,175*160
 DC.L BUF13,MASQ14,128,174*160
 DC.L BUF13,MASQ14,128,174*160
 DC.L BUF13,MASQ14,128,174*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,172*160
 DC.L BUF13,MASQ14,128,172*160
 DC.L BUF13,MASQ14,128,172*160
 DC.L BUF14,MASQ15,128,171*160
 DC.L BUF14,MASQ15,128,171*160
 DC.L BUF14,MASQ15,128,171*160
 DC.L BUF14,MASQ15,128,170*160
 DC.L BUF14,MASQ15,128,170*160
 DC.L BUF14,MASQ15,128,170*160
 DC.L BUF14,MASQ15,128,169*160
 DC.L BUF14,MASQ15,128,169*160
 DC.L BUF14,MASQ15,128,169*160
 DC.L BUF14,MASQ15,128,168*160
 DC.L BUF14,MASQ15,128,168*160
 DC.L BUF14,MASQ15,128,168*160
 DC.L BUF14,MASQ15,128,167*160
 DC.L BUF14,MASQ15,128,167*160
 DC.L BUF14,MASQ15,128,166*160
 DC.L BUF14,MASQ15,128,166*160
 DC.L BUF14,MASQ15,128,166*160
 DC.L BUF14,MASQ15,128,165*160
 DC.L BUF15,MASQ16,128,165*160
 DC.L BUF15,MASQ16,128,164*160
 DC.L BUF15,MASQ16,128,164*160
 DC.L BUF15,MASQ16,128,164*160
 DC.L BUF15,MASQ16,128,163*160
 DC.L BUF15,MASQ16,128,163*160
 DC.L BUF15,MASQ16,128,162*160
 DC.L BUF15,MASQ16,128,162*160
 DC.L BUF15,MASQ16,128,162*160
 DC.L BUF16,MASQ17,128,161*160
 DC.L BUF16,MASQ17,128,161*160
 DC.L BUF16,MASQ17,128,160*160
 DC.L BUF16,MASQ17,128,160*160
 DC.L BUF16,MASQ17,128,159*160
 DC.L BUF16,MASQ17,128,159*160
 DC.L BUF16,MASQ17,128,158*160
 DC.L BUF1,MASQ2,120,158*160
 DC.L BUF1,MASQ2,120,157*160
 DC.L BUF1,MASQ2,120,157*160
 DC.L BUF1,MASQ2,120,156*160
 DC.L BUF1,MASQ2,120,156*160
 DC.L BUF1,MASQ2,120,156*160
 DC.L BUF2,MASQ3,120,155*160
 DC.L BUF2,MASQ3,120,155*160
 DC.L BUF2,MASQ3,120,154*160
 DC.L BUF2,MASQ3,120,154*160

 DC.L BUF2,MASQ3,120,153*160
 DC.L BUF2,MASQ3,120,153*160
 DC.L BUF3,MASQ4,120,152*160
 DC.L BUF3,MASQ4,120,152*160
 DC.L BUF3,MASQ4,120,151*160
 DC.L BUF3,MASQ4,120,150*160
 DC.L BUF3,MASQ4,120,150*160
 DC.L BUF4,MASQ5,120,149*160
 DC.L BUF4,MASQ5,120,149*160
 DC.L BUF4,MASQ5,120,148*160
 DC.L BUF4,MASQ5,120,148*160
 DC.L BUF4,MASQ5,120,147*160
 DC.L BUF5,MASQ6,120,147*160
 DC.L BUF5,MASQ6,120,146*160
 DC.L BUF5,MASQ6,120,146*160
 DC.L BUF5,MASQ6,120,145*160
 DC.L BUF6,MASQ7,120,145*160
 DC.L BUF6,MASQ7,120,144*160
 DC.L BUF6,MASQ7,120,143*160
 DC.L BUF6,MASQ7,120,143*160
 DC.L BUF7,MASQ8,120,142*160
 DC.L BUF7,MASQ8,120,142*160
 DC.L BUF7,MASQ8,120,141*160
 DC.L BUF7,MASQ8,120,141*160
 DC.L BUF8,MASQ9,120,140*160
 DC.L BUF8,MASQ9,120,139*160
 DC.L BUF8,MASQ9,120,139*160
 DC.L BUF8,MASQ9,120,138*160
 DC.L BUF9,MASQ10,120,138*160
 DC.L BUF9,MASQ10,120,137*160
 DC.L BUF9,MASQ10,120,137*160
 DC.L BUF10,MASQ11,120,136*160
 DC.L BUF10,MASQ11,120,135*160
 DC.L BUF10,MASQ11,120,135*160
 DC.L BUF10,MASQ11,120,134*160
 DC.L BUF11,MASQ12,120,134*160
 DC.L BUF11,MASQ12,120,133*160
 DC.L BUF11,MASQ12,120,132*160
 DC.L BUF12,MASQ13,120,132*160
 DC.L BUF12,MASQ13,120,131*160
 DC.L BUF12,MASQ13,120,130*160
 DC.L BUF13,MASQ14,120,130*160
 DC.L BUF13,MASQ14,120,129*160
 DC.L BUF13,MASQ14,120,129*160
 DC.L BUF14,MASQ15,120,128*160
 DC.L BUF14,MASQ15,120,127*160
 DC.L BUF14,MASQ15,120,127*160
 DC.L BUF14,MASQ15,120,126*160
 DC.L BUF15,MASQ16,120,126*160
 DC.L BUF15,MASQ16,120,125*160
 DC.L BUF15,MASQ16,120,124*160
 DC.L BUF16,MASQ17,120,124*160
 DC.L BUF16,MASQ17,120,123*160
 DC.L BUF16,MASQ17,120,122*160
 DC.L BUF1,MASQ2,112,122*160
 DC.L BUF1,MASQ2,112,121*160
 DC.L BUF2,MASQ3,112,120*160
 DC.L BUF2,MASQ3,112,120*160
 DC.L BUF2,MASQ3,112,119*160
 DC.L BUF3,MASQ4,112,118*160
 DC.L BUF3,MASQ4,112,118*160
 DC.L BUF3,MASQ4,112,117*160
 DC.L BUF4,MASQ5,112,117*160
 DC.L BUF4,MASQ5,112,116*160
 DC.L BUF4,MASQ5,112,115*160
 DC.L BUF5,MASQ6,112,115*160
 DC.L BUF5,MASQ6,112,114*160
 DC.L BUF5,MASQ6,112,113*160
 DC.L BUF6,MASQ7,112,113*160
 DC.L BUF6,MASQ7,112,112*160
 DC.L BUF7,MASQ8,112,111*160
 DC.L BUF7,MASQ8,112,111*160
 DC.L BUF7,MASQ8,112,110*160
 DC.L BUF8,MASQ9,112,109*160
 DC.L BUF8,MASQ9,112,109*160
 DC.L BUF9,MASQ10,112,108*160
 DC.L BUF9,MASQ10,112,107*160
 DC.L BUF9,MASQ10,112,107*160
 DC.L BUF10,MASQ11,112,106*160
 DC.L BUF10,MASQ11,112,105*160
 DC.L BUF10,MASQ11,112,105*160
 DC.L BUF11,MASQ12,112,104*160
 DC.L BUF11,MASQ12,112,103*160
 DC.L BUF12,MASQ13,112,103*160
 DC.L BUF12,MASQ13,112,102*160
 DC.L BUF12,MASQ13,112,101*160
 DC.L BUF13,MASQ14,112,101*160
 DC.L BUF13,MASQ14,112,100*160
 DC.L BUF14,MASQ15,112,99*160
 DC.L BUF14,MASQ15,112,99*160
 DC.L BUF15,MASQ16,112,98*160
 DC.L BUF15,MASQ16,112,97*160
 DC.L BUF15,MASQ16,112,97*160
 DC.L BUF16,MASQ17,112,96*160
 DC.L BUF16,MASQ17,112,95*160
 DC.L BUF1,MASQ2,104,95*160
 DC.L BUF1,MASQ2,104,94*160
 DC.L BUF1,MASQ2,104,93*160
 DC.L BUF2,MASQ3,104,93*160
 DC.L BUF2,MASQ3,104,92*160
 DC.L BUF3,MASQ4,104,91*160
 DC.L BUF3,MASQ4,104,91*160
 DC.L BUF4,MASQ5,104,90*160
 DC.L BUF4,MASQ5,104,89*160
 DC.L BUF4,MASQ5,104,89*160
 DC.L BUF5,MASQ6,104,88*160
 DC.L BUF5,MASQ6,104,87*160
 DC.L BUF6,MASQ7,104,87*160
 DC.L BUF6,MASQ7,104,86*160
 DC.L BUF7,MASQ8,104,86*160
 DC.L BUF7,MASQ8,104,85*160
 DC.L BUF7,MASQ8,104,84*160
 DC.L BUF8,MASQ9,104,84*160
 DC.L BUF8,MASQ9,104,83*160
 DC.L BUF9,MASQ10,104,82*160
 DC.L BUF9,MASQ10,104,82*160
 DC.L BUF10,MASQ11,104,81*160
 DC.L BUF10,MASQ11,104,80*160
 DC.L BUF11,MASQ12,104,80*160
 DC.L BUF11,MASQ12,104,79*160
 DC.L BUF11,MASQ12,104,78*160
 DC.L BUF12,MASQ13,104,78*160
 DC.L BUF12,MASQ13,104,77*160
 DC.L BUF13,MASQ14,104,76*160
 DC.L BUF13,MASQ14,104,76*160
 DC.L BUF14,MASQ15,104,75*160
 DC.L BUF14,MASQ15,104,75*160
 DC.L BUF15,MASQ16,104,74*160
 DC.L BUF15,MASQ16,104,73*160
 DC.L BUF15,MASQ16,104,73*160
 DC.L BUF16,MASQ17,104,72*160
 DC.L BUF16,MASQ17,104,71*160
 DC.L BUF1,MASQ2,96,71*160
 DC.L BUF1,MASQ2,96,70*160
 DC.L BUF2,MASQ3,96,70*160
 DC.L BUF2,MASQ3,96,69*160
 DC.L BUF3,MASQ4,96,68*160
 DC.L BUF3,MASQ4,96,68*160
 DC.L BUF4,MASQ5,96,67*160
 DC.L BUF4,MASQ5,96,66*160
 DC.L BUF4,MASQ5,96,66*160
 DC.L BUF5,MASQ6,96,65*160
 DC.L BUF5,MASQ6,96,65*160
 DC.L BUF6,MASQ7,96,64*160
 DC.L BUF6,MASQ7,96,63*160
 DC.L BUF7,MASQ8,96,63*160
 DC.L BUF7,MASQ8,96,62*160
 DC.L BUF8,MASQ9,96,62*160
 DC.L BUF8,MASQ9,96,61*160
 DC.L BUF8,MASQ9,96,61*160
 DC.L BUF9,MASQ10,96,60*160
 DC.L BUF9,MASQ10,96,59*160
 DC.L BUF10,MASQ11,96,59*160
 DC.L BUF10,MASQ11,96,58*160
 DC.L BUF11,MASQ12,96,58*160
 DC.L BUF11,MASQ12,96,57*160
 DC.L BUF12,MASQ13,96,56*160
 DC.L BUF12,MASQ13,96,56*160
 DC.L BUF13,MASQ14,96,55*160
 DC.L BUF13,MASQ14,96,55*160
 DC.L BUF13,MASQ14,96,54*160
 DC.L BUF14,MASQ15,96,54*160
 DC.L BUF14,MASQ15,96,53*160
 DC.L BUF15,MASQ16,96,53*160
 DC.L BUF15,MASQ16,96,52*160
 DC.L BUF16,MASQ17,96,52*160
 DC.L BUF16,MASQ17,96,51*160
 DC.L BUF1,MASQ2,88,50*160
 DC.L BUF1,MASQ2,88,50*160
 DC.L BUF1,MASQ2,88,49*160
 DC.L BUF2,MASQ3,88,49*160
 DC.L BUF2,MASQ3,88,48*160
 DC.L BUF3,MASQ4,88,48*160
 DC.L BUF3,MASQ4,88,47*160
 DC.L BUF4,MASQ5,88,47*160
 DC.L BUF4,MASQ5,88,46*160
 DC.L BUF4,MASQ5,88,46*160
 DC.L BUF5,MASQ6,88,45*160
 DC.L BUF5,MASQ6,88,45*160
 DC.L BUF6,MASQ7,88,44*160
 DC.L BUF6,MASQ7,88,44*160
 DC.L BUF7,MASQ8,88,43*160
 DC.L BUF7,MASQ8,88,43*160
 DC.L BUF7,MASQ8,88,42*160
 DC.L BUF8,MASQ9,88,42*160
 DC.L BUF8,MASQ9,88,41*160
 DC.L BUF9,MASQ10,88,41*160
 DC.L BUF9,MASQ10,88,40*160
 DC.L BUF10,MASQ11,88,40*160
 DC.L BUF10,MASQ11,88,40*160
 DC.L BUF10,MASQ11,88,39*160
 DC.L BUF11,MASQ12,88,39*160
 DC.L BUF11,MASQ12,88,38*160
 DC.L BUF12,MASQ13,88,38*160
 DC.L BUF12,MASQ13,88,37*160
 DC.L BUF13,MASQ14,88,37*160
 DC.L BUF13,MASQ14,88,37*160
 DC.L BUF13,MASQ14,88,36*160
 DC.L BUF14,MASQ15,88,36*160
 DC.L BUF14,MASQ15,88,35*160
 DC.L BUF15,MASQ16,88,35*160
 DC.L BUF15,MASQ16,88,34*160
 DC.L BUF15,MASQ16,88,34*160
 DC.L BUF16,MASQ17,88,34*160
 DC.L BUF16,MASQ17,88,33*160
 DC.L BUF1,MASQ2,80,33*160
 DC.L BUF1,MASQ2,80,32*160
 DC.L BUF1,MASQ2,80,32*160
 DC.L BUF2,MASQ3,80,32*160
 DC.L BUF2,MASQ3,80,31*160
 DC.L BUF3,MASQ4,80,31*160
 DC.L BUF3,MASQ4,80,31*160
 DC.L BUF3,MASQ4,80,30*160
 DC.L BUF4,MASQ5,80,30*160
 DC.L BUF4,MASQ5,80,30*160
 DC.L BUF4,MASQ5,80,29*160
 DC.L BUF5,MASQ6,80,29*160
 DC.L BUF5,MASQ6,80,29*160
 DC.L BUF6,MASQ7,80,28*160
 DC.L BUF6,MASQ7,80,28*160
 DC.L BUF6,MASQ7,80,28*160
 DC.L BUF7,MASQ8,80,27*160
 DC.L BUF7,MASQ8,80,27*160
 DC.L BUF7,MASQ8,80,27*160
 DC.L BUF8,MASQ9,80,26*160
 DC.L BUF8,MASQ9,80,26*160
 DC.L BUF9,MASQ10,80,26*160
 DC.L BUF9,MASQ10,80,25*160
 DC.L BUF9,MASQ10,80,25*160
 DC.L BUF10,MASQ11,80,25*160
 DC.L BUF10,MASQ11,80,25*160
 DC.L BUF10,MASQ11,80,24*160
 DC.L BUF11,MASQ12,80,24*160
 DC.L BUF11,MASQ12,80,24*160
 DC.L BUF11,MASQ12,80,24*160
 DC.L BUF12,MASQ13,80,23*160
 DC.L BUF12,MASQ13,80,23*160
 DC.L BUF12,MASQ13,80,23*160
 DC.L BUF13,MASQ14,80,23*160
 DC.L BUF13,MASQ14,80,22*160
 DC.L BUF13,MASQ14,80,22*160
 DC.L BUF14,MASQ15,80,22*160
 DC.L BUF14,MASQ15,80,22*160
 DC.L BUF14,MASQ15,80,22*160
 DC.L BUF15,MASQ16,80,21*160
 DC.L BUF15,MASQ16,80,21*160
 DC.L BUF15,MASQ16,80,21*160
 DC.L BUF16,MASQ17,80,21*160
 DC.L BUF16,MASQ17,80,21*160
 DC.L BUF16,MASQ17,80,20*160
 DC.L BUF16,MASQ17,80,20*160
 DC.L BUF1,MASQ2,72,20*160
 DC.L BUF1,MASQ2,72,20*160
 DC.L BUF1,MASQ2,72,20*160
 DC.L BUF2,MASQ3,72,20*160
 DC.L BUF2,MASQ3,72,19*160
 DC.L BUF2,MASQ3,72,19*160
 DC.L BUF2,MASQ3,72,19*160
 DC.L BUF3,MASQ4,72,19*160
 DC.L BUF3,MASQ4,72,19*160
 DC.L BUF3,MASQ4,72,19*160
 DC.L BUF4,MASQ5,72,19*160
 DC.L BUF4,MASQ5,72,19*160
 DC.L BUF4,MASQ5,72,18*160
 DC.L BUF4,MASQ5,72,18*160
 DC.L BUF5,MASQ6,72,18*160
 DC.L BUF5,MASQ6,72,18*160
 DC.L BUF5,MASQ6,72,18*160
 DC.L BUF5,MASQ6,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF12,MASQ13,72,18*160
 DC.L BUF12,MASQ13,72,18*160
 DC.L BUF12,MASQ13,72,18*160
 DC.L BUF12,MASQ13,72,19*160
 DC.L BUF12,MASQ13,72,19*160
 DC.L BUF12,MASQ13,72,19*160
 DC.L BUF12,MASQ13,72,19*160
 DC.L BUF13,MASQ14,72,19*160
 DC.L BUF13,MASQ14,72,19*160
 DC.L BUF13,MASQ14,72,19*160
 DC.L BUF13,MASQ14,72,19*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF14,MASQ15,72,21*160
 DC.L BUF14,MASQ15,72,21*160
 DC.L BUF14,MASQ15,72,21*160
 DC.L BUF14,MASQ15,72,21*160
 DC.L BUF14,MASQ15,72,21*160
 DC.L BUF14,MASQ15,72,22*160
 DC.L BUF14,MASQ15,72,22*160
 DC.L BUF14,MASQ15,72,22*160
 DC.L BUF14,MASQ15,72,22*160
 DC.L BUF14,MASQ15,72,22*160
 DC.L BUF14,MASQ15,72,23*160
 DC.L BUF14,MASQ15,72,23*160
 DC.L BUF14,MASQ15,72,23*160
 DC.L BUF14,MASQ15,72,23*160
 DC.L BUF14,MASQ15,72,24*160
 DC.L BUF14,MASQ15,72,24*160
 DC.L BUF15,MASQ16,72,24*160
 DC.L BUF15,MASQ16,72,24*160
 DC.L BUF15,MASQ16,72,25*160
 DC.L BUF15,MASQ16,72,25*160
 DC.L BUF15,MASQ16,72,25*160
 DC.L BUF15,MASQ16,72,26*160
 DC.L BUF15,MASQ16,72,26*160
 DC.L BUF15,MASQ16,72,26*160
 DC.L BUF15,MASQ16,72,26*160
 DC.L BUF15,MASQ16,72,27*160
 DC.L BUF15,MASQ16,72,27*160
 DC.L BUF15,MASQ16,72,27*160
 DC.L BUF15,MASQ16,72,28*160
 DC.L BUF15,MASQ16,72,28*160
 DC.L BUF15,MASQ16,72,28*160
 DC.L BUF15,MASQ16,72,29*160
 DC.L BUF15,MASQ16,72,29*160
 DC.L BUF15,MASQ16,72,29*160
 DC.L BUF14,MASQ15,72,30*160
 DC.L BUF14,MASQ15,72,30*160
 DC.L BUF14,MASQ15,72,30*160
 DC.L BUF14,MASQ15,72,31*160
 DC.L BUF14,MASQ15,72,31*160
 DC.L BUF14,MASQ15,72,32*160
 DC.L BUF14,MASQ15,72,32*160
 DC.L BUF14,MASQ15,72,32*160
 DC.L BUF14,MASQ15,72,33*160
 DC.L BUF14,MASQ15,72,33*160
 DC.L BUF14,MASQ15,72,33*160
 DC.L BUF14,MASQ15,72,34*160
 DC.L BUF14,MASQ15,72,34*160
 DC.L BUF14,MASQ15,72,35*160
 DC.L BUF14,MASQ15,72,35*160
 DC.L BUF14,MASQ15,72,35*160
 DC.L BUF13,MASQ14,72,36*160
 DC.L BUF13,MASQ14,72,36*160
 DC.L BUF13,MASQ14,72,37*160
 DC.L BUF13,MASQ14,72,37*160
 DC.L BUF13,MASQ14,72,38*160
 DC.L BUF13,MASQ14,72,38*160
 DC.L BUF13,MASQ14,72,38*160
 DC.L BUF13,MASQ14,72,39*160
 DC.L BUF13,MASQ14,72,39*160
 DC.L BUF12,MASQ13,72,40*160
 DC.L BUF12,MASQ13,72,40*160
 DC.L BUF12,MASQ13,72,41*160
 DC.L BUF12,MASQ13,72,41*160
 DC.L BUF12,MASQ13,72,42*160
 DC.L BUF12,MASQ13,72,42*160
 DC.L BUF12,MASQ13,72,43*160
 DC.L BUF11,MASQ12,72,43*160
 DC.L BUF11,MASQ12,72,44*160
 DC.L BUF11,MASQ12,72,44*160
 DC.L BUF11,MASQ12,72,45*160
 DC.L BUF11,MASQ12,72,45*160
 DC.L BUF11,MASQ12,72,46*160
 DC.L BUF10,MASQ11,72,46*160
 DC.L BUF10,MASQ11,72,47*160
 DC.L BUF10,MASQ11,72,47*160
 DC.L BUF10,MASQ11,72,48*160
 DC.L BUF10,MASQ11,72,48*160
 DC.L BUF10,MASQ11,72,49*160
 DC.L BUF9,MASQ10,72,49*160
 DC.L BUF9,MASQ10,72,50*160
 DC.L BUF9,MASQ10,72,50*160
 DC.L BUF9,MASQ10,72,51*160
 DC.L BUF9,MASQ10,72,51*160
 DC.L BUF8,MASQ9,72,52*160
 DC.L BUF8,MASQ9,72,52*160
 DC.L BUF8,MASQ9,72,53*160
 DC.L BUF8,MASQ9,72,53*160
 DC.L BUF7,MASQ8,72,54*160
 DC.L BUF7,MASQ8,72,55*160
 DC.L BUF7,MASQ8,72,55*160
 DC.L BUF7,MASQ8,72,56*160
 DC.L BUF6,MASQ7,72,56*160
 DC.L BUF6,MASQ7,72,57*160
 DC.L BUF6,MASQ7,72,57*160
 DC.L BUF6,MASQ7,72,58*160
 DC.L BUF5,MASQ6,72,58*160
 DC.L BUF5,MASQ6,72,59*160
 DC.L BUF5,MASQ6,72,60*160
 DC.L BUF5,MASQ6,72,60*160
 DC.L BUF4,MASQ5,72,61*160
 DC.L BUF4,MASQ5,72,61*160
 DC.L BUF4,MASQ5,72,62*160
 DC.L BUF4,MASQ5,72,63*160
 DC.L BUF3,MASQ4,72,63*160
 DC.L BUF3,MASQ4,72,64*160
 DC.L BUF3,MASQ4,72,64*160
 DC.L BUF2,MASQ3,72,65*160
 DC.L BUF2,MASQ3,72,66*160
 DC.L BUF2,MASQ3,72,66*160
 DC.L BUF2,MASQ3,72,67*160
 DC.L BUF1,MASQ2,72,67*160
 DC.L BUF1,MASQ2,72,68*160
 DC.L BUF1,MASQ2,72,69*160
 DC.L BUF16,MASQ17,80,69*160
 DC.L BUF16,MASQ17,80,70*160
 DC.L BUF16,MASQ17,80,70*160
 DC.L BUF15,MASQ16,80,71*160
 DC.L BUF15,MASQ16,80,72*160
 DC.L BUF15,MASQ16,80,72*160
 DC.L BUF14,MASQ15,80,73*160
 DC.L BUF14,MASQ15,80,74*160
 DC.L BUF14,MASQ15,80,74*160
 DC.L BUF13,MASQ14,80,75*160
 DC.L BUF13,MASQ14,80,75*160
 DC.L BUF13,MASQ14,80,76*160
 DC.L BUF12,MASQ13,80,77*160
 DC.L BUF12,MASQ13,80,77*160
 DC.L BUF12,MASQ13,80,78*160
 DC.L BUF11,MASQ12,80,79*160
 DC.L BUF11,MASQ12,80,79*160
 DC.L BUF11,MASQ12,80,80*160
 DC.L BUF10,MASQ11,80,81*160
 DC.L BUF10,MASQ11,80,81*160
 DC.L BUF9,MASQ10,80,82*160
 DC.L BUF9,MASQ10,80,83*160
 DC.L BUF9,MASQ10,80,83*160
 DC.L BUF8,MASQ9,80,84*160
 DC.L BUF8,MASQ9,80,85*160
 DC.L BUF8,MASQ9,80,85*160
 DC.L BUF7,MASQ8,80,86*160
 DC.L BUF7,MASQ8,80,86*160
 DC.L BUF6,MASQ7,80,87*160
 DC.L BUF6,MASQ7,80,88*160
 DC.L BUF6,MASQ7,80,88*160
 DC.L BUF5,MASQ6,80,89*160
 DC.L BUF5,MASQ6,80,90*160
 DC.L BUF4,MASQ5,80,90*160
 DC.L BUF4,MASQ5,80,91*160
 DC.L BUF4,MASQ5,80,92*160
 DC.L BUF3,MASQ4,80,92*160
 DC.L BUF3,MASQ4,80,93*160
 DC.L BUF2,MASQ3,80,94*160
 DC.L BUF2,MASQ3,80,94*160
 DC.L BUF1,MASQ2,80,95*160
 DC.L BUF1,MASQ2,80,96*160
 DC.L BUF1,MASQ2,80,96*160
 DC.L BUF16,MASQ17,88,97*160
 DC.L BUF16,MASQ17,88,98*160
 DC.L BUF15,MASQ16,88,98*160
 DC.L BUF15,MASQ16,88,99*160
 DC.L BUF14,MASQ15,88,100*160
 DC.L BUF14,MASQ15,88,100*160
 DC.L BUF13,MASQ14,88,101*160
 DC.L BUF13,MASQ14,88,102*160
 DC.L BUF13,MASQ14,88,102*160
 DC.L BUF12,MASQ13,88,103*160
 DC.L BUF12,MASQ13,88,104*160
 DC.L BUF11,MASQ12,88,104*160
 DC.L BUF11,MASQ12,88,105*160
 DC.L BUF10,MASQ11,88,106*160
 DC.L BUF10,MASQ11,88,106*160
 DC.L BUF9,MASQ10,88,107*160
 DC.L BUF9,MASQ10,88,108*160
 DC.L BUF8,MASQ9,88,108*160
 DC.L BUF8,MASQ9,88,109*160
 DC.L BUF7,MASQ8,88,110*160
 DC.L BUF7,MASQ8,88,110*160
 DC.L BUF7,MASQ8,88,111*160
 DC.L BUF6,MASQ7,88,112*160
 DC.L BUF6,MASQ7,88,112*160
 DC.L BUF5,MASQ6,88,113*160
 DC.L BUF5,MASQ6,88,114*160
 DC.L BUF4,MASQ5,88,114*160
 DC.L BUF4,MASQ5,88,115*160
 DC.L BUF3,MASQ4,88,116*160
 DC.L BUF3,MASQ4,88,116*160
 DC.L BUF2,MASQ3,88,117*160
 DC.L BUF2,MASQ3,88,117*160
 DC.L BUF1,MASQ2,88,118*160
 DC.L BUF1,MASQ2,88,119*160
 DC.L BUF16,MASQ17,96,119*160
 DC.L BUF16,MASQ17,96,120*160
 DC.L BUF15,MASQ16,96,121*160
 DC.L BUF15,MASQ16,96,121*160
 DC.L BUF14,MASQ15,96,122*160
 DC.L BUF14,MASQ15,96,123*160
 DC.L BUF13,MASQ14,96,123*160
 DC.L BUF13,MASQ14,96,124*160
 DC.L BUF12,MASQ13,96,125*160
 DC.L BUF12,MASQ13,96,125*160
 DC.L BUF11,MASQ12,96,126*160
 DC.L BUF11,MASQ12,96,126*160
 DC.L BUF10,MASQ11,96,127*160
 DC.L BUF9,MASQ10,96,128*160
 DC.L BUF9,MASQ10,96,128*160
 DC.L BUF8,MASQ9,96,129*160
 DC.L BUF8,MASQ9,96,130*160
 DC.L BUF7,MASQ8,96,130*160
 DC.L BUF7,MASQ8,96,131*160
 DC.L BUF6,MASQ7,96,131*160
 DC.L BUF6,MASQ7,96,132*160
 DC.L BUF5,MASQ6,96,133*160
 DC.L BUF5,MASQ6,96,133*160
 DC.L BUF4,MASQ5,96,134*160
 DC.L BUF4,MASQ5,96,134*160
 DC.L BUF3,MASQ4,96,135*160
 DC.L BUF3,MASQ4,96,136*160
 DC.L BUF2,MASQ3,96,136*160
 DC.L BUF2,MASQ3,96,137*160
 DC.L BUF1,MASQ2,96,137*160
 DC.L BUF16,MASQ17,104,138*160
 DC.L BUF16,MASQ17,104,139*160
 DC.L BUF15,MASQ16,104,139*160
 DC.L BUF15,MASQ16,104,140*160
 DC.L BUF14,MASQ15,104,140*160
 DC.L BUF14,MASQ15,104,141*160
 DC.L BUF13,MASQ14,104,141*160
 DC.L BUF13,MASQ14,104,142*160
 DC.L BUF12,MASQ13,104,143*160
 DC.L BUF12,MASQ13,104,143*160
 DC.L BUF11,MASQ12,104,144*160
 DC.L BUF11,MASQ12,104,144*160
 DC.L BUF10,MASQ11,104,145*160
 DC.L BUF9,MASQ10,104,145*160
 DC.L BUF9,MASQ10,104,146*160
 DC.L BUF8,MASQ9,104,146*160
 DC.L BUF8,MASQ9,104,147*160
 DC.L BUF7,MASQ8,104,148*160
 DC.L BUF7,MASQ8,104,148*160
 DC.L BUF6,MASQ7,104,149*160
 DC.L BUF6,MASQ7,104,149*160
 DC.L BUF5,MASQ6,104,150*160
 DC.L BUF5,MASQ6,104,150*160
 DC.L BUF4,MASQ5,104,151*160
 DC.L BUF3,MASQ4,104,151*160
 DC.L BUF3,MASQ4,104,152*160
 DC.L BUF2,MASQ3,104,152*160
 DC.L BUF2,MASQ3,104,153*160
 DC.L BUF1,MASQ2,104,153*160
 DC.L BUF1,MASQ2,104,154*160
 DC.L BUF16,MASQ17,112,154*160
 DC.L BUF16,MASQ17,112,155*160
 DC.L BUF15,MASQ16,112,155*160
 DC.L BUF15,MASQ16,112,156*160
 DC.L BUF14,MASQ15,112,156*160
 DC.L BUF13,MASQ14,112,157*160
 DC.L BUF13,MASQ14,112,157*160
 DC.L BUF12,MASQ13,112,158*160
 DC.L BUF12,MASQ13,112,158*160
 DC.L BUF11,MASQ12,112,159*160
 DC.L BUF11,MASQ12,112,159*160
 DC.L BUF10,MASQ11,112,159*160
 DC.L BUF10,MASQ11,112,160*160
 DC.L BUF9,MASQ10,112,160*160
 DC.L BUF8,MASQ9,112,161*160
 DC.L BUF8,MASQ9,112,161*160
 DC.L BUF7,MASQ8,112,162*160
 DC.L BUF7,MASQ8,112,162*160
 DC.L BUF6,MASQ7,112,163*160
 DC.L BUF6,MASQ7,112,163*160
 DC.L BUF5,MASQ6,112,163*160
 DC.L BUF5,MASQ6,112,164*160
 DC.L BUF4,MASQ5,112,164*160
 DC.L BUF4,MASQ5,112,165*160
 DC.L BUF3,MASQ4,112,165*160
 DC.L BUF3,MASQ4,112,165*160
 DC.L BUF2,MASQ3,112,166*160
 DC.L BUF1,MASQ2,112,166*160
 DC.L BUF1,MASQ2,112,167*160
 DC.L BUF16,MASQ17,120,167*160
 DC.L BUF16,MASQ17,120,167*160
 DC.L BUF15,MASQ16,120,168*160
 DC.L BUF15,MASQ16,120,168*160
 DC.L BUF14,MASQ15,120,168*160
 DC.L BUF14,MASQ15,120,169*160
 DC.L BUF13,MASQ14,120,169*160
 DC.L BUF13,MASQ14,120,170*160
 DC.L BUF12,MASQ13,120,170*160
 DC.L BUF12,MASQ13,120,170*160
 DC.L BUF11,MASQ12,120,171*160
 DC.L BUF11,MASQ12,120,171*160
 DC.L BUF10,MASQ11,120,171*160
 DC.L BUF10,MASQ11,120,171*160
 DC.L BUF9,MASQ10,120,172*160
 DC.L BUF8,MASQ9,120,172*160
 DC.L BUF8,MASQ9,120,172*160
 DC.L BUF7,MASQ8,120,173*160
 DC.L BUF7,MASQ8,120,173*160
 DC.L BUF6,MASQ7,120,173*160
 DC.L BUF6,MASQ7,120,174*160
 DC.L BUF5,MASQ6,120,174*160
 DC.L BUF5,MASQ6,120,174*160
 DC.L BUF4,MASQ5,120,174*160
 DC.L BUF4,MASQ5,120,175*160
 DC.L BUF3,MASQ4,120,175*160
 DC.L BUF3,MASQ4,120,175*160
 DC.L BUF2,MASQ3,120,175*160
 DC.L BUF2,MASQ3,120,176*160
 DC.L BUF1,MASQ2,120,176*160
 DC.L BUF1,MASQ2,120,176*160
 DC.L BUF16,MASQ17,128,176*160
 DC.L BUF16,MASQ17,128,177*160
 DC.L BUF15,MASQ16,128,177*160
 DC.L BUF15,MASQ16,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF13,MASQ14,128,178*160
 DC.L BUF13,MASQ14,128,178*160
 DC.L BUF12,MASQ13,128,178*160
 DC.L BUF12,MASQ13,128,178*160
 DC.L BUF12,MASQ13,128,178*160
 DC.L BUF11,MASQ12,128,179*160
 DC.L BUF11,MASQ12,128,179*160
 DC.L BUF10,MASQ11,128,179*160
 DC.L BUF10,MASQ11,128,179*160
 DC.L BUF9,MASQ10,128,179*160
 DC.L BUF9,MASQ10,128,179*160
 DC.L BUF8,MASQ9,128,180*160
 DC.L BUF8,MASQ9,128,180*160
 DC.L BUF7,MASQ8,128,180*160
 DC.L BUF7,MASQ8,128,180*160
 DC.L BUF6,MASQ7,128,180*160
 DC.L BUF6,MASQ7,128,180*160
 DC.L BUF6,MASQ7,128,180*160
 DC.L BUF5,MASQ6,128,180*160
 DC.L BUF5,MASQ6,128,181*160
 DC.L BUF4,MASQ5,128,181*160
 DC.L BUF4,MASQ5,128,181*160
 DC.L BUF3,MASQ4,128,181*160
 DC.L BUF3,MASQ4,128,181*160
 DC.L BUF2,MASQ3,128,181*160
 DC.L BUF2,MASQ3,128,181*160
 DC.L BUF2,MASQ3,128,181*160
 DC.L BUF1,MASQ2,128,181*160
 DC.L BUF1,MASQ2,128,181*160
 DC.L BUF16,MASQ17,136,181*160
 DC.L BUF16,MASQ17,136,181*160
 DC.L BUF15,MASQ16,136,181*160
 DC.L BUF15,MASQ16,136,181*160
 DC.L BUF15,MASQ16,136,181*160
 DC.L BUF14,MASQ15,136,181*160
 DC.L BUF14,MASQ15,136,181*160
 DC.L BUF13,MASQ14,136,181*160
 DC.L BUF13,MASQ14,136,181*160
 DC.L BUF13,MASQ14,136,181*160
 DC.L BUF12,MASQ13,136,181*160
 DC.L BUF12,MASQ13,136,181*160
 DC.L BUF11,MASQ12,136,181*160
 DC.L BUF11,MASQ12,136,181*160
 DC.L BUF11,MASQ12,136,181*160
 DC.L BUF10,MASQ11,136,181*160
 DC.L BUF10,MASQ11,136,181*160
 DC.L BUF10,MASQ11,136,181*160
 DC.L BUF9,MASQ10,136,181*160
 DC.L BUF9,MASQ10,136,181*160
 DC.L BUF8,MASQ9,136,181*160
 DC.L BUF8,MASQ9,136,181*160
 DC.L BUF8,MASQ9,136,181*160
 DC.L BUF7,MASQ8,136,181*160
 DC.L BUF7,MASQ8,136,181*160
 DC.L BUF7,MASQ8,136,181*160
 DC.L BUF6,MASQ7,136,181*160
 DC.L BUF6,MASQ7,136,181*160
 DC.L BUF6,MASQ7,136,180*160
 DC.L BUF5,MASQ6,136,180*160
 DC.L BUF5,MASQ6,136,180*160
 DC.L BUF5,MASQ6,136,180*160
 DC.L BUF4,MASQ5,136,180*160
 DC.L BUF4,MASQ5,136,180*160
 DC.L BUF4,MASQ5,136,180*160
 DC.L BUF3,MASQ4,136,180*160
 DC.L BUF3,MASQ4,136,179*160
 DC.L BUF3,MASQ4,136,179*160
 DC.L BUF2,MASQ3,136,179*160
 DC.L BUF2,MASQ3,136,179*160
 DC.L BUF2,MASQ3,136,179*160
 DC.L BUF2,MASQ3,136,179*160
 DC.L BUF1,MASQ2,136,179*160
 DC.L BUF1,MASQ2,136,178*160
 DC.L BUF1,MASQ2,136,178*160
 DC.L BUF16,MASQ17,144,178*160
 DC.L BUF16,MASQ17,144,178*160
 DC.L BUF16,MASQ17,144,178*160
 DC.L BUF16,MASQ17,144,177*160
 DC.L BUF15,MASQ16,144,177*160
 DC.L BUF15,MASQ16,144,177*160
 DC.L BUF15,MASQ16,144,177*160
 DC.L BUF15,MASQ16,144,176*160
 DC.L BUF14,MASQ15,144,176*160
 DC.L BUF14,MASQ15,144,176*160
 DC.L BUF14,MASQ15,144,176*160
 DC.L BUF14,MASQ15,144,176*160
 DC.L BUF13,MASQ14,144,175*160
 DC.L BUF13,MASQ14,144,175*160
 DC.L BUF13,MASQ14,144,175*160
 DC.L BUF13,MASQ14,144,175*160
 DC.L BUF12,MASQ13,144,174*160
 DC.L BUF12,MASQ13,144,174*160
 DC.L BUF12,MASQ13,144,174*160
 DC.L BUF12,MASQ13,144,173*160
 DC.L BUF12,MASQ13,144,173*160
 DC.L BUF11,MASQ12,144,173*160
 DC.L BUF11,MASQ12,144,173*160
 DC.L BUF11,MASQ12,144,172*160
 DC.L BUF11,MASQ12,144,172*160
 DC.L BUF11,MASQ12,144,172*160
 DC.L BUF10,MASQ11,144,171*160
 DC.L BUF10,MASQ11,144,171*160
 DC.L BUF10,MASQ11,144,171*160
 DC.L BUF10,MASQ11,144,170*160
 DC.L BUF10,MASQ11,144,170*160
 DC.L BUF9,MASQ10,144,170*160
 DC.L BUF9,MASQ10,144,169*160
 DC.L BUF9,MASQ10,144,169*160
 DC.L BUF9,MASQ10,144,169*160
 DC.L BUF9,MASQ10,144,168*160
 DC.L BUF9,MASQ10,144,168*160
 DC.L BUF9,MASQ10,144,167*160
 DC.L BUF8,MASQ9,144,167*160
 DC.L BUF8,MASQ9,144,167*160
 DC.L BUF8,MASQ9,144,166*160
 DC.L BUF8,MASQ9,144,166*160
 DC.L BUF8,MASQ9,144,166*160
 DC.L BUF8,MASQ9,144,165*160
 DC.L BUF8,MASQ9,144,165*160
 DC.L BUF7,MASQ8,144,164*160
 DC.L BUF7,MASQ8,144,164*160
 DC.L BUF7,MASQ8,144,164*160
 DC.L BUF7,MASQ8,144,163*160
 DC.L BUF7,MASQ8,144,163*160
 DC.L BUF7,MASQ8,144,162*160
 DC.L BUF7,MASQ8,144,162*160
 DC.L BUF7,MASQ8,144,161*160
 DC.L BUF7,MASQ8,144,161*160
 DC.L BUF7,MASQ8,144,160*160
 DC.L BUF7,MASQ8,144,160*160
 DC.L BUF7,MASQ8,144,160*160
 DC.L BUF6,MASQ7,144,159*160
 DC.L BUF6,MASQ7,144,159*160
 DC.L BUF6,MASQ7,144,158*160
 DC.L BUF6,MASQ7,144,158*160
 DC.L BUF6,MASQ7,144,157*160
 DC.L BUF6,MASQ7,144,157*160
 DC.L BUF6,MASQ7,144,156*160
 DC.L BUF6,MASQ7,144,156*160
 DC.L BUF6,MASQ7,144,155*160
 DC.L BUF6,MASQ7,144,155*160
 DC.L BUF6,MASQ7,144,154*160
 DC.L BUF6,MASQ7,144,154*160
 DC.L BUF6,MASQ7,144,153*160
 DC.L BUF6,MASQ7,144,153*160
 DC.L BUF6,MASQ7,144,152*160
 DC.L BUF6,MASQ7,144,152*160
 DC.L BUF6,MASQ7,144,151*160
 DC.L BUF6,MASQ7,144,151*160
 DC.L BUF6,MASQ7,144,150*160
 DC.L BUF6,MASQ7,144,150*160
 DC.L BUF6,MASQ7,144,149*160
 DC.L BUF6,MASQ7,144,149*160
 DC.L BUF6,MASQ7,144,148*160
 DC.L BUF6,MASQ7,144,148*160
 DC.L BUF6,MASQ7,144,147*160
 DC.L BUF6,MASQ7,144,147*160
 DC.L BUF6,MASQ7,144,146*160
 DC.L BUF6,MASQ7,144,146*160
 DC.L BUF6,MASQ7,144,145*160
 DC.L BUF6,MASQ7,144,144*160
 DC.L BUF6,MASQ7,144,144*160
 DC.L BUF6,MASQ7,144,143*160
 DC.L BUF7,MASQ8,144,143*160
 DC.L BUF7,MASQ8,144,142*160
 DC.L BUF7,MASQ8,144,142*160
 DC.L BUF7,MASQ8,144,141*160
 DC.L BUF7,MASQ8,144,140*160
 DC.L BUF7,MASQ8,144,140*160
 DC.L BUF7,MASQ8,144,139*160
 DC.L BUF7,MASQ8,144,139*160
 DC.L BUF7,MASQ8,144,138*160
 DC.L BUF7,MASQ8,144,138*160
 DC.L BUF7,MASQ8,144,137*160
 DC.L BUF8,MASQ9,144,136*160
 DC.L BUF8,MASQ9,144,136*160
 DC.L BUF8,MASQ9,144,135*160
 DC.L BUF8,MASQ9,144,135*160
 DC.L BUF8,MASQ9,144,134*160
 DC.L BUF8,MASQ9,144,133*160
 DC.L BUF8,MASQ9,144,133*160
 DC.L BUF8,MASQ9,144,132*160
 DC.L BUF9,MASQ10,144,132*160
 DC.L BUF9,MASQ10,144,131*160
 DC.L BUF9,MASQ10,144,130*160
 DC.L BUF9,MASQ10,144,130*160
 DC.L BUF9,MASQ10,144,129*160
 DC.L BUF9,MASQ10,144,128*160
 DC.L BUF10,MASQ11,144,128*160
 DC.L BUF10,MASQ11,144,127*160
 DC.L BUF10,MASQ11,144,127*160
 DC.L BUF10,MASQ11,144,126*160
 DC.L BUF10,MASQ11,144,125*160
 DC.L BUF10,MASQ11,144,125*160
 DC.L BUF11,MASQ12,144,124*160
 DC.L BUF11,MASQ12,144,123*160
 DC.L BUF11,MASQ12,144,123*160
 DC.L BUF11,MASQ12,144,122*160
 DC.L BUF12,MASQ13,144,122*160
 DC.L BUF12,MASQ13,144,121*160
 DC.L BUF12,MASQ13,144,120*160
 DC.L BUF12,MASQ13,144,120*160
 DC.L BUF12,MASQ13,144,119*160
 DC.L BUF13,MASQ14,144,118*160
 DC.L BUF13,MASQ14,144,118*160
 DC.L BUF13,MASQ14,144,117*160
 DC.L BUF13,MASQ14,144,116*160
 DC.L BUF14,MASQ15,144,116*160
 DC.L BUF14,MASQ15,144,115*160
 DC.L BUF14,MASQ15,144,114*160
 DC.L BUF14,MASQ15,144,114*160
 DC.L BUF15,MASQ16,144,113*160
 DC.L BUF15,MASQ16,144,112*160
 DC.L BUF15,MASQ16,144,112*160
 DC.L BUF15,MASQ16,144,111*160
 DC.L BUF16,MASQ17,144,110*160
 DC.L BUF16,MASQ17,144,110*160
 DC.L BUF16,MASQ17,144,109*160
 DC.L BUF1,MASQ2,136,108*160
 DC.L BUF1,MASQ2,136,108*160
 DC.L BUF1,MASQ2,136,107*160
 DC.L BUF1,MASQ2,136,107*160
 DC.L BUF2,MASQ3,136,106*160
 DC.L BUF2,MASQ3,136,105*160
 DC.L BUF2,MASQ3,136,105*160
 DC.L BUF3,MASQ4,136,104*160
 DC.L BUF3,MASQ4,136,103*160
 DC.L BUF3,MASQ4,136,103*160
 DC.L BUF4,MASQ5,136,102*160
 DC.L BUF4,MASQ5,136,101*160
 DC.L BUF4,MASQ5,136,101*160
 DC.L BUF5,MASQ6,136,100*160
 DC.L BUF5,MASQ6,136,99*160
 DC.L BUF5,MASQ6,136,99*160
 DC.L BUF6,MASQ7,136,98*160
 DC.L BUF6,MASQ7,136,97*160
 DC.L BUF6,MASQ7,136,97*160
 DC.L BUF7,MASQ8,136,96*160
 DC.L BUF7,MASQ8,136,95*160
 DC.L BUF8,MASQ9,136,95*160
 DC.L BUF8,MASQ9,136,94*160
 DC.L BUF8,MASQ9,136,93*160
 DC.L BUF9,MASQ10,136,93*160
 DC.L BUF9,MASQ10,136,92*160
 DC.L BUF9,MASQ10,136,91*160
 DC.L BUF10,MASQ11,136,91*160
 DC.L BUF10,MASQ11,136,90*160
 DC.L BUF11,MASQ12,136,89*160
 DC.L BUF11,MASQ12,136,89*160
 DC.L BUF11,MASQ12,136,88*160
 DC.L BUF12,MASQ13,136,87*160
 DC.L BUF12,MASQ13,136,87*160
 DC.L BUF13,MASQ14,136,86*160
 DC.L BUF13,MASQ14,136,85*160
 DC.L BUF13,MASQ14,136,85*160
 DC.L BUF14,MASQ15,136,84*160
 DC.L BUF14,MASQ15,136,83*160
 DC.L BUF15,MASQ16,136,83*160
 DC.L BUF15,MASQ16,136,82*160
 DC.L BUF16,MASQ17,136,81*160
 DC.L BUF16,MASQ17,136,81*160
 DC.L BUF16,MASQ17,136,80*160
 DC.L BUF1,MASQ2,128,79*160
 DC.L BUF1,MASQ2,128,79*160
 DC.L BUF2,MASQ3,128,78*160
 DC.L BUF2,MASQ3,128,78*160
 DC.L BUF3,MASQ4,128,77*160
 DC.L BUF3,MASQ4,128,76*160
 DC.L BUF4,MASQ5,128,76*160
 DC.L BUF4,MASQ5,128,75*160
 DC.L BUF5,MASQ6,128,74*160
 DC.L BUF5,MASQ6,128,74*160
 DC.L BUF5,MASQ6,128,73*160
 DC.L BUF6,MASQ7,128,72*160
 DC.L BUF6,MASQ7,128,72*160
 DC.L BUF7,MASQ8,128,71*160
 DC.L BUF7,MASQ8,128,71*160
 DC.L BUF8,MASQ9,128,70*160
 DC.L BUF8,MASQ9,128,69*160
 DC.L BUF9,MASQ10,128,69*160
 DC.L BUF9,MASQ10,128,68*160
 DC.L BUF10,MASQ11,128,68*160
 DC.L BUF10,MASQ11,128,67*160
 DC.L BUF11,MASQ12,128,66*160
 DC.L BUF11,MASQ12,128,66*160
 DC.L BUF12,MASQ13,128,65*160
 DC.L BUF12,MASQ13,128,64*160
 DC.L BUF13,MASQ14,128,64*160
 DC.L BUF13,MASQ14,128,63*160
 DC.L BUF14,MASQ15,128,63*160
 DC.L BUF14,MASQ15,128,62*160
 DC.L BUF15,MASQ16,128,62*160
 DC.L BUF16,MASQ17,128,61*160
 DC.L BUF16,MASQ17,128,60*160
 DC.L BUF1,MASQ2,120,60*160
 DC.L BUF1,MASQ2,120,59*160
 DC.L BUF2,MASQ3,120,59*160
 DC.L BUF2,MASQ3,120,58*160
 DC.L BUF3,MASQ4,120,57*160
 DC.L BUF3,MASQ4,120,57*160
 DC.L BUF4,MASQ5,120,56*160
 DC.L BUF4,MASQ5,120,56*160
 DC.L BUF5,MASQ6,120,55*160
 DC.L BUF5,MASQ6,120,55*160
 DC.L BUF6,MASQ7,120,54*160
 DC.L BUF7,MASQ8,120,54*160
 DC.L BUF7,MASQ8,120,53*160
 DC.L BUF8,MASQ9,120,52*160
 DC.L BUF8,MASQ9,120,52*160
 DC.L BUF9,MASQ10,120,51*160
 DC.L BUF9,MASQ10,120,51*160
 DC.L BUF10,MASQ11,120,50*160
 DC.L BUF11,MASQ12,120,50*160
 DC.L BUF11,MASQ12,120,49*160
 DC.L BUF12,MASQ13,120,49*160
 DC.L BUF12,MASQ13,120,48*160
 DC.L BUF13,MASQ14,120,48*160
 DC.L BUF13,MASQ14,120,47*160
 DC.L BUF14,MASQ15,120,47*160
 DC.L BUF15,MASQ16,120,46*160
 DC.L BUF15,MASQ16,120,46*160
 DC.L BUF16,MASQ17,120,45*160
 DC.L BUF16,MASQ17,120,45*160
 DC.L BUF1,MASQ2,112,44*160
 DC.L BUF2,MASQ3,112,44*160
 DC.L BUF2,MASQ3,112,43*160
 DC.L BUF3,MASQ4,112,43*160
 DC.L BUF3,MASQ4,112,42*160
 DC.L BUF4,MASQ5,112,42*160
 DC.L BUF5,MASQ6,112,41*160
 DC.L BUF5,MASQ6,112,41*160
 DC.L BUF6,MASQ7,112,40*160
 DC.L BUF6,MASQ7,112,40*160
 DC.L BUF7,MASQ8,112,39*160
 DC.L BUF8,MASQ9,112,39*160
 DC.L BUF8,MASQ9,112,39*160
 DC.L BUF9,MASQ10,112,38*160
 DC.L BUF9,MASQ10,112,38*160
 DC.L BUF10,MASQ11,112,37*160
 DC.L BUF11,MASQ12,112,37*160
 DC.L BUF11,MASQ12,112,36*160
 DC.L BUF12,MASQ13,112,36*160
 DC.L BUF13,MASQ14,112,36*160
 DC.L BUF13,MASQ14,112,35*160
 DC.L BUF14,MASQ15,112,35*160
 DC.L BUF14,MASQ15,112,34*160
 DC.L BUF15,MASQ16,112,34*160
 DC.L BUF16,MASQ17,112,34*160
 DC.L BUF16,MASQ17,112,33*160
 DC.L BUF1,MASQ2,104,33*160
 DC.L BUF2,MASQ3,104,32*160
 DC.L BUF2,MASQ3,104,32*160
 DC.L BUF3,MASQ4,104,32*160
 DC.L BUF3,MASQ4,104,31*160
 DC.L BUF4,MASQ5,104,31*160
 DC.L BUF5,MASQ6,104,31*160
 DC.L BUF5,MASQ6,104,30*160
 DC.L BUF6,MASQ7,104,30*160
 DC.L BUF7,MASQ8,104,29*160
 DC.L BUF7,MASQ8,104,29*160
 DC.L BUF8,MASQ9,104,29*160
 DC.L BUF9,MASQ10,104,28*160
 DC.L BUF9,MASQ10,104,28*160
 DC.L BUF10,MASQ11,104,28*160
 DC.L BUF10,MASQ11,104,27*160
 DC.L BUF11,MASQ12,104,27*160
 DC.L BUF12,MASQ13,104,27*160
 DC.L BUF12,MASQ13,104,27*160
 DC.L BUF13,MASQ14,104,26*160
 DC.L BUF14,MASQ15,104,26*160
 DC.L BUF14,MASQ15,104,26*160
 DC.L BUF15,MASQ16,104,25*160
 DC.L BUF16,MASQ17,104,25*160
 DC.L BUF16,MASQ17,104,25*160
 DC.L BUF1,MASQ2,96,25*160
 DC.L BUF1,MASQ2,96,24*160
 DC.L BUF2,MASQ3,96,24*160
 DC.L BUF3,MASQ4,96,24*160
 DC.L BUF3,MASQ4,96,23*160
 DC.L BUF4,MASQ5,96,23*160
 DC.L BUF5,MASQ6,96,23*160
 DC.L BUF5,MASQ6,96,23*160
 DC.L BUF6,MASQ7,96,23*160
 DC.L BUF7,MASQ8,96,22*160
 DC.L BUF7,MASQ8,96,22*160
 DC.L BUF8,MASQ9,96,22*160
 DC.L BUF9,MASQ10,96,22*160
 DC.L BUF9,MASQ10,96,21*160
 DC.L BUF10,MASQ11,96,21*160
 DC.L BUF10,MASQ11,96,21*160
 DC.L BUF11,MASQ12,96,21*160
 DC.L BUF12,MASQ13,96,21*160
 DC.L BUF12,MASQ13,96,20*160
 DC.L BUF13,MASQ14,96,20*160
 DC.L BUF14,MASQ15,96,20*160
 DC.L BUF14,MASQ15,96,20*160
 DC.L BUF15,MASQ16,96,20*160
 DC.L BUF16,MASQ17,96,20*160
 DC.L BUF16,MASQ17,96,20*160
 DC.L BUF1,MASQ2,88,19*160
 DC.L BUF2,MASQ3,88,19*160
 DC.L BUF2,MASQ3,88,19*160
 DC.L BUF3,MASQ4,88,19*160
 DC.L BUF3,MASQ4,88,19*160
 DC.L BUF4,MASQ5,88,19*160
 DC.L BUF5,MASQ6,88,19*160
 DC.L BUF5,MASQ6,88,19*160
 DC.L BUF6,MASQ7,88,18*160
 DC.L BUF7,MASQ8,88,18*160
 DC.L BUF7,MASQ8,88,18*160
 DC.L BUF8,MASQ9,88,18*160
 DC.L BUF9,MASQ10,88,18*160
 DC.L BUF9,MASQ10,88,18*160
 DC.L BUF10,MASQ11,88,18*160
 DC.L BUF10,MASQ11,88,18*160
 DC.L BUF11,MASQ12,88,18*160
 DC.L BUF12,MASQ13,88,18*160
 DC.L BUF12,MASQ13,88,18*160
 DC.L BUF13,MASQ14,88,18*160
 DC.L BUF14,MASQ15,88,18*160
 DC.L BUF14,MASQ15,88,18*160
 DC.L BUF15,MASQ16,88,18*160
 DC.L BUF15,MASQ16,88,18*160
 DC.L BUF16,MASQ17,88,18*160
 DC.L BUF1,MASQ2,80,18*160
 DC.L BUF1,MASQ2,80,18*160
 DC.L BUF2,MASQ3,80,18*160
 DC.L BUF3,MASQ4,80,18*160
 DC.L BUF3,MASQ4,80,18*160
 DC.L BUF4,MASQ5,80,18*160
 DC.L BUF4,MASQ5,80,18*160
 DC.L BUF5,MASQ6,80,18*160
 DC.L BUF6,MASQ7,80,18*160
 DC.L BUF6,MASQ7,80,18*160
 DC.L BUF7,MASQ8,80,18*160
 DC.L BUF7,MASQ8,80,18*160
 DC.L BUF8,MASQ9,80,18*160
 DC.L BUF9,MASQ10,80,18*160
 DC.L BUF9,MASQ10,80,18*160
 DC.L BUF10,MASQ11,80,18*160
 DC.L BUF10,MASQ11,80,18*160
 DC.L BUF11,MASQ12,80,18*160
 DC.L BUF12,MASQ13,80,18*160
 DC.L BUF12,MASQ13,80,18*160
 DC.L BUF13,MASQ14,80,18*160
 DC.L BUF13,MASQ14,80,19*160
 DC.L BUF14,MASQ15,80,19*160
 DC.L BUF15,MASQ16,80,19*160
 DC.L BUF15,MASQ16,80,19*160
 DC.L BUF16,MASQ17,80,19*160
 DC.L BUF16,MASQ17,80,19*160
 DC.L BUF1,MASQ2,72,19*160
 DC.L BUF2,MASQ3,72,19*160
 DC.L BUF2,MASQ3,72,20*160
 DC.L BUF3,MASQ4,72,20*160
 DC.L BUF3,MASQ4,72,20*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF5,MASQ6,72,20*160
 DC.L BUF6,MASQ7,72,21*160
 DC.L BUF6,MASQ7,72,21*160
 DC.L BUF7,MASQ8,72,21*160
 DC.L BUF7,MASQ8,72,21*160
 DC.L BUF8,MASQ9,72,21*160
 DC.L BUF8,MASQ9,72,21*160
 DC.L BUF9,MASQ10,72,22*160
 DC.L BUF9,MASQ10,72,22*160
 DC.L BUF10,MASQ11,72,22*160
 DC.L BUF11,MASQ12,72,22*160
 DC.L BUF11,MASQ12,72,23*160
 DC.L BUF12,MASQ13,72,23*160
 DC.L BUF12,MASQ13,72,23*160
 DC.L BUF13,MASQ14,72,23*160
 DC.L BUF13,MASQ14,72,24*160
 DC.L BUF14,MASQ15,72,24*160
 DC.L BUF14,MASQ15,72,24*160
 DC.L BUF15,MASQ16,72,24*160
 DC.L BUF15,MASQ16,72,25*160
 DC.L BUF16,MASQ17,72,25*160
 DC.L BUF16,MASQ17,72,25*160
 DC.L BUF1,MASQ2,64,25*160
 DC.L BUF1,MASQ2,64,26*160
 DC.L BUF2,MASQ3,64,26*160
 DC.L BUF2,MASQ3,64,26*160
 DC.L BUF3,MASQ4,64,27*160
 DC.L BUF3,MASQ4,64,27*160
 DC.L BUF4,MASQ5,64,27*160
 DC.L BUF4,MASQ5,64,27*160
 DC.L BUF5,MASQ6,64,28*160
 DC.L BUF5,MASQ6,64,28*160
 DC.L BUF6,MASQ7,64,28*160
 DC.L BUF6,MASQ7,64,29*160
 DC.L BUF7,MASQ8,64,29*160
 DC.L BUF7,MASQ8,64,29*160
 DC.L BUF8,MASQ9,64,30*160
 DC.L BUF8,MASQ9,64,30*160
 DC.L BUF9,MASQ10,64,31*160
 DC.L BUF9,MASQ10,64,31*160
 DC.L BUF10,MASQ11,64,31*160
 DC.L BUF10,MASQ11,64,32*160
 DC.L BUF11,MASQ12,64,32*160
 DC.L BUF11,MASQ12,64,32*160
 DC.L BUF12,MASQ13,64,33*160
 DC.L BUF12,MASQ13,64,33*160
 DC.L BUF13,MASQ14,64,34*160
 DC.L BUF13,MASQ14,64,34*160
 DC.L BUF13,MASQ14,64,34*160
 DC.L BUF14,MASQ15,64,35*160
 DC.L BUF14,MASQ15,64,35*160
 DC.L BUF15,MASQ16,64,36*160
 DC.L BUF15,MASQ16,64,36*160
 DC.L BUF16,MASQ17,64,36*160
 DC.L BUF16,MASQ17,64,37*160
 DC.L BUF16,MASQ17,64,37*160
 DC.L BUF1,MASQ2,56,38*160
 DC.L BUF1,MASQ2,56,38*160
 DC.L BUF2,MASQ3,56,39*160
 DC.L BUF2,MASQ3,56,39*160
 DC.L BUF3,MASQ4,56,39*160
 DC.L BUF3,MASQ4,56,40*160
 DC.L BUF3,MASQ4,56,40*160
 DC.L BUF4,MASQ5,56,41*160
 DC.L BUF4,MASQ5,56,41*160
 DC.L BUF5,MASQ6,56,42*160
 DC.L BUF5,MASQ6,56,42*160
 DC.L BUF5,MASQ6,56,43*160
 DC.L BUF6,MASQ7,56,43*160
 DC.L BUF6,MASQ7,56,44*160
 DC.L BUF6,MASQ7,56,44*160
 DC.L BUF7,MASQ8,56,45*160
 DC.L BUF7,MASQ8,56,45*160
 DC.L BUF8,MASQ9,56,46*160
 DC.L BUF8,MASQ9,56,46*160
 DC.L BUF8,MASQ9,56,47*160
 DC.L BUF9,MASQ10,56,47*160
 DC.L BUF9,MASQ10,56,48*160
 DC.L BUF9,MASQ10,56,48*160
 DC.L BUF10,MASQ11,56,49*160
 DC.L BUF10,MASQ11,56,49*160
 DC.L BUF10,MASQ11,56,50*160
 DC.L BUF11,MASQ12,56,50*160
 DC.L BUF11,MASQ12,56,51*160
 DC.L BUF11,MASQ12,56,51*160
 DC.L BUF12,MASQ13,56,52*160
 DC.L BUF12,MASQ13,56,52*160
 DC.L BUF12,MASQ13,56,53*160
 DC.L BUF13,MASQ14,56,54*160
 DC.L BUF13,MASQ14,56,54*160
 DC.L BUF13,MASQ14,56,55*160
 DC.L BUF14,MASQ15,56,55*160
 DC.L BUF14,MASQ15,56,56*160
 DC.L BUF14,MASQ15,56,56*160
 DC.L BUF14,MASQ15,56,57*160
 DC.L BUF15,MASQ16,56,57*160
 DC.L BUF15,MASQ16,56,58*160
 DC.L BUF15,MASQ16,56,59*160
 DC.L BUF16,MASQ17,56,59*160
 DC.L BUF16,MASQ17,56,60*160
 DC.L BUF16,MASQ17,56,60*160
 DC.L BUF16,MASQ17,56,61*160
 DC.L BUF1,MASQ2,48,62*160
 DC.L BUF1,MASQ2,48,62*160
 DC.L BUF1,MASQ2,48,63*160
 DC.L BUF1,MASQ2,48,63*160
 DC.L BUF2,MASQ3,48,64*160
 DC.L BUF2,MASQ3,48,65*160
 DC.L BUF2,MASQ3,48,65*160
 DC.L BUF2,MASQ3,48,66*160
 DC.L BUF3,MASQ4,48,66*160
 DC.L BUF3,MASQ4,48,67*160
 DC.L BUF3,MASQ4,48,68*160
 DC.L BUF3,MASQ4,48,68*160
 DC.L BUF3,MASQ4,48,69*160
 DC.L BUF4,MASQ5,48,69*160
 DC.L BUF4,MASQ5,48,70*160
 DC.L BUF4,MASQ5,48,71*160
 DC.L BUF4,MASQ5,48,71*160
 DC.L BUF4,MASQ5,48,72*160
 DC.L BUF5,MASQ6,48,73*160
 DC.L BUF5,MASQ6,48,73*160
 DC.L BUF5,MASQ6,48,74*160
 DC.L BUF5,MASQ6,48,74*160
 DC.L BUF5,MASQ6,48,75*160
 DC.L BUF6,MASQ7,48,76*160
 DC.L BUF6,MASQ7,48,76*160
 DC.L BUF6,MASQ7,48,77*160
 DC.L BUF6,MASQ7,48,78*160
 DC.L BUF6,MASQ7,48,78*160
 DC.L BUF6,MASQ7,48,79*160
 DC.L BUF7,MASQ8,48,80*160
 DC.L BUF7,MASQ8,48,80*160
 DC.L BUF7,MASQ8,48,81*160
 DC.L BUF7,MASQ8,48,81*160
 DC.L BUF7,MASQ8,48,82*160
 DC.L BUF7,MASQ8,48,83*160
 DC.L BUF7,MASQ8,48,83*160
 DC.L BUF8,MASQ9,48,84*160
 DC.L BUF8,MASQ9,48,85*160
 DC.L BUF8,MASQ9,48,85*160
 DC.L BUF8,MASQ9,48,86*160
 DC.L BUF8,MASQ9,48,87*160
 DC.L BUF8,MASQ9,48,87*160
 DC.L BUF8,MASQ9,48,88*160
 DC.L BUF8,MASQ9,48,89*160
 DC.L BUF8,MASQ9,48,89*160
 DC.L BUF8,MASQ9,48,90*160
 DC.L BUF9,MASQ10,48,91*160
 DC.L BUF9,MASQ10,48,91*160
 DC.L BUF9,MASQ10,48,92*160
 DC.L BUF9,MASQ10,48,93*160
 DC.L BUF9,MASQ10,48,93*160
 DC.L BUF9,MASQ10,48,94*160
 DC.L BUF9,MASQ10,48,95*160
 DC.L BUF9,MASQ10,48,95*160
 DC.L BUF9,MASQ10,48,96*160
 DC.L BUF9,MASQ10,48,97*160
 DC.L BUF9,MASQ10,48,97*160
 DC.L BUF9,MASQ10,48,98*160
 DC.L BUF9,MASQ10,48,99*160
 DC.L BUF9,MASQ10,48,99*160
 DC.L BUF9,MASQ10,48,100*160
 DC.L BUF9,MASQ10,48,101*160
 DC.L BUF9,MASQ10,48,101*160
 DC.L BUF9,MASQ10,48,102*160
 DC.L BUF9,MASQ10,48,103*160
 DC.L BUF9,MASQ10,48,103*160
 DC.L BUF9,MASQ10,48,104*160
 DC.L BUF9,MASQ10,48,105*160
 DC.L BUF10,MASQ11,48,105*160
 DC.L BUF9,MASQ10,48,106*160
 DC.L BUF9,MASQ10,48,107*160
 DC.L BUF9,MASQ10,48,107*160
 DC.L BUF9,MASQ10,48,108*160
 DC.L BUF9,MASQ10,48,109*160
 DC.L BUF9,MASQ10,48,109*160
 DC.L BUF9,MASQ10,48,110*160
 DC.L BUF9,MASQ10,48,110*160
 DC.L BUF9,MASQ10,48,111*160
 DC.L BUF9,MASQ10,48,112*160
 DC.L BUF9,MASQ10,48,112*160
 DC.L BUF9,MASQ10,48,113*160
 DC.L BUF9,MASQ10,48,114*160
 DC.L BUF9,MASQ10,48,114*160
 DC.L BUF9,MASQ10,48,115*160
 DC.L BUF9,MASQ10,48,116*160
 DC.L BUF9,MASQ10,48,116*160
 DC.L BUF9,MASQ10,48,117*160
 DC.L BUF9,MASQ10,48,118*160
 DC.L BUF9,MASQ10,48,118*160
 DC.L BUF9,MASQ10,48,119*160
 DC.L BUF9,MASQ10,48,120*160
 DC.L BUF9,MASQ10,48,120*160
 DC.L BUF8,MASQ9,48,121*160
 DC.L BUF8,MASQ9,48,122*160
 DC.L BUF8,MASQ9,48,122*160
 DC.L BUF8,MASQ9,48,123*160
 DC.L BUF8,MASQ9,48,123*160
 DC.L BUF8,MASQ9,48,124*160
 DC.L BUF8,MASQ9,48,125*160
 DC.L BUF8,MASQ9,48,125*160
 DC.L BUF8,MASQ9,48,126*160
 DC.L BUF8,MASQ9,48,127*160
 DC.L BUF7,MASQ8,48,127*160
 DC.L BUF7,MASQ8,48,128*160
 DC.L BUF7,MASQ8,48,128*160
 DC.L BUF7,MASQ8,48,129*160
 DC.L BUF7,MASQ8,48,130*160
 DC.L BUF7,MASQ8,48,130*160
 DC.L BUF7,MASQ8,48,131*160
 DC.L BUF6,MASQ7,48,132*160
 DC.L BUF6,MASQ7,48,132*160
 DC.L BUF6,MASQ7,48,133*160
 DC.L BUF6,MASQ7,48,133*160
 DC.L BUF6,MASQ7,48,134*160
 DC.L BUF6,MASQ7,48,135*160
 DC.L BUF6,MASQ7,48,135*160
 DC.L BUF5,MASQ6,48,136*160
 DC.L BUF5,MASQ6,48,136*160
 DC.L BUF5,MASQ6,48,137*160
 DC.L BUF5,MASQ6,48,138*160
 DC.L BUF5,MASQ6,48,138*160
 DC.L BUF5,MASQ6,48,139*160
 DC.L BUF4,MASQ5,48,139*160
 DC.L BUF4,MASQ5,48,140*160
 DC.L BUF4,MASQ5,48,140*160
 DC.L BUF4,MASQ5,48,141*160
 DC.L BUF4,MASQ5,48,142*160
 DC.L BUF3,MASQ4,48,142*160
 DC.L BUF3,MASQ4,48,143*160
 DC.L BUF3,MASQ4,48,143*160
 DC.L BUF3,MASQ4,48,144*160
 DC.L BUF3,MASQ4,48,144*160
 DC.L BUF2,MASQ3,48,145*160
 DC.L BUF2,MASQ3,48,146*160
 DC.L BUF2,MASQ3,48,146*160
 DC.L BUF2,MASQ3,48,147*160
 DC.L BUF1,MASQ2,48,147*160
 DC.L BUF1,MASQ2,48,148*160
 DC.L BUF1,MASQ2,48,148*160
 DC.L BUF1,MASQ2,48,149*160
 DC.L BUF16,MASQ17,56,149*160
 DC.L BUF16,MASQ17,56,150*160
 DC.L BUF16,MASQ17,56,150*160
 DC.L BUF16,MASQ17,56,151*160
 DC.L BUF15,MASQ16,56,151*160
 DC.L BUF15,MASQ16,56,152*160
 DC.L BUF15,MASQ16,56,152*160
 DC.L BUF15,MASQ16,56,153*160
 DC.L BUF14,MASQ15,56,153*160
 DC.L BUF14,MASQ15,56,154*160
 DC.L BUF14,MASQ15,56,154*160
 DC.L BUF14,MASQ15,56,155*160
 DC.L BUF13,MASQ14,56,155*160
 DC.L BUF13,MASQ14,56,156*160
 DC.L BUF13,MASQ14,56,156*160
 DC.L BUF13,MASQ14,56,157*160
 DC.L BUF12,MASQ13,56,157*160
 DC.L BUF12,MASQ13,56,158*160
 DC.L BUF12,MASQ13,56,158*160
 DC.L BUF11,MASQ12,56,159*160
 DC.L BUF11,MASQ12,56,159*160
 DC.L BUF11,MASQ12,56,160*160
 DC.L BUF11,MASQ12,56,160*160
 DC.L BUF10,MASQ11,56,161*160
 DC.L BUF10,MASQ11,56,161*160
 DC.L BUF10,MASQ11,56,161*160
 DC.L BUF9,MASQ10,56,162*160
 DC.L BUF9,MASQ10,56,162*160
 DC.L BUF9,MASQ10,56,163*160
 DC.L BUF8,MASQ9,56,163*160
 DC.L BUF8,MASQ9,56,164*160
 DC.L BUF8,MASQ9,56,164*160
 DC.L BUF7,MASQ8,56,164*160
 DC.L BUF7,MASQ8,56,165*160
 DC.L BUF7,MASQ8,56,165*160
 DC.L BUF6,MASQ7,56,166*160
 DC.L BUF6,MASQ7,56,166*160
 DC.L BUF6,MASQ7,56,166*160
 DC.L BUF5,MASQ6,56,167*160
 DC.L BUF5,MASQ6,56,167*160
 DC.L BUF5,MASQ6,56,167*160
 DC.L BUF4,MASQ5,56,168*160
 DC.L BUF4,MASQ5,56,168*160
 DC.L BUF4,MASQ5,56,169*160
 DC.L BUF3,MASQ4,56,169*160
 DC.L BUF3,MASQ4,56,169*160
 DC.L BUF3,MASQ4,56,170*160
 DC.L BUF2,MASQ3,56,170*160
 DC.L BUF2,MASQ3,56,170*160
 DC.L BUF2,MASQ3,56,171*160
 DC.L BUF1,MASQ2,56,171*160
 DC.L BUF1,MASQ2,56,171*160
 DC.L BUF1,MASQ2,56,172*160
 DC.L BUF16,MASQ17,64,172*160
 DC.L BUF16,MASQ17,64,172*160
 DC.L BUF16,MASQ17,64,173*160
 DC.L BUF15,MASQ16,64,173*160
 DC.L BUF15,MASQ16,64,173*160
 DC.L BUF14,MASQ15,64,173*160
 DC.L BUF14,MASQ15,64,174*160
 DC.L BUF14,MASQ15,64,174*160
 DC.L BUF13,MASQ14,64,174*160
 DC.L BUF13,MASQ14,64,175*160
 DC.L BUF13,MASQ14,64,175*160
 DC.L BUF12,MASQ13,64,175*160
 DC.L BUF12,MASQ13,64,175*160
 DC.L BUF11,MASQ12,64,176*160
 DC.L BUF11,MASQ12,64,176*160
 DC.L BUF11,MASQ12,64,176*160
 DC.L BUF10,MASQ11,64,176*160
 DC.L BUF10,MASQ11,64,177*160
 DC.L BUF10,MASQ11,64,177*160
 DC.L BUF9,MASQ10,64,177*160
 DC.L BUF9,MASQ10,64,177*160
 DC.L BUF8,MASQ9,64,177*160
 DC.L BUF8,MASQ9,64,178*160
 DC.L BUF8,MASQ9,64,178*160
 DC.L BUF7,MASQ8,64,178*160
 DC.L BUF7,MASQ8,64,178*160
 DC.L BUF6,MASQ7,64,178*160
 DC.L BUF6,MASQ7,64,179*160
 DC.L BUF6,MASQ7,64,179*160
 DC.L BUF5,MASQ6,64,179*160
 DC.L BUF5,MASQ6,64,179*160
 DC.L BUF4,MASQ5,64,179*160
 DC.L BUF4,MASQ5,64,179*160
 DC.L BUF4,MASQ5,64,179*160
 DC.L BUF3,MASQ4,64,180*160
 DC.L BUF3,MASQ4,64,180*160
 DC.L BUF2,MASQ3,64,180*160
 DC.L BUF2,MASQ3,64,180*160
 DC.L BUF2,MASQ3,64,180*160
 DC.L BUF1,MASQ2,64,180*160
 DC.L BUF1,MASQ2,64,180*160
 DC.L BUF16,MASQ17,72,180*160
 DC.L BUF16,MASQ17,72,181*160
 DC.L BUF16,MASQ17,72,181*160
 DC.L BUF15,MASQ16,72,181*160
 DC.L BUF15,MASQ16,72,181*160
 DC.L BUF14,MASQ15,72,181*160
 DC.L BUF14,MASQ15,72,181*160
 DC.L BUF14,MASQ15,72,181*160
 DC.L BUF13,MASQ14,72,181*160
 DC.L BUF13,MASQ14,72,181*160
 DC.L BUF12,MASQ13,72,181*160
 DC.L BUF12,MASQ13,72,181*160
 DC.L BUF12,MASQ13,72,181*160
 DC.L BUF11,MASQ12,72,181*160
 DC.L BUF11,MASQ12,72,181*160
 DC.L BUF10,MASQ11,72,181*160
 DC.L BUF10,MASQ11,72,181*160
 DC.L BUF9,MASQ10,72,181*160
 DC.L BUF9,MASQ10,72,181*160
 DC.L BUF9,MASQ10,72,181*160
 DC.L BUF8,MASQ9,72,181*160
 DC.L BUF8,MASQ9,72,181*160
 DC.L BUF7,MASQ8,72,181*160
 DC.L BUF7,MASQ8,72,181*160
 DC.L BUF7,MASQ8,72,181*160
 DC.L BUF6,MASQ7,72,181*160
 DC.L BUF6,MASQ7,72,181*160
 DC.L BUF5,MASQ6,72,181*160
 DC.L BUF5,MASQ6,72,181*160
 DC.L BUF5,MASQ6,72,181*160
 DC.L BUF4,MASQ5,72,181*160
 DC.L BUF4,MASQ5,72,181*160
 DC.L BUF3,MASQ4,72,181*160
 DC.L BUF3,MASQ4,72,181*160
 DC.L BUF2,MASQ3,72,181*160
 DC.L BUF2,MASQ3,72,181*160
 DC.L BUF2,MASQ3,72,181*160
 DC.L BUF1,MASQ2,72,181*160
 DC.L BUF1,MASQ2,72,181*160
 DC.L BUF16,MASQ17,80,180*160
 DC.L BUF16,MASQ17,80,180*160
 DC.L BUF16,MASQ17,80,180*160
 DC.L BUF15,MASQ16,80,180*160
 DC.L BUF15,MASQ16,80,180*160
 DC.L BUF14,MASQ15,80,180*160
 DC.L BUF14,MASQ15,80,180*160
 DC.L BUF14,MASQ15,80,180*160
 DC.L BUF13,MASQ14,80,179*160
 DC.L BUF13,MASQ14,80,179*160
 DC.L BUF12,MASQ13,80,179*160
 DC.L BUF12,MASQ13,80,179*160
 DC.L BUF12,MASQ13,80,179*160
 DC.L BUF11,MASQ12,80,179*160
 DC.L BUF11,MASQ12,80,178*160
 DC.L BUF10,MASQ11,80,178*160
 DC.L BUF10,MASQ11,80,178*160
 DC.L BUF10,MASQ11,80,178*160
 DC.L BUF9,MASQ10,80,178*160
 DC.L BUF9,MASQ10,80,178*160
 DC.L BUF9,MASQ10,80,177*160
 DC.L BUF8,MASQ9,80,177*160
 DC.L BUF8,MASQ9,80,177*160
 DC.L BUF7,MASQ8,80,177*160
 DC.L BUF7,MASQ8,80,176*160
 DC.L BUF7,MASQ8,80,176*160
 DC.L BUF6,MASQ7,80,176*160
 DC.L BUF6,MASQ7,80,176*160
 DC.L BUF5,MASQ6,80,175*160
 DC.L BUF5,MASQ6,80,175*160
 DC.L BUF5,MASQ6,80,175*160
 DC.L BUF4,MASQ5,80,175*160
 DC.L BUF4,MASQ5,80,174*160
 DC.L BUF4,MASQ5,80,174*160
 DC.L BUF3,MASQ4,80,174*160
 DC.L BUF3,MASQ4,80,174*160
 DC.L BUF2,MASQ3,80,173*160
 DC.L BUF2,MASQ3,80,173*160
 DC.L BUF2,MASQ3,80,173*160
 DC.L BUF1,MASQ2,80,172*160
 DC.L BUF1,MASQ2,80,172*160
 DC.L BUF1,MASQ2,80,172*160
 DC.L BUF16,MASQ17,88,171*160
 DC.L BUF16,MASQ17,88,171*160
 DC.L BUF16,MASQ17,88,171*160
 DC.L BUF15,MASQ16,88,171*160
 DC.L BUF15,MASQ16,88,170*160
 DC.L BUF15,MASQ16,88,170*160
 DC.L BUF14,MASQ15,88,169*160
 DC.L BUF14,MASQ15,88,169*160
 DC.L BUF13,MASQ14,88,169*160
 DC.L BUF13,MASQ14,88,168*160
 DC.L BUF13,MASQ14,88,168*160
 DC.L BUF12,MASQ13,88,168*160
 DC.L BUF12,MASQ13,88,167*160
 DC.L BUF12,MASQ13,88,167*160
 DC.L BUF11,MASQ12,88,167*160
 DC.L BUF11,MASQ12,88,166*160
 DC.L BUF11,MASQ12,88,166*160
 DC.L BUF10,MASQ11,88,165*160
 DC.L BUF10,MASQ11,88,165*160
 DC.L BUF10,MASQ11,88,165*160
 DC.L BUF9,MASQ10,88,164*160
 DC.L BUF9,MASQ10,88,164*160
 DC.L BUF9,MASQ10,88,163*160
 DC.L BUF9,MASQ10,88,163*160
 DC.L BUF8,MASQ9,88,163*160
 DC.L BUF8,MASQ9,88,162*160
 DC.L BUF8,MASQ9,88,162*160
 DC.L BUF7,MASQ8,88,161*160
 DC.L BUF7,MASQ8,88,161*160
 DC.L BUF7,MASQ8,88,160*160
 DC.L BUF6,MASQ7,88,160*160
 DC.L BUF6,MASQ7,88,159*160
 DC.L BUF6,MASQ7,88,159*160
 DC.L BUF6,MASQ7,88,159*160
 DC.L BUF5,MASQ6,88,158*160
 DC.L BUF5,MASQ6,88,158*160
 DC.L BUF5,MASQ6,88,157*160
 DC.L BUF4,MASQ5,88,157*160
 DC.L BUF4,MASQ5,88,156*160
 DC.L BUF4,MASQ5,88,156*160
 DC.L BUF4,MASQ5,88,155*160
 DC.L BUF3,MASQ4,88,155*160
 DC.L BUF3,MASQ4,88,154*160
 DC.L BUF3,MASQ4,88,154*160
 DC.L BUF2,MASQ3,88,153*160
 DC.L BUF2,MASQ3,88,153*160
 DC.L BUF2,MASQ3,88,152*160
 DC.L BUF2,MASQ3,88,152*160
 DC.L BUF1,MASQ2,88,151*160
 DC.L BUF1,MASQ2,88,151*160
 DC.L BUF1,MASQ2,88,150*160
 DC.L BUF1,MASQ2,88,150*160
 DC.L BUF16,MASQ17,96,149*160
 DC.L BUF16,MASQ17,96,149*160
 DC.L BUF16,MASQ17,96,148*160
 DC.L BUF16,MASQ17,96,148*160
 DC.L BUF16,MASQ17,96,147*160
 DC.L BUF15,MASQ16,96,146*160
 DC.L BUF15,MASQ16,96,146*160
 DC.L BUF15,MASQ16,96,145*160
 DC.L BUF15,MASQ16,96,145*160
 DC.L BUF14,MASQ15,96,144*160
 DC.L BUF14,MASQ15,96,144*160
 DC.L BUF14,MASQ15,96,143*160
 DC.L BUF14,MASQ15,96,143*160
 DC.L BUF14,MASQ15,96,142*160
 DC.L BUF13,MASQ14,96,141*160
 DC.L BUF13,MASQ14,96,141*160
 DC.L BUF13,MASQ14,96,140*160
 DC.L BUF13,MASQ14,96,140*160
 DC.L BUF13,MASQ14,96,139*160
 DC.L BUF12,MASQ13,96,139*160
 DC.L BUF12,MASQ13,96,138*160
 DC.L BUF12,MASQ13,96,137*160
 DC.L BUF12,MASQ13,96,137*160
 DC.L BUF12,MASQ13,96,136*160
 DC.L BUF12,MASQ13,96,136*160
 DC.L BUF11,MASQ12,96,135*160
 DC.L BUF11,MASQ12,96,134*160
 DC.L BUF11,MASQ12,96,134*160
 DC.L BUF11,MASQ12,96,133*160
 DC.L BUF11,MASQ12,96,133*160
 DC.L BUF11,MASQ12,96,132*160
 DC.L BUF10,MASQ11,96,131*160
 DC.L BUF10,MASQ11,96,131*160
 DC.L BUF10,MASQ11,96,130*160
 DC.L BUF10,MASQ11,96,130*160
 DC.L BUF10,MASQ11,96,129*160
 DC.L BUF10,MASQ11,96,128*160
 DC.L BUF10,MASQ11,96,128*160
 DC.L BUF10,MASQ11,96,127*160
 DC.L BUF9,MASQ10,96,126*160
 DC.L BUF9,MASQ10,96,126*160
 DC.L BUF9,MASQ10,96,125*160
 DC.L BUF9,MASQ10,96,125*160
 DC.L BUF9,MASQ10,96,124*160
 DC.L BUF9,MASQ10,96,123*160
 DC.L BUF9,MASQ10,96,123*160
 DC.L BUF9,MASQ10,96,122*160
 DC.L BUF9,MASQ10,96,121*160
 DC.L BUF9,MASQ10,96,121*160
 DC.L BUF8,MASQ9,96,120*160
 DC.L BUF8,MASQ9,96,119*160
 DC.L BUF8,MASQ9,96,119*160
 DC.L BUF8,MASQ9,96,118*160
 DC.L BUF8,MASQ9,96,117*160
 DC.L BUF8,MASQ9,96,117*160
 DC.L BUF8,MASQ9,96,116*160
 DC.L BUF8,MASQ9,96,116*160
 DC.L BUF8,MASQ9,96,115*160
 DC.L BUF8,MASQ9,96,114*160
 DC.L BUF8,MASQ9,96,114*160
 DC.L BUF8,MASQ9,96,113*160
 DC.L BUF8,MASQ9,96,112*160
 DC.L BUF8,MASQ9,96,112*160
 DC.L BUF8,MASQ9,96,111*160
 DC.L BUF8,MASQ9,96,110*160
 DC.L BUF8,MASQ9,96,110*160
 DC.L BUF8,MASQ9,96,109*160
 DC.L BUF8,MASQ9,96,108*160
 DC.L BUF8,MASQ9,96,108*160
 DC.L BUF8,MASQ9,96,107*160
 DC.L BUF8,MASQ9,96,106*160
 DC.L BUF7,MASQ8,96,106*160
 DC.L BUF8,MASQ9,96,105*160
 DC.L BUF8,MASQ9,96,104*160
 DC.L BUF8,MASQ9,96,104*160
 DC.L BUF8,MASQ9,96,103*160
 DC.L BUF8,MASQ9,96,102*160
 DC.L BUF8,MASQ9,96,102*160
 DC.L BUF8,MASQ9,96,101*160
 DC.L BUF8,MASQ9,96,100*160
 DC.L BUF8,MASQ9,96,100*160
 DC.L BUF8,MASQ9,96,99*160
 DC.L BUF8,MASQ9,96,98*160
 DC.L BUF8,MASQ9,96,98*160
 DC.L BUF8,MASQ9,96,97*160
 DC.L BUF8,MASQ9,96,96*160
 DC.L BUF8,MASQ9,96,96*160
 DC.L BUF8,MASQ9,96,95*160
 DC.L BUF8,MASQ9,96,94*160
 DC.L BUF8,MASQ9,96,94*160
 DC.L BUF8,MASQ9,96,93*160
 DC.L BUF8,MASQ9,96,92*160
 DC.L BUF8,MASQ9,96,92*160
 DC.L BUF8,MASQ9,96,91*160
 DC.L BUF8,MASQ9,96,90*160
 DC.L BUF9,MASQ10,96,90*160
 DC.L BUF9,MASQ10,96,89*160
 DC.L BUF9,MASQ10,96,88*160
 DC.L BUF9,MASQ10,96,88*160
 DC.L BUF9,MASQ10,96,87*160
 DC.L BUF9,MASQ10,96,86*160
 DC.L BUF9,MASQ10,96,86*160
 DC.L BUF9,MASQ10,96,85*160
 DC.L BUF9,MASQ10,96,84*160
 DC.L BUF10,MASQ11,96,84*160
 DC.L BUF10,MASQ11,96,83*160
 DC.L BUF10,MASQ11,96,83*160
 DC.L BUF10,MASQ11,96,82*160
 DC.L BUF10,MASQ11,96,81*160
 DC.L BUF10,MASQ11,96,81*160
 DC.L BUF10,MASQ11,96,80*160
 DC.L BUF10,MASQ11,96,79*160
 DC.L BUF11,MASQ12,96,79*160
 DC.L BUF11,MASQ12,96,78*160
 DC.L BUF11,MASQ12,96,77*160
 DC.L BUF11,MASQ12,96,77*160
 DC.L BUF11,MASQ12,96,76*160
 DC.L BUF11,MASQ12,96,75*160
 DC.L BUF12,MASQ13,96,75*160
 DC.L BUF12,MASQ13,96,74*160
 DC.L BUF12,MASQ13,96,74*160
 DC.L BUF12,MASQ13,96,73*160
 DC.L BUF12,MASQ13,96,72*160
 DC.L BUF13,MASQ14,96,72*160
 DC.L BUF13,MASQ14,96,71*160
 DC.L BUF13,MASQ14,96,70*160
 DC.L BUF13,MASQ14,96,70*160
 DC.L BUF13,MASQ14,96,69*160
 DC.L BUF14,MASQ15,96,69*160
 DC.L BUF14,MASQ15,96,68*160
 DC.L BUF14,MASQ15,96,67*160
 DC.L BUF14,MASQ15,96,67*160
 DC.L BUF15,MASQ16,96,66*160
 DC.L BUF15,MASQ16,96,66*160
 DC.L BUF15,MASQ16,96,65*160
 DC.L BUF15,MASQ16,96,64*160
 DC.L BUF15,MASQ16,96,64*160
 DC.L BUF16,MASQ17,96,63*160
 DC.L BUF16,MASQ17,96,63*160
 DC.L BUF16,MASQ17,96,62*160
 DC.L BUF16,MASQ17,96,61*160
 DC.L BUF1,MASQ2,88,61*160
 DC.L BUF1,MASQ2,88,60*160
 DC.L BUF1,MASQ2,88,60*160
 DC.L BUF2,MASQ3,88,59*160
 DC.L BUF2,MASQ3,88,58*160
 DC.L BUF2,MASQ3,88,58*160
 DC.L BUF2,MASQ3,88,57*160
 DC.L BUF3,MASQ4,88,57*160
 DC.L BUF3,MASQ4,88,56*160
 DC.L BUF3,MASQ4,88,56*160
 DC.L BUF4,MASQ5,88,55*160
 DC.L BUF4,MASQ5,88,54*160
 DC.L BUF4,MASQ5,88,54*160
 DC.L BUF4,MASQ5,88,53*160
 DC.L BUF5,MASQ6,88,53*160
 DC.L BUF5,MASQ6,88,52*160
 DC.L BUF5,MASQ6,88,52*160
 DC.L BUF6,MASQ7,88,51*160
 DC.L BUF6,MASQ7,88,51*160
 DC.L BUF6,MASQ7,88,50*160
 DC.L BUF7,MASQ8,88,50*160
 DC.L BUF7,MASQ8,88,49*160
 DC.L BUF7,MASQ8,88,49*160
 DC.L BUF8,MASQ9,88,48*160
 DC.L BUF8,MASQ9,88,48*160
 DC.L BUF8,MASQ9,88,47*160
 DC.L BUF9,MASQ10,88,47*160
 DC.L BUF9,MASQ10,88,46*160
 DC.L BUF10,MASQ11,88,46*160
 DC.L BUF10,MASQ11,88,45*160
 DC.L BUF10,MASQ11,88,45*160
 DC.L BUF11,MASQ12,88,44*160
 DC.L BUF11,MASQ12,88,44*160
 DC.L BUF11,MASQ12,88,43*160
 DC.L BUF12,MASQ13,88,43*160
 DC.L BUF12,MASQ13,88,42*160
 DC.L BUF13,MASQ14,88,42*160
 DC.L BUF13,MASQ14,88,41*160
 DC.L BUF13,MASQ14,88,41*160
 DC.L BUF14,MASQ15,88,40*160
 DC.L BUF14,MASQ15,88,40*160
 DC.L BUF15,MASQ16,88,39*160
 DC.L BUF15,MASQ16,88,39*160
 DC.L BUF15,MASQ16,88,38*160
 DC.L BUF16,MASQ17,88,38*160
 DC.L BUF16,MASQ17,88,38*160
 DC.L BUF1,MASQ2,80,37*160
 DC.L BUF1,MASQ2,80,37*160
 DC.L BUF2,MASQ3,80,36*160
 DC.L BUF2,MASQ3,80,36*160
 DC.L BUF2,MASQ3,80,35*160
 DC.L BUF3,MASQ4,80,35*160
 DC.L BUF3,MASQ4,80,35*160
 DC.L BUF4,MASQ5,80,34*160
 DC.L BUF4,MASQ5,80,34*160
 DC.L BUF5,MASQ6,80,33*160
 DC.L BUF5,MASQ6,80,33*160
 DC.L BUF6,MASQ7,80,33*160
 DC.L BUF6,MASQ7,80,32*160
 DC.L BUF6,MASQ7,80,32*160
 DC.L BUF7,MASQ8,80,31*160
 DC.L BUF7,MASQ8,80,31*160
 DC.L BUF8,MASQ9,80,31*160
 DC.L BUF8,MASQ9,80,30*160
 DC.L BUF9,MASQ10,80,30*160
 DC.L BUF9,MASQ10,80,30*160
 DC.L BUF10,MASQ11,80,29*160
 DC.L BUF10,MASQ11,80,29*160
 DC.L BUF11,MASQ12,80,29*160
 DC.L BUF11,MASQ12,80,28*160
 DC.L BUF12,MASQ13,80,28*160
 DC.L BUF12,MASQ13,80,28*160
 DC.L BUF13,MASQ14,80,27*160
 DC.L BUF13,MASQ14,80,27*160
 DC.L BUF14,MASQ15,80,27*160
 DC.L BUF14,MASQ15,80,26*160
 DC.L BUF15,MASQ16,80,26*160
 DC.L BUF15,MASQ16,80,26*160
 DC.L BUF16,MASQ17,80,26*160
 DC.L BUF16,MASQ17,80,25*160
 DC.L BUF1,MASQ2,72,25*160
 DC.L BUF1,MASQ2,72,25*160
 DC.L BUF2,MASQ3,72,24*160
 DC.L BUF2,MASQ3,72,24*160
 DC.L BUF3,MASQ4,72,24*160
 DC.L BUF3,MASQ4,72,24*160
 DC.L BUF4,MASQ5,72,23*160
 DC.L BUF4,MASQ5,72,23*160
 DC.L BUF5,MASQ6,72,23*160
 DC.L BUF6,MASQ7,72,23*160
 DC.L BUF6,MASQ7,72,22*160
 DC.L BUF7,MASQ8,72,22*160
 DC.L BUF7,MASQ8,72,22*160
 DC.L BUF8,MASQ9,72,22*160
 DC.L BUF8,MASQ9,72,22*160
 DC.L BUF9,MASQ10,72,21*160
 DC.L BUF9,MASQ10,72,21*160
 DC.L BUF10,MASQ11,72,21*160
 DC.L BUF11,MASQ12,72,21*160
 DC.L BUF11,MASQ12,72,21*160
 DC.L BUF12,MASQ13,72,20*160
 DC.L BUF12,MASQ13,72,20*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF13,MASQ14,72,20*160
 DC.L BUF14,MASQ15,72,20*160
 DC.L BUF14,MASQ15,72,20*160
 DC.L BUF15,MASQ16,72,19*160
 DC.L BUF16,MASQ17,72,19*160
 DC.L BUF16,MASQ17,72,19*160
 DC.L BUF1,MASQ2,64,19*160
 DC.L BUF1,MASQ2,64,19*160
 DC.L BUF2,MASQ3,64,19*160
 DC.L BUF3,MASQ4,64,19*160
 DC.L BUF3,MASQ4,64,19*160
 DC.L BUF4,MASQ5,64,18*160
 DC.L BUF4,MASQ5,64,18*160
 DC.L BUF5,MASQ6,64,18*160
 DC.L BUF6,MASQ7,64,18*160
 DC.L BUF6,MASQ7,64,18*160
 DC.L BUF7,MASQ8,64,18*160
 DC.L BUF7,MASQ8,64,18*160
 DC.L BUF8,MASQ9,64,18*160
 DC.L BUF9,MASQ10,64,18*160
 DC.L BUF9,MASQ10,64,18*160
 DC.L BUF10,MASQ11,64,18*160
 DC.L BUF10,MASQ11,64,18*160
 DC.L BUF11,MASQ12,64,18*160
 DC.L BUF12,MASQ13,64,18*160
 DC.L BUF12,MASQ13,64,18*160
 DC.L BUF13,MASQ14,64,18*160
 DC.L BUF13,MASQ14,64,18*160
 DC.L BUF14,MASQ15,64,18*160
 DC.L BUF15,MASQ16,64,18*160
 DC.L BUF15,MASQ16,64,18*160
 DC.L BUF16,MASQ17,64,18*160
 DC.L BUF16,MASQ17,64,18*160
 DC.L BUF1,MASQ2,56,18*160
 DC.L BUF2,MASQ3,56,18*160
 DC.L BUF2,MASQ3,56,18*160
 DC.L BUF3,MASQ4,56,18*160
 DC.L BUF4,MASQ5,56,18*160
 DC.L BUF4,MASQ5,56,18*160
 DC.L BUF5,MASQ6,56,18*160
 DC.L BUF5,MASQ6,56,18*160
 DC.L BUF6,MASQ7,56,18*160
 DC.L BUF7,MASQ8,56,18*160
 DC.L BUF7,MASQ8,56,18*160
 DC.L BUF8,MASQ9,56,18*160
 DC.L BUF9,MASQ10,56,18*160
 DC.L BUF9,MASQ10,56,18*160
 DC.L BUF10,MASQ11,56,18*160
 DC.L BUF11,MASQ12,56,18*160
 DC.L BUF11,MASQ12,56,18*160
 DC.L BUF12,MASQ13,56,19*160
 DC.L BUF12,MASQ13,56,19*160
 DC.L BUF13,MASQ14,56,19*160
 DC.L BUF14,MASQ15,56,19*160
 DC.L BUF14,MASQ15,56,19*160
 DC.L BUF15,MASQ16,56,19*160
 DC.L BUF16,MASQ17,56,19*160
 DC.L BUF16,MASQ17,56,19*160
 DC.L BUF1,MASQ2,48,20*160
 DC.L BUF2,MASQ3,48,20*160
 DC.L BUF2,MASQ3,48,20*160
 DC.L BUF3,MASQ4,48,20*160
 DC.L BUF4,MASQ5,48,20*160
 DC.L BUF4,MASQ5,48,20*160
 DC.L BUF5,MASQ6,48,21*160
 DC.L BUF5,MASQ6,48,21*160
 DC.L BUF6,MASQ7,48,21*160
 DC.L BUF7,MASQ8,48,21*160
 DC.L BUF7,MASQ8,48,21*160
 DC.L BUF8,MASQ9,48,22*160
 DC.L BUF9,MASQ10,48,22*160
 DC.L BUF9,MASQ10,48,22*160
 DC.L BUF10,MASQ11,48,22*160
 DC.L BUF11,MASQ12,48,22*160
 DC.L BUF11,MASQ12,48,23*160
 DC.L BUF12,MASQ13,48,23*160
 DC.L BUF13,MASQ14,48,23*160
 DC.L BUF13,MASQ14,48,23*160
 DC.L BUF14,MASQ15,48,24*160
 DC.L BUF14,MASQ15,48,24*160
 DC.L BUF15,MASQ16,48,24*160
 DC.L BUF16,MASQ17,48,24*160
 DC.L BUF16,MASQ17,48,25*160
 DC.L BUF1,MASQ2,40,25*160
 DC.L BUF2,MASQ3,40,25*160
 DC.L BUF2,MASQ3,40,25*160
 DC.L BUF3,MASQ4,40,26*160
 DC.L BUF4,MASQ5,40,26*160
 DC.L BUF4,MASQ5,40,26*160
 DC.L BUF5,MASQ6,40,27*160
 DC.L BUF6,MASQ7,40,27*160
 DC.L BUF6,MASQ7,40,27*160
 DC.L BUF7,MASQ8,40,28*160
 DC.L BUF7,MASQ8,40,28*160
 DC.L BUF8,MASQ9,40,28*160
 DC.L BUF9,MASQ10,40,29*160
 DC.L BUF9,MASQ10,40,29*160
 DC.L BUF10,MASQ11,40,29*160
 DC.L BUF11,MASQ12,40,30*160
 DC.L BUF11,MASQ12,40,30*160
 DC.L BUF12,MASQ13,40,30*160
 DC.L BUF13,MASQ14,40,31*160
 DC.L BUF13,MASQ14,40,31*160
 DC.L BUF14,MASQ15,40,31*160
 DC.L BUF14,MASQ15,40,32*160
 DC.L BUF15,MASQ16,40,32*160
 DC.L BUF16,MASQ17,40,32*160
 DC.L BUF16,MASQ17,40,33*160
 DC.L BUF1,MASQ2,32,33*160
 DC.L BUF2,MASQ3,32,34*160
 DC.L BUF2,MASQ3,32,34*160
 DC.L BUF3,MASQ4,32,34*160
 DC.L BUF3,MASQ4,32,35*160
 DC.L BUF4,MASQ5,32,35*160
 DC.L BUF5,MASQ6,32,36*160
 DC.L BUF5,MASQ6,32,36*160
 DC.L BUF6,MASQ7,32,37*160
 DC.L BUF7,MASQ8,32,37*160
 DC.L BUF7,MASQ8,32,37*160
 DC.L BUF8,MASQ9,32,38*160
 DC.L BUF8,MASQ9,32,38*160
 DC.L BUF9,MASQ10,32,39*160
 DC.L BUF10,MASQ11,32,39*160
 DC.L BUF10,MASQ11,32,40*160
 DC.L BUF11,MASQ12,32,40*160
 DC.L BUF11,MASQ12,32,41*160
 DC.L BUF12,MASQ13,32,41*160
 DC.L BUF13,MASQ14,32,41*160
 DC.L BUF13,MASQ14,32,42*160
 DC.L BUF14,MASQ15,32,42*160
 DC.L BUF14,MASQ15,32,43*160
 DC.L BUF15,MASQ16,32,43*160
 DC.L BUF16,MASQ17,32,44*160
 DC.L BUF16,MASQ17,32,44*160
 DC.L BUF1,MASQ2,24,45*160
 DC.L BUF1,MASQ2,24,45*160
 DC.L BUF2,MASQ3,24,46*160
 DC.L BUF3,MASQ4,24,46*160
 DC.L BUF3,MASQ4,24,47*160
 DC.L BUF4,MASQ5,24,47*160
 DC.L BUF4,MASQ5,24,48*160
 DC.L BUF5,MASQ6,24,48*160
 DC.L BUF5,MASQ6,24,49*160
 DC.L BUF6,MASQ7,24,49*160
 DC.L BUF7,MASQ8,24,50*160
 DC.L BUF7,MASQ8,24,50*160
 DC.L BUF8,MASQ9,24,51*160
 DC.L BUF8,MASQ9,24,52*160
 DC.L BUF9,MASQ10,24,52*160
 DC.L BUF9,MASQ10,24,53*160
 DC.L BUF10,MASQ11,24,53*160
 DC.L BUF11,MASQ12,24,54*160
 DC.L BUF11,MASQ12,24,54*160
 DC.L BUF12,MASQ13,24,55*160
 DC.L BUF12,MASQ13,24,55*160
 DC.L BUF13,MASQ14,24,56*160
 DC.L BUF13,MASQ14,24,57*160
 DC.L BUF14,MASQ15,24,57*160
 DC.L BUF14,MASQ15,24,58*160
 DC.L BUF15,MASQ16,24,58*160
 DC.L BUF16,MASQ17,24,59*160
 DC.L BUF16,MASQ17,24,59*160
 DC.L BUF1,MASQ2,16,60*160
 DC.L BUF1,MASQ2,16,61*160
 DC.L BUF2,MASQ3,16,61*160
 DC.L BUF2,MASQ3,16,62*160
 DC.L BUF3,MASQ4,16,62*160
 DC.L BUF3,MASQ4,16,63*160
 DC.L BUF4,MASQ5,16,64*160
 DC.L BUF4,MASQ5,16,64*160
 DC.L BUF5,MASQ6,16,65*160
 DC.L BUF5,MASQ6,16,65*160
 DC.L BUF6,MASQ7,16,66*160
 DC.L BUF6,MASQ7,16,67*160
 DC.L BUF7,MASQ8,16,67*160
 DC.L BUF7,MASQ8,16,68*160
 DC.L BUF8,MASQ9,16,68*160
 DC.L BUF8,MASQ9,16,69*160
 DC.L BUF9,MASQ10,16,70*160
 DC.L BUF9,MASQ10,16,70*160
 DC.L BUF10,MASQ11,16,71*160
 DC.L BUF10,MASQ11,16,71*160
 DC.L BUF11,MASQ12,16,72*160
 DC.L BUF11,MASQ12,16,73*160
 DC.L BUF12,MASQ13,16,73*160
 DC.L BUF12,MASQ13,16,74*160
 DC.L BUF13,MASQ14,16,75*160
 DC.L BUF13,MASQ14,16,75*160
 DC.L BUF14,MASQ15,16,76*160
 DC.L BUF14,MASQ15,16,76*160
 DC.L BUF14,MASQ15,16,77*160
 DC.L BUF15,MASQ16,16,78*160
 DC.L BUF15,MASQ16,16,78*160
 DC.L BUF16,MASQ17,16,79*160
 DC.L BUF16,MASQ17,16,80*160
 DC.L BUF1,MASQ2,8,80*160
 DC.L BUF1,MASQ2,8,81*160
 DC.L BUF2,MASQ3,8,82*160
 DC.L BUF2,MASQ3,8,82*160
 DC.L BUF2,MASQ3,8,83*160
 DC.L BUF3,MASQ4,8,84*160
 DC.L BUF3,MASQ4,8,84*160
 DC.L BUF4,MASQ5,8,85*160
 DC.L BUF4,MASQ5,8,86*160
 DC.L BUF5,MASQ6,8,86*160
 DC.L BUF5,MASQ6,8,87*160
 DC.L BUF5,MASQ6,8,88*160
 DC.L BUF6,MASQ7,8,88*160
 DC.L BUF6,MASQ7,8,89*160
 DC.L BUF7,MASQ8,8,89*160
 DC.L BUF7,MASQ8,8,90*160
 DC.L BUF7,MASQ8,8,91*160
 DC.L BUF8,MASQ9,8,91*160
 DC.L BUF8,MASQ9,8,92*160
 DC.L BUF8,MASQ9,8,93*160
 DC.L BUF9,MASQ10,8,93*160
 DC.L BUF9,MASQ10,8,94*160
 DC.L BUF10,MASQ11,8,95*160
 DC.L BUF10,MASQ11,8,95*160
 DC.L BUF10,MASQ11,8,96*160
 DC.L BUF11,MASQ12,8,97*160
 DC.L BUF11,MASQ12,8,97*160
 DC.L BUF11,MASQ12,8,98*160
 DC.L BUF12,MASQ13,8,99*160
 DC.L BUF12,MASQ13,8,99*160
 DC.L BUF12,MASQ13,8,100*160
 DC.L BUF13,MASQ14,8,101*160
 DC.L BUF13,MASQ14,8,101*160
 DC.L BUF13,MASQ14,8,102*160
 DC.L BUF14,MASQ15,8,103*160
 DC.L BUF14,MASQ15,8,103*160
 DC.L BUF14,MASQ15,8,104*160
 DC.L BUF15,MASQ16,8,105*160
 DC.L BUF15,MASQ16,8,105*160
 DC.L BUF15,MASQ16,8,106*160
 DC.L BUF16,MASQ17,8,107*160
 DC.L BUF16,MASQ17,8,107*160
 DC.L BUF16,MASQ17,8,108*160
 DC.L BUF1,MASQ2,0,109*160
 DC.L BUF1,MASQ2,0,109*160
 DC.L BUF1,MASQ2,0,110*160
 DC.L BUF1,MASQ2,0,111*160
 DC.L BUF2,MASQ3,0,111*160
 DC.L BUF2,MASQ3,0,112*160
 DC.L BUF2,MASQ3,0,113*160
 DC.L BUF2,MASQ3,0,113*160
 DC.L BUF3,MASQ4,0,114*160
 DC.L BUF3,MASQ4,0,115*160
 DC.L BUF3,MASQ4,0,115*160
 DC.L BUF3,MASQ4,0,116*160
 DC.L BUF4,MASQ5,0,117*160
 DC.L BUF4,MASQ5,0,117*160
 DC.L BUF4,MASQ5,0,118*160
 DC.L BUF4,MASQ5,0,119*160
 DC.L BUF5,MASQ6,0,119*160
 DC.L BUF5,MASQ6,0,120*160
 DC.L BUF5,MASQ6,0,120*160
 DC.L BUF5,MASQ6,0,121*160
 DC.L BUF6,MASQ7,0,122*160
 DC.L BUF6,MASQ7,0,122*160
 DC.L BUF6,MASQ7,0,123*160
 DC.L BUF6,MASQ7,0,124*160
 DC.L BUF6,MASQ7,0,124*160
 DC.L BUF7,MASQ8,0,125*160
 DC.L BUF7,MASQ8,0,126*160
 DC.L BUF7,MASQ8,0,126*160
 DC.L BUF7,MASQ8,0,127*160
 DC.L BUF7,MASQ8,0,127*160
 DC.L BUF7,MASQ8,0,128*160
 DC.L BUF8,MASQ9,0,129*160
 DC.L BUF8,MASQ9,0,129*160
 DC.L BUF8,MASQ9,0,130*160
 DC.L BUF8,MASQ9,0,131*160
 DC.L BUF8,MASQ9,0,131*160
 DC.L BUF8,MASQ9,0,132*160
 DC.L BUF9,MASQ10,0,132*160
 DC.L BUF9,MASQ10,0,133*160
 DC.L BUF9,MASQ10,0,134*160
 DC.L BUF9,MASQ10,0,134*160
 DC.L BUF9,MASQ10,0,135*160
 DC.L BUF9,MASQ10,0,135*160
 DC.L BUF9,MASQ10,0,136*160
 DC.L BUF9,MASQ10,0,137*160
 DC.L BUF10,MASQ11,0,137*160
 DC.L BUF10,MASQ11,0,138*160
 DC.L BUF10,MASQ11,0,138*160
 DC.L BUF10,MASQ11,0,139*160
 DC.L BUF10,MASQ11,0,139*160
 DC.L BUF10,MASQ11,0,140*160
 DC.L BUF10,MASQ11,0,141*160
 DC.L BUF10,MASQ11,0,141*160
 DC.L BUF10,MASQ11,0,142*160
 DC.L BUF10,MASQ11,0,142*160
 DC.L BUF10,MASQ11,0,143*160
 DC.L BUF11,MASQ12,0,143*160
 DC.L BUF11,MASQ12,0,144*160
 DC.L BUF11,MASQ12,0,145*160
 DC.L BUF11,MASQ12,0,145*160
 DC.L BUF11,MASQ12,0,146*160
 DC.L BUF11,MASQ12,0,146*160
 DC.L BUF11,MASQ12,0,147*160
 DC.L BUF11,MASQ12,0,147*160
 DC.L BUF11,MASQ12,0,148*160
 DC.L BUF11,MASQ12,0,148*160
 DC.L BUF11,MASQ12,0,149*160
 DC.L BUF11,MASQ12,0,149*160
 DC.L BUF11,MASQ12,0,150*160
 DC.L BUF11,MASQ12,0,151*160
 DC.L BUF11,MASQ12,0,151*160
 DC.L BUF11,MASQ12,0,152*160
 DC.L BUF11,MASQ12,0,152*160
 DC.L BUF11,MASQ12,0,153*160
 DC.L BUF11,MASQ12,0,153*160
 DC.L BUF11,MASQ12,0,154*160
 DC.L BUF11,MASQ12,0,154*160
 DC.L BUF11,MASQ12,0,155*160
 DC.L BUF11,MASQ12,0,155*160
 DC.L BUF11,MASQ12,0,156*160
 DC.L BUF11,MASQ12,0,156*160
 DC.L BUF11,MASQ12,0,157*160
 DC.L BUF11,MASQ12,0,157*160
 DC.L BUF11,MASQ12,0,157*160
 DC.L BUF11,MASQ12,0,158*160
 DC.L BUF11,MASQ12,0,158*160
 DC.L BUF11,MASQ12,0,159*160
 DC.L BUF11,MASQ12,0,159*160
 DC.L BUF10,MASQ11,0,160*160
 DC.L BUF10,MASQ11,0,160*160
 DC.L BUF10,MASQ11,0,161*160
 DC.L BUF10,MASQ11,0,161*160
 DC.L BUF10,MASQ11,0,162*160
 DC.L BUF10,MASQ11,0,162*160
 DC.L BUF10,MASQ11,0,162*160
 DC.L BUF10,MASQ11,0,163*160
 DC.L BUF10,MASQ11,0,163*160
 DC.L BUF10,MASQ11,0,164*160
 DC.L BUF10,MASQ11,0,164*160
 DC.L BUF9,MASQ10,0,164*160
 DC.L BUF9,MASQ10,0,165*160
 DC.L BUF9,MASQ10,0,165*160
 DC.L BUF9,MASQ10,0,166*160
 DC.L BUF9,MASQ10,0,166*160
 DC.L BUF9,MASQ10,0,166*160
 DC.L BUF9,MASQ10,0,167*160
 DC.L BUF9,MASQ10,0,167*160
 DC.L BUF8,MASQ9,0,168*160
 DC.L BUF8,MASQ9,0,168*160
 DC.L BUF8,MASQ9,0,168*160
 DC.L BUF8,MASQ9,0,169*160
 DC.L BUF8,MASQ9,0,169*160
 DC.L BUF8,MASQ9,0,169*160
 DC.L BUF8,MASQ9,0,170*160
 DC.L BUF7,MASQ8,0,170*160
 DC.L BUF7,MASQ8,0,170*160
 DC.L BUF7,MASQ8,0,171*160
 DC.L BUF7,MASQ8,0,171*160
 DC.L BUF7,MASQ8,0,171*160
 DC.L BUF6,MASQ7,0,172*160
 DC.L BUF6,MASQ7,0,172*160
 DC.L BUF6,MASQ7,0,172*160
 DC.L BUF6,MASQ7,0,173*160
 DC.L BUF6,MASQ7,0,173*160
 DC.L BUF5,MASQ6,0,173*160
 DC.L BUF5,MASQ6,0,173*160
 DC.L BUF5,MASQ6,0,174*160
 DC.L BUF5,MASQ6,0,174*160
 DC.L BUF5,MASQ6,0,174*160
 DC.L BUF4,MASQ5,0,175*160
 DC.L BUF4,MASQ5,0,175*160
 DC.L BUF4,MASQ5,0,175*160
 DC.L BUF4,MASQ5,0,175*160
 DC.L BUF3,MASQ4,0,176*160
 DC.L BUF3,MASQ4,0,176*160
 DC.L BUF3,MASQ4,0,176*160
 DC.L BUF3,MASQ4,0,176*160
 DC.L BUF2,MASQ3,0,177*160
 DC.L BUF2,MASQ3,0,177*160
 DC.L BUF2,MASQ3,0,177*160
 DC.L BUF2,MASQ3,0,177*160
 DC.L BUF1,MASQ2,0,177*160
 DC.L BUF1,MASQ2,0,178*160
 DC.L BUF1,MASQ2,0,178*160
 DC.L BUF16,MASQ17,8,178*160
 DC.L BUF16,MASQ17,8,178*160
 DC.L BUF16,MASQ17,8,178*160
 DC.L BUF16,MASQ17,8,179*160
 DC.L BUF15,MASQ16,8,179*160
 DC.L BUF15,MASQ16,8,179*160
 DC.L BUF15,MASQ16,8,179*160
 DC.L BUF14,MASQ15,8,179*160
 DC.L BUF14,MASQ15,8,179*160
 DC.L BUF14,MASQ15,8,180*160
 DC.L BUF13,MASQ14,8,180*160
 DC.L BUF13,MASQ14,8,180*160
 DC.L BUF13,MASQ14,8,180*160
 DC.L BUF13,MASQ14,8,180*160
 DC.L BUF12,MASQ13,8,180*160
 DC.L BUF12,MASQ13,8,180*160
 DC.L BUF12,MASQ13,8,180*160
 DC.L BUF11,MASQ12,8,181*160
 DC.L BUF11,MASQ12,8,181*160
 DC.L BUF11,MASQ12,8,181*160
 DC.L BUF10,MASQ11,8,181*160
 DC.L BUF10,MASQ11,8,181*160
 DC.L BUF9,MASQ10,8,181*160
 DC.L BUF9,MASQ10,8,181*160
 DC.L BUF9,MASQ10,8,181*160
 DC.L BUF8,MASQ9,8,181*160
 DC.L BUF8,MASQ9,8,181*160
 DC.L BUF8,MASQ9,8,181*160
 DC.L BUF7,MASQ8,8,181*160
 DC.L BUF7,MASQ8,8,181*160
 DC.L BUF7,MASQ8,8,181*160
 DC.L BUF6,MASQ7,8,181*160
 DC.L BUF6,MASQ7,8,181*160
 DC.L BUF5,MASQ6,8,181*160
 DC.L BUF5,MASQ6,8,181*160
 DC.L BUF5,MASQ6,8,181*160
 DC.L BUF4,MASQ5,8,181*160
 DC.L BUF4,MASQ5,8,181*160
 DC.L BUF3,MASQ4,8,181*160
 DC.L BUF3,MASQ4,8,181*160
 DC.L BUF3,MASQ4,8,181*160
 DC.L BUF2,MASQ3,8,181*160
 DC.L BUF2,MASQ3,8,181*160
 DC.L BUF1,MASQ2,8,181*160
 DC.L BUF1,MASQ2,8,181*160
 DC.L BUF1,MASQ2,8,181*160
 DC.L BUF16,MASQ17,16,181*160
 DC.L BUF16,MASQ17,16,181*160
 DC.L BUF15,MASQ16,16,181*160
 DC.L BUF15,MASQ16,16,181*160
 DC.L BUF14,MASQ15,16,181*160
 DC.L BUF14,MASQ15,16,181*160
 DC.L BUF14,MASQ15,16,181*160
 DC.L BUF13,MASQ14,16,181*160
 DC.L BUF13,MASQ14,16,181*160
 DC.L BUF12,MASQ13,16,181*160
 DC.L BUF12,MASQ13,16,180*160
 DC.L BUF11,MASQ12,16,180*160
 DC.L BUF11,MASQ12,16,180*160
 DC.L BUF10,MASQ11,16,180*160
 DC.L BUF10,MASQ11,16,180*160
 DC.L BUF10,MASQ11,16,180*160
 DC.L BUF9,MASQ10,16,180*160
 DC.L BUF9,MASQ10,16,180*160
 DC.L BUF8,MASQ9,16,179*160
 DC.L BUF8,MASQ9,16,179*160
 DC.L BUF7,MASQ8,16,179*160
 DC.L BUF7,MASQ8,16,179*160
 DC.L BUF6,MASQ7,16,179*160
 DC.L BUF6,MASQ7,16,179*160
 DC.L BUF5,MASQ6,16,178*160
 DC.L BUF5,MASQ6,16,178*160
 DC.L BUF4,MASQ5,16,178*160
 DC.L BUF4,MASQ5,16,178*160
 DC.L BUF3,MASQ4,16,178*160
 DC.L BUF3,MASQ4,16,177*160
 DC.L BUF2,MASQ3,16,177*160
 DC.L BUF2,MASQ3,16,177*160
 DC.L BUF1,MASQ2,16,177*160
 DC.L BUF1,MASQ2,16,177*160
 DC.L BUF16,MASQ17,24,176*160
 DC.L BUF16,MASQ17,24,176*160
 DC.L BUF15,MASQ16,24,176*160
 DC.L BUF15,MASQ16,24,176*160
 DC.L BUF14,MASQ15,24,175*160
 DC.L BUF14,MASQ15,24,175*160
 DC.L BUF13,MASQ14,24,175*160
 DC.L BUF13,MASQ14,24,175*160
 DC.L BUF12,MASQ13,24,174*160
 DC.L BUF12,MASQ13,24,174*160
 DC.L BUF11,MASQ12,24,174*160
 DC.L BUF11,MASQ12,24,174*160
 DC.L BUF10,MASQ11,24,173*160
 DC.L BUF10,MASQ11,24,173*160
 DC.L BUF9,MASQ10,24,173*160
 DC.L BUF9,MASQ10,24,172*160
 DC.L BUF8,MASQ9,24,172*160
 DC.L BUF8,MASQ9,24,172*160
 DC.L BUF7,MASQ8,24,171*160
 DC.L BUF7,MASQ8,24,171*160
 DC.L BUF6,MASQ7,24,171*160
 DC.L BUF6,MASQ7,24,170*160
 DC.L BUF5,MASQ6,24,170*160
 DC.L BUF5,MASQ6,24,170*160
 DC.L BUF4,MASQ5,24,169*160
 DC.L BUF4,MASQ5,24,169*160
 DC.L BUF3,MASQ4,24,169*160
 DC.L BUF3,MASQ4,24,168*160
 DC.L BUF2,MASQ3,24,168*160
 DC.L BUF1,MASQ2,24,168*160
 DC.L BUF1,MASQ2,24,167*160
 DC.L BUF16,MASQ17,32,167*160
 DC.L BUF16,MASQ17,32,166*160
 DC.L BUF15,MASQ16,32,166*160
 DC.L BUF15,MASQ16,32,166*160
 DC.L BUF14,MASQ15,32,165*160
 DC.L BUF14,MASQ15,32,165*160
 DC.L BUF13,MASQ14,32,164*160
 DC.L BUF13,MASQ14,32,164*160
 DC.L BUF12,MASQ13,32,164*160
 DC.L BUF12,MASQ13,32,163*160
 DC.L BUF11,MASQ12,32,163*160
 DC.L BUF10,MASQ11,32,162*160
 DC.L BUF10,MASQ11,32,162*160
 DC.L BUF9,MASQ10,32,162*160
 DC.L BUF9,MASQ10,32,161*160
 DC.L BUF8,MASQ9,32,161*160
 DC.L BUF8,MASQ9,32,160*160
 DC.L BUF7,MASQ8,32,160*160
 DC.L BUF7,MASQ8,32,159*160
 DC.L BUF6,MASQ7,32,159*160
 DC.L BUF6,MASQ7,32,158*160
 DC.L BUF5,MASQ6,32,158*160
 DC.L BUF4,MASQ5,32,157*160
 DC.L BUF4,MASQ5,32,157*160
 DC.L BUF3,MASQ4,32,157*160
 DC.L BUF3,MASQ4,32,156*160
 DC.L BUF2,MASQ3,32,156*160
 DC.L BUF2,MASQ3,32,155*160
 DC.L BUF1,MASQ2,32,155*160
 DC.L BUF1,MASQ2,32,154*160
 DC.L BUF16,MASQ17,40,154*160
 DC.L BUF16,MASQ17,40,153*160
 DC.L BUF15,MASQ16,40,153*160
 DC.L BUF14,MASQ15,40,152*160
 DC.L BUF14,MASQ15,40,152*160
 DC.L BUF13,MASQ14,40,151*160
 DC.L BUF13,MASQ14,40,151*160
 DC.L BUF12,MASQ13,40,150*160
 DC.L BUF12,MASQ13,40,149*160
 DC.L BUF11,MASQ12,40,149*160
 DC.L BUF11,MASQ12,40,148*160
 DC.L BUF10,MASQ11,40,148*160
 DC.L BUF10,MASQ11,40,147*160
 DC.L BUF9,MASQ10,40,147*160
 DC.L BUF8,MASQ9,40,146*160
 DC.L BUF8,MASQ9,40,146*160
 DC.L BUF7,MASQ8,40,145*160
 DC.L BUF7,MASQ8,40,145*160
 DC.L BUF6,MASQ7,40,144*160
 DC.L BUF6,MASQ7,40,144*160
 DC.L BUF5,MASQ6,40,143*160
 DC.L BUF5,MASQ6,40,142*160
 DC.L BUF4,MASQ5,40,142*160
 DC.L BUF4,MASQ5,40,141*160
 DC.L BUF3,MASQ4,40,141*160
 DC.L BUF2,MASQ3,40,140*160
 DC.L BUF2,MASQ3,40,140*160
 DC.L BUF1,MASQ2,40,139*160
 DC.L BUF1,MASQ2,40,138*160
 DC.L BUF16,MASQ17,48,138*160
 DC.L BUF16,MASQ17,48,137*160
 DC.L BUF15,MASQ16,48,137*160
 DC.L BUF15,MASQ16,48,136*160
 DC.L BUF14,MASQ15,48,135*160
 DC.L BUF14,MASQ15,48,135*160
 DC.L BUF13,MASQ14,48,134*160
 DC.L BUF13,MASQ14,48,134*160
 DC.L BUF12,MASQ13,48,133*160
 DC.L BUF12,MASQ13,48,132*160
 DC.L BUF11,MASQ12,48,132*160
 DC.L BUF10,MASQ11,48,131*160
 DC.L BUF10,MASQ11,48,131*160
 DC.L BUF9,MASQ10,48,130*160
 DC.L BUF9,MASQ10,48,129*160
 DC.L BUF8,MASQ9,48,129*160
 DC.L BUF8,MASQ9,48,128*160
 DC.L BUF7,MASQ8,48,127*160
 DC.L BUF7,MASQ8,48,127*160
 DC.L BUF6,MASQ7,48,126*160
 DC.L BUF6,MASQ7,48,126*160
 DC.L BUF5,MASQ6,48,125*160
 DC.L BUF5,MASQ6,48,124*160
 DC.L BUF4,MASQ5,48,124*160
 DC.L BUF4,MASQ5,48,123*160
 DC.L BUF3,MASQ4,48,122*160
 DC.L BUF3,MASQ4,48,122*160
 DC.L BUF2,MASQ3,48,121*160
 DC.L BUF2,MASQ3,48,120*160
 DC.L BUF1,MASQ2,48,120*160
 DC.L BUF1,MASQ2,48,119*160
 DC.L BUF16,MASQ17,56,119*160
 DC.L BUF16,MASQ17,56,118*160
 DC.L BUF15,MASQ16,56,117*160
 DC.L BUF15,MASQ16,56,117*160
 DC.L BUF14,MASQ15,56,116*160
 DC.L BUF14,MASQ15,56,115*160
 DC.L BUF13,MASQ14,56,115*160
 DC.L BUF13,MASQ14,56,114*160
 DC.L BUF12,MASQ13,56,113*160
 DC.L BUF12,MASQ13,56,113*160
 DC.L BUF11,MASQ12,56,112*160
 DC.L BUF11,MASQ12,56,111*160
 DC.L BUF10,MASQ11,56,111*160
 DC.L BUF10,MASQ11,56,110*160
 DC.L BUF9,MASQ10,56,109*160
 DC.L BUF9,MASQ10,56,109*160
 DC.L BUF8,MASQ9,56,108*160
 DC.L BUF8,MASQ9,56,107*160
 DC.L BUF7,MASQ8,56,107*160
 DC.L BUF7,MASQ8,56,106*160
 DC.L BUF7,MASQ8,56,105*160
 DC.L BUF6,MASQ7,56,105*160
 DC.L BUF6,MASQ7,56,104*160
 DC.L BUF5,MASQ6,56,103*160
 DC.L BUF5,MASQ6,56,103*160
 DC.L BUF4,MASQ5,56,102*160
 DC.L BUF4,MASQ5,56,101*160
 DC.L BUF3,MASQ4,56,101*160
 DC.L BUF3,MASQ4,56,100*160
 DC.L BUF2,MASQ3,56,99*160
 DC.L BUF2,MASQ3,56,99*160
 DC.L BUF2,MASQ3,56,98*160
 DC.L BUF1,MASQ2,56,97*160
 DC.L BUF1,MASQ2,56,97*160
 DC.L BUF16,MASQ17,64,96*160
 DC.L BUF16,MASQ17,64,95*160
 DC.L BUF15,MASQ16,64,95*160
 DC.L BUF15,MASQ16,64,94*160
 DC.L BUF15,MASQ16,64,93*160
 DC.L BUF14,MASQ15,64,93*160
 DC.L BUF14,MASQ15,64,92*160
 DC.L BUF13,MASQ14,64,92*160
 DC.L BUF13,MASQ14,64,91*160
 DC.L BUF13,MASQ14,64,90*160
 DC.L BUF12,MASQ13,64,90*160
 DC.L BUF12,MASQ13,64,89*160
 DC.L BUF11,MASQ12,64,88*160
 DC.L BUF11,MASQ12,64,88*160
 DC.L BUF10,MASQ11,64,87*160
 DC.L BUF10,MASQ11,64,86*160
 DC.L BUF10,MASQ11,64,86*160
 DC.L BUF9,MASQ10,64,85*160
 DC.L BUF9,MASQ10,64,84*160
 DC.L BUF9,MASQ10,64,84*160
 DC.L BUF8,MASQ9,64,83*160
 DC.L BUF8,MASQ9,64,82*160
 DC.L BUF7,MASQ8,64,82*160
 DC.L BUF7,MASQ8,64,81*160
 DC.L BUF7,MASQ8,64,80*160
 DC.L BUF6,MASQ7,64,80*160
 DC.L BUF6,MASQ7,64,79*160
 DC.L BUF6,MASQ7,64,78*160
 DC.L BUF5,MASQ6,64,78*160
 DC.L BUF5,MASQ6,64,77*160
 DC.L BUF5,MASQ6,64,77*160
 DC.L BUF4,MASQ5,64,76*160
 DC.L BUF4,MASQ5,64,75*160
 DC.L BUF3,MASQ4,64,75*160
 DC.L BUF3,MASQ4,64,74*160
 DC.L BUF3,MASQ4,64,73*160
 DC.L BUF2,MASQ3,64,73*160
 DC.L BUF2,MASQ3,64,72*160
 DC.L BUF2,MASQ3,64,71*160
 DC.L BUF1,MASQ2,64,71*160
 DC.L BUF1,MASQ2,64,70*160
 DC.L BUF1,MASQ2,64,70*160
 DC.L BUF1,MASQ2,64,69*160
 DC.L BUF16,MASQ17,72,68*160
 DC.L BUF16,MASQ17,72,68*160
 DC.L BUF16,MASQ17,72,67*160
 DC.L BUF15,MASQ16,72,67*160
 DC.L BUF15,MASQ16,72,66*160
 DC.L BUF15,MASQ16,72,65*160
 DC.L BUF14,MASQ15,72,65*160
 DC.L BUF14,MASQ15,72,64*160
 DC.L BUF14,MASQ15,72,64*160
 DC.L BUF14,MASQ15,72,63*160
 DC.L BUF13,MASQ14,72,62*160
 DC.L BUF13,MASQ14,72,62*160
 DC.L BUF13,MASQ14,72,61*160
 DC.L BUF12,MASQ13,72,61*160
 DC.L BUF12,MASQ13,72,60*160
 DC.L BUF12,MASQ13,72,59*160
 DC.L BUF12,MASQ13,72,59*160
 DC.L BUF11,MASQ12,72,58*160
 DC.L BUF11,MASQ12,72,58*160
 DC.L BUF11,MASQ12,72,57*160
 DC.L BUF11,MASQ12,72,57*160
 DC.L BUF10,MASQ11,72,56*160
 DC.L BUF10,MASQ11,72,55*160
 DC.L BUF10,MASQ11,72,55*160
 DC.L BUF10,MASQ11,72,54*160
 DC.L BUF9,MASQ10,72,54*160
 DC.L BUF9,MASQ10,72,53*160
 DC.L BUF9,MASQ10,72,53*160
 DC.L BUF9,MASQ10,72,52*160
 DC.L BUF9,MASQ10,72,52*160
 DC.L BUF8,MASQ9,72,51*160
 DC.L BUF8,MASQ9,72,51*160
 DC.L BUF8,MASQ9,72,50*160
 DC.L BUF8,MASQ9,72,49*160
 DC.L BUF8,MASQ9,72,49*160
 DC.L BUF7,MASQ8,72,48*160
 DC.L BUF7,MASQ8,72,48*160
 DC.L BUF7,MASQ8,72,47*160
 DC.L BUF7,MASQ8,72,47*160
 DC.L BUF7,MASQ8,72,46*160
 DC.L BUF6,MASQ7,72,46*160
 DC.L BUF6,MASQ7,72,45*160
 DC.L BUF6,MASQ7,72,45*160
 DC.L BUF6,MASQ7,72,44*160
 DC.L BUF6,MASQ7,72,44*160
 DC.L BUF6,MASQ7,72,43*160
 DC.L BUF6,MASQ7,72,43*160
 DC.L BUF5,MASQ6,72,42*160
 DC.L BUF5,MASQ6,72,42*160
 DC.L BUF5,MASQ6,72,41*160
 DC.L BUF5,MASQ6,72,41*160
 DC.L BUF5,MASQ6,72,41*160
 DC.L BUF5,MASQ6,72,40*160
 DC.L BUF5,MASQ6,72,40*160
 DC.L BUF4,MASQ5,72,39*160
 DC.L BUF4,MASQ5,72,39*160
 DC.L BUF4,MASQ5,72,38*160
 DC.L BUF4,MASQ5,72,38*160
 DC.L BUF4,MASQ5,72,37*160
 DC.L BUF4,MASQ5,72,37*160
 DC.L BUF4,MASQ5,72,37*160
 DC.L BUF4,MASQ5,72,36*160
 DC.L BUF4,MASQ5,72,36*160
 DC.L BUF3,MASQ4,72,35*160
 DC.L BUF3,MASQ4,72,35*160
 DC.L BUF3,MASQ4,72,34*160
 DC.L BUF3,MASQ4,72,34*160
 DC.L BUF3,MASQ4,72,34*160
 DC.L BUF3,MASQ4,72,33*160
 DC.L BUF3,MASQ4,72,33*160
 DC.L BUF3,MASQ4,72,33*160
 DC.L BUF3,MASQ4,72,32*160
 DC.L BUF3,MASQ4,72,32*160
 DC.L BUF3,MASQ4,72,31*160
 DC.L BUF3,MASQ4,72,31*160
 DC.L BUF3,MASQ4,72,31*160
 DC.L BUF3,MASQ4,72,30*160
 DC.L BUF3,MASQ4,72,30*160
 DC.L BUF3,MASQ4,72,30*160
 DC.L BUF2,MASQ3,72,29*160
 DC.L BUF2,MASQ3,72,29*160
 DC.L BUF2,MASQ3,72,29*160
 DC.L BUF2,MASQ3,72,28*160
 DC.L BUF2,MASQ3,72,28*160
 DC.L BUF2,MASQ3,72,28*160
 DC.L BUF2,MASQ3,72,27*160
 DC.L BUF2,MASQ3,72,27*160
 DC.L BUF2,MASQ3,72,27*160
 DC.L BUF2,MASQ3,72,26*160
 DC.L BUF2,MASQ3,72,26*160
 DC.L BUF2,MASQ3,72,26*160
 DC.L BUF2,MASQ3,72,25*160
 DC.L BUF2,MASQ3,72,25*160
 DC.L BUF2,MASQ3,72,25*160
 DC.L BUF2,MASQ3,72,25*160
 DC.L BUF2,MASQ3,72,24*160
 DC.L BUF2,MASQ3,72,24*160
 DC.L BUF3,MASQ4,72,24*160
 DC.L BUF3,MASQ4,72,24*160
 DC.L BUF3,MASQ4,72,23*160
 DC.L BUF3,MASQ4,72,23*160
 DC.L BUF3,MASQ4,72,23*160
 DC.L BUF3,MASQ4,72,23*160
 DC.L BUF3,MASQ4,72,22*160
 DC.L BUF3,MASQ4,72,22*160
 DC.L BUF3,MASQ4,72,22*160
 DC.L BUF3,MASQ4,72,22*160
 DC.L BUF3,MASQ4,72,22*160
 DC.L BUF3,MASQ4,72,21*160
 DC.L BUF3,MASQ4,72,21*160
 DC.L BUF3,MASQ4,72,21*160
 DC.L BUF3,MASQ4,72,21*160
 DC.L BUF3,MASQ4,72,21*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF4,MASQ5,72,20*160
 DC.L BUF4,MASQ5,72,19*160
 DC.L BUF4,MASQ5,72,19*160
 DC.L BUF4,MASQ5,72,19*160
 DC.L BUF5,MASQ6,72,19*160
 DC.L BUF5,MASQ6,72,19*160
 DC.L BUF5,MASQ6,72,19*160
 DC.L BUF5,MASQ6,72,19*160
 DC.L BUF5,MASQ6,72,19*160
 DC.L BUF5,MASQ6,72,18*160
 DC.L BUF5,MASQ6,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF6,MASQ7,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF7,MASQ8,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF8,MASQ9,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF9,MASQ10,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF10,MASQ11,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF11,MASQ12,72,18*160
 DC.L BUF12,MASQ13,72,18*160
 DC.L BUF12,MASQ13,72,18*160
 DC.L BUF12,MASQ13,72,18*160
 DC.L BUF12,MASQ13,72,18*160
 DC.L BUF13,MASQ14,72,18*160
 DC.L BUF13,MASQ14,72,18*160
 DC.L BUF13,MASQ14,72,19*160
 DC.L BUF14,MASQ15,72,19*160
 DC.L BUF14,MASQ15,72,19*160
 DC.L BUF14,MASQ15,72,19*160
 DC.L BUF14,MASQ15,72,19*160
 DC.L BUF15,MASQ16,72,19*160
 DC.L BUF15,MASQ16,72,19*160
 DC.L BUF15,MASQ16,72,19*160
 DC.L BUF15,MASQ16,72,20*160
 DC.L BUF16,MASQ17,72,20*160
 DC.L BUF16,MASQ17,72,20*160
 DC.L BUF16,MASQ17,72,20*160
 DC.L BUF1,MASQ2,64,20*160
 DC.L BUF1,MASQ2,64,20*160
 DC.L BUF1,MASQ2,64,21*160
 DC.L BUF2,MASQ3,64,21*160
 DC.L BUF2,MASQ3,64,21*160
 DC.L BUF2,MASQ3,64,21*160
 DC.L BUF3,MASQ4,64,21*160
 DC.L BUF3,MASQ4,64,22*160
 DC.L BUF3,MASQ4,64,22*160
 DC.L BUF3,MASQ4,64,22*160
 DC.L BUF4,MASQ5,64,22*160
 DC.L BUF4,MASQ5,64,22*160
 DC.L BUF4,MASQ5,64,23*160
 DC.L BUF5,MASQ6,64,23*160
 DC.L BUF5,MASQ6,64,23*160
 DC.L BUF5,MASQ6,64,23*160
 DC.L BUF6,MASQ7,64,24*160
 DC.L BUF6,MASQ7,64,24*160
 DC.L BUF6,MASQ7,64,24*160
 DC.L BUF7,MASQ8,64,24*160
 DC.L BUF7,MASQ8,64,25*160
 DC.L BUF8,MASQ9,64,25*160
 DC.L BUF8,MASQ9,64,25*160
 DC.L BUF8,MASQ9,64,26*160
 DC.L BUF9,MASQ10,64,26*160
 DC.L BUF9,MASQ10,64,26*160
 DC.L BUF9,MASQ10,64,26*160
 DC.L BUF10,MASQ11,64,27*160
 DC.L BUF10,MASQ11,64,27*160
 DC.L BUF10,MASQ11,64,27*160
 DC.L BUF11,MASQ12,64,28*160
 DC.L BUF11,MASQ12,64,28*160
 DC.L BUF12,MASQ13,64,28*160
 DC.L BUF12,MASQ13,64,29*160
 DC.L BUF12,MASQ13,64,29*160
 DC.L BUF13,MASQ14,64,29*160
 DC.L BUF13,MASQ14,64,30*160
 DC.L BUF13,MASQ14,64,30*160
 DC.L BUF14,MASQ15,64,30*160
 DC.L BUF14,MASQ15,64,31*160
 DC.L BUF15,MASQ16,64,31*160
 DC.L BUF15,MASQ16,64,31*160
 DC.L BUF15,MASQ16,64,32*160
 DC.L BUF16,MASQ17,64,32*160
 DC.L BUF16,MASQ17,64,33*160
 DC.L BUF1,MASQ2,56,33*160
 DC.L BUF1,MASQ2,56,33*160
 DC.L BUF1,MASQ2,56,34*160
 DC.L BUF2,MASQ3,56,34*160
 DC.L BUF2,MASQ3,56,35*160
 DC.L BUF3,MASQ4,56,35*160
 DC.L BUF3,MASQ4,56,35*160
 DC.L BUF3,MASQ4,56,36*160
 DC.L BUF4,MASQ5,56,36*160
 DC.L BUF4,MASQ5,56,37*160
 DC.L BUF5,MASQ6,56,37*160
 DC.L BUF5,MASQ6,56,38*160
 DC.L BUF5,MASQ6,56,38*160
 DC.L BUF6,MASQ7,56,38*160
 DC.L BUF6,MASQ7,56,39*160
 DC.L BUF7,MASQ8,56,39*160
 DC.L BUF7,MASQ8,56,40*160
 DC.L BUF8,MASQ9,56,40*160
 DC.L BUF8,MASQ9,56,41*160
 DC.L BUF8,MASQ9,56,41*160
 DC.L BUF9,MASQ10,56,42*160
 DC.L BUF9,MASQ10,56,42*160
 DC.L BUF10,MASQ11,56,43*160
 DC.L BUF10,MASQ11,56,43*160
 DC.L BUF11,MASQ12,56,44*160
 DC.L BUF11,MASQ12,56,44*160
 DC.L BUF11,MASQ12,56,44*160
 DC.L BUF12,MASQ13,56,45*160
 DC.L BUF12,MASQ13,56,45*160
 DC.L BUF13,MASQ14,56,46*160
 DC.L BUF13,MASQ14,56,46*160
 DC.L BUF14,MASQ15,56,47*160
 DC.L BUF14,MASQ15,56,47*160
 DC.L BUF14,MASQ15,56,48*160
 DC.L BUF15,MASQ16,56,49*160
 DC.L BUF15,MASQ16,56,49*160
 DC.L BUF16,MASQ17,56,50*160
 DC.L BUF16,MASQ17,56,50*160
 DC.L BUF1,MASQ2,48,51*160
 DC.L BUF1,MASQ2,48,51*160
 DC.L BUF2,MASQ3,48,52*160
 DC.L BUF2,MASQ3,48,52*160
 DC.L BUF2,MASQ3,48,53*160
 DC.L BUF3,MASQ4,48,53*160
 DC.L BUF3,MASQ4,48,54*160
 DC.L BUF4,MASQ5,48,54*160
 DC.L BUF4,MASQ5,48,55*160
 DC.L BUF5,MASQ6,48,56*160
 DC.L BUF5,MASQ6,48,56*160
 DC.L BUF6,MASQ7,48,57*160
 DC.L BUF6,MASQ7,48,57*160
 DC.L BUF6,MASQ7,48,58*160
 DC.L BUF7,MASQ8,48,58*160
 DC.L BUF7,MASQ8,48,59*160
 DC.L BUF8,MASQ9,48,60*160
 DC.L BUF8,MASQ9,48,60*160
 DC.L BUF9,MASQ10,48,61*160
 DC.L BUF9,MASQ10,48,61*160
 DC.L BUF10,MASQ11,48,62*160
 DC.L BUF10,MASQ11,48,62*160
 DC.L BUF10,MASQ11,48,63*160
 DC.L BUF11,MASQ12,48,64*160
 DC.L BUF11,MASQ12,48,64*160
 DC.L BUF12,MASQ13,48,65*160
 DC.L BUF12,MASQ13,48,65*160
 DC.L BUF13,MASQ14,48,66*160
 DC.L BUF13,MASQ14,48,67*160
 DC.L BUF14,MASQ15,48,67*160
 DC.L BUF14,MASQ15,48,68*160
 DC.L BUF15,MASQ16,48,69*160
 DC.L BUF15,MASQ16,48,69*160
 DC.L BUF15,MASQ16,48,70*160
 DC.L BUF16,MASQ17,48,70*160
 DC.L BUF16,MASQ17,48,71*160
 DC.L BUF1,MASQ2,40,72*160
 DC.L BUF1,MASQ2,40,72*160
 DC.L BUF2,MASQ3,40,73*160
 DC.L BUF2,MASQ3,40,74*160
 DC.L BUF3,MASQ4,40,74*160
 DC.L BUF3,MASQ4,40,75*160
 DC.L BUF3,MASQ4,40,75*160
 DC.L BUF4,MASQ5,40,76*160
 DC.L BUF4,MASQ5,40,77*160
 DC.L BUF5,MASQ6,40,77*160
 DC.L BUF5,MASQ6,40,78*160
 DC.L BUF6,MASQ7,40,79*160
 DC.L BUF6,MASQ7,40,79*160
 DC.L BUF7,MASQ8,40,80*160
 DC.L BUF7,MASQ8,40,81*160
 DC.L BUF7,MASQ8,40,81*160
 DC.L BUF8,MASQ9,40,82*160
 DC.L BUF8,MASQ9,40,82*160
 DC.L BUF9,MASQ10,40,83*160
 DC.L BUF9,MASQ10,40,84*160
 DC.L BUF10,MASQ11,40,84*160
 DC.L BUF10,MASQ11,40,85*160
 DC.L BUF11,MASQ12,40,86*160
 DC.L BUF11,MASQ12,40,86*160
 DC.L BUF11,MASQ12,40,87*160
 DC.L BUF12,MASQ13,40,88*160
 DC.L BUF12,MASQ13,40,88*160
 DC.L BUF13,MASQ14,40,89*160
 DC.L BUF13,MASQ14,40,90*160
 DC.L BUF14,MASQ15,40,90*160
 DC.L BUF14,MASQ15,40,91*160
 DC.L BUF14,MASQ15,40,92*160
 DC.L BUF15,MASQ16,40,92*160
 DC.L BUF15,MASQ16,40,93*160
 DC.L BUF16,MASQ17,40,94*160
 DC.L BUF16,MASQ17,40,94*160
 DC.L BUF1,MASQ2,32,95*160
 DC.L BUF1,MASQ2,32,96*160
 DC.L BUF1,MASQ2,32,96*160
 DC.L BUF2,MASQ3,32,97*160
 DC.L BUF2,MASQ3,32,98*160
 DC.L BUF3,MASQ4,32,98*160
 DC.L BUF3,MASQ4,32,99*160
 DC.L BUF3,MASQ4,32,100*160
 DC.L BUF4,MASQ5,32,100*160
 DC.L BUF4,MASQ5,32,101*160
 DC.L BUF5,MASQ6,32,102*160
 DC.L BUF5,MASQ6,32,102*160
 DC.L BUF5,MASQ6,32,103*160
 DC.L BUF6,MASQ7,32,104*160
 DC.L BUF6,MASQ7,32,104*160
 DC.L BUF7,MASQ8,32,105*160
 DC.L BUF7,MASQ8,32,106*160
 DC.L BUF7,MASQ8,32,106*160
 DC.L BUF8,MASQ9,32,107*160
 DC.L BUF8,MASQ9,32,108*160
 DC.L BUF9,MASQ10,32,108*160
 DC.L BUF9,MASQ10,32,109*160
 DC.L BUF9,MASQ10,32,110*160
 DC.L BUF10,MASQ11,32,110*160
 DC.L BUF10,MASQ11,32,111*160
 DC.L BUF11,MASQ12,32,112*160
 DC.L BUF11,MASQ12,32,112*160
 DC.L BUF11,MASQ12,32,113*160
 DC.L BUF12,MASQ13,32,114*160
 DC.L BUF12,MASQ13,32,114*160
 DC.L BUF12,MASQ13,32,115*160
 DC.L BUF13,MASQ14,32,115*160
 DC.L BUF13,MASQ14,32,116*160
 DC.L BUF13,MASQ14,32,117*160
 DC.L BUF14,MASQ15,32,117*160
 DC.L BUF14,MASQ15,32,118*160
 DC.L BUF15,MASQ16,32,119*160
 DC.L BUF15,MASQ16,32,119*160
 DC.L BUF15,MASQ16,32,120*160
 DC.L BUF16,MASQ17,32,121*160
 DC.L BUF16,MASQ17,32,121*160
 DC.L BUF16,MASQ17,32,122*160
 DC.L BUF1,MASQ2,24,123*160
 DC.L BUF1,MASQ2,24,123*160
 DC.L BUF1,MASQ2,24,124*160
 DC.L BUF2,MASQ3,24,124*160
 DC.L BUF2,MASQ3,24,125*160
 DC.L BUF2,MASQ3,24,126*160
 DC.L BUF3,MASQ4,24,126*160
 DC.L BUF3,MASQ4,24,127*160
 DC.L BUF3,MASQ4,24,128*160
 DC.L BUF4,MASQ5,24,128*160
 DC.L BUF4,MASQ5,24,129*160
 DC.L BUF4,MASQ5,24,129*160
 DC.L BUF5,MASQ6,24,130*160
 DC.L BUF5,MASQ6,24,131*160
 DC.L BUF5,MASQ6,24,131*160
 DC.L BUF5,MASQ6,24,132*160
 DC.L BUF6,MASQ7,24,133*160
 DC.L BUF6,MASQ7,24,133*160
 DC.L BUF6,MASQ7,24,134*160
 DC.L BUF7,MASQ8,24,134*160
 DC.L BUF7,MASQ8,24,135*160
 DC.L BUF7,MASQ8,24,136*160
 DC.L BUF8,MASQ9,24,136*160
 DC.L BUF8,MASQ9,24,137*160
 DC.L BUF8,MASQ9,24,137*160
 DC.L BUF8,MASQ9,24,138*160
 DC.L BUF9,MASQ10,24,139*160
 DC.L BUF9,MASQ10,24,139*160
 DC.L BUF9,MASQ10,24,140*160
 DC.L BUF9,MASQ10,24,140*160
 DC.L BUF10,MASQ11,24,141*160
 DC.L BUF10,MASQ11,24,141*160
 DC.L BUF10,MASQ11,24,142*160
 DC.L BUF10,MASQ11,24,143*160
 DC.L BUF11,MASQ12,24,143*160
 DC.L BUF11,MASQ12,24,144*160
 DC.L BUF11,MASQ12,24,144*160
 DC.L BUF11,MASQ12,24,145*160
 DC.L BUF12,MASQ13,24,145*160
 DC.L BUF12,MASQ13,24,146*160
 DC.L BUF12,MASQ13,24,146*160
 DC.L BUF12,MASQ13,24,147*160
 DC.L BUF13,MASQ14,24,147*160
 DC.L BUF13,MASQ14,24,148*160
 DC.L BUF13,MASQ14,24,149*160
 DC.L BUF13,MASQ14,24,149*160
 DC.L BUF13,MASQ14,24,150*160
 DC.L BUF14,MASQ15,24,150*160
 DC.L BUF14,MASQ15,24,151*160
 DC.L BUF14,MASQ15,24,151*160
 DC.L BUF14,MASQ15,24,152*160
 DC.L BUF14,MASQ15,24,152*160
 DC.L BUF15,MASQ16,24,153*160
 DC.L BUF15,MASQ16,24,153*160
 DC.L BUF15,MASQ16,24,154*160
 DC.L BUF15,MASQ16,24,154*160
 DC.L BUF15,MASQ16,24,155*160
 DC.L BUF16,MASQ17,24,155*160
 DC.L BUF16,MASQ17,24,156*160
 DC.L BUF16,MASQ17,24,156*160
 DC.L BUF16,MASQ17,24,157*160
 DC.L BUF16,MASQ17,24,157*160
 DC.L BUF16,MASQ17,24,158*160
 DC.L BUF1,MASQ2,16,158*160
 DC.L BUF1,MASQ2,16,159*160
 DC.L BUF1,MASQ2,16,159*160
 DC.L BUF1,MASQ2,16,159*160
 DC.L BUF1,MASQ2,16,160*160
 DC.L BUF1,MASQ2,16,160*160
 DC.L BUF1,MASQ2,16,161*160
 DC.L BUF1,MASQ2,16,161*160
 DC.L BUF2,MASQ3,16,162*160
 DC.L BUF2,MASQ3,16,162*160
 DC.L BUF2,MASQ3,16,163*160
 DC.L BUF2,MASQ3,16,163*160
 DC.L BUF2,MASQ3,16,163*160
 DC.L BUF2,MASQ3,16,164*160
 DC.L BUF2,MASQ3,16,164*160
 DC.L BUF2,MASQ3,16,165*160
 DC.L BUF2,MASQ3,16,165*160
 DC.L BUF3,MASQ4,16,165*160
 DC.L BUF3,MASQ4,16,166*160
 DC.L BUF3,MASQ4,16,166*160
 DC.L BUF3,MASQ4,16,167*160
 DC.L BUF3,MASQ4,16,167*160
 DC.L BUF3,MASQ4,16,167*160
 DC.L BUF3,MASQ4,16,168*160
 DC.L BUF3,MASQ4,16,168*160
 DC.L BUF3,MASQ4,16,168*160
 DC.L BUF3,MASQ4,16,169*160
 DC.L BUF3,MASQ4,16,169*160
 DC.L BUF3,MASQ4,16,169*160
 DC.L BUF3,MASQ4,16,170*160
 DC.L BUF3,MASQ4,16,170*160
 DC.L BUF3,MASQ4,16,170*160
 DC.L BUF3,MASQ4,16,171*160
 DC.L BUF3,MASQ4,16,171*160
 DC.L BUF4,MASQ5,16,171*160
 DC.L BUF4,MASQ5,16,172*160
 DC.L BUF4,MASQ5,16,172*160
 DC.L BUF4,MASQ5,16,172*160
 DC.L BUF4,MASQ5,16,173*160
 DC.L BUF4,MASQ5,16,173*160
 DC.L BUF4,MASQ5,16,173*160
 DC.L BUF4,MASQ5,16,174*160
 DC.L BUF4,MASQ5,16,174*160
 DC.L BUF4,MASQ5,16,174*160
 DC.L BUF4,MASQ5,16,174*160
 DC.L BUF4,MASQ5,16,175*160
 DC.L BUF3,MASQ4,16,175*160
 DC.L BUF3,MASQ4,16,175*160
 DC.L BUF3,MASQ4,16,175*160
 DC.L BUF3,MASQ4,16,176*160
 DC.L BUF3,MASQ4,16,176*160
 DC.L BUF3,MASQ4,16,176*160
 DC.L BUF3,MASQ4,16,176*160
 DC.L BUF3,MASQ4,16,177*160
 DC.L BUF3,MASQ4,16,177*160
 DC.L BUF3,MASQ4,16,177*160
 DC.L BUF3,MASQ4,16,177*160
 DC.L BUF3,MASQ4,16,177*160
 DC.L BUF3,MASQ4,16,178*160
 DC.L BUF3,MASQ4,16,178*160
 DC.L BUF3,MASQ4,16,178*160
 DC.L BUF3,MASQ4,16,178*160
 DC.L BUF3,MASQ4,16,178*160
 DC.L BUF3,MASQ4,16,179*160
 DC.L BUF2,MASQ3,16,179*160
 DC.L BUF2,MASQ3,16,179*160
 DC.L BUF2,MASQ3,16,179*160
 DC.L BUF2,MASQ3,16,179*160
 DC.L BUF2,MASQ3,16,179*160
 DC.L BUF2,MASQ3,16,180*160
 DC.L BUF2,MASQ3,16,180*160
 DC.L BUF2,MASQ3,16,180*160
 DC.L BUF2,MASQ3,16,180*160
 DC.L BUF1,MASQ2,16,180*160
 DC.L BUF1,MASQ2,16,180*160
 DC.L BUF1,MASQ2,16,180*160
 DC.L BUF1,MASQ2,16,180*160
 DC.L BUF1,MASQ2,16,181*160
 DC.L BUF1,MASQ2,16,181*160
 DC.L BUF1,MASQ2,16,181*160
 DC.L BUF16,MASQ17,24,181*160
 DC.L BUF16,MASQ17,24,181*160
 DC.L BUF16,MASQ17,24,181*160
 DC.L BUF16,MASQ17,24,181*160
 DC.L BUF16,MASQ17,24,181*160
 DC.L BUF16,MASQ17,24,181*160
 DC.L BUF15,MASQ16,24,181*160
 DC.L BUF15,MASQ16,24,181*160
 DC.L BUF15,MASQ16,24,181*160
 DC.L BUF15,MASQ16,24,181*160
 DC.L BUF15,MASQ16,24,181*160
 DC.L BUF14,MASQ15,24,181*160
 DC.L BUF14,MASQ15,24,181*160
 DC.L BUF14,MASQ15,24,181*160
 DC.L BUF14,MASQ15,24,181*160
 DC.L BUF14,MASQ15,24,181*160
 DC.L BUF13,MASQ14,24,181*160
 DC.L BUF13,MASQ14,24,181*160
 DC.L BUF13,MASQ14,24,181*160
 DC.L BUF13,MASQ14,24,181*160
 DC.L BUF12,MASQ13,24,181*160
 DC.L BUF12,MASQ13,24,181*160
 DC.L BUF12,MASQ13,24,181*160
 DC.L BUF12,MASQ13,24,181*160
 DC.L BUF11,MASQ12,24,181*160
 DC.L BUF11,MASQ12,24,181*160
 DC.L BUF11,MASQ12,24,181*160
 DC.L BUF11,MASQ12,24,181*160
 DC.L BUF10,MASQ11,24,181*160
 DC.L BUF10,MASQ11,24,181*160
 DC.L BUF10,MASQ11,24,181*160
 DC.L BUF9,MASQ10,24,181*160
 DC.L BUF9,MASQ10,24,181*160
 DC.L BUF9,MASQ10,24,181*160
 DC.L BUF9,MASQ10,24,181*160
 DC.L BUF8,MASQ9,24,181*160
 DC.L BUF8,MASQ9,24,180*160
 DC.L BUF8,MASQ9,24,180*160
 DC.L BUF7,MASQ8,24,180*160
 DC.L BUF7,MASQ8,24,180*160
 DC.L BUF7,MASQ8,24,180*160
 DC.L BUF6,MASQ7,24,180*160
 DC.L BUF6,MASQ7,24,180*160
 DC.L BUF6,MASQ7,24,180*160
 DC.L BUF5,MASQ6,24,179*160
 DC.L BUF5,MASQ6,24,179*160
 DC.L BUF5,MASQ6,24,179*160
 DC.L BUF4,MASQ5,24,179*160
 DC.L BUF4,MASQ5,24,179*160
 DC.L BUF4,MASQ5,24,179*160
 DC.L BUF3,MASQ4,24,178*160
 DC.L BUF3,MASQ4,24,178*160
 DC.L BUF3,MASQ4,24,178*160
 DC.L BUF2,MASQ3,24,178*160
 DC.L BUF2,MASQ3,24,178*160
 DC.L BUF2,MASQ3,24,177*160
 DC.L BUF1,MASQ2,24,177*160
 DC.L BUF1,MASQ2,24,177*160
 DC.L BUF16,MASQ17,32,177*160
 DC.L BUF16,MASQ17,32,177*160
 DC.L BUF16,MASQ17,32,176*160
 DC.L BUF15,MASQ16,32,176*160
 DC.L BUF15,MASQ16,32,176*160
 DC.L BUF14,MASQ15,32,176*160
 DC.L BUF14,MASQ15,32,175*160
 DC.L BUF14,MASQ15,32,175*160
 DC.L BUF13,MASQ14,32,175*160
 DC.L BUF13,MASQ14,32,175*160
 DC.L BUF12,MASQ13,32,174*160
 DC.L BUF12,MASQ13,32,174*160
 DC.L BUF12,MASQ13,32,174*160
 DC.L BUF11,MASQ12,32,173*160
 DC.L BUF11,MASQ12,32,173*160
 DC.L BUF10,MASQ11,32,173*160
 DC.L BUF10,MASQ11,32,173*160
 DC.L BUF9,MASQ10,32,172*160
 DC.L BUF9,MASQ10,32,172*160
 DC.L BUF9,MASQ10,32,172*160
 DC.L BUF8,MASQ9,32,171*160
 DC.L BUF8,MASQ9,32,171*160
 DC.L BUF7,MASQ8,32,171*160
 DC.L BUF7,MASQ8,32,170*160
 DC.L BUF6,MASQ7,32,170*160
 DC.L BUF6,MASQ7,32,170*160
 DC.L BUF5,MASQ6,32,169*160
 DC.L BUF5,MASQ6,32,169*160
 DC.L BUF4,MASQ5,32,169*160
 DC.L BUF4,MASQ5,32,168*160
 DC.L BUF3,MASQ4,32,168*160
 DC.L BUF3,MASQ4,32,167*160
 DC.L BUF2,MASQ3,32,167*160
 DC.L BUF2,MASQ3,32,167*160
 DC.L BUF1,MASQ2,32,166*160
 DC.L BUF1,MASQ2,32,166*160
 DC.L BUF16,MASQ17,40,166*160
 DC.L BUF16,MASQ17,40,165*160
 DC.L BUF15,MASQ16,40,165*160
 DC.L BUF15,MASQ16,40,164*160
 DC.L BUF14,MASQ15,40,164*160
 DC.L BUF14,MASQ15,40,164*160
 DC.L BUF13,MASQ14,40,163*160
 DC.L BUF13,MASQ14,40,163*160
 DC.L BUF12,MASQ13,40,162*160
 DC.L BUF12,MASQ13,40,162*160
 DC.L BUF11,MASQ12,40,161*160
 DC.L BUF11,MASQ12,40,161*160
 DC.L BUF10,MASQ11,40,161*160
 DC.L BUF10,MASQ11,40,160*160
 DC.L BUF9,MASQ10,40,160*160
 DC.L BUF9,MASQ10,40,159*160
 DC.L BUF8,MASQ9,40,159*160
 DC.L BUF7,MASQ8,40,158*160
 DC.L BUF7,MASQ8,40,158*160
 DC.L BUF6,MASQ7,40,157*160
 DC.L BUF6,MASQ7,40,157*160
 DC.L BUF5,MASQ6,40,156*160
 DC.L BUF5,MASQ6,40,156*160
 DC.L BUF4,MASQ5,40,155*160
 DC.L BUF4,MASQ5,40,155*160
 DC.L BUF3,MASQ4,40,154*160
 DC.L BUF2,MASQ3,40,154*160
 DC.L BUF2,MASQ3,40,153*160
 DC.L BUF1,MASQ2,40,153*160
 DC.L BUF1,MASQ2,40,152*160
 DC.L BUF16,MASQ17,48,152*160
 DC.L BUF16,MASQ17,48,151*160
 DC.L BUF15,MASQ16,48,151*160
 DC.L BUF14,MASQ15,48,150*160
 DC.L BUF14,MASQ15,48,150*160
 DC.L BUF13,MASQ14,48,149*160
 DC.L BUF13,MASQ14,48,149*160
 DC.L BUF12,MASQ13,48,148*160
 DC.L BUF11,MASQ12,48,148*160
 DC.L BUF11,MASQ12,48,147*160
 DC.L BUF10,MASQ11,48,147*160
 DC.L BUF10,MASQ11,48,146*160
 DC.L BUF9,MASQ10,48,146*160
 DC.L BUF8,MASQ9,48,145*160
 DC.L BUF8,MASQ9,48,144*160
 DC.L BUF7,MASQ8,48,144*160
 DC.L BUF7,MASQ8,48,143*160
 DC.L BUF6,MASQ7,48,143*160
 DC.L BUF5,MASQ6,48,142*160
 DC.L BUF5,MASQ6,48,142*160
 DC.L BUF4,MASQ5,48,141*160
 DC.L BUF3,MASQ4,48,141*160
 DC.L BUF3,MASQ4,48,140*160
 DC.L BUF2,MASQ3,48,139*160
 DC.L BUF2,MASQ3,48,139*160
 DC.L BUF1,MASQ2,48,138*160
 DC.L BUF16,MASQ17,56,138*160
 DC.L BUF16,MASQ17,56,137*160
 DC.L BUF15,MASQ16,56,136*160
 DC.L BUF14,MASQ15,56,136*160
 DC.L BUF14,MASQ15,56,135*160
 DC.L BUF13,MASQ14,56,135*160
 DC.L BUF12,MASQ13,56,134*160
 DC.L BUF12,MASQ13,56,133*160
 DC.L BUF11,MASQ12,56,133*160
 DC.L BUF11,MASQ12,56,132*160
 DC.L BUF10,MASQ11,56,132*160
 DC.L BUF9,MASQ10,56,131*160
 DC.L BUF9,MASQ10,56,130*160
 DC.L BUF8,MASQ9,56,130*160
 DC.L BUF7,MASQ8,56,129*160
 DC.L BUF7,MASQ8,56,129*160
 DC.L BUF6,MASQ7,56,128*160
 DC.L BUF5,MASQ6,56,127*160
 DC.L BUF5,MASQ6,56,127*160
 DC.L BUF4,MASQ5,56,126*160
 DC.L BUF3,MASQ4,56,125*160
 DC.L BUF3,MASQ4,56,125*160
 DC.L BUF2,MASQ3,56,124*160
 DC.L BUF1,MASQ2,56,123*160
 DC.L BUF1,MASQ2,56,123*160
 DC.L BUF16,MASQ17,64,122*160
 DC.L BUF15,MASQ16,64,122*160
 DC.L BUF15,MASQ16,64,121*160
 DC.L BUF14,MASQ15,64,120*160
 DC.L BUF13,MASQ14,64,120*160
 DC.L BUF13,MASQ14,64,119*160
 DC.L BUF12,MASQ13,64,118*160
 DC.L BUF11,MASQ12,64,118*160
 DC.L BUF11,MASQ12,64,117*160
 DC.L BUF10,MASQ11,64,116*160
 DC.L BUF9,MASQ10,64,116*160
 DC.L BUF9,MASQ10,64,115*160
 DC.L BUF8,MASQ9,64,114*160
 DC.L BUF7,MASQ8,64,114*160
 DC.L BUF7,MASQ8,64,113*160
 DC.L BUF6,MASQ7,64,113*160
 DC.L BUF5,MASQ6,64,112*160
 DC.L BUF5,MASQ6,64,111*160
 DC.L BUF4,MASQ5,64,111*160
 DC.L BUF3,MASQ4,64,110*160
 DC.L BUF3,MASQ4,64,109*160
 DC.L BUF2,MASQ3,64,109*160
 DC.L BUF1,MASQ2,64,108*160
 DC.L BUF16,MASQ17,72,107*160
 DC.L BUF16,MASQ17,72,107*160
 DC.L BUF15,MASQ16,72,106*160
 DC.L BUF14,MASQ15,72,105*160
 DC.L BUF14,MASQ15,72,105*160
 DC.L BUF13,MASQ14,72,104*160
 DC.L BUF12,MASQ13,72,103*160
 DC.L BUF12,MASQ13,72,103*160
 DC.L BUF11,MASQ12,72,102*160
 DC.L BUF10,MASQ11,72,101*160
 DC.L BUF10,MASQ11,72,101*160
 DC.L BUF9,MASQ10,72,100*160

 DC.L BUF8,MASQ9,72,100*160
 DC.L BUF8,MASQ9,72,100*160
 DC.L BUF7,MASQ8,72,101*160
 DC.L BUF6,MASQ7,72,101*160
 DC.L BUF6,MASQ7,72,102*160
 DC.L BUF5,MASQ6,72,103*160
 DC.L BUF4,MASQ5,72,103*160
 DC.L BUF4,MASQ5,72,104*160
 DC.L BUF3,MASQ4,72,105*160
 DC.L BUF2,MASQ3,72,105*160
 DC.L BUF2,MASQ3,72,106*160
 DC.L BUF1,MASQ2,72,107*160
 DC.L BUF16,MASQ17,80,107*160
 DC.L BUF16,MASQ17,80,108*160
 DC.L BUF15,MASQ16,80,109*160
 DC.L BUF14,MASQ15,80,109*160
 DC.L BUF14,MASQ15,80,110*160
 DC.L BUF13,MASQ14,80,111*160
 DC.L BUF12,MASQ13,80,111*160
 DC.L BUF12,MASQ13,80,112*160
 DC.L BUF11,MASQ12,80,113*160
 DC.L BUF10,MASQ11,80,113*160
 DC.L BUF10,MASQ11,80,114*160
 DC.L BUF9,MASQ10,80,115*160
 DC.L BUF8,MASQ9,80,115*160
 DC.L BUF7,MASQ8,80,116*160
 DC.L BUF7,MASQ8,80,117*160
 DC.L BUF6,MASQ7,80,117*160
 DC.L BUF5,MASQ6,80,118*160
 DC.L BUF5,MASQ6,80,119*160
 DC.L BUF4,MASQ5,80,119*160
 DC.L BUF3,MASQ4,80,120*160
 DC.L BUF3,MASQ4,80,121*160
 DC.L BUF2,MASQ3,80,121*160
 DC.L BUF1,MASQ2,80,122*160
 DC.L BUF1,MASQ2,80,122*160
 DC.L BUF16,MASQ17,88,123*160
 DC.L BUF15,MASQ16,88,124*160
 DC.L BUF15,MASQ16,88,124*160
 DC.L BUF14,MASQ15,88,125*160
 DC.L BUF13,MASQ14,88,126*160
 DC.L BUF13,MASQ14,88,126*160
 DC.L BUF12,MASQ13,88,127*160
 DC.L BUF11,MASQ12,88,127*160
 DC.L BUF11,MASQ12,88,128*160
 DC.L BUF10,MASQ11,88,129*160
 DC.L BUF10,MASQ11,88,129*160
 DC.L BUF9,MASQ10,88,130*160
 DC.L BUF8,MASQ9,88,131*160
 DC.L BUF8,MASQ9,88,131*160
 DC.L BUF7,MASQ8,88,132*160
 DC.L BUF6,MASQ7,88,132*160
 DC.L BUF6,MASQ7,88,133*160
 DC.L BUF5,MASQ6,88,134*160
 DC.L BUF4,MASQ5,88,134*160
 DC.L BUF4,MASQ5,88,135*160
 DC.L BUF3,MASQ4,88,135*160
 DC.L BUF2,MASQ3,88,136*160
 DC.L BUF2,MASQ3,88,137*160
 DC.L BUF1,MASQ2,88,137*160
 DC.L BUF16,MASQ17,96,138*160
 DC.L BUF16,MASQ17,96,138*160
 DC.L BUF15,MASQ16,96,139*160
 DC.L BUF15,MASQ16,96,140*160
 DC.L BUF14,MASQ15,96,140*160
 DC.L BUF13,MASQ14,96,141*160
 DC.L BUF13,MASQ14,96,141*160
 DC.L BUF12,MASQ13,96,142*160
 DC.L BUF11,MASQ12,96,142*160
 DC.L BUF11,MASQ12,96,143*160
 DC.L BUF10,MASQ11,96,144*160
 DC.L BUF10,MASQ11,96,144*160
 DC.L BUF9,MASQ10,96,145*160
 DC.L BUF8,MASQ9,96,145*160
 DC.L BUF8,MASQ9,96,146*160
 DC.L BUF7,MASQ8,96,146*160
 DC.L BUF7,MASQ8,96,147*160
 DC.L BUF6,MASQ7,96,147*160
 DC.L BUF5,MASQ6,96,148*160
 DC.L BUF5,MASQ6,96,148*160
 DC.L BUF4,MASQ5,96,149*160
 DC.L BUF4,MASQ5,96,150*160
 DC.L BUF3,MASQ4,96,150*160
 DC.L BUF2,MASQ3,96,151*160
 DC.L BUF2,MASQ3,96,151*160
 DC.L BUF1,MASQ2,96,152*160
 DC.L BUF1,MASQ2,96,152*160
 DC.L BUF16,MASQ17,104,153*160
 DC.L BUF16,MASQ17,104,153*160
 DC.L BUF15,MASQ16,104,154*160
 DC.L BUF14,MASQ15,104,154*160
 DC.L BUF14,MASQ15,104,155*160
 DC.L BUF13,MASQ14,104,155*160
 DC.L BUF13,MASQ14,104,156*160
 DC.L BUF12,MASQ13,104,156*160
 DC.L BUF12,MASQ13,104,157*160
 DC.L BUF11,MASQ12,104,157*160
 DC.L BUF10,MASQ11,104,158*160
 DC.L BUF10,MASQ11,104,158*160
 DC.L BUF9,MASQ10,104,158*160
 DC.L BUF9,MASQ10,104,159*160
 DC.L BUF8,MASQ9,104,159*160
 DC.L BUF8,MASQ9,104,160*160
 DC.L BUF7,MASQ8,104,160*160
 DC.L BUF7,MASQ8,104,161*160
 DC.L BUF6,MASQ7,104,161*160
 DC.L BUF6,MASQ7,104,162*160
 DC.L BUF5,MASQ6,104,162*160
 DC.L BUF4,MASQ5,104,162*160
 DC.L BUF4,MASQ5,104,163*160
 DC.L BUF3,MASQ4,104,163*160
 DC.L BUF3,MASQ4,104,164*160
 DC.L BUF2,MASQ3,104,164*160
 DC.L BUF2,MASQ3,104,165*160
 DC.L BUF1,MASQ2,104,165*160
 DC.L BUF1,MASQ2,104,165*160
 DC.L BUF16,MASQ17,112,166*160
 DC.L BUF16,MASQ17,112,166*160
 DC.L BUF15,MASQ16,112,166*160
 DC.L BUF15,MASQ16,112,167*160
 DC.L BUF14,MASQ15,112,167*160
 DC.L BUF14,MASQ15,112,168*160
 DC.L BUF13,MASQ14,112,168*160
 DC.L BUF13,MASQ14,112,168*160
 DC.L BUF12,MASQ13,112,169*160
 DC.L BUF12,MASQ13,112,169*160
 DC.L BUF12,MASQ13,112,169*160
 DC.L BUF11,MASQ12,112,170*160
 DC.L BUF11,MASQ12,112,170*160
 DC.L BUF10,MASQ11,112,170*160
 DC.L BUF10,MASQ11,112,171*160
 DC.L BUF9,MASQ10,112,171*160
 DC.L BUF9,MASQ10,112,171*160
 DC.L BUF8,MASQ9,112,172*160
 DC.L BUF8,MASQ9,112,172*160
 DC.L BUF7,MASQ8,112,172*160
 DC.L BUF7,MASQ8,112,173*160
 DC.L BUF7,MASQ8,112,173*160
 DC.L BUF6,MASQ7,112,173*160
 DC.L BUF6,MASQ7,112,174*160
 DC.L BUF5,MASQ6,112,174*160
 DC.L BUF5,MASQ6,112,174*160
 DC.L BUF4,MASQ5,112,174*160
 DC.L BUF4,MASQ5,112,175*160
 DC.L BUF4,MASQ5,112,175*160
 DC.L BUF3,MASQ4,112,175*160
 DC.L BUF3,MASQ4,112,175*160
 DC.L BUF2,MASQ3,112,176*160
 DC.L BUF2,MASQ3,112,176*160
 DC.L BUF2,MASQ3,112,176*160
 DC.L BUF1,MASQ2,112,176*160
 DC.L BUF1,MASQ2,112,177*160
 DC.L BUF16,MASQ17,120,177*160
 DC.L BUF16,MASQ17,120,177*160
 DC.L BUF16,MASQ17,120,177*160
 DC.L BUF15,MASQ16,120,177*160
 DC.L BUF15,MASQ16,120,178*160
 DC.L BUF15,MASQ16,120,178*160
 DC.L BUF14,MASQ15,120,178*160
 DC.L BUF14,MASQ15,120,178*160
 DC.L BUF13,MASQ14,120,178*160
 DC.L BUF13,MASQ14,120,179*160
 DC.L BUF13,MASQ14,120,179*160
 DC.L BUF12,MASQ13,120,179*160
 DC.L BUF12,MASQ13,120,179*160
 DC.L BUF12,MASQ13,120,179*160
 DC.L BUF11,MASQ12,120,179*160
 DC.L BUF11,MASQ12,120,180*160
 DC.L BUF11,MASQ12,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF10,MASQ11,120,180*160
 DC.L BUF9,MASQ10,120,180*160
 DC.L BUF9,MASQ10,120,180*160
 DC.L BUF9,MASQ10,120,181*160
 DC.L BUF8,MASQ9,120,181*160
 DC.L BUF8,MASQ9,120,181*160
 DC.L BUF8,MASQ9,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF7,MASQ8,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF6,MASQ7,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF5,MASQ6,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF4,MASQ5,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF3,MASQ4,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF2,MASQ3,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF1,MASQ2,120,181*160
 DC.L BUF16,MASQ17,128,181*160
 DC.L BUF16,MASQ17,128,181*160
 DC.L BUF16,MASQ17,128,181*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF16,MASQ17,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,180*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF15,MASQ16,128,179*160
 DC.L BUF14,MASQ15,128,179*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,178*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,177*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,176*160
 DC.L BUF14,MASQ15,128,175*160
 DC.L BUF14,MASQ15,128,175*160
 DC.L BUF13,MASQ14,128,175*160
 DC.L BUF13,MASQ14,128,175*160
 DC.L BUF13,MASQ14,128,174*160
 DC.L BUF13,MASQ14,128,174*160
 DC.L BUF13,MASQ14,128,174*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,173*160
 DC.L BUF13,MASQ14,128,172*160
 DC.L BUF13,MASQ14,128,172*160
 DC.L BUF13,MASQ14,128,172*160
 DC.L BUF14,MASQ15,128,171*160
 DC.L BUF14,MASQ15,128,171*160
 DC.L BUF14,MASQ15,128,171*160
 DC.L BUF14,MASQ15,128,170*160
 DC.L BUF14,MASQ15,128,170*160
 DC.L BUF14,MASQ15,128,170*160
 DC.L BUF14,MASQ15,128,169*160
 DC.L BUF14,MASQ15,128,169*160
 DC.L BUF14,MASQ15,128,169*160
 DC.L BUF14,MASQ15,128,168*160
 DC.L BUF14,MASQ15,128,168*160
 DC.L BUF14,MASQ15,128,168*160
 DC.L BUF14,MASQ15,128,167*160
 DC.L BUF14,MASQ15,128,167*160
 DC.L BUF14,MASQ15,128,166*160
 DC.L BUF14,MASQ15,128,166*160
 DC.L BUF14,MASQ15,128,166*160
 DC.L BUF14,MASQ15,128,165*160
 DC.L BUF15,MASQ16,128,165*160
 DC.L BUF15,MASQ16,128,164*160
 DC.L BUF15,MASQ16,128,164*160
 DC.L BUF15,MASQ16,128,164*160
 DC.L BUF15,MASQ16,128,163*160
 DC.L BUF15,MASQ16,128,163*160
 DC.L BUF15,MASQ16,128,162*160
 DC.L BUF15,MASQ16,128,162*160
 DC.L BUF15,MASQ16,128,162*160
 DC.L BUF16,MASQ17,128,161*160
 DC.L BUF16,MASQ17,128,161*160
 DC.L BUF16,MASQ17,128,160*160
 DC.L BUF16,MASQ17,128,160*160
 DC.L BUF16,MASQ17,128,159*160
 DC.L BUF16,MASQ17,128,159*160
 DC.L BUF16,MASQ17,128,158*160
 DC.L BUF1,MASQ2,120,158*160
 DC.L BUF1,MASQ2,120,157*160
 DC.L BUF1,MASQ2,120,157*160
 DC.L BUF1,MASQ2,120,156*160
 DC.L BUF1,MASQ2,120,156*160
 DC.L BUF1,MASQ2,120,156*160
 DC.L BUF2,MASQ3,120,155*160
 DC.L BUF2,MASQ3,120,155*160
 DC.L BUF2,MASQ3,120,154*160
 DC.L BUF2,MASQ3,120,154*160







        DC.B        -1,-1,-1,-1
