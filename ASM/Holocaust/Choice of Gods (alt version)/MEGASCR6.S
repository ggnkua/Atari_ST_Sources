;*************************************************************************;
;
;                        ATTACK OF INDIGESTION
;
;*************************************************************************;
;
; Ce titre pourrave veut juste montrer aux coders de d‚mos que l'on ne peut
; plus encaisser les m‚gascrollers. Surtout les moches comme celui-ci.
;
; Ne regarder pas le code, c'est un d‚lire suicidogŠne!!!
;
; Je m'explique: … l'‚poque o— j'ai cod‚ ‡a ( il y a bien longtemps ), je
; ne connaissais pas l'instruction MOVEP.... ce qui fait que j'ai du in-
; -cruster dans les nops un bŠte truc qui, recod‚ avec des moveps, tien-
; -drait dans le border haut.
;
; Je vous passe les d‚tails, mais par curiosit‚, allez voir dans BUFFER_FULL
; comment je fais mes RTS, hein, allez voir!!! ( j'avais pas assez de nops 
; pour un RTS. Ce code est honteux. )



DEBUT:	
	LEA.L 	D_PILE,A7

	PEA	0.W
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP	

	MOVEQ	#1,D0
	JSR	ZIK2
	
	JMP	INCRUSTE
CESTFINI
	MOVE.L	#1,PNT
	MOVE.L	#1,CNN
	
	MOVE.L	#-8,VALUE2
	MOVE.L	#-8,VALUE

	MOVE.L	#DATA,DATAPNT
	MOVE.L	#DATA,DATAPNT2

	MOVE.L	#FIN,$008.W
	MOVE.L	#FIN,$00C.W
	MOVE.L	#FIN,$010.W

	JSR	SET_SCR

	CLR.B	$FFFFFA07.W
	CLR.B	$FFFFFA09.W
	
	MOVE.B	#$12,$FFFFFC02.W
	
	CLR.B	$FFFFFA1B.W
	BSET	#0,$FFFFFA07.W
	BSET	#0,$FFFFFA13.W

	ANDI.B	#%11111000,$484.W

	CLR	PNTO
	CLR	PNT3
	CLR.L	PNTY		
	CLR.L	PNTX
	CLR.L	PNTDIST

	LEA	DIST_DAT,A2	3
	ADDA.L	PNTDIST,A2	7?

	LEA	TEXTE,A0
	MOVE.L	A0,MEM_LET
	MOVE	#1,PART_AFF

	MOVE.L	#RTE,$120.W

	MOVE.L	#VBLR,$70.W

BOUCLED	CMPI.L	#0,FLAGED
	BEQ.S	BOUCLED
	JMP	LAMED

VBLR	
	CLR.B	$FFFFFA1B.W		4*

	LEA	POS1+$2800,A1	3
	ADDA	PNTO,A1	6
	ADDA	PNT3,A1	6
	MOVE.L	A1,USP	1
	
	CLR.L	$FFFF8240.W
	CLR.L	$FFFF8244.W
	CLR.L	$FFFF8248.W
	CLR.L	$FFFF824C.W
	CLR.L	$FFFF8250.W
	CLR.L	$FFFF8254.W
	CLR.L	$FFFF8258.W
	CLR.L	$FFFF825C.W

	move.l	SCREEN,a1		5*
	ADDA.L	VALUE,A1		6*
	LEA	208+160*7(A1),A1	2*
;	57=SUR

	MOVE.L	A2,SAVEA2
	
	CMPI.L	#0,CNN		7
	BNE.S	OHOH		2
	MOVE.L	GLOUBI,A0		5
	JSR	(A0)		4
	MOVE.L	#VB,GLOUBI2		7
	BRA	GASP		3		.S
OHOH	
	CLR.L	CNN		7
	MOVE.L	#VB2,GLOUBI2	7
	DCB	3700/5,$2090
GASP	;3723
	MOVE.L	SAVEA2,A2
	CLR.L	PLUS3		7*

ACHANGER	ADD.L	#8,VALUE		9*

	MOVE.L	VALUE,D0		5*
	CMPI.L	#29440,D0		4*
	BNE.S	MLML		2
	CLR.L	VALUE		7*
	MOVE.L	#-29440,PLUS3	7*
	BRA.S	GLIBO		3*
MLML	DCB	17,$4E71	16*
GLIBO	
	;44
	MOVE.L	DATAPNT,A6		5
	CMPI.L	#-1,(A6)		5
	BNE.S	OK2		2
	MOVE.L	#DATA,DATAPNT	7
	MOVE.L	DATAPNT,A6		5
	BRA.S	GF		3
OK2	DCB	15,$4E71
GF	MOVE.L	(A6)+,PLUS		7
	MOVE.L	(A6)+,A5		3
;37
	DCB	80,$2090
	CLR.B	$FFFF820A.W
	DCB	18,$4E71
	MOVE.B	#2,$FFFF820A.W

KJ	MOVE.L	#$FFFF8209,A0	
	MOVE.L	#$FFFF8260,A4	
	MOVE.L	#$FFFF820A,A3	
	MOVE	#199+28,D0		* NB DE LIGNES
	MOVEQ	#0,D1		
	MOVEQ	#0,D4
	MOVEQ	#2,D3
	MOVEQ	#$10,D6

SYNCHR	MOVE.B	(A0),D7     * SYNCHRO
	BEQ.S	SYNCHR
	SUB.W	D7,D6		
	LSL.W	D6,D1		

	MOVE.L	GLOUBI2,A0	5

	MOVE.L	A7,SAVEA7
	DCB	75/5,$2090
	DCB	4,$4E71
	MOVE	#$000,$FFFF8240.W

	JSR	(A5)		*4	T=128
	MOVE.L	(A6)+,A5	*3
	JSR	(A5)
	MOVE.L	(A6)+,A5
	JSR	(A5)
	MOVE.L	(A6)+,A5
	JSR	(A5)
	MOVE.L	(A6)+,A5
	JSR	(A5)
	MOVE.L	(A6)+,A5
	JSR	(A5)
	
	MOVE.L	USP,A5	1
	MOVE.L	A6,USP
	LEA	$FFFF8242.W,A6	2
	DCB	7-2-2-1-1,$4E71
	JMP	(A0)
VB
ZAPPY
N	SET	0

	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	
	MOVE.L	#$07400630,$FFFF8252.W
	MOVE.L	#$05200410,$FFFF8256.W
	MOVE.L	#$03000200,$FFFF825A.W
	MOVE	#$0100,$FFFF825E.W

	DCB	4,$4E71
	DCB	10,$2090
	MOVEM.L	N(A5),D1-D4	12
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4

	REPT	39
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	NOP
	DCB	15,$2090
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4
	endr

N	SET	0
	REPT	40
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4
	endr

N	SET	0
	REPT	40
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4
	endr

N	SET	0
	REPT	40
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4
	endr

N	SET	0
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4

VB3
	REPT	39
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4
	endr


N	SET	0
	REPT	21
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4
	endr

	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	MOVEM.L	D1-D4,(A6)	10
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	CLR.B	$FFFF820A.W
	DCB	1,$2A95
	DCB	3,$4E71
N	SET	N+16
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVE	a4,(A3)
	MOVEM.L	N(A5),D1-D4	12
	DCB	14,$2090
	NOP
	NOP
	NOP
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2A95
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	dcb	2,$4e71
	MOVEM.L	D1-D4,(A6)	10

N	SET	N+16
	REPT	17
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)	10
N	SET	N+4*4
	endr


N	SET	0
	REPT	16-10
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)
N	SET	N+4*4
	endr
CHANGE_IT	REPT	10
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	N(A5),D1-D4
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	NOP
	NOP
	MOVEM.L	D1-D4,(A6)
N	SET	N+4*4
	endr

VB4	CLR.L	$FFFF8240.W
	CLR.L	$FFFF8244.W
	CLR.L	$FFFF8248.W
	CLR.L	$FFFF824C.W
	CLR.L	$FFFF8250.W
	CLR.L	$FFFF8254.W
	CLR.L	$FFFF8258.W
	CLR.L	$FFFF825C.W
	MOVE.L	USP,A6

	CMPI.L	#0,FLAGED
	BNE.S	KKK
	MOVE.L	A6,DATAPNT	*5
KKK
	LEA	YDAT,A0
	ADDA.L	PNTY,A0
	CMPI	#-1,(A0)
	BNE.S	PP
	LEA	YDAT,A0
	CLR.L	PNTY
PP
	MOVE	(A0),PNT3

	CMPI.L	#0,FLAGED
	BNE.S	NOAD1
	ADDQ.L	#2,PNTY
NOAD1
	LEA	XDAT,A0
	ADDA.L	PNTX,A0

	CMPI	#-1,(A0)
	BNE.S	PA
	LEA	XDAT,A0
	CLR.L	PNTX
PA
	MOVE	(A0),PNTO
	CMPI.L	#0,FLAGED
	BNE.S	OKQ
	ADDQ.L	#2,PNTX

OK	ADDQ.L	#2,PNTDIST
OKQ	LEA	DIST_DAT,A2	3
	ADDA.L	PNTDIST,A2	7?
	CMPI	#-1,264*2(A2)
	BNE.S	YEP
	CLR.L	PNTDIST
YEP
	MOVE.L	SAVEA7,A7

	MOVE.L	PLUS,D0
	ADD.L	D0,SCREEN1
	MOVE.L	PLUS3,D0
	ADD.L	D0,SCREEN1
	MOVE.B  SCREEN2+1,$FFFF8201.W
	MOVE.B  SCREEN2+2,$FFFF8203.W

	CMPI.L	#0,FLAGED
	BNE.S	RTY
	JSR	AFF_FNT
	JSR	SWAP
	MOVEM.L	D0-A6,-(SP)
	JSR	ZIK2+34
	MOVEM.L	(SP)+,D0-A6
RTY	CMPI.L	#0,FLAGED
	BEQ.S	RTYY
	MOVEM.L	D0-A6,-(SP)
	JSR	ZIK+6
	MOVEM.L	(SP)+,D0-A6
RTYY
;	CMPI.B	#$39,$FFFFFC02.W
;	BEQ	FIN
;	CMPI.B	#2,$FFFFFC02.W
;	BNE.S	RTE2
;	MOVE.L	#0,FLAGED
;	LEA	ACHANGER,A1
;	LEA	2(A1),A1
;	MOVE.L	#8,(A1)
;RTE2	
	ADDQ.L	#1,TEMPS
	CMPI.L	#505+50*5,TEMPS
	BEQ	FIN
	CMPI.L	#505,TEMPS
	BEQ.S	LAMERMICON
	CMPI.B	#$39,$FFFFFC02.W
	BNE.S	RTE
LAMERMICON	MOVE.L	#505,TEMPS
	MOVE.L	#1,FLAGED
	LEA	ACHANGER,A1
	LEA	2(A1),A1
	CLR.L	(A1)
RTE	RTE

FLAGED	DS.L	1
LAMED	MOVE.L	#RTE,$70.W
	MOVEM.L	D0-A6,-(SP)
	LEA	LAME+34,A0
	move.l	SCREENA,a1		5*
	ADDA.L	VALUE2,A1		6*
	LEA	32+2300+160*7(A1),A1	2*

	MOVE	#199,D7
LAMERIZE	
N	SET	0
	REPT	20
	MOVE  N(A0),D0
	MOVE	D0,D1
	NOT	D0
	AND	D0,N(A1)
	AND	D0,N+2(A1)
	AND	D0,N+4(A1)
	AND	D0,N+6(A1)
	OR	D1,N(A1)
	OR	D1,N+2(A1)
	OR	D1,N+4(A1)
	OR	D1,N+6(A1)
	
N	SET	N+8
	ENDR
	LEA	160(A0),A0
	LEA	230(A1),A1
	DBF	D7,LAMERIZE
	MOVEQ	#$10,D0
	JSR	ZIK
	LEA	CHANGE_IT,A0
	MOVE	#$4EF9,(A0)+
	MOVE.L	#VB4,(A0)+
	MOVEM.L	(SP)+,D0-A6
	MOVE.L	#VBLR,$70.W
IFF	JMP	IFF
FIN	
	MOVE	#$2700,SR
	jmp	$500.w
	even

VB2	

N	SET	0
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#$07400630,$FFFF8252.W
	MOVE.L	#$05200410,$FFFF8256.W
	MOVE.L	#$03000200,$FFFF825A.W
	MOVE	#$0100,$FFFF825E.W

	DCB	88-11-3-12-5-5-22,$4E71
	
;	MOVEM.L	IMAGE+2,D0-D7	21*
;	MOVEM.L	D0-D7,$FFFF8240.W	19*

	MOVE.L	#ICI,A7
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDA	(A2),A0		3
	MOVE.L	SAVEA2,A2
	
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
	
ICI	
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
;	NOP
;	NOP
	LEA	160(A5),A5
	MOVEM.L	D1-D4,(A6)	10

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI2,A7
;	LEA	16*9(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#2,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
	
ICI2
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
;	NOP
;	NOP
	LEA	160(A5),A5
	MOVEM.L	D1-D4,(A6)	10

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI3,A7
;	LEA		16*9(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#4,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-2-5,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
ICI3
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
;	NOP
;	NOP
	LEA	160(A5),A5
	MOVEM.L	D1-D4,(A6)	10

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI4,A7
;	LEA		16*9(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#6,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
ICI4
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	15,$2090
	NOP
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	2,$2090
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
;	NOP
;	NOP
	LEA	160(A5),A5
	MOVEM.L	D1-D4,(A6)	10

;N	SET	0
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	LEA	-160*4(A5),A5
	MOVE.L	#ICI5,A7
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#8,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-2-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
ICI5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	88-12,$4E71
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	10,$4E71
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
;	NOP
;	NOP
	LEA	160(A5),A5
	MOVEM.L	D1-D4,(A6)	10

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI6,A7
;	LEA	-640(A5),A5
;	LEA	16*9(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADD.L	#10,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
ICI6
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	88-12,$4E71
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	10,$4E71
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
;	NOP
;	NOP
	LEA	160(A5),A5
	MOVEM.L	D1-D4,(A6)	10

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI7,A7
;	LEA	16*9(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADD.L	#12,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
ICI7
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	88-12,$4E71
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	10,$4E71
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
;	NOP
;	NOP
	LEA	160(A5),A5
	MOVEM.L	D1-D4,(A6)	10

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI8,A7
;	LEA	16*9(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADD.L	#14,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL
ICI8
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	MOVEM.L	16*9(A5),D1-D4	12
	DCB	88-12,$4E71
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	DCB	10,$4E71
	ADDA	(A2)+,A5
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	LEA	160(A5),A5
;	NOP
;	NOP
	MOVEM.L	D1-D4,(A6)	10

;N	SET	0
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2
	ADD.L	#2*8,A2
	CMPI	#$FFFF,16(A2)

	BEQ.S	GO_LET	2
	DCB	5,$4E71
	BRA.S	POL	3

GO_LET
	LEA	TEXTE,A2	3
	DCB	4,$4E71
;	;10
POL	
	MOVE.L	A2,MEM_LET	5
	MOVE.L	SAVEA2,A2
	LEA	-29440(A1),A1
	LEA	-29440(A1),A1

	MOVE.L	#ICIB,A7
	LEA	-160*4(A5),A5
;	LEA	16*9(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-42-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
	
ICIB
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI2B,A7
	LEA	16*10(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#2,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
	
ICI2B
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI3B,A7
	LEA		16*10(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#4,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-2-5-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
ICI3B
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI4B,A7
	LEA		16*10(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#6,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
ICI4B
;N	SET	0
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	LEA	-160*4(A5),A5
	LEA		16*10(A5),A5
	MOVE.L	#ICI5B,A7
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADDQ.L	#8,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
ICI5B

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI6B,A7
;	LEA	-640(A5),A5
	LEA	16*10(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADD.L	#10,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
ICI6B

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI7B,A7
	LEA	16*10(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADD.L	#12,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-6,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
ICI7B

	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	MOVE.L	#ICI8B,A7
	LEA	16*10(A5),A5
	MOVEM.L	N(A5),D1-D4
;	LEA	16(A5),A5
	MOVE.L	#IMAGE+34,A0	3
	MOVE.L	A2,SAVEA2
	MOVE.L	MEM_LET,A2		5
	ADD.L	#14,A2
	ADDA	(A2),A0		3
	DCB	88-11-3-12-5-5-4-2,$4E71
	MOVE.L	SAVEA2,A2
	MOVE.B	#0,(A3)
	MOVE	A3,(A3)
;	DCB	13-3,$4E71
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)
	MOVE	A4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	BUFFER_FULL2
ICI8B
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	LEA	-160*4(A5),A5
	LEA	16*10(A5),A5
	MOVEM.L	N(A5),D1-D4	12
	DCB	88-12-2-2,$4E71
	MOVE.b	#0,(A3)
	MOVE	a4,(A3)
	ADDA	(A2)+,A5
	MOVEM.L	D1-D4,(A6)	10
	MOVE	a4,(A4)
	MOVE.B	#0,(A4)
	DCB	12-3,$4E71
	JMP	VB3

AFF_FNT
 	ADDQ.L	#1,PNT
	CMPI.L	#5,PNT
	BNE.S	OKAY
	MOVE.L	#1,PNT
OKAY	CMPI.L	#1,PNT
	BEQ.S	PART1
	CMPI.L	#2,PNT
	BEQ.S	PART1B
	CMPI.L	#3,PNT
	BEQ.S	PART2
	MOVE.L	#APART2B,GLOUBI
	RTS
PART1	MOVE.L	#1,CNN
	RTS
PART1B	MOVE.L	#APART1B,GLOUBI	
	RTS	
PART2	MOVE.L	#APART2,GLOUBI	
	RTS	
	
APART2
	move.l	#IMAGE+34+32*160,A0	3
	move.l	MEM_LET,a2		5
	ADDA	(a2),a0		3

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+		6
	MOVE.L	INC+4(A0),(A1)+		6
INC	SET	INC+160
	LEA	222(A1),A1		2
	ENDR

	move.l	#IMAGE+34+32*160,a0	3
	move.l	MEM_LET,a2		5
	ADDQ.L	#2,A2	3		2
	ADDA	(a2),a0			3

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+		6
	MOVE.L	INC+4(A0),(A1)+		6
INC	SET	INC+160
	LEA	222(A1),A1		2
	ENDR

	move.l	#IMAGE+34+32*160,a0	3
	move.l	MEM_LET,a2		5
	ADDQ.L	#4,A2			2
	ADDA	(a2),a0			3

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+		6
	MOVE.L	INC+4(A0),(A1)+		6
INC	SET	INC+160
	LEA	222(A1),A1		2
	ENDR

	move.l	#IMAGE+34+32*160,a0	3
	move.l	MEM_LET,a2		5
	ADDQ.L	#6,A2			2
	ADDA	(a2),a0			3

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+		6
	MOVE.L	INC+4(A0),(A1)+		6
INC	SET	INC+160
	LEA	222(A1),A1		2
	ENDR
	
	move.l	#IMAGE+34+32*160,a0
	move.l	MEM_LET,a2
	ADDQ.L	#8,A2			
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR

	move.l	#IMAGE+34+32*160,a0
	move.l	MEM_LET,a2
	ADD.L	#10,A2
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR

	
	move.l	#IMAGE+34+32*160,a0
	move.l	MEM_LET,a2
	ADD.L	#12,A2
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR

	move.l	#IMAGE+34+32*160,a0
	move.l	MEM_LET,a2
	ADD.L	#14,A2
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR


;	T=3691+4
		
	RTS

APART1B	
	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDA	(a2),a0		3


INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDQ.L	#2,A2		3
	ADDA	(a2),a0		3

INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDQ.L	#4,A2		3
	ADDA	(a2),a0		3

INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDQ.L	#6,A2		3
	ADDA	(a2),a0		3

INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADDQ.L	#8,A2
	ADDA	(a2),a0

INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR

	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADD.L	#10,A2
	ADDA	(a2),a0

INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR


	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADD.L	#12,A2
	ADDA	(a2),a0

INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR

	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADD.L	#14,A2
	ADDA	(a2),a0

INC	SET	0
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR



;	3693
	RTS
APART2B	
	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDA	(a2),a0		3


INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDQ.L	#2,A2		3
	ADDA	(a2),a0		3

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDQ.L	#4,A2		3
	ADDA	(a2),a0		3

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0	3
	move.l	MEM_LET,a2	5
	ADDQ.L	#6,A2		3
	ADDA	(a2),a0		3

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+	6
	MOVE.L	INC+4(A0),(A1)+	6
INC	SET	INC+160
	LEA	222(A1),A1	2
	ENDR

	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADDQ.L	#8,A2
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR

	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADD.L	#10,A2
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR


	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADD.L	#12,A2
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR

	move.l	#IMAGE+34,a0
	move.l	MEM_LET,a2
	ADD.L	#14,A2
	ADDA	(a2),a0

INC	SET	8
	REPT	32
	MOVE.L	INC(A0),(A1)+
	MOVE.L	INC+4(A0),(A1)+
INC	SET	INC+160
	LEA	222(A1),A1
	ENDR


;	3693
	RTS



SET_SCR:	MOVE.L	#BUFFERSCR,D0
	AND.L	#$FFFFFF00,D0
	MOVE.L	D0,SCREEN1
	MOVE.L	D0,SCREEN
	ADD.L	#128000,D0
	MOVE.L	D0,SCREEN2
	MOVE.L	D0,SCREENA
	RTS

SWAP
	move.l	SCREEN1,d0
	move.l	SCREEN2,SCREEN1
	move.l	d0,SCREEN2

	move.l	SCREEN,d0
	move.l	SCREENA,SCREEN
	move.l	d0,SCREENA

	move.l	VALUE,d0
	move.l	VALUE2,VALUE
	move.l	d0,VALUE2

	move.l	DATAPNT,d0
	move.l	DATAPNT2,DATAPNT
	move.l	d0,DATAPNT2
	rts
		

NOTHING	
	DCB	115/5,$2090
	DCB	2,$4E71
	RTS

H70
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	DCB	85/5,$2090
	DCB	4,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
	DCB	2,$2090
	DCB	3,$4E71
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	NOP			 
	RTS	=4 NOPS
H44
;	MOVE.B	D3,(A4)
	NOP
;	MOVE.B	D4,(A4)
	DCB	90/5,$2090
	DCB	3,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
	DCB	2,$2090
	DCB	3,$4E71
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	NOP			 
	RTS	=4 NOPS
H24
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	DCB	85/5,$2090
	DCB	2,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
	DCB	2,$2090
	DCB	3,$4E71
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	REPT	1+2
	NOP			 
	ENDR
	RTS	=4 NOPS
H2
;	MOVE.B	D3,(A4)
	NOP
;	MOVE.B	D4,(A4)
	DCB	90/5,$2090
	DCB	1,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
	DCB	2,$2090
	DCB	3,$4E71
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	REPT	1+2
	NOP			 
	ENDR
	RTS	=4 NOPS
H80
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	DCB	35/5,$2090
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	DCB	45/5,$2090
	DCB	4,$4E71
	MOVE.B	D4,(A3)
	MOVE.B	D3,(A3)
	DCB	2,$2090
	DCB	3,$4E71
	MOVE.B	D3,(A4)
	NOP
	MOVE.B	D4,(A4)
	NOP			 
	RTS

INCRUSTE
	CLR.L	PNTI
	MOVE	#16,OFFSET
	CLR.L	LIGNES
	CLR.L	TM
	CLR.L	D0
	
	LEA	BUFFER,A0
	LEA	INSTRUCTIONS,A1
	LEA	BUFFER_FULL,A2

BOUCLE	MOVE	(A1),D2
	MOVE	2(A1),D1
	MOVE	4(A1),D0
	CMP	(A0),D0
	BEQ.S	THATS_IT
	CMPI	#$4E75,(A0)
	BEQ	THE_END
	CMPI	#$ABCD,D0
	BEQ	PROBLEME_NUMERO_UN
	LEA	6*2(A1),A1
	BRA.S	BOUCLE
THATS_IT
	CMPI.L	#0,TM
	BNE.S	PAS_OVER_GAUCHE
	MOVE.L	#$388C18BC,(A2)+
	MOVE	#$0000,(A2)+
	MOVE.L	#$4CED001E,(A2)+
	MOVE	OFFSET,(A2)+
	ADD	#16,OFFSET
	MOVE	#$DADA,(A2)+
	MOVE.L	#5+12+3,TM
PAS_OVER_GAUCHE
	CMPI.L	#93,TM
	BLE	PARTIE_UN
	CMPI.L	#111,TM
	BLE.S	PARTIE_DEUX
;	CMPI.L	#128,TM
;	BLE.S	PARTIE_TROIS

PARTIE_TROIS
	MOVE.L	TM,D4
	ADD.L	D1,D4
	CMPI.L	#128,D4
	BGT.S	TOUJOURS_TROP_GRAND	SI=ALORS CA RENTRE
	BRA	CA_RENTRE
TOUJOURS_TROP_GRAND
	MOVE.L	#128,D4
	MOVE.L	TM,D5
	SUB.L	D5,D4
	CMPI.L	#0,D4
	BEQ.S	DECIDEMENT_PAS_DE_NOP
	SUBQ.L	#1,D4
NOPZ	MOVE	#$4E71,(A2)+
	DBF	D4,NOPZ
DECIDEMENT_PAS_DE_NOP	
JJ	MOVE.L	#$388C18BC,(A2)+
	MOVE	#$0000,(A2)+
	MOVE.L	#$4CED001E,(A2)+
	MOVE	OFFSET,(A2)+
	MOVE	#$DADA,(A2)+
	MOVE.L	#5+12+3,TM
	ADDQ.L	#1,LIGNES
	ADD	#16,OFFSET
	BRA	CA_RENTRE

PARTIE_DEUX
	MOVE.L	TM,D4
	ADD.L	D1,D4
	CMPI.L	#111,D4
	BGT.S	ENCORE_TROP_GRAND	SI=ALORS CA RENTRE
	BRA	CA_RENTRE
ENCORE_TROP_GRAND
	MOVEQ.L	#111,D4
	MOVE.L	TM,D5
	SUB.L	D5,D4
	CMPI.L	#0,D4
	BEQ.S	TOUJOURS_PAS_DE_NOP
	SUBQ.L	#1,D4
NOPX	MOVE	#$4E71,(A2)+
	DBF	D4,NOPX
TOUJOURS_PAS_DE_NOP	
	MOVE.L	#$388C18BC,(A2)+
	MOVE	#$0000,(A2)+
	MOVE.L	#$48D6001E,(A2)+
	MOVE.L	#$4E714E71,(A2)+
	MOVE.L	#126,TM
	BRA	JJ
	
PARTIE_UN
	MOVE.L	TM,D4
	ADD.L	D1,D4
	CMPI.L	#93,D4
	BGT.S	TROP_GRAND	SI=ALORS CA RENTRE
	BRA.S	CA_RENTRE
TROP_GRAND
	MOVEQ.L	#93,D4
	MOVE.L	TM,D5
	SUB.L	D5,D4
	CMPI.L	#0,D4
	BEQ.S	PAS_DE_NOP
	SUBQ.L	#1,D4
NOPY	MOVE	#$4E71,(A2)+
	DBF	D4,NOPY
PAS_DE_NOP	
	MOVE.L	#$16BC0000,(A2)+
	MOVE	#$368C,(A2)+
	MOVE.L	#98,TM
CA_RENTRE	
	SUBQ	#1,D2
ZCI	MOVE	(A0)+,(A2)+
	DBF	D2,ZCI
	ADD.L	D1,TM
	LEA	INSTRUCTIONS,A1
	BRA	BOUCLE

THE_END
	JSR	NOPS_QUI_RESTENT
	
	BRA	TERMINE

PROBLEME_NUMERO_UN
	BRA	TERMINE
PROBLEME_NUMBER_TWO
	MOVE	#$4ED7,(A2)+
	RTS

NOPS_QUI_RESTENT
	CMPI.L	#124,TM
	BGT.S	PROBLEME_NUMBER_TWO

	CMPI.L	#93,TM
	BEQ.S	MILIEU
	CMPI.L	#111,TM
	BEQ.S	OUT_DR
	CMPI.L	#124,TM
	BEQ.S	OUT
	MOVE	#$4E71,(A2)+
	ADDQ.L	#1,TM
	BRA.S	NOPS_QUI_RESTENT
MILIEU	MOVE.L	#$16BC0000,(A2)+
	MOVE	#$368C,(A2)+
	ADDQ.L	#5,TM
	BRA.S	NOPS_QUI_RESTENT
OUT_DR	MOVE.L	#$388C18BC,(A2)+
	MOVE	#$0000,(A2)+
	MOVE.L	#$48D6001E,(A2)+
	ADD.L	#5+10,TM
	BRA.S	NOPS_QUI_RESTENT
OUT	MOVE	#$4E75,(A2)+
	RTS
	
TERMINE	CMPI.L	#0,PNT
	BEQ.S	NOTSOON
	JMP	CESTFINI
NOTSOON	MOVE.L	#1,PNT
	CLR.L	LIGNES
	CLR.L	TM
	CLR.L	D0
	MOVE	#16,OFFSET
	LEA	BUFFER2,A0
	LEA	INSTRUCTIONS,A1
	LEA	BUFFER_FULL2,A2
	JMP	BOUCLE


BUFFER
INC	SET	0
	REPT	32
	MOVE.B	INC+9(A0),(A1)		4
	MOVE.B	INC+11(A0),2(A1)	5
	MOVE.B	INC+13(A0),4(A1)	5
	MOVE.B	INC+15(A0),6(A1)	5
INC	SET	INC+160
	LEA	230(A1),A1	2
	ENDR
	RTS
BUFFER2
INC	SET	0
	REPT	32
	MOVE.B	INC(A0),1(A1)	5
	MOVE.B	INC+2(A0),3(A1)	5
	MOVE.B	INC+4(A0),5(A1)	5
	MOVE.B	INC+6(A0),7(A1)	5
INC	SET	INC+160
	LEA	230(A1),A1	2
	ENDR
	RTS

	SECTION	DATA
ZIK	INCBIN	COUNT.SND
ZIK2	INCBIN	NEXT3.SND
IMAGE	INCBIN	A:\BLOCS3.PI1
TEXTE	INCBIN	DATA2.TXT
LAME	INCBIN	LAME.PI1

PALETTE	DC.W	$000,$700,$773,$650,$540,$430,$320,$210
	DC.W	$100,$111,$222,$333,$444,$555,$666,$777

TEXTE1	DC.B	'INSTRUCTION NON RECONNUE.',0
TEXTE2	DC.B	'CA ROULE.',0
TEXTE3	DC.B	'PROB DS LES NOPS DE FIN.',0
	EVEN

INSTRUCTIONS
 DC	4,6,$217C,$FFFF,$FFFF,$0008	;MOVE.L	#$FFFFFFFF,8(A0)
 DC	2,4,$12A8,$0008,$0000,$0000	;MOVE.B	INC+9(A0),(A1)
 DC	3,5,$1368,$0008,$0008,$0000	;MOVE.B	INC+9(A0),8(A1)
 DC	2,2,$43E9,$00E6,$0000,$0000	;LEA	230(A1),A1
 DC	9,9,$ABCD			;FIN

DATA	
	DC.L	-256,NOTHING,NOTHING,NOTHING,NOTHING,NOTHING,NOTHING
	DC.L	256,H44,H44,H44,H44,H44,H44
	DC.L	0,H24,H2,H2,H2,H2,NOTHING
	DC.L	0,H24,NOTHING,NOTHING,NOTHING,NOTHING,NOTHING
	DC.L	0,H80,H44,H2,H70,NOTHING,NOTHING
	DC.L	0,H44,H2,H2,NOTHING,NOTHING,NOTHING
	DC.L	0,H24,H24,NOTHING,NOTHING,NOTHING,NOTHING
	DC.L	0,H80,H70,H2,H2,H70,NOTHING
	DC.L	0,H70,H2,H2,H2,NOTHING,NOTHING
	DC.L	0,H24,H24,H24,NOTHING,NOTHING,NOTHING
	DC.L	0,H44,H44,H2,H2,H2,H2
	DC.L	0,H44,H44,NOTHING,NOTHING,NOTHING,NOTHING
	DC.L	256,H24,H24,H24,H24,NOTHING,NOTHING
	DC.L	-256,H80,H80,H80,H44,H44,NOTHING
	DC.L	0,H70,H44,H2,NOTHING,NOTHING,NOTHING
	DC.L	0,H24,H24,H24,H24,H24,NOTHING
	DC.L	0,H44,H44,H44,H2,H2,NOTHING
	DC.L	0,H70,H24,H44,H2,NOTHING,NOTHING
	DC.L	0,H24,H24,H24,H24,H24,H24
	DC.L	0,H80,H70,H70,H24,H2,H70

	DC.L	256,H70,H70,H24,H2,H2,NOTHING
	DC.L	0,H80,H2,H2,H2,H2,NOTHING	
	DC.L	-256,H80,NOTHING,NOTHING,NOTHING,NOTHING,NOTHING
	DC.L	512,H70,H70,H44,NOTHING,NOTHING,NOTHING
	DC.L	-512,H80,H80,H80,H80,NOTHING,NOTHING
	DC.L	0,H44,H44,H44,H44,H24,NOTHING
	DC.L	512,H70,H70,H70,H2,NOTHING,NOTHING
	DC.L	-512,H80,H80,H80,H80,H24,NOTHING
	DC.L	0,H44,H44,H44,H44,H24,H24
	
	DC.L	512,H70,H70,H24,H24,H44,NOTHING
	DC.L	-256,H80,H80,H80,H80,H24,H24
	DC.L	0,H2,H2,H2,H2,NOTHING,NOTHING

	DC.L	-1,-1


YDAT	
 DC 320
 DC 352
 DC 400
 DC 448
 DC 496
 DC 544
 DC 592
 DC 0
 DC 48
 DC 96
 DC 144
 DC 192
 DC 240
 DC 288
 DC 320
 DC 368
 DC 416
 DC 448
 DC 496
 DC 528
 DC 576
 DC 608
 DC 16
 DC 48
 DC 80
 DC 128
 DC 160
 DC 192
 DC 224
 DC 256
 DC 288
 DC 320
 DC 336
 DC 368
 DC 400
 DC 416
 DC 448
 DC 464
 DC 480
 DC 512
 DC 528
 DC 544
 DC 560
 DC 576
 DC 576
 DC 592
 DC 608
 DC 608
 DC 624
 DC 624
 DC 624
 DC 624
 DC 624
 DC 624
 DC 624
 DC 624
 DC 624
 DC 624
 DC 608
 DC 608
 DC 592
 DC 576
 DC 560
 DC 544
 DC 528
 DC 512
 DC 496
 DC 480
 DC 464
 DC 432
 DC 416
 DC 384
 DC 368
 DC 336
 DC 304
 DC 272
 DC 240
 DC 208
 DC 176
 DC 144
 DC 112
 DC 80
 DC 48
 DC 0
 DC 608
 DC 560
 DC 528
 DC 480
 DC 448
 DC 400
 DC 352
 DC 320
 DC 272
 DC 224
 DC 176
 DC 128
 DC 80
 DC 32
 DC 0
 DC 592
 DC 544
 DC 496
 DC 448
 DC 400
 DC 352
 DC 304
 DC 256
 DC 208
 DC 160
 DC 112
 DC 64
 DC 16
 DC 608
 DC 560
 DC 512
 DC 464
 DC 416
 DC 368
 DC 336
 DC 288
 DC 240
 DC 208
 DC 160
 DC 112
 DC 80
 DC 32
 DC 0
 DC 608
 DC 560
 DC 528
 DC 496
 DC 464
 DC 416
 DC 384
 DC 368
 DC 336
 DC 304
 DC 272
 DC 240
 DC 224
 DC 192
 DC 176
 DC 160
 DC 128
 DC 112
 DC 96
 DC 80
 DC 64
 DC 48
 DC 32
 DC 32
 DC 16
 DC 16
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 16
 DC 16
 DC 32
 DC 32
 DC 48
 DC 64
 DC 80
 DC 96
 DC 112
 DC 128
 DC 144
 DC 176
 DC 192
 DC 224
 DC 240
 DC 272
 DC 304
 DC 320
 DC 352
 DC 384
 DC 416
 DC 448
 DC 480
 DC 528
 DC 560
 DC 592
 DC 0
 DC 32
 DC 64
 DC 112
 DC 160
 DC 192
 DC 240
 DC 288
 DC 320
 DC 368
 DC 416
 DC 464
 DC 512
 DC 544
 DC 592
 DC 0
 DC 48
 DC 96
 DC 144
 DC 192
 DC 240
 DC 288

 DC -1
XDAT	
 DC 7680
 DC 0
 DC 2560
 DC 6400
 DC 8960
 DC 1280
 DC 5120
 DC 7680
 DC 1280
 DC 3840
 DC 6400
 DC 0
 DC 2560
 DC 5120
 DC 8960
 DC 1280
 DC 3840
 DC 7680
 DC 0
 DC 2560
 DC 5120
 DC 7680
 DC 1280
 DC 3840
 DC 6400
 DC 8960
 DC 1280
 DC 3840
 DC 6400
 DC 8960
 DC 1280
 DC 3840
 DC 6400
 DC 8960
 DC 1280
 DC 3840
 DC 6400
 DC 7680
 DC 0
 DC 2560
 DC 5120
 DC 6400
 DC 8960
 DC 0
 DC 2560
 DC 3840
 DC 6400
 DC 7680
 DC 0
 DC 1280
 DC 2560
 DC 5120
 DC 6400
 DC 7680
 DC 8960
 DC 0
 DC 2560
 DC 3840
 DC 5120
 DC 5120
 DC 6400
 DC 7680
 DC 8960
 DC 0
 DC 0
 DC 1280
 DC 2560
 DC 2560
 DC 3840
 DC 3840
 DC 5120
 DC 5120
 DC 5120
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 6400
 DC 5120
 DC 5120
 DC 5120
 DC 3840
 DC 3840
 DC 2560
 DC 2560
 DC 1280
 DC 1280
 DC 0
 DC 8960
 DC 7680
 DC 6400
 DC 6400
 DC 5120
 DC 3840
 DC 2560
 DC 1280
 DC 8960
 DC 7680
 DC 6400
 DC 5120
 DC 3840
 DC 1280
 DC 0
 DC 8960
 DC 6400
 DC 5120
 DC 2560
 DC 1280
 DC 8960
 DC 6400
 DC 5120
 DC 2560
 DC 0
 DC 8960
 DC 6400
 DC 3840
 DC 1280
 DC 8960
 DC 6400
 DC 3840
 DC 1280
 DC 8960
 DC 6400
 DC 3840
 DC 1280
 DC 8960
 DC 6400
 DC 3840
 DC 1280
 DC 8960
 DC 5120
 DC 2560
 DC 0
 DC 7680
 DC 3840
 DC 1280
 DC 8960
 DC 6400
 DC 2560
 DC 0
 DC 7680
 DC 3840
 DC 1280
 DC 7680
 DC 5120
 DC 2560
 DC 8960
 DC 6400
 DC 2560
 DC 0
 DC 7680
 DC 3840
 DC 1280
 DC 7680
 DC 5120
 DC 2560
 DC 8960
 DC 6400
 DC 3840
 DC 0
 DC 7680
 DC 3840
 DC 1280
 DC 8960
 DC 6400
 DC 2560
 DC 0
 DC 7680
 DC 3840
 DC 1280
 DC 8960
 DC 6400
 DC 3840
 DC 0
 DC 7680
 DC 5120
 DC 2560
 DC 0
 DC 7680
 DC 5120
 DC 2560
 DC 0
 DC 7680
 DC 5120
 DC 2560
 DC 0
 DC 8960
 DC 6400
 DC 3840
 DC 1280
 DC 0
 DC 7680
 DC 5120
 DC 3840
 DC 1280
 DC 0
 DC 7680
 DC 6400
 DC 3840
 DC 2560
 DC 1280
 DC 8960
 DC 7680
 DC 6400
 DC 5120
 DC 3840
 DC 2560
 DC 1280
 DC 0
 DC 8960
 DC 7680
 DC 6400
 DC 5120
 DC 3840
 DC 3840
 DC 2560
 DC 1280
 DC 1280
 DC 0
 DC 0
 DC 8960
 DC 8960
 DC 8960
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 7680
 DC 8960
 DC 8960
 DC 0
 DC 0
 DC 1280
 DC 1280
 DC 2560
 DC 2560
 DC 3840
 DC 5120
 DC 6400
 DC 7680
 DC 7680
 DC 8960
 DC 0
 DC 1280
 DC 2560
 DC 3840
 DC 6400
 DC 7680
 DC 8960
 DC 0
 DC 2560
 DC 3840
 DC 5120
 DC 7680
 DC 8960
 DC 1280
 DC 2560
 DC 5120
 DC 7680
 DC 8960
 DC 1280
 DC 3840
 DC 5120
 DC 7680
 DC 0
 DC 2560
 DC 5120
 DC 7680
 DC 8960
 DC 1280
 DC 3840
 DC 6400
 DC 8960
 DC 2560
 DC 5120
 DC 7680
 DC 0
 DC 2560
 DC 5120
 DC 7680
 DC 1280
 DC 3840
 DC 6400
 DC 8960
 DC 2560
 DC 5120
 DC 7680
 DC 1280
 DC 3840
 DC 6400
 DC 0
 DC 2560
 DC 5120
 DC 8960
 DC 1280
 DC 5120
 DC 7680
 DC 0
 DC 3840
 DC 6400

 DC -1

DIST_DAT	
 DC 5120
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 8960
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 8960
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 8960
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC -8960
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC -8960
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC -8960
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC -8960
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC -8960
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC -8960
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC -8960
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC -8960
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC -8960
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC -8960
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC -8960
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 1280
 DC 0
 DC -8960
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC -8960
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC -8960
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC -8960
 DC 0
 DC 1280
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC -8960
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC -8960
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC -8960
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 1280
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC 8960
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 8960
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC -1280
 DC 0
 DC 8960
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC -1280
 DC 0
 DC -1280
 DC 8960
 DC -1280
 DC 0
 DC -1280
 DC -1280

 DC -1

POS1	INCBIN	POSI.DAT

	SECTION	BSS
 	
F_PILE	DS.L 	128	
D_PILE	DS.L 	1	
PNT	DS.L	1
CNN	DS.L	1
GLOUBI	DS.L	1
GLOUBI2	DS.L	1
SCREENA	DS.L	1
SCREEN	DS.L	1
SCREEN1	DS.L	1
SCREEN2	DS.L	1
BUF	DS.B	(8*32)*8
DATAPNT2	DS.L	1
DATAPNT	DS.L	1
PNTO	DS	1
PNT3	DS	1
PNTY	DS.L	1
PNTX	DS.L	1
PNTDIST	DS.L	1
VALUE2	DS.L	1
VALUE	DS.L	1
ASCREEN2	DS.L	1
ASCREEN1	DS.L	1
PLUS	DS.L	1
PLUS3	DS.L	1
SAVEA2	DS.L	1
SAVEA7	DS.L	1
MEM_LET	DS.L	1
PART_AFF	DS.L	1
	DS.B	256
BUFFERSCR	DS.B	64000*4
	ds.b	256
OFFSET	DS.L	1
LIGNES	DS.L	1
TM	DS.L	1	
PNTI	DS.L	1
TEMPS	DS.L	1
BUFFER_FULL
	DS.B	1200
	EVEN
BUFFER_FULL2
	DS.B	1200
	EVEN
