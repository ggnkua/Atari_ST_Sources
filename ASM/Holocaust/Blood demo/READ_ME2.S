
RIP.PRG: mode d'emploi.
¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹¹
C'est un vieux ripper que j'utilisais il y a bien longtemps pour r‚cup‚rer
les images du jeu 'EXPLORA'... il m'a servi par la suite pour r‚cup‚rer les
images visualis‚es sous Speed Of Light, vu que la version que j'avais ne
sauvegardait qu'une seule des 2 images tram‚es obtenues - et toujours la
meme ‚videmment!

Cette version ne vous sera d'aucune utilit‚ pour r‚cup‚rer les images de
vos d‚mos favorites, vu qu'en g‚n‚ral elles d‚tournent toutes le reset
et/ou d‚gagent la Vbl systeme, effacent toute la ram dŠs le d‚but, etc..
Bref: c'est pas avec ce petit programme que vous pourrez faire des folies.

Mais bon, il m'a souvent ‚t‚ utile, donc il n'est pas completement sans
int‚ret.

L'accŠs au ripper s'opŠre en appuyant sur TAB ou en faisant un reset.

Touches:
Les fleches pour scroller (en hardscroll+full haut/bas, la classe! huhu)
Espace pour stopper net le scroll.
+ et - pour scroller lentement. (1 ligne/vbl)
ESC r‚tablit la palette qui ‚tait active au moment de l'accŠs au ripper.
TAB active une palette en d‚grad‚ de gris.
F1 sauve une image au format PI1, d‚limit‚e par la zone bleue.
(vous pouvez sauver 10 images … la suite, elles se num‚rotent automati-
-quement)
F2 retourne au programme dans lequel vous ‚tiez avant d'appuyer sur TAB
pour acc‚der au ripper. (TrŠs utile!!!) Attention! Si vous acc‚dez au 
ripper par un reset, vous ne pouvez plus revenir au programme de d‚part.
(les coders comprendront sans doute o— est le probleme!)
F10 efface les vecteurs reset. (juste pour ‚viter d'‚teindre complŠtement
sa machine... j'suis un flemmard.)

Vala vala, un bo ripper pratique et efficace.

