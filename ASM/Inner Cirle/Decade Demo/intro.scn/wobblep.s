	dc.w	$0700,$0710,$0720,$0730,$0740,$0750,$0760,$0770 
	dc.w	$0670,$0570,$0470,$0370,$0270,$0170,$0070,$0071 
	dc.w	$0072,$0073,$0074,$0075,$0076,$0077,$0167,$0257 
	dc.w	$0347,$0437,$FFFF 
