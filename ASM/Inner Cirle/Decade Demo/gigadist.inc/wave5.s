	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	2*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	5*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	2*1536
	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	2*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	5*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	2*1536
	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	2*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	5*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	2*1536
	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	1536*0
	DC.W	0
	DC.W	1536*0
	DC.W	0
	DC.W	1536*0
	DC.W	0
	DC.W	1536*0
	DC.W	0
	DC.W	1536*1
	DC.W	0
	DC.W	1536*2
	DC.W	0
	DC.W	1536*2
	DC.W	0
	DC.W	1536*3
	DC.W	0
	DC.W	1536*4
	DC.W	0
	DC.W	1536*5
	DC.W	0
	DC.W	1536*6
	DC.W	0
	DC.W	1536*8
	DC.W	0
	DC.W	1536*9
	DC.W	0
	DC.W	1536*10
	DC.W	0
	DC.W	1536*11
	DC.W	0
	DC.W	1536*12
	DC.W	0
	DC.W	1536*13
	DC.W	0
	DC.W	1536*13
	DC.W	0
	DC.W	1536*14
	DC.W	0
	DC.W	1536*15
	DC.W	0
	DC.W	1536*15
	DC.W	0
	DC.W	1536*15
	DC.W	0
	DC.W	1536*15
	DC.W	0
	DC.W	1536*15
	DC.W	0
	DC.W	1536*15
	DC.W	0
	DC.W	1536*15
	DC.W	0
	DC.W	1536*14
	DC.W	0
	DC.W	1536*14
	DC.W	0
	DC.W	1536*13
	DC.W	0
	DC.W	1536*12
	DC.W	0
	DC.W	1536*11
	DC.W	0
	DC.W	1536*10
	DC.W	0
	DC.W	1536*9
	DC.W	0
	DC.W	1536*8
	DC.W	0
	DC.W	1536*7
	DC.W	0
	DC.W	1536*6
	DC.W	0
	DC.W	1536*5
	DC.W	0
	DC.W	1536*4
	DC.W	0
	DC.W	1536*3
	DC.W	0
	DC.W	1536*2
	DC.W	0
	DC.W	1536*1
	DC.W	0
	DC.W	1536*1
	DC.W	0
	DC.W	1536*0
	DC.W	0
	DC.W	1536*0
	DC.W	0
	DC.W	1536*0
