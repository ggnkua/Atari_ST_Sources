

No, there is no source code for this .. Write it yourselves .. But this
is THE best ever method of designing your maps and TOTALLY invaluable
for any serious coding .. 

                     USE IT !! ......... 
   
                                                            Mat of UNT