			The ASCII Code
			~-~-~-~-~-~-~-

DEC  HEX  ASCII  CTRL      DEC   HEX    ASCII 	 DEC   HEX    ASCII

0    00   NUL    @         43    2B     +     	 85    55     U
1    01   SOH    A         44    2C     '     	 86    56     V
2    02   STX    B         45    2D     -     	 87    57     W
3    04   ETX    C         46    2E     .     	 88    58     X
4    04   EOT    D         47    2F     /     	 89    59     Y
5    05   ENQ    E         48    30     0     	 90    5A     Z
6    06   ACK    F         49    31     1     	 91    5B     [
7    07   BEL    G         50    32     2     	 92    5C     \
8    08   BS     H         51    33     3     	 93    5D     ]
9    09   HF     I         52    34     4     	 94    5E     ^
10   0A   LF     J         53    35     5     	 95    5F     _
11   0B   VT     K         54    36     6     	 96    60      
12   OC   FF     L         55    37     7     	 97    61     a
13   0D   CR     M         56    38     8     	 98    62     b
14   0E   SO     N         57    39     9     	 99    63     c
15   OF   SI     O         58    3A     :    	100    64     d
16   10   DLE    P         59    3B     ;    	101    65     e
17   11   DC1    Q         60    3C     <    	102    66     f
18   12   DC2    R         61    3D     =    	103    67     g
19   13   DC3    S         62    3E     >    	104    68     h
20   14   DC4    T         63    3F     ?    	105    69     i
21   15   NAK    U         64    40     @    	106    6A     j
22   16   SYN    V         65    41     A    	107    6B     k
23   17   ETB    W         66    42     B    	108    6C     l
24   18   CAN    X         67    43     C    	109    6D     m
25   19   EM     Y         68    44     D    	110    6E     n
26   1A   SUB    Z         69    45     E    	111    6F     o
27   1B   ESC    [         70    46     F    	112    70     p
28   1C   FS     \         71    47     G    	113    71     q
29   1D   GS     ]         72    48     H    	114    72     r
30   1E   RS     ^         73    49     I    	115    73     s
31   1F   US     _         74    4A     J    	116    74     t
32   20   Space            75    4B     K    	117    75     u
33   21   !                76    4C     L    	118    76     v
34   22   "                77    4D     M    	119    77     w
35   23   #                78    4E     N    	120    78     x
36   24   $                79    4F     O    	121    79     y
37   25   %                80    50     P    	122    7A     z
38   26   &                81    51     Q    	123    7B     {
39   27   '                82    52     R    	124    7C     |
40   28   (                83    53     S    	125    7D     }
41   29   )                84    54     T    	126    7E     ~
42   2A   *                                  	127    7F     DEL



Typed in by Tony Bennett '90
