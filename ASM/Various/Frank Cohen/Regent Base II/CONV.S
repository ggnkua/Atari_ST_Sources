 DC.B  10 , 10 , 13 , 10 , 13 , 10 , 10 , 10 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  70 , 85 , 78 , 67 , 84 , 73 , 79 , 78 , 90 
 DC.B  32 , 58 , 32 , 84 , 104 , 101 , 32 , 70 , 117 
 DC.B  110 , 99 , 116 , 105 , 111 , 110 , 32 , 75 , 101 
 DC.B  121 , 32 , 76 , 97 , 98 , 101 , 108 , 105 , 110 
 DC.B  103 , 32 , 83 , 121 , 115 , 116 , 101 , 109 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 89 , 111 , 117 , 114 , 32 , 70 , 117 , 110 
 DC.B  99 , 116 , 105 , 111 , 110 , 122 , 32 , 108 , 97 
 DC.B  98 , 101 , 108 , 32 , 97 , 112 , 112 , 101 , 97 
 DC.B  114 , 115 , 32 , 98 , 101 , 108 , 111 , 119 , 32 
 DC.B  116 , 104 , 105 , 115 , 32 , 109 , 101 , 115 , 115 
 DC.B  97 , 103 , 101 , 46 , 32 , 32 , 67 , 117 , 116 
 DC.B  32 , 111 , 117 , 116 , 32 , 116 , 104 , 101 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  108 , 97 , 98 , 101 , 108 , 32 , 97 , 110 , 100 
 DC.B  32 , 102 , 111 , 108 , 100 , 32 , 119 , 104 , 101 
 DC.B  114 , 101 , 32 , 105 , 110 , 100 , 105 , 99 , 97 
 DC.B  116 , 101 , 100 , 46 , 32 , 32 , 71 , 101 , 110 
 DC.B  116 , 108 , 121 , 32 , 105 , 110 , 115 , 101 , 114 
 DC.B  116 , 32 , 116 , 104 , 101 , 32 , 99 , 117 , 116 
 DC.B  32 , 108 , 97 , 98 , 101 , 108 , 32 , 105 , 110 
 DC.B  116 , 111 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 116 , 104 , 101 , 32 , 112 , 108 
 DC.B  97 , 115 , 116 , 105 , 99 , 32 , 102 , 117 , 110 
 DC.B  99 , 116 , 105 , 111 , 110 , 32 , 107 , 101 , 121 
 DC.B  32 , 115 , 116 , 97 , 110 , 100 , 46 , 13 , 10 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 95 , 95 , 95 , 124 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 124 
 DC.B  95 , 95 , 95 , 32 , 67 , 117 , 116 , 32 , 72 
 DC.B  101 , 114 , 101 , 13 , 10 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 13 , 10 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 13 , 10 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 13 , 10 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 13 , 10 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  95 , 95 , 95 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 95 , 95 
 DC.B  95 , 32 , 70 , 111 , 108 , 100 , 32 , 72 , 101 
 DC.B  114 , 101 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 96 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 96 , 13 , 10 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 96 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 96 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  96 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 96 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 96 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 96 , 13 , 10 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 96 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 96 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  95 , 95 , 95 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 124 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 124 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 124 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 124 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 95 
 DC.B  95 , 95 , 32 , 67 , 117 , 116 , 32 , 72 , 101 
 DC.B  114 , 101 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 124 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 124 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 13 , 10 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 49 
 DC.B  50 , 51 , 52 , 53 , 54 , 55 , 56 , 57 , 48 
 DC.B  49 , 50 , 51 , 52 , 53 , 54 , 55 , 56 , 57 
 DC.B  48 , 49 , 50 , 51 , 52 , 53 , 54 , 55 , 56 
 DC.B  57 , 48 , 49 , 50 , 51 , 52 , 53 , 54 , 55 
 DC.B  56 , 57 , 48 , 49 , 50 , 51 , 52 , 53 , 54 
 DC.B  55 , 56 , 57 , 48 , 49 , 50 , 51 , 52 , 53 
 DC.B  54 , 55 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 49 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 50 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  51 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 52 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 53 , 13 , 10 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 13 , 10 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 95 , 95 , 95 , 124 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 124 , 95 , 95 , 95 , 32 , 67 
 DC.B  117 , 116 , 32 , 72 , 101 , 114 , 101 , 13 , 10 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 13 , 10 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 95 , 95 , 95 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 95 , 95 , 95 , 32 , 70 , 111 , 108 
 DC.B  100 , 32 , 72 , 101 , 114 , 101 , 13 , 10 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 96 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 96 
 DC.B  13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 96 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 96 , 13 , 10 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 96 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 96 , 13 , 10 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 96 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 96 
 DC.B  13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 96 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 96 , 13 , 10 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 95 , 95 , 95 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  124 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 124 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 124 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  124 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 95 , 95 , 95 , 32 , 67 , 117 
 DC.B  116 , 32 , 72 , 101 , 114 , 101 , 13 , 10 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 124 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 124 , 13 , 10 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 13 , 10 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  67 , 111 , 110 , 116 , 97 , 99 , 116 , 32 , 121 
 DC.B  111 , 117 , 114 , 32 , 108 , 111 , 99 , 97 , 108 
 DC.B  32 , 100 , 101 , 97 , 108 , 101 , 114 , 32 , 111 
 DC.B  114 , 32 , 82 , 101 , 103 , 101 , 110 , 116 , 32 
 DC.B  83 , 111 , 102 , 116 , 119 , 97 , 114 , 101 , 32 
 DC.B  116 , 111 , 32 , 112 , 117 , 114 , 99 , 104 , 97 
 DC.B  115 , 101 , 13 , 10 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 97 , 100 , 100 , 105 , 116 , 105 
 DC.B  111 , 110 , 97 , 108 , 32 , 112 , 108 , 97 , 115 
 DC.B  116 , 105 , 99 , 32 , 115 , 116 , 97 , 110 , 100 
 DC.B  115 , 46 , 32 , 32 , 65 , 115 , 107 , 32 , 102 
 DC.B  111 , 114 , 32 , 116 , 104 , 101 , 32 , 108 , 111 
 DC.B  119 , 32 , 112 , 114 , 105 , 99 , 101 , 100 , 32 
 DC.B  70 , 117 , 110 , 99 , 116 , 105 , 111 , 110 , 122 
 DC.B  13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 83 , 117 , 112 , 112 , 108 , 121 , 32 , 80 
 DC.B  97 , 99 , 107 , 97 , 103 , 101 , 46 , 13 , 10 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 13 
 DC.B  10 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 82 
 DC.B  101 , 103 , 101 , 110 , 116 , 32 , 83 , 111 , 102 
 DC.B  116 , 119 , 97 , 114 , 101 , 13 , 10 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 80 , 46 , 79 , 46 
 DC.B  32 , 66 , 111 , 120 , 32 , 49 , 52 , 54 , 50 
 DC.B  56 , 13 , 10 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 76 , 111 , 110 , 103 
 DC.B  32 , 66 , 101 , 97 , 99 , 104 , 44 , 32 , 67 
 DC.B  65 , 32 , 57 , 48 , 56 , 48 , 51 , 45 , 49 
 DC.B  50 , 48 , 56 , 13 , 10 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 32 , 32 , 80 , 104 
 DC.B  111 , 110 , 101 , 58 , 32 , 40 , 50 , 49 , 51 
 DC.B  41 , 32 , 52 , 51 , 57 , 45 , 57 , 54 , 54 
 DC.B  52 , 32 , 32 , 70 , 65 , 88 , 58 , 32 , 40 
 DC.B  50 , 49 , 51 , 41 , 32 , 52 , 51 , 52 , 45 
 DC.B  50 , 51 , 49 , 48 , 13 , 10 , 32 , 32 , 32 
 DC.B  32 , 32 , 32 , 32 , 32 , 13 , 10 , 10 , 10 
 DC.B  10 , 10 , 10 , 10 , 13 , 10 , 13 , 10 , 10 
 DC.B  10 
