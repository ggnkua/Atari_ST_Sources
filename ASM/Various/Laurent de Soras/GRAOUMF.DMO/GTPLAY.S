	text
begin
	bra	relocation
	bra	player_on
	bra	boucle_instrumen
player_on	movem.l	a0-a6/d0-d7,-(a7)
	pea	init_mod_player
	move.w	#$26,-(a7)
	trap	#$e
	addq.l	#6,a7
	movem.l	(a7)+,a0-a6/d0-d7
	rts

relocation	movem.l	a0-a2/d1,-(a7)
	movea.l	20(a7),a0
	move.l	2(a0),d0
	add.l	6(a0),d0
	add.l	14(a0),d0
	adda.l	#$1c,a0
	move.l	a0,d1
	movea.l	a0,a1
	movea.l	a1,a2
	adda.l	d0,a1
	move.l	(a1)+,d0
	adda.l	d0,a2
	add.l	d1,(a2)
	clr.l	d0
relocloop	move.b	(a1)+,d0
	beq.s	reloc_end
	cmp.b	#1,d0
	beq.s	reloc_nxt
	adda.l	d0,a2
	add.l	d1,(a2)
	bra.s	relocloop
reloc_nxt	adda.l	#$fe,a2
	bra.s	relocloop
reloc_end	lea	adr_labels(pc),a0
	move.l	a0,d0
	movem.l	(a7)+,a0-a2/d1
	rts

init_mod_player	movem.l	a0-a6/d0-d7,-(a7)
	bsr	prepare_module
	pea	routine_dsp
	move.l	adrlodnom,-(a7)
	move.w	#$6f,-(a7)
	trap	#$e
	adda.w	#$a,a7
	move.l	d0,routine_dsp_lon
	move.w	#$71,-(a7)
	trap	#$e
	move.w	d0,(a7)
	move.l	routine_dsp_lon,-(a7)
	pea	routine_dsp
	move.w	#$6d,-(a7)
	trap	#$e
	lea	12(a7),a7
	move.l	#$902000,$ffff8930.w
	move.w	#$101,$ffff8934.w
	move.w	#$500,$ffff8900.w
	move.w	#3,$ffff8920.w
	move.b	#$ff,$ffffa203.w
	move.l	#interruption,$3fc.w
	move.b	#1,$ffffa200.w
	clr.w	flag_the_end
wrhst_001	btst	#1,$ffffa202.w
	beq.s	wrhst_001
	move.l	#0,$ffffa204.w
	movem.l	(a7)+,a0-a6/d0-d7
	rts

prepare_module	movem.l	a0-a6/d0-d7,-(a7)
	lea	module_inf1,a1
	lea	module_inf2,a5
	movea.l	1024(a1),a0
	move.w	200(a0),d0
	move.w	d0,nbrvoies
	move.w	d0,0(a5)
	move.w	198(a0),2(a5)
	move.w	202(a0),4(a5)
	move.w	204(a0),6(a5)
	move.l	#sample_vide,0(a1)
	lea	repeatbuffer,a6
	move.w	#$ff,d0
l0008	clr.l	(a6)+
	dbf	d0,l0008
	move.w	196(a0),d1
	tst.w	d1
	beq.s	prepa_pas_instr
prepa_mod_loop4	move.w	d1,-(a7)
	bsr	boucle_instrumen
	addq.l	#2,a7
	subq.w	#1,d1
	bne.s	prepa_mod_loop4
prepa_pas_instr	lea	module_inf1,a1
	lea	info_track,a4
	moveq	#0,d1
	move.w	#$fff,d2
	moveq	#$1f,d0
prepa_mod_loop3	move.w	#1,0(a4)
	move.w	#1,2(a4)
	move.w	#$20ab,4(a4)
	clr.w	6(a4)
	move.w	d1,8(a4)
	eor.w	d2,d1
	eori.w	#$fff,d2
	move.w	#$6b00,10(a4)
	move.l	(a1),12(a4)
	clr.l	16(a4)
	clr.w	20(a4)
	clr.l	22(a4)
	move.l	#2,26(a4)
	move.l	#repeatbuffer,30(a4)
	clr.w	34(a4)
	clr.w	36(a4)
	clr.w	38(a4)
	clr.w	40(a4)
	move.w	#0,42(a4)
	clr.w	46(a4)
	clr.w	44(a4)
	move.w	#$18,48(a4)
	move.w	#$6b00,50(a4)
	clr.w	52(a4)
	clr.w	54(a4)
	clr.w	56(a4)
	move.w	#$30,58(a4)
	move.w	#$1ac0,60(a4)
	clr.b	62(a4)
	clr.b	63(a4)
	clr.b	64(a4)
	clr.b	65(a4)
	clr.b	66(a4)
	clr.b	67(a4)
	clr.b	68(a4)
	clr.b	69(a4)
	move.b	#3,70(a4)
	clr.b	71(a4)
	clr.w	72(a4)
	clr.w	74(a4)
	clr.w	76(a4)
	adda.w	#$4e,a4
	dbf	d0,prepa_mod_loop3
	clr.w	current_track
	clr.w	dsp_plein
	clr.w	8(a5)
	clr.w	10(a5)
	clr.w	12(a5)
	clr.w	16(a5)
	move.w	#6,14(a5)
	move.w	#$ffff,18(a5)
	move.l	#$1000,d0
	divu	0(a5),d0
	move.w	d0,master_vol
	move.w	#$3d7,vblsize
	clr.w	flag_stop_voices
	clr.w	flag_mt_display
	bsr	gestion_partitio
	movem.l	(a7)+,a0-a6/d0-d7
	rts

boucle_instrumen	moveq	#0,d0
	move.w	4(a7),d0
	movem.l	a0-a6/d1-d7,-(a7)
	lea	module_inf1,a1
	move.w	d0,d1
	add.w	d1,d1
	add.w	d1,d1
	lea	([1028,a1],$34.w),a3
	adda.w	d1,a1
	move.w	#$40,d1
	mulu	d0,d1
	adda.l	d1,a3
	lea	repeatbuffer(pc),a6
	swap	d0
	lsr.l	#6,d0
	adda.l	d0,a6
	move.w	#$200,d1
l000d	movea.l	(a1),a2
	adda.l	(a3),a2
	move.l	4(a3),d2
	lsr.l	#1,d2
	subq.l	#1,d2
	tst.l	d2
	bne.s	l0011
	tst.l	(a3)
	bne.s	l0011
	cmpi.w	#2,-8(a3)
	beq.s	l000f
	move.w	#$3ff,d1
	adda.l	-4(a3),a2
	subq.l	#1,a2
l000e	move.b	(a2),(a6)+
	dbf	d1,l000e
	bra.s	l0012
l000f	subq.w	#1,d1
	adda.l	-4(a3),a2
	subq.l	#2,a2
l0010	move.w	(a2),(a6)+
	dbf	d1,l0010
	bra.s	l0012
l0011	move.w	(a2)+,(a6)+
	subq.w	#1,d1
	beq.s	l0012
	subq.l	#1,d2
	bpl.s	l0011
	bra.s	l000d
l0012	movem.l	(a7)+,a0-a6/d1-d7
	rts

interruption	ori.w	#$2700,sr
	movem.l	a0-a6/d0-d7,-(a7)
	tst.w	flag_mt_display(pc)
	beq.s	rdhst_002
	move.l	#$ff000000,$ffff9800.w
rdhst_002	btst	#0,$ffffa202.w
	beq.s	rdhst_002
	move.w	$ffffa206.w,d0
	tst.w	flag_the_end
	beq.s	sendsam_nostop
	move.b	#0,$ffffa200.w
wrhst_003	btst	#1,$ffffa202.w
	beq.s	wrhst_003
	move.l	#8,$ffffa204.w
	tst.w	flag_mt_display(pc)
	beq	sendsam_the_end
	clr.l	$ffff9800.w
	bra	sendsam_the_end
sendsam_nostop	lea	info_track,a0
	move.w	nbrvoies(pc),d1
	move.w	current_track,d0
	move.w	d0,d2
	mulu	#$4e,d2
	adda.w	d2,a0
sendsam_tsttrklo	cmp.w	d0,d1
	beq	sendsam_apuvoi
	tst.w	0(a0)
	beq	sendsam_tsttrknx
	cmpi.l	#2,26(a0)
	bgt.s	l0018
	tst.l	22(a0)
	beq	sendsam_tsttrknx
	move.l	16(a0),d3
	cmp.l	22(a0),d3
	bge.s	sendsam_cst
l0018	tst.w	6(a0)
	bne	sendsam_voieon
	moveq	#0,d5
	move.w	10(a0),d5
	mulu	#$c012,d5
	move.l	#$1ac00000,d2
	moveq	#0,d4
	move.w	4(a0),d4
	mulu.l	d4,d3	d2
	divu.l	d5,d3	d2
	moveq	#0,d5
	move.w	vblsize(pc),d5
	mulu.l	d2,d5
	add.w	d5,20(a0)
	bcc.s	l0019
	addi.l	#$10000,d5
l0019	clr.w	d5
	swap	d5
	cmpi.w	#2,2(a0)
	bne.s	l001a
	add.l	d5,d5
l001a	add.l	16(a0),d5
	cmp.l	22(a0),d5
	ble.s	l001b
	sub.l	22(a0),d5
	divul.l	26(a0),d4	d5
	add.l	22(a0),d4
	move.l	d4,d5
l001b	move.l	d5,16(a0)
sendsam_tsttrknx	addq.w	#1,d0
	adda.w	#$4e,a0
	bra	sendsam_tsttrklo
sendsam_cst	moveq	#0,d4
wrhst_004	btst	#1,$ffffa202.w
	beq.s	wrhst_004
	move.l	#$10,$ffffa204.w
	move.w	6(a0),d4
	mulu	master_vol,d4
wrhst_005	btst	#1,$ffffa202.w
	beq.s	wrhst_005
	move.l	d4,$ffffa204.w
	move.w	8(a0),d4
	lsl.w	#3,d4
	lsl.l	#8,d4
wrhst_006	btst	#1,$ffffa202.w
	beq.s	wrhst_006
	move.l	d4,$ffffa204.w
	moveq	#0,d4
	movea.l	30(a0),a1
	move.w	(a1),d4
	lsl.l	#8,d4
	cmpi.w	#2,2(a0)
	beq.s	wrhst_007
	clr.w	d4
wrhst_007	btst	#1,$ffffa202.w
	beq.s	wrhst_007
	move.l	d4,$ffffa204.w
	clr.l	22(a0)
	bra.s	sendsam_tsttrknx
sendsam_voieon	move.l	22(a0),d1
	add.l	26(a0),d1
	cmp.l	16(a0),d1
	bgt.s	l0023
	subq.l	#2,d1
	move.l	d1,16(a0)
l0023	lea	$ffffa204.w,a2
	lea	$ffffa206.w,a3
	lea	$ffffa202.w,a4
wrhst_008	btst	#1,$ffffa202.w
	beq.s	wrhst_008
	move.l	#1,$ffffa204.w
	moveq	#0,d1
	move.w	vblsize(pc),d1
wrhst_009	btst	#1,$ffffa202.w
	beq.s	wrhst_009
	move.l	d1,$ffffa204.w
	move.w	6(a0),d1
	mulu	master_vol,d1
wrhst_010	btst	#1,$ffffa202.w
	beq.s	wrhst_010
	move.l	d1,$ffffa204.w
	move.w	8(a0),d1
	lsl.w	#3,d1
	lsl.l	#8,d1
wrhst_011	btst	#1,$ffffa202.w
	beq.s	wrhst_011
	move.l	d1,$ffffa204.w
	moveq	#0,d1
	move.w	10(a0),d1
	mulu	#$c012,d1
	move.l	#$1ac00000,d2
	moveq	#0,d4
	move.w	4(a0),d4
	mulu.l	d4,d3	d2
	divu.l	d1,d3	d2
	swap	d2
	moveq	#0,d1
	move.w	d2,d1
	swap	d2
	move.w	d2,d3
	lsl.l	#8,d3
wrhst_012	btst	#1,$ffffa202.w
	beq.s	wrhst_012
	move.l	d1,$ffffa204.w
wrhst_013	btst	#1,$ffffa202.w
	beq.s	wrhst_013
	move.l	d3,$ffffa204.w
	move.w	20(a0),d3
	lsl.l	#8,d3
wrhst_014	btst	#1,$ffffa202.w
	beq.s	wrhst_014
	move.l	d3,$ffffa204.w
	moveq	#0,d1
	move.w	vblsize(pc),d1
	mulu.l	d2,d1
	add.w	d1,20(a0)
	bcc.s	l002b
	addi.l	#$10000,d1
l002b	clr.w	d1
	swap	d1
	cmpi.w	#2,2(a0)
	beq	wrhst_024
wrhst_015	btst	#1,$ffffa202.w
	beq.s	wrhst_015
	move.l	#1,$ffffa204.w
	addq.l	#1,d1
	btst	#0,19(a0)
	beq.s	sendsam_8even
	move.l	22(a0),d3
	addq.l	#1,d3
	cmp.l	16(a0),d3
	bne.s	l002d
	movea.l	30(a0),a1
	addq.l	#1,a1
	bra.s	l002e
l002d	movea.l	12(a0),a1
	adda.l	16(a0),a1
l002e	move.l	d1,d2
	subq.l	#2,d2
	lsr.l	#1,d2
	subq.l	#1,d1
	addq.l	#1,16(a0)
wrhst_016	btst	#1,$ffffa202.w
	beq.s	wrhst_016
	move.l	d2,$ffffa204.w
wrhst_017	btst	#1,$ffffa202.w
	beq.s	wrhst_017
	move.w	#1,$ffffa206.w
wrhst_018	btst	#1,$ffffa202.w
	beq.s	wrhst_018
	move.b	(a1)+,$ffffa207.w
	bra.s	sendsam_8transfe
sendsam_8even	move.l	d1,d2
	subq.l	#1,d2
	lsr.l	#1,d2
wrhst_019	btst	#1,$ffffa202.w
	beq.s	wrhst_019
	move.l	d2,$ffffa204.w
wrhst_020	btst	#1,$ffffa202.w
	beq.s	wrhst_020
	move.l	#0,$ffffa204.w
sendsam_8transfe	move.l	d1,d2
	subq.l	#1,d1
	add.l	16(a0),d1
	cmp.l	22(a0),d1
	ble.s	l0036
	sub.l	22(a0),d1
	divul.l	26(a0),d6	d1
	add.l	22(a0),d6
	bra.s	sendsam_8avantfi
l0036	move.l	d1,d6
sendsam_8avantfi	move.l	16(a0),d3
	move.l	22(a0),d4
	cmp.l	d4,d3
	beq.s	sendsam_8boucle
	movea.l	12(a0),a1
	adda.l	d3,a1
	add.l	d2,d3
	add.l	26(a0),d4
	cmp.l	d4,d3
	blt	sendsam_8noloop
	sub.l	16(a0),d4
	beq.s	sendsam_8boucle
	sub.l	d4,d2
	subq.l	#1,d4
	lsr.l	#1,d4
	move.w	d4,d3
	not.w	d3
	andi.w	#$f,d3
	lsr.w	#4,d4
wrhst_021	btst	#1,$ffffa202.w
	beq.s	wrhst_021
	jmp	(sendsam_8loopt2,d3.w*2)
sendsam_8loopt2	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	dbf	d4,sendsam_8loopt2
	tst.l	d2
	bne.s	sendsam_8boucle
	move.l	d6,16(a0)
	bra	sendsam_next
sendsam_8boucle	movea.l	30(a0),a1
	move.l	#$400,d3
	cmp.l	d3,d2
	bgt.s	l003b
	move.l	d2,d3
l003b	sub.l	d3,d2
	move.l	d3,d5
	subq.l	#1,d3
	lsr.l	#1,d3
	move.w	d3,d4
	not.w	d4
	andi.w	#$f,d4
	lsr.w	#4,d3
wrhst_022	btst	#1,$ffffa202.w
	beq.s	wrhst_022
	jmp	(sendsam_8loopt3,d4.w*2)
sendsam_8loopt3	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	dbf	d3,sendsam_8loopt3
	tst.l	d2
	beq.s	sendsam_8fin
	divul.l	26(a0),d4	d5
	add.l	22(a0),d4
	move.l	d4,16(a0)
	bra	sendsam_8avantfi
sendsam_8fin	move.l	d6,16(a0)
	bra	sendsam_next
sendsam_8noloop	subq.l	#1,d2
	lsr.l	#1,d2
	move.w	d2,d4
	not.w	d4
	andi.w	#$f,d4
	lsr.w	#4,d2
wrhst_023	btst	#1,$ffffa202.w
	beq.s	wrhst_023
	jmp	(sendsam_8loopt1,d4.w*2)
sendsam_8loopt1	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	dbf	d2,sendsam_8loopt1
	move.l	d6,16(a0)
	bra	sendsam_next
wrhst_024	btst	#1,$ffffa202.w
	beq.s	wrhst_024
	move.l	#2,$ffffa204.w
	move.l	d1,d2
	add.l	d2,d2
	addq.l	#2,d2
wrhst_025	btst	#1,$ffffa202.w
	beq.s	wrhst_025
	move.l	d1,$ffffa204.w
sendsam_16avantf	move.l	16(a0),d3
	movea.l	12(a0),a1
	adda.l	d3,a1
	add.l	d2,d3
	move.l	22(a0),d4
	add.l	26(a0),d4
	cmp.l	d4,d3
	blt	sendsam_16noloop
	sub.l	16(a0),d4
	beq.s	sendsam_16boucle
	sub.l	d4,d2
	lsr.l	#1,d4
	subq.l	#1,d4
	move.w	d4,d3
	not.w	d3
	andi.w	#$f,d3
	lsr.w	#4,d4
wrhst_026	btst	#1,$ffffa202.w
	beq.s	wrhst_026
	jmp	(sendsam_16loopt2,d3.w*2)
sendsam_16loopt2	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	dbf	d4,sendsam_16loopt2
	tst.l	d2
	bne.s	sendsam_16boucle
	move.l	22(a0),d1
	add.l	26(a0),d1
	subq.l	#2,d1
	move.l	d1,16(a0)
	bra	sendsam_next
sendsam_16boucle	movea.l	30(a0),a1
	move.l	#$400,d3
	cmp.l	d3,d2
	bgt.s	l0048
	move.l	d2,d3
l0048	sub.l	d3,d2
	move.l	d3,d5
	lsr.l	#1,d3
	subq.l	#1,d3
	move.w	d3,d4
	not.w	d4
	andi.w	#$f,d4
	lsr.w	#4,d3
wrhst_027	btst	#1,$ffffa202.w
	beq.s	wrhst_027
	jmp	(sendsam_16loopt3,d4.w*2)
sendsam_16loopt3	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	dbf	d3,sendsam_16loopt3
	tst.l	d2
	beq.s	sendsam_16fin
	divul.l	26(a0),d4	d5
	add.l	22(a0),d4
	move.l	d4,16(a0)
	bra	sendsam_16avantf
sendsam_16fin	subq.l	#2,d5
	divul.l	26(a0),d4	d5
	add.l	22(a0),d4
	move.l	d4,16(a0)
	bra.s	sendsam_next
sendsam_16noloop	lsr.w	#1,d2
	subq.w	#1,d2
	move.w	d2,d4
	not.w	d4
	andi.w	#$f,d4
	lsr.w	#4,d2
wrhst_028	btst	#1,$ffffa202.w
	beq.s	wrhst_028
	jmp	(sendsam_16loopt1,d4.w*2)
sendsam_16loopt1	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	move.w	(a1)+,(a3)
	dbf	d2,sendsam_16loopt1
	subq.l	#2,d3
	move.l	d3,16(a0)
sendsam_next	st	dsp_plein
	tst.w	flag_mt_display(pc)
	beq.s	l0050
	move.l	#$ff,$ffff9800.w
l0050	addq.w	#1,d0
	bra.s	sendsam_encore
sendsam_apuvoi	moveq	#0,d0
	moveq	#2,d1
	tst.w	dsp_plein
	bne.s	wrhst_029
	moveq	#4,d1
wrhst_029	btst	#1,$ffffa202.w
	beq.s	wrhst_029
	move.l	d1,$ffffa204.w
	clr.w	dsp_plein
	tst.w	flag_mt_display(pc)
	beq.s	l0053
	move.l	#$ff000000,$ffff9800.w
l0053	bsr	gestion_partitio
	tst.w	flag_mt_display(pc)
	beq.s	sendsam_encore
	clr.l	$ffff9800.w
sendsam_encore	move.w	d0,current_track
sendsam_the_end	movem.l	(a7)+,a0-a6/d0-d7
	rte

gestion_partitio	movem.l	a0-a6/d0-d7,-(a7)
	lea	module_inf2,a0
	lea	module_inf1,a1
	lea	per_table(pc),a5
	move.w	0(a0),nbrvoies
	tst.w	flag_stop_voices(pc)
	beq	gp_new_vbl
	moveq	#$1f,d0
	lea	info_track(pc),a4
	lea	sample_vide(pc),a2
l0057	clr.w	6(a4)
	move.l	a2,12(a4)
	clr.l	16(a4)
	clr.w	20(a4)
	clr.l	22(a4)
	move.l	#2,26(a4)
	move.l	#repeatbuffer,30(a4)
	clr.w	34(a4)
	clr.w	36(a4)
	clr.w	38(a4)
	clr.w	40(a4)
	move.w	#0,42(a4)
	clr.w	46(a4)
	clr.w	44(a4)
	move.w	#$18,48(a4)
	move.w	#$6b00,50(a4)
	clr.w	52(a4)
	clr.w	54(a4)
	clr.w	56(a4)
	move.w	#$30,58(a4)
	move.w	#$1ac0,60(a4)
	clr.b	62(a4)
	clr.b	63(a4)
	clr.b	64(a4)
	clr.b	65(a4)
	clr.b	66(a4)
	clr.b	67(a4)
	clr.b	68(a4)
	clr.b	69(a4)
	adda.w	#$4e,a4
	dbf	d0,l0057
	clr.w	flag_stop_voices
gp_new_vbl	move.w	18(a0),d0
	addq.w	#1,d0
	cmp.w	14(a0),d0
	blt.s	l005d
	moveq	#0,d0
	tst.w	16(a0)
	beq.s	l0059
	subq.w	#1,16(a0)
	bne.s	l005d
l0059	move.w	12(a0),d1
	move.w	10(a0),d3
	mulu	2(a0),d3
	add.w	d1,d3
	mulu	0(a0),d3
	lea	([1036,a1],d3.l*4),a2
	lea	0(a2,d3.l),a2
	lea	l00fa,a3
	move.w	0(a0),d3
	subq.w	#1,d3
l005a	move.b	(a2)+,(a3)
	move.b	(a2)+,2(a3)
	move.w	(a2)+,3(a3)
	move.b	(a2)+,6(a3)
	adda.w	#$4e,a3
	dbf	d3,l005a
	addq.w	#1,d1
	cmp.w	2(a0),d1
	blt.s	l005c
	moveq	#0,d1
	move.w	8(a0),d2
	addq.w	#1,d2
	cmp.w	4(a0),d2
	blt.s	l005b
	move.w	6(a0),d2
l005b	move.w	d2,8(a0)
	move.w	([1032,a1],d2.w*2),10(a0)
l005c	move.w	d1,12(a0)
l005d	move.w	d0,18(a0)
	lea	info_track,a3
	move.w	0(a0),d7
	subq.w	#1,d7
	tst.w	d0
	bne	pas_seulement_1e
	tst.w	16(a0)
	bne	pas_seulement_1e
premvbl_loop	move.w	34(a3),d0
	move.w	36(a3),d1
	move.w	38(a3),d2
	tst.w	d1
	bne.s	instrum
	tst.w	d0
	bne.s	pas_instrument
	tst.w	d2
	bne	effets1
	tst.w	40(a3)
	beq	fx_fin1
	bra	effets1
instrum	move.w	d2,d3
	andi.w	#$ff00,d3
	cmp.w	#$900,d3
	beq	effets1_no_vol
	tst.w	d1
	beq.s	pas_instrument
	move.w	d1,42(a3)
	moveq	#$40,d3
	mulu	d1,d3
	lea	([1028,a1],d3.w,$3c.w),a2
	move.l	(a2),44(a3)
	move.w	-18(a2),d3
	bmi.s	l0060
	move.w	d3,8(a3)
l0060	move.w	44(a3),d3
	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d3.w*2),54(a3)
	lsl.w	#3,d3
	move.w	d3,52(a3)
pas_instrument	tst.w	d0
	beq	effets1
	move.w	d2,d3
	andi.w	#$ff00,d3
	cmp.w	#$300,d3
	beq.s	tone_p
	cmp.w	#$500,d3
	beq.s	tone_p
	cmp.w	#$600,d3
	beq.s	tone_p
	cmp.w	#$ab00,d3
	beq.s	tone_p
	cmp.w	#$1800,d3
	blt.s	pas_tone_p
	cmp.w	#$1b00,d3
	bgt.s	pas_tone_p
tone_p	move.w	d0,58(a3)
	move.w	d0,d3
	subi.w	#$18,d3
	lsl.w	#3,d3
	add.w	46(a3),d3
	move.w	(0.b,a5,d3.w*2),60(a3)
	move.w	40(a3),d3
	beq	fx_fin1
	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d3.w*2),54(a3)
	lsl.w	#3,d3
	move.w	d3,52(a3)
	bra	fx_fin1
pas_tone_p	move.w	d0,48(a3)
	move.w	d0,58(a3)
	move.w	d0,d3
	subi.w	#$18,d3
	lsl.w	#3,d3
	add.w	46(a3),d3
	add.w	d3,d3
	move.w	0(a5,d3.w),50(a3)
	move.w	0(a5,d3.w),60(a3)
	moveq	#0,d3
	move.w	d2,d4
	andi.w	#$f000,d4
	cmp.w	#$9000,d4
	bne.s	fin_ppart
	move.w	d2,d3
	subi.w	#$9000,d3
	lsl.l	#8,d3
fin_ppart	move.l	d3,16(a3)
	clr.w	20(a3)
	move.w	42(a3),d1
	move.l	(0,a1,d1.w*4),12(a3)
	moveq	#0,d3
	move.w	d1,d3
	swap	d3
	lsr.l	#6,d3
	addi.l	#repeatbuffer,d3
	move.l	d3,30(a3)
	moveq	#$40,d3
	mulu	d1,d3
	lea	([1028,a1],d3.w),a4
	move.w	44(a4),2(a3)
	move.w	46(a4),4(a3)
	lea	52(a4),a4
	move.l	(a4)+,d3
	move.l	(a4),d4
	move.l	d4,d5
	add.l	d3,d5
	cmp.l	#2,d5
	bgt.s	l0065
	move.l	-8(a4),d3
	moveq	#2,d4
	subq.l	#2,d3
	tst.l	d3
	bpl.s	l0065
	moveq	#0,d3
l0065	move.l	d3,22(a3)
	move.l	d4,26(a3)
effets1	move.w	40(a3),d3
	beq.s	effets1_no_vol
	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d3.w*2),54(a3)
	lsl.w	#3,d3
	move.w	d3,52(a3)
effets1_no_vol	move.w	d2,d3
	lsr.w	#8,d3
	move.w	d2,d4
	cmp.w	#$20,d3
	blt.s	l0068
	cmp.w	#$a0,d3
	blt.s	l0069
	cmp.w	#$af,d3
	bgt.s	l0069
	subi.w	#$80,d3
l0068	andi.w	#$ff,d4
	jmp	([fx_table_de_saut,d3.w*4])
l0069	lsr.b	#4,d3
	andi.w	#$fff,d4
	cmp.b	#2,d3
	bne.s	l006b
	cmp.w	#$100,d4
	ble.s	l006a
	move.w	#$100,d4
l006a	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d4.w*2),54(a3)
	lsl.w	#3,d4
	move.w	d4,52(a3)
	bra	fx_fin1
l006b	cmp.b	#3,d3
	bne.s	l006d
	cmp.w	#$800,d4
	ble.s	l006c
	move.w	#$800,d4
l006c	move.w	d4,54(a3)
	lea	vexp_2_lin(pc),a4
	move.w	(0.b,a4,d4.w*2),52(a3)
	bra	fx_fin1
l006d	cmp.b	#4,d3
	bne.s	l006e
	move.w	d4,8(a3)
	bra	fx_fin1
l006e	cmp.b	#5,d3
	bne.s	l0070
	cmp.w	#$fff,d4
	ble.s	l006f
	move.w	#$fff,d4
l006f	move.w	d4,master_vol
	bra.s	fx_fin1
l0070	cmp.b	#6,d3
	bne.s	l0071
	lea	vexp_2_lin_maste(pc),a4
	move.w	(0.b,a4,d4.w*2),master_vol
	bra.s	fx_fin1
l0071	cmp.b	#7,d3
	bne.s	l0073
	move.w	d4,d5
	andi.w	#$ff,d5
	bne.s	l0072
	moveq	#$ff,d5
l0072	move.w	d5,72(a3)
	lsr.w	#8,d4
	beq.s	fx_fin1
	move.b	d4,70(a3)
	clr.b	71(a3)
	bra.s	fx_fin1
l0073	cmp.b	#8,d3
	bne.s	fx_fin1
	move.w	d4,d5
	andi.w	#$ff,d5
	move.w	#$ffff,72(a3)
	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d5.w*2),54(a3)
	lsl.w	#3,d5
	move.w	d5,52(a3)
	lsr.w	#8,d4
	beq.s	fx_fin1
	move.b	d4,70(a3)
	clr.b	71(a3)
fx_fin1	adda.w	#$4e,a3
	dbf	d7,premvbl_loop
	lea	info_track,a3
	move.w	0(a0),d7
	subq.w	#1,d7
pas_seulement_1e	move.w	34(a3),d0
	move.w	36(a3),d1
	move.w	38(a3),d2
	beq	fx_fin_normale
	move.w	d2,d3
	lsr.w	#8,d3
	move.w	d2,d4
	cmp.w	#$20,d3
	blt.s	l0076
	cmp.w	#$a0,d3
	blt.s	l0077
	cmp.w	#$af,d3
	bgt.s	l0077
	subi.w	#$80,d3
l0076	andi.w	#$ff,d4
	jmp	([l00db,d3.w*4])
l0077	lsr.b	#4,d3
	andi.w	#$fff,d4
	cmp.b	#7,d3
	beq.s	l0078
	cmp.b	#8,d3
	bne	fx_fin_normale
l0078	tst.w	72(a3)
	beq	fx_fin_normale
	tst.b	71(a3)
	bne	l007b
	tst.w	d1
	beq.s	l007a
	move.w	d1,42(a3)
	moveq	#$40,d4
	mulu	d1,d4
	lea	([1028,a1],d4.w),a4
	move.w	62(a4),46(a3)
	move.w	44(a4),2(a3)
	move.w	46(a4),4(a3)
	tst.w	42(a4)
	bmi.s	l0079
	move.w	42(a4),8(a3)
l0079	cmp.b	#8,d3
	beq.s	l007a
	move.w	60(a4),44(a3)
	move.w	44(a3),d3
	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d3.w*2),54(a3)
	lsl.w	#3,d3
	move.w	d3,52(a3)
l007a	clr.l	16(a3)
	clr.w	20(a3)
	subq.w	#1,72(a3)
l007b	move.b	71(a3),d4
	addq.b	#1,d4
	cmp.b	70(a3),d4
	bne.s	l007c
	moveq	#0,d4
l007c	move.b	d4,71(a3)
	bra	fx_fin_normale
fx_fin_normale	move.w	52(a3),6(a3)
	move.w	50(a3),10(a3)
fx_fin_speciale	adda.w	#$4e,a3
	dbf	d7,pas_seulement_1e
	movem.l	(a7)+,a0-a6/d0-d7
	rts

fx_set_ftune	move.w	d4,d5
	andi.w	#$f,d4
	lsr.w	#4,d5
	sub.w	d4,d5
	move.w	d5,46(a3)
	tst.w	d0
	beq	fx_fin1
	move.w	d0,d3
	subi.w	#$18,d3
	lsl.w	#3,d3
	add.w	d5,d3
	move.w	(0.b,a5,d3.w*2),50(a3)
	bra	fx_fin1
	move.w	d4,76(a3)
	bra	fx_fin1
fx_pos_jump	cmp.w	4(a0),d4
	bge	fx_fin1
	move.w	d4,8(a0)
	move.w	([1032,a1],d4.w*2),10(a0)
	clr.w	12(a0)
	bra	fx_fin1
fx_set_vib_wave	andi.b	#3,d4
	move.b	d4,65(a3)
	bra	fx_fin1
fx_set_trem_wave	andi.b	#3,d4
	move.b	d4,69(a3)
	bra	fx_fin1
fx_break_pat	move.w	8(a0),d3
	tst.w	12(a0)
	beq.s	l0085
	addq.w	#1,d3
	cmp.w	4(a0),d3
	blt.s	l0084
	move.w	6(a0),d3
l0084	move.w	d3,8(a0)
	move.w	([1032,a1],d3.w*2),10(a0)
l0085	cmp.w	2(a0),d4
	blt.s	l0086
	moveq	#0,d4
l0086	move.w	d4,12(a0)
	bra	fx_fin1
fx_set_global_sp	tst.w	d4
	beq	fx_fin1
	cmp.w	#$1f,d4
	bgt.s	l0088
	move.w	d4,14(a0)
	move.w	#$3d7,vblsize
	bra	fx_fin1
l0088	lea	tempo_table(pc),a4
	move.w	(-128.b,a4,d4.w*4),14(a0)
	move.w	(-126.b,a4,d4.w*4),vblsize
	bra	fx_fin1
fx_set_nbr_of_fr	tst.w	d4
	beq	fx_fin1
	move.w	d4,14(a0)
	bra	fx_fin1
fx_set_fine_spee	add.w	d4,d4
	beq	fx_fin1
	addi.w	#$2d7,d4
	move.w	d4,vblsize
	bra	fx_fin1
fx_fine_porta_up	move.w	50(a3),d5
	lsl.w	#4,d4
	sub.w	d4,d5
	cmp.w	#$300,d5
	bge.s	l008c
	move.w	#$300,d5
l008c	move.w	d5,50(a3)
	bra	fx_fin1
fx_fine_porta_do	ext.l	d4
	lsl.w	#4,d4
	add.w	50(a3),d4
	cmp.l	#$7f3f,d4
	ble.s	l008e
	move.w	#$7f3f,d4
l008e	move.w	d4,50(a3)
	bra	fx_fin1
fx_predelay	move.w	d4,74(a3)
	bra	fx_fin1
fx_fine_v_sldown	neg.w	d4
fx_fine_v_slup_l	bsr	fx_do_v_slide_l
	bra	fx_fin1
fx_fine_mv_sldow	neg.w	d4
fx_fine_mv_slup_	bsr	fx_do_mv_slide_l
	bra	fx_fin1
fx_pattern_delay	move.w	d4,16(a0)
	bra	fx_fin1
fx_arpeggio	moveq	#0,d5
	move.w	18(a0),d5
	divu	#3,d5
	swap	d5
	tst.w	d5
	beq	fx_fin_normale
	cmp.b	#1,d5
	bne.s	l0096
	lsr.b	#4,d4
l0096	andi.b	#$f,d4
	beq	fx_fin_normale
	add.w	48(a3),d4
	subi.w	#$18,d4
	lsl.w	#3,d4
	add.w	46(a3),d4
	move.w	(0.b,a5,d4.w*2),d4
	cmp.w	#$300,d4
	bge.s	l0097
	move.w	#$300,d4
l0097	move.w	d4,10(a3)
	move.w	52(a3),6(a3)
	bra	fx_fin_speciale
fx_porta_up	lsl.w	#4,d4
fx_extra_fine_po	sub.w	d4,50(a3)
	cmpi.w	#$300,50(a3)
	bge	fx_fin_normale
	move.w	#$300,50(a3)
	bra	fx_fin_normale
fx_porta_down	lsl.w	#4,d4
l009b	ext.l	d4
	add.w	50(a3),d4
	cmp.l	#$7f3f,d4
	ble.s	l009c
	move.w	#$7f3f,d4
l009c	move.w	d4,50(a3)
	bra	fx_fin_normale
fx_tone_porta	bsr.s	fx_do_tone_porta
	bra	fx_fin_normale
fx_extra_fine_to	bsr.s	fx_do_very_fine_
	bra	fx_fin_normale
fx_do_tone_porta	lsl.w	#4,d4
fx_do_very_fine_	tst.w	d4
	bne.s	l00a1
	move.w	56(a3),d4
l00a1	move.w	d4,56(a3)
	move.w	50(a3),d5
	move.w	60(a3),d6
	cmp.w	d6,d5
	beq.s	l00a4
	blt.s	l00a2
	sub.w	d4,d5
	cmp.w	d6,d5
	bge.s	l00a3
	move.w	d6,d5
	move.w	58(a3),48(a3)
	bra.s	l00a3
l00a2	add.w	d4,d5
	cmp.w	d6,d5
	ble.s	l00a3
	move.w	d6,d5
	move.w	58(a3),48(a3)
l00a3	move.w	d5,50(a3)
l00a4	rts

fx_vibrato	bsr.s	fx_do_vibrato
	bra	fx_fin_speciale
fx_do_vibrato	tst.w	d4
	beq.s	l00a7
	move.w	d4,d5
	andi.w	#$f,d4
	move.b	d4,64(a3)
	lsr.w	#2,d5
	andi.w	#$3c,d5
	move.b	d5,62(a3)
l00a7	moveq	#0,d3
	move.b	63(a3),d3
	move.b	65(a3),d4
	andi.b	#3,d4
	beq.s	l00aa
	subq.b	#1,d4
	bne.s	l00a9
	add.b	d3,d3
	bpl.s	l00a8
	not.b	d3
l00a8	add.b	d3,d3
	bra.s	l00ab
l00a9	move.w	#$ff,d3
	bra.s	l00ab
l00aa	lsr.w	#2,d3
	andi.w	#$1f,d3
	lea	sin_table(pc),a4
	move.w	(0.b,a4,d3.w*2),d3
l00ab	move.b	64(a3),d4
	andi.w	#$f,d4
	mulu	d4,d3
	lsr.w	#3,d3
	move.w	50(a3),d4
	tst.b	63(a3)
	bpl.s	l00ac
	add.w	d3,d4
	bra.s	l00ad
l00ac	sub.w	d3,d4
l00ad	move.b	62(a3),d3
	add.b	d3,63(a3)
	move.w	d4,10(a3)
	move.w	52(a3),6(a3)
	rts

fx_tone_porta_vi	bsr	fx_do_tone_porta
	moveq	#0,d4
	bsr	fx_do_vibrato
	bra	fx_fin_speciale
fx_vib_tone_port	move.w	d4,-(a7)
	moveq	#0,d4
	bsr	fx_do_tone_porta
	move.w	d4,(a7)+
	bsr	fx_do_vibrato
	bra	fx_fin_speciale
fx_tremolo	tst.w	d4
	beq.s	l00b1
	move.w	d4,d5
	andi.w	#$f,d4
	move.b	d4,68(a3)
	lsr.w	#2,d5
	andi.w	#$3c,d5
	move.b	d5,66(a3)
l00b1	moveq	#0,d3
	move.b	67(a3),d3
	move.b	69(a3),d4
	andi.b	#3,d4
	beq.s	l00b4
	subq.b	#1,d4
	bne.s	l00b3
	add.b	d3,d3
	bpl.s	l00b2
	not.b	d3
l00b2	add.b	d3,d3
	bra.s	l00b5
l00b3	move.w	#$ff,d3
	bra.s	l00b5
l00b4	lsr.w	#2,d3
	andi.w	#$1f,d3
	lea	sin_table(pc),a4
	move.w	(0.b,a4,d3.w*2),d3
l00b5	move.b	68(a3),d4
	andi.w	#$f,d4
	mulu	d4,d3
	lsr.w	#1,d3
	move.w	52(a3),d4
	tst.b	67(a3)
	bmi.s	l00b6
	add.w	d3,d4
	cmp.w	#$800,d4
	ble.s	l00b7
	move.w	#$800,d4
	bra.s	l00b7
l00b6	sub.w	d3,d4
	bpl.s	l00b7
	moveq	#0,d4
l00b7	move.b	66(a3),d3
	add.b	d3,67(a3)
	move.w	d4,6(a3)
	move.w	50(a3),10(a3)
	bra	fx_fin_speciale
fx_delay	tst.w	74(a3)
	bmi	fx_fin_normale
	bne	l00bc
	tst.w	d1
	beq.s	l00ba
	move.w	d1,42(a3)
	moveq	#$40,d3
	mulu	d1,d3
	lea	([1028,a1],d3.w),a4
	move.l	60(a4),44(a3)
	move.w	44(a4),2(a3)
	move.w	46(a4),4(a3)
	move.w	42(a4),d3
	bmi.s	l00b9
	move.w	d3,8(a3)
l00b9	move.w	44(a3),d3
	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d3.w*2),54(a3)
	lsl.w	#3,d3
	move.w	d3,52(a3)
l00ba	tst.w	d0
	beq	fx_fin_normale
	move.w	d0,48(a3)
	move.w	d0,58(a3)
	move.w	d0,d3
	subi.w	#$18,d3
	lsl.w	#3,d3
	add.w	46(a3),d3
	add.w	d3,d3
	move.w	0(a5,d3.w),50(a3)
	move.w	0(a5,d3.w),60(a3)
	clr.l	16(a3)
	clr.w	20(a3)
	move.w	42(a3),d1
	move.l	(0,a1,d1.w*4),12(a3)
	moveq	#0,d3
	move.w	d1,d3
	swap	d3
	lsr.l	#6,d3
	addi.l	#repeatbuffer,d3
	move.l	d3,30(a3)
	moveq	#$40,d3
	mulu	d1,d3
	lea	([1028,a1],d3.w,$34.w),a4
	move.l	(a4)+,d3
	move.l	(a4),d4
	move.l	d4,d5
	add.l	d3,d5
	cmp.l	#2,d5
	bne.s	l00bb
	move.l	-8(a4),d3
	subq.l	#2,d3
	moveq	#2,d4
l00bb	move.l	d3,22(a3)
	move.l	d4,26(a3)
	move.w	40(a3),d3
	beq.s	l00bc
	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d3.w*2),54(a3)
	lsl.w	#3,d3
	move.w	d3,52(a3)
l00bc	subq.w	#1,74(a3)
	bra	fx_fin_normale
fx_note_cut	tst.w	76(a3)
	bmi	fx_fin_normale
	bne.s	l00be
	clr.w	52(a3)
	clr.w	54(a3)
l00be	subq.w	#1,76(a3)
	bra	fx_fin_normale
fx_v_sldown_l	neg.w	d4
fx_v_slup_l	bsr.s	fx_do_v_slide_l
	bra	fx_fin_normale
fx_do_v_slide_l	move.w	52(a3),d5
	lsr.w	#3,d5
	add.w	d5,d4
	tst.w	d4
	bgt.s	l00c2
	moveq	#0,d4
l00c2	cmp.w	#$100,d4
	ble.s	l00c3
	move.w	#$100,d4
l00c3	lea	vlin_2_exp(pc),a4
	move.w	(0.b,a4,d4.w*2),54(a3)
	lsl.w	#3,d4
	move.w	d4,52(a3)
	rts

fx_v_sldown_e	neg.w	d4
fx_v_slup_e	bsr.s	fx_do_v_slide_e
	bra	fx_fin_normale
fx_do_v_slide_e	add.w	54(a3),d4
	tst.w	d4
	bgt.s	l00c7
	moveq	#0,d4
l00c7	cmp.w	#$800,d4
	ble.s	l00c8
	move.w	#$800,d4
l00c8	move.w	d4,54(a3)
	lea	vexp_2_lin(pc),a4
	move.w	(0.b,a4,d4.w*2),52(a3)
	rts

fx_v_sldown_l_tp	neg.w	d4
fx_v_slup_l_tp	bsr.s	fx_do_v_slide_l
	moveq	#0,d4
	bsr	fx_do_tone_porta
	bra	fx_fin_normale
fx_v_sldown_e_tp	neg.w	d4
fx_v_slup_e_tp	bsr.s	fx_do_v_slide_e
	moveq	#0,d4
	bsr	fx_do_tone_porta
	bra	fx_fin_normale
fx_v_sldown_l_vi	neg.w	d4
fx_v_slup_l_vib	bsr.s	fx_do_v_slide_l
	moveq	#0,d4
	bsr	fx_do_vibrato
	bra	fx_fin_speciale
fx_v_sldown_e_vi	neg.w	d4
fx_v_slup_e_vib	bsr.s	fx_do_v_slide_e
	moveq	#0,d4
	bsr	fx_do_vibrato
	bra	fx_fin_speciale
fx_mv_sldown_l	neg.w	d4
fx_mv_slup_l	bsr.s	fx_do_mv_slide_l
	bra	fx_fin_normale
fx_do_mv_slide_l	move.w	master_vol(pc),d5
	add.w	d5,d4
	tst.w	d4
	bpl.s	l00d4
	moveq	#0,d4
l00d4	cmp.w	#$fff,d4
	ble.s	l00d5
	move.w	#$fff,d4
l00d5	move.w	d4,master_vol
	rts

fx_left_bal_move	sub.w	d4,8(a3)
	tst.w	8(a3)
	bpl	fx_fin1
	clr.w	8(a3)
	bra	fx_fin_normale
fx_right_bal_mov	add.w	8(a3),d4
	cmp.w	#$fff,d4
	ble.s	l00d8
	move.w	#$fff,d4
l00d8	move.w	d4,8(a3)
	bra	fx_fin_normale
	data
adr_labels	dc.b	0,'N'
	dc.l	nbrvoies
	dc.l	master_vol
	dc.l	module_inf1
	dc.l	l00eb
	dc.l	l00ec
	dc.l	l00ed
	dc.l	l00ee
	dc.l	module_inf2
	dc.l	l00f0
	dc.l	l00f1
	dc.l	l00f2
	dc.l	l00f3
	dc.l	l00f4
	dc.l	l00f5
	dc.l	l00f6
	dc.l	l00f8
	dc.l	info_track
	dc.l	repeatbuffer
	dc.l	flag_stop_voices
	dc.l	adrlodnom
	dc.l	flag_the_end
	dcb.w	3
	dc.b	0,2,0,0,0,4,0,0
	dc.b	0,8
	dc.l	flag_mt_display
	dc.l	vblsize
	dc.l	l00f7
fx_table_de_saut	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_set_ftune
	dc.l	fx_predelay
	dc.l	fx_note_cut
	dc.l	fx_pos_jump
	dc.l	fx_set_vib_wave
	dc.l	fx_break_pat
	dc.l	fx_set_trem_wave
	dc.l	fx_set_global_sp
	dc.l	fx_fin1
	dc.l	fx_fine_porta_up
	dc.l	fx_fine_porta_do
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fine_v_slup_l
	dc.l	fx_fine_v_sldown
	dc.l	fx_fine_mv_slup_
	dc.l	fx_fine_mv_sldow
	dc.l	fx_set_nbr_of_fr
	dc.l	fx_set_fine_spee
	dc.l	fx_pattern_delay
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
	dc.l	fx_fin1
l00db	dc.l	fx_fin_normale
	dc.l	fx_porta_up
	dc.l	fx_porta_down
	dc.l	fx_tone_porta
	dc.l	fx_vibrato
	dc.l	fx_tone_porta_vi
	dc.l	fx_vib_tone_port
	dc.l	fx_tremolo
	dc.l	fx_fin_normale
	dc.l	fx_delay
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_arpeggio
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_v_slup_l
	dc.l	fx_v_sldown_l
	dc.l	fx_v_slup_e
	dc.l	fx_v_sldown_e
	dc.l	fx_v_slup_l_tp
	dc.l	fx_v_sldown_l_tp
	dc.l	fx_v_slup_e_tp
	dc.l	fx_v_sldown_e_tp
	dc.l	fx_v_slup_l_vib
	dc.l	fx_v_sldown_l_vi
	dc.l	fx_v_slup_e_vib
	dc.l	fx_v_sldown_e_vi
	dc.l	fx_mv_slup_l
	dc.l	fx_mv_sldown_l
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_fin_normale
	dc.l	fx_extra_fine_to
	dc.l	fx_extra_fine_po
	dc.l	l009b
	dc.l	fx_left_bal_move
	dc.l	fx_right_bal_mov
sin_table	dc.b	0,0,0,$18,0,'1',0,'J'
	dc.b	0,'a',0,'x',0,$8d,0,$a1
	dc.b	0,$b4,0,$c5,0,$d4,0,$e0
	dc.b	0,$eb,0,$f4,0,$fa,0,$fd
	dc.b	0,$ff,0,$fd,0,$fa,0,$f4
	dc.b	0,$eb,0,$e0,0,$d4,0,$c5
	dc.b	0,$b4,0,$a1,0,$8d,0,'x'
	dc.b	0,'a',0,'J',0,'1',0,$18
	dc.b	$7f,'?~T}l|',$85
	dc.b	'{',$9f,'z',$bc,'y',$da,'x',$f9
	dc.b	'x',$1a,'w=vbu',$88
	dc.b	't',$af,'s',$d8,'s',3,'r/'
	dc.b	'q]p',$8c,'o',$bd,'n',$ef
	dc.b	'n#mXlŽk',$c6
per_table	dc.b	'k',0,'j;iwh',$b5
	dc.b	'g',$f4,'g5fwe',$ba
	dc.b	'd',$ff,'dEc',$8c,'b',$d5
	dc.b	'b',$1f,'aj`',$b6,'`',4
	dc.b	'_S^',$a4,']',$f6,']I'
	dc.b	'\',$9d,'[',$f2,'[IZ',$a1
	dc.b	'Y',$fa,'YTX',$b0,'X',$c
	dc.b	'WjV',$c9,'V)U',$8b
	dc.b	'T',$ed,'TQS',$b5,'S',$1b
	dc.b	'R',$82,'Q',$ea,'QSP',$be
	dc.b	'P)O',$95,'O',3,'Nq'
	dc.b	'M',$e1,'MQL',$c3,'L5'
	dc.b	'K',$a9,'K',$1e,'J',$93,'J',$a
	dc.b	'I',$82,'H',$fa,'HtG',$ee
	dc.b	'GjF',$e6,'FdE',$e2
	dc.b	'EbD',$e2,'DcC',$e5
	dc.b	'ChB',$ec,'BpA',$f6
	dc.b	'A}A',4,'@',$8c,'@',$15
	dc.b	'?',$9f,'?*>',$b6,'>B'
	dc.b	'=',$d0,'=^<',$ed,'<}'
	dc.b	'<',$d,';',$9f,';1:',$c4
	dc.b	':X9',$ec,'9�9',$18
	dc.b	'8',$ae,'8F7',$de,'7w'
	dc.b	'7',$11,'6',$ac,'6G5',$e3
	dc.b	'5',$80,'5',$1d,'4',$bc,'4['
	dc.b	'3',$fa,'3š3;2',$dd
	dc.b	'2',$7f,'2"1',$c6,'1j'
	dc.b	'1',$f,'0',$b5,'0[0',2
	dc.b	'/',$aa,'/R.',$fb,'.',$a4
	dc.b	'.N-',$f9,'-',$a4,'-P'
	dc.b	',',$fd,',',$aa,',X,',6
	dc.b	'+',$b5,'+e+',$15,'*',$c5
	dc.b	'*w*()',$db,')Ž'
	dc.b	')A(',$f5,'(',$aa,'(_'
	dc.b	'(',$14,$27,$cb,$27,'�',$27,'9'
	dc.b	'&',$f0,'&',$a9,'&a&',$1b
	dc.b	'%',$d5,'%',$8f,'%J%',5
	dc.b	'$',$c1,'$}$:#',$f7
	dc.b	'#',$b5,'#s#2"',$f1
	dc.b	'"',$b1,'"q"1!',$f2
	dc.b	'!',$b4,'!v!8 ',$fb
	dc.b	' ',$be,' ',$82,' F ',$b
	dc.b	$1f,$d0,$1f,$95,$1f,'[',$1f,'!'
	dc.b	$1e,$e8,$1e,$af,$1e,'v',$1e,'>'
	dc.b	$1e,7,$1d,$cf,$1d,$98,$1d,'b'
	dc.b	$1d,',',$1c,$f6,$1c,$c1,$1c,$8c
	dc.b	$1c,'W',$1c,'#',$1b,$ef,$1b,$bc
	dc.b	$1b,$89,$1b,'V',$1b,'$',$1a,$f2
	dc.b	$1a,$c0,$1a,$8f,$1a,'^',$1a,'-'
	dc.b	$19,$fd,$19,$cd,$19,$9e,$19,'n'
	dc.b	$19,'@',$19,$11,$18,$e3,$18,$b5
	dc.b	$18,$88,$18,'Z',$18,'.',$18,1
	dc.b	$17,$d5,$17,$a9,$17,'}',$17,'R'
	dc.b	$17,$27,$16,$fd,$16,$d2,$16,$a8
	dc.b	$16,'~',$16,'U',$16,',',$16,3
	dc.b	$15,$db,$15,$b2,$15,$8a,$15,'c'
	dc.b	$15,';',$15,$14,$14,$ed,$14,$c7
	dc.b	$14,$a1,$14,'{',$14,'U',$14,'/'
	dc.b	$14,$a,$13,$e5,$13,$c1,$13,$9c
	dc.b	$13,'x',$13,'T',$13,'1',$13,$d
	dc.b	$12,$ea,$12,$c7,$12,$a5,$12,$83
	dc.b	$12,'`',$12,'?',$12,$1d,$11,$fc
	dc.b	$11,$da,$11,$ba,$11,$99,$11,'y'
	dc.b	$11,'X',$11,'8',$11,$19,$10,$f9
	dc.b	$10,$da,$10,$bb,$10,$9c,$10,'~'
	dc.b	$10,'_',$10,'A',$10,'#',$10,5
	dc.b	$f,$e8,$f,$cb,$f,$ad,$f,$91
	dc.b	$f,'t',$f,'W',$f,';',$f,$1f
	dc.b	$f,3,$e,$e8,$e,$cc,$e,$b1
	dc.b	$e,$96,$e,'{',$e,'`',$e,'F'
	dc.b	$e,',',$e,$12,$d,$f8,$d,$de
	dc.b	$d,$c4,$d,$ab,$d,$92,$d,'y'
	dc.b	$d,'`',$d,'G',$d,'/',$d,$17
	dc.b	$c,$ff,$c,$e7,$c,$cf,$c,$b7
	dc.b	$c,$a0,$c,$89,$c,'q',$c,'['
	dc.b	$c,'D',$c,'-',$c,$17,$c,1
	dc.b	$b,$ea,$b,$d4,$b,$bf,$b,$a9
	dc.b	$b,$94,$b,'~',$b,'i',$b,'T'
	dc.b	$b,'?',$b,'+',$b,$16,$b,2
	dc.b	$a,$ed,$a,$d9,$a,$c5,$a,$b1
	dc.b	$a,$9e,$a,$8a,$a,'w',$a,'c'
	dc.b	$a,'P',$a,'=',$a,'*',$a,$18
	dc.b	$a,5,9,$f3,9,$e0,9,$ce
	dc.b	9,$bc,9,$aa,9,$98,9,$87
	dc.b	9,'u',9,'d',9,'R',9,'A'
	dc.b	9,'0',9,$1f,9,$e,8,$fe
	dc.b	8,$ed,8,$dd,8,$cc,8,$bc
	dc.b	8,$ac,8,$9c,8,$8c,8,'}'
	dc.b	8,'m',8,']',8,'N',8,'?'
	dc.b	8,'0',8,'!',8,$12,8,3
	dc.b	7,$f4,7,$e5,7,$d7,7,$c8
	dc.b	7,$ba,7,$ac,7,$9e,7,$90
	dc.b	7,$82,7,'t',7,'f',7,'X'
	dc.b	7,'K',7,'>',7,'0',7,'#'
	dc.b	7,$16,7,9,6,$fc,6,$ef
	dc.b	6,$e2,6,$d5,6,$c9,6,$bc
	dc.b	6,$b0,6,$a4,6,$97,6,$8b
	dc.b	6,$7f,6,'s',6,'g',6,'\'
	dc.b	6,'P',6,'D',6,'9',6,'-'
	dc.b	6,'"',6,$17,6,$b,6,0
	dc.b	5,$f5,5,$ea,5,$df,5,$d5
	dc.b	5,$ca,5,$bf,5,$b5,5,$aa
	dc.b	5,$a0,5,$95,5,$8b,5,$81
	dc.b	5,'w',5,'m',5,'c',5,'Y'
	dc.b	5,'O',5,'E',5,';',5,'2'
	dc.b	5,'(',5,$1f,5,$15,5,$c
	dc.b	5,3,4,$f9,4,$f0,4,$e7
	dc.b	4,$de,4,$d5,4,$cc,4,$c3
	dc.b	4,$bb,4,$b2,4,$a9,4,$a1
	dc.b	4,$98,4,$90,4,$87,4,$7f
	dc.b	4,'w',4,'n',4,'f',4,'^'
	dc.b	4,'V',4,'N',4,'F',4,'>'
	dc.b	4,'6',4,'/',4,$27,4,$1f
	dc.b	4,$18,4,$10,4,9,4,1
	dc.b	3,$fa,3,$f3,3,$eb,3,$e4
	dc.b	3,$dd,3,$d6,3,$cf,3,$c8
	dc.b	3,$c1,3,$ba,3,$b3,3,$ac
	dc.b	3,$a5,3,$9f,3,$98,3,$91
	dc.b	3,$8b,3,$84,3,'~',3,'w'
	dc.b	3,'q',3,'k',3,'d',3,'^'
	dc.b	3,'X',3,'R',3,'L',3,'F'
	dc.b	3,'@',3,':',3,'4',3,'.'
	dc.b	3,'(',3,'"',3,$1c,3,$17
	dc.b	3,$11,3,$b,3,6,3,0
	dc.b	2,$fb,2,$f5,2,$f0,2,$ea
	dc.b	2,$e5,2,$e0,2,$da,2,$d5
	dc.b	2,$d0,2,$cb,2,$c5,2,$c0
	dc.b	2,$bb,2,$b6,2,$b1,2,$ac
	dc.b	2,$a7,2,$a3,2,$9e,2,$99
	dc.b	2,$94,2,$8f,2,$8b,2,$86
	dc.b	2,$81,2,'}',2,'x',2,'t'
	dc.b	2,'o',2,'k',2,'f',2,'b'
	dc.b	2,']',2,'Y',2,'U',2,'P'
	dc.b	2,'L',2,'H',2,'D',2,'?'
	dc.b	2,';',2,'7',2,'3',2,'/'
	dc.b	2,'+',2,$27,2,'#',2,$1f
	dc.b	2,$1b,2,$17,2,$14,2,$10
	dc.b	2,$c,2,8,2,4,2,1
	dc.b	1,$fd,1,$f9,1,$f6,1,$f2
	dc.b	1,$ee,1,$eb,1,$e7,1,$e4
	dc.b	1,$e0,1,$dd,1,$da,1,$d6
	dc.b	1,$d3,1,$cf,1,$cc,1,$c9
	dc.b	1,$c5,1,$c2,1,$bf,1,$bc
	dc.b	1,$b9,1,$b5,1,$b2,1,$af
	dc.b	1,$ac,1,$a9,1,$a6,1,$a3
	dc.b	1,$a0,1,$9d,1,$9a,1,$97
	dc.b	1,$94,1,$91,1,$8e,1,$8b
	dc.b	1,$88,1,$86,1,$83,1,$80
	dc.b	1,'}',1,'{',1,'x',1,'u'
	dc.b	1,'r',1,'p',1,'m',1,'k'
	dc.b	1,'h',1,'e',1,'c',1,'`'
	dc.b	1,'^',1,'[',1,'Y',1,'V'
	dc.b	1,'T',1,'Q',1,'O',1,'L'
	dc.b	1,'J',1,'H',1,'E',1,'C'
	dc.b	1,'A',1,'>',1,'<',1,':'
	dc.b	1,'8',1,'5',1,'3',1,'1'
	dc.b	1,'/',1,',',1,'*',1,'('
	dc.b	1,'&',1,'$',1,'"',1,' '
	dc.b	1,$1e,1,$1c,1,$1a,1,$18
	dc.b	1,$16,1,$14,1,$12,1,$10
	dc.b	1,$e,1,$c,1,$a,1,8
	dc.b	1,6,1,4,1,2,1,0
	dc.b	0,$fe,0,$fd,0,$fb,0,$f9
	dc.b	0,$f7,0,$f5,0,$f4,0,$f2
	dc.b	0,$f0,0,$ee,0,$ed,0,$eb
	dc.b	0,$e9,0,$e8,0,$e6,0,$e4
	dc.b	0,$e3,0,$e1,0,$df,0,$de
	dc.b	0,$dc,0,$db,0,$d9,0,$d8
	dc.b	0,$d6,0,$d4,0,$d3,0,$d1
	dc.b	0,$d0,0,$ce,0,$cd,0,$cb
	dc.b	0,$ca,0,$c9,0,$c7,0,$c6
	dc.b	0,$c4,0,$c3,0,$c1,0,$c0
	dc.b	0,$bf,0,$bd,0,$bc,0,$bb
	dc.b	0,$b9,0,$b8,0,$b7,0,$b5
	dc.b	0,$b4,0,$b3,0,$b1,0,$b0
	dc.b	0,$af,0,$ae,0,$ac,0,$ab
	dc.b	0,$aa,0,$a9,0,$a7,0,$a6
	dc.b	0,$a5,0,$a4,0,$a3,0,$a1
	dc.b	0,$a0,0,$9f,0,$9e,0,$9d
	dc.b	0,$9c,0,$9b,0,$9a,0,$98
	dc.b	0,$97,0,$96,0,$95,0,$94
	dc.b	0,$93,0,$92,0,$91,0,$90
	dc.b	0,$8f,0,$8e,0,$8d,0,$8c
	dc.b	0,$8b,0,$8a,0,$89,0,$88
	dc.b	0,$87,0,$86,0,$85,0,$84
	dc.b	0,$83,0,$82,0,$81,0,$80
	dc.b	0,$7f,0,'~',0,'}',0,'}'
	dc.b	0,'|',0,'{',0,'z',0,'y'
	dc.b	0,'x',0,'w',0,'v',0,'v'
	dc.b	0,'u',0,'t',0,'s',0,'r'
	dc.b	0,'q',0,'q',0,'p',0,'o'
	dc.b	0,'n',0,'m',0,'m',0,'l'
	dc.b	0,'k',0,'j',0,'i',0,'i'
	dc.b	0,'h',0,'g',0,'f',0,'f'
	dc.b	0,'e',0,'d',0,'d',0,'c'
	dc.b	0,'b',0,'a',0,'a',0,'`'
tempo_table	dc.b	0,$16,4,$17,0,$15,4,'('
	dc.b	0,$15,4,8,0,$14,4,$1d
	dc.b	0,$14,4,0,0,$13,4,$19
	dc.b	0,$12,4,'6',0,$12,4,$1a
	dc.b	0,$12,4,0,0,$11,4,'"'
	dc.b	0,$11,4,8,0,$10,4,'0'
	dc.b	0,$10,4,$17,0,$10,4,0
	dc.b	0,$f,4,',',0,$f,4,$16
	dc.b	0,$f,4,0,0,$e,4,'3'
	dc.b	0,$e,4,$1d,0,$e,4,8
	dc.b	0,$e,3,$f5,0,$d,4,'.'
	dc.b	0,$d,4,$1a,0,$d,4,7
	dc.b	0,$d,3,$f5,0,$c,4,'6'
	dc.b	0,$c,4,'#',0,$c,4,$11
	dc.b	0,$c,4,0,0,$c,3,$ef
	dc.b	0,$b,4,'9',0,$b,4,'('
	dc.b	0,$b,4,$17,0,$b,4,7
	dc.b	0,$b,3,$f7,0,$a,4,'L'
	dc.b	0,$a,4,'<',0,$a,4,','
	dc.b	0,$a,4,$1d,0,$a,4,$e
	dc.b	0,$a,4,0,0,$a,3,$f2
	dc.b	0,$a,3,$e4,0,9,4,'D'
	dc.b	0,9,4,'6',0,9,4,'('
	dc.b	0,9,4,$1a,0,9,4,$d
	dc.b	0,9,4,0,0,9,3,$f3
	dc.b	0,9,3,$e7,0,8,4,'V'
	dc.b	0,8,4,'I',0,8,4,'<'
	dc.b	0,8,4,'0',0,8,4,'#'
	dc.b	0,8,4,$17,0,8,4,$b
	dc.b	0,8,4,0,0,8,3,$f5
	dc.b	0,8,3,$ea,0,8,3,$df
	dc.b	0,7,4,'`',0,7,4,'U'
	dc.b	0,7,4,'I',0,7,4,'>'
	dc.b	0,7,4,'3',0,7,4,'('
	dc.b	0,7,4,$1d,0,7,4,$13
	dc.b	0,7,4,8,0,7,3,$fe
	dc.b	0,7,3,$f5,0,7,3,$eb
	dc.b	0,7,3,$e2,0,7,3,$d8
	dc.b	0,7,3,$cf,0,6,4,'g'
	dc.b	0,6,4,']',0,6,4,'S'
	dc.b	0,6,4,'I',0,6,4,'?'
	dc.b	0,6,4,'6',0,6,4,','
	dc.b	0,6,4,'#',0,6,4,$1a
	dc.b	0,6,4,$11,0,6,4,8
	dc.b	0,6,4,0,0,6,3,$f7
	dc.b	0,6,3,$ef,0,6,3,$e7
	dc.b	0,6,3,$df,0,6,3,$d7
	dc.b	0,6,3,$cf,0,6,3,$c7
	dc.b	0,6,3,$c0,0,5,4,'w'
	dc.b	0,5,4,'n',0,5,4,'f'
	dc.b	0,5,4,']',0,5,4,'U'
	dc.b	0,5,4,'L',0,5,4,'D'
	dc.b	0,5,4,'<',0,5,4,'4'
	dc.b	0,5,4,',',0,5,4,'%'
	dc.b	0,5,4,$1d,0,5,4,$16
	dc.b	0,5,4,$e,0,5,4,7
	dc.b	0,5,4,0,0,5,3,$f9
	dc.b	0,5,3,$f2,0,5,3,$eb
	dc.b	0,5,3,$e4,0,5,3,$de
	dc.b	0,5,3,$d7,0,5,3,$d0
	dc.b	0,5,3,$ca,0,5,3,$c4
	dc.b	0,5,3,$bd,0,5,3,$b7
	dc.b	0,5,3,$b1,0,5,3,$ab
	dc.b	0,4,4,$8f,0,4,4,$87
	dc.b	0,4,4,$80,0,4,4,'y'
	dc.b	0,4,4,'r',0,4,4,'k'
	dc.b	0,4,4,'d',0,4,4,']'
	dc.b	0,4,4,'V',0,4,4,'P'
	dc.b	0,4,4,'I',0,4,4,'C'
	dc.b	0,4,4,'<',0,4,4,'6'
	dc.b	0,4,4,'0',0,4,4,')'
	dc.b	0,4,4,'#',0,4,4,$1d
	dc.b	0,4,4,$17,0,4,4,$11
	dc.b	0,4,4,$b,0,4,4,6
	dc.b	0,4,4,0,0,4,3,$fa
	dc.b	0,4,3,$f5,0,4,3,$ef
	dc.b	0,4,3,$ea,0,4,3,$e4
	dc.b	0,4,3,$df,0,4,3,$da
	dc.b	0,4,3,$d4,0,4,3,$cf
	dc.b	0,4,3,$ca,0,4,3,$c5
	dc.b	0,4,3,$c0,0,4,3,$bb
	dc.b	0,4,3,$b6,0,4,3,$b1
	dc.b	0,4,3,$ac,0,4,3,$a7
	dc.b	0,4,3,$a3,0,4,3,$9e
	dc.b	0,4,3,$99,0,4,3,$95
	dc.b	0,4,3,$90,0,4,3,$8c
	dc.b	0,4,3,$87,0,3,4,$af
	dc.b	0,3,4,$a9,0,3,4,$a3
	dc.b	0,3,4,$9d,0,3,4,$98
	dc.b	0,3,4,$92,0,3,4,$8d
	dc.b	0,3,4,$87,0,3,4,$82
	dc.b	0,3,4,'|',0,3,4,'w'
	dc.b	0,3,4,'r',0,3,4,'l'
	dc.b	0,3,4,'g',0,3,4,'b'
	dc.b	0,3,4,']',0,3,4,'X'
	dc.b	0,3,4,'S',0,3,4,'N'
	dc.b	0,3,4,'I',0,3,4,'D'
	dc.b	0,3,4,'?',0,3,4,';'
	dc.b	0,3,4,'6',0,3,4,'1'
	dc.b	0,3,4,',',0,3,4,'('
	dc.b	0,3,4,'#',0,3,4,$1f
	dc.b	0,3,4,$1a,0,3,4,$16
	dc.b	0,3,4,$11,0,3,4,$d
	dc.b	0,3,4,8,0,3,4,4
	dc.b	0,3,4,0,0,3,3,$fc
	dc.b	0,3,3,$f7,0,3,3,$f3
	dc.b	0,3,3,$ef,0,3,3,$eb
	dc.b	0,3,3,$e7,0,3,3,$e3
	dc.b	0,3,3,$df,0,3,3,$db
	dc.b	0,3,3,$d7,0,3,3,$d3
	dc.b	0,3,3,$cf,0,3,3,$cb
	dc.b	0,3,3,$c7,0,3,3,$c4
vexp_2_lin	dc.b	0,0,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$19,0,$19
	dc.b	0,$19,0,$19,0,$19,0,$19
	dc.b	0,$19,0,$19,0,$19,0,$19
	dc.b	0,$19,0,$19,0,$19,0,$19
	dc.b	0,$19,0,$1a,0,$1a,0,$1a
	dc.b	0,$1a,0,$1a,0,$1a,0,$1a
	dc.b	0,$1a,0,$1a,0,$1a,0,$1a
	dc.b	0,$1a,0,$1a,0,$1a,0,$1b
	dc.b	0,$1b,0,$1b,0,$1b,0,$1b
	dc.b	0,$1b,0,$1b,0,$1b,0,$1b
	dc.b	0,$1b,0,$1b,0,$1b,0,$1b
	dc.b	0,$1b,0,$1c,0,$1c,0,$1c
	dc.b	0,$1c,0,$1c,0,$1c,0,$1c
	dc.b	0,$1c,0,$1c,0,$1c,0,$1c
	dc.b	0,$1c,0,$1c,0,$1d,0,$1d
	dc.b	0,$1d,0,$1d,0,$1d,0,$1d
	dc.b	0,$1d,0,$1d,0,$1d,0,$1d
	dc.b	0,$1d,0,$1d,0,$1e,0,$1e
	dc.b	0,$1e,0,$1e,0,$1e,0,$1e
	dc.b	0,$1e,0,$1e,0,$1e,0,$1e
	dc.b	0,$1e,0,$1e,0,$1e,0,$1f
	dc.b	0,$1f,0,$1f,0,$1f,0,$1f
	dc.b	0,$1f,0,$1f,0,$1f,0,$1f
	dc.b	0,$1f,0,$1f,0,$1f,0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,'!',0,'!'
	dc.b	0,'!',0,'!',0,'!',0,'!'
	dc.b	0,'!',0,'!',0,'!',0,'!'
	dc.b	0,'!',0,'"',0,'"',0,'"'
	dc.b	0,'"',0,'"',0,'"',0,'"'
	dc.b	0,'"',0,'"',0,'"',0,'"'
	dc.b	0,'#',0,'#',0,'#',0,'#'
	dc.b	0,'#',0,'#',0,'#',0,'#'
	dc.b	0,'#',0,'#',0,'#',0,'$'
	dc.b	0,'$',0,'$',0,'$',0,'$'
	dc.b	0,'$',0,'$',0,'$',0,'$'
	dc.b	0,'$',0,'%',0,'%',0,'%'
	dc.b	0,'%',0,'%',0,'%',0,'%'
	dc.b	0,'%',0,'%',0,'%',0,'&'
	dc.b	0,'&',0,'&',0,'&',0,'&'
	dc.b	0,'&',0,'&',0,'&',0,'&'
	dc.b	0,'&',0,$27,0,$27,0,$27
	dc.b	0,$27,0,$27,0,$27,0,$27
	dc.b	0,$27,0,$27,0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,')',0,')',0,')',0,')'
	dc.b	0,')',0,')',0,')',0,')'
	dc.b	0,')',0,'*',0,'*',0,'*'
	dc.b	0,'*',0,'*',0,'*',0,'*'
	dc.b	0,'*',0,'+',0,'+',0,'+'
	dc.b	0,'+',0,'+',0,'+',0,'+'
	dc.b	0,'+',0,'+',0,',',0,','
	dc.b	0,',',0,',',0,',',0,','
	dc.b	0,',',0,',',0,'-',0,'-'
	dc.b	0,'-',0,'-',0,'-',0,'-'
	dc.b	0,'-',0,'-',0,'.',0,'.'
	dc.b	0,'.',0,'.',0,'.',0,'.'
	dc.b	0,'.',0,'.',0,'.',0,'/'
	dc.b	0,'/',0,'/',0,'/',0,'/'
	dc.b	0,'/',0,'/',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'1',0,'1'
	dc.b	0,'1',0,'1',0,'1',0,'1'
	dc.b	0,'1',0,'1',0,'2',0,'2'
	dc.b	0,'2',0,'2',0,'2',0,'2'
	dc.b	0,'2',0,'3',0,'3',0,'3'
	dc.b	0,'3',0,'3',0,'3',0,'3'
	dc.b	0,'4',0,'4',0,'4',0,'4'
	dc.b	0,'4',0,'4',0,'4',0,'5'
	dc.b	0,'5',0,'5',0,'5',0,'5'
	dc.b	0,'5',0,'5',0,'6',0,'6'
	dc.b	0,'6',0,'6',0,'6',0,'6'
	dc.b	0,'6',0,'7',0,'7',0,'7'
	dc.b	0,'7',0,'7',0,'7',0,'7'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'9',0,'9'
	dc.b	0,'9',0,'9',0,'9',0,'9'
	dc.b	0,'9',0,':',0,':',0,':'
	dc.b	0,':',0,':',0,':',0,';'
	dc.b	0,';',0,';',0,';',0,';'
	dc.b	0,';',0,';',0,'<',0,'<'
	dc.b	0,'<',0,'<',0,'<',0,'<'
	dc.b	0,'=',0,'=',0,'=',0,'='
	dc.b	0,'=',0,'=',0,'>',0,'>'
	dc.b	0,'>',0,'>',0,'>',0,'>'
	dc.b	0,'?',0,'?',0,'?',0,'?'
	dc.b	0,'?',0,'?',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'A'
	dc.b	0,'A',0,'A',0,'A',0,'A'
	dc.b	0,'A',0,'B',0,'B',0,'B'
	dc.b	0,'B',0,'B',0,'B',0,'C'
	dc.b	0,'C',0,'C',0,'C',0,'C'
	dc.b	0,'D',0,'D',0,'D',0,'D'
	dc.b	0,'D',0,'D',0,'E',0,'E'
	dc.b	0,'E',0,'E',0,'E',0,'F'
	dc.b	0,'F',0,'F',0,'F',0,'F'
	dc.b	0,'G',0,'G',0,'G',0,'G'
	dc.b	0,'G',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'I'
	dc.b	0,'I',0,'I',0,'I',0,'I'
	dc.b	0,'J',0,'J',0,'J',0,'J'
	dc.b	0,'J',0,'K',0,'K',0,'K'
	dc.b	0,'K',0,'K',0,'L',0,'L'
	dc.b	0,'L',0,'L',0,'M',0,'M'
	dc.b	0,'M',0,'M',0,'M',0,'N'
	dc.b	0,'N',0,'N',0,'N',0,'N'
	dc.b	0,'O',0,'O',0,'O',0,'O'
	dc.b	0,'O',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'Q',0,'Q',0,'Q'
	dc.b	0,'Q',0,'Q',0,'R',0,'R'
	dc.b	0,'R',0,'R',0,'S',0,'S'
	dc.b	0,'S',0,'S',0,'S',0,'T'
	dc.b	0,'T',0,'T',0,'T',0,'U'
	dc.b	0,'U',0,'U',0,'U',0,'V'
	dc.b	0,'V',0,'V',0,'V',0,'V'
	dc.b	0,'W',0,'W',0,'W',0,'W'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'Y',0,'Y',0,'Y',0,'Y'
	dc.b	0,'Z',0,'Z',0,'Z',0,'Z'
	dc.b	0,'[',0,'[',0,'[',0,'['
	dc.b	0,'[',0,'\',0,'\',0,'\'
	dc.b	0,'\',0,']',0,']',0,']'
	dc.b	0,']',0,'^',0,'^',0,'^'
	dc.b	0,'_',0,'_',0,'_',0,'_'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'a',0,'a',0,'a',0,'a'
	dc.b	0,'b',0,'b',0,'b',0,'b'
	dc.b	0,'c',0,'c',0,'c',0,'d'
	dc.b	0,'d',0,'d',0,'d',0,'e'
	dc.b	0,'e',0,'e',0,'e',0,'f'
	dc.b	0,'f',0,'f',0,'g',0,'g'
	dc.b	0,'g',0,'g',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'i',0,'i'
	dc.b	0,'i',0,'j',0,'j',0,'j'
	dc.b	0,'j',0,'k',0,'k',0,'k'
	dc.b	0,'l',0,'l',0,'l',0,'m'
	dc.b	0,'m',0,'m',0,'m',0,'n'
	dc.b	0,'n',0,'n',0,'o',0,'o'
	dc.b	0,'o',0,'o',0,'p',0,'p'
	dc.b	0,'p',0,'q',0,'q',0,'q'
	dc.b	0,'r',0,'r',0,'r',0,'s'
	dc.b	0,'s',0,'s',0,'s',0,'t'
	dc.b	0,'t',0,'t',0,'u',0,'u'
	dc.b	0,'u',0,'v',0,'v',0,'v'
	dc.b	0,'w',0,'w',0,'w',0,'x'
	dc.b	0,'x',0,'x',0,'y',0,'y'
	dc.b	0,'y',0,'z',0,'z',0,'z'
	dc.b	0,'{',0,'{',0,'{',0,'|'
	dc.b	0,'|',0,'|',0,'}',0,'}'
	dc.b	0,'}',0,'~',0,'~',0,'~'
	dc.b	0,$7f,0,$7f,0,$7f,0,$80
	dc.b	0,$80,0,$80,0,$81,0,$81
	dc.b	0,$81,0,$82,0,$82,0,$82
	dc.b	0,$83,0,$83,0,$84,0,$84
	dc.b	0,$84,0,$85,0,$85,0,$85
	dc.b	0,$86,0,$86,0,$86,0,$87
	dc.b	0,$87,0,$87,0,$88,0,$88
	dc.b	0,$89,0,$89,0,$89,0,$8a
	dc.b	0,$8a,0,$8a,0,$8b,0,$8b
	dc.b	0,$8c,0,$8c,0,$8c,0,$8d
	dc.b	0,$8d,0,$8d,0,$8e,0,$8e
	dc.b	0,$8f,0,$8f,0,$8f,0,$90
	dc.b	0,$90,0,$91,0,$91,0,$91
	dc.b	0,$92,0,$92,0,$93,0,$93
	dc.b	0,$93,0,$94,0,$94,0,$95
	dc.b	0,$95,0,$95,0,$96,0,$96
	dc.b	0,$97,0,$97,0,$97,0,$98
	dc.b	0,$98,0,$99,0,$99,0,$99
	dc.b	0,$9a,0,$9a,0,$9b,0,$9b
	dc.b	0,$9c,0,$9c,0,$9c,0,$9d
	dc.b	0,$9d,0,$9e,0,$9e,0,$9f
	dc.b	0,$9f,0,$9f,0,$a0,0,$a0
	dc.b	0,$a1,0,$a1,0,$a2,0,$a2
	dc.b	0,$a2,0,$a3,0,$a3,0,$a4
	dc.b	0,$a4,0,$a5,0,$a5,0,$a6
	dc.b	0,$a6,0,$a6,0,$a7,0,$a7
	dc.b	0,$a8,0,$a8,0,$a9,0,$a9
	dc.b	0,$aa,0,$aa,0,$ab,0,$ab
	dc.b	0,$ab,0,$ac,0,$ac,0,$ad
	dc.b	0,$ad,0,$ae,0,$ae,0,$af
	dc.b	0,$af,0,$b0,0,$b0,0,$b1
	dc.b	0,$b1,0,$b2,0,$b2,0,$b3
	dc.b	0,$b3,0,$b4,0,$b4,0,$b5
	dc.b	0,$b5,0,$b6,0,$b6,0,$b6
	dc.b	0,$b7,0,$b7,0,$b8,0,$b8
	dc.b	0,$b9,0,$b9,0,$ba,0,$ba
	dc.b	0,$bb,0,$bc,0,$bc,0,$bd
	dc.b	0,$bd,0,$be,0,$be,0,$bf
	dc.b	0,$bf,0,$c0,0,$c0,0,$c1
	dc.b	0,$c1,0,$c2,0,$c2,0,$c3
	dc.b	0,$c3,0,$c4,0,$c4,0,$c5
	dc.b	0,$c5,0,$c6,0,$c6,0,$c7
	dc.b	0,$c8,0,$c8,0,$c9,0,$c9
	dc.b	0,$ca,0,$ca,0,$cb,0,$cb
	dc.b	0,$cc,0,$cc,0,$cd,0,$ce
	dc.b	0,$ce,0,$cf,0,$cf,0,$d0
	dc.b	0,$d0,0,$d1,0,$d2,0,$d2
	dc.b	0,$d3,0,$d3,0,$d4,0,$d4
	dc.b	0,$d5,0,$d6,0,$d6,0,$d7
	dc.b	0,$d7,0,$d8,0,$d8,0,$d9
	dc.b	0,$da,0,$da,0,$db,0,$db
	dc.b	0,$dc,0,$dd,0,$dd,0,$de
	dc.b	0,$de,0,$df,0,$e0,0,$e0
	dc.b	0,$e1,0,$e1,0,$e2,0,$e3
	dc.b	0,$e3,0,$e4,0,$e4,0,$e5
	dc.b	0,$e6,0,$e6,0,$e7,0,$e8
	dc.b	0,$e8,0,$e9,0,$e9,0,$ea
	dc.b	0,$eb,0,$eb,0,$ec,0,$ed
	dc.b	0,$ed,0,$ee,0,$ef,0,$ef
	dc.b	0,$f0,0,$f1,0,$f1,0,$f2
	dc.b	0,$f3,0,$f3,0,$f4,0,$f4
	dc.b	0,$f5,0,$f6,0,$f6,0,$f7
	dc.b	0,$f8,0,$f8,0,$f9,0,$fa
	dc.b	0,$fb,0,$fb,0,$fc,0,$fd
	dc.b	0,$fd,0,$fe,0,$ff,0,$ff
	dc.b	1,0,1,1,1,1,1,2
	dc.b	1,3,1,3,1,4,1,5
	dc.b	1,6,1,6,1,7,1,8
	dc.b	1,8,1,9,1,$a,1,$b
	dc.b	1,$b,1,$c,1,$d,1,$e
	dc.b	1,$e,1,$f,1,$10,1,$10
	dc.b	1,$11,1,$12,1,$13,1,$13
	dc.b	1,$14,1,$15,1,$16,1,$16
	dc.b	1,$17,1,$18,1,$19,1,$19
	dc.b	1,$1a,1,$1b,1,$1c,1,$1d
	dc.b	1,$1d,1,$1e,1,$1f,1,' '
	dc.b	1,' ',1,'!',1,'"',1,'#'
	dc.b	1,'$',1,'$',1,'%',1,'&'
	dc.b	1,$27,1,'(',1,'(',1,')'
	dc.b	1,'*',1,'+',1,',',1,','
	dc.b	1,'-',1,'.',1,'/',1,'0'
	dc.b	1,'0',1,'1',1,'2',1,'3'
	dc.b	1,'4',1,'5',1,'5',1,'6'
	dc.b	1,'7',1,'8',1,'9',1,':'
	dc.b	1,':',1,';',1,'<',1,'='
	dc.b	1,'>',1,'?',1,'@',1,'A'
	dc.b	1,'A',1,'B',1,'C',1,'D'
	dc.b	1,'E',1,'F',1,'G',1,'H'
	dc.b	1,'H',1,'I',1,'J',1,'K'
	dc.b	1,'L',1,'M',1,'N',1,'O'
	dc.b	1,'P',1,'Q',1,'Q',1,'R'
	dc.b	1,'S',1,'T',1,'U',1,'V'
	dc.b	1,'W',1,'X',1,'Y',1,'Z'
	dc.b	1,'[',1,'\',1,']',1,'^'
	dc.b	1,'^',1,'_',1,'`',1,'a'
	dc.b	1,'b',1,'c',1,'d',1,'e'
	dc.b	1,'f',1,'g',1,'h',1,'i'
	dc.b	1,'j',1,'k',1,'l',1,'m'
	dc.b	1,'n',1,'o',1,'p',1,'q'
	dc.b	1,'r',1,'s',1,'t',1,'u'
	dc.b	1,'v',1,'w',1,'x',1,'y'
	dc.b	1,'z',1,'{',1,'|',1,'}'
	dc.b	1,'~',1,$7f,1,$80,1,$81
	dc.b	1,$82,1,$83,1,$84,1,$85
	dc.b	1,$87,1,$88,1,$89,1,$8a
	dc.b	1,$8b,1,$8c,1,$8d,1,$8e
	dc.b	1,$8f,1,$90,1,$91,1,$92
	dc.b	1,$93,1,$95,1,$96,1,$97
	dc.b	1,$98,1,$99,1,$9a,1,$9b
	dc.b	1,$9c,1,$9d,1,$9f,1,$a0
	dc.b	1,$a1,1,$a2,1,$a3,1,$a4
	dc.b	1,$a5,1,$a6,1,$a8,1,$a9
	dc.b	1,$aa,1,$ab,1,$ac,1,$ad
	dc.b	1,$af,1,$b0,1,$b1,1,$b2
	dc.b	1,$b3,1,$b4,1,$b6,1,$b7
	dc.b	1,$b8,1,$b9,1,$ba,1,$bc
	dc.b	1,$bd,1,$be,1,$bf,1,$c0
	dc.b	1,$c2,1,$c3,1,$c4,1,$c5
	dc.b	1,$c6,1,$c8,1,$c9,1,$ca
	dc.b	1,$cb,1,$cd,1,$ce,1,$cf
	dc.b	1,$d0,1,$d2,1,$d3,1,$d4
	dc.b	1,$d6,1,$d7,1,$d8,1,$d9
	dc.b	1,$db,1,$dc,1,$dd,1,$de
	dc.b	1,$e0,1,$e1,1,$e2,1,$e4
	dc.b	1,$e5,1,$e6,1,$e8,1,$e9
	dc.b	1,$ea,1,$ec,1,$ed,1,$ee
	dc.b	1,$f0,1,$f1,1,$f2,1,$f4
	dc.b	1,$f5,1,$f6,1,$f8,1,$f9
	dc.b	1,$fa,1,$fc,1,$fd,1,$ff
	dc.b	2,0,2,1,2,3,2,4
	dc.b	2,6,2,7,2,8,2,$a
	dc.b	2,$b,2,$d,2,$e,2,$f
	dc.b	2,$11,2,$12,2,$14,2,$15
	dc.b	2,$17,2,$18,2,$1a,2,$1b
	dc.b	2,$1c,2,$1e,2,$1f,2,'!'
	dc.b	2,'"',2,'$',2,'%',2,$27
	dc.b	2,'(',2,'*',2,'+',2,'-'
	dc.b	2,'.',2,'0',2,'1',2,'3'
	dc.b	2,'4',2,'6',2,'7',2,'9'
	dc.b	2,';',2,'<',2,'>',2,'?'
	dc.b	2,'A',2,'B',2,'D',2,'E'
	dc.b	2,'G',2,'I',2,'J',2,'L'
	dc.b	2,'M',2,'O',2,'Q',2,'R'
	dc.b	2,'T',2,'U',2,'W',2,'Y'
	dc.b	2,'Z',2,'\',2,'^',2,'_'
	dc.b	2,'a',2,'c',2,'d',2,'f'
	dc.b	2,'h',2,'i',2,'k',2,'m'
	dc.b	2,'n',2,'p',2,'r',2,'s'
	dc.b	2,'u',2,'w',2,'x',2,'z'
	dc.b	2,'|',2,'~',2,$7f,2,$81
	dc.b	2,$83,2,$84,2,$86,2,$88
	dc.b	2,$8a,2,$8c,2,$8d,2,$8f
	dc.b	2,$91,2,$93,2,$94,2,$96
	dc.b	2,$98,2,$9a,2,$9c,2,$9d
	dc.b	2,$9f,2,$a1,2,$a3,2,$a5
	dc.b	2,$a7,2,$a8,2,$aa,2,$ac
	dc.b	2,$ae,2,$b0,2,$b2,2,$b4
	dc.b	2,$b5,2,$b7,2,$b9,2,$bb
	dc.b	2,$bd,2,$bf,2,$c1,2,$c3
	dc.b	2,$c5,2,$c6,2,$c8,2,$ca
	dc.b	2,$cc,2,$ce,2,$d0,2,$d2
	dc.b	2,$d4,2,$d6,2,$d8,2,$da
	dc.b	2,$dc,2,$de,2,$e0,2,$e2
	dc.b	2,$e4,2,$e6,2,$e8,2,$ea
	dc.b	2,$ec,2,$ee,2,$f0,2,$f2
	dc.b	2,$f4,2,$f6,2,$f8,2,$fa
	dc.b	2,$fc,2,$fe,3,1,3,3
	dc.b	3,5,3,7,3,9,3,$b
	dc.b	3,$d,3,$f,3,$11,3,$13
	dc.b	3,$16,3,$18,3,$1a,3,$1c
	dc.b	3,$1e,3,' ',3,'#',3,'%'
	dc.b	3,$27,3,')',3,'+',3,'-'
	dc.b	3,'0',3,'2',3,'4',3,'6'
	dc.b	3,'9',3,';',3,'=',3,'?'
	dc.b	3,'B',3,'D',3,'F',3,'H'
	dc.b	3,'K',3,'M',3,'O',3,'Q'
	dc.b	3,'T',3,'V',3,'X',3,'['
	dc.b	3,']',3,'_',3,'b',3,'d'
	dc.b	3,'f',3,'i',3,'k',3,'n'
	dc.b	3,'p',3,'r',3,'u',3,'w'
	dc.b	3,'z',3,'|',3,'~',3,$81
	dc.b	3,$83,3,$86,3,$88,3,$8b
	dc.b	3,$8d,3,$8f,3,$92,3,$94
	dc.b	3,$97,3,$99,3,$9c,3,$9e
	dc.b	3,$a1,3,$a3,3,$a6,3,$a8
	dc.b	3,$ab,3,$ae,3,$b0,3,$b3
	dc.b	3,$b5,3,$b8,3,$ba,3,$bd
	dc.b	3,$c0,3,$c2,3,$c5,3,$c7
	dc.b	3,$ca,3,$cd,3,$cf,3,$d2
	dc.b	3,$d5,3,$d7,3,$da,3,$dd
	dc.b	3,$df,3,$e2,3,$e5,3,$e7
	dc.b	3,$ea,3,$ed,3,$ef,3,$f2
	dc.b	3,$f5,3,$f8,3,$fa,3,$fd
	dc.b	4,0,4,3,4,6,4,8
	dc.b	4,$b,4,$e,4,$11,4,$14
	dc.b	4,$16,4,$19,4,$1c,4,$1f
	dc.b	4,'"',4,'%',4,'(',4,'*'
	dc.b	4,'-',4,'0',4,'3',4,'6'
	dc.b	4,'9',4,'<',4,'?',4,'B'
	dc.b	4,'E',4,'H',4,'K',4,'N'
	dc.b	4,'Q',4,'T',4,'W',4,'Z'
	dc.b	4,']',4,'`',4,'c',4,'f'
	dc.b	4,'i',4,'l',4,'o',4,'r'
	dc.b	4,'u',4,'x',4,'{',4,'~'
	dc.b	4,$82,4,$85,4,$88,4,$8b
	dc.b	4,$8e,4,$91,4,$94,4,$98
	dc.b	4,$9b,4,$9e,4,$a1,4,$a4
	dc.b	4,$a8,4,$ab,4,$ae,4,$b1
	dc.b	4,$b5,4,$b8,4,$bb,4,$be
	dc.b	4,$c2,4,$c5,4,$c8,4,$cc
	dc.b	4,$cf,4,$d2,4,$d6,4,$d9
	dc.b	4,$dc,4,$e0,4,$e3,4,$e7
	dc.b	4,$ea,4,$ed,4,$f1,4,$f4
	dc.b	4,$f8,4,$fb,4,$ff,5,2
	dc.b	5,6,5,9,5,$c,5,$10
	dc.b	5,$14,5,$17,5,$1b,5,$1e
	dc.b	5,'"',5,'%',5,')',5,','
	dc.b	5,'0',5,'4',5,'7',5,';'
	dc.b	5,'>',5,'B',5,'F',5,'I'
	dc.b	5,'M',5,'Q',5,'T',5,'X'
	dc.b	5,'\',5,'`',5,'c',5,'g'
	dc.b	5,'k',5,'o',5,'r',5,'v'
	dc.b	5,'z',5,'~',5,$81,5,$85
	dc.b	5,$89,5,$8d,5,$91,5,$95
	dc.b	5,$99,5,$9c,5,$a0,5,$a4
	dc.b	5,$a8,5,$ac,5,$b0,5,$b4
	dc.b	5,$b8,5,$bc,5,$c0,5,$c4
	dc.b	5,$c8,5,$cc,5,$d0,5,$d4
	dc.b	5,$d8,5,$dc,5,$e0,5,$e4
	dc.b	5,$e8,5,$ec,5,$f0,5,$f5
	dc.b	5,$f9,5,$fd,6,1,6,5
	dc.b	6,9,6,$e,6,$12,6,$16
	dc.b	6,$1a,6,$1e,6,'#',6,$27
	dc.b	6,'+',6,'0',6,'4',6,'8'
	dc.b	6,'<',6,'A',6,'E',6,'I'
	dc.b	6,'N',6,'R',6,'W',6,'['
	dc.b	6,'_',6,'d',6,'h',6,'m'
	dc.b	6,'q',6,'v',6,'z',6,$7f
	dc.b	6,$83,6,$88,6,$8c,6,$91
	dc.b	6,$95,6,$9a,6,$9e,6,$a3
	dc.b	6,$a8,6,$ac,6,$b1,6,$b5
	dc.b	6,$ba,6,$bf,6,$c4,6,$c8
	dc.b	6,$cd,6,$d2,6,$d6,6,$db
	dc.b	6,$e0,6,$e5,6,$e9,6,$ee
	dc.b	6,$f3,6,$f8,6,$fd,7,2
	dc.b	7,6,7,$b,7,$10,7,$15
	dc.b	7,$1a,7,$1f,7,'$',7,')'
	dc.b	7,'.',7,'3',7,'8',7,'='
	dc.b	7,'B',7,'G',7,'L',7,'Q'
	dc.b	7,'V',7,'[',7,'`',7,'e'
	dc.b	7,'j',7,'p',7,'u',7,'z'
	dc.b	7,$7f,7,$84,7,$8a,7,$8f
	dc.b	7,$94,7,$99,7,$9f,7,$a4
	dc.b	7,$a9,7,$ae,7,$b4,7,$b9
	dc.b	7,$bf,7,$c4,7,$c9,7,$cf
	dc.b	7,$d4,7,$da,7,$df,7,$e4
	dc.b	7,$ea,7,$ef,7,$f5,7,$fa
	dc.b	8,0
vlin_2_exp	dcb.w	2
	dc.b	1,0,1,$96,2,0,2,'R'
	dc.b	2,$96,2,$cf,3,0,3,','
	dc.b	3,'R',3,'v',3,$96,3,$b3
	dc.b	3,$cf,3,$e8,4,0,4,$16
	dc.b	4,',',4,'?',4,'R',4,'d'
	dc.b	4,'v',4,$86,4,$96,4,$a5
	dc.b	4,$b3,4,$c1,4,$cf,4,$dc
	dc.b	4,$e8,4,$f4,5,0,5,$b
	dc.b	5,$16,5,'!',5,',',5,'6'
	dc.b	5,'?',5,'I',5,'R',5,'\'
	dc.b	5,'d',5,'m',5,'v',5,'~'
	dc.b	5,$86,5,$8e,5,$96,5,$9d
	dc.b	5,$a5,5,$ac,5,$b3,5,$ba
	dc.b	5,$c1,5,$c8,5,$cf,5,$d5
	dc.b	5,$dc,5,$e2,5,$e8,5,$ee
	dc.b	5,$f4,5,$fa,6,0,6,6
	dc.b	6,$b,6,$11,6,$16,6,$1c
	dc.b	6,'!',6,'&',6,',',6,'1'
	dc.b	6,'6',6,';',6,'?',6,'D'
	dc.b	6,'I',6,'N',6,'R',6,'W'
	dc.b	6,'\',6,'`',6,'d',6,'i'
	dc.b	6,'m',6,'q',6,'v',6,'z'
	dc.b	6,'~',6,$82,6,$86,6,$8a
	dc.b	6,$8e,6,$92,6,$96,6,$9a
	dc.b	6,$9d,6,$a1,6,$a5,6,$a9
	dc.b	6,$ac,6,$b0,6,$b3,6,$b7
	dc.b	6,$ba,6,$be,6,$c1,6,$c5
	dc.b	6,$c8,6,$cb,6,$cf,6,$d2
	dc.b	6,$d5,6,$d8,6,$dc,6,$df
	dc.b	6,$e2,6,$e5,6,$e8,6,$eb
	dc.b	6,$ee,6,$f1,6,$f4,6,$f7
	dc.b	6,$fa,6,$fd,7,0,7,3
	dc.b	7,6,7,9,7,$b,7,$e
	dc.b	7,$11,7,$14,7,$16,7,$19
	dc.b	7,$1c,7,$1e,7,'!',7,'$'
	dc.b	7,'&',7,')',7,',',7,'.'
	dc.b	7,'1',7,'3',7,'6',7,'8'
	dc.b	7,';',7,'=',7,'?',7,'B'
	dc.b	7,'D',7,'G',7,'I',7,'K'
	dc.b	7,'N',7,'P',7,'R',7,'U'
	dc.b	7,'W',7,'Y',7,'\',7,'^'
	dc.b	7,'`',7,'b',7,'d',7,'g'
	dc.b	7,'i',7,'k',7,'m',7,'o'
	dc.b	7,'q',7,'t',7,'v',7,'x'
	dc.b	7,'z',7,'|',7,'~',7,$80
	dc.b	7,$82,7,$84,7,$86,7,$88
	dc.b	7,$8a,7,$8c,7,$8e,7,$90
	dc.b	7,$92,7,$94,7,$96,7,$98
	dc.b	7,$9a,7,$9b,7,$9d,7,$9f
	dc.b	7,$a1,7,$a3,7,$a5,7,$a7
	dc.b	7,$a9,7,$aa,7,$ac,7,$ae
	dc.b	7,$b0,7,$b2,7,$b3,7,$b5
	dc.b	7,$b7,7,$b9,7,$ba,7,$bc
	dc.b	7,$be,7,$c0,7,$c1,7,$c3
	dc.b	7,$c5,7,$c6,7,$c8,7,$ca
	dc.b	7,$cb,7,$cd,7,$cf,7,$d0
	dc.b	7,$d2,7,$d4,7,$d5,7,$d7
	dc.b	7,$d8,7,$da,7,$dc,7,$dd
	dc.b	7,$df,7,$e0,7,$e2,7,$e4
	dc.b	7,$e5,7,$e7,7,$e8,7,$ea
	dc.b	7,$eb,7,$ed,7,$ee,7,$f0
	dc.b	7,$f1,7,$f3,7,$f4,7,$f6
	dc.b	7,$f7,7,$f9,7,$fa,7,$fc
	dc.b	7,$fd,7,$ff,8,0
vexp_2_lin_maste	dc.b	0,0,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,1,0,1,0,1,0,1
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,2,0,2,0,2,0,2
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,3,0,3,0,3
	dc.b	0,3,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,4,0,4,0,4
	dc.b	0,4,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,5,0,5,0,5,0,5
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,6,0,6
	dc.b	0,6,0,6,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,7,0,7,0,7
	dc.b	0,7,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,8,0,8
	dc.b	0,8,0,8,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,9,0,9,0,9
	dc.b	0,9,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$a,0,$a
	dc.b	0,$a,0,$a,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$b
	dc.b	0,$b,0,$b,0,$b,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$c,0,$c,0,$c,0,$c
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$d,0,$d
	dc.b	0,$d,0,$d,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$e,0,$e,0,$e
	dc.b	0,$e,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$f,0,$f
	dc.b	0,$f,0,$f,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$10,0,$10,0,$10
	dc.b	0,$10,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$11,0,$11
	dc.b	0,$11,0,$11,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$12,0,$12,0,$12
	dc.b	0,$12,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$13
	dc.b	0,$13,0,$13,0,$13,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$14,0,$14,0,$14,0,$14
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$15
	dc.b	0,$15,0,$15,0,$15,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$16,0,$16
	dc.b	0,$16,0,$16,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$17
	dc.b	0,$17,0,$17,0,$17,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$18,0,$18,0,$18,0,$18
	dc.b	0,$19,0,$19,0,$19,0,$19
	dc.b	0,$19,0,$19,0,$19,0,$19
	dc.b	0,$19,0,$19,0,$19,0,$19
	dc.b	0,$19,0,$19,0,$19,0,$19
	dc.b	0,$19,0,$19,0,$19,0,$1a
	dc.b	0,$1a,0,$1a,0,$1a,0,$1a
	dc.b	0,$1a,0,$1a,0,$1a,0,$1a
	dc.b	0,$1a,0,$1a,0,$1a,0,$1a
	dc.b	0,$1a,0,$1a,0,$1a,0,$1a
	dc.b	0,$1a,0,$1a,0,$1b,0,$1b
	dc.b	0,$1b,0,$1b,0,$1b,0,$1b
	dc.b	0,$1b,0,$1b,0,$1b,0,$1b
	dc.b	0,$1b,0,$1b,0,$1b,0,$1b
	dc.b	0,$1b,0,$1b,0,$1b,0,$1b
	dc.b	0,$1b,0,$1c,0,$1c,0,$1c
	dc.b	0,$1c,0,$1c,0,$1c,0,$1c
	dc.b	0,$1c,0,$1c,0,$1c,0,$1c
	dc.b	0,$1c,0,$1c,0,$1c,0,$1c
	dc.b	0,$1c,0,$1c,0,$1d,0,$1d
	dc.b	0,$1d,0,$1d,0,$1d,0,$1d
	dc.b	0,$1d,0,$1d,0,$1d,0,$1d
	dc.b	0,$1d,0,$1d,0,$1d,0,$1d
	dc.b	0,$1d,0,$1d,0,$1d,0,$1e
	dc.b	0,$1e,0,$1e,0,$1e,0,$1e
	dc.b	0,$1e,0,$1e,0,$1e,0,$1e
	dc.b	0,$1e,0,$1e,0,$1e,0,$1e
	dc.b	0,$1e,0,$1e,0,$1e,0,$1e
	dc.b	0,$1f,0,$1f,0,$1f,0,$1f
	dc.b	0,$1f,0,$1f,0,$1f,0,$1f
	dc.b	0,$1f,0,$1f,0,$1f,0,$1f
	dc.b	0,$1f,0,$1f,0,$1f,0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,'!'
	dc.b	0,'!',0,'!',0,'!',0,'!'
	dc.b	0,'!',0,'!',0,'!',0,'!'
	dc.b	0,'!',0,'!',0,'!',0,'!'
	dc.b	0,'!',0,'!',0,'"',0,'"'
	dc.b	0,'"',0,'"',0,'"',0,'"'
	dc.b	0,'"',0,'"',0,'"',0,'"'
	dc.b	0,'"',0,'"',0,'"',0,'"'
	dc.b	0,'#',0,'#',0,'#',0,'#'
	dc.b	0,'#',0,'#',0,'#',0,'#'
	dc.b	0,'#',0,'#',0,'#',0,'#'
	dc.b	0,'#',0,'#',0,'$',0,'$'
	dc.b	0,'$',0,'$',0,'$',0,'$'
	dc.b	0,'$',0,'$',0,'$',0,'$'
	dc.b	0,'$',0,'$',0,'$',0,'$'
	dc.b	0,'%',0,'%',0,'%',0,'%'
	dc.b	0,'%',0,'%',0,'%',0,'%'
	dc.b	0,'%',0,'%',0,'%',0,'%'
	dc.b	0,'%',0,'&',0,'&',0,'&'
	dc.b	0,'&',0,'&',0,'&',0,'&'
	dc.b	0,'&',0,'&',0,'&',0,'&'
	dc.b	0,'&',0,'&',0,$27,0,$27
	dc.b	0,$27,0,$27,0,$27,0,$27
	dc.b	0,$27,0,$27,0,$27,0,$27
	dc.b	0,$27,0,$27,0,$27,0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,')'
	dc.b	0,')',0,')',0,')',0,')'
	dc.b	0,')',0,')',0,')',0,')'
	dc.b	0,')',0,')',0,')',0,'*'
	dc.b	0,'*',0,'*',0,'*',0,'*'
	dc.b	0,'*',0,'*',0,'*',0,'*'
	dc.b	0,'*',0,'*',0,'*',0,'+'
	dc.b	0,'+',0,'+',0,'+',0,'+'
	dc.b	0,'+',0,'+',0,'+',0,'+'
	dc.b	0,'+',0,'+',0,',',0,','
	dc.b	0,',',0,',',0,',',0,','
	dc.b	0,',',0,',',0,',',0,','
	dc.b	0,',',0,',',0,'-',0,'-'
	dc.b	0,'-',0,'-',0,'-',0,'-'
	dc.b	0,'-',0,'-',0,'-',0,'-'
	dc.b	0,'.',0,'.',0,'.',0,'.'
	dc.b	0,'.',0,'.',0,'.',0,'.'
	dc.b	0,'.',0,'.',0,'.',0,'/'
	dc.b	0,'/',0,'/',0,'/',0,'/'
	dc.b	0,'/',0,'/',0,'/',0,'/'
	dc.b	0,'/',0,'/',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'1',0,'1',0,'1',0,'1'
	dc.b	0,'1',0,'1',0,'1',0,'1'
	dc.b	0,'1',0,'1',0,'2',0,'2'
	dc.b	0,'2',0,'2',0,'2',0,'2'
	dc.b	0,'2',0,'2',0,'2',0,'2'
	dc.b	0,'3',0,'3',0,'3',0,'3'
	dc.b	0,'3',0,'3',0,'3',0,'3'
	dc.b	0,'3',0,'4',0,'4',0,'4'
	dc.b	0,'4',0,'4',0,'4',0,'4'
	dc.b	0,'4',0,'4',0,'4',0,'5'
	dc.b	0,'5',0,'5',0,'5',0,'5'
	dc.b	0,'5',0,'5',0,'5',0,'5'
	dc.b	0,'6',0,'6',0,'6',0,'6'
	dc.b	0,'6',0,'6',0,'6',0,'6'
	dc.b	0,'6',0,'7',0,'7',0,'7'
	dc.b	0,'7',0,'7',0,'7',0,'7'
	dc.b	0,'7',0,'7',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'9'
	dc.b	0,'9',0,'9',0,'9',0,'9'
	dc.b	0,'9',0,'9',0,'9',0,'9'
	dc.b	0,':',0,':',0,':',0,':'
	dc.b	0,':',0,':',0,':',0,':'
	dc.b	0,';',0,';',0,';',0,';'
	dc.b	0,';',0,';',0,';',0,';'
	dc.b	0,';',0,'<',0,'<',0,'<'
	dc.b	0,'<',0,'<',0,'<',0,'<'
	dc.b	0,'<',0,'=',0,'=',0,'='
	dc.b	0,'=',0,'=',0,'=',0,'='
	dc.b	0,'=',0,'>',0,'>',0,'>'
	dc.b	0,'>',0,'>',0,'>',0,'>'
	dc.b	0,'>',0,'?',0,'?',0,'?'
	dc.b	0,'?',0,'?',0,'?',0,'?'
	dc.b	0,'?',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'A',0,'A',0,'A',0,'A'
	dc.b	0,'A',0,'A',0,'A',0,'A'
	dc.b	0,'B',0,'B',0,'B',0,'B'
	dc.b	0,'B',0,'B',0,'B',0,'C'
	dc.b	0,'C',0,'C',0,'C',0,'C'
	dc.b	0,'C',0,'C',0,'C',0,'D'
	dc.b	0,'D',0,'D',0,'D',0,'D'
	dc.b	0,'D',0,'D',0,'E',0,'E'
	dc.b	0,'E',0,'E',0,'E',0,'E'
	dc.b	0,'E',0,'F',0,'F',0,'F'
	dc.b	0,'F',0,'F',0,'F',0,'F'
	dc.b	0,'G',0,'G',0,'G',0,'G'
	dc.b	0,'G',0,'G',0,'G',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'I',0,'I'
	dc.b	0,'I',0,'I',0,'I',0,'I'
	dc.b	0,'I',0,'J',0,'J',0,'J'
	dc.b	0,'J',0,'J',0,'J',0,'K'
	dc.b	0,'K',0,'K',0,'K',0,'K'
	dc.b	0,'K',0,'K',0,'L',0,'L'
	dc.b	0,'L',0,'L',0,'L',0,'L'
	dc.b	0,'M',0,'M',0,'M',0,'M'
	dc.b	0,'M',0,'M',0,'M',0,'N'
	dc.b	0,'N',0,'N',0,'N',0,'N'
	dc.b	0,'N',0,'O',0,'O',0,'O'
	dc.b	0,'O',0,'O',0,'O',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'Q',0,'Q',0,'Q'
	dc.b	0,'Q',0,'Q',0,'Q',0,'Q'
	dc.b	0,'R',0,'R',0,'R',0,'R'
	dc.b	0,'R',0,'R',0,'S',0,'S'
	dc.b	0,'S',0,'S',0,'S',0,'T'
	dc.b	0,'T',0,'T',0,'T',0,'T'
	dc.b	0,'T',0,'U',0,'U',0,'U'
	dc.b	0,'U',0,'U',0,'U',0,'V'
	dc.b	0,'V',0,'V',0,'V',0,'V'
	dc.b	0,'V',0,'W',0,'W',0,'W'
	dc.b	0,'W',0,'W',0,'W',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'Y',0,'Y',0,'Y',0,'Y'
	dc.b	0,'Y',0,'Y',0,'Z',0,'Z'
	dc.b	0,'Z',0,'Z',0,'Z',0,'['
	dc.b	0,'[',0,'[',0,'[',0,'['
	dc.b	0,'[',0,'\',0,'\',0,'\'
	dc.b	0,'\',0,'\',0,']',0,']'
	dc.b	0,']',0,']',0,']',0,'^'
	dc.b	0,'^',0,'^',0,'^',0,'^'
	dc.b	0,'_',0,'_',0,'_',0,'_'
	dc.b	0,'_',0,'_',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'a'
	dc.b	0,'a',0,'a',0,'a',0,'a'
	dc.b	0,'b',0,'b',0,'b',0,'b'
	dc.b	0,'b',0,'c',0,'c',0,'c'
	dc.b	0,'c',0,'c',0,'d',0,'d'
	dc.b	0,'d',0,'d',0,'d',0,'e'
	dc.b	0,'e',0,'e',0,'e',0,'e'
	dc.b	0,'f',0,'f',0,'f',0,'f'
	dc.b	0,'g',0,'g',0,'g',0,'g'
	dc.b	0,'g',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'i',0,'i'
	dc.b	0,'i',0,'i',0,'i',0,'j'
	dc.b	0,'j',0,'j',0,'j',0,'k'
	dc.b	0,'k',0,'k',0,'k',0,'k'
	dc.b	0,'l',0,'l',0,'l',0,'l'
	dc.b	0,'m',0,'m',0,'m',0,'m'
	dc.b	0,'m',0,'n',0,'n',0,'n'
	dc.b	0,'n',0,'o',0,'o',0,'o'
	dc.b	0,'o',0,'o',0,'p',0,'p'
	dc.b	0,'p',0,'p',0,'q',0,'q'
	dc.b	0,'q',0,'q',0,'q',0,'r'
	dc.b	0,'r',0,'r',0,'r',0,'s'
	dc.b	0,'s',0,'s',0,'s',0,'t'
	dc.b	0,'t',0,'t',0,'t',0,'u'
	dc.b	0,'u',0,'u',0,'u',0,'u'
	dc.b	0,'v',0,'v',0,'v',0,'v'
	dc.b	0,'w',0,'w',0,'w',0,'w'
	dc.b	0,'x',0,'x',0,'x',0,'x'
	dc.b	0,'y',0,'y',0,'y',0,'y'
	dc.b	0,'z',0,'z',0,'z',0,'z'
	dc.b	0,'{',0,'{',0,'{',0,'{'
	dc.b	0,'|',0,'|',0,'|',0,'|'
	dc.b	0,'}',0,'}',0,'}',0,'}'
	dc.b	0,'~',0,'~',0,'~',0,'~'
	dc.b	0,$7f,0,$7f,0,$7f,0,$7f
	dc.b	0,$80,0,$80,0,$80,0,$80
	dc.b	0,$81,0,$81,0,$81,0,$81
	dc.b	0,$82,0,$82,0,$82,0,$83
	dc.b	0,$83,0,$83,0,$83,0,$84
	dc.b	0,$84,0,$84,0,$84,0,$85
	dc.b	0,$85,0,$85,0,$85,0,$86
	dc.b	0,$86,0,$86,0,$87,0,$87
	dc.b	0,$87,0,$87,0,$88,0,$88
	dc.b	0,$88,0,$89,0,$89,0,$89
	dc.b	0,$89,0,$8a,0,$8a,0,$8a
	dc.b	0,$8a,0,$8b,0,$8b,0,$8b
	dc.b	0,$8c,0,$8c,0,$8c,0,$8c
	dc.b	0,$8d,0,$8d,0,$8d,0,$8e
	dc.b	0,$8e,0,$8e,0,$8e,0,$8f
	dc.b	0,$8f,0,$8f,0,$90,0,$90
	dc.b	0,$90,0,$90,0,$91,0,$91
	dc.b	0,$91,0,$92,0,$92,0,$92
	dc.b	0,$93,0,$93,0,$93,0,$93
	dc.b	0,$94,0,$94,0,$94,0,$95
	dc.b	0,$95,0,$95,0,$96,0,$96
	dc.b	0,$96,0,$96,0,$97,0,$97
	dc.b	0,$97,0,$98,0,$98,0,$98
	dc.b	0,$99,0,$99,0,$99,0,$9a
	dc.b	0,$9a,0,$9a,0,$9b,0,$9b
	dc.b	0,$9b,0,$9b,0,$9c,0,$9c
	dc.b	0,$9c,0,$9d,0,$9d,0,$9d
	dc.b	0,$9e,0,$9e,0,$9e,0,$9f
	dc.b	0,$9f,0,$9f,0,$a0,0,$a0
	dc.b	0,$a0,0,$a1,0,$a1,0,$a1
	dc.b	0,$a2,0,$a2,0,$a2,0,$a3
	dc.b	0,$a3,0,$a3,0,$a4,0,$a4
	dc.b	0,$a4,0,$a5,0,$a5,0,$a5
	dc.b	0,$a6,0,$a6,0,$a6,0,$a7
	dc.b	0,$a7,0,$a7,0,$a8,0,$a8
	dc.b	0,$a8,0,$a9,0,$a9,0,$a9
	dc.b	0,$aa,0,$aa,0,$aa,0,$ab
	dc.b	0,$ab,0,$ab,0,$ac,0,$ac
	dc.b	0,$ac,0,$ad,0,$ad,0,$ad
	dc.b	0,$ae,0,$ae,0,$af,0,$af
	dc.b	0,$af,0,$b0,0,$b0,0,$b0
	dc.b	0,$b1,0,$b1,0,$b1,0,$b2
	dc.b	0,$b2,0,$b2,0,$b3,0,$b3
	dc.b	0,$b4,0,$b4,0,$b4,0,$b5
	dc.b	0,$b5,0,$b5,0,$b6,0,$b6
	dc.b	0,$b6,0,$b7,0,$b7,0,$b8
	dc.b	0,$b8,0,$b8,0,$b9,0,$b9
	dc.b	0,$b9,0,$ba,0,$ba,0,$bb
	dc.b	0,$bb,0,$bb,0,$bc,0,$bc
	dc.b	0,$bd,0,$bd,0,$bd,0,$be
	dc.b	0,$be,0,$be,0,$bf,0,$bf
	dc.b	0,$c0,0,$c0,0,$c0,0,$c1
	dc.b	0,$c1,0,$c2,0,$c2,0,$c2
	dc.b	0,$c3,0,$c3,0,$c4,0,$c4
	dc.b	0,$c4,0,$c5,0,$c5,0,$c6
	dc.b	0,$c6,0,$c6,0,$c7,0,$c7
	dc.b	0,$c8,0,$c8,0,$c8,0,$c9
	dc.b	0,$c9,0,$ca,0,$ca,0,$ca
	dc.b	0,$cb,0,$cb,0,$cc,0,$cc
	dc.b	0,$cc,0,$cd,0,$cd,0,$ce
	dc.b	0,$ce,0,$cf,0,$cf,0,$cf
	dc.b	0,$d0,0,$d0,0,$d1,0,$d1
	dc.b	0,$d2,0,$d2,0,$d2,0,$d3
	dc.b	0,$d3,0,$d4,0,$d4,0,$d5
	dc.b	0,$d5,0,$d5,0,$d6,0,$d6
	dc.b	0,$d7,0,$d7,0,$d8,0,$d8
	dc.b	0,$d8,0,$d9,0,$d9,0,$da
	dc.b	0,$da,0,$db,0,$db,0,$dc
	dc.b	0,$dc,0,$dc,0,$dd,0,$dd
	dc.b	0,$de,0,$de,0,$df,0,$df
	dc.b	0,$e0,0,$e0,0,$e0,0,$e1
	dc.b	0,$e1,0,$e2,0,$e2,0,$e3
	dc.b	0,$e3,0,$e4,0,$e4,0,$e5
	dc.b	0,$e5,0,$e6,0,$e6,0,$e7
	dc.b	0,$e7,0,$e7,0,$e8,0,$e8
	dc.b	0,$e9,0,$e9,0,$ea,0,$ea
	dc.b	0,$eb,0,$eb,0,$ec,0,$ec
	dc.b	0,$ed,0,$ed,0,$ee,0,$ee
	dc.b	0,$ef,0,$ef,0,$f0,0,$f0
	dc.b	0,$f1,0,$f1,0,$f2,0,$f2
	dc.b	0,$f3,0,$f3,0,$f3,0,$f4
	dc.b	0,$f4,0,$f5,0,$f5,0,$f6
	dc.b	0,$f6,0,$f7,0,$f7,0,$f8
	dc.b	0,$f8,0,$f9,0,$f9,0,$fa
	dc.b	0,$fb,0,$fb,0,$fc,0,$fc
	dc.b	0,$fd,0,$fd,0,$fe,0,$fe
	dc.b	0,$ff,0,$ff,1,0,1,0
	dc.b	1,1,1,1,1,2,1,2
	dc.b	1,3,1,3,1,4,1,4
	dc.b	1,5,1,5,1,6,1,6
	dc.b	1,7,1,8,1,8,1,9
	dc.b	1,9,1,$a,1,$a,1,$b
	dc.b	1,$b,1,$c,1,$c,1,$d
	dc.b	1,$e,1,$e,1,$f,1,$f
	dc.b	1,$10,1,$10,1,$11,1,$11
	dc.b	1,$12,1,$12,1,$13,1,$14
	dc.b	1,$14,1,$15,1,$15,1,$16
	dc.b	1,$16,1,$17,1,$18,1,$18
	dc.b	1,$19,1,$19,1,$1a,1,$1a
	dc.b	1,$1b,1,$1c,1,$1c,1,$1d
	dc.b	1,$1d,1,$1e,1,$1e,1,$1f
	dc.b	1,' ',1,' ',1,'!',1,'!'
	dc.b	1,'"',1,'#',1,'#',1,'$'
	dc.b	1,'$',1,'%',1,'&',1,'&'
	dc.b	1,$27,1,$27,1,'(',1,')'
	dc.b	1,')',1,'*',1,'*',1,'+'
	dc.b	1,',',1,',',1,'-',1,'-'
	dc.b	1,'.',1,'/',1,'/',1,'0'
	dc.b	1,'0',1,'1',1,'2',1,'2'
	dc.b	1,'3',1,'4',1,'4',1,'5'
	dc.b	1,'5',1,'6',1,'7',1,'7'
	dc.b	1,'8',1,'9',1,'9',1,':'
	dc.b	1,':',1,';',1,'<',1,'<'
	dc.b	1,'=',1,'>',1,'>',1,'?'
	dc.b	1,'@',1,'@',1,'A',1,'B'
	dc.b	1,'B',1,'C',1,'D',1,'D'
	dc.b	1,'E',1,'F',1,'F',1,'G'
	dc.b	1,'H',1,'H',1,'I',1,'J'
	dc.b	1,'J',1,'K',1,'L',1,'L'
	dc.b	1,'M',1,'N',1,'N',1,'O'
	dc.b	1,'P',1,'P',1,'Q',1,'R'
	dc.b	1,'R',1,'S',1,'T',1,'T'
	dc.b	1,'U',1,'V',1,'V',1,'W'
	dc.b	1,'X',1,'Y',1,'Y',1,'Z'
	dc.b	1,'[',1,'[',1,'\',1,']'
	dc.b	1,'^',1,'^',1,'_',1,'`'
	dc.b	1,'`',1,'a',1,'b',1,'c'
	dc.b	1,'c',1,'d',1,'e',1,'e'
	dc.b	1,'f',1,'g',1,'h',1,'h'
	dc.b	1,'i',1,'j',1,'k',1,'k'
	dc.b	1,'l',1,'m',1,'m',1,'n'
	dc.b	1,'o',1,'p',1,'p',1,'q'
	dc.b	1,'r',1,'s',1,'s',1,'t'
	dc.b	1,'u',1,'v',1,'w',1,'w'
	dc.b	1,'x',1,'y',1,'z',1,'z'
	dc.b	1,'{',1,'|',1,'}',1,'}'
	dc.b	1,'~',1,$7f,1,$80,1,$81
	dc.b	1,$81,1,$82,1,$83,1,$84
	dc.b	1,$84,1,$85,1,$86,1,$87
	dc.b	1,$88,1,$88,1,$89,1,$8a
	dc.b	1,$8b,1,$8c,1,$8c,1,$8d
	dc.b	1,$8e,1,$8f,1,$90,1,$90
	dc.b	1,$91,1,$92,1,$93,1,$94
	dc.b	1,$95,1,$95,1,$96,1,$97
	dc.b	1,$98,1,$99,1,$9a,1,$9a
	dc.b	1,$9b,1,$9c,1,$9d,1,$9e
	dc.b	1,$9f,1,$9f,1,$a0,1,$a1
	dc.b	1,$a2,1,$a3,1,$a4,1,$a4
	dc.b	1,$a5,1,$a6,1,$a7,1,$a8
	dc.b	1,$a9,1,$aa,1,$aa,1,$ab
	dc.b	1,$ac,1,$ad,1,$ae,1,$af
	dc.b	1,$b0,1,$b1,1,$b1,1,$b2
	dc.b	1,$b3,1,$b4,1,$b5,1,$b6
	dc.b	1,$b7,1,$b8,1,$b9,1,$b9
	dc.b	1,$ba,1,$bb,1,$bc,1,$bd
	dc.b	1,$be,1,$bf,1,$c0,1,$c1
	dc.b	1,$c2,1,$c3,1,$c3,1,$c4
	dc.b	1,$c5,1,$c6,1,$c7,1,$c8
	dc.b	1,$c9,1,$ca,1,$cb,1,$cc
	dc.b	1,$cd,1,$ce,1,$cf,1,$d0
	dc.b	1,$d0,1,$d1,1,$d2,1,$d3
	dc.b	1,$d4,1,$d5,1,$d6,1,$d7
	dc.b	1,$d8,1,$d9,1,$da,1,$db
	dc.b	1,$dc,1,$dd,1,$de,1,$df
	dc.b	1,$e0,1,$e1,1,$e2,1,$e3
	dc.b	1,$e4,1,$e5,1,$e6,1,$e7
	dc.b	1,$e8,1,$e9,1,$ea,1,$eb
	dc.b	1,$ec,1,$ed,1,$ee,1,$ef
	dc.b	1,$f0,1,$f1,1,$f2,1,$f3
	dc.b	1,$f4,1,$f5,1,$f6,1,$f7
	dc.b	1,$f8,1,$f9,1,$fa,1,$fb
	dc.b	1,$fc,1,$fd,1,$fe,1,$ff
	dc.b	2,0,2,1,2,2,2,3
	dc.b	2,4,2,5,2,6,2,7
	dc.b	2,8,2,9,2,$b,2,$c
	dc.b	2,$d,2,$e,2,$f,2,$10
	dc.b	2,$11,2,$12,2,$13,2,$14
	dc.b	2,$15,2,$16,2,$17,2,$18
	dc.b	2,$1a,2,$1b,2,$1c,2,$1d
	dc.b	2,$1e,2,$1f,2,' ',2,'!'
	dc.b	2,'"',2,'#',2,'%',2,'&'
	dc.b	2,$27,2,'(',2,')',2,'*'
	dc.b	2,'+',2,',',2,'.',2,'/'
	dc.b	2,'0',2,'1',2,'2',2,'3'
	dc.b	2,'4',2,'6',2,'7',2,'8'
	dc.b	2,'9',2,':',2,';',2,'='
	dc.b	2,'>',2,'?',2,'@',2,'A'
	dc.b	2,'B',2,'D',2,'E',2,'F'
	dc.b	2,'G',2,'H',2,'I',2,'K'
	dc.b	2,'L',2,'M',2,'N',2,'O'
	dc.b	2,'Q',2,'R',2,'S',2,'T'
	dc.b	2,'U',2,'W',2,'X',2,'Y'
	dc.b	2,'Z',2,'\',2,']',2,'^'
	dc.b	2,'_',2,'`',2,'b',2,'c'
	dc.b	2,'d',2,'e',2,'g',2,'h'
	dc.b	2,'i',2,'j',2,'l',2,'m'
	dc.b	2,'n',2,'o',2,'q',2,'r'
	dc.b	2,'s',2,'u',2,'v',2,'w'
	dc.b	2,'x',2,'z',2,'{',2,'|'
	dc.b	2,'~',2,$7f,2,$80,2,$81
	dc.b	2,$83,2,$84,2,$85,2,$87
	dc.b	2,$88,2,$89,2,$8b,2,$8c
	dc.b	2,$8d,2,$8f,2,$90,2,$91
	dc.b	2,$93,2,$94,2,$95,2,$97
	dc.b	2,$98,2,$99,2,$9b,2,$9c
	dc.b	2,$9d,2,$9f,2,$a0,2,$a1
	dc.b	2,$a3,2,$a4,2,$a6,2,$a7
	dc.b	2,$a8,2,$aa,2,$ab,2,$ad
	dc.b	2,$ae,2,$af,2,$b1,2,$b2
	dc.b	2,$b4,2,$b5,2,$b6,2,$b8
	dc.b	2,$b9,2,$bb,2,$bc,2,$bd
	dc.b	2,$bf,2,$c0,2,$c2,2,$c3
	dc.b	2,$c5,2,$c6,2,$c7,2,$c9
	dc.b	2,$ca,2,$cc,2,$cd,2,$cf
	dc.b	2,$d0,2,$d2,2,$d3,2,$d5
	dc.b	2,$d6,2,$d8,2,$d9,2,$da
	dc.b	2,$dc,2,$dd,2,$df,2,$e0
	dc.b	2,$e2,2,$e3,2,$e5,2,$e6
	dc.b	2,$e8,2,$e9,2,$eb,2,$ec
	dc.b	2,$ee,2,$f0,2,$f1,2,$f3
	dc.b	2,$f4,2,$f6,2,$f7,2,$f9
	dc.b	2,$fa,2,$fc,2,$fd,2,$ff
	dc.b	3,1,3,2,3,4,3,5
	dc.b	3,7,3,8,3,$a,3,$c
	dc.b	3,$d,3,$f,3,$10,3,$12
	dc.b	3,$13,3,$15,3,$17,3,$18
	dc.b	3,$1a,3,$1c,3,$1d,3,$1f
	dc.b	3,' ',3,'"',3,'$',3,'%'
	dc.b	3,$27,3,')',3,'*',3,','
	dc.b	3,'-',3,'/',3,'1',3,'2'
	dc.b	3,'4',3,'6',3,'7',3,'9'
	dc.b	3,';',3,'<',3,'>',3,'@'
	dc.b	3,'B',3,'C',3,'E',3,'G'
	dc.b	3,'H',3,'J',3,'L',3,'M'
	dc.b	3,'O',3,'Q',3,'S',3,'T'
	dc.b	3,'V',3,'X',3,'Z',3,'['
	dc.b	3,']',3,'_',3,'a',3,'b'
	dc.b	3,'d',3,'f',3,'h',3,'i'
	dc.b	3,'k',3,'m',3,'o',3,'q'
	dc.b	3,'r',3,'t',3,'v',3,'x'
	dc.b	3,'z',3,'{',3,'}',3,$7f
	dc.b	3,$81,3,$83,3,$84,3,$86
	dc.b	3,$88,3,$8a,3,$8c,3,$8e
	dc.b	3,$8f,3,$91,3,$93,3,$95
	dc.b	3,$97,3,$99,3,$9b,3,$9d
	dc.b	3,$9e,3,$a0,3,$a2,3,$a4
	dc.b	3,$a6,3,$a8,3,$aa,3,$ac
	dc.b	3,$ae,3,$af,3,$b1,3,$b3
	dc.b	3,$b5,3,$b7,3,$b9,3,$bb
	dc.b	3,$bd,3,$bf,3,$c1,3,$c3
	dc.b	3,$c5,3,$c7,3,$c9,3,$cb
	dc.b	3,$cd,3,$cf,3,$d1,3,$d3
	dc.b	3,$d5,3,$d7,3,$d9,3,$db
	dc.b	3,$dd,3,$df,3,$e1,3,$e3
	dc.b	3,$e5,3,$e7,3,$e9,3,$eb
	dc.b	3,$ed,3,$ef,3,$f1,3,$f3
	dc.b	3,$f5,3,$f7,3,$f9,3,$fb
	dc.b	3,$fd,3,$ff,4,1,4,3
	dc.b	4,6,4,8,4,$a,4,$c
	dc.b	4,$e,4,$10,4,$12,4,$14
	dc.b	4,$16,4,$19,4,$1b,4,$1d
	dc.b	4,$1f,4,'!',4,'#',4,'%'
	dc.b	4,'(',4,'*',4,',',4,'.'
	dc.b	4,'0',4,'2',4,'5',4,'7'
	dc.b	4,'9',4,';',4,'=',4,'@'
	dc.b	4,'B',4,'D',4,'F',4,'H'
	dc.b	4,'K',4,'M',4,'O',4,'Q'
	dc.b	4,'T',4,'V',4,'X',4,'Z'
	dc.b	4,']',4,'_',4,'a',4,'d'
	dc.b	4,'f',4,'h',4,'j',4,'m'
	dc.b	4,'o',4,'q',4,'t',4,'v'
	dc.b	4,'x',4,'{',4,'}',4,$7f
	dc.b	4,$82,4,$84,4,$86,4,$89
	dc.b	4,$8b,4,$8d,4,$90,4,$92
	dc.b	4,$94,4,$97,4,$99,4,$9c
	dc.b	4,$9e,4,$a0,4,$a3,4,$a5
	dc.b	4,$a8,4,$aa,4,$ad,4,$af
	dc.b	4,$b1,4,$b4,4,$b6,4,$b9
	dc.b	4,$bb,4,$be,4,$c0,4,$c3
	dc.b	4,$c5,4,$c8,4,$ca,4,$cd
	dc.b	4,$cf,4,$d2,4,$d4,4,$d7
	dc.b	4,$d9,4,$dc,4,$de,4,$e1
	dc.b	4,$e3,4,$e6,4,$e8,4,$eb
	dc.b	4,$ed,4,$f0,4,$f3,4,$f5
	dc.b	4,$f8,4,$fa,4,$fd,4,$ff
	dc.b	5,2,5,5,5,7,5,$a
	dc.b	5,$c,5,$f,5,$12,5,$14
	dc.b	5,$17,5,$1a,5,$1c,5,$1f
	dc.b	5,'"',5,'$',5,$27,5,'*'
	dc.b	5,',',5,'/',5,'2',5,'4'
	dc.b	5,'7',5,':',5,'=',5,'?'
	dc.b	5,'B',5,'E',5,'H',5,'J'
	dc.b	5,'M',5,'P',5,'S',5,'U'
	dc.b	5,'X',5,'[',5,'^',5,'`'
	dc.b	5,'c',5,'f',5,'i',5,'l'
	dc.b	5,'o',5,'q',5,'t',5,'w'
	dc.b	5,'z',5,'}',5,$80,5,$82
	dc.b	5,$85,5,$88,5,$8b,5,$8e
	dc.b	5,$91,5,$94,5,$97,5,$9a
	dc.b	5,$9c,5,$9f,5,$a2,5,$a5
	dc.b	5,$a8,5,$ab,5,$ae,5,$b1
	dc.b	5,$b4,5,$b7,5,$ba,5,$bd
	dc.b	5,$c0,5,$c3,5,$c6,5,$c9
	dc.b	5,$cc,5,$cf,5,$d2,5,$d5
	dc.b	5,$d8,5,$db,5,$de,5,$e1
	dc.b	5,$e4,5,$e7,5,$ea,5,$ed
	dc.b	5,$f0,5,$f4,5,$f7,5,$fa
	dc.b	5,$fd,6,0,6,3,6,6
	dc.b	6,9,6,$d,6,$10,6,$13
	dc.b	6,$16,6,$19,6,$1c,6,' '
	dc.b	6,'#',6,'&',6,')',6,','
	dc.b	6,'0',6,'3',6,'6',6,'9'
	dc.b	6,'<',6,'@',6,'C',6,'F'
	dc.b	6,'I',6,'M',6,'P',6,'S'
	dc.b	6,'W',6,'Z',6,']',6,'`'
	dc.b	6,'d',6,'g',6,'j',6,'n'
	dc.b	6,'q',6,'t',6,'x',6,'{'
	dc.b	6,$7f,6,$82,6,$85,6,$89
	dc.b	6,$8c,6,$90,6,$93,6,$96
	dc.b	6,$9a,6,$9d,6,$a1,6,$a4
	dc.b	6,$a8,6,$ab,6,$af,6,$b2
	dc.b	6,$b5,6,$b9,6,$bc,6,$c0
	dc.b	6,$c4,6,$c7,6,$cb,6,$ce
	dc.b	6,$d2,6,$d5,6,$d9,6,$dc
	dc.b	6,$e0,6,$e3,6,$e7,6,$eb
	dc.b	6,$ee,6,$f2,6,$f5,6,$f9
	dc.b	6,$fd,7,0,7,4,7,8
	dc.b	7,$b,7,$f,7,$13,7,$16
	dc.b	7,$1a,7,$1e,7,'!',7,'%'
	dc.b	7,')',7,'-',7,'0',7,'4'
	dc.b	7,'8',7,'<',7,'?',7,'C'
	dc.b	7,'G',7,'K',7,'N',7,'R'
	dc.b	7,'V',7,'Z',7,'^',7,'b'
	dc.b	7,'e',7,'i',7,'m',7,'q'
	dc.b	7,'u',7,'y',7,'}',7,$80
	dc.b	7,$84,7,$88,7,$8c,7,$90
	dc.b	7,$94,7,$98,7,$9c,7,$a0
	dc.b	7,$a4,7,$a8,7,$ac,7,$b0
	dc.b	7,$b4,7,$b8,7,$bc,7,$c0
	dc.b	7,$c4,7,$c8,7,$cc,7,$d0
	dc.b	7,$d4,7,$d8,7,$dc,7,$e0
	dc.b	7,$e4,7,$e9,7,$ed,7,$f1
	dc.b	7,$f5,7,$f9,7,$fd,8,1
	dc.b	8,6,8,$a,8,$e,8,$12
	dc.b	8,$16,8,$1b,8,$1f,8,'#'
	dc.b	8,$27,8,'+',8,'0',8,'4'
	dc.b	8,'8',8,'<',8,'A',8,'E'
	dc.b	8,'I',8,'N',8,'R',8,'V'
	dc.b	8,'[',8,'_',8,'c',8,'h'
	dc.b	8,'l',8,'p',8,'u',8,'y'
	dc.b	8,'~',8,$82,8,$87,8,$8b
	dc.b	8,$8f,8,$94,8,$98,8,$9d
	dc.b	8,$a1,8,$a6,8,$aa,8,$af
	dc.b	8,$b3,8,$b8,8,$bc,8,$c1
	dc.b	8,$c5,8,$ca,8,$cf,8,$d3
	dc.b	8,$d8,8,$dc,8,$e1,8,$e6
	dc.b	8,$ea,8,$ef,8,$f4,8,$f8
	dc.b	8,$fd,9,2,9,6,9,$b
	dc.b	9,$10,9,$14,9,$19,9,$1e
	dc.b	9,'#',9,$27,9,',',9,'1'
	dc.b	9,'6',9,':',9,'?',9,'D'
	dc.b	9,'I',9,'N',9,'S',9,'W'
	dc.b	9,'\',9,'a',9,'f',9,'k'
	dc.b	9,'p',9,'u',9,'z',9,$7f
	dc.b	9,$83,9,$88,9,$8d,9,$92
	dc.b	9,$97,9,$9c,9,$a1,9,$a6
	dc.b	9,$ab,9,$b0,9,$b5,9,$bb
	dc.b	9,$c0,9,$c5,9,$ca,9,$cf
	dc.b	9,$d4,9,$d9,9,$de,9,$e3
	dc.b	9,$e8,9,$ee,9,$f3,9,$f8
	dc.b	9,$fd,$a,2,$a,8,$a,$d
	dc.b	$a,$12,$a,$17,$a,$1c,$a,'"'
	dc.b	$a,$27,$a,',',$a,'2',$a,'7'
	dc.b	$a,'<',$a,'B',$a,'G',$a,'L'
	dc.b	$a,'R',$a,'W',$a,'\',$a,'b'
	dc.b	$a,'g',$a,'m',$a,'r',$a,'w'
	dc.b	$a,'}',$a,$82,$a,$88,$a,$8d
	dc.b	$a,$93,$a,$98,$a,$9e,$a,$a3
	dc.b	$a,$a9,$a,$ae,$a,$b4,$a,$b9
	dc.b	$a,$bf,$a,$c5,$a,$ca,$a,$d0
	dc.b	$a,$d6,$a,$db,$a,$e1,$a,$e6
	dc.b	$a,$ec,$a,$f2,$a,$f8,$a,$fd
	dc.b	$b,3,$b,9,$b,$e,$b,$14
	dc.b	$b,$1a,$b,' ',$b,'%',$b,'+'
	dc.b	$b,'1',$b,'7',$b,'=',$b,'C'
	dc.b	$b,'H',$b,'N',$b,'T',$b,'Z'
	dc.b	$b,'`',$b,'f',$b,'l',$b,'r'
	dc.b	$b,'x',$b,'~',$b,$84,$b,$8a
	dc.b	$b,$90,$b,$96,$b,$9c,$b,$a2
	dc.b	$b,$a8,$b,$ae,$b,$b4,$b,$ba
	dc.b	$b,$c0,$b,$c6,$b,$cc,$b,$d3
	dc.b	$b,$d9,$b,$df,$b,$e5,$b,$eb
	dc.b	$b,$f1,$b,$f8,$b,$fe,$c,4
	dc.b	$c,$a,$c,$11,$c,$17,$c,$1d
	dc.b	$c,'$',$c,'*',$c,'0',$c,'7'
	dc.b	$c,'=',$c,'C',$c,'J',$c,'P'
	dc.b	$c,'V',$c,']',$c,'c',$c,'j'
	dc.b	$c,'p',$c,'w',$c,'}',$c,$84
	dc.b	$c,$8a,$c,$91,$c,$97,$c,$9e
	dc.b	$c,$a4,$c,$ab,$c,$b2,$c,$b8
	dc.b	$c,$bf,$c,$c5,$c,$cc,$c,$d3
	dc.b	$c,$d9,$c,$e0,$c,$e7,$c,$ed
	dc.b	$c,$f4,$c,$fb,$d,2,$d,8
	dc.b	$d,$f,$d,$16,$d,$1d,$d,'$'
	dc.b	$d,'+',$d,'1',$d,'8',$d,'?'
	dc.b	$d,'F',$d,'M',$d,'T',$d,'['
	dc.b	$d,'b',$d,'i',$d,'p',$d,'w'
	dc.b	$d,'~',$d,$85,$d,$8c,$d,$93
	dc.b	$d,$9a,$d,$a1,$d,$a8,$d,$af
	dc.b	$d,$b6,$d,$bd,$d,$c5,$d,$cc
	dc.b	$d,$d3,$d,$da,$d,$e1,$d,$e8
	dc.b	$d,$f0,$d,$f7,$d,$fe,$e,6
	dc.b	$e,$d,$e,$14,$e,$1b,$e,'#'
	dc.b	$e,'*',$e,'2',$e,'9',$e,'@'
	dc.b	$e,'H',$e,'O',$e,'W',$e,'^'
	dc.b	$e,'f',$e,'m',$e,'u',$e,'|'
	dc.b	$e,$84,$e,$8b,$e,$93,$e,$9a
	dc.b	$e,$a2,$e,$aa,$e,$b1,$e,$b9
	dc.b	$e,$c0,$e,$c8,$e,$d0,$e,$d8
	dc.b	$e,$df,$e,$e7,$e,$ef,$e,$f7
	dc.b	$e,$fe,$f,6,$f,$e,$f,$16
	dc.b	$f,$1e,$f,'%',$f,'-',$f,'5'
	dc.b	$f,'=',$f,'E',$f,'M',$f,'U'
	dc.b	$f,']',$f,'e',$f,'m',$f,'u'
	dc.b	$f,'}',$f,$85,$f,$8d,$f,$95
	dc.b	$f,$9d,$f,$a6,$f,$ae,$f,$b6
	dc.b	$f,$be,$f,$c6,$f,$ce,$f,$d7
	dc.b	$f,$df,$f,$e7,$f,$ef,$f,$f8
	bss
nbrvoies	ds.l	1
current_track	ds.w	1
dsp_plein	ds.w	1
master_vol	ds.w	1
vblsize	ds.w	1
flag_stop_voices	ds.w	1
flag_the_end	ds.w	1
flag_mt_display	ds.w	1
module_inf1	ds.b	1024
l00eb	ds.l	1
l00ec	ds.l	1
l00ed	ds.l	1
l00ee	ds.l	1
module_inf2	ds.w	1
l00f0	ds.w	1
l00f1	ds.w	1
l00f2	ds.w	1
l00f3	ds.w	1
l00f4	ds.w	1
l00f5	ds.w	1
l00f6	ds.w	1
l00f7	ds.w	1
l00f8	ds.w	1
info_track	ds.b	35
l00fa	ds.b	2461
sample_vide	ds.l	1
repeatbuffer	ds.b	262144
adrlodnom	ds.l	1
routine_dsp	ds.b	10000
routine_dsp_lon	ds.l	1
zuend	end
