#define MENUE 0  	/* TREE */
#define DESK 3  	/* OBJECT in TREE #0 */
#define INFO 7  	/* OBJECT in TREE #0 */
#define DATEI 4  	/* OBJECT in TREE #0 */
#define FPL1 16  	/* OBJECT in TREE #0 */
#define FPL2 17  	/* OBJECT in TREE #0 */
#define FPL3 18  	/* OBJECT in TREE #0 */
#define QUIT 20  	/* OBJECT in TREE #0 */
