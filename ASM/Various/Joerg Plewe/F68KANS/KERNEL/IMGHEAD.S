.TEXT

magic:          DC.W 'JP'
iscodelen:      DC.L HERE-sys
isdatalen:      DC.L dataHERE-datas
                DS.W 9          ;yet unused

