*
* the F68KANS provided messages
*
.DATA

msg_undef:		ASCIIL '<undefined error code, remained on stack> '

.EVEN
msg_stkunder:	ASCIIL '<stack underflow> '

.EVEN

msg_unknown:	ASCIIL ' unknown!'
.EVEN

msg_restrict:	ASCIIL ' compile only!'
.EVEN

msg_divbyzero:	ASCIIL '<division by zero>'
.EVEN

msg_outofrange: ASCIIL '<result out of range>'
.EVEN

msg_emptyname:	ASCIIL '<empty string for header!>'
.EVEN

msg_notunique:	ASCIIL ' is not unique!'
.EVEN

msg_filenotfound: ASCIIL 'non-existent file: '
.EVEN
