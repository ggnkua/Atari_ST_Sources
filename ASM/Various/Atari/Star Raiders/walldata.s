*
*	WALLDATA.S	ST Star-Raiders Word-Aligned Image Data
*

*
*	PUBLIC SYMBOLS
*
	.globl	bzimgtbl
	.globl	gmapwal
	.globl	titlewal

	.globl	timebzy
timebzy	.equ	0
	.globl	swepbzy
swepbzy	.equ	timebzy+9
	.globl	basebzy
basebzy	.equ	swepbzy+8
	.globl	rockbzy
rockbzy	.equ	basebzy+8
	.globl	shipbzy
shipbzy	.equ	rockbzy+8
	.globl	rollbzy
rollbzy	.equ	shipbzy+7
	.globl	damgbzy
damgbzy	.equ	rollbzy+8
	.globl	hyprbzy
hyprbzy	.equ	damgbzy+9

	.data
*
*	Main Buzy Box Image Data Table
*
bzimgtbl:
	.dc.l	bzimg15		* Numbers
	.dc.l	bzimg13
	.dc.l	bzimg11
	.dc.l	bzimg9
	.dc.l	bzimg7
	.dc.l	bzimg5
	.dc.l	bzimg3
	.dc.l	bzimg1
	.dc.l	bzimgn

	.dc.l	bzimg14		* Sweeep Hand
	.dc.l	bzimg12
	.dc.l	bzimg10
	.dc.l	bzimg8
	.dc.l	bzimg6
	.dc.l	bzimg4
	.dc.l	bzimg2
	.dc.l	bzimg0

	.dc.l	bzimg16		* StarBase
	.dc.l	bzimg17
	.dc.l	bzimg18
	.dc.l	bzimg19
	.dc.l	bzimg20
	.dc.l	bzimg21
	.dc.l	bzimg22
	.dc.l	bzimg23

	.dc.l	bzimg24		* Asteroid
	.dc.l	bzimg25
	.dc.l	bzimg26
	.dc.l	bzimg27
	.dc.l	bzimg28
	.dc.l	bzimg29
	.dc.l	bzimg30
	.dc.l	bzimg31

	.dc.l	bzimg35		* Ship Types
	.dc.l	bzimg33
	.dc.l	bzimg37
	.dc.l	bzimg32
	.dc.l	bzimg38
	.dc.l	bzimg36
	.dc.l	bzimg34

	.dc.l	bzimg40		* Video Roll
	.dc.l	bzimg41
	.dc.l	bzimg42
	.dc.l	bzimg43
	.dc.l	bzimg44
	.dc.l	bzimg45
	.dc.l	bzimg46
	.dc.l	bzimg47

	.dc.l	bzimg50		* Damaged Devices
	.dc.l	bzimg51
	.dc.l	bzimg52
	.dc.l	bzimg53
	.dc.l	bzimg54
	.dc.l	bzimg55
	.dc.l	bzimg56
	.dc.l	bzimg57
	.dc.l	bzimg58

	.dc.l	bzimg60		* HyperWarp "thinking"
	.dc.l	bzimg61
	.dc.l	bzimg62
	.dc.l	bzimg63
	.dc.l	bzimg64
	.dc.l	bzimg65
	.dc.l	bzimg66
	.dc.l	bzimg67


*
*	Title Screen Viewer
*
titlewal:			* Handsome Title Screen Aftview
	.dc.w	64,32
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0015,$0015,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0050,$0550,$0550,$0005,$4000,$5400,$5400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$8000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0505,$152A,$1520,$0055,$4400,$8500,$8500,$5000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0011,$0071,$000E,$0000,$0000,$C000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1416,$1481,$142A,$0155,$1500,$6500,$8500,$5000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0098,$0187,$007F,$0007,$A000,$3000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$10B2,$528D,$522A,$055F,$2100,$F940,$8940,$D400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0137,$0308,$00FC,$000C,$D000,$1800,$E000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0040,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1036,$5209,$50AA,$055F,$1100,$C940,$A140,$D400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0130,$030F,$00FF,$000F,$5000,$9800,$E000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$103D,$5202,$50AA,$0557,$D100,$0940,$A140,$5400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$009F,$0380,$027F,$0000,$9000,$1800,$E800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$108F,$5080,$502A,$0555,$6100,$2140,$8140,$5400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$00C0,$003F,$0000,$4000,$6000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0007,$0007
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0420,$1420,$140A,$0155,$8400,$8500,$0500,$5000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$003F,$0020,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0500,$1500,$1500,$0055,$1400,$1500,$1500,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4710,$0200,$0001
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4510,$4F90,$0000,$0000
	.dc.w	$0100,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8055,$0555,$0555,$0000,$4000,$5400,$5400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0F80,$1AC0,$4510,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6230,$3DE0,$4213,$0203
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0015,$0015,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0D80,$5AD0,$0500,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0000,$0000,$0000,$0500,$4F90,$0200,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0500,$0000,$0001
	.dc.w	$0800,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0020,$0020
	.dc.w	$0000,$0000,$8208,$8208,$0000,$0000,$2080,$2080
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$2082,$2082
	.dc.w	$0000,$0000,$0800,$0800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0020,$0024
	.dc.w	$0000,$0000,$8208,$9249,$0000,$0000,$2080,$2488
	.dc.w	$0000,$0000,$0208,$2249,$0000,$0000,$2082,$2492
	.dc.w	$0000,$0000,$0800,$4800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0001
	.dc.w	$0400,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0200,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$8000,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0198,$001C,$01E0,$0100,$1700,$7000,$0E00,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0028,$03CE,$03F0,$0300,$2980,$E600,$1F80,$0180
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0014,$04E6,$05F8,$0400,$5140,$CE00,$3F40,$0040
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0001
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0117,$09E7,$08F8,$0800,$D100,$CE20,$3F20,$0020
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0098,$10F8,$1067,$1020,$3200,$3E10,$CC10,$0810
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2023,$00E0,$285F,$0040,$C808,$0E00,$F428,$0400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$C000,$C000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4466,$04A1,$40DF,$0081,$EC44,$0A40,$F604,$C200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00CD,$0242,$21BF,$0003,$F600,$0480,$3B0A,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$13CC,$1243,$01BF,$0003,$F511,$0411,$BB80,$A000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$634C,$60C3,$1FBF,$0003,$558F,$A60F,$FBF0,$E000
	.dc.w	$1000,$E000,$1000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1C66,$7C21,$03DF,$0001,$2C70,$C87F,$F783,$C000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$63A3,$1FA0,$605F,$0000,$CB8E,$0BF3,$F40C,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3CD8,$03D8,$7C27,$0000,$367A,$3782,$C87C,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0080,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4637,$40F7,$3F08,$0000,$D8C4,$DE04,$21F8,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3809,$79F8,$07C7,$0000,$2038,$3F38,$C7C0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0645,$1FEC,$0183,$0000,$44C0,$6FF0,$8300,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0005,$0784,$0003,$0000,$4000,$43C0,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0006,$0000,$0000,$8000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0002,$0001,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0001,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0200,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$001F,$001C,$0010,$000F
	.dc.w	$FC00,$1C00,$0400,$F800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0038,$0030,$0027,$0017
	.dc.w	$0E00,$0E00,$F200,$FC00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0038,$0018,$0007,$003F
	.dc.w	$0C00,$0E00,$F000,$FE00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

*
*	Galactic Map Grid
*
gmapwal:			* Galactic Map (Empty Grid)
	.dc.w	64,32
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$2800,$2800
	.dc.w	$0000,$0000,$0A00,$0A00,$0000,$0000,$0280,$0280
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0028,$0028
	.dc.w	$0000,$0000,$000A,$000A,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$1000,$1000,$0000,$0000,$4400,$4400
	.dc.w	$0000,$0000,$1100,$1100,$0000,$0000,$0440,$0440
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$0044,$0044
	.dc.w	$0000,$0000,$0011,$0011,$0000,$0000,$0004,$0004
	.dc.w	$0000,$0000,$4800,$4800,$0000,$0000,$8200,$8200
	.dc.w	$0000,$0000,$2080,$2080,$0000,$0000,$0820,$0820
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$0082,$0082
	.dc.w	$0000,$0000,$0020,$0020,$0000,$0000,$8009,$8009
	.dc.w	$0000,$0000,$0401,$0401,$0000,$0000,$0100,$0100
	.dc.w	$0000,$0000,$4040,$4040,$0000,$0000,$1010,$1010
	.dc.w	$0000,$0000,$0404,$0404,$0000,$0000,$0101,$0101
	.dc.w	$0000,$0000,$0040,$0040,$0000,$0000,$4010,$4010
	.dc.w	$0000,$0000,$5202,$5202,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$8020,$8020,$0000,$0000,$2008,$2008
	.dc.w	$0000,$0000,$0802,$0802,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$8080,$8080,$0000,$0000,$2025,$2025
	.dc.w	$0000,$0000,$0104,$0104,$0000,$0000,$0041,$0041
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$4004,$4004
	.dc.w	$0000,$0000,$1001,$1001,$0000,$0000,$0400,$0400
	.dc.w	$0000,$0000,$4100,$4100,$0000,$0000,$1040,$1040
	.dc.w	$0000,$0000,$5488,$5488,$0000,$0000,$0022,$0022
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$8002,$8002
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$8800,$8800
	.dc.w	$0000,$0000,$2200,$2200,$0000,$0000,$0895,$0895
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0014,$0014
	.dc.w	$0000,$0000,$0005,$0005,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$4000,$4000,$0000,$0000,$5000,$5000
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$552A,$552A,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AA55,$AA55
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0014,$0014
	.dc.w	$0000,$0000,$0005,$0005,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$4000,$4000,$0000,$0000,$5000,$5000
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$5488,$5488,$0000,$0000,$0022,$0022
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$8002,$8002
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$8800,$8800
	.dc.w	$0000,$0000,$2200,$2200,$0000,$0000,$0895,$0895
	.dc.w	$0000,$0000,$0104,$0104,$0000,$0000,$0041,$0041
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$4004,$4004
	.dc.w	$0000,$0000,$1001,$1001,$0000,$0000,$0400,$0400
	.dc.w	$0000,$0000,$4100,$4100,$0000,$0000,$1040,$1040
	.dc.w	$0000,$0000,$5202,$5202,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$8020,$8020,$0000,$0000,$2008,$2008
	.dc.w	$0000,$0000,$0802,$0802,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$8080,$8080,$0000,$0000,$2025,$2025
	.dc.w	$0000,$0000,$0401,$0401,$0000,$0000,$0100,$0100
	.dc.w	$0000,$0000,$4040,$4040,$0000,$0000,$1010,$1010
	.dc.w	$0000,$0000,$0404,$0404,$0000,$0000,$0101,$0101
	.dc.w	$0000,$0000,$0040,$0040,$0000,$0000,$4010,$4010
	.dc.w	$0000,$0000,$4800,$4800,$0000,$0000,$8200,$8200
	.dc.w	$0000,$0000,$2080,$2080,$0000,$0000,$0820,$0820
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$0082,$0082
	.dc.w	$0000,$0000,$0020,$0020,$0000,$0000,$8009,$8009
	.dc.w	$0000,$0000,$1000,$1000,$0000,$0000,$4400,$4400
	.dc.w	$0000,$0000,$1100,$1100,$0000,$0000,$0440,$0440
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$0044,$0044
	.dc.w	$0000,$0000,$0011,$0011,$0000,$0000,$0004,$0004
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$2800,$2800
	.dc.w	$0000,$0000,$0A00,$0A00,$0000,$0000,$0280,$0280
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0028,$0028
	.dc.w	$0000,$0000,$000A,$000A,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$2800,$2800
	.dc.w	$0000,$0000,$0A00,$0A00,$0000,$0000,$0280,$0280
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0028,$0028
	.dc.w	$0000,$0000,$000A,$000A,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$1000,$1000,$0000,$0000,$4400,$4400
	.dc.w	$0000,$0000,$1100,$1100,$0000,$0000,$0440,$0440
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$0044,$0044
	.dc.w	$0000,$0000,$0011,$0011,$0000,$0000,$0004,$0004
	.dc.w	$0000,$0000,$4800,$4800,$0000,$0000,$8200,$8200
	.dc.w	$0000,$0000,$2080,$2080,$0000,$0000,$0820,$0820
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$0082,$0082
	.dc.w	$0000,$0000,$0020,$0020,$0000,$0000,$8009,$8009
	.dc.w	$0000,$0000,$0401,$0401,$0000,$0000,$0100,$0100
	.dc.w	$0000,$0000,$4040,$4040,$0000,$0000,$1010,$1010
	.dc.w	$0000,$0000,$0404,$0404,$0000,$0000,$0101,$0101
	.dc.w	$0000,$0000,$0040,$0040,$0000,$0000,$4010,$4010
	.dc.w	$0000,$0000,$5202,$5202,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$8020,$8020,$0000,$0000,$2008,$2008
	.dc.w	$0000,$0000,$0802,$0802,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$8080,$8080,$0000,$0000,$2025,$2025
	.dc.w	$0000,$0000,$0104,$0104,$0000,$0000,$0041,$0041
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$4004,$4004
	.dc.w	$0000,$0000,$1001,$1001,$0000,$0000,$0400,$0400
	.dc.w	$0000,$0000,$4100,$4100,$0000,$0000,$1040,$1040
	.dc.w	$0000,$0000,$5488,$5488,$0000,$0000,$0022,$0022
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$8002,$8002
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$8800,$8800
	.dc.w	$0000,$0000,$2200,$2200,$0000,$0000,$0895,$0895
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0014,$0014
	.dc.w	$0000,$0000,$0005,$0005,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$4000,$4000,$0000,$0000,$5000,$5000
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$552A,$552A,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AA55,$AA55
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0014,$0014
	.dc.w	$0000,$0000,$0005,$0005,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$4000,$4000,$0000,$0000,$5000,$5000
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$5488,$5488,$0000,$0000,$0022,$0022
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$8002,$8002
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$8800,$8800
	.dc.w	$0000,$0000,$2200,$2200,$0000,$0000,$0895,$0895
	.dc.w	$0000,$0000,$0104,$0104,$0000,$0000,$0041,$0041
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$4004,$4004
	.dc.w	$0000,$0000,$1001,$1001,$0000,$0000,$0400,$0400
	.dc.w	$0000,$0000,$4100,$4100,$0000,$0000,$1040,$1040
	.dc.w	$0000,$0000,$5202,$5202,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$8020,$8020,$0000,$0000,$2008,$2008
	.dc.w	$0000,$0000,$0802,$0802,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$8080,$8080,$0000,$0000,$2025,$2025
	.dc.w	$0000,$0000,$0401,$0401,$0000,$0000,$0100,$0100
	.dc.w	$0000,$0000,$4040,$4040,$0000,$0000,$1010,$1010
	.dc.w	$0000,$0000,$0404,$0404,$0000,$0000,$0101,$0101
	.dc.w	$0000,$0000,$0040,$0040,$0000,$0000,$4010,$4010
	.dc.w	$0000,$0000,$4800,$4800,$0000,$0000,$8200,$8200
	.dc.w	$0000,$0000,$2080,$2080,$0000,$0000,$0820,$0820
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$0082,$0082
	.dc.w	$0000,$0000,$0020,$0020,$0000,$0000,$8009,$8009
	.dc.w	$0000,$0000,$1000,$1000,$0000,$0000,$4400,$4400
	.dc.w	$0000,$0000,$1100,$1100,$0000,$0000,$0440,$0440
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$0044,$0044
	.dc.w	$0000,$0000,$0011,$0011,$0000,$0000,$0004,$0004
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$2800,$2800
	.dc.w	$0000,$0000,$0A00,$0A00,$0000,$0000,$0280,$0280
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0028,$0028
	.dc.w	$0000,$0000,$000A,$000A,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$2800,$2800
	.dc.w	$0000,$0000,$0A00,$0A00,$0000,$0000,$0280,$0280
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0028,$0028
	.dc.w	$0000,$0000,$000A,$000A,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$1000,$1000,$0000,$0000,$4400,$4400
	.dc.w	$0000,$0000,$1100,$1100,$0000,$0000,$0440,$0440
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$0044,$0044
	.dc.w	$0000,$0000,$0011,$0011,$0000,$0000,$0004,$0004
	.dc.w	$0000,$0000,$4800,$4800,$0000,$0000,$8200,$8200
	.dc.w	$0000,$0000,$2080,$2080,$0000,$0000,$0820,$0820
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$0082,$0082
	.dc.w	$0000,$0000,$0020,$0020,$0000,$0000,$8009,$8009
	.dc.w	$0000,$0000,$0401,$0401,$0000,$0000,$0100,$0100
	.dc.w	$0000,$0000,$4040,$4040,$0000,$0000,$1010,$1010
	.dc.w	$0000,$0000,$0404,$0404,$0000,$0000,$0101,$0101
	.dc.w	$0000,$0000,$0040,$0040,$0000,$0000,$4010,$4010
	.dc.w	$0000,$0000,$5202,$5202,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$8020,$8020,$0000,$0000,$2008,$2008
	.dc.w	$0000,$0000,$0802,$0802,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$8080,$8080,$0000,$0000,$2025,$2025
	.dc.w	$0000,$0000,$0104,$0104,$0000,$0000,$0041,$0041
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$4004,$4004
	.dc.w	$0000,$0000,$1001,$1001,$0000,$0000,$0400,$0400
	.dc.w	$0000,$0000,$4100,$4100,$0000,$0000,$1040,$1040
	.dc.w	$0000,$0000,$5488,$5488,$0000,$0000,$0022,$0022
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$8002,$8002
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$8800,$8800
	.dc.w	$0000,$0000,$2200,$2200,$0000,$0000,$0895,$0895
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0014,$0014
	.dc.w	$0000,$0000,$0005,$0005,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$4000,$4000,$0000,$0000,$5000,$5000
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$552A,$552A,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AA55,$AA55
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0014,$0014
	.dc.w	$0000,$0000,$0005,$0005,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$4000,$4000,$0000,$0000,$5000,$5000
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$5488,$5488,$0000,$0000,$0022,$0022
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$8002,$8002
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$8800,$8800
	.dc.w	$0000,$0000,$2200,$2200,$0000,$0000,$0895,$0895
	.dc.w	$0000,$0000,$0104,$0104,$0000,$0000,$0041,$0041
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$4004,$4004
	.dc.w	$0000,$0000,$1001,$1001,$0000,$0000,$0400,$0400
	.dc.w	$0000,$0000,$4100,$4100,$0000,$0000,$1040,$1040
	.dc.w	$0000,$0000,$5202,$5202,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$8020,$8020,$0000,$0000,$2008,$2008
	.dc.w	$0000,$0000,$0802,$0802,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$8080,$8080,$0000,$0000,$2025,$2025
	.dc.w	$0000,$0000,$0401,$0401,$0000,$0000,$0100,$0100
	.dc.w	$0000,$0000,$4040,$4040,$0000,$0000,$1010,$1010
	.dc.w	$0000,$0000,$0404,$0404,$0000,$0000,$0101,$0101
	.dc.w	$0000,$0000,$0040,$0040,$0000,$0000,$4010,$4010
	.dc.w	$0000,$0000,$4800,$4800,$0000,$0000,$8200,$8200
	.dc.w	$0000,$0000,$2080,$2080,$0000,$0000,$0820,$0820
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$0082,$0082
	.dc.w	$0000,$0000,$0020,$0020,$0000,$0000,$8009,$8009
	.dc.w	$0000,$0000,$1000,$1000,$0000,$0000,$4400,$4400
	.dc.w	$0000,$0000,$1100,$1100,$0000,$0000,$0440,$0440
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$0044,$0044
	.dc.w	$0000,$0000,$0011,$0011,$0000,$0000,$0004,$0004
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$2800,$2800
	.dc.w	$0000,$0000,$0A00,$0A00,$0000,$0000,$0280,$0280
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0028,$0028
	.dc.w	$0000,$0000,$000A,$000A,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$2800,$2800
	.dc.w	$0000,$0000,$0A00,$0A00,$0000,$0000,$0280,$0280
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0028,$0028
	.dc.w	$0000,$0000,$000A,$000A,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$1000,$1000,$0000,$0000,$4400,$4400
	.dc.w	$0000,$0000,$1100,$1100,$0000,$0000,$0440,$0440
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$0044,$0044
	.dc.w	$0000,$0000,$0011,$0011,$0000,$0000,$0004,$0004
	.dc.w	$0000,$0000,$4800,$4800,$0000,$0000,$8200,$8200
	.dc.w	$0000,$0000,$2080,$2080,$0000,$0000,$0820,$0820
	.dc.w	$0000,$0000,$0208,$0208,$0000,$0000,$0082,$0082
	.dc.w	$0000,$0000,$0020,$0020,$0000,$0000,$8009,$8009
	.dc.w	$0000,$0000,$0401,$0401,$0000,$0000,$0100,$0100
	.dc.w	$0000,$0000,$4040,$4040,$0000,$0000,$1010,$1010
	.dc.w	$0000,$0000,$0404,$0404,$0000,$0000,$0101,$0101
	.dc.w	$0000,$0000,$0040,$0040,$0000,$0000,$4010,$4010
	.dc.w	$0000,$0000,$5202,$5202,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$8020,$8020,$0000,$0000,$2008,$2008
	.dc.w	$0000,$0000,$0802,$0802,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$8080,$8080,$0000,$0000,$2025,$2025
	.dc.w	$0000,$0000,$0104,$0104,$0000,$0000,$0041,$0041
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$4004,$4004
	.dc.w	$0000,$0000,$1001,$1001,$0000,$0000,$0400,$0400
	.dc.w	$0000,$0000,$4100,$4100,$0000,$0000,$1040,$1040
	.dc.w	$0000,$0000,$5488,$5488,$0000,$0000,$0022,$0022
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$8002,$8002
	.dc.w	$0000,$0000,$2000,$2000,$0000,$0000,$8800,$8800
	.dc.w	$0000,$0000,$2200,$2200,$0000,$0000,$0895,$0895
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0014,$0014
	.dc.w	$0000,$0000,$0005,$0005,$0000,$0000,$0001,$0001
	.dc.w	$0000,$0000,$4000,$4000,$0000,$0000,$5000,$5000
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$552A,$552A,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AA55,$AA55

*
*	Buzy Box Image Data
*		All Word-Aligned 32 pixels by 15 lines
*
bzimgn:			* Count-Down Sequence (9)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$C000,$8000
	.dc.w	$000F,$0000,$001F,$000F,$C000,$0000,$F000,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000F,$0000,$004F,$000F,$C000,$0000,$C400,$C000
	.dc.w	$1F07,$1F00,$005F,$0007,$C1F0,$01F0,$F400,$C000
	.dc.w	$0000,$0000,$0041,$0000,$C000,$0000,$C400,$C000
	.dc.w	$0000,$0000,$0021,$0000,$C000,$0000,$C800,$C000
	.dc.w	$0000,$0000,$0021,$0000,$C000,$0000,$C800,$C000
	.dc.w	$0001,$0000,$0019,$0001,$C000,$0000,$F000,$C000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$C000,$8000
	.dc.w	$0007,$0000,$0007,$0007,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg0:			* Count-Down Sequence (pre-8)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0006,$0000,$0007,$0000,$9000,$C000,$0000,$0000
	.dc.w	$0018,$0000,$0018,$0000,$3800,$0000,$0000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$3000,$0800,$2000,$2000
	.dc.w	$0020,$0000,$0021,$0000,$4800,$0800,$4000,$4000
	.dc.w	$0040,$0000,$0041,$0000,$8000,$0000,$8400,$8000
	.dc.w	$0041,$0000,$1F5F,$0001,$0400,$0000,$F5F0,$0000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0018,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg1:			* Count-Down Sequence (8)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$C000,$8000
	.dc.w	$000F,$0000,$001F,$000F,$C000,$0000,$F000,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$0007,$0000,$0047,$0007,$8000,$0000,$8400,$8000
	.dc.w	$1F07,$1F00,$005F,$0007,$81F0,$01F0,$F400,$8000
	.dc.w	$000C,$0000,$004D,$000C,$C000,$0000,$C400,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$001C,$000C,$C000,$0000,$F000,$C000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$8000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg2:			* Count-Down Sequence (pre-7)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0018,$0000,$0018,$0000,$2000,$0000,$3000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0800,$0000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0000,$0800,$0000,$0000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0000,$0000
	.dc.w	$0041,$0000,$1F5F,$0001,$FE00,$0000,$F1F0,$F000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0000,$0800,$0000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0800,$0000,$0000
	.dc.w	$0018,$0000,$0018,$0000,$2000,$0000,$3000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg3:			* Count-Down Sequence (7)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$000F,$0000,$001F,$000F,$C000,$0000,$F000,$C000
	.dc.w	$0000,$0000,$0021,$0000,$C000,$0000,$C800,$C000
	.dc.w	$0000,$0000,$0021,$0000,$C000,$0000,$C800,$C000
	.dc.w	$0001,$0000,$0041,$0001,$8000,$0000,$8400,$8000
	.dc.w	$1F01,$1F00,$005F,$0001,$81F0,$01F0,$F400,$8000
	.dc.w	$0003,$0000,$0043,$0003,$0000,$0000,$0400,$0000
	.dc.w	$0003,$0000,$0023,$0003,$0000,$0000,$0800,$0000
	.dc.w	$0006,$0000,$0027,$0006,$0000,$0000,$0800,$0000
	.dc.w	$0006,$0000,$001E,$0006,$0000,$0000,$3000,$0000
	.dc.w	$0006,$0000,$0007,$0006,$0000,$0000,$C000,$0000
	.dc.w	$0006,$0000,$0007,$0006,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg4:			* Count-Down Sequence (pre-6)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0018,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0041,$0000,$1F5F,$0001,$0400,$0000,$F5F0,$0000
	.dc.w	$0040,$0000,$0041,$0000,$8000,$0000,$8400,$8000
	.dc.w	$0020,$0000,$0021,$0000,$4800,$0800,$4000,$4000
	.dc.w	$0020,$0000,$0021,$0000,$3000,$0800,$2000,$2000
	.dc.w	$0018,$0000,$0018,$0000,$3800,$0000,$0000,$0000
	.dc.w	$0006,$0000,$0007,$0000,$9000,$C000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg5:			* Count-Down Sequence (6)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0000,$0007,$0003,$8000,$0000,$C000,$8000
	.dc.w	$0007,$0000,$001F,$0007,$8000,$0000,$B000,$8000
	.dc.w	$000E,$0000,$002F,$000E,$0000,$0000,$0800,$0000
	.dc.w	$000C,$0000,$002D,$000C,$0000,$0000,$0800,$0000
	.dc.w	$000C,$0000,$004D,$000C,$0000,$0000,$0400,$0000
	.dc.w	$1F0F,$1F00,$005F,$000F,$81F0,$01F0,$F400,$8000
	.dc.w	$000F,$0000,$004F,$000F,$C000,$0000,$C400,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$001C,$000C,$C000,$0000,$F000,$C000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$8000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg6:			* Count-Down Sequence (pre-5)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0018,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0041,$0000,$1F5F,$0001,$0400,$0000,$F5F0,$0000
	.dc.w	$0041,$0000,$0041,$0001,$0400,$0000,$0400,$0000
	.dc.w	$0021,$0000,$0021,$0001,$0800,$0000,$0800,$0000
	.dc.w	$0021,$0000,$0021,$0001,$0800,$0000,$0800,$0000
	.dc.w	$0009,$0008,$0010,$0000,$2000,$2000,$1000,$0000
	.dc.w	$0003,$0004,$0000,$0000,$8000,$4000,$0000,$0000
	.dc.w	$0001,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg7:			* Count-Down Sequence (5)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$000F,$0000,$001F,$000F,$C000,$0000,$F000,$C000
	.dc.w	$000C,$0000,$002D,$000C,$0000,$0000,$0800,$0000
	.dc.w	$000C,$0000,$002D,$000C,$0000,$0000,$0800,$0000
	.dc.w	$000F,$0000,$004F,$000F,$8000,$0000,$8400,$8000
	.dc.w	$1F0F,$1F00,$005F,$000F,$C1F0,$01F0,$F400,$C000
	.dc.w	$0000,$0000,$0041,$0000,$C000,$0000,$C400,$C000
	.dc.w	$0000,$0000,$0021,$0000,$C000,$0000,$C800,$C000
	.dc.w	$0000,$0000,$0021,$0000,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$001C,$000C,$C000,$0000,$F000,$C000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$8000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg8:			* Count-Down Sequence (pre-4)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0018,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0041,$0000,$1F5F,$0001,$0400,$0000,$F5F0,$0000
	.dc.w	$0002,$0000,$0043,$0002,$0400,$0000,$0400,$0000
	.dc.w	$0024,$0020,$0005,$0004,$0800,$0000,$0800,$0000
	.dc.w	$0018,$0020,$0009,$0008,$0800,$0000,$0800,$0000
	.dc.w	$0038,$0000,$0000,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0012,$0006,$0001,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg9:			* Count-Down Sequence (4)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0000,$0007,$0001,$8000,$0000,$C000,$8000
	.dc.w	$0001,$0000,$0019,$0001,$8000,$0000,$B000,$8000
	.dc.w	$0003,$0000,$0023,$0003,$8000,$0000,$8800,$8000
	.dc.w	$0003,$0000,$0023,$0003,$8000,$0000,$8800,$8000
	.dc.w	$0007,$0000,$0047,$0007,$8000,$0000,$8400,$8000
	.dc.w	$1F07,$1F00,$005F,$0007,$81F0,$01F0,$F400,$8000
	.dc.w	$000D,$0000,$004D,$000D,$8000,$0000,$8400,$8000
	.dc.w	$000D,$0000,$002D,$000D,$8000,$0000,$8800,$8000
	.dc.w	$000F,$0000,$002F,$000F,$C000,$0000,$C800,$C000
	.dc.w	$000F,$0000,$001F,$000F,$C000,$0000,$F000,$C000
	.dc.w	$0001,$0000,$0007,$0001,$8000,$0000,$C000,$8000
	.dc.w	$0001,$0000,$0001,$0001,$8000,$0000,$8000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg10:		* Count-Down Sequence (pre-3)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0008,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0020,$0020,$0001,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0000,$0020,$0001,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0040,$0000,$0001,$0000,$0400,$0000,$0400,$0000
	.dc.w	$00FF,$0000,$1F1F,$001F,$0400,$0000,$F5F0,$0000
	.dc.w	$0040,$0000,$0001,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0000,$0020,$0001,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0020,$0020,$0001,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0008,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg11:		* Count-Down Sequence (3)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$000F,$0000,$001F,$000F,$C000,$0000,$F000,$C000
	.dc.w	$0001,$0000,$0021,$0001,$8000,$0000,$8800,$8000
	.dc.w	$0001,$0000,$0021,$0001,$8000,$0000,$8800,$8000
	.dc.w	$0003,$0000,$0043,$0003,$0000,$0000,$0400,$0000
	.dc.w	$1F03,$1F00,$005F,$0003,$01F0,$01F0,$F400,$0000
	.dc.w	$0001,$0000,$0041,$0001,$8000,$0000,$8400,$8000
	.dc.w	$0001,$0000,$0021,$0001,$8000,$0000,$8800,$8000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$001C,$000C,$C000,$0000,$F000,$C000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$8000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg12:		* Count-Down Sequence (pre-2)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0012,$0006,$0001,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0038,$0000,$0000,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0018,$0020,$0009,$0008,$0800,$0000,$0800,$0000
	.dc.w	$0024,$0020,$0005,$0004,$0800,$0000,$0800,$0000
	.dc.w	$0002,$0000,$0043,$0002,$0400,$0000,$0400,$0000
	.dc.w	$0041,$0000,$1F5F,$0001,$0400,$0000,$F5F0,$0000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0018,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg13:		* Count-Down Sequence (2)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$0000,$0007,$0007,$8000,$0000,$C000,$8000
	.dc.w	$000F,$0000,$001F,$000F,$C000,$0000,$F000,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$000C,$0000,$002D,$000C,$C000,$0000,$C800,$C000
	.dc.w	$0001,$0000,$0041,$0001,$8000,$0000,$8400,$8000
	.dc.w	$1F01,$1F00,$005F,$0001,$81F0,$01F0,$F400,$8000
	.dc.w	$0003,$0000,$0043,$0003,$0000,$0000,$0400,$0000
	.dc.w	$0003,$0000,$0023,$0003,$0000,$0000,$0800,$0000
	.dc.w	$0006,$0000,$0027,$0006,$0000,$0000,$0800,$0000
	.dc.w	$0006,$0000,$001E,$0006,$0000,$0000,$3000,$0000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg14:		* Count-Down Sequence (pre-1)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0004,$0000,$0000,$8000,$4000,$0000,$0000
	.dc.w	$0009,$0008,$0010,$0000,$2000,$2000,$1000,$0000
	.dc.w	$0021,$0000,$0021,$0001,$0800,$0000,$0800,$0000
	.dc.w	$0021,$0000,$0021,$0001,$0800,$0000,$0800,$0000
	.dc.w	$0041,$0000,$0041,$0001,$0400,$0000,$0400,$0000
	.dc.w	$0041,$0000,$1F5F,$0001,$0400,$0000,$F5F0,$0000
	.dc.w	$0040,$0000,$0041,$0000,$0400,$0000,$0400,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0020,$0000,$0021,$0000,$0800,$0000,$0800,$0000
	.dc.w	$0018,$0000,$0018,$0000,$3000,$0000,$3000,$0000
	.dc.w	$0007,$0000,$0007,$0000,$C000,$0000,$C000,$0000
	.dc.w	$0001,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg15:		* Count-Down Sequence (1)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0000,$0007,$0003,$0000,$0000,$C000,$0000
	.dc.w	$0003,$0000,$001B,$0003,$0000,$0000,$3000,$0000
	.dc.w	$0007,$0000,$0027,$0007,$0000,$0000,$0800,$0000
	.dc.w	$0007,$0000,$0027,$0007,$0000,$0000,$0800,$0000
	.dc.w	$0003,$0000,$0043,$0003,$0000,$0000,$0400,$0000
	.dc.w	$1F03,$1F00,$005F,$0003,$01F0,$01F0,$F400,$0000
	.dc.w	$0003,$0000,$0043,$0003,$0000,$0000,$0400,$0000
	.dc.w	$0003,$0000,$0023,$0003,$0000,$0000,$0800,$0000
	.dc.w	$0003,$0000,$0023,$0003,$0000,$0000,$0800,$0000
	.dc.w	$0003,$0000,$001B,$0003,$0000,$0000,$3000,$0000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$000F,$0000,$000F,$000F,$C000,$0000,$C000,$C000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg16:		* StarBase Sequence (step 0)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$0040,$0040,$0000,$0000,$4000,$0000,$0000
	.dc.w	$00E0,$01F0,$01B0,$0040,$0000,$0000,$0040,$0040
	.dc.w	$0040,$064C,$064C,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$0040,$0040
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$1000,$0000
	.dc.w	$10E1,$10A1,$10A1,$0040,$0000,$0006,$0040,$0046
	.dc.w	$38E3,$3842,$2802,$10E0,$9000,$801C,$9080,$009C
	.dc.w	$10E1,$10A1,$10A1,$0040,$0000,$0006,$0040,$0046
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$1000,$0000
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$0040,$0040
	.dc.w	$0040,$064C,$064C,$0000,$2000,$2000,$0000,$0000
	.dc.w	$00E0,$01B0,$01B0,$0000,$0000,$0000,$0040,$0040
	.dc.w	$0040,$0040,$0040,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg17:		* StarBase Sequence (step 1)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0020,$0020,$0020,$0000,$0000,$4000,$4000,$0000
	.dc.w	$0070,$01F0,$01D0,$0020,$0000,$0000,$0080,$0080
	.dc.w	$0020,$062C,$062C,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$0080,$0080
	.dc.w	$1000,$1802,$1802,$0000,$1000,$1000,$0000,$0000
	.dc.w	$38E0,$38A1,$28A1,$1040,$0000,$0006,$0080,$0086
	.dc.w	$10E1,$1041,$1001,$00E0,$0000,$001C,$1000,$001C
	.dc.w	$00E3,$10A2,$10A2,$0040,$8000,$8006,$8080,$0086
	.dc.w	$0001,$0803,$0803,$0000,$1000,$1000,$0100,$0100
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$0080,$0080
	.dc.w	$0080,$068C,$068C,$0000,$0000,$2000,$0000,$0000
	.dc.w	$01C0,$0170,$0170,$0000,$0000,$0000,$0080,$0080
	.dc.w	$0080,$0080,$0080,$0000,$0000,$4000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg18:		* StarBase Sequence (step 2)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0010,$0010,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0038,$01F8,$01E8,$0010,$0000,$0000,$0100,$0100
	.dc.w	$0010,$061C,$061C,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0800,$0802,$0802,$0000,$0000,$0000,$0100,$0100
	.dc.w	$1C00,$1C02,$1402,$0800,$0000,$0000,$1000,$0000
	.dc.w	$08E0,$18A1,$18A1,$0040,$0000,$0000,$0100,$0100
	.dc.w	$00E0,$1041,$1001,$00E0,$1006,$0000,$1000,$0006
	.dc.w	$00E2,$10A3,$10A3,$0040,$001C,$0000,$0100,$011C
	.dc.w	$0007,$0805,$0805,$0000,$0006,$0000,$1000,$0006
	.dc.w	$0002,$0802,$0802,$0000,$0000,$0000,$0100,$0100
	.dc.w	$0100,$070C,$070C,$0000,$2000,$2000,$0200,$0200
	.dc.w	$0380,$02F0,$02F0,$0000,$0000,$0000,$0100,$0100
	.dc.w	$0100,$0100,$0100,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg19:		* StarBase Sequence (step 3)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$4000,$0000
	.dc.w	$0008,$01F8,$01F8,$0000,$0000,$0000,$0200,$0200
	.dc.w	$081C,$0E1C,$0E14,$0008,$0000,$2000,$0000,$0000
	.dc.w	$1C08,$1C0A,$140A,$0800,$0000,$0000,$0200,$0200
	.dc.w	$0800,$0802,$0802,$0000,$1000,$1000,$0000,$0000
	.dc.w	$00E0,$10A1,$10A1,$0040,$0006,$0000,$0200,$0206
	.dc.w	$00E0,$1041,$1001,$00E0,$001C,$0000,$1000,$001C
	.dc.w	$00E0,$10A1,$10A1,$0040,$0006,$0000,$0200,$0206
	.dc.w	$0002,$0802,$0802,$0000,$1000,$1000,$0400,$0400
	.dc.w	$0207,$0A05,$0A05,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0702,$050E,$050E,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0200,$03F0,$03F0,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg20:		* StarBase Sequence (step 4)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0404,$05F4,$05F4,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0E0E,$0E0E,$0A0A,$0404,$2000,$2000,$0000,$0000
	.dc.w	$0404,$0C06,$0C06,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$1000,$0000
	.dc.w	$00E0,$10A1,$10A1,$0040,$0000,$0006,$0200,$0206
	.dc.w	$00E0,$1041,$1001,$00E0,$1000,$001C,$1400,$041C
	.dc.w	$00E0,$10A1,$10A1,$0040,$0000,$0006,$0200,$0206
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$1000,$0000
	.dc.w	$0404,$0C06,$0C06,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0E0E,$0E0E,$0A0A,$0404,$2000,$2000,$0000,$0000
	.dc.w	$0404,$05F4,$05F4,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg21:		* StarBase Sequence (step 5)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$4000,$0000
	.dc.w	$0200,$03F0,$03F0,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0702,$070E,$050E,$0200,$0000,$2000,$0000,$0000
	.dc.w	$0207,$0A07,$0A05,$0002,$0000,$0000,$0200,$0200
	.dc.w	$0002,$0802,$0802,$0000,$1000,$1000,$0400,$0400
	.dc.w	$00E0,$10A1,$10A1,$0040,$0000,$0006,$0200,$0206
	.dc.w	$00E0,$1041,$1001,$00E0,$0000,$001C,$1000,$001C
	.dc.w	$00E0,$10A1,$10A1,$0040,$0000,$0006,$0200,$0206
	.dc.w	$0800,$0802,$0802,$0000,$1000,$1000,$0000,$0000
	.dc.w	$1C08,$1C0A,$140A,$0800,$0000,$0000,$0200,$0200
	.dc.w	$081C,$0E1C,$0E14,$0008,$0000,$2000,$0000,$0000
	.dc.w	$0008,$01F8,$01F8,$0000,$0000,$0000,$0200,$0200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$4000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg22:		* StarBase Sequence (step 6)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0100,$0100,$0100,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0380,$03F0,$02F0,$0100,$0000,$0000,$0100,$0100
	.dc.w	$0100,$070C,$070C,$0000,$2000,$2000,$0200,$0200
	.dc.w	$0002,$0802,$0802,$0000,$0000,$0000,$0100,$0100
	.dc.w	$0007,$0807,$0805,$0002,$0006,$0000,$1000,$0006
	.dc.w	$00E2,$10A3,$10A3,$0040,$001C,$0000,$0100,$011C
	.dc.w	$00E0,$1041,$1001,$00E0,$1006,$0000,$1000,$0006
	.dc.w	$08E0,$18A1,$18A1,$0040,$0000,$0000,$0100,$0100
	.dc.w	$1C00,$1C02,$1402,$0800,$0000,$0000,$1000,$0000
	.dc.w	$0800,$0802,$0802,$0000,$0000,$0000,$0100,$0100
	.dc.w	$0010,$061C,$061C,$0000,$2000,$2000,$0000,$0000
	.dc.w	$0038,$01F8,$01E8,$0010,$0000,$0000,$0100,$0100
	.dc.w	$0010,$0010,$0010,$0000,$0000,$4000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg23:		* StarBase Sequence (step 7)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0080,$0080,$0000,$0000,$4000,$4000,$0000
	.dc.w	$01C0,$01F0,$0170,$0080,$0000,$0000,$0080,$0080
	.dc.w	$0080,$068C,$068C,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$0080,$0080
	.dc.w	$0001,$0803,$0803,$0000,$1000,$1000,$0100,$0100
	.dc.w	$00E3,$10A3,$10A2,$0041,$8006,$8000,$8080,$0086
	.dc.w	$10E1,$1041,$1001,$00E0,$001C,$0000,$1000,$001C
	.dc.w	$38E0,$38A1,$28A1,$1040,$0006,$0000,$0080,$0086
	.dc.w	$1000,$1802,$1802,$0000,$1000,$1000,$0000,$0000
	.dc.w	$0000,$0802,$0802,$0000,$0000,$0000,$0080,$0080
	.dc.w	$0020,$062C,$062C,$0000,$0000,$2000,$0000,$0000
	.dc.w	$0070,$01F0,$01D0,$0020,$0000,$0000,$0080,$0080
	.dc.w	$0020,$0020,$0020,$0000,$0000,$4000,$4000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg24:		* Asteroid Sequence (step 0)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0001,$0003,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0680,$0003,$0EC3,$0003,$7000,$05C0,$05C6,$0006
	.dc.w	$0940,$0007,$1947,$0007,$0000,$0000,$0002,$0002
	.dc.w	$1040,$0003,$1443,$0003,$0000,$6EE0,$6EE2,$0002
	.dc.w	$0240,$0001,$0E43,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0480,$0000,$06C2,$0002,$0000,$7B80,$7B82,$0002
	.dc.w	$0300,$0000,$0382,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg25:		* Asteroid Sequence (step 1)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0001,$0003,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0B00,$0003,$1F03,$0003,$7400,$01C0,$01C2,$7002
	.dc.w	$0080,$0007,$3087,$0007,$0000,$0000,$0002,$0002
	.dc.w	$1080,$0003,$3083,$0003,$0000,$6EE0,$6EE6,$0006
	.dc.w	$0C80,$0001,$1C83,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0300,$0000,$0302,$0002,$0000,$7B80,$7B82,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg26:		* Asteroid Sequence (step 2)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0180,$0000,$0183,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0240,$0001,$0643,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0480,$0003,$0CC3,$0003,$75C0,$0000,$0002,$7402
	.dc.w	$0480,$0007,$0C87,$0007,$0000,$0000,$0006,$0006
	.dc.w	$0700,$0003,$0F83,$0003,$0000,$6EE0,$6EE2,$0002
	.dc.w	$0000,$0001,$0B03,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$7B80,$7B86,$0006
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg27:		* Asteroid Sequence (step 3)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0180,$0000,$0183,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0180,$0000,$0382,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0280,$0001,$0683,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0480,$0003,$0C83,$0003,$0000,$0000,$0006,$75C6
	.dc.w	$0580,$0007,$0D87,$0007,$0000,$0000,$0002,$0002
	.dc.w	$0680,$0003,$0783,$0003,$6000,$0EE0,$0EE2,$0002
	.dc.w	$0000,$0001,$0003,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0000,$0000,$0002,$0002,$0000,$7B80,$7B82,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg28:		* Asteroid Sequence (step 4)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0180,$0000,$0783,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0280,$0000,$0A82,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0440,$0000,$1442,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0440,$0001,$1443,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0640,$0003,$0E43,$0003,$0000,$0000,$0002,$75C2
	.dc.w	$0180,$0007,$0187,$0007,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0003,$0003,$0003,$6E00,$00E0,$00E6,$6006
	.dc.w	$0000,$0001,$0003,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$7B80,$7B82,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg29:		* Asteroid Sequence (step 5)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0200,$0000,$0703,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0500,$0000,$0D02,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0880,$0001,$1883,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0880,$0003,$1883,$0003,$0000,$0000,$0006,$75C6
	.dc.w	$0A40,$0007,$1A47,$0007,$0000,$0000,$0002,$0002
	.dc.w	$0D40,$0003,$0F43,$0003,$6EE0,$0000,$0002,$6E02
	.dc.w	$0180,$0001,$0183,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0000,$0000,$0002,$0002,$0000,$7B80,$7B82,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg30:		* Asteroid Sequence (step 6)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0300,$0001,$0303,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0480,$0003,$0C83,$0003,$0000,$0000,$0002,$75C2
	.dc.w	$0880,$0007,$0887,$0007,$0000,$0000,$0006,$0006
	.dc.w	$0880,$0003,$0883,$0003,$6EE0,$0000,$0002,$6EE2
	.dc.w	$0500,$0001,$0D83,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0300,$0000,$0783,$0003,$7800,$0380,$0386,$0006
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg31:		* Asteroid Sequence (step 7)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0280,$0001,$0283,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0140,$0003,$0D43,$0003,$75C0,$75C0,$75C2,$0002
	.dc.w	$0240,$0007,$1247,$0007,$0000,$0000,$0002,$0002
	.dc.w	$0480,$0003,$0C83,$0003,$0000,$0000,$0006,$6EE6
	.dc.w	$0480,$0001,$0483,$0003,$0000,$0000,$0002,$0002
	.dc.w	$0280,$0000,$0282,$0002,$7B80,$0000,$0002,$7802
	.dc.w	$0300,$0000,$0303,$0003,$0000,$0000,$0006,$0006
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$0002,$0002
	.dc.w	$0000,$0000,$0003,$0003,$0000,$0000,$800E,$800E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

bzimg32:		* Alien Ships (WC Fields)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00C1,$74C1,$74C1,$0000,$8000,$80BA,$80BA
	.dc.w	$0000,$0122,$0322,$0322,$0000,$4000,$4100,$4100
	.dc.w	$0000,$021C,$031C,$031C,$0000,$2000,$2200,$2200
	.dc.w	$0000,$043E,$043E,$043E,$0000,$1000,$1000,$1000
	.dc.w	$0000,$3FBE,$3FBE,$3FBE,$0000,$FE00,$FE00,$FE00
	.dc.w	$0000,$049C,$049C,$049C,$0000,$9000,$9000,$9000
	.dc.w	$0000,$0322,$0322,$0322,$0000,$6000,$6580,$6580
	.dc.w	$0000,$00C9,$01C9,$01C9,$0000,$8000,$8000,$8000
	.dc.w	$0000,$0008,$0208,$0208,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0008,$0409,$0409,$A748,$0000,$A748,$A748
	.dc.w	$0001,$0000,$7001,$7001,$256C,$0000,$256C,$256C
	.dc.w	$0001,$0000,$0001,$0001,$B524,$0000,$B524,$B524
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg33:		* Alien Ships (Butterfly)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0800,$0800,$0800
	.dc.w	$0000,$0003,$0DE3,$0DE3,$0000,$0860,$0860,$0860
	.dc.w	$0000,$0007,$0017,$0017,$0000,$BEF0,$BEF0,$BEF0
	.dc.w	$0000,$0007,$0ECF,$0ECF,$0000,$BEF0,$BEF0,$BEF0
	.dc.w	$0000,$0003,$0007,$0007,$0000,$E3F0,$E3F0,$E3F0
	.dc.w	$0000,$0007,$0007,$0007,$0000,$E3F0,$E3F0,$E3F0
	.dc.w	$0000,$0007,$0007,$0007,$0000,$BEF0,$BEF0,$BEF0
	.dc.w	$0000,$0007,$0007,$0007,$0000,$BEF0,$BEF0,$BEF0
	.dc.w	$0000,$0003,$0003,$0003,$0000,$0860,$0A60,$0A60
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0800,$0900,$0900
	.dc.w	$0DD3,$0000,$0DD3,$0DD3,$0000,$0000,$00E8,$00E8
	.dc.w	$095B,$0000,$095B,$095B,$0000,$0000,$0000,$0000
	.dc.w	$0DC9,$0000,$0DC9,$0DC9,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg34:		* Alien Ships (TVSet)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$3E80,$3E80,$13A8,$0000,$13A8,$13A8
	.dc.w	$0000,$0000,$0000,$0000,$3A2C,$0000,$3A2C,$3A2C
	.dc.w	$0000,$01F0,$01F0,$01F0,$2BAC,$0000,$2BAC,$2BAC
	.dc.w	$0000,$03F8,$03F8,$03F8,$0000,$0000,$0000,$0000
	.dc.w	$0000,$17FD,$17FD,$17FD,$0000,$0000,$1D40,$1D40
	.dc.w	$0000,$171D,$171D,$171D,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1E0F,$1E0F,$1E0F,$0000,$0000,$17B4,$17B4
	.dc.w	$0000,$171D,$171D,$171D,$0000,$0000,$0000,$0000
	.dc.w	$0000,$17FD,$17FD,$17FD,$0000,$0000,$1DA0,$1DA0
	.dc.w	$0000,$03F8,$03F8,$03F8,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01F0,$05F0,$05F0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$7800,$7800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg35:		* Alien Ships (Eyeball)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0028,$0000,$78AA,$7800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0400,$0400,$0000,$0000,$17BA,$17BA
	.dc.w	$0200,$00AA,$02BA,$00AA,$0000,$8000,$A000,$A000
	.dc.w	$0000,$0001,$01FF,$0101,$0000,$0000,$46F0,$46F0
	.dc.w	$0000,$02AA,$0BFF,$02AA,$0000,$8000,$A000,$8000
	.dc.w	$0000,$0000,$01FF,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0AAA,$0BFF,$0AAA,$0000,$A000,$A000,$A000
	.dc.w	$0000,$0000,$01FF,$0000,$0000,$0000,$07A0,$07A0
	.dc.w	$0000,$02AA,$0BFF,$02AA,$0000,$8000,$A000,$8000
	.dc.w	$0000,$0000,$00FE,$0000,$0CEA,$0000,$0CEA,$0CEA
	.dc.w	$0200,$00AA,$02BA,$00AA,$0AEE,$8000,$8AEE,$8AEE
	.dc.w	$0000,$0000,$0000,$0000,$0C82,$0000,$0C82,$0C82
	.dc.w	$0000,$0028,$00AA,$0028,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg36:		* Alien Ships (Flatiron)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0067,$0000,$0067,$0067,$5400,$0000,$5400,$5400
	.dc.w	$0055,$0000,$0055,$0055,$5400,$0000,$5400,$5400
	.dc.w	$0065,$0000,$0065,$0065,$7400,$0000,$7400,$7400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0010,$0000,$0000,$0000,$1000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFC,$FFFC,$FFFC
	.dc.w	$0000,$301F,$301F,$301F,$0000,$F018,$F018,$F018
	.dc.w	$0000,$2000,$2000,$2000,$0000,$0018,$0018,$0018
	.dc.w	$0000,$0000,$0810,$0810,$0000,$0000,$2000,$2000
	.dc.w	$0000,$0000,$0408,$0408,$0000,$0000,$177C,$177C
	.dc.w	$0000,$0000,$0384,$0384,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$EC00,$EC00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg37:		* Alien Ships (Titties)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$24AE,$0000,$24AE,$24AE,$0000,$0000,$0000,$0000
	.dc.w	$2EE6,$0000,$2EE6,$2EE6,$0000,$0000,$0000,$0000
	.dc.w	$24AE,$0000,$24AE,$24AE,$0000,$0000,$005C,$005C
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0080,$0080
	.dc.w	$0000,$0000,$3DBC,$3DBC,$0000,$6B00,$6B00,$6B00
	.dc.w	$0000,$0000,$12A2,$12A2,$0000,$DD80,$DD80,$DD80
	.dc.w	$0000,$000D,$3DCD,$3DCD,$0000,$E3D8,$E3D8,$E3D8
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1C00,$1C00,$1C00
	.dc.w	$0000,$0003,$0003,$0003,$0000,$6B60,$6B60,$6B60
	.dc.w	$0000,$0007,$0007,$0007,$0000,$6B70,$6B70,$6B70
	.dc.w	$0000,$0007,$0007,$0007,$0000,$AAF0,$AAF0,$AAF0
	.dc.w	$0000,$0003,$0003,$0003,$0000,$C1E0,$C1E0,$C1E0
	.dc.w	$0000,$0000,$007C,$007C,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg38:		* Alien Ships (King Tut)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$754C,$0000,$754C,$754C
	.dc.w	$0000,$03F8,$03F8,$03F8,$656C,$0000,$656C,$656C
	.dc.w	$0000,$01F0,$71F0,$71F0,$7764,$0000,$7764,$7764
	.dc.w	$0000,$02A8,$0AA8,$0AA8,$0000,$0000,$0000,$0000
	.dc.w	$0000,$05F4,$05F4,$05F4,$0000,$0000,$5DB8,$5DB8
	.dc.w	$0000,$0AEA,$0AEA,$0AEA,$0000,$0000,$8000,$8000
	.dc.w	$0000,$1555,$1555,$1555,$0000,$0000,$1770,$1770
	.dc.w	$0000,$1A4B,$1A4B,$1A4B,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1FFF,$1FFF,$1FFF,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07FC,$07FC,$07FC,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00A0,$00A8,$00A8,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0007,$0007,$0000,$0000,$C000,$C000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

bzimg40:		* Rolling Change Sequence (step 0)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$4824,$4824,$0000,$0000,$9040,$9040,$0000
	.dc.w	$0000,$1049,$1049,$0000,$0000,$0482,$0482,$0000
	.dc.w	$0000,$2082,$2082,$0000,$0000,$4904,$4904,$0000
	.dc.w	$0000,$0124,$0124,$0000,$0000,$9208,$9208,$0000
	.dc.w	$0000,$0249,$0249,$0000,$0000,$2412,$2412,$0000
	.dc.w	$0000,$0492,$0492,$0000,$0000,$4824,$4824,$0000
	.dc.w	$0000,$0104,$0104,$0000,$0000,$9040,$9040,$0000
	.dc.w	$0000,$1048,$1048,$0000,$0000,$2092,$2092,$0000
	.dc.w	$0000,$0492,$0492,$0000,$0000,$4124,$4124,$0000
	.dc.w	$0000,$4920,$4920,$0000,$0000,$8208,$8208,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$2017,$5FE8,$0000,$FFFE,$F404,$0BFA
	.dc.w	$0000,$1208,$1208,$0000,$0000,$2490,$2490,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg41:		* Rolling Change Sequence (step 1)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0820,$0820,$0820,$0000,$8200,$8200,$8200,$0000
	.dc.w	$1049,$1049,$1049,$0000,$2482,$2482,$2482,$0000
	.dc.w	$2012,$2012,$2012,$0000,$4104,$4104,$4104,$0000
	.dc.w	$4124,$4124,$4124,$0000,$1200,$1200,$1200,$0000
	.dc.w	$0249,$0249,$0249,$0000,$0412,$0412,$0412,$0000
	.dc.w	$0482,$0482,$0482,$0000,$4820,$4820,$4820,$0000
	.dc.w	$0824,$0824,$0824,$0000,$9048,$9048,$9048,$0000
	.dc.w	$1249,$1249,$1249,$0000,$2092,$2092,$2092,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5FE8,$7FFF,$2017,$5FE8,$0BFA,$FFFE,$F404,$0BFA
	.dc.w	$4904,$4904,$4904,$0000,$9248,$9248,$9248,$0000
	.dc.w	$1208,$1208,$1208,$0000,$2492,$2492,$2492,$0000
	.dc.w	$0412,$0412,$0412,$0000,$4820,$4820,$4820,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg42:		* Rolling Change Sequence (step 2)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$4124,$0000,$0000,$0000,$9200
	.dc.w	$0000,$0000,$0000,$0208,$0000,$0000,$0000,$2082
	.dc.w	$0000,$0000,$0000,$0092,$0000,$0000,$0000,$4904
	.dc.w	$0000,$0000,$0000,$0904,$0000,$0000,$0000,$9200
	.dc.w	$0000,$0000,$0000,$1049,$0000,$0000,$0000,$0412
	.dc.w	$0000,$0000,$0000,$2492,$0000,$0000,$0000,$4820
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5FE8,$2017,$2017,$0000,$0BFA,$F404,$F404,$0000
	.dc.w	$0000,$0000,$0000,$4904,$0000,$0000,$0000,$1248
	.dc.w	$0000,$0000,$0000,$1209,$0000,$0000,$0000,$0492
	.dc.w	$0000,$0000,$0000,$2002,$0000,$0000,$0000,$0924
	.dc.w	$0000,$0000,$0000,$0824,$0000,$0000,$0000,$1248
	.dc.w	$0000,$0000,$0000,$1048,$0000,$0000,$0000,$2400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg43:		* Rolling Change Sequence (step 3)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2012,$0000,$0000,$2012,$4024,$0000,$0000,$4024
	.dc.w	$4124,$0000,$0000,$4124,$8248,$0000,$0000,$8248
	.dc.w	$0248,$0000,$0000,$0248,$0490,$0000,$0000,$0490
	.dc.w	$0482,$0000,$0000,$0482,$0800,$0000,$0000,$0800
	.dc.w	$0924,$0000,$0000,$0924,$1200,$0000,$0000,$1200
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5FE8,$2017,$2017,$0000,$0BFA,$F404,$F404,$0000
	.dc.w	$1041,$0000,$0000,$1041,$2482,$0000,$0000,$2482
	.dc.w	$2482,$0000,$0000,$2482,$4804,$0000,$0000,$4804
	.dc.w	$4100,$0000,$0000,$4100,$8208,$0000,$0000,$8208
	.dc.w	$1208,$0000,$0000,$1208,$2412,$0000,$0000,$2412
	.dc.w	$2412,$0000,$0000,$2412,$4824,$0000,$0000,$4824
	.dc.w	$0824,$0000,$0000,$0824,$9048,$0000,$0000,$9048
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg44:		* Rolling Change Sequence (step 4)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$2412,$0000,$2412,$0000,$0904,$0000,$0904
	.dc.w	$0000,$4820,$0000,$4820,$0000,$1040,$0000,$1040
	.dc.w	$0000,$1048,$0000,$1048,$0000,$2412,$0000,$2412
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5FE8,$2017,$2017,$0000,$0BFA,$F404,$F404,$0000
	.dc.w	$0000,$2492,$0000,$2492,$0000,$0904,$0000,$0904
	.dc.w	$0000,$0904,$0000,$0904,$0000,$0208,$0000,$0208
	.dc.w	$0000,$1040,$0000,$1040,$0000,$2012,$0000,$2012
	.dc.w	$0000,$2490,$0000,$2490,$0000,$0824,$0000,$0824
	.dc.w	$0000,$4120,$0000,$4120,$0000,$8040,$0000,$8040
	.dc.w	$0000,$0241,$0000,$0241,$0000,$2092,$0000,$2092
	.dc.w	$0000,$0082,$0000,$0082,$0000,$0104,$0000,$0104
	.dc.w	$0000,$0904,$0000,$0904,$0000,$8240,$0000,$8240
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg45:		* Rolling Change Sequence (step 5)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2012,$2012,$0000,$2012,$4924,$4924,$0000,$4924
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5FE8,$2017,$2017,$0000,$0BFA,$F404,$F404,$0000
	.dc.w	$4824,$4824,$0000,$4824,$8248,$8248,$0000,$8248
	.dc.w	$1049,$1049,$0000,$1049,$0492,$0492,$0000,$0492
	.dc.w	$0012,$0012,$0000,$0012,$0104,$0104,$0000,$0104
	.dc.w	$4124,$4124,$0000,$4124,$1040,$1040,$0000,$1040
	.dc.w	$0248,$0248,$0000,$0248,$0482,$0482,$0000,$0482
	.dc.w	$0080,$0080,$0000,$0080,$4904,$4904,$0000,$4904
	.dc.w	$0920,$0920,$0000,$0920,$9208,$9208,$0000,$9208
	.dc.w	$1041,$1041,$0000,$1041,$2002,$2002,$0000,$2002
	.dc.w	$2482,$2482,$0000,$2482,$4820,$4820,$0000,$4820
	.dc.w	$0904,$0904,$0000,$0904,$1248,$1248,$0000,$1248
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg46:		* Rolling Change Sequence (step 6)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5FE8,$2017,$2017,$0000,$0BFA,$F404,$F404,$0000
	.dc.w	$1209,$0000,$0000,$0000,$2482,$0000,$0000,$0000
	.dc.w	$0412,$0000,$0000,$0000,$0804,$0000,$0000,$0000
	.dc.w	$4004,$0000,$0000,$0000,$0208,$0000,$0000,$0000
	.dc.w	$1048,$0000,$0000,$0000,$2402,$0000,$0000,$0000
	.dc.w	$2090,$0000,$0000,$0000,$4824,$0000,$0000,$0000
	.dc.w	$4124,$0000,$0000,$0000,$9048,$0000,$0000,$0000
	.dc.w	$0249,$0000,$0000,$0000,$2012,$0000,$0000,$0000
	.dc.w	$0082,$0000,$0000,$0000,$0124,$0000,$0000,$0000
	.dc.w	$0920,$0000,$0000,$0000,$8248,$0000,$0000,$0000
	.dc.w	$1248,$0000,$0000,$0000,$0082,$0000,$0000,$0000
	.dc.w	$0412,$0000,$0000,$0000,$0820,$0000,$0000,$0000
	.dc.w	$4124,$0000,$0000,$0000,$1248,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg47:		* Rolling Change Sequence (step 7)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1209,$0000,$0000,$0000,$2482,$0000,$0000,$0000
	.dc.w	$0412,$0000,$0000,$0000,$0804,$0000,$0000,$0000
	.dc.w	$4004,$0000,$0000,$0000,$0208,$0000,$0000,$0000
	.dc.w	$1048,$0000,$0000,$0000,$2402,$0000,$0000,$0000
	.dc.w	$2090,$0000,$0000,$0000,$4824,$0000,$0000,$0000
	.dc.w	$4124,$0000,$0000,$0000,$9048,$0000,$0000,$0000
	.dc.w	$0249,$0000,$0000,$0000,$2012,$0000,$0000,$0000
	.dc.w	$0082,$0000,$0000,$0000,$0124,$0000,$0000,$0000
	.dc.w	$0920,$0000,$0000,$0000,$8248,$0000,$0000,$0000
	.dc.w	$1248,$0000,$0000,$0000,$0082,$0000,$0000,$0000
	.dc.w	$0412,$0000,$0000,$0000,$0820,$0000,$0000,$0000
	.dc.w	$4124,$0000,$0000,$0000,$1248,$0000,$0000,$0000
	.dc.w	$1048,$0000,$0000,$0000,$2492,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

bzimg50:		* Damaged Device (Computer)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0A80,$499E,$4800,$47BF,$0150,$F992,$0012,$FDE2
	.dc.w	$000A,$402A,$400A,$403F,$A000,$AC02,$A802,$F402
	.dc.w	$0A8E,$49AE,$480E,$47B5,$8950,$AD92,$A812,$55E2
	.dc.w	$0002,$402A,$400A,$4037,$A000,$AC02,$A802,$F402
	.dc.w	$0A8A,$49AE,$480E,$47B1,$8950,$AD92,$A812,$55E2
	.dc.w	$0022,$400B,$400B,$4034,$AC00,$2802,$2802,$FC02
	.dc.w	$0A80,$499B,$4800,$47BF,$0150,$B992,$0012,$FDE2
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg51:		* Damaged Device (Port Gun)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$4000,$4000,$4000,$00D0,$00D2,$00D2,$002E
	.dc.w	$0000,$4000,$4000,$4000,$072C,$0722,$0722,$00DE
	.dc.w	$0000,$4000,$4000,$4000,$1858,$1846,$1842,$07BE
	.dc.w	$0000,$4000,$4000,$4000,$63B4,$608E,$6082,$1F7E
	.dc.w	$00FF,$40FF,$40FF,$40AA,$9FAC,$809E,$8082,$FF7E
	.dc.w	$0700,$4700,$4700,$40FF,$60AC,$1F9A,$0082,$FF7A
	.dc.w	$00FF,$40FF,$40FF,$40AA,$9FAC,$809E,$8082,$FF7E
	.dc.w	$0000,$4000,$4000,$4000,$6394,$608E,$6082,$1F7E
	.dc.w	$0000,$4000,$4000,$4000,$1858,$1846,$1842,$07BE
	.dc.w	$0000,$4000,$4000,$4000,$072C,$0722,$0722,$00DE
	.dc.w	$0000,$4000,$4000,$4000,$00D0,$00D2,$00D2,$002E
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg52:		* Damaged Device (Stbd Gun)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0B00,$4B00,$4B00,$7400,$0000,$0002,$0002,$0002
	.dc.w	$34E0,$44E0,$44E0,$7B00,$0000,$0002,$0002,$0002
	.dc.w	$1A18,$6218,$4218,$7DE0,$0000,$0002,$0002,$0002
	.dc.w	$2DC6,$7106,$4106,$7EF8,$0000,$0002,$0002,$0002
	.dc.w	$35F9,$7901,$4101,$7EFF,$FF00,$FF02,$FF02,$5502
	.dc.w	$3506,$59F8,$4100,$5EFF,$00E0,$00E2,$00E2,$FF02
	.dc.w	$35F9,$7901,$4101,$7EFF,$FF00,$FF02,$FF02,$5502
	.dc.w	$29C6,$7106,$4106,$7EF8,$0000,$0002,$0002,$0002
	.dc.w	$1A18,$6218,$4218,$7DE0,$0000,$0002,$0002,$0002
	.dc.w	$34E0,$44E0,$44E0,$7B00,$0000,$0002,$0002,$0002
	.dc.w	$0B00,$4B00,$4B00,$7400,$0000,$0002,$0002,$0002
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg53:		* Damaged Device (Aft Gun)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0001,$4001,$4001,$4001,$C000,$C002,$C002,$4002
	.dc.w	$0000,$4000,$4000,$4000,$8000,$8002,$8002,$0002
	.dc.w	$0001,$4001,$4001,$4001,$C000,$C002,$C002,$4002
	.dc.w	$0000,$4000,$4000,$4001,$8000,$8002,$8002,$4002
	.dc.w	$0003,$4003,$4003,$4001,$E000,$E002,$E002,$4002
	.dc.w	$0012,$4016,$4016,$4009,$A400,$B402,$B402,$4802
	.dc.w	$01E9,$41E5,$41E5,$401B,$CBC0,$D3C2,$D3C2,$6C02
	.dc.w	$0258,$4244,$4244,$41BB,$8D20,$9122,$9122,$6EC2
	.dc.w	$01B3,$408D,$4085,$437B,$E6C0,$5882,$5082,$EF62
	.dc.w	$07AB,$449C,$4484,$437B,$EAF0,$1C92,$1092,$EF62
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg54:		* Damaged Device (Shields)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0111,$4111,$4111,$4111,$1100,$1102,$1102,$1102
	.dc.w	$0000,$4000,$4000,$4000,$0010,$0012,$0012,$0012
	.dc.w	$1061,$5061,$5061,$5000,$8600,$8602,$8602,$0002
	.dc.w	$0110,$4150,$4150,$40A1,$0880,$0A82,$0A82,$8502
	.dc.w	$1EB1,$5E40,$5E40,$41B1,$8D78,$027A,$027A,$8D82
	.dc.w	$2584,$6475,$6444,$5BB1,$21A4,$AE26,$2226,$8DDA
	.dc.w	$1B35,$48F1,$4840,$77B5,$ACD8,$8F12,$0212,$ADEE
	.dc.w	$3AB3,$49CF,$4840,$77BF,$CD5C,$F392,$0212,$FDEE
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg55:		* Damaged Device (Radio)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$1000,$5000,$5000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0C00,$4C00,$4C00,$5000,$1400,$1402,$1402,$1402
	.dc.w	$1200,$4200,$4200,$5C00,$4100,$4102,$4102,$4102
	.dc.w	$0F30,$5030,$4030,$5FC0,$0800,$0802,$0802,$1002
	.dc.w	$1C70,$5F80,$4000,$5FFF,$E880,$F882,$E082,$1882
	.dc.w	$0F30,$5030,$4030,$5FC0,$0800,$0802,$0802,$1002
	.dc.w	$1200,$4200,$4200,$5C00,$4100,$4102,$4102,$4102
	.dc.w	$0C00,$4C00,$4C00,$5000,$1400,$1402,$1402,$1402
	.dc.w	$1000,$5000,$5000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg56:		* Damaged Device (Warp Drive)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0168,$4117,$4102,$40FD,$B400,$4402,$0402,$F802
	.dc.w	$15D5,$5377,$5042,$4F3D,$5D40,$7642,$1042,$E782
	.dc.w	$2BBF,$66F8,$6088,$5E70,$EEA0,$FB22,$8822,$73C2
	.dc.w	$175D,$4D3F,$410F,$7CF5,$D750,$E592,$8412,$79E2
	.dc.w	$016A,$411F,$410F,$40FA,$B400,$C402,$8402,$F802
	.dc.w	$33D5,$4F57,$4057,$7F3D,$5E64,$5786,$5006,$E7FA
	.dc.w	$19FA,$47BF,$403F,$7F8A,$FCCC,$EF0E,$E00E,$8FF2
	.dc.w	$02BD,$4277,$4217,$41ED,$EA00,$7202,$4202,$BC02
	.dc.w	$0258,$423F,$420F,$41F0,$D200,$E202,$8202,$7C02
	.dc.w	$0167,$411F,$4107,$40F8,$3400,$C402,$0402,$F802
	.dc.w	$00B7,$4088,$4088,$4077,$6800,$8802,$8802,$7002
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg57:		* Damaged Device (Aft View)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$1400,$5400,$4000,$5400,$0054,$0056,$0002,$0056
	.dc.w	$3ED7,$7ED7,$4007,$7ED3,$D6FC,$D6FE,$C002,$D6FE
	.dc.w	$2AAC,$7EAC,$400C,$7EA4,$2AA8,$2AFE,$2002,$2AFE
	.dc.w	$0019,$7E59,$4019,$7E48,$9000,$94FE,$9002,$14FE
	.dc.w	$1433,$6AB2,$4032,$7E91,$4854,$4AAA,$4802,$8AFE
	.dc.w	$2AB4,$4035,$4034,$7E93,$AAA8,$2802,$2802,$4AFE
	.dc.w	$2A33,$4032,$4032,$7E91,$48A8,$4802,$4802,$8AFE
	.dc.w	$0019,$4019,$4019,$7E48,$9000,$9002,$9002,$14FE
	.dc.w	$14AC,$54AC,$54AC,$6A04,$2A54,$2A56,$2A56,$20AA
	.dc.w	$3ED7,$7ED7,$7ED7,$4003,$D6FC,$D6FE,$D6FE,$C002
	.dc.w	$2A00,$6A00,$6A00,$4000,$00A8,$00AA,$00AA,$0002
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
bzimg58:		* Damaged Device (Scanner)
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0000,$4000,$4000,$4000,$0000,$0002,$0002,$0002
	.dc.w	$0015,$4013,$4010,$400F,$5000,$9002,$1002,$E002
	.dc.w	$003E,$403B,$403B,$402E,$F800,$B802,$B802,$E802
	.dc.w	$0035,$4037,$4037,$401C,$5800,$D802,$D802,$7002
	.dc.w	$0014,$4012,$4010,$400F,$5000,$9002,$1002,$E002
	.dc.w	$0001,$4000,$4000,$4001,$0000,$0002,$0002,$0002
	.dc.w	$0000,$4001,$4000,$4001,$0000,$0002,$0002,$0002
	.dc.w	$0181,$4181,$4180,$4001,$0300,$0302,$0302,$0002
	.dc.w	$1C41,$5D41,$5D40,$4281,$1470,$1572,$1572,$0282
	.dc.w	$18D1,$4BC1,$4900,$76D1,$1630,$07A2,$0122,$16DA
	.dc.w	$0000,$7FFF,$7FFF,$7FFF,$0000,$FFFE,$FFFE,$FFFE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

bzimg60:		* HyperComputer Sequence (Step 1)
	.dc.w	$0000,$0000,$8002,$8002,$0000,$0000,$2000,$2000
	.dc.w	$0000,$0000,$0001,$0001,$0000,$0000,$4000,$4000
	.dc.w	$AAAA,$0000,$AAAA,$AAAA,$8000,$0000,$AAAA,$AAAA
	.dc.w	$4005,$0000,$4005,$4005,$0000,$0000,$4000,$4000
	.dc.w	$8002,$0000,$8002,$8002,$0000,$0000,$2000,$2000
	.dc.w	$4004,$0000,$4004,$4004,$0000,$0000,$1001,$1001
	.dc.w	$2008,$0000,$2008,$2008,$0000,$0000,$0802,$0802
	.dc.w	$1010,$0000,$1010,$1010,$0000,$0000,$0404,$0404
	.dc.w	$0820,$0000,$0820,$0820,$0000,$0000,$0208,$0208
	.dc.w	$0540,$0000,$0540,$0540,$0000,$0000,$0110,$0110
	.dc.w	$0280,$0000,$0280,$0280,$0000,$0000,$00A0,$00A0
	.dc.w	$0100,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$0280,$0280,$0000,$0000,$00A0,$00A0
	.dc.w	$0000,$0000,$0440,$0440,$0000,$0000,$0110,$0110
	.dc.w	$0000,$0000,$0820,$0820,$0000,$0000,$0208,$0208
bzimg61:		* HyperComputer Sequence (Step 2)
	.dc.w	$0000,$0000,$8208,$8208,$0000,$0000,$2082,$2082
	.dc.w	$0000,$0000,$4404,$4404,$0000,$0000,$4044,$4044
	.dc.w	$0000,$0000,$2802,$2802,$0000,$0000,$8028,$8028
	.dc.w	$0001,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0002,$0000,$2802,$2802,$8000,$0000,$8028,$8028
	.dc.w	$0004,$0000,$4404,$4404,$4000,$0000,$4044,$4044
	.dc.w	$0008,$0000,$8208,$8208,$2000,$0000,$2082,$2082
	.dc.w	$0010,$0000,$0110,$0110,$1000,$0000,$1101,$1101
	.dc.w	$0020,$0000,$00A0,$00A0,$0800,$0000,$0A00,$0A00
	.dc.w	$0055,$0000,$5555,$5555,$5400,$0000,$5555,$5555
	.dc.w	$0000,$0000,$00A0,$00A0,$0000,$0000,$0A00,$0A00
	.dc.w	$0000,$0000,$0110,$0110,$0000,$0000,$1101,$1101
	.dc.w	$0000,$0000,$8208,$8208,$0000,$0000,$2082,$2082
	.dc.w	$0000,$0000,$4404,$4404,$0000,$0000,$4044,$4044
	.dc.w	$0000,$0000,$2802,$2802,$0000,$0000,$8028,$8028
bzimg62:		* HyperComputer Sequence (Step 3)
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$0A0A,$0A0A,$0000,$0000,$0A0A,$0A0A
	.dc.w	$0000,$0000,$1111,$1111,$0000,$0000,$1111,$1111
	.dc.w	$0000,$0000,$A0A0,$A0A0,$0000,$0000,$A0A0,$A0A0
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$A0A0,$A0A0,$0000,$0000,$A0A0,$A0A0
	.dc.w	$0000,$0000,$1111,$1111,$0000,$0000,$1111,$1111
	.dc.w	$0000,$0000,$0A0A,$0A0A,$0000,$0000,$0A0A,$0A0A
	.dc.w	$0554,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0208,$0000,$0A0A,$0A0A,$0000,$0000,$0A0A,$0A0A
	.dc.w	$0110,$0000,$1111,$1111,$0000,$0000,$1111,$1111
	.dc.w	$00A0,$0000,$A0A0,$A0A0,$0000,$0000,$A0A0,$A0A0
	.dc.w	$0040,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$A0A0,$A0A0,$0000,$0000,$A0A0,$A0A0
	.dc.w	$0000,$0000,$1111,$1111,$0000,$0000,$1111,$1111
bzimg63:		* HyperComputer Sequence (Step 4)
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$4514,$4514,$0000,$0000,$5514,$5514
	.dc.w	$0000,$0000,$28A2,$28A2,$0000,$0000,$88A2,$88A2
	.dc.w	$0001,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0002,$0000,$28A2,$28A2,$8000,$0000,$8A28,$8A28
	.dc.w	$0004,$0000,$4514,$4514,$4000,$0000,$5145,$5145
	.dc.w	$000A,$0000,$AAAA,$AAAA,$A000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$4514,$4514,$0000,$0000,$5145,$5145
	.dc.w	$0000,$0000,$28A2,$28A2,$0000,$0000,$8A28,$8A28
	.dc.w	$0000,$0000,$5555,$5555,$0000,$0000,$5555,$5555
	.dc.w	$0000,$0000,$28A2,$28A2,$0000,$0000,$8A28,$8A28
	.dc.w	$0000,$0000,$4514,$4514,$0000,$0000,$5145,$5145
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$4514,$4514,$0000,$0000,$5145,$5145
	.dc.w	$0000,$0000,$28A2,$28A2,$0000,$0000,$8A28,$8A28
bzimg64:		* HyperComputer Sequence (Step 5)
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$5050,$5050,$0000,$0000,$5050,$5050
	.dc.w	$0000,$0000,$8888,$8888,$0000,$0000,$8888,$8888
	.dc.w	$0000,$0000,$0505,$0505,$0000,$0000,$0505,$0505
	.dc.w	$0000,$0000,$AAAA,$AAAA,$02AA,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$0505,$0505,$0104,$0000,$0505,$0505
	.dc.w	$0000,$0000,$8888,$8888,$0088,$0000,$8888,$8888
	.dc.w	$0000,$0000,$5050,$5050,$0050,$0000,$5050,$5050
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0020,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$5050,$5050,$0000,$0000,$5050,$5050
	.dc.w	$0000,$0000,$8888,$8888,$0000,$0000,$8888,$8888
	.dc.w	$0000,$0000,$0505,$0505,$0000,$0000,$0505,$0505
	.dc.w	$0000,$0000,$AAAA,$AAAA,$0000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$0505,$0505,$0000,$0000,$0505,$0505
	.dc.w	$0000,$0000,$0888,$0888,$0000,$0000,$8888,$8888
bzimg65:		* HyperComputer Sequence (Step 6)
	.dc.w	$0000,$0000,$4104,$4104,$0000,$0000,$1041,$1041
	.dc.w	$0000,$0000,$2202,$2202,$0000,$0000,$2022,$2022
	.dc.w	$0000,$0000,$1401,$1401,$0000,$0000,$4014,$4014
	.dc.w	$0000,$0000,$AAAA,$AAAA,$8000,$0000,$AAAA,$AAAA
	.dc.w	$0001,$0000,$1401,$1401,$4000,$0000,$4014,$4014
	.dc.w	$0002,$0000,$2202,$2202,$2000,$0000,$2022,$2022
	.dc.w	$0004,$0000,$4104,$4104,$1000,$0000,$1041,$1041
	.dc.w	$0008,$0000,$8088,$8088,$0800,$0000,$0880,$0880
	.dc.w	$0010,$0000,$0050,$0050,$0400,$0000,$0500,$0500
	.dc.w	$002A,$0000,$AAAA,$AAAA,$AA00,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$0050,$0050,$0000,$0000,$0500,$0500
	.dc.w	$0000,$0000,$8088,$8088,$0000,$0000,$0880,$0880
	.dc.w	$0000,$0000,$4104,$4104,$0000,$0000,$1041,$1041
	.dc.w	$0000,$0000,$2202,$2202,$0000,$0000,$2022,$2022
	.dc.w	$0000,$0000,$1401,$1401,$0000,$0000,$4014,$4014
bzimg66:		* HyperComputer Sequence (Step 7)
	.dc.w	$0000,$0000,$1400,$1400,$0000,$0000,$0014,$0014
	.dc.w	$0AAA,$0000,$AAAA,$AAAA,$AAA8,$0000,$AAAA,$AAAA
	.dc.w	$0500,$0000,$1500,$1500,$0050,$0000,$0054,$0054
	.dc.w	$0200,$0000,$2200,$2200,$0020,$0000,$0022,$0022
	.dc.w	$0100,$0000,$4100,$4100,$0040,$0000,$0041,$0041
	.dc.w	$0080,$0000,$8080,$8080,$0080,$0000,$0080,$0080
	.dc.w	$0040,$0000,$0040,$0040,$0100,$0000,$0100,$0100
	.dc.w	$0020,$0000,$0020,$0020,$0200,$0000,$0200,$0200
	.dc.w	$0010,$0000,$0010,$0010,$0400,$0000,$0400,$0400
	.dc.w	$0008,$0000,$0008,$0008,$0800,$0000,$0800,$0800
	.dc.w	$0004,$0000,$0004,$0004,$1000,$0000,$1000,$1000
	.dc.w	$0002,$0000,$0002,$0002,$A000,$0000,$A000,$A000
	.dc.w	$0001,$0000,$0001,$0001,$4000,$0000,$4000,$4000
	.dc.w	$0000,$0000,$AAAA,$AAAA,$8000,$0000,$AAAA,$AAAA
	.dc.w	$0000,$0000,$0001,$0001,$0000,$0000,$4000,$4000
bzimg67:		* HyperComputer Sequence (Step 8)
	.dc.w	$0000,$0000,$0400,$0400,$0040,$0000,$0040,$0040
	.dc.w	$0000,$0000,$0200,$0200,$0080,$0000,$0080,$0080
	.dc.w	$0000,$0000,$0100,$0100,$0100,$0000,$0100,$0100
	.dc.w	$0000,$0000,$0080,$0080,$0200,$0000,$0200,$0200
	.dc.w	$0000,$0000,$0040,$0040,$0400,$0000,$0400,$0400
	.dc.w	$0000,$0000,$0020,$0020,$0800,$0000,$0800,$0800
	.dc.w	$0000,$0000,$0010,$0010,$1400,$0000,$1400,$1400
	.dc.w	$0000,$0000,$0008,$0008,$2200,$0000,$2200,$2200
	.dc.w	$0000,$0000,$0004,$0004,$4100,$0000,$4100,$4100
	.dc.w	$0000,$0000,$0002,$0002,$8080,$0000,$8080,$8080
	.dc.w	$0001,$0000,$5555,$5555,$5555,$0000,$5555,$5555
	.dc.w	$0000,$0000,$0002,$0002,$0000,$0000,$8000,$8000
	.dc.w	$0000,$0000,$0004,$0004,$0000,$0000,$4000,$4000
	.dc.w	$0000,$0000,$0008,$0008,$0000,$0000,$2000,$2000
	.dc.w	$0000,$0000,$0010,$0010,$0000,$0000,$1000,$1000

	.end
