*
*	ROCKDATA.S	ST Star-Raiders ASTEROID Image Data
*

*
*	PUBLIC SYMBOLS
*
	.globl	rock00
	.globl	rock01
	.globl	rock02
	.globl	rock03
	.globl	rock04
	.globl	rock05
	.globl	rock06
	.globl	rock07
	.globl	rock10
	.globl	rock11
	.globl	rock12
	.globl	rock13
	.globl	rock14
	.globl	rock15
	.globl	rock16
	.globl	rock17
	.globl	rock20
	.globl	rock21
	.globl	rock22
	.globl	rock23
	.globl	rock24
	.globl	rock25
	.globl	rock26
	.globl	rock27
	.globl	rock30
	.globl	rock31
	.globl	rock32
	.globl	rock33
	.globl	rock34
	.globl	rock35
	.globl	rock36
	.globl	rock37
	.globl	rock40
	.globl	rock41
	.globl	rock42
	.globl	rock43
	.globl	rock44
	.globl	rock45
	.globl	rock46
	.globl	rock47
	.globl	rock50
	.globl	rock51
	.globl	rock52
	.globl	rock53
	.globl	rock54
	.globl	rock55
	.globl	rock56
	.globl	rock57
	.globl	rock60
	.globl	rock61
	.globl	rock62
	.globl	rock63
	.globl	rock64
	.globl	rock65
	.globl	rock66
	.globl	rock67
	.globl	rock70
	.globl	rock71
	.globl	rock72
	.globl	rock73
	.globl	rock74
	.globl	rock75
	.globl	rock76
	.globl	rock77

*
*	ASTEROID Image data
*		Xoffset,Yoffset (pixels)
*		Height (lines), Width (words)
*		Image_Data
*
*	        Each ROCK Having EIGHT Perspective Depths
*

	.data
	.even

rock00:		* Asteroid (Perspective:0 - Animation:0)
	.dc.w	16,15
	.dc.w	32,3
	.dc.w	$0000,$0000,$0000,$0000,$0000,$7438,$1000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0000,$0000
	.dc.w	$0028,$FFEC,$5F10,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$01C4,$FFC6,$9E38,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0000,$0000
	.dc.w	$0854,$FFC1,$F7BE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0004,$1F7F,$0A3B,$0000,$100A,$BF22,$EFFD,$0020
	.dc.w	$8000,$C000,$0000,$0000,$0002,$3FFE,$1FFD,$0000
	.dc.w	$EFD5,$FFC0,$103F,$0000,$4000,$4000,$8000,$0000
	.dc.w	$0007,$3FFF,$1FF8,$0000,$00AA,$FF80,$FF7F,$0000
	.dc.w	$8000,$0000,$C000,$0000,$00C0,$7FFF,$3F3F,$0000
	.dc.w	$8351,$FFC4,$2CBF,$0004,$4000,$0000,$C000,$0000
	.dc.w	$0028,$FFFF,$7FD7,$0000,$40AB,$FFA1,$175E,$0000
	.dc.w	$C000,$C000,$0000,$0000,$1000,$FFFF,$6FFE,$0000
	.dc.w	$0347,$FF51,$A8BE,$0010,$0000,$C000,$0000,$0000
	.dc.w	$0001,$FFFF,$7FFE,$0000,$00A8,$FE83,$577E,$0002
	.dc.w	$0000,$8000,$0000,$0000,$0000,$FFFF,$7FEA,$0000
	.dc.w	$0A12,$F603,$A9FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$FFFF,$7FD4,$0000,$06A8,$EC00,$53FC,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$FFFF,$3FAA,$0000
	.dc.w	$0514,$7D06,$AAF8,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0005,$3FFE,$3FD1,$0000,$5728,$0200,$FDFC,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000A,$1FFF,$0FA0,$0000
	.dc.w	$2F6C,$0774,$F898,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0004,$03FB,$0055,$0000,$1FF8,$02C4,$FD38,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000A,$00FC,$0063,$0000
	.dc.w	$2AF8,$2400,$DFF8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0038,$001F,$0000,$1560,$8B30,$FED8,$0010
	.dc.w	$0000,$0000,$0000,$0000,$0009,$0078,$0047,$0000
	.dc.w	$EF88,$E9D8,$1670,$0050,$0000,$0000,$0000,$0000
	.dc.w	$000F,$005C,$0043,$0000,$A970,$7918,$D6E0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0005,$000C,$0003,$0000
	.dc.w	$D3B0,$32B8,$ED40,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0006,$0006,$0001,$0000,$FE80,$1810,$E7E0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0003,$0007,$0000,$0000
	.dc.w	$73E0,$17A0,$EC40,$0400,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0007,$0000,$0000,$FF00,$E020,$1FC0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0003,$0000
	.dc.w	$9F40,$8A60,$7580,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0001,$0000,$6E40,$D860,$B780,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0001,$0000
	.dc.w	$5480,$F000,$AFC0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0007,$0004,$0000,$6F80,$FF80,$1000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2800,$FB00,$1440,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0002,$0000,$0000,$0800,$7E00,$2400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$3880,$0000,$0000,$0000,$0000,$0000,$0000
rock01:		* Asteroid (Perspective:0 - Animation:1)
	.dc.w	16,16
	.dc.w	33,2
	.dc.w	$0000,$0003,$0001,$0000,$4800,$CC00,$3000,$0000
	.dc.w	$0001,$000F,$0004,$0000,$6400,$1600,$F800,$1000
	.dc.w	$002A,$0066,$0019,$0000,$F500,$0980,$FE00,$0800
	.dc.w	$0052,$01CC,$003F,$000C,$AE80,$00E0,$FF00,$0000
	.dc.w	$03A5,$0F58,$04FF,$0058,$5AE8,$154C,$EFB0,$0500
	.dc.w	$023A,$7EC0,$2DFF,$00C0,$2528,$808C,$FFF0,$8080
	.dc.w	$07C5,$7F38,$18FF,$0038,$58D0,$0020,$FFF4,$0020
	.dc.w	$058A,$7C70,$1BFF,$0070,$2E68,$8E0C,$F1F0,$8000
	.dc.w	$0440,$FC3D,$7BFF,$003D,$45A0,$05A0,$FA40,$0000
	.dc.w	$041C,$FC62,$3BFF,$0062,$A9C0,$01E0,$FE20,$0000
	.dc.w	$0C2B,$FC54,$73FF,$0054,$0580,$5198,$FE78,$5000
	.dc.w	$06D0,$FE2F,$19FF,$002F,$8A20,$2278,$FDC8,$2000
	.dc.w	$0923,$FD2C,$76DF,$000C,$51E0,$0598,$FE60,$0400
	.dc.w	$08DC,$FC01,$17FF,$0001,$8AC0,$2158,$FFB0,$2100
	.dc.w	$08C3,$FEC8,$373F,$0008,$05E0,$D270,$FF90,$D200
	.dc.w	$0324,$FB20,$7CDF,$0000,$DD00,$20BC,$FFC4,$2080
	.dc.w	$0943,$FFC3,$743C,$0000,$6840,$107C,$FFB0,$1000
	.dc.w	$101E,$FFDC,$6AA3,$0000,$5D00,$6D38,$B2F0,$2000
	.dc.w	$014D,$FFEE,$3413,$0000,$A2A0,$9838,$7FD8,$1000
	.dc.w	$00BB,$7FF9,$1A06,$0000,$6540,$1018,$FFF0,$1000
	.dc.w	$0104,$FFE4,$745B,$0000,$9888,$023C,$FFE0,$0200
	.dc.w	$0005,$FF7C,$5ABB,$0000,$1114,$0454,$FFE8,$0440
	.dc.w	$002B,$FFEB,$3D54,$0000,$AA38,$9080,$7FFC,$1080
	.dc.w	$03C6,$FFD5,$6C3A,$0000,$8140,$C000,$3FFC,$0000
	.dc.w	$0139,$FFFF,$16C4,$0000,$01F0,$A0F4,$5F08,$0000
	.dc.w	$0000,$3E3F,$27FA,$0000,$2988,$79E8,$8660,$0000
	.dc.w	$0339,$FFFF,$30C4,$0000,$1E00,$FFE0,$4160,$0000
	.dc.w	$0002,$8FFF,$07F8,$0000,$0400,$FFE0,$AB80,$0000
	.dc.w	$0001,$0FFF,$01C8,$0000,$0000,$F280,$5200,$0000
	.dc.w	$0000,$01F7,$00F6,$0000,$0000,$FF00,$B000,$0000
	.dc.w	$0000,$00FB,$0052,$0000,$0000,$F000,$F000,$0000
	.dc.w	$0040,$0045,$0034,$0000,$0000,$A000,$0000,$0000
	.dc.w	$0000,$0014,$0000,$0000,$0000,$4000,$4000,$0000
rock02:		* Asteroid (Perspective:0 - Animation:2)
	.dc.w	17,15
	.dc.w	33,3
	.dc.w	$0001,$0003,$0000,$0000,$5000,$1800,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0002,$01C4,$0103,$0000
	.dc.w	$8000,$0C04,$FC00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0299,$0648,$01F7,$0000,$1520,$1338,$ECC0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$041E,$0C10,$03EF,$0000
	.dc.w	$22D8,$2408,$DFF0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$09A0,$3844,$07FF,$0004,$40A4,$4150,$BFFC,$0150
	.dc.w	$0000,$0000,$0000,$0000,$194A,$78C0,$27BF,$0000
	.dc.w	$8DF4,$AC06,$53F8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1195,$7180,$2E7F,$0000,$1600,$1E04,$E9F8,$0000
	.dc.w	$0000,$0000,$0000,$0000,$16A2,$74E0,$0B5F,$0000
	.dc.w	$ADF4,$7DFA,$D204,$0000,$0000,$8000,$0000,$0000
	.dc.w	$08C0,$7900,$37FF,$0000,$1652,$3F7A,$E9AC,$0000
	.dc.w	$0000,$0000,$0000,$0000,$364A,$7608,$49F7,$0000
	.dc.w	$7020,$1661,$EFDE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0914,$7921,$76DF,$0001,$A963,$1865,$F79A,$0000
	.dc.w	$0000,$0000,$0000,$0000,$3A61,$FE04,$45FF,$0004
	.dc.w	$D69A,$1198,$EF67,$0000,$0000,$8000,$0000,$0000
	.dc.w	$3190,$F991,$4E6F,$0001,$B967,$2DE0,$D69F,$0400
	.dc.w	$8000,$C000,$0000,$0000,$0079,$7A78,$7587,$0000
	.dc.w	$E3B1,$01B2,$FE4F,$0002,$4000,$6000,$8000,$0000
	.dc.w	$0A23,$7FA2,$60DD,$0000,$D062,$11E0,$EF1F,$0000
	.dc.w	$8000,$C000,$0000,$0000,$045C,$7FD5,$512B,$0001
	.dc.w	$A871,$28F1,$D78E,$0000,$0000,$8000,$0000,$0000
	.dc.w	$08A3,$7F90,$227F,$0000,$119B,$41F8,$FE67,$0000
	.dc.w	$0000,$8000,$8000,$0000,$107C,$7EFC,$0503,$0000
	.dc.w	$A86C,$026C,$FF93,$0000,$0000,$4000,$8000,$0000
	.dc.w	$0091,$3D90,$0A6F,$0000,$153B,$C13A,$FEC5,$C000
	.dc.w	$C000,$A000,$4000,$0000,$0017,$3FB4,$154B,$0000
	.dc.w	$8BCE,$625E,$FDB1,$6000,$6000,$6000,$8000,$0000
	.dc.w	$0400,$7D51,$3AAF,$0001,$9874,$6780,$FFFF,$6780
	.dc.w	$4000,$9000,$E000,$8000,$0017,$7FFE,$1D41,$0000
	.dc.w	$2FBA,$D040,$FFFF,$D040,$F000,$1000,$E000,$0000
	.dc.w	$2E2C,$7FFC,$5083,$0000,$E0D5,$0000,$FFFF,$0000
	.dc.w	$0000,$4000,$F000,$4000,$0010,$7FB8,$7D47,$0000
	.dc.w	$8402,$84A8,$7BFF,$00A8,$8000,$A800,$7000,$2000
	.dc.w	$0008,$6D58,$2EA7,$0000,$EF00,$CD55,$32FF,$0055
	.dc.w	$4800,$1800,$F000,$1000,$0301,$13A0,$045F,$0000
	.dc.w	$EE2A,$F180,$1FFF,$0180,$2000,$8000,$F800,$8000
	.dc.w	$020D,$03DB,$0136,$0000,$5140,$C015,$BFFF,$0015
	.dc.w	$5800,$0800,$F000,$0000,$107E,$12FF,$0081,$0000
	.dc.w	$8E20,$CE02,$71FF,$0002,$0000,$0800,$F000,$0000
	.dc.w	$0018,$00FE,$00A0,$0000,$4F93,$EF90,$806F,$0000
	.dc.w	$4000,$5800,$A000,$0000,$0000,$00E8,$0000,$0000
	.dc.w	$83D9,$83F9,$0006,$0000,$8000,$E000,$2000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$01BF,$01FF,$0000,$0000
	.dc.w	$0000,$E000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000E,$007F,$0000,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0002,$0002,$0000
	.dc.w	$0000,$0000,$0000,$0000
rock03:		* Asteroid (Perspective:0 - Animation:3)
	.dc.w	18,16
	.dc.w	34,3
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1810,$0810,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$3E30,$1C00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0DA0,$FFA8,$5250,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0001,$0000
	.dc.w	$03D8,$FF88,$FC70,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$008F,$0000,$0000,$0860,$FF44,$F7B8,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$007F,$001F,$0000
	.dc.w	$00FC,$FFB6,$FF48,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01FF,$007F,$0000,$04D0,$FE42,$FBBC,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0004,$01FF,$007B,$0000
	.dc.w	$08AC,$FCA2,$E35C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03FF,$01FF,$0000,$0112,$FF42,$D4FC,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0004,$03FF,$03FB,$0000
	.dc.w	$0A28,$FF80,$A0FE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$07FF,$03FF,$0000,$0056,$FF04,$D5FA,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0008,$0FFF,$07F7,$0000
	.dc.w	$22A2,$FF0B,$88FC,$0008,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0FFF,$07FF,$0000,$1551,$FE03,$C1FC,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0004,$0FFF,$07D2,$0000
	.dc.w	$0AA6,$FE2A,$21DD,$0008,$0000,$0000,$0000,$0000
	.dc.w	$0009,$0FFF,$0FA0,$0000,$FDD9,$AFE5,$523E,$0020
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1FFE,$0F11,$0000
	.dc.w	$55E1,$4F0F,$BAFE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$002B,$3FF4,$1F0B,$0000,$8696,$0A09,$FDFF,$0000
	.dc.w	$8000,$8000,$0000,$0000,$0010,$3FFA,$3F45,$0000
	.dc.w	$F3D5,$3040,$CFBF,$0000,$0000,$4000,$8000,$0000
	.dc.w	$0083,$7FF7,$3F08,$0000,$7FEA,$7C20,$83DF,$0000
	.dc.w	$8000,$4000,$8000,$0000,$0002,$7FFE,$3FC1,$0000
	.dc.w	$8791,$1400,$FBFF,$0000,$4000,$6000,$8000,$0000
	.dc.w	$0211,$7FFF,$3DEC,$0000,$6462,$2448,$DBBF,$0008
	.dc.w	$A000,$3000,$C000,$0000,$000D,$FFFF,$7FF0,$0000
	.dc.w	$5B91,$03C0,$FC7F,$0040,$5000,$1000,$E000,$0000
	.dc.w	$0212,$FFFE,$3DE9,$0000,$BCEA,$4340,$FFBF,$4000
	.dc.w	$E000,$0800,$F000,$0000,$0096,$7FF1,$0F4F,$0001
	.dc.w	$DDF1,$0424,$FBDF,$0004,$2800,$3800,$D000,$1000
	.dc.w	$012F,$0FE8,$0697,$0000,$BEF3,$1A2D,$E5DE,$000C
	.dc.w	$D000,$2000,$F800,$2000,$0059,$07C8,$0137,$0000
	.dc.w	$FBDB,$F80C,$07F7,$0004,$F000,$0000,$F800,$0000
	.dc.w	$001B,$03FA,$0161,$0000,$88A9,$98A4,$075F,$0004
	.dc.w	$6800,$0800,$F000,$0000,$0003,$0027,$0000,$0000
	.dc.w	$07AC,$1FE2,$185F,$0002,$1000,$1800,$E800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0011,$01F0,$00EF,$0000
	.dc.w	$E000,$7800,$9000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0022,$01E2,$009D,$0000,$8000,$F000,$6000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000B,$00FB,$0064,$0000
	.dc.w	$C000,$E000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$007F,$001C,$0000,$0000,$4000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$003F,$001F,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$000F,$0000,$0000,$0000,$8000,$0000,$0000
rock04:		* Asteroid (Perspective:0 - Animation:4)
	.dc.w	14,15
	.dc.w	32,2
	.dc.w	$0000,$0000,$0000,$0000,$0B00,$3980,$0600,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1280,$70C0,$4F00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1340,$F060,$4F80,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2140,$E060,$DF80,$0000
	.dc.w	$0000,$0001,$0001,$0000,$3550,$FC98,$83E0,$0080
	.dc.w	$0000,$0003,$0003,$0000,$CBA0,$F808,$37F0,$0000
	.dc.w	$0002,$000F,$0005,$0000,$3E08,$F818,$C7F0,$0010
	.dc.w	$0000,$003E,$0007,$0000,$0060,$A040,$FFB8,$0000
	.dc.w	$0005,$007C,$001B,$0000,$F318,$3710,$C8E8,$0000
	.dc.w	$0008,$00FC,$00B7,$0000,$5E60,$4E62,$B19A,$0000
	.dc.w	$0005,$01FC,$00FB,$0000,$C1D0,$09D8,$FE20,$0000
	.dc.w	$000A,$03F0,$01FF,$0000,$2F90,$0FB4,$F048,$0000
	.dc.w	$002B,$07E1,$03DE,$0000,$B7E8,$8024,$7FD8,$0000
	.dc.w	$0029,$07E1,$07DE,$0000,$13EC,$1224,$EDD8,$0000
	.dc.w	$0020,$1FE2,$07DF,$0000,$FE60,$2008,$DFFC,$0008
	.dc.w	$0016,$3FFF,$0FC1,$0000,$A4BC,$1100,$FFFC,$1100
	.dc.w	$006A,$7FFE,$1F85,$0000,$EA54,$0028,$FFFC,$0028
	.dc.w	$0032,$FE0E,$7FFD,$0000,$D7A0,$2058,$FFFC,$2058
	.dc.w	$0001,$FE50,$75FF,$0040,$6844,$14CC,$FFB8,$1488
	.dc.w	$02AD,$7F25,$28DA,$0000,$5DA8,$0224,$FFD8,$0200
	.dc.w	$0445,$7E86,$1179,$0000,$E010,$011C,$FFE8,$0100
	.dc.w	$02A5,$7F0C,$28FB,$0000,$B668,$346C,$CB90,$0000
	.dc.w	$0015,$3E8C,$117B,$0000,$A5D4,$E5C6,$5A38,$0000
	.dc.w	$0220,$3E08,$21FF,$0000,$3514,$FDA6,$CAF8,$0000
	.dc.w	$038E,$3F9F,$1061,$0000,$C0F4,$FEF4,$2B08,$0000
	.dc.w	$0000,$3F8E,$0000,$0000,$3918,$7BCE,$46F4,$0000
	.dc.w	$0000,$0800,$0000,$0000,$05F4,$0D66,$0A98,$0000
	.dc.w	$0000,$2000,$0000,$0000,$0A18,$181C,$07E0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0CA0,$3E68,$0190,$0000
	.dc.w	$0000,$0000,$0000,$0000,$02E0,$1EF0,$0110,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0100,$07C0,$0200,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0380,$0000,$0000
rock05:		* Asteroid (Perspective:0 - Animation:5)
	.dc.w	16,14
	.dc.w	30,3
	.dc.w	$0000,$0000,$0000,$0000,$0480,$0CC0,$0300,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$05A0,$1C60,$0BC0,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$17C0,$7E68,$0980,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0DD0,$FD1A,$32E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0000,$0000,$1460,$FC7E,$6B98,$0018
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0001,$0000
	.dc.w	$4FDE,$FFC7,$B038,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$003F,$0007,$0000,$30F9,$F0F9,$CF06,$0000
	.dc.w	$0000,$8000,$0000,$0000,$0061,$01F7,$001E,$0000
	.dc.w	$6B7A,$EB70,$948F,$0000,$4000,$8000,$4000,$0000
	.dc.w	$0231,$06FF,$01CC,$0000,$C487,$84C6,$7B79,$0000
	.dc.w	$C000,$8000,$4000,$0000,$0461,$0FFF,$0B9C,$0000
	.dc.w	$0A3C,$0038,$FFC7,$0000,$0000,$0000,$C000,$0000
	.dc.w	$00BB,$1FBF,$0E44,$0000,$957F,$8004,$7FFB,$0000
	.dc.w	$C000,$4000,$8000,$0000,$0006,$1FFF,$0FF8,$0000
	.dc.w	$AAFD,$8001,$7FFE,$0000,$0000,$4000,$8000,$0000
	.dc.w	$00A0,$1FB7,$1E4D,$0000,$D4C7,$C491,$3B7E,$0010
	.dc.w	$8000,$0000,$8000,$0000,$0011,$1FFF,$1FEE,$0000
	.dc.w	$618B,$E1A0,$1E7F,$0020,$0000,$0000,$8000,$0000
	.dc.w	$0401,$1FFF,$1BDC,$0000,$7211,$6244,$9DFF,$0044
	.dc.w	$8000,$8000,$0000,$0000,$0202,$3FFF,$1DFD,$0000
	.dc.w	$898B,$81A0,$7E7F,$0020,$0000,$8000,$0000,$0000
	.dc.w	$0000,$3FFF,$1FFE,$0000,$1751,$0704,$F8FF,$0004
	.dc.w	$0000,$0000,$0000,$0000,$0012,$1FFE,$1FE9,$0000
	.dc.w	$330A,$7320,$CCFF,$0020,$0000,$0000,$0000,$0000
	.dc.w	$0145,$3F7C,$1C93,$0000,$77D7,$FFC1,$883E,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0007,$7F7F,$1FE8,$0000
	.dc.w	$48F8,$C965,$379E,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0B9A,$7F8A,$3475,$0000,$5726,$5722,$A8DC,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0CA7,$7E99,$737E,$0018
	.dc.w	$3C8C,$3886,$C778,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00DD,$7FE2,$7F3F,$0022,$FF38,$FF0C,$00F0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0136,$FF95,$5E6B,$0001
	.dc.w	$73F0,$6910,$9EE0,$0800,$0000,$0000,$0000,$0000
	.dc.w	$00E3,$7FE2,$5E1D,$0000,$12A0,$CA30,$FDC0,$0800
	.dc.w	$0000,$0000,$0000,$0000,$0073,$FF73,$660C,$0000
	.dc.w	$5C40,$DC60,$2380,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000C,$4F0F,$0303,$0000,$3680,$F0C0,$CF00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$000F,$0005,$0000
	.dc.w	$0800,$DE00,$A000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$000F,$0000,$0000,$5000,$5800,$A000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$C000,$0000,$0000,$0000,$0000,$0000,$0000
rock06:		* Asteroid (Perspective:0 - Animation:6)
	.dc.w	20,14
	.dc.w	31,3
	.dc.w	$0000,$0000,$0000,$0000,$0050,$0198,$0060,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0000,$0000
	.dc.w	$0010,$C3D8,$4020,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0001,$001E,$0000,$1C0D,$FF01,$02FE,$0000
	.dc.w	$0000,$0000,$0000,$0000,$004C,$0043,$003F,$0002
	.dc.w	$00AB,$FEA0,$DF5F,$0000,$8000,$8000,$0000,$0000
	.dc.w	$01B3,$01B5,$004E,$0000,$E055,$A145,$5EBA,$0000
	.dc.w	$5000,$1800,$E000,$0000,$00E4,$1FE2,$181F,$0000
	.dc.w	$16AF,$0002,$FFFD,$0000,$1800,$0400,$F800,$0000
	.dc.w	$0058,$3FFD,$3C87,$0000,$A841,$8103,$7FFE,$0100
	.dc.w	$8C00,$0400,$F800,$0000,$0223,$7FFA,$7C1D,$0000
	.dc.w	$1480,$0004,$FFFB,$0000,$6000,$6800,$9C00,$0000
	.dc.w	$0153,$7FF0,$3A8F,$0000,$AB08,$0000,$FFFF,$0000
	.dc.w	$AC00,$0000,$FC00,$0000,$0054,$7FF0,$7FAF,$0000
	.dc.w	$4594,$1040,$FFFF,$1040,$1400,$0200,$FC00,$0000
	.dc.w	$0021,$FFFC,$7F4B,$0000,$AA28,$0182,$FFFF,$0182
	.dc.w	$AA00,$0200,$FC00,$0000,$001E,$FFFE,$7F81,$0000
	.dc.w	$0395,$0000,$FFFF,$0000,$5400,$4000,$BE00,$0000
	.dc.w	$04A1,$FFA0,$7A5F,$0000,$DE2A,$D5C0,$2BFF,$01C0
	.dc.w	$A000,$0A00,$FC00,$0800,$01A2,$7F80,$7E7F,$0000
	.dc.w	$411F,$D860,$27FF,$0060,$5400,$1400,$E800,$0000
	.dc.w	$0145,$7F10,$3CFF,$0010,$08A9,$7A16,$A7FF,$0216
	.dc.w	$A000,$0400,$FC00,$0000,$0028,$3F02,$14FF,$0002
	.dc.w	$C556,$B409,$5BFF,$0009,$1D00,$4D00,$F200,$4000
	.dc.w	$0151,$1F45,$04BE,$0000,$58A8,$5A16,$A7FF,$0216
	.dc.w	$AC00,$0600,$F800,$0000,$0068,$0FE2,$061D,$0000
	.dc.w	$D509,$D05C,$2FF7,$0054,$1100,$4100,$FE00,$4000
	.dc.w	$0021,$07E5,$001E,$0004,$4A0A,$C0AC,$3FF7,$00A4
	.dc.w	$A200,$0700,$F800,$0000,$004C,$01C3,$003D,$0000
	.dc.w	$6400,$B15D,$DFFF,$015D,$1400,$4600,$F800,$4000
	.dc.w	$003E,$007E,$0041,$0000,$F65E,$21E0,$DFBF,$01A0
	.dc.w	$2800,$8C00,$F000,$8000,$0007,$007E,$0009,$0000
	.dc.w	$D456,$130A,$EFFD,$0308,$5000,$1C00,$E000,$0000
	.dc.w	$0009,$0018,$0007,$0000,$F828,$2680,$DFFF,$0680
	.dc.w	$8000,$3800,$C000,$0000,$0004,$000C,$0003,$0000
	.dc.w	$F547,$0014,$FFEB,$0000,$6000,$3000,$C000,$0000
	.dc.w	$0002,$0046,$0001,$0000,$18AE,$160B,$EFF5,$0600
	.dc.w	$C000,$F000,$0000,$0000,$0001,$0003,$0000,$0000
	.dc.w	$6050,$6557,$9FAC,$0500,$0000,$E000,$8000,$0000
	.dc.w	$0001,$0001,$0000,$0000,$7620,$F02F,$8FD6,$0000
	.dc.w	$0000,$8000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3D00,$795E,$06A8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$3BF8,$0680,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0200,$2E00,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1E00,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000
rock07:		* Asteroid (Perspective:0 - Animation:7)
	.dc.w	21,15
	.dc.w	34,3
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$9000,$1000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00A2,$47B6,$0241,$0000,$9000,$B000,$0000,$0000
	.dc.w	$012C,$016C,$0010,$0000,$215E,$AFDE,$5821,$0000
	.dc.w	$2000,$6A00,$D000,$0000,$0149,$034D,$00B2,$0000
	.dc.w	$C8C9,$EFFD,$3722,$0000,$0000,$1600,$FA00,$1000
	.dc.w	$004E,$1FD2,$04AD,$0000,$8012,$18F0,$FFEF,$0000
	.dc.w	$8000,$8300,$7C00,$0000,$0153,$3F40,$1CBF,$0000
	.dc.w	$46EB,$671B,$B9F4,$0000,$5500,$0100,$FE00,$0000
	.dc.w	$0040,$3FC0,$1F3F,$0000,$086D,$0B8C,$F7F3,$0380
	.dc.w	$AA00,$0000,$FF00,$0000,$113C,$374C,$2CF3,$0040
	.dc.w	$4510,$1050,$FFEF,$0040,$5400,$0000,$FF00,$0000
	.dc.w	$0402,$3DE6,$33F9,$01E0,$8274,$A014,$7FEB,$0000
	.dc.w	$0300,$2900,$FE00,$2800,$0B9D,$787F,$27E0,$0060
	.dc.w	$416C,$1500,$FEFF,$1400,$0000,$0100,$FE00,$0000
	.dc.w	$0421,$FC5F,$73F0,$0050,$2A0F,$002F,$FFF0,$0020
	.dc.w	$6600,$6200,$9C00,$0000,$1068,$F037,$4FCA,$0000
	.dc.w	$0530,$0000,$FFFF,$0000,$0400,$0600,$F800,$0000
	.dc.w	$0C11,$FC3F,$23C4,$0000,$228F,$8A87,$7D78,$0800
	.dc.w	$2000,$6200,$9C00,$0000,$05A0,$7DBF,$224A,$0000
	.dc.w	$898C,$8380,$7C7F,$0000,$0E00,$8B00,$7400,$0000
	.dc.w	$0250,$3FFF,$3005,$0000,$0CE3,$87C7,$7A3C,$0004
	.dc.w	$5900,$5900,$A600,$0000,$0000,$1F3F,$080A,$0000
	.dc.w	$C8CF,$DF80,$227F,$0000,$E600,$6000,$9F00,$0000
	.dc.w	$0000,$0E7F,$0435,$0000,$5138,$EF26,$90DF,$0006
	.dc.w	$0000,$0200,$FF00,$0200,$0000,$00FF,$007F,$0000
	.dc.w	$8A26,$FF20,$20DF,$0000,$E300,$A100,$5E00,$0000
	.dc.w	$0000,$007F,$007F,$0000,$0086,$FA00,$C5FF,$0000
	.dc.w	$4600,$0100,$FE00,$0000,$0003,$007F,$001C,$0000
	.dc.w	$802C,$FD23,$2ADF,$0003,$3200,$1200,$EC00,$0000
	.dc.w	$0000,$001F,$000F,$0000,$00C3,$FB00,$15FF,$0100
	.dc.w	$8400,$0000,$FC00,$0000,$0004,$000F,$0002,$0000
	.dc.w	$03F0,$FC01,$2BFF,$0001,$EC00,$6C00,$9000,$0000
	.dc.w	$0000,$000F,$0006,$0000,$1BE4,$F804,$27FB,$0000
	.dc.w	$8800,$8800,$7000,$0000,$0003,$000F,$0004,$0000
	.dc.w	$21A5,$F000,$1FFF,$0000,$5000,$5000,$A000,$0000
	.dc.w	$0001,$0007,$0006,$0000,$641A,$E418,$9BE7,$0000
	.dc.w	$8000,$9000,$7000,$0000,$0000,$0007,$0001,$0000
	.dc.w	$45B4,$E410,$BBEF,$0000,$C000,$F000,$0000,$0000
	.dc.w	$0000,$0003,$0000,$0000,$3C49,$FC01,$C3FE,$0000
	.dc.w	$0000,$C000,$4000,$0000,$0000,$0001,$0000,$0000
	.dc.w	$2A10,$FE11,$D5EF,$0000,$0000,$C000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$072C,$FF0F,$18F2,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0188,$7F8E,$2E70,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00D0,$7FD8,$0928,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0540,$0FF0,$0080,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0300,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0240,$0000,$0000,$0000,$0000,$0000,$0000
rock10:		* Asteroid (Perspective:1 - Animation:0)
	.dc.w	15,14
	.dc.w	29,2
	.dc.w	$0000,$0001,$0001,$0000,$0000,$C000,$4000,$0000
	.dc.w	$0000,$0007,$0003,$0000,$0000,$E200,$0100,$0000
	.dc.w	$0000,$0007,$0005,$0000,$0700,$FFC0,$F840,$0000
	.dc.w	$0000,$0007,$0001,$0000,$11C0,$FC70,$EF90,$0000
	.dc.w	$0000,$1C3F,$1C2F,$0000,$6570,$FC1C,$9BE4,$0000
	.dc.w	$0004,$3FFF,$1EF1,$0000,$D8B8,$F80C,$27F4,$0000
	.dc.w	$001C,$7FFF,$3FE3,$0000,$4410,$F558,$BBE0,$0140
	.dc.w	$0202,$7FFF,$787D,$0000,$0820,$F898,$E7E8,$0080
	.dc.w	$0001,$FFFF,$7EFC,$0000,$0040,$F410,$7BF0,$0000
	.dc.w	$0002,$FFFF,$7FF9,$0000,$8080,$F800,$77E0,$0000
	.dc.w	$0009,$FFFB,$7FE6,$0000,$0920,$F860,$27C0,$0040
	.dc.w	$0002,$FFFF,$7FFD,$0000,$2CC0,$E720,$9BC0,$0300
	.dc.w	$0001,$FFFF,$7FFC,$0000,$2380,$2020,$DFE0,$0000
	.dc.w	$0005,$7FFC,$3FD3,$0000,$BE40,$79C0,$C780,$0180
	.dc.w	$0028,$3FF8,$0F87,$0000,$DF80,$1C40,$E380,$0000
	.dc.w	$0040,$07C4,$00BF,$0000,$3E00,$7340,$CDC0,$4100
	.dc.w	$0048,$01C0,$00BF,$0000,$B680,$8780,$7900,$0100
	.dc.w	$0034,$0070,$000F,$0000,$2900,$1880,$F700,$0000
	.dc.w	$0000,$0020,$003F,$0000,$8400,$2B80,$FF80,$0300
	.dc.w	$0035,$0030,$000F,$0000,$7F00,$6900,$9600,$0000
	.dc.w	$001A,$0018,$0007,$0000,$B000,$8300,$7E00,$0200
	.dc.w	$000D,$001C,$0003,$0000,$F800,$1B00,$E700,$0200
	.dc.w	$000F,$001F,$0000,$0000,$DE00,$C000,$3E00,$0000
	.dc.w	$0002,$000E,$000D,$0000,$1C00,$1000,$EE00,$0000
	.dc.w	$0001,$000F,$0006,$0000,$D200,$0200,$FC00,$0000
	.dc.w	$0001,$000F,$000E,$0000,$6400,$E600,$9800,$0000
	.dc.w	$0003,$000F,$0008,$0000,$DC00,$DE00,$2200,$0000
	.dc.w	$0000,$0003,$0002,$0000,$F000,$FE00,$0200,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6000,$E400,$0400,$0000
rock11:		* Asteroid (Perspective:1 - Animation:1)
	.dc.w	13,15
	.dc.w	30,2
	.dc.w	$0000,$0003,$0002,$0000,$8000,$8000,$4000,$0000
	.dc.w	$0001,$000E,$0001,$0000,$4000,$7000,$9000,$0000
	.dc.w	$000B,$0038,$0027,$0000,$A000,$7800,$C800,$4000
	.dc.w	$0086,$0380,$027F,$0000,$2800,$0E00,$F200,$0000
	.dc.w	$02AD,$0E00,$09FF,$0000,$1880,$00E0,$FF20,$0000
	.dc.w	$0400,$7D52,$43FF,$0152,$AF00,$00C0,$FFC0,$00C0
	.dc.w	$0EA9,$7E00,$11FF,$0000,$1700,$1000,$EF40,$0000
	.dc.w	$0740,$7C12,$53FF,$0012,$A300,$2100,$DE80,$0000
	.dc.w	$04A9,$FC00,$B3FF,$0000,$5C00,$5C00,$A300,$0000
	.dc.w	$0406,$7C50,$73FF,$0050,$0D00,$AF80,$F280,$8000
	.dc.w	$04A9,$FC06,$B3FF,$0006,$5000,$0980,$F780,$0000
	.dc.w	$0926,$F918,$F6FF,$0018,$8600,$2780,$F800,$2000
	.dc.w	$06DC,$FE01,$31FF,$0001,$4680,$1180,$FF00,$1000
	.dc.w	$82F6,$FEC0,$393F,$0000,$AE00,$0200,$FD80,$0000
	.dc.w	$0A31,$FA10,$65EF,$0000,$0000,$4440,$FFC0,$4400
	.dc.w	$03FC,$FFFC,$7C03,$0000,$A380,$23C0,$DC40,$0000
	.dc.w	$00D9,$FFF1,$7F0E,$0000,$1800,$1980,$E700,$0000
	.dc.w	$0386,$FFEA,$7C7D,$0000,$EE00,$23C0,$DDC0,$0000
	.dc.w	$0013,$FF28,$7EF7,$0000,$1880,$6440,$FF80,$6400
	.dc.w	$0018,$FFF0,$BFCF,$0000,$7D40,$02C0,$FF80,$0280
	.dc.w	$0291,$FEBF,$BD6C,$0000,$6180,$1E00,$FFC0,$1E00
	.dc.w	$03FF,$FFF3,$580C,$0000,$3700,$0100,$FEC0,$0000
	.dc.w	$0247,$FFC7,$4D38,$0000,$4F00,$4740,$B880,$0000
	.dc.w	$0124,$7F3D,$0CD2,$0000,$D980,$FF80,$0200,$0000
	.dc.w	$060A,$BFFB,$01E5,$0000,$0000,$FF00,$7A00,$0000
	.dc.w	$000C,$AFFF,$0F93,$0000,$0000,$FE00,$FC00,$0000
	.dc.w	$0000,$0FFF,$03E9,$0000,$0000,$C400,$C000,$0000
	.dc.w	$0000,$03EF,$01AF,$0000,$0000,$C800,$C000,$0000
	.dc.w	$0000,$00E7,$00C5,$0000,$0000,$C000,$8000,$0000
	.dc.w	$0000,$0031,$0001,$0000,$0000,$0000,$0000,$0000
rock12:		* Asteroid (Perspective:1 - Animation:2)
	.dc.w	15,15
	.dc.w	30,2
	.dc.w	$0003,$000F,$0008,$0000,$0000,$C000,$4000,$0000
	.dc.w	$000D,$0039,$0026,$0000,$0000,$C000,$4000,$0000
	.dc.w	$0412,$3F7E,$314D,$000C,$4000,$7000,$9000,$0000
	.dc.w	$107E,$71C2,$4FBD,$0000,$0A00,$3B00,$E400,$0000
	.dc.w	$176B,$F78F,$C874,$0000,$9E00,$C180,$7F00,$0100
	.dc.w	$6858,$E870,$17AF,$0020,$BE80,$A080,$5F00,$0000
	.dc.w	$C7BE,$C303,$3CFD,$0000,$6700,$E740,$98C0,$0000
	.dc.w	$5D19,$D401,$2BFE,$0000,$DC80,$DC50,$2390,$0000
	.dc.w	$2053,$E044,$5FBF,$0000,$6440,$F460,$9BA0,$0000
	.dc.w	$5F7E,$DE01,$21FF,$0000,$0D00,$87A0,$FA40,$0000
	.dc.w	$7305,$F029,$8FFE,$0028,$7760,$2F20,$D8C0,$0000
	.dc.w	$48EA,$E8C7,$373D,$0004,$9880,$5C50,$E7F0,$4040
	.dc.w	$1C0E,$FC00,$E3FF,$0000,$6F40,$1F20,$F0D0,$0000
	.dc.w	$15E1,$F5ED,$CA1E,$000C,$5160,$1F38,$EEC8,$0000
	.dc.w	$1CE1,$FDAB,$E35E,$0008,$8340,$CB70,$7C90,$0000
	.dc.w	$311F,$FB84,$86FB,$0000,$3F60,$BF10,$C0F0,$8000
	.dc.w	$2CE6,$FCE1,$931F,$0001,$8580,$6388,$FE78,$0000
	.dc.w	$138E,$7381,$6C7F,$0001,$7270,$904C,$EFB4,$8000
	.dc.w	$0F59,$FFC6,$60BF,$0006,$B128,$451C,$FEF0,$4410
	.dc.w	$20FF,$FFF0,$5E0F,$0000,$6A9C,$8006,$FFFA,$8000
	.dc.w	$4467,$F7E0,$291F,$0000,$D170,$041A,$FFEC,$0408
	.dc.w	$0143,$FF81,$FC7E,$0000,$422E,$4883,$BFFD,$0880
	.dc.w	$03C5,$B7C5,$3C3A,$0000,$F510,$D045,$2FFE,$0044
	.dc.w	$070C,$5F04,$10FB,$0000,$E0A1,$1A0B,$FFFE,$1A0A
	.dc.w	$056F,$1FDF,$10B0,$0000,$1516,$0041,$FFFE,$0040
	.dc.w	$0077,$4FFF,$4308,$0000,$E280,$E023,$1FFF,$0020
	.dc.w	$0041,$05F7,$0514,$0000,$7C50,$7C06,$83F8,$0000
	.dc.w	$0000,$0042,$0002,$0000,$0B20,$3B2C,$24D0,$0000
	.dc.w	$0000,$0004,$0004,$0000,$0080,$07F0,$0630,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0040,$0040,$0000
rock13:		* Asteroid (Perspective:1 - Animation:3)
	.dc.w	15,14
	.dc.w	30,2
	.dc.w	$0000,$0000,$0000,$0000,$0000,$E000,$2000,$0000
	.dc.w	$0000,$0003,$0000,$0000,$3A00,$FF80,$4480,$0000
	.dc.w	$0000,$0007,$0003,$0000,$0000,$F880,$FF00,$0000
	.dc.w	$0000,$003F,$001B,$0000,$3680,$FAC0,$CD40,$0000
	.dc.w	$0000,$007F,$000F,$0000,$1900,$F860,$E7A0,$0000
	.dc.w	$0000,$03FF,$01FF,$0000,$1540,$F460,$CBA0,$0000
	.dc.w	$0010,$03FF,$01EF,$0000,$2FC0,$FE20,$81C0,$0000
	.dc.w	$0400,$07FF,$03FE,$0000,$07A0,$EC20,$BBC0,$0000
	.dc.w	$0020,$07FF,$03DD,$0000,$1760,$F060,$4F80,$0000
	.dc.w	$0010,$0FFF,$03EA,$0000,$2CC0,$F8C0,$8700,$0000
	.dc.w	$0040,$1FFF,$07BC,$0000,$1A40,$F1E0,$4F80,$0180
	.dc.w	$0022,$1FFF,$0FD8,$0000,$AF40,$F070,$0F90,$0000
	.dc.w	$0005,$1FFF,$1FF0,$0000,$4000,$E3F0,$1FF0,$0380
	.dc.w	$0016,$3FFB,$1FCC,$0008,$A200,$74F0,$9FF0,$0400
	.dc.w	$0068,$3FC0,$3F3F,$0000,$2D60,$5098,$FFE8,$0000
	.dc.w	$008F,$7F8D,$3E72,$0000,$85D0,$8038,$7FE0,$0020
	.dc.w	$005F,$7FDF,$3F20,$0000,$EAA8,$E20C,$1DF4,$0000
	.dc.w	$048C,$7FFD,$7B33,$0000,$1750,$D404,$EBF8,$0000
	.dc.w	$0077,$FFF8,$7F8F,$0000,$BEA0,$3802,$C7FE,$0000
	.dc.w	$0408,$FFF1,$BBFF,$0001,$2C00,$D752,$FBFC,$8350
	.dc.w	$0036,$3FE4,$1F9B,$0000,$F60A,$3E82,$C9FC,$0880
	.dc.w	$0231,$1FF4,$0DCB,$0000,$F316,$CE41,$3DFF,$0C40
	.dc.w	$004C,$0FDF,$0323,$0000,$39AE,$E081,$9F7E,$0000
	.dc.w	$0000,$07EC,$0324,$0000,$3691,$F651,$89EE,$0040
	.dc.w	$0000,$0018,$0008,$0000,$22DE,$FE3F,$CDE1,$0020
	.dc.w	$0000,$0000,$0000,$0000,$0100,$0F0B,$0EF6,$0000
	.dc.w	$0000,$0000,$0000,$0000,$023C,$0E3E,$01C0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$01C0,$07FC,$0238,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$03F8,$01F0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$00F0,$0000,$0000
rock14:		* Asteroid (Perspective:1 - Animation:4)
	.dc.w	14,14
	.dc.w	28,2
	.dc.w	$0000,$0001,$0000,$0000,$2000,$F800,$8800,$0000
	.dc.w	$0000,$0003,$0001,$0000,$4000,$D400,$AC00,$0000
	.dc.w	$0000,$0003,$0003,$0000,$5400,$DF00,$A100,$0000
	.dc.w	$0000,$0007,$0006,$0000,$BE00,$B780,$4880,$0000
	.dc.w	$0003,$000F,$000C,$0000,$5A00,$4580,$BE00,$0400
	.dc.w	$0008,$001F,$0017,$0000,$3E80,$8380,$FD00,$0100
	.dc.w	$0000,$007A,$003F,$0000,$4000,$0000,$FF80,$0000
	.dc.w	$0017,$00F0,$00EF,$0000,$DF00,$7F80,$8000,$0000
	.dc.w	$0016,$03F3,$01EC,$0000,$B100,$71C0,$CE40,$0000
	.dc.w	$001F,$03F0,$03EF,$0000,$4400,$7F80,$B300,$0000
	.dc.w	$001D,$0FC4,$07FB,$0000,$3100,$F1C0,$4E40,$0000
	.dc.w	$0044,$0FC4,$0FBB,$0000,$5E00,$1380,$EC80,$0000
	.dc.w	$0063,$1FE8,$0F1F,$0000,$B100,$0DC0,$FE40,$0800
	.dc.w	$007A,$3FFC,$1F87,$0000,$ED00,$03C0,$FE40,$0200
	.dc.w	$00AB,$7F38,$7FD7,$0000,$1980,$C480,$FF00,$C400
	.dc.w	$027D,$FEFC,$B983,$0000,$6500,$1080,$FF00,$1000
	.dc.w	$06E5,$FE00,$79FF,$0000,$9000,$00C0,$FFC0,$0000
	.dc.w	$02D5,$7E18,$79EF,$0000,$0B00,$9740,$F880,$9000
	.dc.w	$0F92,$7870,$77EF,$0040,$DFC0,$C3C0,$3C00,$0000
	.dc.w	$058C,$7199,$3E67,$0000,$80C0,$83C0,$7F00,$0000
	.dc.w	$0340,$73E3,$2C3F,$0000,$A680,$AEE0,$5920,$0000
	.dc.w	$0C3B,$7FFF,$0084,$0000,$C980,$F940,$1680,$0000
	.dc.w	$1000,$3F79,$2341,$0000,$0780,$93E0,$FC60,$0000
	.dc.w	$0000,$1800,$1800,$0000,$2000,$77C0,$5E00,$0400
	.dc.w	$0000,$0000,$0000,$0000,$2C00,$FC40,$D3C0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1200,$7380,$4C80,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$3F00,$3C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$3800,$0800,$0000
rock15:		* Asteroid (Perspective:1 - Animation:5)
	.dc.w	15,13
	.dc.w	27,2
	.dc.w	$0000,$0000,$0000,$0000,$0C00,$3F00,$2100,$0000
	.dc.w	$0000,$0001,$0000,$0000,$3200,$F380,$8C80,$0000
	.dc.w	$0000,$0003,$0000,$0000,$1D00,$F1E0,$CE60,$0000
	.dc.w	$0000,$0007,$0001,$0000,$7BC0,$FB30,$84D0,$0000
	.dc.w	$0001,$001F,$000E,$0000,$06A0,$C6F8,$F948,$0040
	.dc.w	$0008,$007F,$0037,$0000,$7F50,$FF7C,$00A4,$0020
	.dc.w	$00E5,$03FF,$001A,$0000,$8328,$C32C,$7CD0,$0000
	.dc.w	$0443,$0DFE,$03B9,$0000,$ACF4,$3EF4,$D308,$0000
	.dc.w	$00BE,$1FBC,$0E43,$0000,$41C0,$0304,$FEF8,$0000
	.dc.w	$00B6,$3FFE,$1E49,$0000,$D7E0,$2024,$FFDC,$2000
	.dc.w	$0043,$3FFF,$1FB8,$0000,$8FB0,$F040,$7FF8,$7040
	.dc.w	$008A,$3FFE,$1F71,$0000,$7EE8,$0908,$F7F0,$0100
	.dc.w	$0013,$3FFF,$1FE8,$0000,$FD90,$A668,$5BF0,$0260
	.dc.w	$0400,$3FFF,$1BFE,$0000,$BE70,$BF88,$41F8,$0180
	.dc.w	$0024,$3FFC,$1FD3,$0000,$4780,$0470,$FBF0,$0070
	.dc.w	$0008,$3FF9,$1FE7,$0000,$F2A0,$D140,$2FF0,$0140
	.dc.w	$0813,$3FF3,$37CC,$0000,$0FD0,$1D10,$F2E0,$0000
	.dc.w	$04AE,$7FAE,$3A51,$0000,$FDE0,$F430,$0BC0,$0000
	.dc.w	$103E,$7706,$2FF9,$0000,$0EC0,$0E70,$F190,$0000
	.dc.w	$1163,$7F1B,$6EFC,$0018,$F080,$38E0,$C720,$0000
	.dc.w	$02FB,$FF87,$7D7C,$0004,$0F00,$0CC0,$F340,$0000
	.dc.w	$01FC,$7FC3,$7C3F,$0000,$7E00,$1380,$EC80,$0000
	.dc.w	$0028,$FEEF,$6C97,$0000,$7C00,$C700,$B900,$0000
	.dc.w	$0000,$4E5F,$064F,$0000,$F800,$FE00,$0200,$0000
	.dc.w	$0000,$001F,$0017,$0000,$E000,$F800,$0800,$0000
	.dc.w	$0000,$0011,$0000,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$8000,$0000,$0000
rock16:		* Asteroid (Perspective:1 - Animation:6)
	.dc.w	17,13
	.dc.w	28,3
	.dc.w	$0000,$0003,$0000,$0000,$0300,$0FC0,$0840,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0001,$0000
	.dc.w	$0540,$1D70,$1290,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0018,$0027,$0018,$0000,$0430,$FC5C,$03E4,$0040
	.dc.w	$0000,$0000,$0000,$0000,$00A0,$00DF,$003F,$0018
	.dc.w	$6BA8,$EB9E,$1472,$0010,$0000,$0000,$0000,$0000
	.dc.w	$031F,$0306,$00F9,$0000,$D0FE,$8523,$7BDC,$0000
	.dc.w	$0000,$8000,$8000,$0000,$01E0,$1FF8,$181F,$0000
	.dc.w	$2A71,$8070,$FF8F,$8000,$8000,$4000,$C000,$0000
	.dc.w	$00C3,$3DC6,$3B3D,$0000,$D4E8,$01E0,$FF1F,$0100
	.dc.w	$8000,$4000,$8000,$0000,$063E,$7FF8,$7807,$0000
	.dc.w	$08F6,$2246,$FFB9,$2200,$4000,$C000,$8000,$0000
	.dc.w	$001F,$7FF1,$7B8E,$0000,$D5D3,$0000,$FFFF,$0000
	.dc.w	$8000,$4000,$8000,$0000,$0019,$FFF8,$7FE7,$0000
	.dc.w	$E3AB,$0808,$FFF7,$0800,$0000,$C000,$C000,$8000
	.dc.w	$0023,$FFE9,$7F9E,$0000,$7951,$0600,$FFFF,$0600
	.dc.w	$8000,$4000,$8000,$0000,$0155,$FF11,$7CEE,$0000
	.dc.w	$01AB,$1600,$FFFF,$1600,$4000,$C000,$8000,$8000
	.dc.w	$0128,$7F02,$7CFD,$0000,$0815,$0341,$FFFE,$0340
	.dc.w	$C000,$0000,$C000,$0000,$02C5,$7E10,$39FF,$0010
	.dc.w	$552A,$4080,$BFFF,$0080,$0000,$0000,$C000,$0000
	.dc.w	$0000,$3E28,$15FF,$0028,$8B93,$8046,$7FFD,$0044
	.dc.w	$8000,$C000,$4000,$0000,$0195,$1F85,$067A,$0000
	.dc.w	$413C,$14C2,$FFFF,$14C2,$4000,$2000,$E000,$0000
	.dc.w	$00A8,$0F82,$037F,$0000,$2287,$09B8,$FF7F,$0938
	.dc.w	$8000,$4000,$E000,$0000,$00B5,$038D,$0072,$0000
	.dc.w	$103F,$07C0,$FFFF,$07C0,$C000,$4000,$8000,$0000
	.dc.w	$00DA,$06C4,$023F,$0000,$80E5,$8F09,$7FFE,$0F08
	.dc.w	$0000,$C000,$4000,$0000,$0574,$05F0,$008F,$0000
	.dc.w	$00CC,$1200,$FFFF,$1200,$8000,$8000,$0000,$0000
	.dc.w	$000E,$0078,$0027,$0000,$A138,$8467,$7F9C,$0404
	.dc.w	$0000,$8000,$0000,$0000,$0013,$0070,$004F,$0000
	.dc.w	$0A04,$0087,$FF79,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$00B8,$0027,$0000,$052C,$302E,$FFD0,$3000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0007,$0004,$0000
	.dc.w	$6280,$4AB8,$BD48,$0800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$3000,$E570,$9FA0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$4000,$CAC0,$3580,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0000,$0000,$0000,$FC00,$2000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0000,$0000
	.dc.w	$0000,$E000,$6000,$0000,$0000,$0000,$0000,$0000
rock17:		* Asteroid (Perspective:1 - Animation:7)
	.dc.w	17,13
	.dc.w	29,3
	.dc.w	$0000,$0006,$0005,$0000,$1010,$3173,$014D,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0087,$02FC,$0333,$0000
	.dc.w	$4096,$7F97,$BE68,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0098,$1F98,$1967,$0000,$0029,$C509,$FFF6,$0000
	.dc.w	$0000,$C000,$4000,$0000,$027F,$7EC0,$79BF,$0000
	.dc.w	$36BC,$38BC,$CF43,$0000,$8000,$E000,$2000,$0000
	.dc.w	$0041,$7E01,$3BFE,$0000,$C1DF,$CBC0,$3E3F,$0A00
	.dc.w	$8000,$E000,$2000,$0000,$4A22,$78A2,$37DD,$0080
	.dc.w	$450F,$D100,$BEFF,$1000,$8000,$E000,$2000,$0000
	.dc.w	$0051,$7114,$2FEF,$0100,$8A47,$2040,$FFBF,$2000
	.dc.w	$8000,$E000,$2000,$0000,$1620,$70A8,$6FD7,$0080
	.dc.w	$41C1,$9001,$FFFE,$9000,$0000,$C000,$4000,$0000
	.dc.w	$1C46,$FC16,$63F9,$0000,$AA22,$0803,$F7FC,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0683,$FE8F,$E170,$0000
	.dc.w	$513D,$003D,$FFC2,$0000,$0000,$C000,$4000,$0000
	.dc.w	$0244,$7F5C,$70BB,$0000,$09C2,$4800,$F7FF,$4000
	.dc.w	$8000,$E000,$2000,$0000,$004B,$7F7F,$0294,$0000
	.dc.w	$6C30,$3C70,$D3CF,$0040,$6000,$0000,$E000,$0000
	.dc.w	$0047,$3E7F,$0038,$0000,$C3F9,$FB01,$14FE,$0000
	.dc.w	$C000,$2000,$E000,$2000,$0041,$0CFF,$083E,$0000
	.dc.w	$1A82,$7862,$E7FD,$0060,$2000,$6000,$C000,$4000
	.dc.w	$0001,$01FF,$00FC,$0000,$1869,$F009,$CFF6,$0000
	.dc.w	$4000,$6000,$8000,$0000,$0000,$02FF,$027D,$0000
	.dc.w	$23F4,$E200,$9DFF,$0000,$0000,$6000,$A000,$0000
	.dc.w	$0008,$017F,$0117,$0000,$0420,$C011,$BFFF,$0010
	.dc.w	$8000,$C000,$4000,$0000,$0004,$003F,$0019,$0000
	.dc.w	$0206,$8A10,$7DFF,$0810,$0000,$8000,$0000,$0000
	.dc.w	$0004,$005F,$0059,$0000,$54F9,$C001,$BFFE,$0000
	.dc.w	$0000,$8000,$8000,$0000,$000C,$001F,$0010,$0000
	.dc.w	$0A0A,$800B,$FFF4,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$001F,$0008,$0000,$05AC,$008F,$FF71,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$001F,$0007,$0000
	.dc.w	$284C,$200E,$DFF2,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$000F,$0002,$0000,$E590,$E11C,$1EE0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0003,$0000
	.dc.w	$1200,$F038,$EFF0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$000B,$0008,$0000,$1900,$F960,$C6C0,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$0C00,$FCC0,$D300,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0002,$0002,$0000,$0400,$FD80,$6300,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0400,$3E00,$1A00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0A00,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000
rock20:		* Asteroid (Perspective:2 - Animation:0)
	.dc.w	10,11
	.dc.w	23,2
	.dc.w	$0000,$0020,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0074,$0020,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0012,$007B,$004C,$0000,$4000,$7000,$9000,$0000
	.dc.w	$0004,$11FE,$01AB,$0020,$7000,$8000,$F000,$8000
	.dc.w	$00B3,$7FFF,$3E4C,$0040,$F000,$0800,$F800,$0800
	.dc.w	$0084,$7FFE,$7F7B,$0000,$F800,$0800,$F000,$0000
	.dc.w	$0013,$FFFF,$7FE8,$0000,$A000,$4800,$F000,$4000
	.dc.w	$2011,$FFFF,$DF6C,$0000,$7000,$1800,$E800,$0000
	.dc.w	$0005,$FFFD,$FE32,$0000,$E000,$1000,$E000,$0000
	.dc.w	$003A,$FFE2,$FF9D,$0000,$C000,$1000,$F000,$0000
	.dc.w	$007A,$FFEA,$7F15,$0000,$A000,$6000,$C000,$4000
	.dc.w	$01FF,$7FE3,$3C1C,$0000,$C000,$A000,$4000,$0000
	.dc.w	$033B,$1F21,$04DE,$0000,$C000,$6000,$A000,$0000
	.dc.w	$0172,$07F2,$040D,$0000,$8000,$4000,$8000,$0000
	.dc.w	$0074,$0183,$017F,$0001,$8000,$4000,$C000,$0000
	.dc.w	$0007,$0170,$01BF,$0020,$0000,$C000,$C000,$8000
	.dc.w	$0038,$008C,$00F7,$0000,$0000,$0000,$8000,$0000
	.dc.w	$0026,$00E0,$009F,$0000,$8000,$8000,$0000,$0000
	.dc.w	$006B,$00E9,$0096,$0000,$0000,$8000,$0000,$0000
	.dc.w	$000D,$00EC,$0073,$0000,$0000,$8000,$8000,$0000
	.dc.w	$002C,$00FA,$0095,$0000,$8000,$0000,$8000,$0000
	.dc.w	$001C,$003F,$0001,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0018,$0000,$0000,$0000,$0000,$0000,$0000
rock21:		* Asteroid (Perspective:2 - Animation:1)
	.dc.w	10,11
	.dc.w	22,2
	.dc.w	$0028,$004C,$0030,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00FC,$0387,$0679,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0156,$18A3,$17FC,$00A0,$0000,$E000,$C000,$0000
	.dc.w	$16F2,$7105,$0FFF,$0105,$4000,$7000,$9000,$0000
	.dc.w	$19C1,$7E30,$27FF,$0630,$8000,$6000,$C000,$0000
	.dc.w	$1C3C,$F7C4,$2BFB,$03C0,$8000,$2000,$A000,$0000
	.dc.w	$06E6,$611A,$3FFD,$0110,$0000,$C000,$8000,$0000
	.dc.w	$1139,$F2C7,$EFFC,$02C4,$8000,$C000,$0000,$0000
	.dc.w	$0F72,$FA8E,$65FD,$008C,$8000,$4000,$8000,$0000
	.dc.w	$0BD6,$F028,$7FFF,$0028,$8000,$C000,$4000,$0000
	.dc.w	$2F87,$FE38,$51FF,$0038,$0000,$E000,$2000,$0000
	.dc.w	$1959,$F940,$66BF,$0000,$C000,$E000,$0000,$0000
	.dc.w	$01CD,$FFD4,$FC3B,$0010,$0000,$2000,$E000,$0000
	.dc.w	$0627,$FF28,$79DF,$0008,$C000,$3000,$D000,$0000
	.dc.w	$02E3,$FE8C,$397F,$000C,$C000,$2000,$C000,$0000
	.dc.w	$075D,$FF42,$78BF,$0002,$4000,$7000,$9000,$0000
	.dc.w	$005A,$FA58,$DDA7,$0000,$C000,$E000,$2000,$0000
	.dc.w	$0198,$77DA,$5E65,$0000,$0000,$C000,$4000,$0000
	.dc.w	$0608,$7FBF,$58E7,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0002,$1FDB,$2FF4,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0FFE,$06F8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$01D0,$0380,$0000,$0000,$0000,$0000,$0000
rock22:		* Asteroid (Perspective:2 - Animation:2)
	.dc.w	11,11
	.dc.w	23,2
	.dc.w	$0048,$05CE,$0132,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0518,$1C5B,$13E6,$0040,$4000,$7000,$9000,$0000
	.dc.w	$1290,$3210,$2DEF,$0000,$E000,$3800,$C800,$0000
	.dc.w	$1CEF,$786E,$4791,$0000,$C000,$0000,$E000,$0000
	.dc.w	$17DB,$761A,$49E5,$0000,$8000,$B000,$5000,$0000
	.dc.w	$14B3,$344B,$2BFC,$0040,$0000,$5000,$E000,$0000
	.dc.w	$3A5C,$780D,$07F3,$0000,$9000,$B800,$4800,$0000
	.dc.w	$26A2,$640E,$5BFD,$0000,$8000,$8C00,$7400,$0000
	.dc.w	$37AC,$F710,$48FF,$0000,$3800,$0C00,$F000,$0000
	.dc.w	$2B29,$7B09,$54F6,$0000,$5000,$C000,$BC00,$0000
	.dc.w	$1929,$7F19,$66F6,$0000,$5800,$4400,$BC00,$0000
	.dc.w	$26DE,$7F03,$19FD,$0000,$D800,$C400,$3C00,$0000
	.dc.w	$2FAE,$3F90,$107F,$0010,$8000,$0C00,$F800,$0800
	.dc.w	$0AEE,$7B91,$357F,$0011,$2800,$AE00,$D200,$8000
	.dc.w	$17D3,$77EC,$483F,$002C,$F400,$0200,$FC00,$0000
	.dc.w	$08A5,$7E10,$77FF,$0010,$6A00,$9600,$FC00,$9400
	.dc.w	$32AA,$7E22,$4DDD,$0000,$BC00,$4000,$FE00,$4000
	.dc.w	$1FA7,$3F2C,$00DB,$0000,$FA00,$0400,$FE00,$0400
	.dc.w	$0101,$0760,$04FF,$0000,$D000,$2800,$FE00,$2800
	.dc.w	$01FE,$1FFE,$1201,$0000,$4800,$5200,$BE00,$1000
	.dc.w	$0023,$04B3,$0010,$0000,$4000,$C400,$3800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$3000,$F800,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$0000,$0000
rock23:		* Asteroid (Perspective:2 - Animation:3)
	.dc.w	12,11
	.dc.w	23,2
	.dc.w	$0000,$000C,$000C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$003F,$0038,$0000,$0000,$C000,$4000,$0000
	.dc.w	$0005,$017C,$0033,$0000,$0000,$6000,$A000,$0000
	.dc.w	$0000,$07FE,$00FF,$0000,$A000,$8000,$6000,$0000
	.dc.w	$0085,$0FFD,$0772,$0000,$A000,$9000,$7000,$0000
	.dc.w	$0002,$0FFF,$07FD,$0000,$6000,$1000,$E000,$0000
	.dc.w	$0102,$1FFE,$0EF9,$0000,$B000,$3000,$C000,$0000
	.dc.w	$0015,$1FFC,$1FEB,$0000,$E000,$6000,$9000,$0000
	.dc.w	$0006,$3FFD,$1FF3,$0001,$4000,$0800,$F800,$0000
	.dc.w	$0024,$3FFC,$3FDB,$0000,$1000,$7800,$E000,$4000
	.dc.w	$06BE,$3D3F,$3BC1,$0001,$9800,$7800,$E000,$0000
	.dc.w	$03DD,$7E88,$3977,$0000,$A000,$5400,$FC00,$0000
	.dc.w	$02B7,$7EB4,$3D4B,$0000,$7000,$4C00,$B800,$0800
	.dc.w	$0099,$7FD9,$7F26,$0000,$AC00,$8400,$7800,$0000
	.dc.w	$0173,$FF0A,$7EFD,$0008,$D800,$0000,$FC00,$0000
	.dc.w	$00CD,$FF22,$FFFF,$0020,$6400,$0A00,$FE00,$0800
	.dc.w	$097D,$3F00,$36FF,$0000,$FC00,$0600,$F800,$0000
	.dc.w	$03F2,$1FB0,$1C4F,$0000,$5E00,$6200,$BC00,$2000
	.dc.w	$0103,$0F1F,$004C,$0000,$C800,$AA00,$7600,$2000
	.dc.w	$0080,$0287,$0001,$0000,$FC00,$8E00,$7000,$0000
	.dc.w	$0000,$0003,$0000,$0000,$8800,$8C00,$7400,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1000,$F800,$E800,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$F000,$6000,$0000
rock24:		* Asteroid (Perspective:2 - Animation:4)
	.dc.w	11,10
	.dc.w	22,2
	.dc.w	$0002,$000C,$0002,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000B,$0038,$0017,$0000,$8000,$0000,$8000,$0000
	.dc.w	$0007,$0076,$0019,$0000,$4000,$0000,$C000,$0000
	.dc.w	$0017,$007C,$002B,$0000,$0000,$0000,$C000,$0000
	.dc.w	$002E,$00F8,$00D7,$0000,$0000,$4000,$C000,$4000
	.dc.w	$0013,$03E3,$00DC,$0000,$8000,$8000,$4000,$0000
	.dc.w	$003A,$0796,$03ED,$0000,$8000,$B000,$7000,$0000
	.dc.w	$009C,$07A6,$025B,$0000,$0000,$6000,$C000,$0000
	.dc.w	$01DB,$1F0F,$0EF4,$0000,$2000,$A000,$C000,$0000
	.dc.w	$003E,$1E28,$1FD7,$0000,$C000,$0000,$E000,$0000
	.dc.w	$01A5,$3F88,$1E7F,$0008,$6000,$2000,$C000,$0000
	.dc.w	$044F,$FDC0,$7BBF,$0000,$4000,$A000,$C000,$8000
	.dc.w	$0CD8,$F8C7,$373F,$0007,$4000,$2000,$E000,$0000
	.dc.w	$0DB9,$7AA2,$775F,$0202,$0000,$2000,$C000,$0000
	.dc.w	$1BA6,$7480,$6F7F,$0400,$6000,$F000,$9000,$0000
	.dc.w	$05E5,$6495,$3B7A,$0000,$C000,$D000,$2000,$0000
	.dc.w	$0088,$64BB,$3B55,$0000,$3000,$B000,$C000,$0000
	.dc.w	$000C,$2CFF,$1013,$0000,$6000,$8000,$F000,$0000
	.dc.w	$0001,$0007,$0006,$0000,$8000,$C000,$2000,$0000
	.dc.w	$0000,$000F,$0001,$0000,$0000,$A000,$4000,$0000
	.dc.w	$0005,$000F,$0002,$0000,$8000,$C000,$4000,$0000
	.dc.w	$0000,$0007,$0000,$0000,$0000,$0000,$0000,$0000
rock25:		* Asteroid (Perspective:2 - Animation:5)
	.dc.w	10,11
	.dc.w	22,2
	.dc.w	$0000,$0001,$0003,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0005,$000C,$0003,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0001,$003C,$000F,$0000,$5000,$4000,$9000,$0000
	.dc.w	$000D,$007D,$0032,$0000,$6000,$1000,$F000,$0000
	.dc.w	$0009,$01F9,$00E6,$0000,$E000,$F800,$1800,$1800
	.dc.w	$0002,$07FA,$03FD,$0000,$5C00,$5000,$AC00,$0000
	.dc.w	$089A,$1FD6,$176D,$0000,$4C00,$C400,$3800,$0000
	.dc.w	$057E,$3F62,$1A9D,$0000,$F800,$2400,$D800,$0000
	.dc.w	$0063,$3FEC,$1F9F,$000C,$5000,$AC00,$FC00,$A000
	.dc.w	$013D,$3FF0,$1ECF,$0000,$B000,$4800,$F000,$4000
	.dc.w	$0299,$3FD8,$3D67,$0000,$B800,$4800,$F000,$4000
	.dc.w	$001B,$3FD3,$3FEC,$0000,$4000,$B000,$F800,$B000
	.dc.w	$00AD,$3FCF,$3F72,$0000,$D800,$2800,$F000,$2000
	.dc.w	$1873,$3FF3,$278C,$0000,$3000,$4800,$F000,$4000
	.dc.w	$05DE,$6E5E,$3BA1,$0000,$B000,$8800,$7800,$0000
	.dc.w	$0E6C,$7FA4,$71DB,$0180,$C000,$0000,$F000,$0000
	.dc.w	$09DF,$FD10,$72EF,$0000,$4000,$C000,$8000,$8000
	.dc.w	$069D,$FEB4,$696B,$0000,$8000,$0000,$C000,$0000
	.dc.w	$001D,$58FD,$0062,$0000,$8000,$8000,$0000,$0000
	.dc.w	$0008,$00FA,$00A4,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0010,$0010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0010,$0000,$0000,$0000,$0000,$0000,$0000
rock26:		* Asteroid (Perspective:2 - Animation:6)
	.dc.w	12,8
	.dc.w	21,2
	.dc.w	$0000,$0033,$0011,$0000,$3000,$9000,$6000,$0000
	.dc.w	$00C9,$003F,$01E2,$0000,$2800,$0E00,$F200,$0000
	.dc.w	$05D7,$0503,$02FC,$0000,$AA00,$8300,$7C00,$0000
	.dc.w	$0229,$3EE0,$35DF,$0000,$F200,$7100,$8E00,$0000
	.dc.w	$01AC,$7FE0,$385F,$0000,$DF00,$3700,$C800,$0000
	.dc.w	$03B6,$7F80,$7C7F,$0000,$2C00,$0000,$FF00,$0000
	.dc.w	$018F,$FF80,$7E7F,$0000,$DA00,$2900,$F700,$2100
	.dc.w	$0403,$FF00,$79FF,$0000,$F300,$0080,$FF80,$0000
	.dc.w	$06D9,$FC3A,$7BE7,$0002,$5400,$A180,$FF00,$A100
	.dc.w	$0F72,$7C09,$73FF,$0001,$E280,$16C0,$FD00,$1400
	.dc.w	$05F9,$3C28,$1BD7,$0000,$BC80,$4140,$FFC0,$4000
	.dc.w	$02B9,$3E78,$0987,$0000,$E440,$1040,$FF80,$1000
	.dc.w	$02D0,$0E31,$01EF,$0001,$BA00,$6080,$DF00,$4000
	.dc.w	$03DB,$0B08,$04F7,$0000,$6600,$8880,$FF80,$8800
	.dc.w	$00FE,$03C9,$0037,$0001,$BC00,$5300,$EE00,$4000
	.dc.w	$00A5,$0192,$017F,$0012,$4000,$A600,$DC00,$8400
	.dc.w	$00CA,$02CC,$0037,$0004,$5C00,$5E00,$A000,$0000
	.dc.w	$0034,$0030,$000F,$0000,$A000,$F800,$1800,$0000
	.dc.w	$0008,$0019,$0006,$0000,$0000,$F000,$4000,$0000
	.dc.w	$0004,$000F,$0002,$0000,$0000,$C000,$0000,$0000
	.dc.w	$0000,$001C,$0004,$0000,$0000,$0000,$0000,$0000
rock27:		* Asteroid (Perspective:2 - Animation:7)
	.dc.w	11,9
	.dc.w	22,2
	.dc.w	$0009,$002D,$0000,$0000,$A000,$B800,$4800,$0000
	.dc.w	$0221,$0E2F,$09D2,$0000,$9000,$D100,$2D00,$0000
	.dc.w	$1C93,$7C9E,$436D,$0000,$1000,$1100,$EE00,$0000
	.dc.w	$1C15,$F812,$47EF,$0002,$9F00,$8100,$7E00,$0000
	.dc.w	$1366,$C551,$7EBF,$0401,$CC00,$C200,$3F00,$0200
	.dc.w	$4C3D,$C180,$3FFF,$0000,$8900,$0300,$FE00,$0200
	.dc.w	$78D6,$E6CA,$9F3D,$0608,$B800,$3900,$C600,$0000
	.dc.w	$3722,$F5EE,$CA9D,$000C,$F200,$3300,$CD00,$0000
	.dc.w	$2C4E,$FDC2,$C2BD,$0000,$8C00,$4900,$F600,$4000
	.dc.w	$0425,$FFE7,$0398,$0000,$7900,$0900,$F600,$0000
	.dc.w	$0072,$37EE,$039D,$0000,$4400,$2400,$FB00,$2000
	.dc.w	$00C2,$07DE,$0739,$0000,$5F00,$3500,$EA00,$2000
	.dc.w	$0005,$07FC,$03D3,$0000,$B000,$4100,$FE00,$4000
	.dc.w	$000D,$03FE,$01D3,$0002,$F400,$8100,$7F00,$0000
	.dc.w	$000B,$01F8,$00B7,$0000,$3000,$0000,$FE00,$0000
	.dc.w	$00CA,$01F8,$0017,$0000,$DC00,$4C00,$B000,$0000
	.dc.w	$0092,$00F0,$004F,$0000,$3000,$3400,$CC00,$0000
	.dc.w	$0015,$00F4,$006B,$0000,$9000,$9800,$6800,$0000
	.dc.w	$000C,$007C,$0033,$0000,$0000,$3800,$F000,$0000
	.dc.w	$0002,$003E,$0009,$0000,$C000,$6000,$8000,$0000
	.dc.w	$0001,$003F,$000E,$0000,$8000,$C000,$0000,$0000
	.dc.w	$0000,$000F,$0002,$0000,$0000,$0000,$0000,$0000
rock30:		* Asteroid (Perspective:3 - Animation:0)
	.dc.w	8,10
	.dc.w	19,2
	.dc.w	$0000,$0054,$0014,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$00FB,$0034,$0000,$0000,$C000,$C000,$0000
	.dc.w	$005F,$13B8,$03E7,$0000,$8000,$4000,$8000,$0000
	.dc.w	$01AB,$7FF8,$3E57,$0000,$C000,$4000,$8000,$0000
	.dc.w	$0101,$7FFA,$7CF7,$0002,$8000,$C000,$0000,$0000
	.dc.w	$0606,$FFFD,$70F3,$0001,$0000,$C000,$4000,$0000
	.dc.w	$008D,$FFFA,$7F67,$0002,$0000,$8000,$8000,$0000
	.dc.w	$00AF,$FF89,$7E76,$0000,$0000,$0000,$0000,$0000
	.dc.w	$012E,$7F69,$7CD6,$0040,$0000,$0000,$0000,$0000
	.dc.w	$023C,$7E0B,$39F7,$0002,$0000,$0000,$0000,$0000
	.dc.w	$00BA,$0F90,$046E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0148,$06EA,$03B6,$0002,$0000,$0000,$0000,$0000
	.dc.w	$01FA,$026D,$0197,$0004,$0000,$0000,$0000,$0000
	.dc.w	$01A6,$0372,$02DC,$0040,$0000,$0000,$0000,$0000
	.dc.w	$005C,$0102,$00FC,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00EC,$01E2,$011E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0070,$00E4,$001C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0038,$0168,$0050,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0030,$0070,$0000,$0000,$0000,$0000,$0000,$0000
rock31:		* Asteroid (Perspective:3 - Animation:1)
	.dc.w	6,9
	.dc.w	19,1
	.dc.w	$0040,$0120,$0060,$0020,$03E0,$0E38,$09C8,$0000
	.dc.w	$08E0,$3B16,$27FE,$0310,$1340,$F48F,$6FF9,$0488
	.dc.w	$0308,$ECCF,$5FF1,$0CC0,$2DCC,$EA2E,$D7D2,$0200
	.dc.w	$3EC8,$F13A,$CFF6,$0120,$18EC,$F30A,$EFF4,$0300
	.dc.w	$34FC,$F606,$CBF8,$0200,$18A0,$F84E,$C7FC,$0048
	.dc.w	$036C,$FF0E,$F4F2,$0000,$02DC,$FEA7,$797B,$0000
	.dc.w	$05A8,$FC16,$A3FC,$0010,$1BF4,$FA8F,$4579,$0008
	.dc.w	$12CA,$F2C2,$4D3C,$0000,$116A,$7B6E,$2E94,$0000
	.dc.w	$1810,$3F7C,$278C,$0000,$0100,$3FD8,$0E50,$0000
	.dc.w	$0000,$0FC0,$04C0,$0000
rock32:		* Asteroid (Perspective:3 - Animation:2)
	.dc.w	8,10
	.dc.w	20,2
	.dc.w	$0080,$0000,$00C0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01A0,$183E,$03CA,$0000,$0000,$0000,$0000,$0000
	.dc.w	$13CE,$70EB,$4F34,$0000,$0000,$8000,$8000,$0000
	.dc.w	$1FEC,$CCE7,$3319,$0000,$0000,$0000,$0000,$0000
	.dc.w	$460A,$C54A,$BBF4,$0100,$0000,$8000,$0000,$0000
	.dc.w	$0960,$9023,$7FDE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1714,$D015,$EFEB,$0001,$0000,$8000,$8000,$0000
	.dc.w	$5544,$D42D,$ABFB,$0021,$0000,$8000,$0000,$0000
	.dc.w	$67E1,$EE5C,$99BF,$0000,$8000,$8000,$0000,$0000
	.dc.w	$2F55,$FE7C,$D1AB,$0000,$0000,$4000,$C000,$0000
	.dc.w	$33E1,$F2B0,$4D5F,$0000,$0000,$C000,$8000,$0000
	.dc.w	$7526,$74C2,$0BFD,$00C0,$C000,$4000,$8000,$0000
	.dc.w	$3D55,$FCA9,$43FE,$00A8,$0000,$A000,$E000,$8000
	.dc.w	$059B,$FD04,$CAFF,$0004,$4000,$2000,$C000,$0000
	.dc.w	$492D,$F922,$A6DF,$0002,$E000,$2000,$C000,$0000
	.dc.w	$10B2,$708D,$4F7F,$000D,$4000,$8000,$E000,$8000
	.dc.w	$06AE,$0EA1,$095F,$0001,$C000,$0000,$C000,$0000
	.dc.w	$023C,$0EFD,$0883,$0001,$8000,$4000,$8000,$0000
	.dc.w	$0002,$000F,$0008,$0000,$0000,$C000,$8000,$0000
	.dc.w	$0000,$0003,$0002,$0000,$0000,$0000,$0000,$0000
rock33:		* Asteroid (Perspective:3 - Animation:3)
	.dc.w	8,9
	.dc.w	20,2
	.dc.w	$0000,$0030,$0010,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0014,$007A,$0046,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$02FA,$0064,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$03FA,$03FD,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0012,$0FF8,$07EF,$0000,$0000,$8000,$8000,$0000
	.dc.w	$000A,$1FFC,$0FF7,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0007,$1FF9,$0FFE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0016,$3FF0,$1FCF,$0000,$8000,$C000,$4000,$0000
	.dc.w	$0054,$3FD3,$3F2F,$0002,$0000,$4000,$8000,$0000
	.dc.w	$023C,$3E19,$39E7,$0000,$C000,$C000,$0000,$0000
	.dc.w	$0FD5,$7D0C,$22FB,$0008,$8000,$2000,$E000,$0000
	.dc.w	$1BFD,$7FB0,$204F,$0000,$C000,$2000,$C000,$0000
	.dc.w	$0197,$7F94,$7A6B,$0000,$E000,$2000,$C000,$0000
	.dc.w	$01B5,$FE0E,$7DFB,$0002,$0000,$4000,$E000,$4000
	.dc.w	$02F7,$3E00,$3DFF,$0000,$E000,$0000,$E000,$0000
	.dc.w	$07AE,$1F21,$18DF,$0001,$E000,$0000,$E000,$0000
	.dc.w	$0408,$0F3D,$01B7,$0001,$6000,$7000,$8000,$0000
	.dc.w	$0002,$000E,$0005,$0000,$8000,$6000,$A000,$0000
	.dc.w	$0003,$0007,$0004,$0000,$8000,$8000,$4000,$0000
	.dc.w	$0000,$0003,$0003,$0000,$0000,$C000,$8000,$0000
rock34:		* Asteroid (Perspective:3 - Animation:4)
	.dc.w	7,8
	.dc.w	18,1
	.dc.w	$0000,$0034,$0034,$0000,$0028,$00FE,$0002,$0000
	.dc.w	$00F8,$01FE,$0102,$0000,$0078,$0342,$03BE,$0000
	.dc.w	$0094,$0E96,$0368,$0000,$01D6,$0F37,$04E9,$0000
	.dc.w	$0290,$1E3C,$19CA,$0000,$057E,$3D54,$32AA,$0000
	.dc.w	$06E6,$7E1A,$39FC,$0018,$08B0,$FE0E,$F3FC,$000C
	.dc.w	$03C8,$EB32,$7CFE,$0830,$174C,$EB1F,$FCF0,$0810
	.dc.w	$17FF,$E247,$FDB8,$0000,$08EA,$C0EC,$7F17,$0000
	.dc.w	$0A22,$5FE7,$609C,$0000,$0004,$0027,$0039,$0000
	.dc.w	$0008,$007E,$0016,$0000,$0000,$003C,$0018,$0000
rock35:		* Asteroid (Perspective:3 - Animation:5)
	.dc.w	7,10
	.dc.w	18,2
	.dc.w	$0030,$002C,$0014,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0078,$00E4,$0018,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0068,$01EF,$0194,$0004,$0000,$0000,$0000,$0000
	.dc.w	$002E,$07AF,$07D0,$0000,$0000,$8000,$8000,$0000
	.dc.w	$00BE,$1FFF,$1B40,$0000,$0000,$8000,$8000,$0000
	.dc.w	$34FD,$7FBD,$4B42,$0000,$0000,$0000,$0000,$0000
	.dc.w	$147E,$7E02,$4BFD,$0000,$8000,$8000,$0000,$0000
	.dc.w	$00EB,$7FA4,$3E5F,$0004,$0000,$8000,$0000,$0000
	.dc.w	$01C5,$7F8A,$6E7F,$000A,$0000,$8000,$8000,$0000
	.dc.w	$123D,$FE1A,$6DE7,$0002,$0000,$0000,$8000,$0000
	.dc.w	$0158,$7FD7,$6EAF,$0007,$8000,$8000,$0000,$0000
	.dc.w	$00AB,$FEA5,$795E,$0004,$0000,$8000,$0000,$0000
	.dc.w	$23F2,$FBF3,$DC0C,$0000,$0000,$8000,$8000,$0000
	.dc.w	$2EF4,$E0F7,$9F09,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2C48,$E98E,$97F6,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0F48,$BFC8,$B0B0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03E0,$0300,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0080,$0000,$0000,$0000,$0000,$0000,$0000
rock36:		* Asteroid (Perspective:3 - Animation:6)
	.dc.w	10,9
	.dc.w	19,2
	.dc.w	$0004,$000C,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0125,$00FC,$0353,$0000,$0000,$C000,$4000,$0000
	.dc.w	$0682,$0DDA,$0375,$0100,$C000,$7000,$9000,$0000
	.dc.w	$0C6D,$7D15,$23FA,$0010,$E000,$1000,$F000,$0000
	.dc.w	$0CEF,$FF13,$F3FC,$0010,$C000,$D000,$2000,$0000
	.dc.w	$01BF,$FC00,$7BFF,$0000,$3000,$1000,$E000,$0000
	.dc.w	$04B7,$FE48,$F3FF,$0048,$F000,$C000,$3000,$0000
	.dc.w	$09E3,$F8DC,$F73F,$001C,$7000,$C800,$B800,$8000
	.dc.w	$0B2D,$FCE2,$775F,$0402,$F000,$0800,$F000,$0000
	.dc.w	$0616,$7149,$5FBF,$0109,$6800,$9800,$F000,$8000
	.dc.w	$0E05,$3D5A,$12BF,$001A,$D000,$0800,$F000,$0000
	.dc.w	$0770,$1CCD,$033F,$000D,$9000,$6800,$F800,$6000
	.dc.w	$07D2,$0708,$00FF,$0008,$8000,$4000,$F000,$4000
	.dc.w	$02F3,$020D,$01FE,$000C,$4000,$2000,$C000,$0000
	.dc.w	$01E0,$0118,$00FF,$0018,$8000,$C000,$0000,$0000
	.dc.w	$01D6,$01C2,$003D,$0000,$0000,$C000,$0000,$0000
	.dc.w	$0030,$006F,$0019,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0078,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0020,$0000,$0000,$0000,$0000,$0000,$0000
rock37:		* Asteroid (Perspective:3 - Animation:7)
	.dc.w	8,9
	.dc.w	20,2
	.dc.w	$0422,$1F3E,$11C9,$0000,$0000,$6000,$A000,$0000
	.dc.w	$1244,$724C,$4DBB,$0000,$E000,$B000,$4000,$0000
	.dc.w	$15BB,$F0E2,$EF5D,$0000,$E000,$3000,$C000,$0000
	.dc.w	$2DF4,$C54C,$FABB,$0008,$A000,$3800,$C800,$0000
	.dc.w	$50CC,$CE60,$BBBF,$0820,$C000,$7000,$9000,$0000
	.dc.w	$7F33,$C353,$BCEC,$0040,$A000,$8000,$6000,$0000
	.dc.w	$5B73,$DB13,$A4EC,$0000,$0000,$8000,$6000,$0000
	.dc.w	$1F19,$FF1B,$80E6,$0002,$8000,$9000,$7000,$1000
	.dc.w	$00CF,$6FF0,$262F,$0000,$F000,$D000,$2000,$0000
	.dc.w	$0032,$0FE0,$0E9F,$0000,$A000,$3000,$C000,$0000
	.dc.w	$000B,$0FC0,$0F7F,$0000,$0000,$3000,$D000,$0000
	.dc.w	$0009,$07D0,$037F,$0010,$4000,$6000,$A000,$0000
	.dc.w	$011A,$03C2,$027D,$0000,$0000,$4000,$8000,$0000
	.dc.w	$00A4,$03E4,$035B,$0000,$8000,$C000,$4000,$0000
	.dc.w	$0008,$03A0,$01DF,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0044,$01E5,$01BB,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0010,$00F2,$00CE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$007C,$0020,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0010,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0008,$0000,$0000,$0000,$0000,$0000,$0000
rock40:		* Asteroid (Perspective:4 - Animation:0)
	.dc.w	7,8
	.dc.w	16,1
	.dc.w	$0010,$0300,$0110,$0000,$00D8,$03EC,$0130,$0000
	.dc.w	$005C,$7DC4,$3F38,$0000,$2328,$7FE0,$5C9C,$0000
	.dc.w	$4134,$FFEC,$3E98,$0008,$0078,$FFC4,$7F38,$0000
	.dc.w	$0108,$FF00,$7CF8,$0000,$0280,$7E40,$79F8,$0000
	.dc.w	$0B98,$1948,$06F0,$0000,$07F0,$0D98,$0A60,$0000
	.dc.w	$0740,$0450,$03A0,$0000,$0340,$0650,$01B0,$0000
	.dc.w	$00E0,$02E0,$0300,$0000,$0100,$0360,$0280,$0000
	.dc.w	$0280,$07E0,$0560,$0000,$0000,$0080,$0000,$0000
rock41:		* Asteroid (Perspective:4 - Animation:1)
	.dc.w	6,8
	.dc.w	16,1
	.dc.w	$0180,$02E0,$0120,$0000,$0740,$3CF0,$0390,$0080
	.dc.w	$3720,$7C38,$43C8,$0000,$3120,$E438,$5FC8,$0400
	.dc.w	$06C0,$E970,$5F90,$0900,$1DE0,$F270,$4F90,$0200
	.dc.w	$1760,$F0B0,$4FC0,$0080,$15F0,$F410,$4BE0,$0000
	.dc.w	$4080,$FD00,$BBF0,$0100,$12E0,$FE38,$6DC8,$0000
	.dc.w	$17A0,$F030,$CFC0,$0000,$1E20,$FC38,$A3C8,$0000
	.dc.w	$0580,$6790,$3A70,$0000,$0200,$3FE0,$35E0,$0000
	.dc.w	$0300,$BF80,$1C00,$0000,$0000,$0F00,$0900,$0000
rock42:		* Asteroid (Perspective:4 - Animation:2)
	.dc.w	6,8
	.dc.w	16,1
	.dc.w	$0200,$1080,$1700,$0000,$16E0,$00F0,$3F00,$0000
	.dc.w	$2450,$9418,$FBE0,$0000,$46B0,$C1B8,$3F40,$0000
	.dc.w	$96E8,$C1E8,$7F10,$0000,$B110,$E310,$1EE8,$0200
	.dc.w	$5A00,$D8EC,$A7FC,$0088,$3F48,$F964,$86B8,$0000
	.dc.w	$2F44,$EC64,$D3B8,$0000,$2E10,$E950,$97EC,$0140
	.dc.w	$2F74,$EC80,$93FC,$0080,$115C,$F126,$CEF8,$0020
	.dc.w	$6AF4,$6A8E,$1578,$0008,$1F60,$1F0A,$00FE,$0008
	.dc.w	$02FC,$1AF4,$0008,$0000,$0010,$0038,$0000,$0000
rock43:		* Asteroid (Perspective:4 - Animation:3)
	.dc.w	7,8
	.dc.w	17,1
	.dc.w	$0000,$0080,$0000,$0000,$0010,$01C0,$01F0,$0000
	.dc.w	$0040,$0FD8,$03B0,$0010,$0078,$1FE0,$0F98,$0000
	.dc.w	$04B8,$3FC0,$1B78,$0000,$0130,$3FC8,$1EB0,$0000
	.dc.w	$0078,$3FC8,$3F34,$0000,$0968,$7FDC,$3430,$0010
	.dc.w	$0AFC,$7846,$67BA,$0000,$2C18,$FC02,$53FC,$0000
	.dc.w	$06BE,$FC42,$FBFC,$0000,$0AF8,$FE60,$719E,$0000
	.dc.w	$0BDE,$3988,$3676,$0000,$0202,$06E2,$00BC,$0000
	.dc.w	$0018,$0032,$002E,$0000,$001C,$001C,$0000,$0000
	.dc.w	$0000,$0008,$0000,$0000
rock44:		* Asteroid (Perspective:4 - Animation:4)
	.dc.w	6,7
	.dc.w	16,1
	.dc.w	$0000,$01A0,$0020,$0000,$0040,$0270,$0390,$0000
	.dc.w	$01E0,$03A0,$0240,$0000,$01C0,$0700,$04E0,$0000
	.dc.w	$0340,$19D0,$1E30,$0000,$0200,$3810,$1FE0,$0000
	.dc.w	$07F0,$7E70,$3180,$0000,$0520,$7CC0,$33F0,$00C0
	.dc.w	$0FC0,$FC20,$E3F0,$0020,$1810,$F100,$CFF0,$0100
	.dc.w	$3A40,$EC00,$93F0,$0000,$6280,$C280,$BD70,$0000
	.dc.w	$3CD0,$BFD0,$4020,$0000,$4020,$70F0,$1000,$0000
	.dc.w	$0000,$0070,$0050,$0000,$0000,$0020,$0020,$0000
rock45:		* Asteroid (Perspective:4 - Animation:5)
	.dc.w	6,7
	.dc.w	14,1
	.dc.w	$00E0,$00B8,$0048,$0000,$0090,$0384,$037C,$0000
	.dc.w	$01F8,$07E4,$0618,$0000,$09D4,$1FC4,$1638,$0000
	.dc.w	$35F8,$7C54,$43A8,$0000,$0AF8,$7E04,$71FC,$0000
	.dc.w	$0170,$7F40,$7CB8,$0000,$03F4,$FF44,$7CB8,$0000
	.dc.w	$0A78,$788C,$77F0,$0000,$5E60,$FE78,$A190,$0010
	.dc.w	$68B0,$E500,$9FF0,$0400,$2C40,$E060,$5FA0,$0020
	.dc.w	$0C00,$EE00,$23E0,$0000,$0000,$0780,$0300,$0000
rock46:		* Asteroid (Perspective:4 - Animation:6)
	.dc.w	8,7
	.dc.w	16,2
	.dc.w	$0000,$0004,$0014,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0028,$076E,$0512,$0000,$0000,$0000,$0000,$0000
	.dc.w	$06C4,$1DE7,$1339,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0E3E,$7E93,$11EC,$0080,$0000,$8000,$8000,$0000
	.dc.w	$0092,$FC0B,$73F5,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0368,$FA03,$7DFE,$0002,$0000,$8000,$8000,$0000
	.dc.w	$0436,$FC43,$F3FC,$0040,$0000,$8000,$8000,$0000
	.dc.w	$0592,$F0AB,$6F7D,$0028,$0000,$0000,$0000,$0000
	.dc.w	$1FEE,$7A93,$257D,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0986,$3B2B,$04FC,$0028,$0000,$8000,$8000,$0000
	.dc.w	$0DEA,$1A93,$177C,$0010,$0000,$8000,$8000,$0000
	.dc.w	$014C,$0C25,$07FA,$0020,$0000,$0000,$0000,$0000
	.dc.w	$0218,$027E,$01E2,$0060,$0000,$0000,$0000,$0000
	.dc.w	$01A0,$01DC,$0060,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0080,$00B0,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0180,$0080,$0000,$0000,$0000,$0000,$0000
rock47:		* Asteroid (Perspective:4 - Animation:7)
	.dc.w	8,7
	.dc.w	16,2
	.dc.w	$0018,$07D8,$04C0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0919,$79F9,$2666,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0B67,$7941,$66BE,$0000,$0000,$8000,$0000,$0000
	.dc.w	$6CBB,$44D8,$3B67,$0040,$8000,$8000,$0000,$0000
	.dc.w	$2198,$FC48,$9BF7,$1840,$0000,$8000,$0000,$0000
	.dc.w	$14C9,$F31D,$CEF6,$0014,$0000,$0000,$0000,$0000
	.dc.w	$08BD,$7E68,$03D7,$0000,$0000,$8000,$0000,$0000
	.dc.w	$019B,$2FD0,$266F,$0000,$8000,$8000,$0000,$0000
	.dc.w	$040C,$0E80,$0BFF,$0000,$8000,$8000,$0000,$0000
	.dc.w	$00AF,$0783,$067C,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0043,$07A7,$04FC,$0024,$0000,$0000,$0000,$0000
	.dc.w	$0638,$0708,$00F6,$0000,$0000,$0000,$0000,$0000
	.dc.w	$001C,$030E,$03F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0048,$03CC,$01B0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0020,$01E0,$00D0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0020,$0060,$0040,$0000,$0000,$0000,$0000,$0000
rock50:		* Asteroid (Perspective:5 - Animation:0)
	.dc.w	4,6
	.dc.w	13,1
	.dc.w	$0000,$0400,$0000,$0000,$0000,$0F80,$0780,$0000
	.dc.w	$0A20,$7BE0,$3540,$0000,$05E0,$FFA0,$7A40,$0000
	.dc.w	$1100,$FF00,$ECE0,$0000,$02E0,$FE20,$F9C0,$0000
	.dc.w	$0980,$F920,$66C0,$0000,$0340,$3240,$0D80,$0000
	.dc.w	$0480,$1740,$0980,$0000,$0A00,$0800,$0780,$0000
	.dc.w	$0180,$0980,$0E00,$0000,$0E00,$0E00,$0100,$0000
	.dc.w	$0200,$0600,$0000,$0000
rock51:		* Asteroid (Perspective:5 - Animation:1)
	.dc.w	5,5
	.dc.w	12,1
	.dc.w	$1600,$1200,$0C00,$0000,$2E00,$6080,$1F00,$0000
	.dc.w	$7E00,$C380,$BC80,$0000,$4980,$D380,$3E00,$1000
	.dc.w	$5700,$C980,$BE80,$0800,$6100,$E480,$9F80,$0400
	.dc.w	$1B00,$EF80,$F480,$0400,$0900,$FA00,$D780,$0200
	.dc.w	$1A80,$F080,$EF00,$0000,$1F00,$FF80,$C000,$0000
	.dc.w	$0000,$7F00,$6F00,$0000,$0000,$3C00,$3400,$0000
rock52:		* Asteroid (Perspective:5 - Animation:2)
	.dc.w	5,5
	.dc.w	12,1
	.dc.w	$2A00,$2200,$0C00,$0000,$1900,$F980,$C600,$0000
	.dc.w	$2C00,$E080,$9F00,$0000,$3480,$F9C0,$8F00,$0800
	.dc.w	$0AC0,$84C0,$FF00,$0000,$3000,$B200,$CFC0,$0000
	.dc.w	$3CE0,$F020,$8FC0,$0000,$7540,$FA60,$8F80,$0A00
	.dc.w	$5940,$EC60,$B780,$0400,$3240,$F460,$4F80,$0000
	.dc.w	$1720,$1720,$00C0,$0000,$0040,$04E0,$0000,$0000
rock53:		* Asteroid (Perspective:5 - Animation:3)
	.dc.w	6,6
	.dc.w	13,1
	.dc.w	$0000,$0700,$0200,$0000,$0000,$1E80,$0F00,$0000
	.dc.w	$0080,$3E40,$3FC0,$0000,$1280,$7F40,$2D80,$0000
	.dc.w	$0140,$7E40,$7F80,$0000,$0F40,$76C0,$7980,$0080
	.dc.w	$32A0,$E320,$5DC0,$0100,$0AC0,$FE20,$F5E0,$0020
	.dc.w	$07C0,$F260,$FD80,$0000,$1C00,$7C50,$63F0,$0040
	.dc.w	$0B20,$0B60,$00C0,$0040,$00C0,$01E0,$0020,$0000
	.dc.w	$0000,$00C0,$0040,$0000
rock54:		* Asteroid (Perspective:5 - Animation:4)
	.dc.w	5,6
	.dc.w	12,1
	.dc.w	$0300,$0300,$0000,$0000,$0000,$0480,$0700,$0000
	.dc.w	$0380,$0C80,$0700,$0000,$0B00,$1900,$1680,$0000
	.dc.w	$0900,$3340,$3E80,$0000,$12C0,$7140,$6F80,$0100
	.dc.w	$1580,$F200,$4FC0,$0200,$1080,$D180,$6F40,$0100
	.dc.w	$1840,$48C0,$7780,$0000,$6000,$7440,$0380,$0000
	.dc.w	$0180,$03C0,$0240,$0000,$0000,$0180,$0100,$0000
rock55:		* Asteroid (Perspective:5 - Animation:5)
	.dc.w	5,5
	.dc.w	12,1
	.dc.w	$0200,$0200,$0000,$0000,$0100,$0780,$0680,$0000
	.dc.w	$0500,$1DC0,$0A40,$0000,$0740,$7FC0,$3800,$0000
	.dc.w	$2280,$E4C0,$5F40,$0400,$2580,$FC00,$53C0,$0000
	.dc.w	$0240,$F680,$F9C0,$0080,$1980,$F940,$E680,$0000
	.dc.w	$1C80,$CC00,$F380,$0000,$7D00,$E480,$9B00,$0000
	.dc.w	$1A00,$DB00,$4400,$0000,$0000,$1C00,$1000,$0000
rock56:		* Asteroid (Perspective:5 - Animation:6)
	.dc.w	5,5
	.dc.w	12,1
	.dc.w	$0000,$0100,$0000,$0000,$0F00,$1F40,$0080,$0000
	.dc.w	$1EE0,$F590,$4B60,$0100,$0290,$F010,$EFE0,$0000
	.dc.w	$17A0,$F030,$CFC0,$0000,$2040,$EC50,$9FB0,$0800
	.dc.w	$2D50,$F8B0,$17C0,$1080,$1440,$6DB0,$13E0,$01A0
	.dc.w	$12A0,$3410,$0FF0,$0000,$0440,$0DE0,$0300,$0100
	.dc.w	$0400,$04C0,$0300,$0000,$0000,$0700,$0200,$0000
rock57:		* Asteroid (Perspective:5 - Animation:7)
	.dc.w	6,5
	.dc.w	12,1
	.dc.w	$2C80,$2FC8,$0238,$0000,$19B0,$F020,$6FD8,$0000
	.dc.w	$2DF8,$C888,$B770,$0000,$6A00,$D880,$A7F0,$0080
	.dc.w	$6000,$FB00,$9FF8,$0200,$0258,$5F10,$1DE8,$0000
	.dc.w	$0D58,$1E18,$13E0,$0000,$0350,$1E10,$0DE0,$0000
	.dc.w	$0060,$0EB0,$03D0,$0080,$00C0,$0C60,$07A0,$0000
	.dc.w	$0100,$0740,$0680,$0000,$0000,$0380,$0200,$0000
rock60:		* Asteroid (Perspective:6 - Animation:0)
	.dc.w	5,5
	.dc.w	10,1
	.dc.w	$0000,$0400,$0400,$0000,$0000,$0E00,$0780,$0000
	.dc.w	$0180,$7C00,$5F80,$0000,$0B00,$FE00,$7580,$0000
	.dc.w	$0300,$7A00,$3D00,$0000,$1700,$7200,$2D00,$0000
	.dc.w	$1700,$1200,$0D00,$0000,$0000,$0400,$0E00,$0000
	.dc.w	$0800,$0800,$0600,$0000,$0400,$0E00,$0200,$0000
rock61:		* Asteroid (Perspective:6 - Animation:1)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$2C00,$2400,$1800,$0000,$7B00,$C100,$3E00,$0000
	.dc.w	$7600,$E600,$1800,$0000,$3C00,$E000,$DE00,$0000
	.dc.w	$5A00,$D300,$AD00,$0000,$0400,$C100,$7F00,$0000
	.dc.w	$2700,$F100,$5E00,$0000,$1600,$7600,$6800,$0000
	.dc.w	$0000,$F800,$3800,$0000
rock62:		* Asteroid (Perspective:6 - Animation:2)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$3E00,$3200,$0C00,$0000,$5D00,$4500,$3A00,$0000
	.dc.w	$3C00,$F400,$4B00,$0000,$5480,$C680,$3900,$0000
	.dc.w	$1180,$F100,$6E80,$0000,$6D80,$6100,$1E80,$0000
	.dc.w	$1E00,$E800,$7780,$0000,$5D40,$6C40,$1380,$0000
	.dc.w	$0B80,$1B80,$0000,$0000
rock63:		* Asteroid (Perspective:6 - Animation:3)
	.dc.w	5,4
	.dc.w	9,1
	.dc.w	$0100,$0F00,$0000,$0000,$0300,$1E00,$0D00,$0000
	.dc.w	$0100,$3C00,$1F00,$0000,$0280,$7880,$3F00,$0000
	.dc.w	$0B80,$7880,$7700,$0000,$0D00,$FC00,$7380,$0000
	.dc.w	$0F00,$F800,$7780,$0000,$1A80,$38C0,$0740,$0000
	.dc.w	$0180,$05C0,$0200,$0000
rock64:		* Asteroid (Perspective:6 - Animation:4)
	.dc.w	4,4
	.dc.w	9,1
	.dc.w	$0600,$0E00,$0800,$0000,$0000,$1900,$1F00,$0000
	.dc.w	$1200,$3B00,$2500,$0000,$3600,$6300,$5D00,$0000
	.dc.w	$0C00,$C100,$FF00,$0000,$6E00,$C200,$BC00,$0000
	.dc.w	$5800,$C900,$B600,$0000,$2900,$6900,$0600,$0000
	.dc.w	$0600,$0600,$0000,$0000
rock65:		* Asteroid (Perspective:6 - Animation:5)
	.dc.w	3,4
	.dc.w	10,1
	.dc.w	$0400,$0400,$0000,$0000,$0100,$0D00,$0A00,$0000
	.dc.w	$0180,$3980,$3E00,$0000,$0600,$7080,$7F00,$0000
	.dc.w	$1300,$7080,$6F00,$0000,$3800,$7C00,$4700,$0000
	.dc.w	$4A00,$EA00,$B500,$0000,$0400,$C400,$7A00,$0000
	.dc.w	$0C00,$5C00,$0000,$0000,$0000,$0800,$0800,$0000
rock66:		* Asteroid (Perspective:6 - Animation:6)
	.dc.w	5,3
	.dc.w	9,1
	.dc.w	$0080,$0E80,$0900,$0000,$0A80,$7840,$2780,$0000
	.dc.w	$0500,$7000,$2FC0,$0000,$0A80,$F000,$7FC0,$0000
	.dc.w	$2FC0,$6440,$1B80,$0000,$06C0,$2CC0,$1B00,$0000
	.dc.w	$1A00,$1040,$0F80,$0000,$0D00,$1980,$0680,$0000
	.dc.w	$0400,$0700,$0100,$0000
rock67:		* Asteroid (Perspective:6 - Animation:7)
	.dc.w	4,4
	.dc.w	10,1
	.dc.w	$1500,$3740,$0880,$0000,$07C0,$C100,$BEC0,$0000
	.dc.w	$1600,$9000,$EFC0,$0000,$61C0,$F180,$9E40,$0000
	.dc.w	$03C0,$3480,$3F40,$0000,$0580,$1C00,$1BC0,$0000
	.dc.w	$1300,$1900,$0E80,$0000,$0600,$1C80,$0B00,$0000
	.dc.w	$0000,$0C00,$0A00,$0000,$0000,$0200,$0000,$0000
rock70:		* Asteroid (Perspective:7 - Animation:0)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$0000,$1400,$0000,$0000,$0000,$7800,$7600,$0000
	.dc.w	$0800,$FA00,$E400,$0000,$1400,$7400,$4800,$0000
	.dc.w	$1000,$3400,$0800,$0000,$1800,$1800,$0000,$0000
	.dc.w	$0000,$1800,$0000,$0000
rock71:		* Asteroid (Perspective:7 - Animation:1)
	.dc.w	2,3
	.dc.w	6,1
	.dc.w	$3000,$3000,$0000,$0000,$4800,$C800,$B000,$0000
	.dc.w	$0800,$8800,$7000,$0000,$4000,$C800,$3000,$0000
	.dc.w	$2000,$A800,$D800,$0000,$3000,$7800,$4800,$0000
rock72:		* Asteroid (Perspective:7 - Animation:2)
	.dc.w	3,3
	.dc.w	7,1
	.dc.w	$1000,$3800,$2800,$0000,$1400,$5400,$6800,$0000
	.dc.w	$4800,$C800,$B400,$0000,$3800,$B800,$C400,$0000
	.dc.w	$4400,$C600,$B800,$0000,$0200,$5200,$3C00,$0000
	.dc.w	$0400,$0C00,$0000,$0000
rock73:		* Asteroid (Perspective:7 - Animation:3)
	.dc.w	4,3
	.dc.w	6,1
	.dc.w	$0400,$3E00,$3000,$0000,$0000,$7800,$6400,$0000
	.dc.w	$0C00,$6E00,$5200,$0000,$2200,$E200,$DC00,$0000
	.dc.w	$3200,$7200,$4C00,$0000,$0400,$0E00,$0A00,$0000
rock74:		* Asteroid (Perspective:7 - Animation:4)
	.dc.w	2,3
	.dc.w	6,1
	.dc.w	$0000,$1800,$0000,$0000,$1800,$3800,$2000,$0000
	.dc.w	$0800,$6800,$5000,$0000,$0000,$C000,$B800,$0000
	.dc.w	$4800,$C800,$B000,$0000,$0000,$7800,$1000,$0000
rock75:		* Asteroid (Perspective:7 - Animation:5)
	.dc.w	2,2
	.dc.w	6,1
	.dc.w	$1800,$1800,$0000,$0000,$2C00,$6C00,$5000,$0000
	.dc.w	$2000,$E400,$9C00,$0000,$7000,$F000,$8800,$0000
	.dc.w	$2000,$E800,$9800,$0000,$0000,$B000,$B000,$0000
rock76:		* Asteroid (Perspective:7 - Animation:6)
	.dc.w	3,2
	.dc.w	5,1
	.dc.w	$2400,$7400,$1800,$0000,$2200,$E200,$DC00,$0000
	.dc.w	$0800,$E800,$9600,$0000,$2000,$6200,$5C00,$0000
	.dc.w	$0800,$3C00,$0000,$0000
rock77:		* Asteroid (Perspective:7 - Animation:7)
	.dc.w	3,3
	.dc.w	6,1
	.dc.w	$2400,$7600,$4200,$0000,$3200,$B200,$CC00,$0000
	.dc.w	$8600,$E600,$3800,$0000,$0200,$7A00,$6400,$0000
	.dc.w	$2000,$3200,$1E00,$0000,$1800,$1C00,$0400,$0000

	.end
