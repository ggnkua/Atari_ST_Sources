
* File name = map8.intel

* Previously loaded at $6980

	DC.B	$08,$A0,$20,$E0,$09,$60,$20,$C0,$09,$E0,$20,$E0,$0A,$20,$20,$80
	DC.B	$0A,$80,$20,$A0,$0A,$C0,$20,$80,$0B,$20,$20,$60,$0B,$40,$20,$20
	DC.B	$0B,$C0,$1F,$A0,$0C,$20,$1F,$40,$0C,$20,$1F,$20,$0C,$20,$1E,$C0
	DC.B	$0C,$60,$1E,$80,$0C,$A0,$1E,$40,$0C,$A0,$1E,$20,$0C,$A0,$1D,$E0
	DC.B	$0C,$A0,$1D,$80,$0C,$E0,$1D,$20,$0D,$20,$1C,$80,$0D,$20,$1C,$60
	DC.B	$0D,$40,$1B,$C0,$0D,$A0,$1B,$80,$0E,$00,$1B,$20,$0E,$E0,$1A,$80
	DC.B	$0F,$40,$1A,$40,$0F,$80,$1A,$60,$10,$00,$1A,$20,$10,$60,$19,$E0
	DC.B	$10,$80,$19,$E0,$11,$00,$19,$A0,$11,$A0,$19,$40,$11,$C0,$18,$E0
	DC.B	$12,$60,$18,$80,$12,$60,$18,$60,$12,$60,$18,$00,$12,$60,$17,$A0
	DC.B	$12,$20,$17,$60,$12,$20,$17,$20,$11,$E0,$16,$C0,$11,$80,$16,$80
	DC.B	$11,$40,$16,$40,$11,$00,$15,$E0,$11,$60,$15,$40,$11,$A0,$14,$E0
	DC.B	$12,$40,$13,$C0,$12,$80,$13,$80,$12,$40,$13,$60,$11,$C0,$12,$A0
	DC.B	$10,$E0,$12,$60,$10,$40,$12,$60,$10,$00,$12,$60,$0F,$80,$12,$60
	DC.B	$0F,$40,$12,$00,$0F,$00,$11,$E0,$0E,$C0,$11,$80,$0F,$00,$11,$00
	DC.B	$0F,$00,$10,$C0,$0F,$00,$10,$20,$0F,$00,$0F,$80,$0F,$00,$0F,$20
	DC.B	$0E,$60,$0E,$60,$0D,$C0,$0E,$60,$0D,$60,$0E,$A0,$0D,$00,$0E,$80
	DC.B	$0C,$A0,$0F,$20,$0C,$00,$0F,$80,$0B,$80,$0F,$C0,$0B,$60,$0F,$E0
	DC.B	$0A,$E0,$0F,$E0,$0A,$A0,$0F,$C0,$0A,$00,$0F,$A0,$09,$A0,$0F,$40
	DC.B	$09,$00,$0F,$00,$08,$80,$0F,$00,$08,$00,$0E,$E0,$07,$80,$0E,$C0
	DC.B	$07,$40,$0E,$E0,$06,$E0,$0E,$C0,$06,$60,$0E,$80,$05,$E0,$0E,$80
	DC.B	$05,$60,$0E,$A0,$04,$C0,$0E,$A0,$04,$20,$0E,$C0,$03,$80,$0F,$00
	DC.B	$03,$40,$0F,$80,$03,$00,$10,$00,$02,$C0,$10,$80,$02,$C0,$11,$40
	DC.B	$02,$E0,$12,$20,$02,$E0,$12,$A0,$02,$E0,$13,$00,$02,$E0,$13,$80
	DC.B	$03,$20,$14,$20,$03,$20,$14,$A0,$03,$60,$15,$20,$03,$60,$15,$80
	DC.B	$03,$A0,$16,$20,$03,$A0,$16,$A0,$03,$E0,$17,$20,$03,$E0,$17,$60
	DC.B	$03,$E0,$17,$80,$04,$20,$18,$00,$04,$20,$18,$60,$04,$20,$18,$E0
	DC.B	$04,$60,$19,$40,$04,$60,$19,$C0,$04,$60,$1A,$20,$04,$A0,$1A,$40
	DC.B	$04,$A0,$1A,$E0,$04,$E0,$1B,$20,$04,$C0,$1B,$60,$04,$E0,$1B,$E0
	DC.B	$05,$00,$1C,$40,$05,$20,$1C,$E0,$05,$20,$1D,$20,$05,$40,$1D,$A0
	DC.B	$05,$60,$1D,$E0,$05,$60,$1E,$00,$05,$60,$1E,$40,$05,$A0,$1E,$E0
	DC.B	$05,$E0,$1F,$40,$05,$E0,$1F,$A0,$06,$60,$20,$00,$06,$A0,$20,$60
	DC.B	$06,$C0,$20,$40,$07,$00,$20,$60,$07,$80,$20,$A0,$07,$C0,$20,$A0
