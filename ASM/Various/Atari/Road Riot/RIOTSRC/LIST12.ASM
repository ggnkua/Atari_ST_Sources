
* File name = list12.intel

* Previously loaded at $F800

	DC.B	$00,$09,$FF,$31,$33,$47,$FF,$FF,$19,$FF,$FF,$4A,$FF,$FF,$FF,$1B
	DC.B	$FF,$1C,$FF,$1D,$1E,$04,$1F,$20,$FF,$21,$22,$23,$FF,$FF,$FF,$FF
	DC.B	$FF,$FF,$0B,$0C,$0D,$FF,$0E,$0F,$FF,$44,$FF,$3E,$FF,$FF,$FF,$FF
	DC.B	$FF,$37,$3B,$FF,$05,$FF,$FF,$3C,$FF,$3D,$45,$46,$FF,$FF,$07,$FF
	DC.B	$FF,$34,$FF,$FF,$FF,$FF,$06,$FF,$FF,$FF,$FF,$10,$FF,$11,$08,$12
	DC.B	$FF,$FF,$13,$14,$FF,$15,$16,$FF,$17,$18,$FF,$25,$FF,$FF,$26,$27
	DC.B	$FF,$FF,$01,$FF,$FF,$35,$36,$43,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$3F,$40,$FF,$FF,$42,$41,$FF,$FF,$49,$29,$2A,$2C,$2D,$2E,$28
	DC.B	$00,$4B,$80,$04,$F5,$00,$0C,$00,$00,$00,$00,$7D,$E7,$60,$05,$7E
	DC.B	$00,$6C,$00,$7C,$27,$1A,$00,$00,$00,$00,$80,$7C,$40,$DA,$0A,$1E
	DC.B	$00,$CA,$80,$7C,$24,$EA,$05,$8E,$00,$00,$80,$7E,$18,$00,$00,$00
	DC.B	$00,$00,$80,$7B,$F3,$FA,$00,$00,$00,$00,$80,$7C,$DF,$9E,$0E,$A2
	DC.B	$00,$00,$80,$67,$23,$4A,$0C,$3E,$00,$00,$00,$7A,$EC,$BE,$09,$FC
	DC.B	$00,$00,$C0,$7A,$11,$38,$09,$C6,$00,$00,$80,$7A,$15,$48,$00,$00
	DC.B	$00,$00,$81,$82,$14,$E0,$00,$00,$00,$00,$80,$7A,$14,$D0,$05,$9E
	DC.B	$00,$00,$80,$7A,$14,$F4,$00,$00,$00,$00,$80,$7A,$14,$46,$07,$2E
	DC.B	$00,$00,$80,$7A,$19,$6C,$07,$A4,$00,$00,$80,$7A,$16,$5E,$00,$00
	DC.B	$00,$00,$80,$7A,$11,$46,$00,$00,$00,$00,$80,$7A,$15,$AE,$00,$00
	DC.B	$00,$00,$80,$7A,$16,$5C,$09,$7E,$00,$00,$80,$7A,$16,$E8,$04,$02
	DC.B	$00,$00,$80,$7A,$17,$84,$0C,$A4,$00,$00,$C0,$3F,$16,$46,$06,$82
	DC.B	$00,$00,$80,$79,$0C,$F4,$00,$00,$00,$00,$00,$7C,$30,$00,$00,$00
	DC.B	$00,$60,$80,$7C,$30,$00,$08,$00,$00,$60,$80,$7C,$31,$B6,$08,$00
	DC.B	$00,$00,$80,$7C,$31,$B6,$00,$00,$00,$00,$80,$7C,$31,$B6,$00,$00
	DC.B	$FF,$C0,$81,$82,$25,$18,$06,$AE,$00,$00,$80,$7A,$E5,$82,$00,$00
	DC.B	$00,$00,$80,$7A,$E9,$24,$05,$3E,$00,$00,$80,$7A,$EB,$54,$00,$00
	DC.B	$00,$00,$81,$81,$11,$5E,$00,$00,$00,$00,$01,$81,$2E,$04,$07,$FE
	DC.B	$00,$23,$C0,$78,$F5,$AE,$00,$00,$00,$00,$81,$81,$2B,$78,$00,$00
	DC.B	$00,$00,$80,$7C,$3F,$CA,$05,$FE,$00,$00,$80,$7C,$33,$8E,$05,$FE
	DC.B	$00,$54,$80,$7C,$30,$D2,$0A,$5A,$00,$00,$80,$7A,$14,$0E,$00,$00
	DC.B	$00,$00,$00,$7A,$14,$04,$08,$9E,$00,$00,$C0,$5F,$EC,$8A,$00,$00
	DC.B	$00,$00,$C0,$78,$EF,$0E,$00,$00,$00,$00,$80,$7A,$14,$08,$00,$00
	DC.B	$00,$00,$00,$5F,$18,$08,$0D,$6E,$00,$00,$40,$78,$EE,$FA,$00,$00
	DC.B	$00,$00,$C0,$79,$F0,$3A,$09,$DC,$00,$00,$00,$78,$0C,$34,$05,$5E
	DC.B	$00,$00,$C0,$6E,$D8,$C4,$06,$1E,$00,$00,$C0,$79,$F2,$90,$05,$5E
	DC.B	$00,$00,$81,$82,$1F,$A0,$00,$00,$00,$00,$80,$7C,$2A,$2A,$00,$00
	DC.B	$00,$00,$80,$7B,$F6,$90,$04,$A2,$00,$11,$00,$82,$1F,$F4,$0D,$90
	DC.B	$00,$00,$00,$3F,$F4,$90,$00,$00,$00,$00,$00,$5F,$11,$B8,$00,$00
	DC.B	$00,$00,$80,$79,$0D,$1C,$00,$00,$00,$00,$80,$7C,$2B,$00,$06,$16
	DC.B	$00,$00,$80,$7C,$25,$A6,$00,$00,$FF,$00,$80,$7C,$36,$A6,$00,$00
	DC.B	$00,$00,$80,$7C,$33,$B4,$06,$4E,$00,$00,$80,$7C,$1B,$72,$00,$00
	DC.B	$00,$00,$80,$7C,$2F,$C0,$00,$00,$00,$B8,$80,$7C,$3C,$24,$00,$00
	DC.B	$00,$00,$80,$82,$1E,$00,$00,$00,$00,$00,$80,$81,$23,$5C,$05,$80
	DC.B	$00,$5D,$C0,$7E,$E6,$40,$0C,$FE,$00,$00,$80,$7D,$1C,$96,$00,$00
	DC.B	$00,$00,$C0,$7D,$E2,$B8,$00,$00,$00,$00,$00,$5F,$13,$50,$01,$BA
	DC.B	$00,$00,$80,$3A,$16,$8E,$06,$C6,$00,$00,$C0,$79,$ED,$02,$0B,$9E
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$80,$2C,$F7,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$B0,$00,$00,$00,$00,$7F,$FF,$FF,$FF,$FF,$FD
	DC.B	$04,$00,$40,$00,$1A,$84,$08,$88,$AE,$BF,$EC,$EE,$FF,$BF,$FF,$FF
	DC.B	$00,$20,$00,$08,$00,$50,$00,$17,$FF,$CA,$FF,$C2,$FF,$7F,$55,$CC
	DC.B	$00,$60,$00,$00,$81,$00,$00,$00,$6F,$FF,$FE,$ED,$FF,$FF,$FD,$FD
	DC.B	$80,$00,$00,$00,$00,$00,$00,$00,$7F,$FF,$DF,$FD,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$ED,$FF,$FF,$FF,$FE,$FF
	DC.B	$00,$FF,$00,$FA,$20,$DB,$02,$DF,$BF,$00,$FB,$04,$FF,$18,$EF,$04
	DC.B	$00,$00,$00,$02,$24,$00,$00,$00,$FF,$EF,$FE,$3F,$BF,$FF,$E7,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FD,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$30,$00,$00,$00,$44,$00,$FE,$FF,$FF,$FE,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$10,$00,$FF,$FF,$7F,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$FB,$00,$7F,$00,$FF,$00,$5F,$FF,$08,$FF,$00,$FF,$02,$FF,$30
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FD,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$6E,$00,$02,$00,$11,$00,$0D,$00,$9B,$FB,$FE,$FF,$AC,$FF,$DF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$F7
	DC.B	$00,$02,$00,$00,$00,$00,$80,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$5A,$00,$4F,$00,$2E,$20,$79,$40,$FC,$FF,$FD,$FF,$FD,$FF,$EF,$FF
	DC.B	$00,$21,$00,$48,$00,$01,$02,$11,$FF,$CB,$D7,$F9,$FF,$7E,$55,$7F
	DC.B	$01,$00,$00,$00,$00,$00,$00,$50,$FF,$7F,$FF,$FF,$FF,$FF,$FD,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FB,$EF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$BF,$EF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$FF,$00,$FD,$00,$FF,$01,$FD,$FF,$04,$FF,$20,$FE,$44,$FF,$00
	DC.B	$00,$00,$00,$00,$A0,$00,$08,$00,$F7,$FF,$EF,$FF,$EF,$FF,$FD,$FF
	DC.B	$00,$00,$00,$00,$00,$10,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$40,$00,$00,$00,$FF,$FF,$7F,$FF,$FF,$FF,$FE,$FF
	DC.B	$00,$00,$00,$00,$00,$C0,$00,$00,$FF,$FF,$FD,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$FE,$08,$F5,$00,$F7,$00,$FF,$FF,$00,$AF,$02,$FB,$10,$FF,$20
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FE,$FF,$FF,$FF,$FF,$FF,$BF,$FF
	DC.B	$00,$20,$00,$00,$04,$00,$20,$00,$33,$EF,$DD,$FF,$BA,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$40,$00,$FF,$7D,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$40,$00,$00,$00,$00,$05,$0A,$00,$FF,$FE,$DB,$FF,$FB,$FF,$FD,$FF
	DC.B	$00,$90,$00,$10,$00,$90,$00,$12,$FF,$DE,$FF,$6F,$BF,$7D,$55,$FF
	DC.B	$20,$00,$08,$00,$00,$00,$00,$00,$FF,$F7,$F9,$FD,$FF,$FF,$FF,$FF
	DC.B	$00,$04,$00,$00,$04,$00,$08,$00,$FF,$FB,$FF,$FF,$FF,$FF,$F7,$FF
	DC.B	$00,$00,$00,$00,$02,$00,$00,$00,$FF,$FF,$DE,$FF,$BB,$FF,$FF,$FF
	DC.B	$00,$FB,$00,$FF,$00,$FF,$50,$FF,$FF,$04,$DB,$00,$F5,$00,$FF,$00
	DC.B	$00,$08,$00,$00,$02,$00,$08,$00,$FF,$FF,$CF,$FF,$FB,$FF,$FD,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$02,$00,$FF,$FF,$FF,$F7,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$80,$00,$00,$01,$00,$08,$FF,$FF,$FD,$FF,$FF,$FF,$79,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$20,$FF,$FF,$FF,$FF,$F7,$FF,$FF,$AA
	DC.B	$00,$FC,$00,$FF,$08,$FF,$00,$FF,$FF,$00,$FF,$00,$FF,$12,$FF,$00
	DC.B	$00,$00,$00,$00,$04,$00,$00,$10,$6F,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$80,$00,$DF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$0C,$00,$45,$00,$83,$00,$52,$00,$FF,$FF,$B6,$FF,$FE,$FF,$FD,$BF
	DC.B	$00,$08,$00,$08,$00,$00,$20,$01,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$40,$00,$00,$00,$00,$00,$01,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$0E,$00,$15,$08,$10,$00,$1C,$00,$D2,$EB,$97,$FE,$FF,$DF,$ED,$BF
	DC.B	$00,$14,$00,$08,$00,$04,$00,$49,$FF,$BA,$F7,$CE,$FF,$FB,$55,$FF
	DC.B	$00,$00,$00,$00,$80,$20,$20,$00,$FF,$FF,$FF,$FF,$FE,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$40,$00,$00,$FD,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$80,$00,$00,$00,$BC,$FF,$DF,$FF,$CF,$FF,$FF,$FF
	DC.B	$04,$FF,$00,$BD,$02,$FF,$00,$FB,$BF,$40,$FF,$06,$FD,$00,$FD,$51
	DC.B	$00,$04,$00,$00,$00,$00,$00,$10,$FF,$FF,$F7,$FD,$FF,$F7,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$F7,$FF,$BF,$FF,$7F,$FB,$FF
	DC.B	$00,$00,$00,$00,$12,$00,$00,$00,$FF,$FF,$DE,$F7,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$08,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$FA,$00,$7D,$00,$F9,$00,$FF,$FF,$00,$7F,$00,$FF,$80,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$00,$20,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$DF,$FF,$FF,$FD
	DC.B	$00,$00,$03,$00,$03,$00,$00,$00,$FE,$FF,$FF,$EF,$B6,$FF,$F6,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$DF,$DF,$FF
	DC.B	$02,$00,$20,$00,$5E,$00,$08,$40,$DF,$FF,$C1,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$08,$00,$00,$00,$10,$00,$0A,$FF,$AF,$FF,$FA,$FF,$DF,$55,$E7
	DC.B	$00,$00,$00,$00,$40,$00,$40,$00,$FF,$FF,$FD,$EF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$04,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$01,$00,$FF,$FF,$FF,$FF,$DE,$FF,$FF,$FF
	DC.B	$00,$FF,$00,$FF,$04,$FF,$00,$FF,$EF,$00,$FC,$00,$FF,$20,$7F,$00
	DC.B	$00,$80,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$EF,$FF
