
* File name = map1.intel

* Previously loaded at $5C00

	DC.B	$09,$00,$19,$40,$09,$60,$18,$E0,$09,$80,$18,$A0,$0A,$00,$18,$00
	DC.B	$0A,$40,$17,$E0,$0A,$80,$17,$A0,$0A,$C0,$17,$40,$0B,$00,$16,$E0
	DC.B	$0B,$60,$16,$40,$0B,$A0,$15,$E0,$0B,$E0,$15,$20,$0B,$E0,$14,$C0
	DC.B	$0C,$20,$14,$60,$0C,$20,$13,$C0,$0C,$00,$13,$00,$0B,$C0,$12,$60
	DC.B	$0B,$80,$11,$80,$0B,$20,$11,$20,$0A,$A0,$10,$A0,$0A,$20,$10,$20
	DC.B	$09,$E0,$0F,$E0,$09,$A0,$0F,$C0,$09,$40,$0F,$A0,$08,$E0,$0F,$80
	DC.B	$08,$20,$0F,$A0,$07,$A0,$0F,$80,$07,$60,$0F,$A0,$07,$20,$0F,$80
	DC.B	$06,$C0,$0F,$C0,$06,$60,$10,$00,$06,$20,$10,$60,$05,$A0,$10,$C0
	DC.B	$05,$00,$11,$60,$04,$C0,$12,$20,$04,$80,$12,$A0,$04,$80,$13,$20
	DC.B	$04,$60,$13,$C0,$04,$60,$14,$40,$04,$A0,$14,$C0,$04,$E0,$15,$80
	DC.B	$05,$00,$16,$60,$05,$A0,$17,$20,$06,$00,$17,$E0,$06,$40,$18,$00
	DC.B	$06,$C0,$18,$80,$07,$60,$19,$40,$07,$A0,$19,$80,$08,$00,$19,$E0
	DC.B	$08,$40,$1A,$00,$08,$A0,$1A,$60,$09,$00,$1A,$A0,$09,$A0,$1B,$00
	DC.B	$09,$C0,$1B,$60,$0A,$60,$1C,$00,$0A,$A0,$1C,$40,$0B,$40,$1D,$40
	DC.B	$0B,$80,$1E,$20,$0B,$E0,$1E,$E0,$0C,$00,$1F,$40,$0C,$00,$1F,$C0
	DC.B	$0C,$00,$20,$60,$0C,$20,$20,$C0,$0B,$E0,$21,$60,$0B,$E0,$21,$C0
	DC.B	$0B,$60,$22,$40,$0B,$00,$22,$A0,$0A,$80,$23,$00,$0A,$40,$23,$20
	DC.B	$0A,$00,$23,$60,$09,$C0,$23,$80,$09,$80,$23,$80,$09,$40,$23,$C0
	DC.B	$08,$40,$24,$20,$07,$E0,$23,$E0,$07,$60,$23,$C0,$06,$C0,$23,$C0
	DC.B	$06,$60,$23,$80,$05,$E0,$23,$00,$05,$A0,$22,$C0,$05,$40,$22,$60
	DC.B	$05,$00,$22,$20,$04,$E0,$21,$E0,$04,$80,$21,$A0,$04,$80,$21,$00
	DC.B	$04,$80,$20,$E0,$04,$40,$20,$40,$04,$80,$1F,$C0,$04,$80,$1F,$20
	DC.B	$04,$E0,$1E,$00,$05,$20,$1D,$80,$05,$A0,$1C,$C0,$06,$60,$1C,$20
	DC.B	$06,$80,$1B,$40,$06,$E0,$1A,$C0,$07,$E0,$1A,$00,$08,$40,$1A,$20
