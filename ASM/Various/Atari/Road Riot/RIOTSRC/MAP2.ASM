
* File name = map2.intel

* Previously loaded at $5D80

	DC.B	$0C,$40,$1E,$00,$0C,$40,$1D,$A0,$0C,$40,$1D,$20,$0C,$40,$1C,$E0
	DC.B	$0C,$40,$1C,$40,$0C,$40,$1B,$E0,$0C,$40,$1B,$40,$0C,$40,$1A,$E0
	DC.B	$0C,$80,$1A,$00,$0C,$A0,$19,$00,$0C,$A0,$18,$80,$0C,$A0,$18,$00
	DC.B	$0C,$40,$17,$80,$0C,$40,$17,$00,$0C,$60,$16,$C0,$0C,$20,$16,$20
	DC.B	$0B,$60,$15,$A0,$0B,$00,$15,$60,$0A,$A0,$15,$40,$0A,$40,$15,$20
	DC.B	$09,$C0,$14,$E0,$09,$80,$14,$A0,$09,$80,$14,$80,$09,$40,$14,$60
	DC.B	$09,$60,$13,$C0,$09,$20,$13,$20,$09,$60,$12,$60,$09,$40,$12,$00
	DC.B	$09,$C0,$11,$A0,$0A,$80,$11,$80,$0B,$00,$11,$C0,$0B,$A0,$11,$E0
	DC.B	$0C,$80,$12,$00,$0D,$60,$11,$C0,$0D,$C0,$11,$A0,$0E,$40,$11,$20
	DC.B	$0E,$80,$10,$40,$0E,$40,$0F,$A0,$0E,$60,$0F,$20,$0D,$A0,$0E,$40
	DC.B	$0C,$40,$0D,$E0,$0B,$E0,$0E,$20,$0B,$40,$0E,$20,$0B,$00,$0E,$00
	DC.B	$0A,$A0,$0E,$60,$0A,$00,$0E,$A0,$09,$E0,$0E,$A0,$09,$60,$0E,$E0
	DC.B	$08,$C0,$0F,$20,$08,$20,$0F,$60,$07,$E0,$0F,$80,$07,$40,$0F,$E0
	DC.B	$07,$00,$0F,$E0,$06,$E0,$10,$00,$06,$80,$10,$40,$06,$20,$10,$A0
	DC.B	$05,$80,$10,$C0,$05,$00,$11,$A0,$05,$00,$12,$A0,$05,$60,$13,$40
	DC.B	$05,$60,$13,$A0,$05,$60,$14,$00,$05,$60,$14,$60,$04,$E0,$14,$C0
	DC.B	$04,$40,$15,$60,$03,$C0,$15,$C0,$03,$A0,$16,$20,$03,$00,$16,$A0
	DC.B	$02,$C0,$16,$C0,$02,$A0,$17,$60,$02,$E0,$17,$A0,$02,$80,$17,$C0
	DC.B	$02,$C0,$18,$80,$03,$60,$19,$40,$03,$A0,$19,$A0,$04,$00,$1A,$20
	DC.B	$04,$40,$1A,$40,$04,$40,$1A,$80,$04,$80,$1A,$E0,$04,$A0,$1B,$40
	DC.B	$04,$A0,$1B,$E0,$04,$60,$1C,$60,$04,$00,$1C,$C0,$04,$00,$1D,$00
	DC.B	$03,$E0,$1D,$60,$03,$A0,$1D,$E0,$03,$20,$1E,$40,$03,$60,$1E,$E0
	DC.B	$03,$60,$1F,$40,$03,$E0,$20,$20,$04,$00,$20,$A0,$04,$00,$21,$00
	DC.B	$04,$00,$21,$A0,$03,$C0,$22,$00,$03,$80,$22,$80,$03,$80,$23,$00
	DC.B	$03,$40,$23,$E0,$03,$A0,$24,$A0,$03,$A0,$25,$00,$03,$E0,$25,$60
	DC.B	$04,$C0,$25,$60,$05,$80,$25,$40,$06,$40,$25,$20,$07,$00,$24,$40
	DC.B	$07,$40,$23,$40,$07,$40,$22,$80,$07,$00,$21,$A0,$06,$C0,$20,$E0
	DC.B	$06,$E0,$20,$40,$06,$E0,$20,$00,$06,$C0,$1F,$80,$06,$C0,$1E,$E0
	DC.B	$07,$20,$1E,$20,$08,$20,$1D,$E0,$08,$E0,$1E,$00,$09,$00,$1E,$80
	DC.B	$09,$40,$1E,$C0,$09,$40,$1F,$40,$09,$80,$1F,$C0,$09,$80,$20,$60
	DC.B	$09,$E0,$20,$E0,$0A,$40,$21,$20,$0A,$E0,$21,$60,$0B,$40,$21,$20
	DC.B	$0B,$C0,$20,$C0,$0C,$00,$20,$40,$0C,$00,$20,$00,$0C,$60,$1F,$40
