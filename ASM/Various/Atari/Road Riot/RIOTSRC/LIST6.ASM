
* File name = list6.intel

* Previously loaded at $C800

	DC.B	$00,$01,$03,$6B,$05,$FF,$06,$79,$09,$FF,$0A,$FF,$0D,$FF,$0E,$7A
	DC.B	$11,$FF,$4E,$50,$53,$56,$5B,$5F,$63,$66,$68,$6A,$14,$FF,$17,$70
	DC.B	$1A,$FF,$1C,$FF,$1D,$FF,$1F,$FF,$20,$7B,$22,$FF,$FF,$75,$86,$7C
	DC.B	$24,$88,$FF,$8B,$8C,$6C,$8D,$8E,$27,$8F,$91,$93,$28,$FF,$29,$FF
	DC.B	$2D,$FF,$2F,$FF,$30,$FF,$33,$FF,$34,$FF,$35,$FF,$38,$FF,$39,$FF
	DC.B	$3B,$FF,$3F,$72,$43,$6D,$45,$FF,$48,$FF,$49,$FF,$4C,$FF,$FF,$FF
	DC.B	$95,$FF,$FF,$98,$99,$9A,$9B,$FF,$FF,$FF,$9C,$FF,$AB,$AE,$FF,$FF
	DC.B	$FF,$9F,$9E,$7F,$A0,$A4,$A8,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$81
	DC.B	$00,$AF,$80,$18,$F5,$00,$0C,$02,$00,$00,$40,$5F,$F0,$EC,$00,$00
	DC.B	$00,$00,$80,$5F,$13,$02,$00,$00,$00,$00,$01,$3B,$E7,$A0,$00,$00
	DC.B	$00,$00,$81,$36,$24,$2E,$0D,$3E,$00,$26,$80,$13,$32,$0C,$03,$A0
	DC.B	$00,$1C,$00,$1E,$D5,$A6,$0F,$BE,$00,$00,$00,$3A,$27,$C0,$00,$00
	DC.B	$00,$00,$80,$5F,$13,$12,$00,$00,$00,$00,$80,$13,$34,$5A,$00,$00
	DC.B	$00,$00,$00,$4B,$13,$3E,$00,$00,$00,$30,$00,$0A,$05,$20,$00,$00
	DC.B	$00,$30,$80,$0A,$F6,$C2,$0D,$0E,$00,$22,$80,$4A,$E7,$C0,$00,$00
	DC.B	$00,$20,$00,$4B,$22,$B6,$06,$DE,$00,$62,$00,$19,$0F,$DC,$00,$C0
	DC.B	$00,$43,$80,$19,$F1,$26,$00,$00,$00,$40,$00,$08,$F1,$38,$00,$00
	DC.B	$01,$40,$00,$13,$31,$C0,$00,$00,$01,$40,$80,$25,$14,$00,$0F,$F0
	DC.B	$00,$90,$40,$25,$F3,$56,$00,$00,$00,$00,$00,$4B,$33,$5E,$00,$00
	DC.B	$00,$00,$80,$4A,$18,$06,$0B,$80,$00,$00,$00,$35,$2F,$80,$00,$00
	DC.B	$00,$00,$00,$08,$12,$F8,$00,$00,$00,$00,$80,$48,$0F,$CA,$09,$64
	DC.B	$00,$00,$00,$09,$10,$00,$00,$00,$00,$00,$C0,$09,$F0,$00,$00,$00
	DC.B	$00,$30,$80,$25,$15,$68,$00,$00,$00,$00,$00,$4B,$EF,$B4,$0F,$F0
	DC.B	$00,$00,$80,$0B,$F8,$16,$00,$00,$00,$00,$80,$0A,$F8,$90,$00,$00
	DC.B	$00,$00,$00,$13,$2F,$D4,$00,$00,$00,$18,$80,$0B,$07,$D2,$00,$00
	DC.B	$00,$18,$00,$4B,$F0,$00,$00,$00,$00,$00,$80,$08,$0B,$C0,$00,$00
	DC.B	$01,$90,$00,$08,$0F,$42,$00,$00,$00,$00,$00,$0A,$F6,$1E,$00,$00
	DC.B	$FF,$C0,$80,$0A,$09,$A0,$00,$00,$FF,$C0,$80,$4A,$19,$D8,$00,$00
	DC.B	$00,$B0,$80,$08,$F0,$00,$00,$00,$00,$00,$00,$09,$EC,$5E,$05,$7E
	DC.B	$00,$00,$00,$19,$0F,$56,$03,$56,$00,$00,$00,$11,$10,$56,$00,$00
	DC.B	$00,$00,$80,$19,$EC,$1E,$00,$00,$00,$00,$00,$09,$EE,$10,$00,$00
	DC.B	$00,$00,$C0,$08,$11,$C4,$00,$00,$00,$00,$80,$09,$17,$00,$00,$00
	DC.B	$00,$00,$00,$08,$F0,$44,$02,$7E,$00,$00,$00,$13,$32,$3A,$0F,$F0
	DC.B	$00,$00,$80,$0B,$00,$00,$00,$00,$00,$00,$80,$09,$10,$00,$00,$00
	DC.B	$00,$00,$C1,$0F,$E8,$32,$00,$00,$00,$00,$00,$08,$10,$00,$00,$00
	DC.B	$00,$00,$00,$4B,$41,$7C,$03,$BE,$00,$00,$80,$4A,$28,$C2,$0F,$F0
	DC.B	$00,$00,$80,$13,$33,$56,$00,$00,$00,$00,$40,$3F,$10,$00,$08,$C8
	DC.B	$00,$00,$80,$5F,$11,$64,$00,$00,$00,$00,$00,$13,$33,$C8,$00,$00
	DC.B	$00,$10,$40,$19,$EC,$48,$07,$00,$00,$13,$00,$0A,$FD,$A2,$00,$18
	DC.B	$00,$10,$C0,$19,$16,$F4,$07,$64,$00,$13,$00,$08,$10,$00,$00,$00
	DC.B	$00,$00,$00,$0A,$F8,$E8,$03,$26,$00,$23,$41,$1B,$EE,$00,$00,$00
	DC.B	$00,$28,$C0,$1B,$EE,$00,$08,$00,$00,$1C,$40,$1B,$EE,$00,$00,$00
	DC.B	$00,$00,$C0,$1B,$EE,$00,$08,$00,$00,$00,$40,$08,$10,$50,$00,$00
	DC.B	$00,$00,$00,$0A,$07,$4E,$04,$C8,$00,$00,$C2,$1B,$EE,$00,$00,$00
	DC.B	$00,$00,$80,$0A,$F6,$64,$00,$18,$00,$00,$00,$09,$15,$70,$00,$00
	DC.B	$00,$10,$00,$08,$F0,$00,$00,$00,$00,$00,$80,$0B,$F7,$80,$0B,$C2
	DC.B	$00,$0A,$00,$08,$10,$00,$01,$40,$00,$00,$80,$08,$F1,$C0,$00,$00
	DC.B	$00,$00,$01,$1A,$0E,$E0,$08,$00,$00,$68,$C0,$4A,$E6,$C0,$00,$00
	DC.B	$00,$70,$00,$1A,$0E,$E0,$00,$00,$00,$60,$00,$29,$0E,$E0,$08,$00
	DC.B	$00,$50,$C0,$4A,$1C,$68,$06,$C0,$00,$53,$00,$29,$0E,$E0,$00,$00
	DC.B	$00,$40,$00,$1A,$0E,$E0,$08,$00,$00,$30,$80,$4A,$17,$80,$00,$00
	DC.B	$00,$40,$00,$1B,$0E,$E0,$00,$00,$00,$20,$00,$1A,$0E,$E0,$08,$00
	DC.B	$00,$10,$00,$29,$2C,$B4,$00,$00,$00,$20,$00,$27,$E5,$7C,$00,$4C
	DC.B	$00,$1F,$80,$4B,$22,$00,$00,$00,$00,$20,$40,$29,$0E,$E0,$01,$40
	DC.B	$00,$00,$00,$1A,$11,$6C,$0A,$BE,$00,$00,$00,$1A,$11,$92,$05,$68
	DC.B	$00,$00,$80,$28,$F1,$1E,$00,$00,$00,$00,$00,$1B,$10,$26,$01,$A8
	DC.B	$00,$00,$00,$1A,$0E,$E0,$08,$00,$FF,$F0,$40,$26,$E9,$84,$01,$68
	DC.B	$00,$00,$80,$26,$EF,$B6,$00,$00,$00,$00,$00,$1A,$11,$60,$00,$00
	DC.B	$00,$00,$00,$1A,$0E,$E0,$08,$00,$FF,$CC,$80,$4A,$4A,$F0,$00,$00
	DC.B	$00,$00,$00,$29,$0E,$E0,$00,$00,$FF,$B8,$80,$1A,$0E,$E0,$08,$00
	DC.B	$FF,$9C,$00,$1A,$0E,$E0,$00,$00,$FF,$80,$80,$1A,$0E,$E0,$08,$00
	DC.B	$FF,$68,$C2,$1A,$0E,$E0,$00,$00,$FF,$50,$C0,$5F,$E7,$EE,$00,$00
	DC.B	$00,$20,$80,$0A,$00,$00,$00,$00,$00,$10,$00,$0B,$05,$68,$00,$18
	DC.B	$00,$00,$40,$1B,$EE,$00,$00,$00,$00,$00,$C2,$1B,$EE,$00,$08,$00
	DC.B	$00,$00,$00,$25,$F0,$A0,$00,$00,$00,$00,$80,$13,$34,$8C,$07,$74
	DC.B	$00,$15,$00,$0B,$0C,$6C,$00,$00,$00,$10,$40,$1B,$EE,$00,$00,$00
	DC.B	$00,$10,$C0,$1B,$EE,$00,$08,$00,$00,$08,$00,$0A,$F6,$1E,$00,$00
	DC.B	$00,$10,$00,$5D,$18,$A0,$0F,$F0,$00,$00,$00,$4A,$D3,$E0,$0F,$F0
	DC.B	$00,$00,$80,$0A,$09,$A0,$00,$00,$00,$10,$80,$5D,$1A,$F0,$00,$00
	DC.B	$00,$00,$C0,$3E,$DD,$80,$00,$00,$00,$90,$80,$4A,$DE,$40,$00,$00
	DC.B	$00,$B0,$00,$4A,$C6,$82,$05,$FE,$00,$00,$00,$0A,$F6,$1E,$00,$00
	DC.B	$FF,$60,$80,$0A,$09,$A0,$00,$00,$FF,$60,$01,$29,$F1,$62,$08,$01
	DC.B	$00,$00,$C0,$29,$F1,$62,$0C,$01,$00,$00,$01,$36,$22,$D8,$00,$00
	DC.B	$00,$00,$01,$3C,$E0,$32,$00,$00,$00,$00,$01,$38,$E7,$02,$0F,$F0
	DC.B	$00,$00,$00,$3A,$D0,$00,$00,$00,$00,$00,$80,$78,$0E,$36,$06,$DE
	DC.B	$00,$00,$00,$0A,$F6,$1E,$00,$00,$FF,$B0,$80,$0A,$09,$A0,$00,$00
	DC.B	$FF,$B0,$00,$0A,$F6,$1E,$00,$00,$00,$00,$00,$0A,$09,$A0,$00,$00
	DC.B	$00,$00,$80,$33,$E3,$40,$0D,$7E,$00,$A1,$80,$0A,$00,$00,$00,$00
	DC.B	$00,$00,$80,$0A,$00,$00,$00,$00,$00,$10,$80,$0A,$00,$00,$00,$00
	DC.B	$00,$00,$80,$0A,$00,$00,$00,$00,$00,$00,$00,$0A,$F7,$04,$00,$00
	DC.B	$00,$00,$80,$0A,$0A,$A2,$00,$00,$00,$00,$00,$0A,$F7,$04,$00,$00
	DC.B	$00,$00,$80,$0A,$0A,$A2,$00,$00,$00,$00,$00,$0A,$F7,$04,$00,$00
	DC.B	$00,$00,$80,$0A,$09,$22,$00,$00,$00,$00,$00,$5D,$17,$40,$0A,$BE
	DC.B	$00,$00,$00,$0B,$08,$60,$00,$00,$00,$00,$80,$0B,$08,$60,$08,$00
	DC.B	$FF,$00,$80,$0B,$F6,$F0,$00,$00,$00,$00,$80,$0B,$F6,$F0,$00,$00
	DC.B	$00,$00,$80,$0B,$09,$A2,$00,$00,$01,$00,$80,$0B,$09,$A2,$03,$02
	DC.B	$01,$2F,$00,$32,$1E,$4C,$0C,$1E,$01,$84,$80,$34,$DF,$00,$00,$00
	DC.B	$01,$30,$C0,$5F,$E0,$E2,$00,$00,$00,$00,$81,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$00,$29,$F1,$62,$00,$01,$00,$00,$40,$29,$F1,$62,$04,$01
	DC.B	$00,$00,$00,$29,$F1,$62,$08,$01,$00,$00,$80,$29,$F1,$62,$0C,$01
	DC.B	$00,$00,$40,$1B,$F1,$62,$00,$01,$00,$00,$00,$29,$F1,$62,$04,$01
	DC.B	$00,$00,$00,$29,$F1,$62,$08,$01,$00,$00,$80,$29,$F1,$62,$0C,$01
	DC.B	$00,$00,$00,$29,$F1,$62,$00,$01,$00,$00,$00,$29,$F1,$62,$04,$01
	DC.B	$00,$00,$C2,$1B,$F1,$62,$08,$01,$00,$00,$00,$78,$0E,$8C,$07,$0E
	DC.B	$01,$20,$00,$5F,$15,$F4,$05,$CA,$01,$20,$C0,$79,$F2,$DA,$0A,$36
	DC.B	$01,$20,$C0,$3B,$E9,$FC,$0C,$0E,$01,$20,$81,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$81,$3D,$E1,$5E,$00,$00,$00,$00,$81,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$81,$3D,$E1,$5E,$00,$00,$00,$00,$81,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$81,$3D,$E1,$5E,$00,$00,$00,$00,$80,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$80,$3D,$E1,$5E,$00,$00,$00,$00,$80,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$80,$3D,$E1,$5E,$00,$00,$00,$00,$80,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$80,$3D,$E1,$5E,$00,$00,$00,$00,$80,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$80,$3D,$E1,$5E,$00,$00,$00,$00,$80,$3D,$E1,$5E,$00,$00
	DC.B	$00,$00,$80,$3D,$E1,$5E,$00,$00,$00,$00,$80,$51,$09,$A2,$08,$00
	DC.B	$01,$80,$80,$51,$09,$A2,$08,$00,$01,$80,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
