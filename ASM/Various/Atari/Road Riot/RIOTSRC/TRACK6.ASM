
* File name = track6.intel

* Previously loaded at $8980

	DC.B	$00,$00,$00,$00,$00,$07,$00,$0D,$00,$0D,$00,$0D,$00,$0D,$00,$0D
	DC.B	$00,$08,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$04,$00,$08,$00,$0C,$00,$10,$00,$10,$00,$10,$00,$10,$00,$10
	DC.B	$00,$10,$00,$10,$00,$10,$00,$10,$00,$10,$00,$0C,$00,$08,$00,$04
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$F7,$FF,$F4,$FF,$F7
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$F7,$FF,$F5,$FF,$F7
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$04,$00,$08,$00,$0C,$00,$10,$00,$12,$00,$12,$00,$12,$00,$12
	DC.B	$00,$12,$00,$12,$00,$12,$00,$12,$00,$12,$00,$0F,$00,$0A,$00,$06
	DC.B	$00,$00,$FF,$F8,$FF,$EA,$FF,$F0,$FF,$F0,$00,$00,$00,$08,$00,$10
	DC.B	$00,$10,$00,$10,$00,$10,$00,$10,$00,$12,$00,$10,$00,$04,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$FF,$EE,$FF,$EE,$FF,$EE,$FF,$EE,$FF,$EE
	DC.B	$FF,$EE,$FF,$EE,$FF,$F0,$FF,$F2,$FF,$F6,$00,$00,$00,$0A,$00,$0A
	DC.B	$00,$00,$00,$00,$00,$00,$00,$30,$00,$30,$00,$10,$00,$00,$FF,$78
	DC.B	$FF,$F0,$00,$30,$00,$30,$00,$20,$00,$58,$00,$10,$00,$40,$00,$90
	DC.B	$01,$40,$00,$90,$00,$70,$00,$60,$00,$40,$00,$20,$00,$00,$00,$00
	DC.B	$FF,$E0,$FF,$B8,$FF,$80,$FF,$50,$FF,$60,$FF,$C0,$FF,$E0,$00,$00
	DC.B	$00,$30,$00,$20,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$D8,$00,$00
	DC.B	$00,$18,$00,$B0,$01,$90,$00,$60,$00,$30,$00,$10,$FF,$B0,$FF,$60
	DC.B	$FF,$C0,$00,$00,$00,$C0,$00,$00,$00,$10,$00,$10,$00,$00,$00,$00
	DC.B	$00,$B0,$00,$00,$00,$00,$00,$00,$00,$98,$00,$18,$00,$00,$00,$00
	DC.B	$FF,$E0,$FF,$60,$FE,$B8,$FF,$20,$FF,$C8,$FF,$F0,$FF,$E0,$FF,$F0
	DC.B	$00,$00,$FF,$C0,$FF,$E0,$FF,$F0,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$10,$00,$18,$00,$28,$00,$10,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$10,$00,$08,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$FF,$00,$FF,$00,$00,$00,$00,$00,$00,$00,$01,$00,$01,$00,$02,$00
	DC.B	$02,$00,$01,$00,$01,$30,$01,$A0,$01,$20,$01,$20,$01,$20,$01,$20
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
