/*	Obsticle linked list structure		*/
typedef	struct	obblk
	{
	struct	links oblnk;			/* Linked list				*/
	MDTYPE	*op;				/* Pointer to obj structure	*/
	} OBBLK;
