
* File name = track2.intel

* Previously loaded at $8180

	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$08,$00,$00,$00,$00,$00,$00,$00,$04,$00,$04,$00,$04,$00,$04
	DC.B	$00,$00,$00,$00,$00,$00,$FF,$FC,$FF,$F8,$FF,$F5,$FF,$F0,$FF,$EC
	DC.B	$FF,$EC,$FF,$EC,$FF,$EC,$FF,$EE,$FF,$EE,$FF,$EE,$FF,$EE,$00,$0E
	DC.B	$00,$08,$00,$0A,$00,$0F,$00,$0F,$00,$0F,$00,$11,$00,$11,$00,$06
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$10,$00,$10,$00,$12,$00,$11,$FF,$F0,$FF,$F0,$FF,$F0
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$0B,$00,$0B,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FE
	DC.B	$FF,$FC,$FF,$FE,$FF,$FE,$00,$00,$00,$00,$00,$00,$00,$04,$00,$0A
	DC.B	$00,$0A,$00,$0A,$00,$00,$FF,$F7,$FF,$ED,$FF,$ED,$FF,$F0,$00,$00
	DC.B	$00,$12,$00,$12,$00,$12,$00,$14,$00,$14,$00,$14,$00,$14,$00,$14
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$F7,$FF,$EF,$FF,$E9,$FF,$E9
	DC.B	$FF,$E9,$FF,$EC,$FF,$EC,$FF,$EC,$FF,$EC,$FF,$EC,$00,$00,$00,$00
	DC.B	$00,$09,$00,$12,$00,$15,$00,$15,$00,$15,$00,$15,$00,$15,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$38,$00,$00,$00,$90,$00,$00
	DC.B	$FF,$F0,$00,$00,$00,$B8,$00,$00,$00,$00,$00,$00,$00,$60,$00,$00
	DC.B	$00,$C0,$00,$00,$FF,$F0,$FF,$E0,$FF,$E0,$FF,$C0,$FF,$F8,$FF,$80
	DC.B	$FF,$80,$FF,$60,$FF,$10,$FF,$40,$FF,$60,$FF,$80,$FF,$C0,$FF,$E0
	DC.B	$FF,$B0,$FF,$60,$FF,$B0,$FF,$E0,$FF,$F8,$FF,$F8,$00,$00,$FF,$E0
	DC.B	$FF,$C0,$FF,$80,$00,$58,$00,$10,$00,$00,$00,$30,$FF,$B0,$00,$28
	DC.B	$00,$10,$FF,$88,$FF,$C0,$00,$48,$00,$00,$00,$20,$00,$B0,$00,$90
	DC.B	$FF,$D0,$FF,$B8,$FF,$88,$FF,$50,$FF,$20,$FF,$40,$FF,$60,$FF,$80
	DC.B	$FF,$C0,$00,$00,$00,$18,$00,$00,$01,$08,$FF,$E0,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$01,$18,$FF,$F8,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$01,$28,$FF,$E0,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$60,$FF,$E0,$00,$20,$00,$10,$00,$08,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$40,$00,$A0,$00,$70,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$08,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
