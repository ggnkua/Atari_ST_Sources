
* File name = list10.intel

* Previously loaded at $E800

	DC.B	$00,$3A,$0E,$42,$10,$FF,$01,$02,$FF,$11,$FF,$40,$FF,$41,$FF,$12
	DC.B	$FF,$14,$FF,$15,$FF,$FF,$FF,$FF,$FF,$16,$FF,$17,$FF,$FF,$FF,$FF
	DC.B	$1F,$FF,$20,$FF,$21,$FF,$FF,$FF,$FF,$FF,$FF,$18,$19,$1A,$1B,$1C
	DC.B	$1D,$1E,$3B,$FF,$FF,$03,$FF,$04,$FF,$05,$FF,$06,$FF,$08,$FF,$0A
	DC.B	$FF,$0C,$FF,$FF,$0D,$22,$FF,$FF,$23,$FF,$FF,$24,$FF,$25,$FF,$26
	DC.B	$FF,$27,$FF,$FF,$30,$FF,$32,$FF,$34,$FF,$FF,$3C,$FF,$FF,$FF,$FF
	DC.B	$28,$FF,$FF,$FF,$FF,$FF,$2A,$FF,$2B,$FF,$2C,$FF,$FF,$FF,$2D,$FF
	DC.B	$2E,$FF,$2F,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$3F,$3D,$37
	DC.B	$00,$43,$80,$04,$F5,$00,$0C,$00,$00,$00,$80,$28,$11,$18,$00,$00
	DC.B	$00,$00,$80,$48,$11,$E8,$00,$00,$00,$00,$80,$09,$F6,$D2,$04,$1E
	DC.B	$00,$00,$80,$08,$F9,$76,$04,$1E,$00,$00,$80,$08,$09,$A0,$04,$1E
	DC.B	$00,$00,$00,$08,$09,$A0,$04,$1E,$00,$00,$80,$09,$D7,$E0,$07,$BE
	DC.B	$00,$00,$40,$09,$F7,$52,$04,$1E,$00,$00,$80,$09,$C1,$60,$07,$BE
	DC.B	$00,$00,$00,$08,$08,$A4,$04,$1E,$00,$00,$80,$09,$48,$80,$07,$BE
	DC.B	$00,$00,$80,$08,$00,$B6,$04,$1E,$00,$00,$80,$09,$F6,$C0,$00,$00
	DC.B	$00,$00,$00,$5F,$11,$88,$00,$00,$00,$00,$C0,$79,$EE,$F0,$00,$00
	DC.B	$00,$00,$80,$51,$08,$C2,$0A,$D2,$00,$00,$80,$7C,$31,$78,$00,$00
	DC.B	$00,$00,$00,$51,$09,$40,$00,$00,$00,$00,$80,$7C,$31,$78,$00,$00
	DC.B	$00,$00,$80,$09,$09,$08,$00,$00,$00,$00,$80,$09,$01,$F0,$00,$00
	DC.B	$00,$00,$80,$09,$FB,$B6,$00,$00,$00,$00,$80,$09,$13,$FE,$00,$00
	DC.B	$00,$00,$80,$51,$04,$D4,$00,$00,$00,$00,$80,$51,$04,$D4,$00,$00
	DC.B	$00,$00,$80,$51,$FC,$66,$00,$00,$00,$00,$80,$51,$F7,$06,$00,$00
	DC.B	$00,$00,$80,$51,$F7,$06,$00,$00,$00,$00,$80,$51,$FD,$66,$00,$00
	DC.B	$00,$00,$80,$51,$08,$46,$00,$00,$00,$E8,$80,$67,$24,$18,$00,$00
	DC.B	$00,$00,$80,$67,$24,$18,$00,$00,$00,$00,$80,$67,$24,$18,$00,$00
	DC.B	$00,$00,$80,$08,$0B,$FE,$0F,$DA,$00,$00,$80,$33,$C8,$78,$00,$00
	DC.B	$00,$00,$80,$67,$19,$44,$00,$00,$00,$00,$80,$67,$1F,$00,$00,$00
	DC.B	$00,$00,$80,$67,$1F,$00,$00,$00,$00,$00,$80,$09,$FB,$50,$00,$00
	DC.B	$00,$00,$00,$09,$F2,$C0,$0A,$7E,$00,$00,$80,$08,$0C,$F6,$0B,$B6
	DC.B	$00,$00,$80,$68,$1D,$72,$00,$00,$00,$00,$80,$68,$1D,$72,$00,$00
	DC.B	$FF,$80,$80,$68,$1D,$72,$00,$00,$FF,$40,$80,$51,$F7,$F8,$00,$00
	DC.B	$00,$00,$80,$51,$F4,$7E,$00,$00,$00,$00,$80,$51,$EF,$F8,$00,$00
	DC.B	$00,$00,$00,$09,$09,$DC,$05,$9A,$00,$00,$80,$7C,$2F,$7A,$05,$9C
	DC.B	$00,$00,$00,$09,$0A,$7A,$04,$6C,$00,$00,$80,$7C,$2F,$7A,$05,$9C
	DC.B	$FF,$24,$00,$09,$0B,$74,$04,$B6,$00,$00,$00,$7C,$2F,$7A,$05,$9C
	DC.B	$FF,$87,$80,$7C,$33,$66,$0F,$F0,$00,$AE,$01,$57,$0E,$80,$04,$02
	DC.B	$00,$00,$00,$57,$0E,$80,$08,$02,$00,$00,$82,$57,$0E,$80,$0C,$02
	DC.B	$00,$00,$C0,$78,$EE,$F0,$06,$2E,$00,$00,$80,$67,$20,$2C,$09,$98
	DC.B	$02,$0B,$C0,$09,$F6,$B4,$09,$BE,$01,$50,$00,$79,$0C,$10,$0D,$34
	DC.B	$00,$00,$81,$3D,$15,$86,$07,$02,$00,$00,$80,$78,$0F,$86,$0F,$F0
	DC.B	$00,$00,$80,$7C,$31,$78,$00,$00,$FF,$C0,$80,$7C,$31,$78,$00,$00
	DC.B	$FF,$F0,$80,$1E,$23,$00,$08,$0A,$00,$00,$80,$1E,$23,$00,$08,$0A
	DC.B	$00,$00,$80,$1E,$23,$00,$08,$0A,$00,$00,$80,$1E,$23,$00,$08,$0A
	DC.B	$00,$00,$80,$1E,$23,$00,$08,$0A,$00,$00,$80,$1E,$23,$00,$08,$0A
	DC.B	$00,$00,$80,$81,$70,$9A,$00,$00,$00,$00,$80,$81,$70,$9A,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FB,$FF,$E7,$FF,$F7,$FF
	DC.B	$00,$FB,$00,$FF,$05,$BF,$08,$FE,$FF,$00,$FF,$00,$FF,$20,$FF,$04
	DC.B	$00,$00,$00,$00,$00,$00,$0A,$00,$EF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$04,$FF,$FF,$FD,$FF,$F7,$FF,$FF,$FF
	DC.B	$10,$00,$00,$00,$00,$00,$08,$00,$FF,$FF,$EF,$FF,$FB,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$C0,$00,$01,$00,$FF,$FF,$F7,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$EF,$00,$FF,$00,$FB,$00,$FF,$FA,$80,$7F,$20,$FF,$01,$FF,$42
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$F7,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$10,$00,$00,$00,$40,$00,$00,$FF,$FF,$FF,$EF,$FF,$FF,$FF,$FF
	DC.B	$0A,$00,$20,$00,$A5,$00,$42,$00,$F1,$FF,$41,$FF,$EF,$FF,$FE,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$90,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$20,$02,$08,$00,$80,$08,$38,$00,$33,$77,$76,$EF,$F3,$EF,$FD,$FF
	DC.B	$00,$06,$00,$00,$00,$C0,$00,$04,$FF,$BD,$FF,$AB,$FF,$D6,$55,$D9
	DC.B	$00,$00,$00,$00,$00,$00,$00,$09,$BF,$FF,$FE,$F7,$FF,$FF,$DF,$FF
	DC.B	$08,$00,$00,$00,$20,$00,$02,$00,$FF,$FF,$FF,$FF,$FD,$FF,$FF,$FF
	DC.B	$00,$00,$01,$00,$40,$00,$00,$00,$FF,$FF,$F7,$FF,$FF,$FF,$FD,$FF
	DC.B	$01,$FF,$20,$FF,$40,$FF,$00,$FF,$C7,$00,$FF,$00,$FF,$00,$FF,$80
	DC.B	$00,$00,$00,$00,$00,$00,$40,$80,$FF,$FF,$FF,$FD,$FF,$CF,$FD,$BF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$02,$00,$00,$00,$00,$00,$00,$02,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$08,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$F6,$FF,$FF,$AA
	DC.B	$00,$FF,$00,$FF,$00,$FF,$00,$DF,$FF,$90,$FF,$81,$EF,$00,$FF,$40
	DC.B	$00,$00,$00,$00,$02,$00,$00,$80,$FF,$FF,$FF,$BF,$FF,$FF,$FF,$FE
	DC.B	$00,$00,$00,$00,$00,$00,$00,$40,$FF,$FF,$F7,$FF,$FF,$FF,$FF,$EF
	DC.B	$08,$00,$10,$00,$28,$40,$01,$00,$F5,$FF,$7F,$FF,$FF,$FF,$EF,$FF
	DC.B	$00,$00,$00,$00,$00,$01,$00,$80,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$01,$00,$00,$FD,$FF,$FF,$FF,$FF,$FD,$FF,$FF
	DC.B	$40,$00,$00,$00,$04,$00,$32,$00,$B3,$FB,$FD,$BB,$77,$EF,$FF,$FF
	DC.B	$00,$28,$00,$11,$00,$01,$00,$05,$FF,$F4,$FF,$75,$FF,$CF,$55,$F7
	DC.B	$20,$02,$00,$00,$00,$00,$05,$02,$FF,$FF,$FD,$FF,$FF,$7F,$FF,$FF
	DC.B	$00,$00,$00,$00,$20,$00,$20,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$00,$00,$DF,$FF,$FD,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$FF,$00,$FD,$00,$FF,$80,$FF,$FF,$00,$BB,$01,$FF,$10,$FF,$4C
	DC.B	$0A,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FD,$FD,$DF,$FF,$EF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$01,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$02,$00,$01,$00,$FF,$FF,$FB,$FF,$BF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$FF,$00,$DA,$00,$FF,$00,$FF,$FF,$04,$FF,$30,$FF,$00,$FF,$20
	DC.B	$00,$20,$00,$00,$10,$00,$00,$20,$FF,$FF,$FF,$DF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$02,$00,$00,$FF,$FF,$FB,$FF,$FF,$FF,$FF,$FF
	DC.B	$1A,$00,$04,$00,$54,$00,$19,$00,$F7,$FF,$9F,$FF,$FE,$FF,$FB,$FF
	DC.B	$00,$00,$00,$00,$00,$10,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$EF,$FF,$FF,$CF,$FF,$FF,$DF
	DC.B	$84,$00,$42,$80,$7C,$01,$91,$68,$FD,$5F,$7F,$DF,$FF,$FF,$FF,$FF
	DC.B	$00,$11,$00,$01,$00,$02,$04,$88,$FF,$EE,$FF,$6F,$FF,$FE,$55,$EF
	DC.B	$00,$80,$00,$00,$02,$40,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$08,$00,$00,$00,$FF,$FF,$F7,$FF,$FF,$FF,$FF,$DF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FE,$FF,$BD,$FF,$FF,$FF
	DC.B	$80,$FF,$20,$FF,$00,$FF,$09,$FF,$FF,$24,$FF,$00,$FF,$02,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$00,$01,$00,$FF,$7F,$7F,$FF,$FD,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$00,$02,$00,$08,$FD,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$20,$08,$00,$00,$00,$00,$00,$04,$BB,$FF,$FD,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$08,$FB,$FF,$FF,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$DF,$00,$FF,$00,$FF,$00,$FF,$FF,$00,$FF,$20,$FF,$00,$EF,$40
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$EF,$FF,$FF
	DC.B	$50,$00,$20,$00,$01,$10,$09,$00,$3E,$FF,$CC,$FF,$FD,$FF,$EF,$FF
	DC.B	$00,$40,$00,$00,$00,$00,$00,$02,$FF,$EF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$DF,$FF
	DC.B	$4A,$82,$06,$00,$00,$00,$02,$01,$FF,$FF,$FD,$FF,$F7,$DF,$FF,$7F
	DC.B	$00,$92,$00,$00,$00,$12,$00,$00,$FF,$EF,$FF,$DF,$FF,$BD,$55,$73
	DC.B	$00,$00,$00,$00,$00,$80,$10,$00,$7F,$DF,$DF,$EF,$FF,$EF,$FF,$FF
	DC.B	$00,$00,$00,$00,$10,$00,$18,$00,$EF,$FF,$FF,$FF,$EF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$BF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$FF,$00,$F7,$00,$FF,$90,$FF,$EF,$80,$ED,$00,$FF,$00,$FF,$06
	DC.B	$00,$00,$00,$00,$00,$20,$00,$20,$FB,$FF,$FF,$FF,$EF,$DB,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$EF,$FF,$FF,$FE
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$F7,$FF,$7E,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$01,$00,$7F,$FF,$F5,$FF,$FF,$FF,$77,$AA
	DC.B	$00,$FF,$00,$FF,$00,$FF,$00,$FF,$FF,$40,$FF,$40,$FF,$00,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$F6,$FF,$FB,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$04,$00,$8C,$00,$80,$00,$02,$00,$EB,$7F,$E0,$FF,$EA,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$08,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$DF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$F7,$FF,$FF,$FF
	DC.B	$06,$00,$28,$00,$F1,$00,$25,$04,$EA,$FF,$9F,$FC,$BF,$F7,$F5,$FF
	DC.B	$00,$00,$00,$00,$00,$A2,$80,$84,$FF,$F7,$FF,$23,$FF,$FA,$55,$DB
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$DF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$40,$00,$DD,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FD,$FF,$FF,$FF
	DC.B	$02,$EF,$00,$FF,$09,$FF,$00,$FD,$EF,$00,$FF,$00,$FF,$00,$FF,$04
	DC.B	$00,$04,$00,$00,$00,$80,$04,$00,$FF,$FD,$FF,$FF,$7F,$FF,$FF,$FF
