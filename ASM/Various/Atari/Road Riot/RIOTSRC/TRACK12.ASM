
* File name = track12.intel

* Previously loaded at $95C0

	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$0F,$00,$10
	DC.B	$00,$11,$00,$10,$FF,$F4,$FF,$ED,$FF,$EA,$FF,$EA,$FF,$EA,$FF,$EB
	DC.B	$FF,$EB,$FF,$EC,$FF,$F2,$FF,$FA,$00,$00,$00,$00,$00,$00,$00,$0F
	DC.B	$00,$12,$00,$15,$00,$16,$00,$16,$00,$14,$00,$11,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$0C,$00,$14,$00,$13
	DC.B	$00,$14,$00,$14,$00,$14,$00,$14,$00,$14,$00,$14,$00,$14,$00,$08
	DC.B	$00,$00,$00,$00,$00,$15,$00,$15,$00,$15,$00,$15,$00,$10,$00,$0D
	DC.B	$00,$00,$00,$00,$FF,$F0,$FF,$F1,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$00,$00,$FF,$FF
	DC.B	$FF,$FC,$FF,$FF,$FF,$FE,$00,$00,$00,$00,$00,$00,$00,$02,$00,$03
	DC.B	$00,$01,$00,$00,$00,$00,$00,$03,$00,$05,$00,$08,$00,$0B,$00,$0B
	DC.B	$00,$10,$00,$13,$00,$14,$00,$16,$00,$16,$00,$16,$00,$16,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$FF,$38,$FF,$E8,$00,$00,$00,$00,$FF,$48
	DC.B	$00,$50,$00,$60,$00,$50,$FF,$18,$FF,$00,$FF,$E8,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$FF,$E0,$FF,$C0,$FF,$80,$FF,$80,$FF,$A0,$FF,$C0
	DC.B	$FF,$E0,$FF,$F0,$00,$00,$00,$00,$00,$48,$FE,$C8,$FF,$80,$FF,$80
	DC.B	$FF,$A0,$FF,$C0,$FF,$E0,$FF,$F0,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$FE,$90,$FE,$80,$00,$00,$00,$00,$00,$00,$00,$88,$00,$00
	DC.B	$FF,$00,$FE,$C0,$00,$00,$00,$00,$00,$00,$00,$78,$00,$00,$FF,$00
	DC.B	$FE,$A8,$FF,$F8,$00,$00,$00,$00,$00,$A0,$FF,$F8,$FE,$F0,$FD,$F0
	DC.B	$FE,$18,$FF,$A8,$FF,$78,$FF,$C0,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$FE,$E0,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FE,$58,$FF,$70,$00,$28
	DC.B	$00,$A0,$FF,$90,$00,$00,$01,$28,$FF,$A0,$FF,$68,$00,$08,$FF,$E0
	DC.B	$00,$B8,$00,$00,$00,$90,$FF,$90,$00,$88,$00,$00,$FF,$50,$FF,$A8
	DC.B	$FF,$38,$00,$00,$00,$88,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
