
* File name = track8.intel

* Previously loaded at $8D80

	DC.B	$00,$00,$00,$0A,$00,$09,$00,$0A,$00,$08,$00,$0A,$00,$0B,$00,$09
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$FF,$F9,$FF,$FA,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$08,$00,$12,$00,$12,$00,$12,$00,$12,$00,$0B,$FF,$F7,$FF,$EE
	DC.B	$FF,$ED,$FF,$EC,$FF,$ED,$00,$03,$00,$0C,$00,$0E,$00,$10,$00,$0C
	DC.B	$00,$0A,$FF,$F5,$FF,$F2,$FF,$F5,$FF,$FE,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$17,$00,$17,$00,$16,$00,$15
	DC.B	$FF,$F4,$FF,$F4,$FF,$F3,$FF,$F2,$FF,$F6,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$10,$00,$10,$00,$09,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$0A,$00,$0A,$00,$0A,$00,$0A,$00,$0A,$00,$08,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$40,$00,$80,$FF,$98,$FF,$D8,$00,$00
	DC.B	$00,$D8,$00,$10,$00,$00,$00,$00,$00,$00,$00,$00,$00,$E8,$00,$00
	DC.B	$FF,$E8,$00,$40,$00,$80,$00,$C0,$01,$08,$02,$20,$01,$60,$01,$C0
	DC.B	$02,$40,$01,$78,$01,$80,$02,$18,$01,$00,$01,$18,$FF,$A0,$00,$38
	DC.B	$FF,$80,$FF,$D8,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$FF,$D0,$FF,$B0,$FF,$A8,$FF,$80,$FF,$70
	DC.B	$FF,$60,$FF,$70,$FF,$A0,$FF,$E0,$00,$80,$01,$40,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$28,$01,$28,$00,$00
	DC.B	$00,$00,$01,$20,$00,$00,$00,$00,$00,$D8,$FF,$A8,$FE,$F0,$FE,$90
	DC.B	$FE,$80,$FE,$90,$FE,$A0,$FE,$A0,$FE,$D0,$FF,$60,$00,$10,$01,$60
	DC.B	$00,$08,$FF,$E0,$FF,$B0,$FF,$E0,$00,$00,$FF,$70,$FF,$48,$00,$28
	DC.B	$00,$78,$01,$00,$02,$08,$00,$00,$00,$00,$00,$50,$01,$58,$00,$C8
	DC.B	$00,$00,$00,$08,$FF,$30,$FF,$10,$00,$08,$FF,$F8,$00,$00,$01,$88
	DC.B	$00,$00,$00,$00,$01,$60,$00,$00,$00,$70,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
