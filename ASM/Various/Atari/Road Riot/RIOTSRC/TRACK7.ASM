
* File name = track7.intel

* Previously loaded at $8B80

	DC.B	$00,$00,$00,$00,$FF,$F6,$FF,$EF,$FF,$FF,$00,$0A,$00,$0C,$00,$0E
	DC.B	$00,$0A,$00,$09,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$08,$00,$08,$00,$00,$00,$12
	DC.B	$00,$13,$00,$14,$00,$15,$00,$16,$00,$16,$00,$16,$00,$16,$00,$16
	DC.B	$00,$16,$00,$14,$00,$13,$00,$12,$00,$11,$00,$11,$00,$0E,$00,$0A
	DC.B	$00,$0A,$00,$08,$FF,$FC,$FF,$FA,$FF,$FA,$FF,$FA,$FF,$FA,$FF,$FA
	DC.B	$00,$00,$FF,$FA,$FF,$FA,$FF,$F7,$FF,$F7,$FF,$F7,$FF,$F7,$00,$00
	DC.B	$00,$0B,$00,$15,$00,$15,$00,$12,$00,$04,$FF,$F1,$FF,$EB,$FF,$EB
	DC.B	$FF,$F3,$00,$00,$00,$0D,$00,$13,$00,$16,$00,$16,$00,$00,$FF,$F5
	DC.B	$FF,$E8,$FF,$E8,$FF,$E8,$00,$00,$00,$0C,$00,$1B,$00,$1B,$00,$11
	DC.B	$FF,$F5,$FF,$ED,$FF,$ED,$FF,$F1,$FF,$F3,$00,$0C,$00,$0C,$00,$0C
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$0C,$00,$10,$00,$13,$00,$13,$00,$13,$00,$13,$00,$15,$00,$15
	DC.B	$00,$15,$00,$15,$00,$15,$00,$15,$00,$15,$00,$15,$00,$15,$FF,$FA
	DC.B	$FF,$FA,$FF,$FA,$FF,$FA,$FF,$FA,$FF,$FA,$FF,$FA,$FF,$FA,$FF,$FA
	DC.B	$00,$00,$00,$00,$00,$00,$FF,$C0,$FF,$88,$FF,$C0,$FF,$E0,$00,$00
	DC.B	$00,$00,$FF,$F8,$FF,$80,$FE,$F8,$FE,$68,$FE,$30,$FF,$38,$FF,$A8
	DC.B	$00,$00,$FF,$C8,$01,$08,$FF,$B8,$00,$00,$00,$00,$FF,$D0,$00,$28
	DC.B	$FE,$C0,$FE,$78,$FE,$C0,$FF,$C0,$FF,$E0,$00,$00,$FF,$E0,$FF,$C0
	DC.B	$FF,$80,$FF,$58,$FF,$A0,$FF,$D0,$00,$38,$00,$80,$00,$A0,$00,$C0
	DC.B	$00,$E0,$01,$20,$01,$40,$01,$60,$01,$80,$01,$80,$01,$A0,$01,$C0
	DC.B	$01,$E0,$02,$00,$02,$60,$FF,$A0,$FF,$E0,$FF,$E0,$FF,$C0,$FF,$C0
	DC.B	$00,$40,$FE,$60,$FE,$F8,$FF,$70,$FF,$B8,$FF,$F0,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$01,$00,$FF,$C0,$FF,$D0,$FF,$50,$FE,$40,$FD,$A8,$FF,$68
	DC.B	$FF,$F0,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$FF,$38,$FF,$08,$FE,$A8,$FF,$78,$00,$00,$00,$00,$00,$00
