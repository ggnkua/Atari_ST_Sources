
* File name = list9.intel

* Previously loaded at $E000

	DC.B	$00,$65,$44,$46,$FF,$5A,$FF,$FF,$FF,$FF,$02,$FF,$FF,$03,$FF,$FF
	DC.B	$FF,$FF,$04,$FF,$05,$FF,$06,$FF,$07,$FF,$08,$FF,$09,$FF,$FF,$5B
	DC.B	$5C,$FF,$FF,$47,$49,$4A,$FF,$FF,$FF,$5E,$5F,$0A,$60,$0C,$FF,$0E
	DC.B	$FF,$0F,$6B,$10,$FF,$57,$FF,$4C,$4E,$53,$FF,$FF,$FF,$FF,$68,$58
	DC.B	$FF,$FF,$50,$FF,$51,$FF,$FF,$52,$FF,$FF,$FF,$61,$63,$FF,$FF,$FF
	DC.B	$FF,$FF,$11,$FF,$FF,$FF,$FF,$FF,$12,$FF,$FF,$6C,$FF,$FF,$FF,$13
	DC.B	$FF,$FF,$FF,$6D,$14,$FF,$FF,$FF,$FF,$FF,$15,$16,$1A,$1E,$22,$26
	DC.B	$2A,$2E,$32,$36,$3A,$3E,$42,$43,$FF,$69,$FF,$6A,$FF,$6E,$54,$55
	DC.B	$00,$6F,$00,$18,$F5,$00,$0C,$00,$00,$00,$81,$44,$11,$D4,$0E,$00
	DC.B	$00,$00,$80,$13,$32,$EA,$0F,$F0,$00,$00,$81,$66,$13,$20,$0F,$F0
	DC.B	$00,$00,$80,$68,$22,$16,$00,$00,$00,$00,$80,$68,$22,$16,$00,$00
	DC.B	$FF,$88,$80,$68,$22,$16,$00,$00,$FF,$B8,$80,$68,$22,$16,$00,$00
	DC.B	$00,$00,$80,$68,$22,$16,$00,$00,$FF,$00,$80,$68,$22,$16,$00,$00
	DC.B	$00,$00,$01,$30,$12,$CC,$00,$00,$00,$00,$80,$50,$F5,$58,$00,$00
	DC.B	$00,$00,$01,$30,$14,$24,$00,$00,$00,$00,$80,$50,$F5,$58,$00,$00
	DC.B	$00,$00,$81,$30,$14,$0C,$00,$00,$00,$00,$81,$30,$14,$EC,$00,$00
	DC.B	$00,$00,$80,$6B,$2A,$3E,$0F,$F0,$00,$00,$81,$66,$11,$10,$0E,$3A
	DC.B	$00,$8B,$81,$66,$12,$48,$0F,$F0,$00,$9F,$80,$67,$21,$7A,$00,$00
	DC.B	$00,$A0,$80,$5A,$13,$C8,$0D,$F0,$00,$98,$80,$6C,$1A,$74,$04,$44
	DC.B	$00,$00,$01,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$00,$46,$10,$68,$00,$00,$00,$00,$00,$46,$10,$68,$04,$00
	DC.B	$00,$00,$00,$46,$10,$68,$08,$00,$00,$00,$80,$46,$10,$68,$0C,$00
	DC.B	$00,$00,$82,$46,$10,$68,$00,$00,$00,$00,$80,$7A,$11,$04,$04,$00
	DC.B	$00,$00,$40,$78,$F1,$0E,$00,$00,$00,$00,$80,$79,$0E,$6C,$02,$BA
	DC.B	$00,$00,$80,$4F,$22,$50,$0D,$B2,$00,$00,$00,$7C,$31,$C0,$00,$00
	DC.B	$00,$00,$80,$7C,$31,$C0,$08,$00,$FF,$20,$80,$7C,$31,$C0,$00,$00
	DC.B	$FF,$98,$00,$7C,$31,$C0,$00,$00,$FF,$D8,$80,$7C,$31,$C0,$08,$00
	DC.B	$FF,$EC,$00,$7C,$32,$1C,$00,$00,$00,$00,$80,$7C,$32,$1C,$08,$00
	DC.B	$FF,$00,$00,$7C,$32,$1C,$00,$00,$FF,$00,$80,$7C,$32,$1C,$08,$00
	DC.B	$FF,$00,$80,$7C,$36,$38,$00,$00,$00,$00,$80,$13,$32,$80,$00,$00
	DC.B	$00,$00,$80,$13,$32,$C2,$0C,$40,$00,$6E,$80,$5C,$13,$DA,$0D,$56
	DC.B	$00,$00,$81,$39,$16,$2E,$00,$00,$00,$00,$00,$78,$0E,$00,$00,$00
	DC.B	$00,$00,$C0,$79,$F2,$98,$07,$3E,$00,$00,$80,$14,$35,$60,$0C,$2E
	DC.B	$00,$79,$00,$62,$2E,$70,$0F,$F0,$00,$00,$81,$3E,$E6,$5C,$0F,$F0
	DC.B	$00,$00,$80,$3F,$0E,$C4,$00,$00,$00,$00,$80,$50,$04,$06,$00,$00
	DC.B	$00,$00,$00,$50,$04,$06,$00,$00,$FE,$98,$80,$50,$04,$06,$08,$00
	DC.B	$FE,$D8,$80,$50,$F5,$16,$00,$00,$00,$00,$80,$50,$F6,$20,$00,$00
	DC.B	$00,$00,$80,$50,$F5,$58,$00,$00,$00,$00,$40,$6F,$D8,$80,$08,$2E
	DC.B	$00,$00,$C0,$78,$F3,$88,$05,$3E,$00,$00,$40,$6F,$D8,$80,$0F,$F0
	DC.B	$00,$00,$C0,$3F,$EE,$58,$0A,$56,$00,$00,$00,$5F,$11,$86,$0C,$90
	DC.B	$00,$00,$00,$44,$11,$D4,$02,$00,$00,$00,$82,$44,$11,$D4,$06,$00
	DC.B	$00,$00,$C0,$79,$F1,$DC,$0E,$20,$00,$00,$80,$3F,$ED,$C2,$00,$00
	DC.B	$00,$00,$80,$14,$31,$78,$0F,$F0,$00,$00,$80,$7C,$2D,$AC,$0D,$CE
	DC.B	$00,$00,$80,$7C,$31,$22,$00,$00,$00,$00,$80,$7C,$33,$F6,$00,$00
	DC.B	$00,$00,$81,$38,$ED,$8C,$0D,$7A,$00,$00,$80,$7C,$33,$F6,$00,$00
	DC.B	$00,$00,$80,$7C,$33,$F6,$00,$00,$00,$00,$FD,$F7,$FF,$FF,$F7,$FF
	DC.B	$00,$00,$00,$00,$42,$00,$08,$00,$3F,$FF,$FF,$FF,$FF,$FF,$7D,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FE,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$BF,$00,$E3,$00,$F3,$00,$FF,$FF,$00,$FF,$00,$FF,$00,$FF,$00
	DC.B	$00,$00,$10,$00,$00,$00,$04,$02,$F7,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$20,$00,$FF,$DF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$08,$00,$08,$00,$02,$00,$97,$20,$A0,$FF,$DE,$FF,$DE,$FB,$FA,$FF
	DC.B	$00,$01,$00,$00,$00,$00,$00,$00,$FF,$F7,$FF,$FF,$FF,$FF,$FF,$FE
	DC.B	$02,$00,$00,$00,$00,$02,$08,$00,$FF,$FF,$FB,$FF,$FF,$FF,$FF,$FF
	DC.B	$28,$00,$10,$00,$A3,$20,$AB,$00,$A0,$FF,$F7,$EF,$FF,$FF,$FF,$FD
	DC.B	$00,$24,$00,$00,$00,$68,$00,$00,$FF,$EA,$FF,$8E,$FE,$CB,$55,$D2
	DC.B	$00,$00,$00,$00,$00,$80,$00,$10,$F7,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$40,$00,$00,$FF,$FF,$EF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$10,$00,$DF,$FF,$FF,$FF,$FD,$FF,$FF,$FF
	DC.B	$00,$FF,$00,$FF,$00,$FF,$30,$FF,$F5,$00,$FF,$00,$FF,$40,$FF,$00
	DC.B	$00,$00,$00,$00,$02,$40,$00,$00,$FF,$EF,$FF,$FF,$BF,$FD,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$20,$04,$00,$FF,$FF,$FF,$FD,$FF,$FF,$FF,$FB
	DC.B	$02,$00,$00,$00,$00,$02,$00,$00,$DB,$BF,$3F,$FF,$DE,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$DF,$AA
	DC.B	$00,$FF,$00,$FF,$00,$BF,$00,$FF,$7F,$00,$FF,$00,$FF,$00,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$01,$FF,$FF,$FF,$FF,$FD,$7F,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$F7,$FF,$FF
	DC.B	$80,$00,$10,$00,$00,$00,$04,$00,$F7,$FF,$BE,$FF,$6D,$FF,$EF,$FF
	DC.B	$00,$00,$00,$00,$00,$02,$00,$00,$F7,$FF,$FF,$FF,$FF,$FF,$FF,$DF
	DC.B	$08,$00,$00,$00,$00,$00,$70,$00,$FF,$F7,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$02,$00,$20,$00,$20,$00,$80,$F5,$FF,$FF,$FF,$FF,$FB,$FF,$FF
	DC.B	$00,$C0,$00,$00,$00,$07,$04,$82,$FE,$FE,$DF,$F7,$FF,$AE,$55,$EF
	DC.B	$40,$00,$00,$00,$00,$00,$20,$00,$7E,$FF,$BF,$FF,$EF,$FF,$FB,$FF
	DC.B	$04,$00,$00,$00,$00,$00,$00,$04,$FF,$FF,$FF,$FF,$FF,$EF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$20,$00,$FF,$FF,$FF,$FF,$FB,$FF,$FF,$FF
	DC.B	$00,$FF,$00,$FF,$00,$FF,$00,$FF,$FD,$00,$FF,$00,$7F,$20,$EE,$00
	DC.B	$02,$00,$00,$80,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$F5,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$10,$00,$00,$01,$00,$40,$BE,$FF,$FF,$FF,$FF,$FF,$DF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$62,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$AB
	DC.B	$80,$FF,$00,$FB,$04,$FF,$01,$FF,$FF,$00,$EF,$00,$FF,$04,$FF,$00
	DC.B	$00,$00,$00,$02,$00,$00,$00,$08,$FE,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$C0,$00,$08,$00,$90,$00,$0B,$00,$F4,$FF,$E6,$FF,$BF,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$00,$08,$00,$00,$FF,$EF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$08,$00,$00,$00,$00,$FF,$FF,$7F,$FF,$FF,$FF,$F9,$F7
	DC.B	$04,$02,$A2,$00,$30,$11,$78,$21,$AF,$BF,$FF,$FF,$FF,$FB,$7F,$FF
	DC.B	$00,$10,$00,$00,$00,$44,$00,$88,$FF,$A7,$FF,$FD,$FF,$F8,$55,$8F
	DC.B	$00,$00,$00,$00,$80,$20,$30,$A0,$FF,$EF,$FF,$FF,$FF,$FF,$FF,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$40,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$04,$00,$00,$00,$FF,$FF,$FE,$FF,$FF,$FF,$FD,$FF
	DC.B	$00,$FE,$00,$FF,$00,$FF,$08,$EF,$FF,$01,$FF,$00,$FF,$08,$FF,$E0
	DC.B	$00,$00,$00,$00,$00,$00,$04,$00,$FE,$F7,$FF,$FF,$FF,$7F,$FF,$9D
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$80,$00,$08,$00,$08,$00,$FF,$FF,$7F,$FF,$FF,$FF,$EF,$FF
	DC.B	$00,$00,$00,$00,$80,$00,$00,$00,$FF,$BF,$FF,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$FE,$00,$FE,$00,$DB,$00,$FD,$FF,$00,$FF,$18,$FF,$00,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$10,$00,$00,$FF,$FB,$FF,$FF,$BF,$FF,$FF,$FB
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$B0,$00,$40,$00,$27,$00,$6D,$FF,$D2,$FF,$DF,$FF,$4E,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$28,$10,$00,$00,$00,$01,$4A,$00,$ED,$FF,$EE,$BE,$DF,$FF,$FF,$FF
	DC.B	$10,$80,$00,$04,$00,$E0,$00,$C5,$FF,$1F,$FE,$F5,$FF,$DE,$55,$BF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00,$F7,$FF,$FF,$FF,$FF,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$08,$00,$00,$00,$FD,$FF,$FF,$FF,$DF,$FF,$FB,$FF
	DC.B	$00,$FF,$00,$FF,$02,$FF,$00,$F7,$F7,$00,$FF,$10,$FF,$00,$FF,$01
	DC.B	$00,$00,$00,$00,$00,$04,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
