	TTL	'ALFTBL'

SYSID	EQU	1	* VMS = 0, ARIUM = 1

	SECTION	3				* Put this in ROM

	PAGE
	XDEF	DASH000,DASH001,DASH002
	XDEF	MIRR003,LOGO010

	XDEF	LNKR000,LNKR001
	XDEF	LNKR010,LNKR011,LNKR012,LNKR013
	XDEF	LNKR014,LNKR015,LNKR016,LNKR017

	XDEF	needles
needles:
	DC.L	DASH100,DASH101,DASH102,DASH103,DASH104,DASH105,DASH106,DASH107
	DC.L	DASH108,DASH109,DASH110,DASH111,DASH112,DASH113,DASH114,DASH115
	DC.L	DASH116,DASH117,DASH118,DASH119,DASH120,DASH121,DASH122,DASH123
	DC.L	DASH124,DASH126,DASH126,DASH127,DASH128,DASH129,DASH130,DASH131

	XDEF	muds
muds:	DC.L	SPLT001,SPLT002,SPLT003,SPLT004

	XDEF	maps
maps:	DC.L	MAP150,MAP152,MAP151,MAP153
	DC.L	MAP154,MAP155,MAP156,MAP157
	DC.L	MAP158,MAP159,MAP161,MAP160

	XDEF	bnums
bnums:	DC.L	BNUM000,BNUM001,BNUM002,BNUM003,BNUM004
	DC.L	BNUM005,BNUM006,BNUM007,BNUM008,BNUM009

	PAGE
	IFEQ	SYSID
	INCLUDE '[speed.grafix]alpha.asm'
	ENDC
	IFNE	SYSID
	INCLUDE grafix/alpha.asm
	ENDC

	END
