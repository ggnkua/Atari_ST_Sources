
* File name = track5.intel

* Previously loaded at $8780

	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$03,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$01,$00,$00,$00,$00,$FF,$FE,$00,$00,$00,$00
	DC.B	$00,$02,$00,$00,$00,$00,$FF,$FE,$FF,$FE,$FF,$FE,$FF,$FE,$00,$00
	DC.B	$00,$00,$00,$00,$00,$02,$00,$00,$00,$00,$00,$03,$00,$04,$00,$00
	DC.B	$00,$00,$00,$08,$00,$0A,$00,$0A,$00,$00,$00,$00,$00,$00,$FF,$F8
	DC.B	$FF,$F4,$FF,$F0,$FF,$EF,$FF,$EE,$FF,$F8,$FF,$FC,$00,$00,$00,$08
	DC.B	$00,$10,$00,$14,$00,$16,$00,$16,$00,$16,$00,$16,$00,$16,$00,$10
	DC.B	$00,$01,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$FF,$F8,$FF,$F8,$FF,$F6,$FF,$F6,$FF,$FC,$00,$00,$00,$04
	DC.B	$00,$0A,$00,$0A,$00,$08,$00,$04,$00,$00,$00,$04,$00,$04,$00,$08
	DC.B	$00,$04,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FE,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$FF,$F0,$FF,$F0,$FF,$F0,$FF,$F0,$00,$00
	DC.B	$00,$00,$00,$14,$00,$14,$00,$14,$00,$14,$00,$00,$FF,$EC,$FF,$EC
	DC.B	$FF,$EC,$FF,$EC,$FF,$EC,$FF,$EC,$00,$00,$00,$0A,$00,$14,$00,$14
	DC.B	$00,$14,$00,$14,$00,$14,$00,$15,$00,$15,$00,$15,$00,$16,$00,$16
	DC.B	$00,$15,$00,$0A,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$10,$00,$80,$01,$40,$02,$18,$00,$98,$00,$20,$FF,$98
	DC.B	$00,$00,$FF,$68,$FF,$50,$00,$10,$00,$50,$00,$C8,$01,$20,$00,$D8
	DC.B	$01,$F8,$02,$30,$02,$48,$02,$F8,$02,$A0,$02,$00,$01,$10,$00,$80
	DC.B	$00,$10,$FF,$D8,$00,$A0,$FF,$B0,$FF,$D0,$00,$C8,$00,$40,$00,$60
	DC.B	$00,$B0,$00,$20,$00,$20,$00,$40,$00,$A0,$01,$48,$00,$30,$00,$30
	DC.B	$00,$30,$00,$30,$00,$30,$00,$30,$00,$30,$00,$30,$00,$30,$00,$30
	DC.B	$00,$30,$00,$30,$00,$30,$00,$30,$00,$40,$00,$60,$00,$E0,$01,$48
	DC.B	$01,$B0,$FF,$F8,$FF,$E0,$FF,$B0,$FF,$E0,$00,$F0,$01,$98,$02,$08
	DC.B	$01,$F8,$01,$90,$01,$38,$00,$C0,$00,$48,$FF,$C0,$FF,$50,$FF,$00
	DC.B	$FF,$28,$FF,$90,$FF,$F8,$00,$78,$01,$20,$00,$30,$00,$10,$00,$10
	DC.B	$00,$50,$FF,$10,$FF,$00,$FF,$50,$FF,$E0,$00,$40,$00,$88,$01,$18
	DC.B	$00,$F0,$00,$A0,$FF,$90,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$FF,$C0,$FF,$78,$FF,$D0
