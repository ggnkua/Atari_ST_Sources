
* File name = map3.intel

* Previously loaded at $5F80

	DC.B	$10,$80,$1A,$60,$10,$80,$19,$40,$10,$A0,$18,$00,$10,$20,$17,$A0
	DC.B	$0F,$C0,$17,$60,$0E,$80,$16,$E0,$0D,$80,$17,$00,$0D,$00,$17,$A0
	DC.B	$0C,$A0,$18,$60,$0C,$00,$19,$00,$0B,$A0,$19,$C0,$0B,$40,$1A,$40
	DC.B	$0B,$00,$1A,$E0,$0A,$E0,$1B,$40,$0A,$A0,$1B,$C0,$0A,$40,$1C,$00
	DC.B	$0A,$20,$1C,$60,$09,$A0,$1C,$A0,$08,$80,$1D,$20,$07,$80,$1D,$00
	DC.B	$06,$A0,$1C,$60,$06,$40,$1B,$60,$06,$A0,$1A,$C0,$06,$80,$1A,$80
	DC.B	$07,$00,$1A,$20,$07,$80,$19,$80,$08,$40,$19,$40,$09,$A0,$18,$A0
	DC.B	$09,$E0,$17,$60,$09,$A0,$16,$A0,$09,$40,$16,$20,$08,$80,$15,$C0
	DC.B	$07,$60,$16,$60,$06,$60,$17,$40,$05,$40,$17,$A0,$04,$C0,$17,$80
	DC.B	$04,$80,$17,$00,$04,$40,$16,$80,$04,$40,$16,$80,$04,$40,$15,$E0
	DC.B	$04,$E0,$14,$E0,$05,$40,$14,$80,$05,$C0,$14,$40,$06,$00,$14,$20
	DC.B	$06,$40,$13,$C0,$06,$80,$13,$A0,$06,$C0,$13,$A0,$07,$00,$13,$60
	DC.B	$07,$60,$12,$C0,$07,$80,$12,$60,$07,$C0,$11,$E0,$07,$C0,$11,$A0
	DC.B	$07,$C0,$11,$00,$07,$C0,$10,$E0,$07,$80,$10,$20,$07,$00,$0F,$80
	DC.B	$06,$00,$0F,$60,$05,$40,$0F,$00,$04,$C0,$0F,$60,$04,$60,$0F,$60
	DC.B	$03,$E0,$10,$20,$03,$80,$10,$60,$03,$20,$10,$80,$02,$C0,$11,$00
	DC.B	$02,$60,$11,$80,$02,$00,$12,$00,$02,$00,$12,$80,$02,$00,$13,$60
	DC.B	$02,$00,$14,$00,$02,$00,$14,$A0,$02,$00,$15,$60,$02,$00,$16,$60
	DC.B	$02,$20,$17,$20,$02,$20,$18,$20,$02,$20,$19,$00,$02,$20,$19,$E0
	DC.B	$02,$20,$1A,$40,$02,$00,$1B,$00,$02,$00,$1B,$E0,$02,$00,$1C,$40
	DC.B	$02,$00,$1C,$C0,$02,$00,$1D,$60,$02,$00,$1E,$40,$02,$00,$1E,$C0
	DC.B	$02,$00,$1F,$40,$02,$00,$1F,$C0,$02,$00,$20,$80,$02,$00,$21,$20
	DC.B	$02,$00,$21,$E0,$02,$60,$22,$E0,$02,$60,$23,$00,$02,$80,$23,$80
	DC.B	$03,$00,$24,$00,$03,$40,$24,$60,$03,$E0,$24,$80,$04,$20,$24,$C0
	DC.B	$04,$80,$25,$00,$05,$20,$24,$C0,$05,$A0,$24,$C0,$05,$E0,$24,$40
	DC.B	$06,$40,$23,$A0,$06,$60,$23,$40,$06,$A0,$22,$C0,$06,$A0,$22,$80
	DC.B	$07,$60,$22,$00,$08,$60,$21,$80,$08,$C0,$21,$40,$09,$00,$21,$00
	DC.B	$09,$A0,$20,$80,$09,$E0,$20,$40,$0A,$20,$20,$20,$0A,$60,$1F,$C0
	DC.B	$0A,$C0,$1F,$40,$0B,$60,$1E,$C0,$0B,$C0,$1E,$60,$0C,$20,$1D,$E0
	DC.B	$0C,$60,$1D,$80,$0C,$A0,$1D,$20,$0C,$E0,$1C,$C0,$0D,$20,$1C,$80
	DC.B	$0D,$80,$1C,$00,$0E,$40,$1B,$80,$0F,$20,$1B,$60,$0F,$80,$1B,$60
	DC.B	$0F,$C0,$1B,$20,$10,$00,$1B,$20,$10,$40,$1B,$00,$10,$A0,$1A,$80
