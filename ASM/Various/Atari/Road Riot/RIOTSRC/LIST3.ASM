
* File name = list3.intel

* Previously loaded at $B000

	DC.B	$00,$41,$49,$FF,$FF,$39,$4C,$FF,$FF,$FF,$3A,$05,$FF,$FF,$FF,$FF
	DC.B	$52,$54,$06,$56,$58,$5A,$09,$5C,$FF,$FF,$3B,$FF,$0D,$4E,$4F,$3C
	DC.B	$5D,$5F,$61,$63,$65,$67,$69,$0E,$6B,$6D,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$22,$FF,$FF,$FF,$24,$4D,$25,$FF,$FF,$FF,$FF,$26,$27,$FF,$FF
	DC.B	$FF,$11,$FF,$FF,$FF,$FF,$FF,$13,$15,$16,$50,$17,$FF,$FF,$18,$FF
	DC.B	$FF,$FF,$19,$3F,$FF,$28,$1A,$29,$1C,$43,$2B,$2A,$40,$1D,$FF,$2C
	DC.B	$1E,$2D,$FF,$FF,$1F,$FF,$21,$2F,$FF,$FF,$FF,$3D,$30,$FF,$FF,$FF
	DC.B	$33,$32,$34,$35,$36,$37,$FF,$44,$45,$3E,$46,$FF,$FF,$FF,$FF,$47
	DC.B	$00,$6F,$00,$18,$F5,$00,$0C,$00,$00,$00,$01,$60,$12,$04,$00,$00
	DC.B	$00,$00,$00,$61,$12,$04,$04,$00,$FF,$F0,$00,$60,$12,$04,$08,$00
	DC.B	$00,$00,$80,$60,$12,$04,$0C,$00,$FF,$D0,$C0,$5A,$15,$08,$00,$00
	DC.B	$00,$20,$40,$06,$EE,$F8,$06,$7E,$00,$00,$40,$40,$EF,$E0,$00,$00
	DC.B	$FE,$68,$C0,$40,$EF,$E0,$08,$00,$FE,$AC,$40,$08,$16,$0C,$00,$00
	DC.B	$00,$00,$40,$0F,$C6,$7E,$00,$00,$00,$00,$40,$40,$EF,$E0,$00,$00
	DC.B	$FF,$B0,$C0,$40,$EF,$E0,$08,$00,$FF,$D8,$C0,$5A,$14,$F4,$00,$00
	DC.B	$01,$00,$00,$0F,$B7,$80,$09,$3E,$00,$00,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C0,$41,$EF,$94,$08,$00,$00,$00,$01,$0F,$1B,$50,$00,$00
	DC.B	$00,$B0,$C1,$0F,$E5,$CC,$00,$00,$00,$B0,$40,$73,$F1,$8C,$00,$00
	DC.B	$00,$00,$80,$73,$0E,$DC,$05,$60,$00,$00,$80,$26,$EE,$60,$00,$00
	DC.B	$00,$00,$80,$28,$11,$F0,$00,$00,$00,$70,$80,$13,$34,$C0,$00,$00
	DC.B	$02,$50,$81,$69,$11,$E0,$00,$00,$02,$00,$80,$28,$EE,$20,$00,$00
	DC.B	$00,$40,$00,$28,$11,$E0,$00,$00,$00,$40,$80,$0B,$F8,$C0,$00,$00
	DC.B	$00,$40,$80,$28,$F0,$88,$00,$00,$00,$B0,$80,$0F,$29,$40,$00,$00
	DC.B	$00,$A8,$80,$26,$ED,$80,$00,$00,$00,$00,$00,$26,$15,$9E,$00,$00
	DC.B	$00,$00,$80,$0F,$45,$4E,$00,$00,$00,$00,$80,$25,$E9,$E0,$00,$00
	DC.B	$00,$00,$00,$13,$34,$40,$00,$00,$00,$00,$80,$73,$10,$38,$05,$36
	DC.B	$00,$00,$80,$13,$33,$00,$00,$00,$00,$00,$80,$13,$30,$C0,$00,$00
	DC.B	$00,$00,$80,$13,$34,$80,$00,$00,$00,$00,$80,$09,$F7,$D2,$00,$00
	DC.B	$00,$00,$80,$0F,$2C,$00,$00,$00,$00,$00,$80,$0F,$BF,$20,$00,$00
	DC.B	$01,$00,$80,$0F,$44,$80,$00,$00,$00,$F8,$C1,$0F,$ED,$40,$00,$00
	DC.B	$01,$58,$80,$0F,$39,$A0,$00,$00,$00,$00,$00,$13,$32,$46,$00,$00
	DC.B	$00,$00,$80,$0F,$D5,$7A,$0F,$F0,$00,$00,$81,$0F,$12,$40,$00,$00
	DC.B	$00,$00,$41,$0F,$E9,$80,$00,$00,$00,$10,$80,$0F,$A3,$80,$00,$00
	DC.B	$00,$10,$81,$0F,$1F,$20,$00,$00,$00,$00,$C1,$0F,$E6,$80,$00,$00
	DC.B	$00,$00,$80,$0B,$00,$00,$00,$00,$00,$00,$80,$0B,$07,$2E,$00,$00
	DC.B	$00,$00,$80,$0B,$F9,$2E,$00,$00,$00,$00,$00,$0B,$06,$6E,$00,$00
	DC.B	$00,$00,$80,$0F,$CE,$5A,$00,$00,$00,$00,$81,$0F,$15,$5E,$00,$00
	DC.B	$00,$00,$80,$13,$33,$00,$00,$00,$00,$58,$C1,$0F,$E6,$88,$00,$00
	DC.B	$00,$C0,$80,$0F,$36,$E0,$00,$00,$00,$90,$C0,$0F,$9C,$D8,$00,$00
	DC.B	$00,$00,$80,$13,$32,$C0,$00,$00,$00,$00,$80,$0B,$09,$00,$00,$00
	DC.B	$00,$00,$80,$08,$0F,$60,$0A,$36,$00,$88,$00,$60,$12,$04,$00,$00
	DC.B	$FF,$C0,$82,$61,$12,$04,$04,$00,$FF,$A0,$80,$0B,$08,$00,$00,$00
	DC.B	$01,$10,$80,$0A,$F7,$80,$00,$00,$00,$00,$80,$0A,$00,$A0,$08,$00
	DC.B	$00,$00,$80,$0A,$0B,$48,$00,$00,$00,$00,$00,$06,$12,$6A,$00,$00
	DC.B	$00,$00,$C0,$07,$EC,$00,$00,$00,$00,$00,$40,$73,$F1,$5C,$04,$E6
	DC.B	$00,$00,$00,$73,$0D,$BE,$00,$00,$00,$00,$80,$07,$13,$40,$01,$1E
	DC.B	$00,$00,$C0,$73,$F2,$D8,$00,$00,$00,$00,$81,$69,$14,$E0,$00,$00
	DC.B	$00,$00,$80,$73,$0C,$48,$07,$CE,$00,$D4,$80,$09,$13,$CC,$08,$10
	DC.B	$00,$A8,$00,$73,$0B,$68,$00,$00,$01,$40,$80,$07,$17,$00,$09,$26
	DC.B	$01,$D7,$41,$40,$EF,$E0,$00,$00,$00,$00,$C0,$40,$EF,$E0,$08,$00
	DC.B	$FE,$7C,$40,$40,$EF,$E0,$00,$00,$FE,$60,$C0,$40,$EF,$E0,$08,$00
	DC.B	$FE,$64,$40,$40,$EF,$E0,$00,$00,$FE,$F0,$C0,$40,$EF,$E0,$08,$00
	DC.B	$FF,$20,$40,$40,$EF,$E0,$00,$00,$FF,$50,$C0,$40,$EF,$E0,$08,$00
	DC.B	$FF,$68,$40,$40,$EF,$E0,$00,$00,$FF,$80,$C0,$40,$EF,$E0,$08,$00
	DC.B	$FF,$98,$C2,$40,$EF,$E0,$00,$00,$00,$00,$41,$41,$EF,$94,$00,$00
	DC.B	$00,$60,$C0,$41,$EF,$94,$08,$00,$00,$48,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$30,$C0,$41,$EF,$94,$08,$00,$00,$18,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C0,$41,$EF,$94,$08,$00,$00,$00,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C0,$41,$EF,$94,$08,$00,$00,$00,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C0,$41,$EF,$94,$08,$00,$00,$00,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C0,$41,$EF,$94,$08,$00,$00,$00,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C0,$41,$EF,$94,$08,$00,$00,$00,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C0,$41,$EF,$94,$08,$00,$00,$00,$40,$41,$EF,$94,$00,$00
	DC.B	$00,$00,$C2,$41,$EF,$94,$08,$00,$00,$00,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$26,$11,$F4,$0A,$36
	DC.B	$00,$88,$80,$26,$11,$F4,$0A,$36,$00,$88,$80,$13,$32,$C0,$00,$00
	DC.B	$00,$00,$80,$13,$32,$C0,$00,$00,$00,$00,$00,$00,$00,$C0,$04,$80
	DC.B	$B5,$00,$2B,$00,$6B,$20,$AF,$A0,$08,$FF,$44,$FF,$40,$FF,$0C,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$F7,$FF,$FF
	DC.B	$FF,$40,$FF,$10,$F7,$28,$FF,$22,$00,$FF,$10,$FF,$00,$FF,$10,$FF
	DC.B	$80,$00,$00,$00,$00,$01,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$04,$5D,$00,$C9,$F7,$41,$FF,$A2,$FF,$60,$FF,$EE
	DC.B	$00,$00,$00,$00,$04,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FE,$FF
	DC.B	$00,$00,$04,$00,$C6,$00,$80,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FC,$FF
	DC.B	$29,$00,$9F,$00,$FF,$00,$FF,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$02,$00,$00,$00,$BF,$FF,$BB,$FF,$FF,$FF,$FF,$7F
	DC.B	$FB,$00,$31,$04,$EF,$10,$FF,$00,$00,$FF,$00,$FF,$00,$FF,$40,$FF
	DC.B	$00,$FF,$00,$EF,$FE,$FF,$CD,$FF,$21,$00,$08,$00,$60,$00,$43,$00
	DC.B	$9F,$00,$F3,$00,$FF,$00,$FF,$00,$02,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$0F,$23,$6D,$8F,$FF,$FF,$FF,$EF,$04,$00,$A0,$00,$00,$00,$08,$00
	DC.B	$00,$00,$00,$00,$00,$80,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$DA,$16,$00,$0C,$FF,$FF,$FB,$FF,$00,$06,$06,$40,$60,$02,$08,$02
	DC.B	$C0,$00,$C3,$00,$FB,$00,$FF,$00,$20,$FF,$00,$FB,$01,$FF,$F0,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FB,$FF,$FF,$FF,$FF,$FF,$7F
	DC.B	$FF,$10,$FF,$00,$FF,$08,$7F,$00,$00,$BF,$40,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$40,$02,$00,$00,$FF,$FF,$FF,$FB,$BF,$FF,$FF,$FF
	DC.B	$00,$00,$02,$00,$30,$C3,$00,$DF,$FF,$A6,$BF,$42,$FF,$F0,$FF,$C0
	DC.B	$00,$00,$00,$00,$00,$00,$40,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$20,$00,$C9,$10,$80,$00,$AB,$FF,$FA,$FF,$6F,$3E,$FF,$FF
	DC.B	$0C,$00,$87,$40,$FF,$00,$FF,$04,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$11,$00,$FF,$FF,$FE,$FF,$FB,$FF,$FF,$FF
	DC.B	$F8,$00,$63,$09,$FF,$00,$FF,$00,$20,$6D,$00,$DF,$00,$FF,$02,$FF
	DC.B	$00,$FF,$40,$7F,$FA,$FF,$7B,$FF,$04,$00,$80,$00,$04,$00,$08,$00
	DC.B	$5D,$00,$71,$00,$FF,$00,$FF,$00,$00,$FF,$01,$FF,$00,$FF,$20,$FF
	DC.B	$47,$9B,$BD,$DF,$FF,$FF,$FF,$FF,$80,$20,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$01,$00,$00,$00,$00,$FB,$FF,$FF,$BF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$04,$FF,$FF,$FF,$F3,$FE,$FF,$FF,$FF
	DC.B	$64,$18,$55,$B7,$FF,$FF,$DF,$9F,$04,$00,$08,$80,$00,$00,$08,$22
	DC.B	$01,$00,$89,$00,$FF,$00,$7F,$00,$42,$FF,$02,$FF,$00,$7F,$41,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FD,$FF,$FF,$EF,$FF,$FF,$FF
	DC.B	$FB,$00,$FF,$88,$FF,$00,$FF,$00,$00,$FF,$00,$FF,$00,$FF,$00,$F3
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$DF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$61,$61,$B1,$F7,$9C,$FF,$02,$FF,$43,$FF,$02
	DC.B	$00,$00,$00,$00,$00,$00,$01,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$20,$00,$80,$00,$00,$01,$00,$00,$BF,$FF,$DF,$FF,$FF,$FF,$FF,$FF
	DC.B	$6F,$00,$4D,$02,$FF,$00,$DF,$00,$00,$FF,$20,$FF,$00,$F7,$00,$FF
	DC.B	$00,$00,$00,$00,$12,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FB
	DC.B	$2D,$0E,$F7,$10,$FF,$00,$FF,$00,$00,$5D,$00,$BF,$08,$FF,$00,$FF
	DC.B	$00,$DF,$00,$FB,$FC,$FF,$54,$FF,$52,$00,$8B,$00,$02,$00,$06,$00
	DC.B	$84,$00,$8D,$00,$EF,$00,$F7,$00,$C8,$FF,$00,$FF,$04,$FF,$00,$FF
	DC.B	$CC,$03,$FD,$F1,$FF,$FF,$F7,$FF,$04,$00,$00,$02,$00,$08,$08,$10
	DC.B	$00,$00,$00,$00,$00,$02,$00,$60,$FF,$FF,$FF,$BF,$FF,$7F,$FF,$5F
