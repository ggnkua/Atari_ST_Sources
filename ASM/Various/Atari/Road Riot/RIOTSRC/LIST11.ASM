
* File name = list11.intel

* Previously loaded at $F000

	DC.B	$00,$0D,$FF,$FF,$27,$FF,$FF,$53,$FF,$FF,$FF,$02,$FF,$03,$FF,$04
	DC.B	$FF,$05,$FF,$06,$FF,$08,$FF,$0A,$FF,$0B,$FF,$FF,$FF,$38,$10,$14
	DC.B	$18,$1C,$20,$4D,$FF,$FF,$3B,$3D,$FF,$FF,$24,$25,$26,$FF,$54,$FF
	DC.B	$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$55,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$FF,$FF,$FF,$29,$FF,$31,$2A,$32,$FF,$2B,$FF,$33,$FF,$FF,$34
	DC.B	$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$4E,$FF,$4F,$FF,$50
	DC.B	$FF,$FF,$FF,$FF,$FF,$FF,$FF,$01,$35,$FF,$36,$FF,$37,$FF,$FF,$FF
	DC.B	$FF,$FF,$39,$3E,$FF,$FF,$0C,$FF,$FF,$FF,$FF,$51,$FF,$FF,$FF,$FF
	DC.B	$3F,$43,$FF,$FF,$46,$48,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$4B,$2D,$2E
	DC.B	$00,$56,$80,$04,$F5,$00,$0C,$00,$00,$00,$80,$74,$00,$46,$02,$3C
	DC.B	$00,$00,$81,$80,$10,$82,$00,$00,$00,$00,$81,$80,$12,$8A,$00,$00
	DC.B	$00,$00,$81,$80,$11,$9E,$00,$00,$00,$00,$81,$80,$0F,$5E,$00,$00
	DC.B	$00,$00,$01,$80,$0F,$5E,$00,$00,$01,$60,$80,$1C,$79,$AE,$00,$00
	DC.B	$01,$60,$01,$80,$0F,$5E,$00,$00,$02,$60,$80,$1C,$79,$76,$00,$00
	DC.B	$02,$60,$81,$80,$0F,$5E,$00,$00,$02,$00,$81,$80,$0F,$5E,$00,$00
	DC.B	$00,$E8,$80,$71,$33,$20,$00,$00,$00,$00,$00,$77,$11,$24,$07,$90
	DC.B	$00,$00,$40,$77,$EF,$96,$05,$6E,$00,$00,$C0,$71,$D2,$14,$0C,$BA
	DC.B	$00,$00,$40,$6C,$E1,$3C,$00,$00,$00,$00,$41,$46,$F0,$C4,$04,$00
	DC.B	$FD,$D6,$40,$46,$F0,$C4,$08,$00,$FD,$D4,$C0,$46,$F0,$C4,$0C,$00
	DC.B	$FD,$D2,$40,$46,$F0,$C4,$00,$00,$FD,$D0,$40,$46,$F0,$C4,$04,$00
	DC.B	$FD,$D4,$40,$46,$F0,$C4,$08,$00,$FD,$D8,$C0,$46,$F0,$C4,$0C,$00
	DC.B	$FD,$DC,$40,$46,$F0,$C4,$00,$00,$FD,$E0,$40,$46,$F0,$C4,$04,$00
	DC.B	$FD,$E0,$40,$46,$F0,$C4,$08,$00,$FD,$E0,$C0,$46,$F0,$C4,$0C,$00
	DC.B	$FD,$E0,$40,$46,$F0,$C4,$00,$00,$FD,$E0,$40,$46,$F0,$C4,$04,$00
	DC.B	$FD,$F0,$40,$46,$F0,$C4,$08,$00,$FE,$00,$C0,$46,$F0,$C4,$0C,$00
	DC.B	$FE,$10,$40,$46,$F0,$C4,$00,$00,$FE,$20,$40,$46,$F0,$C4,$04,$00
	DC.B	$FE,$2C,$40,$46,$F0,$C4,$08,$00,$FE,$38,$C2,$46,$F0,$C4,$0C,$00
	DC.B	$FE,$44,$80,$74,$00,$00,$08,$00,$00,$24,$80,$74,$00,$00,$08,$00
	DC.B	$FF,$E8,$80,$74,$00,$00,$08,$00,$FF,$88,$00,$77,$0E,$C2,$00,$00
	DC.B	$00,$00,$80,$71,$3C,$F4,$0B,$AE,$00,$00,$81,$80,$12,$80,$00,$00
	DC.B	$00,$00,$81,$80,$12,$1E,$00,$00,$00,$00,$01,$80,$10,$B6,$0E,$8E
	DC.B	$00,$00,$80,$51,$00,$00,$00,$00,$00,$00,$81,$80,$11,$AE,$00,$00
	DC.B	$00,$00,$01,$3A,$14,$70,$00,$00,$00,$00,$00,$77,$0D,$0E,$09,$20
	DC.B	$00,$00,$C0,$77,$F0,$40,$04,$DE,$00,$00,$80,$51,$00,$00,$00,$00
	DC.B	$00,$00,$80,$51,$00,$00,$00,$00,$00,$00,$80,$51,$00,$00,$00,$00
	DC.B	$FF,$C0,$80,$2C,$F0,$F6,$0B,$9C,$00,$00,$80,$74,$00,$46,$02,$3C
	DC.B	$00,$0A,$80,$74,$00,$46,$02,$3C,$00,$0F,$80,$74,$00,$46,$02,$3C
	DC.B	$FE,$B6,$C0,$6F,$CB,$FC,$0F,$E6,$00,$00,$00,$0E,$0A,$76,$05,$7E
	DC.B	$00,$00,$80,$0E,$0A,$76,$0D,$7E,$FF,$39,$00,$13,$33,$40,$00,$00
	DC.B	$00,$A0,$80,$77,$0C,$B6,$00,$00,$00,$A0,$80,$80,$10,$5A,$0F,$F0
	DC.B	$00,$00,$80,$0E,$0A,$76,$05,$7E,$FF,$AF,$00,$0D,$0C,$C0,$00,$00
	DC.B	$00,$00,$00,$0D,$0C,$C0,$08,$00,$FF,$60,$00,$0D,$F3,$24,$00,$00
	DC.B	$00,$00,$80,$0D,$F3,$24,$08,$00,$FF,$60,$00,$0D,$0C,$C0,$00,$00
	DC.B	$FF,$E0,$00,$0D,$F3,$24,$00,$00,$FF,$E0,$80,$0D,$F3,$24,$08,$00
	DC.B	$00,$0C,$00,$0E,$0A,$80,$04,$FE,$00,$00,$80,$0E,$0A,$80,$0C,$FE
	DC.B	$FF,$A2,$00,$0E,$0A,$80,$04,$FE,$FF,$F2,$00,$0E,$0A,$80,$0C,$FE
	DC.B	$00,$36,$C0,$77,$F1,$2C,$00,$00,$00,$00,$00,$51,$00,$00,$00,$00
	DC.B	$00,$00,$80,$77,$0E,$82,$00,$00,$00,$50,$80,$14,$31,$10,$07,$EE
	DC.B	$00,$00,$81,$80,$12,$40,$00,$00,$00,$00,$81,$80,$12,$40,$00,$00
	DC.B	$FF,$80,$81,$80,$12,$40,$00,$00,$00,$00,$01,$80,$13,$00,$00,$00
	DC.B	$00,$18,$80,$13,$2E,$96,$0B,$F8,$00,$A1,$C0,$6B,$D2,$D4,$00,$00
	DC.B	$00,$00,$80,$80,$12,$AE,$07,$6E,$00,$3F,$80,$2C,$0C,$B0,$00,$00
	DC.B	$00,$00,$80,$2C,$0C,$B0,$00,$00,$00,$00,$FF,$00,$FF,$00,$FF,$00
	DC.B	$00,$00,$00,$00,$00,$04,$00,$02,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$BF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$04,$00,$60,$04,$8C,$00,$FB,$FF,$D7,$FF,$FF,$FF,$DD,$FF
	DC.B	$00,$01,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$7F,$FE,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$80,$00,$00,$00,$01,$C0,$40,$FF,$FF,$FF,$FE,$FF,$DF,$FF,$FF
	DC.B	$00,$04,$00,$00,$00,$16,$00,$21,$FF,$FD,$DF,$59,$FF,$7D,$55,$DF
	DC.B	$22,$00,$20,$00,$40,$10,$10,$00,$FF,$F7,$FF,$FF,$FF,$FD,$FF,$FF
	DC.B	$00,$00,$00,$40,$00,$00,$00,$00,$FD,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$20,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$6F,$FF
	DC.B	$00,$FB,$00,$DF,$00,$FF,$02,$F7,$FF,$08,$FF,$2C,$FF,$24,$FF,$28
	DC.B	$00,$00,$00,$00,$00,$08,$00,$00,$FF,$FF,$FF,$FF,$FF,$DF,$BB,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$40,$00,$FF,$FF,$FE,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$00,$00,$FF,$FF,$FF,$FF,$BF,$FF,$FF,$AA
	DC.B	$08,$FF,$00,$7F,$40,$FF,$00,$9F,$FF,$00,$FF,$A0,$FF,$00,$FF,$02
	DC.B	$00,$00,$00,$01,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$04,$80,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$40,$00,$80,$00,$87,$00,$89,$00,$FF,$FF,$76,$FF,$6F,$FF,$7E,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$02,$08,$49,$00,$67,$10,$FC,$00,$FF,$FF,$B7,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$B8,$00,$08,$00,$E0,$00,$48,$FF,$B2,$FF,$EB,$FF,$DB,$55,$D7
	DC.B	$80,$00,$00,$00,$00,$00,$00,$00,$7F,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$08,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$EF,$FF
	DC.B	$02,$7F,$00,$FF,$04,$FF,$00,$FF,$FD,$20,$FB,$00,$FF,$21,$FF,$00
	DC.B	$02,$00,$00,$00,$00,$80,$00,$04,$FF,$BF,$FF,$FD,$FF,$DF,$FF,$BF
	DC.B	$00,$00,$00,$00,$00,$02,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$08,$00,$00,$00,$00,$02,$02,$00,$FF,$FF,$9F,$FF,$F7,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$BF,$DF,$7F,$FF,$F7,$AA
	DC.B	$00,$FF,$00,$7F,$00,$BF,$00,$FF,$FF,$00,$FF,$00,$FF,$40,$FF,$00
	DC.B	$00,$00,$20,$00,$00,$00,$00,$01,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$02,$00,$7F,$FF,$FF,$FF,$F7,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$02,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$02,$00,$00,$02,$FF,$FF,$FF,$FE,$FF,$FF,$FF,$FF
	DC.B	$42,$00,$21,$20,$00,$40,$00,$30,$F9,$FF,$FF,$F7,$FF,$9B,$F7,$FF
	DC.B	$00,$82,$00,$01,$00,$84,$00,$00,$FF,$BF,$FF,$DC,$FF,$BA,$55,$D5
	DC.B	$08,$00,$00,$00,$00,$00,$00,$80,$DD,$FF,$FF,$FF,$EF,$FF,$FF,$BF
	DC.B	$00,$00,$00,$00,$00,$00,$40,$00,$FE,$FE,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$08,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FE,$FF,$BF,$FF
	DC.B	$00,$FF,$00,$FF,$20,$FF,$00,$FF,$FF,$00,$FF,$00,$FF,$00,$FD,$11
	DC.B	$80,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$F9,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$EF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$81,$00,$80,$00,$BF,$FF,$FF,$FF,$FF,$FF,$BF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$DF,$FF,$DF,$FF,$7F,$AA
	DC.B	$20,$FC,$00,$F7,$00,$CF,$00,$3F,$FF,$00,$7F,$00,$FF,$20,$FF,$03
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$F7,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$20,$00,$00,$00,$00,$FF,$FF,$DF,$FF,$FF,$FF,$FF,$FF
	DC.B	$20,$00,$00,$00,$2C,$00,$29,$00,$FF,$FF,$DA,$FF,$FF,$FF,$F7,$FF
	DC.B	$00,$00,$00,$00,$00,$08,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$20,$00,$FF,$FF,$7B,$FD,$FF,$FF,$EF,$FF
	DC.B	$00,$00,$00,$00,$BD,$00,$20,$40,$CF,$AF,$E4,$FF,$FF,$FF,$FF,$CA
	DC.B	$00,$00,$00,$00,$00,$84,$00,$60,$FB,$FD,$FF,$3B,$FF,$FF,$55,$7D
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$EF,$FF,$7F,$FF,$FF,$FF,$FF,$FF
	DC.B	$80,$00,$00,$00,$60,$00,$04,$00,$FF,$FF,$FF,$FF,$FF,$FB,$7F,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$01,$FE,$00,$FF,$80,$FF,$00,$FF,$FF,$02,$FF,$00,$FF,$06,$F7,$20
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$DF,$FF,$FF,$FF,$FE,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$02,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FD,$FF
	DC.B	$00,$00,$81,$00,$28,$00,$02,$00,$FE,$FF,$FF,$FF,$FF,$FF,$FF,$FD
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$BF,$FF,$FF,$FF,$FF,$FF,$FF,$AA
	DC.B	$00,$FF,$00,$7F,$08,$FF,$00,$FF,$FF,$40,$FF,$04,$FF,$00,$FF,$20
	DC.B	$00,$00,$00,$00,$80,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$DF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$EF,$FF,$FF,$FF,$FF
	DC.B	$80,$08,$08,$00,$00,$00,$00,$00,$DF,$FF,$FC,$FF,$E7,$FF,$BF,$FF
	DC.B	$00,$80,$00,$00,$00,$00,$00,$00,$FF,$FB,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$40,$00,$00,$00,$EF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$09,$10,$09,$00,$00,$20,$FD,$FF,$EC,$FF,$FB,$FB,$FF,$FF
	DC.B	$00,$01,$00,$00,$01,$00,$00,$41,$FF,$FE,$FF,$FC,$FF,$F7,$55,$DD
	DC.B	$00,$00,$00,$80,$04,$10,$00,$00,$FB,$FD,$FF,$F7,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$20,$00,$10,$00,$B5,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$22,$00,$10,$00,$FE,$FF,$FF,$FF,$7F,$FF,$F7,$FF
	DC.B	$00,$FF,$00,$FF,$42,$FF,$40,$DF,$FB,$00,$FF,$20,$FF,$00,$FF,$00
