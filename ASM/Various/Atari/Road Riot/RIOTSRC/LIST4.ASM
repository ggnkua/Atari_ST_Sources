
* File name = list4.intel

* Previously loaded at $B800

	DC.B	$0D,$45,$49,$5E,$00,$4E,$2D,$FF,$2F,$FF,$53,$FF,$30,$FF,$31,$FF
	DC.B	$32,$5D,$FF,$FF,$33,$FF,$25,$FF,$60,$28,$FF,$FF,$2B,$FF,$FF,$FF
	DC.B	$35,$39,$37,$2A,$38,$34,$FF,$02,$FF,$03,$FF,$05,$FF,$07,$FF,$4F
	DC.B	$08,$FF,$FF,$13,$FF,$0E,$0F,$FF,$10,$FF,$12,$FF,$FF,$14,$FF,$15
	DC.B	$16,$17,$FF,$09,$FF,$FF,$3A,$FF,$5F,$27,$FF,$3B,$FF,$0A,$58,$5A
	DC.B	$59,$FF,$0B,$FF,$54,$FF,$FF,$0C,$FF,$FF,$19,$1B,$1F,$21,$23,$FF
	DC.B	$FF,$4A,$FF,$52,$FF,$4B,$51,$4C,$50,$4D,$FF,$5B,$FF,$5C,$FF,$57
	DC.B	$3C,$FF,$3D,$FF,$FF,$3E,$FF,$3F,$FF,$40,$FF,$42,$FF,$61,$FF,$62
	DC.B	$00,$63,$80,$14,$32,$9A,$00,$00,$00,$00,$80,$3F,$EC,$70,$0A,$BE
	DC.B	$00,$00,$80,$1C,$34,$D0,$00,$00,$00,$00,$C0,$1C,$9E,$50,$00,$00
	DC.B	$00,$00,$80,$1C,$B8,$20,$0B,$36,$00,$00,$40,$1C,$CE,$50,$00,$00
	DC.B	$FF,$E0,$80,$1C,$8C,$F0,$0F,$F0,$00,$00,$80,$14,$33,$F0,$00,$00
	DC.B	$00,$00,$80,$1C,$CF,$F8,$00,$00,$00,$00,$80,$14,$32,$E2,$00,$00
	DC.B	$01,$30,$80,$14,$32,$00,$00,$00,$01,$30,$80,$14,$32,$0E,$00,$00
	DC.B	$01,$20,$80,$14,$32,$10,$00,$00,$01,$20,$80,$04,$F5,$00,$0C,$00
	DC.B	$00,$00,$80,$1C,$3F,$98,$00,$00,$00,$20,$80,$30,$27,$DC,$00,$00
	DC.B	$00,$30,$00,$1D,$E3,$D2,$00,$00,$00,$50,$80,$1C,$48,$34,$0F,$F0
	DC.B	$00,$40,$80,$1C,$48,$34,$0F,$F0,$00,$20,$80,$14,$30,$FE,$00,$00
	DC.B	$00,$00,$80,$1C,$48,$A0,$00,$00,$00,$00,$C0,$1C,$45,$EE,$00,$00
	DC.B	$00,$00,$80,$1C,$30,$00,$00,$00,$00,$00,$01,$59,$13,$3C,$00,$00
	DC.B	$00,$00,$80,$0B,$00,$00,$00,$00,$00,$00,$00,$0B,$02,$A8,$00,$00
	DC.B	$00,$00,$80,$0B,$FC,$8E,$07,$90,$00,$00,$00,$0B,$FD,$D0,$00,$00
	DC.B	$00,$00,$00,$0B,$01,$EC,$04,$00,$00,$00,$00,$0B,$00,$00,$0C,$00
	DC.B	$00,$00,$81,$59,$16,$10,$00,$00,$00,$00,$00,$0B,$00,$00,$04,$00
	DC.B	$00,$00,$80,$0B,$02,$3E,$0C,$6C,$00,$00,$00,$0B,$00,$00,$04,$00
	DC.B	$00,$00,$80,$0B,$FC,$DE,$0C,$00,$00,$00,$00,$0B,$02,$F6,$05,$B8
	DC.B	$00,$00,$80,$14,$31,$20,$00,$00,$00,$00,$01,$59,$13,$88,$00,$00
	DC.B	$01,$90,$80,$14,$33,$44,$00,$00,$01,$80,$80,$2C,$00,$16,$00,$00
	DC.B	$00,$00,$00,$19,$11,$A2,$00,$00,$02,$98,$80,$19,$ED,$CC,$00,$12
	DC.B	$02,$97,$C0,$5A,$16,$94,$00,$00,$00,$00,$01,$1D,$15,$B4,$00,$00
	DC.B	$01,$60,$C1,$1D,$EF,$10,$00,$00,$01,$60,$40,$5F,$EA,$5A,$06,$9E
	DC.B	$00,$00,$81,$3B,$E1,$DC,$00,$00,$00,$00,$81,$59,$18,$40,$00,$00
	DC.B	$00,$C0,$80,$14,$33,$44,$00,$00,$00,$00,$80,$14,$33,$44,$0B,$6C
	DC.B	$00,$00,$81,$1D,$14,$DC,$00,$00,$00,$00,$80,$14,$33,$44,$00,$00
	DC.B	$00,$78,$80,$14,$30,$6E,$00,$00,$00,$00,$00,$1C,$8F,$60,$0F,$F0
	DC.B	$00,$00,$80,$1C,$3B,$3C,$0F,$F0,$00,$00,$80,$1C,$79,$E0,$0F,$F0
	DC.B	$00,$00,$80,$14,$32,$A0,$0F,$F0,$00,$00,$81,$30,$1B,$7A,$0F,$00
	DC.B	$00,$00,$80,$14,$33,$0E,$00,$00,$00,$00,$80,$14,$32,$E8,$00,$00
	DC.B	$00,$00,$80,$14,$2F,$68,$00,$00,$00,$00,$81,$59,$17,$C0,$00,$00
	DC.B	$00,$00,$80,$14,$2A,$80,$00,$00,$00,$00,$80,$0A,$07,$38,$00,$00
	DC.B	$00,$00,$00,$1C,$35,$AE,$00,$00,$00,$00,$80,$0A,$06,$38,$00,$00
	DC.B	$00,$00,$00,$1C,$CF,$2E,$00,$00,$00,$00,$00,$0A,$06,$A8,$00,$00
	DC.B	$00,$00,$80,$1C,$3C,$00,$0C,$B6,$00,$00,$01,$57,$11,$BA,$00,$00
	DC.B	$00,$00,$00,$57,$11,$C0,$04,$00,$00,$00,$00,$57,$11,$C0,$08,$00
	DC.B	$00,$00,$82,$57,$11,$C0,$0C,$00,$00,$00,$C0,$78,$F1,$8C,$04,$00
	DC.B	$00,$00,$80,$14,$31,$78,$00,$00,$00,$48,$80,$14,$32,$20,$00,$00
	DC.B	$00,$00,$80,$14,$32,$20,$00,$00,$00,$00,$80,$14,$32,$20,$00,$00
	DC.B	$00,$00,$81,$38,$1B,$00,$00,$00,$00,$00,$80,$1C,$AB,$C0,$00,$00
	DC.B	$00,$00,$80,$2B,$F7,$82,$00,$00,$00,$00,$80,$2B,$05,$80,$00,$00
	DC.B	$00,$00,$80,$2B,$08,$F2,$00,$00,$00,$00,$80,$0B,$00,$00,$00,$00
	DC.B	$00,$00,$00,$0B,$00,$00,$00,$00,$00,$00,$00,$0A,$04,$00,$05,$3C
	DC.B	$00,$00,$80,$0A,$02,$4E,$00,$00,$00,$00,$80,$0B,$F9,$28,$00,$00
	DC.B	$00,$00,$80,$0B,$04,$80,$00,$00,$00,$08,$80,$2B,$F3,$C0,$00,$00
	DC.B	$00,$00,$81,$30,$15,$40,$00,$00,$00,$00,$80,$4D,$C6,$40,$00,$00
	DC.B	$00,$00,$C0,$1C,$B2,$62,$00,$00,$00,$00,$80,$1C,$3F,$0C,$0E,$7E
	DC.B	$00,$00,$80,$5F,$19,$50,$00,$00,$00,$00,$81,$65,$11,$8E,$00,$00
	DC.B	$01,$30,$80,$5F,$17,$62,$00,$00,$02,$68,$80,$1C,$C7,$E2,$09,$3A
	DC.B	$00,$00,$80,$1C,$CA,$26,$00,$00,$00,$00,$80,$5F,$17,$62,$00,$00
	DC.B	$02,$68,$80,$5F,$17,$62,$00,$00,$02,$68,$80,$65,$11,$8E,$00,$00
	DC.B	$01,$30,$80,$65,$11,$8E,$00,$00,$01,$30,$80,$65,$11,$8E,$00,$00
	DC.B	$01,$30,$80,$65,$11,$8E,$00,$00,$01,$30,$80,$65,$11,$8E,$00,$00
	DC.B	$01,$30,$80,$65,$11,$8E,$00,$00,$01,$30,$80,$65,$11,$8E,$00,$00
	DC.B	$01,$30,$80,$00,$00,$00,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$5F,$16,$42,$00,$00,$00,$00,$80,$5F,$16,$42,$00,$00
	DC.B	$00,$00,$80,$1C,$3F,$0C,$0E,$7E,$00,$00,$80,$1C,$3F,$0C,$0E,$7E
	DC.B	$00,$00,$80,$1C,$3F,$0C,$0E,$7E,$00,$00,$80,$1C,$3F,$0C,$0E,$7E
	DC.B	$00,$00,$80,$1C,$3F,$0C,$0E,$7E,$00,$00,$80,$1C,$3F,$0C,$0E,$7E
	DC.B	$00,$00,$80,$1C,$3F,$0C,$0E,$7E,$00,$00,$80,$30,$15,$40,$00,$00
	DC.B	$00,$00,$80,$30,$15,$40,$00,$00,$00,$00,$80,$30,$15,$40,$00,$00
	DC.B	$00,$00,$80,$30,$15,$40,$00,$00,$00,$00,$80,$30,$15,$40,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$80,$36,$21,$00,$00,$00
	DC.B	$00,$00,$80,$36,$21,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$BF
	DC.B	$C1,$60,$11,$D2,$FF,$FF,$BC,$AF,$00,$0A,$01,$00,$0A,$10,$82,$00
	DC.B	$F3,$00,$D6,$00,$FF,$00,$FB,$00,$20,$FF,$02,$EF,$0B,$FF,$84,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$10,$FF,$FF,$FF,$FD,$FF,$FF,$FF,$F9
	DC.B	$FF,$40,$FF,$18,$FD,$00,$FF,$00,$00,$FF,$10,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$08,$C4,$00,$80,$00,$00,$FF,$FF,$FF,$FF,$EF,$FF,$FF,$FF
	DC.B	$00,$11,$00,$10,$00,$E5,$00,$BF,$7F,$24,$FF,$22,$BF,$88,$FB,$00
	DC.B	$00,$00,$80,$00,$08,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$88,$00,$C8,$00,$D5,$00,$3F,$BF,$F7,$F7,$FD,$FE,$EF,$BF
	DC.B	$39,$00,$53,$10,$FF,$00,$FF,$00,$00,$FB,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$19,$00,$FF,$FF,$F8,$FF,$AF,$FF,$FE,$FF
	DC.B	$1D,$00,$65,$00,$FF,$09,$FF,$95,$00,$AF,$00,$DF,$08,$FF,$00,$BF
	DC.B	$00,$F6,$00,$FD,$FB,$FF,$D5,$FF,$16,$00,$09,$00,$03,$00,$22,$00
	DC.B	$36,$00,$19,$00,$DF,$00,$FF,$00,$20,$FF,$00,$FF,$00,$FF,$10,$FF
	DC.B	$DF,$2A,$53,$D3,$FF,$FF,$FF,$FF,$02,$00,$40,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$80,$00,$00,$FF,$7F,$FF,$FF,$FF,$EF,$FF,$FF
	DC.B	$00,$00,$00,$A0,$00,$00,$00,$02,$FF,$FF,$FF,$F7,$FF,$FF,$FF,$FF
	DC.B	$80,$FA,$00,$D7,$FF,$DF,$FF,$FF,$00,$00,$02,$01,$08,$00,$00,$00
	DC.B	$A0,$00,$2F,$00,$FF,$00,$FF,$40,$09,$FF,$00,$FF,$80,$FF,$10,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FE,$FE
	DC.B	$FB,$00,$FF,$00,$FF,$00,$FE,$09,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$40,$20,$FF,$FF,$FB,$AF,$7E,$FF,$FF,$BD
	DC.B	$00,$10,$00,$00,$14,$87,$00,$7D,$FF,$F6,$DF,$48,$FF,$07,$FF,$EE
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$61,$00,$01,$00,$FF,$FF,$FF,$FF,$F7,$FF,$FF,$FF
	DC.B	$01,$00,$77,$00,$FF,$00,$FF,$00,$00,$FE,$20,$DF,$00,$FF,$00,$FD
	DC.B	$00,$00,$00,$00,$00,$00,$41,$00,$FE,$FF,$FE,$FF,$FF,$FF,$DF,$FF
	DC.B	$6F,$40,$BA,$00,$FF,$04,$FF,$80,$00,$FF,$00,$FB,$40,$FF,$00,$BF
	DC.B	$00,$FB,$40,$FF,$FF,$FF,$F1,$FF,$24,$00,$04,$00,$04,$00,$09,$00
	DC.B	$9C,$00,$9C,$00,$FF,$00,$7F,$00,$40,$FF,$00,$FF,$2A,$FF,$02,$FF
	DC.B	$5D,$6C,$03,$4B,$FE,$FF,$FF,$FF,$80,$00,$80,$00,$01,$00,$40,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$EF,$FF,$D7,$FF,$FF,$FF,$FB
