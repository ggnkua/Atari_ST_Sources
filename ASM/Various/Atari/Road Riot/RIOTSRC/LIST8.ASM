
* File name = list8.intel

* Previously loaded at $D800

	DC.B	$00,$4A,$3D,$FF,$FF,$41,$28,$FF,$FF,$FF,$09,$0D,$0B,$08,$2B,$FF
	DC.B	$0C,$07,$FF,$42,$FF,$FF,$FF,$FF,$43,$FF,$FF,$FF,$FF,$FF,$FF,$2C
	DC.B	$FF,$FF,$FF,$03,$04,$05,$FF,$FF,$FF,$FF,$2D,$FF,$2F,$FF,$FF,$FF
	DC.B	$FF,$30,$FF,$FF,$FF,$40,$FF,$FF,$FF,$FF,$31,$33,$34,$35,$36,$FF
	DC.B	$FF,$FF,$37,$38,$FF,$1A,$FF,$FF,$15,$FF,$FF,$1D,$FF,$FF,$FF,$FF
	DC.B	$FF,$1F,$FF,$FF,$FF,$45,$FF,$FF,$0E,$10,$11,$0F,$12,$13,$FF,$FF
	DC.B	$FF,$21,$FF,$FF,$48,$FF,$FF,$FF,$FF,$FF,$23,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$17,$FF,$FF,$FF,$FF,$FF,$FF,$39,$FF,$3A,$FF,$FF,$FF,$3B,$44
	DC.B	$00,$4D,$00,$04,$F5,$00,$0C,$02,$00,$00,$00,$6D,$1D,$DC,$00,$00
	DC.B	$00,$00,$81,$46,$10,$4E,$0C,$D0,$00,$00,$80,$0B,$05,$26,$00,$00
	DC.B	$00,$00,$80,$0B,$FB,$D0,$00,$00,$00,$00,$00,$0B,$FB,$D8,$00,$00
	DC.B	$00,$00,$80,$0B,$FA,$80,$0F,$F0,$00,$00,$80,$0A,$05,$00,$00,$00
	DC.B	$00,$40,$80,$0A,$04,$92,$00,$00,$00,$00,$00,$0A,$03,$20,$00,$00
	DC.B	$00,$00,$80,$13,$32,$00,$0C,$3A,$00,$00,$80,$0A,$FB,$F6,$00,$00
	DC.B	$00,$00,$80,$0B,$00,$00,$00,$00,$00,$00,$80,$0B,$00,$00,$00,$00
	DC.B	$00,$00,$80,$0B,$00,$00,$00,$00,$00,$00,$80,$0B,$00,$00,$00,$00
	DC.B	$00,$00,$80,$0B,$00,$00,$00,$00,$00,$00,$80,$0B,$00,$00,$00,$00
	DC.B	$00,$00,$80,$0B,$00,$00,$00,$00,$00,$00,$00,$0B,$00,$00,$07,$10
	DC.B	$00,$00,$80,$2C,$00,$00,$0E,$28,$00,$00,$00,$5D,$16,$80,$00,$00
	DC.B	$00,$00,$80,$13,$31,$8A,$0C,$46,$00,$DC,$01,$3B,$13,$24,$00,$00
	DC.B	$00,$00,$40,$5F,$E9,$D4,$00,$00,$00,$00,$C0,$78,$F0,$0E,$00,$00
	DC.B	$00,$00,$40,$6E,$C3,$2C,$05,$6E,$00,$7A,$40,$5F,$EE,$B2,$01,$9C
	DC.B	$00,$41,$C0,$79,$F5,$84,$00,$00,$00,$28,$00,$5D,$19,$00,$00,$00
	DC.B	$00,$00,$80,$13,$34,$7C,$0F,$F0,$00,$D7,$00,$28,$EE,$48,$0B,$3E
	DC.B	$00,$00,$80,$0B,$00,$00,$0F,$F0,$00,$00,$00,$09,$F4,$FC,$0B,$EA
	DC.B	$01,$C4,$80,$08,$0B,$9C,$0B,$42,$01,$B9,$00,$08,$00,$00,$04,$BE
	DC.B	$00,$00,$00,$5B,$14,$1C,$00,$96,$00,$00,$00,$5B,$15,$06,$04,$86
	DC.B	$00,$00,$00,$5B,$14,$76,$09,$9E,$00,$00,$80,$5B,$14,$60,$0F,$F0
	DC.B	$00,$00,$00,$5F,$10,$C2,$00,$00,$00,$00,$00,$0A,$F6,$80,$0F,$F0
	DC.B	$00,$00,$80,$5D,$19,$C0,$0A,$A4,$00,$00,$80,$5D,$18,$BE,$00,$00
	DC.B	$00,$E8,$80,$5D,$18,$C0,$00,$00,$00,$38,$00,$5D,$14,$EA,$00,$00
	DC.B	$00,$00,$80,$4B,$BD,$C8,$0F,$F0,$00,$00,$80,$4B,$29,$A4,$0F,$F0
	DC.B	$00,$00,$80,$33,$26,$78,$0F,$F0,$00,$00,$00,$2C,$FB,$40,$00,$00
	DC.B	$00,$00,$80,$5D,$18,$70,$00,$00,$00,$00,$80,$5D,$18,$70,$00,$00
	DC.B	$00,$00,$80,$5D,$18,$70,$00,$00,$00,$00,$80,$5D,$18,$70,$00,$00
	DC.B	$00,$00,$80,$5D,$18,$70,$00,$00,$00,$00,$80,$5D,$16,$48,$00,$00
	DC.B	$00,$00,$80,$35,$B7,$00,$0F,$F0,$00,$00,$80,$08,$F7,$5C,$00,$00
	DC.B	$00,$00,$80,$08,$0A,$A4,$00,$00,$00,$00,$00,$08,$09,$82,$00,$00
	DC.B	$00,$00,$81,$3D,$E6,$00,$00,$00,$00,$00,$01,$36,$1C,$6C,$0F,$F0
	DC.B	$00,$3F,$40,$5F,$F1,$FA,$00,$00,$00,$00,$C0,$78,$F2,$A2,$08,$7E
	DC.B	$00,$20,$80,$5D,$19,$FE,$00,$00,$01,$40,$C1,$3E,$ED,$86,$07,$2E
	DC.B	$00,$00,$80,$5D,$18,$AC,$00,$00,$00,$C0,$80,$5D,$17,$DC,$00,$00
	DC.B	$02,$40,$C0,$5F,$F1,$98,$00,$00,$00,$00,$00,$78,$0E,$9C,$00,$00
	DC.B	$00,$00,$00,$79,$11,$26,$04,$BE,$00,$00,$80,$39,$20,$B6,$0F,$F0
	DC.B	$00,$0F,$00,$5D,$19,$00,$00,$00,$00,$00,$80,$4B,$25,$B4,$0C,$7C
	DC.B	$00,$3E,$40,$78,$F0,$7C,$06,$D0,$00,$00,$00,$46,$10,$4E,$00,$D0
	DC.B	$00,$00,$82,$46,$10,$4E,$04,$D0,$00,$00,$00,$00,$01,$02,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$7F,$F9,$FF,$FF
	DC.B	$00,$00,$00,$4C,$40,$10,$00,$00,$FF,$FF,$FF,$FD,$FF,$FF,$FF,$7F
	DC.B	$24,$6A,$90,$CB,$FF,$FF,$EF,$CF,$20,$20,$00,$20,$00,$02,$00,$0A
	DC.B	$04,$00,$20,$00,$77,$20,$B3,$04,$00,$FF,$0E,$FF,$00,$FD,$A4,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$80,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$E7
	DC.B	$FF,$01,$DF,$00,$FF,$00,$FF,$60,$00,$FD,$00,$FF,$00,$FF,$00,$7F
	DC.B	$00,$80,$00,$00,$00,$00,$40,$00,$BF,$FF,$FF,$BB,$FF,$FE,$FF,$FD
	DC.B	$08,$10,$40,$00,$04,$77,$40,$67,$FF,$3A,$FF,$80,$FF,$CF,$FF,$0A
	DC.B	$00,$00,$10,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$12,$00,$00,$00,$BF,$7F,$7F,$FF,$BF,$FF,$EB,$FE
	DC.B	$16,$00,$5F,$10,$FF,$00,$FF,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$10,$00,$FF,$FB,$FD,$FF,$EE,$FF,$FF,$F7
	DC.B	$5F,$48,$EC,$20,$FF,$00,$FF,$80,$00,$7A,$00,$BF,$04,$FF,$00,$FF
	DC.B	$00,$FD,$00,$FF,$EE,$FF,$FF,$FF,$C7,$00,$00,$00,$5A,$00,$4E,$00
	DC.B	$CA,$00,$5A,$00,$7F,$00,$FF,$00,$00,$FF,$02,$FF,$04,$FF,$80,$FF
	DC.B	$2B,$9D,$36,$3B,$FF,$FF,$B7,$DF,$00,$00,$02,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FE,$FF,$FF,$FF,$FF,$FF,$BD
	DC.B	$00,$00,$00,$88,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$CF,$7F,$FF
	DC.B	$71,$5F,$65,$D1,$F3,$FF,$FD,$FF,$12,$00,$02,$00,$38,$08,$00,$00
	DC.B	$AB,$00,$B5,$00,$F9,$00,$DF,$02,$06,$FF,$00,$FF,$00,$FE,$A2,$F7
	DC.B	$00,$00,$00,$04,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$EF,$FF,$FF,$7F
	DC.B	$FF,$00,$BF,$20,$FF,$00,$FD,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$10,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$01,$00,$C8,$01,$5E,$EF,$6E,$FF,$26,$FF,$18,$FF,$72
	DC.B	$00,$02,$00,$00,$00,$00,$00,$00,$FD,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$40,$00,$68,$01,$10,$00,$FF,$FF,$EF,$DF,$F5,$FF,$BF,$FF
	DC.B	$AE,$00,$0E,$00,$FF,$00,$FD,$40,$00,$FE,$00,$FF,$80,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$03,$00,$13,$00,$EF,$FF,$DE,$FD,$FF,$FF,$F8,$FF
	DC.B	$BC,$00,$E4,$00,$FF,$62,$BF,$00,$00,$BF,$00,$7F,$40,$FF,$00,$BF
	DC.B	$00,$5F,$00,$FF,$7B,$FF,$7D,$FF,$02,$00,$01,$00,$0E,$00,$06,$00
	DC.B	$75,$00,$76,$00,$FF,$00,$FB,$00,$00,$FF,$20,$FF,$00,$FF,$81,$FF
	DC.B	$8C,$9D,$74,$F6,$FF,$FF,$FF,$F7,$00,$00,$A0,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$80,$00,$01,$C0,$40,$F7,$7F,$BF,$FF,$FF,$EF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$EF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$36,$40,$1A,$10,$FF,$FF,$F7,$7F,$00,$00,$00,$20,$00,$14,$04,$88
	DC.B	$D0,$00,$16,$00,$FD,$00,$FF,$11,$80,$FF,$00,$FF,$BE,$FE,$0A,$7F
	DC.B	$00,$00,$00,$00,$20,$00,$10,$00,$FF,$FF,$FF,$BF,$FF,$FF,$FF,$BF
	DC.B	$FF,$00,$EF,$01,$FF,$22,$FE,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$01,$FF,$FF,$FF,$FF,$FF,$FF,$DD,$FF
	DC.B	$00,$00,$00,$00,$00,$67,$40,$75,$FF,$14,$FF,$88,$FF,$22,$FF,$10
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$10,$00,$00,$20,$20,$00,$7F,$EB,$FF,$FF,$FF,$FF,$FF,$AF
	DC.B	$0F,$01,$8A,$00,$FF,$00,$FF,$00,$00,$DF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$10,$00,$04,$00,$7E,$FF,$FE,$FF,$FF,$FF,$BF,$FF
	DC.B	$E1,$00,$AF,$00,$FF,$00,$FF,$80,$00,$EF,$02,$FF,$40,$FF,$00,$FF
	DC.B	$00,$FF,$00,$E9,$FF,$FF,$DF,$FF,$0B,$00,$C4,$00,$03,$00,$02,$00
	DC.B	$E5,$00,$09,$00,$FF,$00,$FF,$00,$04,$FF,$00,$FF,$40,$FF,$08,$FF
	DC.B	$97,$1F,$69,$EE,$FF,$FF,$FF,$E7,$20,$21,$28,$08,$20,$00,$00,$00
	DC.B	$00,$00,$00,$04,$00,$00,$00,$00,$FF,$FF,$FF,$FE,$FF,$FB,$FF,$FF
	DC.B	$00,$00,$00,$40,$00,$10,$00,$00,$FF,$FF,$FF,$FF,$FF,$BF,$7F,$FF
	DC.B	$D1,$C0,$20,$7A,$FF,$FF,$6F,$EF,$12,$00,$01,$08,$00,$02,$38,$10
	DC.B	$7A,$00,$BF,$00,$CF,$40,$FB,$00,$00,$FF,$00,$FF,$14,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$EF,$FF,$FE,$DF,$FF,$FF
	DC.B	$FF,$00,$FF,$01,$FB,$00,$FD,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$02,$12,$00,$81,$BF,$FB,$FF,$FF,$FF,$FF,$E7,$FB
	DC.B	$00,$49,$10,$8C,$40,$BF,$0C,$B7,$FF,$01,$FF,$01,$B7,$00,$FF,$20
	DC.B	$10,$00,$00,$00,$02,$40,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$04,$7C,$00,$B6,$00,$BB,$FF,$7D,$BF,$AA,$FE,$A6,$EF
	DC.B	$B6,$00,$EB,$00,$FF,$00,$FF,$00,$00,$FF,$00,$DF,$00,$FF,$00,$7F
	DC.B	$00,$00,$00,$00,$0F,$00,$3B,$00,$FF,$FF,$DD,$FF,$B8,$FF,$BE,$FF
	DC.B	$F0,$10,$FD,$70,$FF,$21,$FF,$84,$00,$FF,$00,$2B,$46,$FF,$00,$F3
	DC.B	$19,$FF,$40,$FF,$7F,$FF,$BF,$FF,$08,$00,$04,$00,$00,$00,$00,$00
	DC.B	$1F,$00,$E7,$00,$FF,$00,$FF,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$05,$AE,$FA,$1F,$FE,$FF,$FF,$FF,$00,$00,$00,$00,$00,$06,$00,$00
	DC.B	$00,$00,$00,$00,$00,$08,$00,$02,$FF,$EF,$FF,$7F,$BE,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$04,$00,$00,$FF,$FF,$FF,$FF,$FF,$7F,$FF,$FF
	DC.B	$11,$8C,$02,$ED,$DF,$BF,$3F,$FF,$80,$00,$00,$00,$40,$02,$80,$00
	DC.B	$37,$00,$71,$00,$F8,$00,$79,$00,$10,$FF,$00,$FF,$10,$7F,$40,$FF
	DC.B	$00,$00,$00,$40,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$00,$FF,$00,$FF,$00,$FF,$00,$00,$FE,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$02,$00,$00,$00,$00,$00,$03,$7F,$FF,$FF,$7F,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$10,$00,$A1,$04,$FD,$FF,$61,$FB,$E2,$FF,$68,$FF,$C0
	DC.B	$00,$00,$00,$00,$00,$00,$04,$00,$7F,$FF,$EB,$FF,$FF,$FF,$FF,$FF
	DC.B	$08,$00,$00,$02,$00,$00,$00,$00,$EF,$FF,$FF,$CF,$BF,$7D,$EF,$FF
	DC.B	$07,$00,$45,$00,$EF,$40,$FF,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$F0,$02,$EF,$30,$FF,$00,$EF,$10,$10,$7F,$00,$DF,$00,$FF,$01,$FB
	DC.B	$00,$E6,$00,$A7,$DF,$FF,$FB,$FF,$09,$00,$3E,$00,$4A,$00,$2C,$00
	DC.B	$09,$00,$60,$00,$FB,$00,$7F,$00,$00,$FF,$00,$FF,$08,$FF,$00,$FF
	DC.B	$1A,$03,$D7,$D9,$FF,$FF,$7F,$FF,$00,$00,$00,$04,$04,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$02,$00,$88,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
