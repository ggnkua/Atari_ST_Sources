
* File name = map7.intel

* Previously loaded at $6780

	DC.B	$07,$00,$1E,$00,$07,$80,$1D,$40,$07,$80,$1C,$C0,$07,$C0,$1C,$60
	DC.B	$08,$00,$1B,$E0,$08,$20,$1B,$40,$08,$20,$1B,$20,$08,$60,$1A,$80
	DC.B	$09,$20,$1A,$20,$09,$A0,$19,$60,$0A,$00,$19,$20,$0A,$00,$18,$A0
	DC.B	$0A,$00,$18,$40,$0A,$00,$17,$C0,$0A,$40,$17,$40,$0A,$60,$16,$C0
	DC.B	$0A,$A0,$16,$60,$0A,$C0,$15,$E0,$0B,$20,$15,$60,$0B,$20,$15,$20
	DC.B	$0B,$20,$14,$E0,$0B,$40,$14,$A0,$0B,$60,$14,$60,$0B,$80,$14,$20
	DC.B	$0B,$C0,$13,$C0,$0C,$20,$13,$40,$0C,$A0,$12,$A0,$0C,$C0,$12,$40
	DC.B	$0D,$20,$11,$E0,$0D,$20,$11,$60,$0D,$60,$10,$C0,$0D,$20,$10,$60
	DC.B	$0C,$E0,$0F,$A0,$0C,$A0,$0F,$00,$0C,$A0,$0E,$C0,$0C,$60,$0E,$80
	DC.B	$0B,$C0,$0D,$C0,$0B,$A0,$0D,$80,$0B,$40,$0D,$A0,$0B,$00,$0D,$80
	DC.B	$0A,$20,$0D,$40,$09,$80,$0D,$A0,$08,$C0,$0D,$C0,$08,$60,$0D,$E0
	DC.B	$07,$E0,$0E,$60,$07,$80,$0E,$E0,$07,$20,$0F,$40,$06,$E0,$10,$40
	DC.B	$06,$E0,$11,$00,$07,$00,$12,$20,$07,$20,$12,$A0,$07,$60,$12,$E0
	DC.B	$07,$60,$13,$40,$07,$60,$13,$80,$07,$60,$14,$00,$07,$60,$14,$60
	DC.B	$06,$C0,$14,$C0,$06,$E0,$15,$40,$06,$80,$15,$80,$06,$60,$15,$80
	DC.B	$06,$20,$15,$E0,$05,$E0,$16,$20,$05,$80,$16,$20,$05,$00,$16,$40
	DC.B	$04,$C0,$16,$80,$04,$E0,$17,$00,$04,$E0,$17,$E0,$05,$60,$18,$40
	DC.B	$05,$40,$18,$C0,$05,$40,$19,$40,$05,$20,$19,$80,$04,$A0,$19,$C0
	DC.B	$04,$20,$19,$C0,$03,$C0,$1A,$40,$03,$C0,$1B,$00,$03,$E0,$1B,$40
	DC.B	$03,$C0,$1B,$E0,$04,$40,$1C,$20,$04,$80,$1C,$80,$04,$80,$1C,$E0
	DC.B	$04,$A0,$1D,$60,$04,$00,$1D,$A0,$03,$80,$1D,$E0,$03,$20,$1E,$20
	DC.B	$02,$80,$1E,$80,$02,$A0,$1F,$20,$02,$A0,$1F,$40,$02,$A0,$1F,$A0
	DC.B	$02,$E0,$20,$00,$03,$20,$20,$A0,$03,$60,$21,$00,$03,$60,$21,$A0
	DC.B	$03,$00,$22,$20,$02,$E0,$22,$80,$02,$A0,$22,$E0,$02,$A0,$23,$40
	DC.B	$02,$A0,$23,$C0,$02,$A0,$24,$80,$02,$C0,$25,$20,$03,$00,$25,$80
	DC.B	$03,$20,$25,$C0,$03,$20,$26,$00,$03,$60,$26,$60,$03,$A0,$26,$A0
	DC.B	$03,$E0,$26,$E0,$04,$60,$27,$00,$05,$20,$27,$80,$05,$A0,$27,$80
	DC.B	$06,$20,$27,$60,$06,$E0,$27,$40,$07,$A0,$26,$C0,$07,$C0,$26,$80
	DC.B	$08,$40,$26,$20,$08,$A0,$25,$40,$08,$40,$24,$E0,$08,$80,$24,$A0
	DC.B	$08,$60,$23,$C0,$08,$40,$23,$40,$07,$E0,$22,$C0,$07,$A0,$22,$A0
	DC.B	$07,$60,$22,$20,$07,$00,$21,$80,$06,$E0,$21,$40,$06,$80,$20,$E0
	DC.B	$06,$80,$20,$60,$06,$80,$1F,$E0,$06,$C0,$1F,$60,$07,$20,$1E,$E0
