
* File name = list7.intel

* Previously loaded at $D000

	DC.B	$00,$2D,$FF,$FF,$01,$31,$02,$FF,$03,$FF,$04,$FF,$FF,$FF,$FF,$32
	DC.B	$FF,$FF,$FF,$FF,$30,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$25
	DC.B	$FF,$FF,$26,$0B,$0C,$0D,$0E,$0F,$10,$11,$12,$2C,$13,$14,$16,$17
	DC.B	$18,$19,$FF,$FF,$05,$07,$08,$09,$FF,$27,$0A,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$FF,$FF,$FF,$FF,$FF,$21,$FF,$FF,$FF,$FF,$FF,$22,$FF,$FF,$FF
	DC.B	$FF,$FF,$FF,$23,$FF,$FF,$FF,$24,$FF,$FF,$FF,$34,$FF,$FF,$FF,$FF
	DC.B	$FF,$FF,$FF,$28,$29,$2A,$FF,$FF,$FF,$20,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$FF,$FF,$FF,$FF,$FF,$2F,$FF,$FF,$FF,$FF,$2B,$FF,$1A,$1C,$1E
	DC.B	$00,$35,$80,$18,$F5,$00,$0C,$02,$00,$00,$80,$71,$33,$7E,$09,$5E
	DC.B	$00,$00,$80,$71,$33,$7E,$09,$5E,$FF,$F2,$80,$71,$33,$7E,$09,$5E
	DC.B	$FF,$FB,$80,$71,$33,$7E,$09,$5E,$FF,$30,$00,$0D,$03,$F0,$00,$00
	DC.B	$00,$00,$80,$71,$33,$88,$0B,$3A,$00,$00,$80,$0D,$F3,$3A,$00,$00
	DC.B	$00,$00,$80,$0D,$F9,$E0,$00,$00,$00,$00,$80,$0D,$03,$F0,$00,$00
	DC.B	$FF,$C0,$80,$13,$33,$B8,$00,$00,$00,$00,$80,$0D,$0F,$32,$00,$00
	DC.B	$00,$00,$80,$0D,$0F,$80,$00,$00,$00,$38,$80,$0D,$0F,$5C,$00,$00
	DC.B	$00,$80,$80,$0D,$0F,$2E,$00,$00,$00,$A0,$80,$0D,$0E,$F2,$00,$00
	DC.B	$00,$C0,$80,$0D,$0F,$38,$00,$00,$00,$E0,$80,$0D,$0F,$FE,$00,$00
	DC.B	$01,$20,$80,$0D,$0F,$8C,$00,$00,$01,$40,$80,$0D,$0F,$C4,$00,$00
	DC.B	$01,$80,$00,$0D,$0F,$D0,$00,$00,$01,$80,$80,$72,$31,$40,$09,$FE
	DC.B	$01,$93,$80,$0D,$0F,$DE,$00,$00,$01,$A0,$80,$0D,$0F,$22,$00,$00
	DC.B	$01,$C0,$80,$0D,$0F,$80,$00,$00,$01,$E0,$80,$0D,$0F,$5A,$00,$00
	DC.B	$02,$00,$00,$0D,$04,$40,$00,$00,$00,$00,$80,$0D,$04,$40,$08,$00
	DC.B	$00,$00,$00,$0D,$04,$40,$00,$00,$00,$00,$80,$0D,$04,$40,$08,$00
	DC.B	$00,$00,$00,$0D,$04,$40,$00,$00,$00,$00,$80,$0D,$04,$40,$08,$00
	DC.B	$00,$00,$80,$74,$FA,$A2,$0F,$F0,$00,$00,$80,$2B,$F7,$70,$00,$00
	DC.B	$00,$00,$80,$2B,$06,$5C,$00,$00,$00,$00,$80,$2B,$F3,$F0,$00,$00
	DC.B	$00,$00,$80,$2C,$F7,$EE,$00,$00,$00,$00,$80,$72,$34,$36,$00,$00
	DC.B	$00,$00,$80,$71,$33,$62,$00,$00,$00,$00,$80,$2B,$F9,$4A,$03,$7C
	DC.B	$00,$00,$80,$0E,$FF,$44,$00,$00,$00,$00,$80,$0E,$06,$6C,$00,$00
	DC.B	$00,$00,$80,$0E,$05,$80,$00,$00,$00,$00,$80,$2C,$0B,$30,$00,$00
	DC.B	$00,$00,$80,$0D,$11,$46,$00,$00,$01,$60,$40,$77,$EE,$90,$00,$00
	DC.B	$00,$00,$80,$77,$0D,$9A,$02,$9E,$00,$00,$80,$74,$11,$0A,$00,$00
	DC.B	$00,$00,$80,$75,$F5,$00,$00,$00,$00,$00,$C0,$75,$0F,$02,$00,$00
	DC.B	$00,$00,$00,$77,$10,$5C,$00,$00,$00,$00,$C0,$77,$F2,$88,$00,$00
	DC.B	$00,$00,$C0,$77,$F2,$10,$00,$00,$00,$00,$00,$FF,$42,$FF,$20,$FF
	DC.B	$00,$00,$00,$80,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$7F,$00,$FF,$10,$FF,$00,$FF,$02,$00,$FF,$00,$FF,$00,$FF,$10,$FF
	DC.B	$00,$40,$00,$00,$01,$01,$00,$00,$7F,$FF,$FF,$F7,$FF,$FF,$7F,$FF
	DC.B	$00,$00,$00,$00,$00,$7B,$04,$F7,$FF,$00,$FF,$04,$FF,$00,$FF,$C0
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$03,$00,$05,$10,$51,$00,$2E,$FF,$F7,$7F,$EF,$FF,$BF,$FD
	DC.B	$3F,$00,$37,$00,$FF,$00,$FF,$00,$00,$FF,$00,$FE,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$8D,$00,$68,$00,$FC,$FF,$FF,$FF,$F0,$FF,$FE,$FF
	DC.B	$DB,$00,$FF,$20,$FF,$08,$FF,$40,$80,$BE,$00,$FF,$00,$FF,$00,$7F
	DC.B	$44,$DF,$40,$DF,$F7,$FF,$FF,$FF,$C8,$00,$00,$00,$20,$00,$20,$00
	DC.B	$07,$00,$13,$00,$FF,$00,$FF,$00,$00,$FF,$40,$FF,$00,$FF,$00,$FF
	DC.B	$57,$7F,$ED,$07,$FF,$FF,$FF,$FF,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$0C,$00,$01,$FF,$FE,$FF,$FF,$7F,$FF,$FF,$FF
	DC.B	$00,$01,$00,$22,$00,$00,$00,$00,$FF,$EF,$FF,$BF,$FF,$FF,$FF,$FF
	DC.B	$00,$7F,$24,$20,$FF,$BF,$FB,$FF,$00,$00,$00,$02,$40,$40,$80,$00
	DC.B	$00,$00,$09,$00,$FF,$00,$DB,$80,$22,$FF,$82,$FF,$D8,$FF,$44,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$00,$00,$FF,$FE,$FF,$FF,$FB,$FF,$FF,$FF
	DC.B	$FF,$30,$FF,$80,$FF,$00,$FF,$04,$00,$DF,$00,$7F,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$10,$18,$00,$00,$80,$7F,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$08,$00,$00,$01,$80,$7E,$08,$7F,$FF,$3D,$FD,$CC,$FF,$69,$D7,$A3
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$02,$00,$00,$28,$41,$08,$1A,$04,$FD,$FF,$FE,$FF,$FF,$FF,$DB,$FF
	DC.B	$DF,$00,$B2,$00,$FF,$01,$FF,$00,$40,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FB,$FF,$FF,$FF,$FF,$FF
	DC.B	$D5,$00,$6D,$A0,$FF,$20,$FF,$02,$00,$5F,$80,$FF,$10,$FF,$00,$FF
	DC.B	$00,$DF,$20,$FD,$76,$FF,$9D,$FF,$03,$00,$0B,$00,$21,$00,$0E,$00
	DC.B	$6F,$00,$E4,$00,$FF,$00,$FF,$00,$00,$FF,$00,$FF,$0A,$FF,$00,$FF
	DC.B	$58,$B9,$D2,$75,$F7,$FF,$FF,$BF,$02,$00,$10,$00,$00,$00,$01,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$EF,$FF,$FF
	DC.B	$00,$40,$00,$20,$00,$00,$00,$00,$FF,$BF,$FF,$CF,$FF,$FF,$FF,$FF
	DC.B	$20,$CE,$A4,$54,$FF,$FF,$EE,$FF,$00,$00,$00,$01,$01,$00,$20,$20
	DC.B	$92,$00,$CD,$00,$F7,$04,$FE,$00,$04,$FF,$00,$FF,$21,$FF,$19,$FF
	DC.B	$00,$00,$00,$00,$20,$00,$00,$80,$FF,$FF,$FF,$FF,$7F,$FF,$FF,$FF
	DC.B	$FD,$00,$FE,$80,$BF,$00,$FF,$00,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$08,$20,$08,$00,$01,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$02,$00,$01,$00,$FB,$08,$FF,$FF,$00,$FF,$8A,$FF,$10,$FF,$20
	DC.B	$00,$00,$00,$20,$00,$40,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$B1,$00,$A0,$00,$9E,$FF,$97,$FF,$17,$FF,$BE,$FB
	DC.B	$48,$00,$1B,$00,$FE,$00,$FF,$80,$00,$FF,$00,$FF,$00,$FF,$10,$FF
	DC.B	$00,$00,$00,$00,$03,$00,$11,$02,$ED,$FF,$E3,$FF,$38,$FF,$F2,$FF
	DC.B	$FD,$00,$1C,$00,$FF,$00,$FF,$00,$00,$DF,$00,$FB,$00,$FF,$00,$FF
	DC.B	$00,$DF,$00,$BF,$FF,$FF,$FB,$FF,$00,$00,$00,$00,$08,$00,$23,$00
	DC.B	$B3,$00,$A7,$00,$FF,$00,$FF,$00,$01,$FF,$80,$FF,$00,$FF,$04,$FF
	DC.B	$2D,$EB,$9D,$5D,$FF,$FF,$FF,$FF,$00,$00,$40,$00,$04,$00,$00,$10
	DC.B	$00,$00,$00,$00,$00,$00,$10,$00,$FF,$FF,$FF,$BF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$01,$00,$80,$FF,$7F,$FF,$FD,$FF,$FF,$FF,$FF
	DC.B	$66,$77,$55,$80,$FF,$FF,$7F,$FB,$00,$00,$20,$12,$00,$90,$42,$00
	DC.B	$F7,$00,$B0,$08,$D7,$00,$FF,$00,$4C,$AF,$04,$FF,$1A,$FF,$80,$FF
	DC.B	$00,$00,$00,$00,$00,$50,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$FF,$00,$FF,$00,$FF,$00,$FB,$02,$00,$FF,$00,$FF,$20,$FF,$00,$FF
	DC.B	$00,$08,$20,$00,$00,$00,$00,$80,$FF,$FF,$FF,$BF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$00,$BB,$80,$75,$FF,$00,$FF,$88,$FF,$22,$FF,$0D
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$EF,$FF
	DC.B	$90,$40,$04,$00,$80,$00,$06,$00,$9E,$DE,$ED,$FB,$FF,$FF,$FE,$FF
	DC.B	$5F,$00,$46,$00,$FF,$00,$FF,$00,$00,$FF,$00,$FF,$00,$F7,$04,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$00,$00,$FF,$FF,$FD,$FF,$FE,$FF,$F5,$FF
	DC.B	$E7,$00,$66,$02,$FF,$21,$FF,$00,$08,$FF,$00,$FA,$00,$FF,$32,$FE
	DC.B	$00,$F7,$40,$FD,$F6,$FF,$F4,$FB,$04,$00,$50,$00,$03,$00,$52,$00
	DC.B	$5C,$00,$B4,$00,$FF,$00,$FF,$00,$00,$FF,$08,$FF,$00,$FF,$00,$FF
	DC.B	$77,$45,$EC,$B5,$FB,$FF,$FF,$FF,$00,$00,$24,$00,$C0,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$BF,$EE,$FB,$FF,$FF,$FF
	DC.B	$00,$02,$00,$00,$00,$00,$00,$80,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$BF
	DC.B	$C1,$60,$11,$D2,$FF,$FF,$BC,$AF,$00,$0A,$01,$00,$0A,$10,$82,$00
	DC.B	$F3,$00,$D6,$00,$FF,$00,$FB,$00,$20,$FF,$02,$EF,$0B,$FF,$84,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$00,$10,$FF,$FF,$FF,$FD,$FF,$FF,$FF,$F9
	DC.B	$FF,$40,$FF,$18,$FD,$00,$FF,$00,$00,$FF,$10,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$08,$C4,$00,$80,$00,$00,$FF,$FF,$FF,$FF,$EF,$FF,$FF,$FF
	DC.B	$00,$11,$00,$10,$00,$E5,$00,$BF,$7F,$24,$FF,$22,$BF,$88,$FB,$00
	DC.B	$00,$00,$80,$00,$08,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$88,$00,$C8,$00,$D5,$00,$3F,$BF,$F7,$F7,$FD,$FE,$EF,$BF
	DC.B	$39,$00,$53,$10,$FF,$00,$FF,$00,$00,$FB,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$01,$00,$19,$00,$FF,$FF,$F8,$FF,$AF,$FF,$FE,$FF
	DC.B	$1D,$00,$65,$00,$FF,$09,$FF,$95,$00,$AF,$00,$DF,$08,$FF,$00,$BF
	DC.B	$00,$F6,$00,$FD,$FB,$FF,$D5,$FF,$16,$00,$09,$00,$03,$00,$22,$00
	DC.B	$36,$00,$19,$00,$DF,$00,$FF,$00,$20,$FF,$00,$FF,$00,$FF,$10,$FF
	DC.B	$DF,$2A,$53,$D3,$FF,$FF,$FF,$FF,$02,$00,$40,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$80,$00,$00,$FF,$7F,$FF,$FF,$FF,$EF,$FF,$FF
	DC.B	$00,$00,$00,$A0,$00,$00,$00,$02,$FF,$FF,$FF,$F7,$FF,$FF,$FF,$FF
	DC.B	$80,$FA,$00,$D7,$FF,$DF,$FF,$FF,$00,$00,$02,$01,$08,$00,$00,$00
	DC.B	$A0,$00,$2F,$00,$FF,$00,$FF,$40,$09,$FF,$00,$FF,$80,$FF,$10,$7F
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FE,$FE
	DC.B	$FB,$00,$FF,$00,$FF,$00,$FE,$09,$00,$FF,$00,$FF,$00,$FF,$00,$FF
	DC.B	$00,$00,$00,$00,$00,$00,$40,$20,$FF,$FF,$FB,$AF,$7E,$FF,$FF,$BD
	DC.B	$00,$10,$00,$00,$14,$87,$00,$7D,$FF,$F6,$DF,$48,$FF,$07,$FF,$EE
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF
	DC.B	$00,$00,$00,$00,$61,$00,$01,$00,$FF,$FF,$FF,$FF,$F7,$FF,$FF,$FF
	DC.B	$01,$00,$77,$00,$FF,$00,$FF,$00,$00,$FE,$20,$DF,$00,$FF,$00,$FD
	DC.B	$00,$00,$00,$00,$00,$00,$41,$00,$FE,$FF,$FE,$FF,$FF,$FF,$DF,$FF
	DC.B	$6F,$40,$BA,$00,$FF,$04,$FF,$80,$00,$FF,$00,$FB,$40,$FF,$00,$BF
	DC.B	$00,$FB,$40,$FF,$FF,$FF,$F1,$FF,$24,$00,$04,$00,$04,$00,$09,$00
	DC.B	$9C,$00,$9C,$00,$FF,$00,$7F,$00,$40,$FF,$00,$FF,$2A,$FF,$02,$FF
	DC.B	$5D,$6C,$03,$4B,$FE,$FF,$FF,$FF,$80,$00,$80,$00,$01,$00,$40,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$FF,$EF,$FF,$D7,$FF,$FF,$FF,$FB
