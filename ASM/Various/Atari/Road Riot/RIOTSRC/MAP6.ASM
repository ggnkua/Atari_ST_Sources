
* File name = map6.intel

* Previously loaded at $6580

	DC.B	$0A,$20,$16,$20,$0A,$40,$16,$00,$0A,$E0,$15,$C0,$0A,$E0,$15,$A0
	DC.B	$0B,$00,$15,$20,$0B,$20,$14,$E0,$0B,$20,$14,$80,$0B,$20,$14,$20
	DC.B	$0B,$00,$13,$A0,$0A,$E0,$13,$00,$0A,$A0,$12,$E0,$0A,$A0,$12,$A0
	DC.B	$0A,$80,$12,$00,$0A,$20,$11,$C0,$0A,$00,$11,$40,$09,$A0,$10,$E0
	DC.B	$09,$60,$10,$80,$09,$20,$10,$20,$08,$E0,$0F,$40,$08,$C0,$0E,$E0
	DC.B	$08,$60,$0E,$80,$08,$00,$0E,$00,$07,$20,$0D,$A0,$06,$60,$0D,$40
	DC.B	$05,$A0,$0D,$60,$04,$80,$0D,$C0,$04,$00,$0E,$20,$03,$A0,$0F,$20
	DC.B	$03,$40,$0F,$80,$03,$00,$10,$00,$03,$00,$10,$C0,$03,$20,$11,$A0
	DC.B	$03,$60,$12,$40,$03,$60,$12,$C0,$03,$80,$13,$40,$03,$C0,$13,$C0
	DC.B	$04,$00,$14,$00,$04,$40,$14,$A0,$04,$80,$15,$00,$04,$80,$15,$A0
	DC.B	$04,$C0,$16,$60,$04,$E0,$16,$C0,$04,$E0,$17,$40,$04,$E0,$17,$A0
	DC.B	$04,$C0,$18,$00,$05,$00,$18,$40,$05,$00,$18,$E0,$05,$00,$19,$40
	DC.B	$05,$00,$19,$C0,$05,$00,$1A,$40,$05,$00,$1A,$C0,$05,$00,$1B,$20
	DC.B	$05,$00,$1B,$40,$05,$00,$1B,$80,$05,$00,$1B,$E0,$05,$00,$1C,$60
	DC.B	$05,$00,$1D,$00,$05,$40,$1D,$C0,$05,$40,$1E,$00,$05,$40,$1E,$40
	DC.B	$05,$40,$1E,$E0,$05,$40,$1F,$00,$05,$40,$1F,$40,$05,$40,$1F,$A0
	DC.B	$05,$40,$20,$00,$05,$40,$21,$00,$05,$A0,$21,$E0,$05,$E0,$22,$60
	DC.B	$06,$00,$22,$40,$06,$A0,$22,$A0,$06,$E0,$22,$80,$07,$40,$22,$E0
	DC.B	$08,$00,$23,$20,$09,$00,$22,$C0,$09,$A0,$22,$80,$09,$C0,$22,$80
	DC.B	$0A,$20,$22,$60,$0A,$80,$22,$20,$0A,$A0,$21,$E0,$0B,$00,$21,$60
	DC.B	$0B,$60,$20,$A0,$0B,$60,$20,$00,$0B,$A0,$1F,$80,$0B,$A0,$1F,$60
	DC.B	$0B,$E0,$1F,$00,$0C,$C0,$1E,$60,$0D,$40,$1E,$40,$0D,$80,$1E,$40
	DC.B	$0E,$60,$1E,$00,$0E,$80,$1D,$E0,$0E,$E0,$1D,$80,$0E,$E0,$1D,$00
	DC.B	$0E,$A0,$1C,$80,$0E,$80,$1C,$40,$0D,$E0,$1B,$E0,$0D,$00,$1B,$80
	DC.B	$0C,$C0,$1B,$80,$0C,$40,$1B,$40,$0B,$E0,$1B,$20,$0B,$80,$1A,$E0
	DC.B	$0B,$60,$1A,$C0,$0B,$20,$1A,$80,$0A,$C0,$1A,$60,$0A,$80,$1A,$40
	DC.B	$0A,$00,$1A,$60,$09,$E0,$1A,$00,$09,$80,$19,$E0,$09,$60,$19,$C0
	DC.B	$09,$20,$19,$A0,$08,$C0,$19,$60,$08,$80,$18,$E0,$08,$60,$18,$A0
	DC.B	$08,$00,$18,$60,$07,$E0,$18,$00,$07,$A0,$17,$C0,$07,$40,$17,$80
	DC.B	$07,$60,$17,$60,$07,$60,$16,$E0,$07,$60,$16,$A0,$07,$80,$16,$40
	DC.B	$07,$A0,$15,$E0,$07,$C0,$15,$E0,$08,$40,$15,$C0,$08,$C0,$15,$E0
	DC.B	$09,$00,$16,$00,$09,$00,$16,$20,$09,$60,$16,$40,$09,$80,$16,$20
