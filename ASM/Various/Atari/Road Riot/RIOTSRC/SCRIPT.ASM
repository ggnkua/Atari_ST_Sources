	TTL	'Animation Scripts'

SYSID	EQU	1	* VMS = 0	ARIUM = 1

*
* Include animation macros and defs
*

	IFEQ	SYSID

	INCLUDE	'inc:mobmac.asm'
	INCLUDE	'inc:audio.i'

	ENDC

	IFNE	SYSID

	INCLUDE	prog/inc/mobmac.asm
	INCLUDE	prog/inc/audio.i

	ENDC

HFLIP	EQU	$4000

*
*	AGLOBAL DEFINES
*

PLRGBL		EQU	0			* 2 Players

FULL_SCALE	EQU	$0100			* Default scale value
QRTR3_SCALE	EQU	$00C0
HALF_SCALE	EQU	$0080
QRTR_SCALE	EQU	$0040

CAR_STRAIGHT	EQU	$30			* Straight angle for cars

*
* General purpose external routines
*
	XREF	obflip
	XREF	lock_flip

	SECTION	13
*
* Generic Freeze and Delete
*
freeze:	DCAC	ASC_FREEZE
delcmd:	DCAC	ASC_DEL

*
* Hardware Test blocks
*
	XDEF	test16
test16:	DCPB	TEST000
	XDEF	test32
test32:	DCPB	TEST001
	XDEF	test64
test64:	DCPB	TEST002

	XDEF	motest0
motest0:DCPB	TEST000

*
* Clear picture
*
	XDEF	clear
clear:	DCPB	BLOCK000

*
* Player
*
	XDEF	rat0
	XREF	body0blk,shadowblk
	XREF	init_carblk,carpix
rat0:	DCACP	ASC_SUB,init_carblk
	DCACC	ASC_SPAWN,ASS_LOCK,body0blk,0,0
	DCACC	ASC_SPAWN,ASS_LOCK,shadowblk,0,0
	DCAGLB	ASC_GLBSET,UD1,CAR_STRAIGHT
	DCACP	ASC_SUBSTP,carpix
	DCAC	ASC_FREEZE

	XDEF	rat1
	XREF	body1blk
rat1:	DCACP	ASC_SUB,init_carblk
	DCACC	ASC_SPAWN,ASS_LOCK,body1blk,0,0
	DCACC	ASC_SPAWN,ASS_LOCK,shadowblk,0,0
	DCAGLB	ASC_GLBSET,UD1,CAR_STRAIGHT
	DCACP	ASC_SUBSTP,carpix
	DCAC	ASC_FREEZE

	XDEF	rat2
	XREF	body2blk
rat2:	DCACP	ASC_SUB,init_carblk
	DCACC	ASC_SPAWN,ASS_LOCK,body2blk,0,0
	DCACC	ASC_SPAWN,ASS_LOCK,shadowblk,0,0
	DCAGLB	ASC_GLBSET,UD1,CAR_STRAIGHT
	DCACP	ASC_SUBSTP,carpix
	DCAC	ASC_FREEZE

	XDEF	body
body:	DCAC	ASC_SPRI,1
	DCAGLB	ASC_GLBSET,UD1,CAR_STRAIGHT
	DCPB	BLOCK000
	DCAC	ASC_FREEZE

	XDEF	shadow
shadow:	DCAC	ASC_SPRI,-2
	DCAGLB	ASC_GLBSET,UD1,CAR_STRAIGHT
	DCPB	BLOCK000
	DCAC	ASC_FREEZE

*
* Special effects
*
	XDEF	roll
	XREF	end_roll
roll:	
	DCPB   	ROLL000 
	DCAC	ASC_ATSET,3
	DCPB	ROLL000,ROLL001,ROLL006,ROLL002,ROLL003,ROLL004
	DCPB	ROLL000,ROLL005,ROLL006,ROLL007,ROLL008,ROLL009,ROLL010
	DCACP	ASC_SUBSTP,end_roll

	XDEF	shd_roll
shd_roll:	
	DCPB   	SHD500 
	DCAC	ASC_ATSET,3
	DCPB	SHD500,SHD501,SHD506,SHD502,SHD503,SHD504
	DCPB	SHD500,SHD505,SHD506,SHD507,SHD508,SHD509,SHD510
	DCAC	ASC_FREEZE

	XDEF	droll
	XREF	end_droll
droll:	
	DCPB   	LDRN014
	DCAC	ASC_ATSET,3
drll:	DCPB	LDRN014,LDRN015,LDRN016,LDRN017,LDRN018
	DCACP	ASC_LOOP,drll


	XDEF	endo,endo1
endo:	
	DCPB   	EOE200 
	DCPB	EOE200
	DCAC	ASC_ATSET,4
	DCPB	EOE201,EOE202,EOE203
	DCPB	EOE204,EOE205,EOE206,EOE207
	DCACG	ASC_TRIGGER,UD3
	DCAC	ASC_ATSET,3
	DCPB	EOE200,EOE201,EOE202,EOE203
	DCPB	EOE204,EOE205,EOE206,EOE207
	DCAC	ASC_FREEZE

endo1:	
	DCPB   	EOE200 
	DCPB	EOE200
	DCAC	ASC_ATSET,4
	DCPB	EOE201,EOE202,EOE203
	DCPB	EOE204,EOE205,EOE206,EOE207
	DCAC	ASC_FREEZE

	XDEF	shd_endo,shd_endo1
shd_endo:
	DCPB   	SHD300 
	DCPB	SHD300
	DCAC	ASC_ATSET,4
	DCPB	SHD301,SHD302,SHD303
	DCPB	SHD304,SHD305,SHD306,SHD307
	DCACG	ASC_TRIGGER,UD3
	DCAC	ASC_ATSET,3
	DCPB	SHD300,SHD301,SHD302,SHD303
	DCPB	SHD304,SHD305,SHD306,SHD307
	DCAC	ASC_FREEZE

shd_endo1:
	DCPB   	SHD300 
	DCPB	SHD300
	DCAC	ASC_ATSET,4
	DCPB	SHD301,SHD302,SHD303
	DCPB	SHD304,SHD305,SHD306,SHD307
	DCAC	ASC_FREEZE

	XDEF	dendo
dendo:	
	DCPB   	LDRN007
	DCAC	ASC_ATSET,4
dndo:	DCPB	LDRN007,LDRN008,LDRN009,LDRN010
	DCPB	LDRN011,LDRN012,LDRN013,LDRN000
	DCACP	ASC_LOOP,dndo

	XDEF	drive_by	
drive_by:
	DCPB   	ROLL000 	* will be drive by car pic
	DCAC	ASC_XPOS,$1000
    DCAC    ASC_YPOS,$200
    DCPB    ROLL000
	DCAC	ASC_XPOS,$1000
    DCAC    ASC_YPOS,-$200
	DCACP	ASC_TLOOP,drive_by,8
    DCAC    ASC_DEL

*
* Laser shots
*

	XDEF	laser
	XREF	laser_delete
laser:	DCPB	SHOT000
	DCACP	ASC_SUB,laser_delete
	DCAC	ASC_FREEZE

	XDEF	fball
fball:	DCAC	ASC_SPRI,2
	DCPB	SHOT000
	DCAC	ASC_FREEZE

*
* Dunes Panel
*
	XDEF	dune0,dune0f
	XREF	dune0fblk
dune0:	DCACC	ASC_SPAWN,ASS_LOCK,dune0fblk,-$320,0
dune0f:	DCPB	DUNE500

	XDEF	dune1,dune1f
	XREF	dune1fblk
dune1:	DCACC	ASC_SPAWN,ASS_LOCK,dune1fblk,-$320,0
dune1f:	DCPB	DUNE501

	XDEF	dune2,dune2f
	XREF	dune2fblk
dune2:	DCACC	ASC_SPAWN,ASS_LOCK,dune2fblk,-$320,0
dune2f:	DCPB	DUNE503

	XDEF	dune3,dune3f
	XREF	dune3fblk
dune3:	DCACC	ASC_SPAWN,ASS_LOCK,dune3fblk,-$320,0
dune3f:	DCPB	DUNE504

	XDEF	curb0,curb0f
	XREF	curb0fblk
curb0:	DCACC	ASC_SPAWN,ASS_LOCK,curb0fblk,-$290,0
curb0f:	DCPB	CURB502

	XDEF	grass,grassf
	XREF	grassfblk
grass:	DCACC	ASC_SPAWN,ASS_LOCK,grassfblk,-$320,0
grassf:	DCPB	DUNE505

*
* 	Dust Clouds
*
	XDEF	dust1
dust1:	DCAC	ASC_SPRI,-1
	DCPB	DUST210,DUST211,DUST212,DUST213
	DCAC	ASC_DEL

	XDEF	dust2
dust2:	DCAC	ASC_SPRI,-1
	DCPB	DUST000,DUST001,DUST002,DUST003
	DCPB	DUST004,DUST005,DUST006,DUST007
	DCAC	ASC_DEL

*
*	Starting Gate
*
	XDEF	gate0,gate0f
	XREF	gate0fblk,line0blk,line0fblk,bannerblk
gate0:	DCACC	ASC_SPAWN,ASS_LOCK,gate0fblk,176,0
	DCACC	ASC_SPAWN,ASS_LOCK,line0blk,0,0
	DCACC	ASC_SPAWN,ASS_LOCK,line0fblk,176,0
	DCACC	ASC_SPAWN,ASS_LOCK,bannerblk,87,-70
gate0f:	DCPB	GATE051

	XDEF	gate1,gate1f
	XREF	gate1fblk
gate1:	DCACC	ASC_SPAWN,ASS_LOCK,gate1fblk,176,0
	DCACC	ASC_SPAWN,ASS_LOCK,line0blk,0,0
	DCACC	ASC_SPAWN,ASS_LOCK,line0fblk,176,0
	DCACC	ASC_SPAWN,ASS_LOCK,bannerblk,87,-70
	DCACC	ASC_SPAWN,ASS_LOCK,line0fblk,0,0
gate1f:	DCPB	GATE052

	XDEF	gate2,gate2f
	XREF	gate2fblk,line1blk,line1fblk
gate2:	DCACC	ASC_SPAWN,ASS_LOCK,gate2fblk,176,0
	DCACC	ASC_SPAWN,ASS_LOCK,line1blk,0,0
	DCACC	ASC_SPAWN,ASS_LOCK,line1fblk,176,0
	DCACC	ASC_SPAWN,ASS_LOCK,bannerblk,87,-70
gate2f:	DCPB	GATE053

	XDEF	line0
line0:	DCAC	ASC_SPRI,-2
	DCPB	STRT000

	XDEF	line1
line1:	DCAC	ASC_SPRI,-2
	DCPB	STRT001

	XDEF	banner
banner:	DCAC	ASC_SPRI,1
	DCPB	GATE060



*
*	Turn Sign
*
	XDEF	sign0,dsign0
	XREF	dsign0fblk
dsign0:	DCACC	ASC_SPAWN,ASS_LOCK,dsign0fblk,-$140,0
sign0:	DCAC	ASC_SPRI,-2
	DCPB	SIGN070
	DCPB	SIGN071
	DCAC	ASC_FREEZE

	XDEF	sign1,dsign1
	XREF	dsign1fblk
dsign1:	DCACC	ASC_SPAWN,ASS_LOCK,dsign1fblk,-$140,0
sign1:	DCAC	ASC_SPRI,-2
	DCPB	SIGN072
	DCPB	SIGN071
	DCAC	ASC_FREEZE

	XDEF	hydrnt
hydrnt:
	DCAC	ASC_SPRI,-2
	DCPB	SIGN073
*
*	Hay Bale
*
	XDEF	bale0,dbale0
	XREF	dbale1fblk
dbale0:	DCACC	ASC_SPAWN,ASS_LOCK,dbale1fblk,-$280,0
bale0:	DCPB	BALE100

	XDEF	bale1
bale1:	DCPB	BALE101

	XDEF	bale2,dbale2
dbale2:	DCACC	ASC_SPAWN,ASS_LOCK,dbale1fblk,-$280,0
bale2:	DCPB	BALE102

	XDEF	balexpl
balexpl:
	DCPB	BALE104
	DCAC	ASC_YSSET,-$40
	DCPB	BALE105,BALE106
	DCAC	ASC_DEL
*
*	Trash Cans
*
	XDEF	trash0
trash0:	DCPB	TRASH150

	XDEF	trash1
trash1:	DCPB	TRASH151

	XDEF	trash2
trash2:	DCPB	TRASH152

	XDEF	trashxpl
trashxpl:
	DCPB	TRASH154
	DCAC	ASC_YSSET,-$20
	DCPB	TRASH155,TRASH156
	DCAC	ASC_DEL
*
*	Tires
*
	XDEF	tire0,dtire0
	XREF	dtire1fblk
dtire0:	DCACC	ASC_SPAWN,ASS_LOCK,dtire1fblk,-$280,0
tire0:	DCPB	TIRE200

	XDEF	tire1
tire1:	DCPB	TIRE201

	XDEF	tire2,dtire2
	XREF	dtire0fblk
dtire2:	DCACC	ASC_SPAWN,ASS_LOCK,dtire0fblk,-$280,0
tire2:	DCPB	TIRE202


	XDEF	tirexpl
tirexpl:
	DCPB	TIRE204
	DCAC	ASC_YSSUM,-$20
	DCPB	TIRE205,TIRE206
	DCAC	ASC_DEL
*
*	Sand Bags
*
	XDEF	bag0,dbag0
	XREF	dbag1fblk
dbag0:	DCACC	ASC_SPAWN,ASS_LOCK,dbag1fblk,-$240,0
bag0:	DCPB	BAG250

	XDEF	bag1
bag1:	DCPB	BAG251

	XDEF	bag2,dbag2
	XREF	dbag0fblk
dbag2:	DCACC	ASC_SPAWN,ASS_LOCK,dbag0fblk,-$240,0
bag2:	DCPB	BAG252

	XDEF	bagxpl
bagxpl:
	DCPB	BAG254
	DCAC	ASC_YSSET,-$20
	DCPB	BAG255,BAG256
	DCAC	ASC_DEL

*
*	Guard Rails
*
	XDEF	post,dpost
	XREF	dpostfblk
dpost:	DCACC	ASC_SPAWN,ASS_LOCK,dpostfblk,-$180,0
post:	DCPB	RAIL020

	XDEF	post1,dpost1
	XREF	dpost1fblk
dpost1:	DCACC	ASC_SPAWN,ASS_LOCK,dpost1fblk,-$220,0
post1:	DCPB	RAIL025

	XDEF	rail0,drail0
	XREF	drail0fblk
drail0:	DCACC	ASC_SPAWN,ASS_LOCK,drail0fblk,-$180,0
rail0:	DCPB	RAIL021


*
*	Bumps
*
	XDEF	bump0
bump0:	DCAC	ASC_SPRI,-2
	DCPB	BUMP002

	XDEF	bump1,bump1a
	XREF	bump1fblk
bump1:	DCACC	ASC_SPAWN,ASS_LOCK,bump1fblk,0,0
bump1a:
	DCAC	ASC_SPRI,-2
	DCPB	BUMP003

	XDEF	bump2
bump2:	DCAC	ASC_SPRI,-2
	DCPB	BUMP014

	XDEF	bump3,bump3a
	XREF	bump3fblk
bump3:	DCACC	ASC_SPAWN,ASS_LOCK,bump3fblk,0,0
bump3a:
	DCAC	ASC_SPRI,-2
	DCPB	BUMP015

	XDEF	bump4
bump4:	DCAC	ASC_SPRI,-2
	DCPB	BUMP016

	XDEF	bump5,bump5a
	XREF	bump5fblk
bump5:	DCACC	ASC_SPAWN,ASS_LOCK,bump5fblk,0,0
bump5a:
	DCAC	ASC_SPRI,-2
	DCPB	BUMP017

*
*	Mud Puddle
*
	XDEF	mud0
mud0:	DCAC	ASC_SPRI,-2
	DCPB	MUD004

	XDEF	mud1,mud1a
	XREF	mud1fblk
mud1:	DCACC	ASC_SPAWN,ASS_LOCK,mud1fblk,0,0
mud1a:
	DCAC	ASC_SPRI,-2
	DCPB	MUD005

	XDEF	splash
splash:	DCPB	SPL000,SPL001,SPL002,SPL003
	DCAC	ASC_DEL

*
*	Side dirt
*
	XDEF	dirt0,ddirt0
	XREF	ddirt1fblk
ddirt0:	DCACC	ASC_SPAWN,ASS_LOCK,ddirt1fblk,-$280,0
dirt0:	DCPB	DIRT006

	XDEF	dirt1
dirt1:	DCPB	DIRT007

	XDEF	dirt2,ddirt2
	XREF	ddirt3fblk
ddirt2:	DCACC	ASC_SPAWN,ASS_LOCK,ddirt3fblk,-$280,0
dirt2:	DCPB	DIRT030

	XDEF	dirt3
dirt3:	DCPB	DIRT031

	XDEF	dirt4
dirt4:	DCPB	DIRT032

*
*	Corn & Cactus
*
	XDEF	corn,cornf
	XREF	cornfblk
corn:	DCACC	ASC_SPAWN,ASS_LOCK,cornfblk,-$400,0
cornf:	DCPB	CORN033

	XDEF	cactus0,dcactus0
	XREF	dcact1fblk
dcactus0:
	DCACC	ASC_SPAWN,ASS_LOCK,dcact1fblk,-$300,0
cactus0:
	DCPB	CACT034

	XDEF	cactus1
cactus1:
	DCPB	CACT035
*
*	Trees & side stuff
*
	XDEF	tree0,dtree0
	XREF	dtree0fblk
dtree0:	DCACC	ASC_SPAWN,ASS_LOCK,dtree0fblk,-$120,0
tree0:	DCPB	TREE000

	XDEF	tree1,dtree1
	XREF	dtree1fblk
dtree1:	DCACC	ASC_SPAWN,ASS_LOCK,dtree1fblk,-$120,0
tree1:	DCPB	TREE001

	XDEF	tree2,dtree2
	XREF	dtree2fblk
dtree2:	DCACC	ASC_SPAWN,ASS_LOCK,dtree2fblk,-$120,0
tree2:	DCPB	TREE002

	XDEF	tree3,dtree3
	XREF	dtree3fblk
dtree3:	DCACC	ASC_SPAWN,ASS_LOCK,dtree3fblk,-$200,0
tree3:	DCPB	TREE101

	XDEF	tree4,dtree4
	XREF	dtree4fblk
dtree4:	DCACC	ASC_SPAWN,ASS_LOCK,dtree4fblk,-$200,0
tree4:	DCPB	TREE102

	XDEF	tree5,dtree5
	XREF	dtree5fblk
dtree5:	DCACC	ASC_SPAWN,ASS_LOCK,dtree5fblk,-$120,0
tree5:	DCPB	TREE004

	XDEF	tree6,dtree6
	XREF	dtree6fblk
dtree6:	DCACC	ASC_SPAWN,ASS_LOCK,dtree6fblk,-$200,0
tree6:	DCPB	TREE103

	XDEF	palm,dpalm
	XREF	dpalmfblk
dpalm:	DCACC	ASC_SPAWN,ASS_LOCK,dpalmfblk,-$120,0
palm:	DCPB	TREE003

	XDEF	trees0,trees1
	XREF	treesfblk
trees0:	DCACC	ASC_SPAWN,ASS_LOCK,treesfblk,-$320,0
trees1:	DCPB	TREES100

	XDEF	stand
stand:	DCPB	STAND201

	XDEF	wreck0
wreck0:	DCPB	WRECK200

	XDEF	wreck1
wreck1:	DCPB	WRECK210

	XDEF	wreck2
wreck2:	DCPB	WRECK211

	XDEF	rock0
rock0:	DCPB	ROCK212

	XDEF	rock1
rock1:	DCPB	ROCK213

	XDEF	rock2
rock2:	DCPB	ROCK214

	XDEF	rock3
rock3:	DCPB	ROCK020

*
*	Explosions and stuff
*
	XDEF	expl0
	XREF	end_xplo
expl0:	DCPB	EXPL000
	DCAC	ASC_ATSET,3
	DCPB	EXPL000,EXPL001,EXPL002
	DCAC	ASC_ATSET,4
	DCPB	EXPL003,EXPL004,EXPL005,EXPL006,EXPL007
	DCPB	EXPL008,EXPL009,EXPL010,EXPL011,EXPL012
	DCACP	ASC_SUBSTP,end_xplo

	XDEF	expl1
expl1:	DCPB	EXPL050
	DCAC	ASC_ATSET,3
exp1:	DCPB	EXPL050,EXPL051
	DCACP	ASC_LOOP,exp1

	XDEF	splat
splat:	DCPB	EXPL050,EXPL051
	DCAC	ASC_DEL

*
*	Road Kills
*
	XDEF	cow
cow:	DCPB	COW050,COW051,COW053
	DCAC	ASC_FREEZE

	XDEF	cows
cows:	DCPB	COW500

*
*	Extra Cars
*
	XDEF	car0
car0:	DCPB	CAR000

	XDEF	car2
car2:	DCPB	CAR085

	XDEF	car3
car3:	DCPB	CAR089

	XDEF	car4
car4:	DCPB	CAR097

	XDEF	car5
car5:	DCPB	CAR100

	XDEF	car6
car6:	DCPB	CAR108

	XDEF	car7
car7:	DCPB	CAR115

	XDEF	car8
car8:	DCPB	CAR119

	XDEF	car9
car9:	DCPB	CAR303
	DCPB	CAR304,CAR305,CAR306,CAR307
	DCAC	ASC_PAL,14
	DCAC	ASC_SND,S_EXPA
	DCPB	EXPL003,EXPL004,EXPL005,EXPL006,EXPL007
	DCPB	EXPL008,EXPL009,EXPL010,EXPL011,EXPL012
	DCAC	ASC_DEL

	XDEF	car10
car10:	DCPB	CAR116

	XDEF	car11
car11:	DCPB	CAR117

	XDEF	car12
car12:	DCPB	CAR118

	XDEF	car13
car13:	DCPB	CAR400
	DCPB	CAR401,CAR402,CAR403,CAR404
	DCAC	ASC_PAL,14
	DCAC	ASC_SND,S_EXPA
	DCPB	EXPL003,EXPL004,EXPL005,EXPL006,EXPL007
	DCPB	EXPL008,EXPL009,EXPL010,EXPL011,EXPL012
	DCAC	ASC_DEL



*
*	Buildings
*
	XDEF	bldg0,dbldg0
	XREF	dbldg1fblk
dbldg0:	DCACC	ASC_SPAWN,ASS_LOCK,dbldg1fblk,-$200,0
bldg0:	DCPB	BLDG100

	XDEF	bldg1
bldg1:	DCPB	BLDG101

	XDEF	bldg2,dbldg2
	XREF	dbldg3fblk
dbldg2:	DCACC	ASC_SPAWN,ASS_LOCK,dbldg3fblk,-$280,0
bldg2:	DCPB	BLDG102

	XDEF	bldg3
bldg3:	DCPB	BLDG103

	XDEF	bldg4
bldg4:	DCPB	BLDG104

	XDEF	bldg5
bldg5:	DCPB	BLDG105

	XDEF	bldg6
bldg6:	DCPB	BLDG106


*
*	Loda the Flag Girl
*
	XDEF	fgirl_right
fgirl_right:
	DCPB	GIRL000
	DCAC	ASC_XPOS,-$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCPB	GIRL001
	DCAC	ASC_XPOS,-$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCPB	GIRL002
	DCAC	ASC_XPOS,-$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCPB	GIRL003
	DCAC	ASC_XPOS,-$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCACP	ASC_LOOP,fgirl_right

	XDEF	fgirl_left
fgirl_left:
	DCPB	GIRL000
	DCAC	ASC_XPOS,$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCPB	GIRL001
	DCAC	ASC_XPOS,$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCPB	GIRL002
	DCAC	ASC_XPOS,$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCPB	GIRL003
	DCAC	ASC_XPOS,$80
	DCAGO	ASC_CBRANCH,UD1,1
	DC.L	fg1
	DCACP	ASC_LOOP,fgirl_left

fg1:	DCPB	GIRL001,GIRL004,GIRL004,GIRL004,GIRL005
	DCAC	ASC_GLBCLR,UD1
	DCACG	ASC_TRIGGER,UD1

	DCPB	GIRL012,GIRL010,GIRL011			* READY
	DCAC	ASC_GLBCLR,UD1
	DCACG	ASC_TRIGGER,UD1

	DCPB	GIRL010,GIRL011				* SET
	DCAC	ASC_GLBCLR,UD1
	DCACG	ASC_TRIGGER,UD1

	DCPB	GIRL012,GIRL014				* GO
fg2:	DCPB	GIRL015,GIRL016,GIRL017
	DCPB	GIRL018,GIRL019,GIRL020,GIRL021
	DCACP	ASC_TLOOP,fg2,3
	DCPB	GIRL015,GIRL016,GIRL012
	DCPB	GIRL051,GIRL052,GIRL053
	DCAC	ASC_ATSET,8
fg3:	DCAC	ASC_PAUSE,16
	DCPB	GIRL052,GIRL053
	DCACP	ASC_LOOP,fg3

	XDEF	fingirl
fingirl:
	DCPB	GIRL012,GIRL014
fng2:	DCPB	GIRL015,GIRL016,GIRL017
	DCPB	GIRL018,GIRL019,GIRL020,GIRL021
	DCACP	ASC_LOOP,fng2

	XDEF	biglada
biglada:
	DCPB	GIRL005
	DCAC	ASC_RANDOM,10
	DCPB	GIRL004
	DCAC	ASC_RANDOM,10
	DCACP	ASC_LOOP,biglada

*
*	Win screen sequences
*
	XDEF	win1
win1:	DCPB	DRVR000,DRVR008,DRVR009
	DCAC	ASC_PAUSE,8
	DCPB	DRVR008,DRVR000,DRVR001,DRVR000
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,win1

	XDEF	first
first:	DCPB	DRVR004
	DCAC	ASC_SND,S_KISS
	DCPB	DRVR005,DRVR005,DRVR005
	DCPB	DRVR004
	DCAC	ASC_SND,S_KISS
	DCPB	DRVR006,DRVR006,DRVR006
	DCPB	DRVR004
	DCPB	DRVR007,DRVR007,DRVR007,DRVR007,DRVR004
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,first

	XDEF	first2
first2:
	DCPB	DRVR804,DRVR804,DRVR800,DRVR800,DRVR801
	DCAC	ASC_SND,S_KISS
	DCPB	DRVR802,DRVR802,DRVR802
	DCPB	DRVR801,DRVR801
	DCAC	ASC_SND,S_KISS
	DCPB	DRVR802,DRVR802,DRVR802
	DCPB	DRVR801,DRVR803,DRVR803
	DCPB	DRVR804,DRVR804,DRVR804
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,first2

	XDEF	snogirls
snogirls:
	DCPB	DRVR025,DRVR026,DRVR026
	DCPB	DRVR027,DRVR027,DRVR027,DRVR027
	DCPB	DRVR027,DRVR027,DRVR027,DRVR027
	DCPB	DRVR029,DRVR030,DRVR029,DRVR030
	DCPB	DRVR029,DRVR030,DRVR029
	DCPB	DRVR031,DRVR031,DRVR031,DRVR031
	DCPB	DRVR031,DRVR031,DRVR031,DRVR031
	DCPB	DRVR032,DRVR032,DRVR032,DRVR032,DRVR032
	DCPB	DRVR033,DRVR033,DRVR033,DRVR033
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,snogirls

	XDEF	second
second:
	DCPB	DRVR050,DRVR050,DRVR050
	DCPB	DRVR051,DRVR051
	DCPB	DRVR052,DRVR053,DRVR052,DRVR053,DRVR052,DRVR053
	DCPB	DRVR051,DRVR051,DRVR051
	DCPB	DRVR054,DRVR054,DRVR054
	DCPB	DRVR055,DRVR055,DRVR055,DRVR055
	DCPB	DRVR056,DRVR056,DRVR057,DRVR057
	DCPB	DRVR056,DRVR056,DRVR057,DRVR057
	DCPB	DRVR056,DRVR056,DRVR057,DRVR057
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,second

	XDEF	third
third:	DCPB	DRVR107,DRVR107,DRVR107
	DCPB	DRVR100,DRVR100,DRVR101,DRVR101
	DCPB	DRVR102,DRVR102
	DCPB	DRVR103,DRVR103,DRVR104,DRVR104
	DCPB	DRVR103,DRVR103,DRVR104,DRVR104,DRVR105
	DCPB	DRVR106,DRVR107,DRVR106,DRVR107
	DCPB	DRVR106,DRVR107,DRVR108,DRVR107
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,third
*
*	Crowds
*
	XDEF	crowd0
crowd0:	DCPB	CRWD900
	DCAC	ASC_RANDOM,4
	DCPB	CRWD901
	DCAC	ASC_RANDOM,4
	DCACP	ASC_LOOP,crowd0

	XDEF	crowd2,crowd2_end
crowd2:	DCPB	CRWD051
	DCAC	ASC_RANDOM,4
	DCPB	CRWD052
	DCAC	ASC_RANDOM,4
	DCACP	ASC_LOOP,crowd2
crowd2_end:
	DCPB	CRWD053
	DCAC	ASC_FREEZE
	DCPB	CRWD054,CRWD055,CRWD055
	DCAC	ASC_DEL

	XDEF	crowd3,crowd3_end
crowd3:	DCPB	CRWD700
	DCAC	ASC_RANDOM,4
	DCPB	CRWD701
	DCAC	ASC_RANDOM,4
	DCACP	ASC_LOOP,crowd3
crowd3_end:
	DCPB	CRWD702
	DCAC	ASC_FREEZE
	DCPB	CRWD703,CRWD703,CRWD703
	DCAC	ASC_DEL

	XDEF	crowd4,crowd4_end
crowd4:	DCPB	CRWD4050
	DCAC	ASC_RANDOM,4
	DCPB	CRWD4051
	DCAC	ASC_RANDOM,4
	DCACP	ASC_LOOP,crowd4
crowd4_end:
	DCPB	CRWD4052
	DCAC	ASC_FREEZE
	DCPB	CRWD4053,CRWD4053,CRWD4053
	DCAC	ASC_DEL


*	Mr. Fin - jumps out at the end of the race
*
	xdef  mrfin
mrfin:
	DCAC	ASC_SPRI,2
	DCAC	ASC_ZPOS,$38
	DCPB	FIN000
	DCPB	FIN001
	DCAC	ASC_ZPOS,$0C
	DCPB	FIN002
	DCAC	ASC_ZPOS,-$05
	DCPB	FIN003
	DCAC	ASC_ZPOS,-$20
	DCPB	FIN004
	DCPB	FIN004
	DCPB	FIN005,FIN006
	DCPB    FIN006
	DCPB	FIN005,FIN006
	DCAC	ASC_FREEZE

*
*	Arabs
*
	XDEF	arab0,arab0_end
arab0:	DCPB	ARAB030,ARAB031
	DCACP	ASC_LOOP,arab0
arab0_end:
	DCPB	ARAB032
	DCAC	ASC_FREEZE
	DCPB	ARAB033,ARAB033,ARAB033
	DCAC	ASC_DEL

	XDEF	arab2
arab2:	DCPB	ARAB710,ARAB711
	DCACP	ASC_LOOP,arab2

	XDEF	arab3
arab3:	DCPB	ARAB700,ARAB701
	DCACP	ASC_LOOP,arab3

*
*	End game sequences
*
	XDEF	endwin
endwin:	DCPB	END035,END035,END035,END035,END035,END035
	DCPB	END036,END036
	DCPB	END037,END039,END037,END039,END037,END039
	DCPB	END038,END038,END038,END038
	DCPB	END037,END037,END037,END037,END037
	DCPB	END038,END038,END038,END038
	DCPB	END039,END038,END039,END038
	DCPB	END036,END036,END036
	DCPB	END037,END037,END037
	DCPB	END036,END035,END035,END035,END035
	DCPB	END038,END039,END037,END039,END035
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,endwin

	XDEF	end2nd
end2nd:	DCPB	END050,END050
	DCPB	END053,END053,END053,END053,END053,END053,END053
	DCPB	END054,END054
	DCPB	END053,END053,END053,END053,END053
	DCPB	END050,END050,END050,END050
	DCPB	END051,END052,END051,END052,END051,END052,END051,END052
	DCPB	END051,END050,END050,END050,END050
	DCPB	END053,END053,END053,END053,END053,END053,END053,END053
	DCPB	END054,END054,END054
	DCPB	END055,END055,END055,END055,END055,END055,END055,END055
	DCPB	END050
	DCAC	ASC_PAUSE,4
	DCAC	ASC_RANDOM,16
	DCACP	ASC_LOOP,end2nd

	XDEF	mony0
mony0:	DCPB	BUCK000,BUCK001,BUCK002
	DCPB	BUCK003,BUCK004,BUCK005
	DCACP	ASC_LOOP,mony0
	
	XDEF	mony1
mony1:	DCPB	BUCK105,BUCK106,BUCK107,BUCK108
	DCPB	BUCK109,BUCK110,BUCK111,BUCK112
	DCPB	BUCK113,BUCK114
	DCACP	ASC_LOOP,mony1

	XDEF	prize0
prize0:	DCPB	PRZ000

	XDEF	prize1
prize1:	DCPB	PRZ001

	XDEF	prize2
prize2:	DCPB	PRZ002

	XDEF	prize3
prize3:	DCPB	PRZ005

	XDEF	prize4
prize4:	DCPB	PRZ100

	XDEF	prize5
prize5:	DCPB	PRZ101

	XDEF	prize6
prize6:	DCPB	PRZ103

	XDEF	prize7
prize7:	DCPB	PRZ104

	XDEF	prize8
prize8:	DCPB	PRZ105

	XDEF	prize9
prize9:	DCPB	PRZ106


*
*	Animals
*
	XDEF	rhino
rhino:	DCPB	ANML000,ANML001,ANML002
	DCAC	ASC_FREEZE

	XDEF	elephant
elephant:
	DCPB	ANML500

	XDEF	lion
lion:	DCPB	ANML501

*
*	Game Over
*
	XDEF	mask0
mask0:	DCPB	MASK000

	XDEF	mask1
mask1:	DCPB	MASK001

	XDEF	bill0
bill0:	DCPB	BILL300,BILL301,BILL302,BILL303
	DCACP	ASC_LOOP,bill0

	XDEF	bill1
bill1:	DCPB	BILL304,BILL305,BILL306,BILL307
	DCACP	ASC_LOOP,bill1

*
*	Dot go BOOM
*
	XDEF	dotxplo
	XREF	end_dxpl
dotxplo:
	DCPB	DOT301,DOT302,DOT302,DOT304
	DCPB	DOT305,DOT306,DOT307
	DCACP	ASC_SUBSTP,end_dxpl

	PAGE
	XDEF	BLOCK000

	IFEQ	SYSID
	INCLUDE	'[speed.grafix]mobs.equ'
	ENDC

	IFNE	SYSID
	INCLUDE	grafix/mobs.equ
	ENDC

	END
