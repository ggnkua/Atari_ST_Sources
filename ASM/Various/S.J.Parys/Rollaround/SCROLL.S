*-------------------------------------------------------------------------

SCROLL		MOVE.W	#15,D7
		MOVE.L	PSEUDO,A3
		ADDA.L	#29592,A3	START POS
AD		MOVE.L	A3,A2		STORE
		MOVE.L	(A3)+,STORSHIFT
		MOVE.L	(A3)+,STORSHIFT+4

		LEA	STORSHIFT,A3	START OF LINE
		MOVEQ	#0,D1
		
		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 1
		ROXR	#1,D2
		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 2
		ROXR	#1,D2
		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 3
		ROXR	#1,D2
		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 4
		ROXL	#4,D2
		EXG	D2,D1
		MOVEQ	#0,D2

		MOVE.L	A2,A3
		SUBA.L	#152,A3		NEXT WORD ON SCREEN
		MOVE.W	#19,D0		COUNT
SLOP		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 1
		ROXR	#1,D2
		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 2
		ROXR	#1,D2
		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 3
		ROXR	#1,D2
		ROXR	#1,D1
		ROXR.W	(A3)+		PLANE 4
		ROXL	#4,D2
		EXG	D2,D1
		MOVEQ	#0,D2
		DBF	D0,SLOP
		ADDA.L	#152,A3
		DBF	D7,AD
		RTS

STORSHIFT	DS.B	8

