SPTABLES        DC.B    $80             FLAGS
                DC.B    0
                DC.W    0
                DC.W    144             X CO
                DC.W    40              Y CO
                DC.B    0               SPEED
                DC.B    %00000000       DIRECTION
                DC.L    0               SCREEN ADD
                DC.W    13              BIT MAP POS OF SPRITE
                DC.W    0               32 WIDE 32 HIGH
                DC.B    0
                DC.B    0

S
