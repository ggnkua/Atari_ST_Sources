TREE00		equ	0
TREE1		equ	0
INFO		equ	9
LOAD		equ	18
SAVE		equ	19
QUIT		equ	21
DESK		equ	3
FILE		equ	4
OPTIONS		equ	5
SELECTS		equ	6
OPTION1		equ	23
OPTION2		equ	24
OPTION3		equ	25
ONOFF		equ	27
SELECT1		equ	29
SELECT2		equ	30
SELECT3		equ	31

