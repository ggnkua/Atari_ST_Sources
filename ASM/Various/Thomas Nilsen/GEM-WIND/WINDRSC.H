/* Resource file indices for WINDRSC. */

#define FORM1            0   /* Form/Dialog-box */
#define EXIT_BUTTON      1   /* BOXTEXT in tree FORM1 */
#define FORM_2           2   /* BOXTEXT in tree FORM1 */
