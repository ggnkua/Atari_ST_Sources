*
*  NEOchrome cut buffer contents (left justified):
*
*    pixels/scanline    = $0040 (bytes/scanline: $0020)
*  # scanlines (height) = $0070
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0700,$0770,$0037,$0070,$0642,$0555,$0331
*      $0357,$0402,$0402,$0402,$0402,$0402,$0402,$0777
*
*

			clr.w	-(sp)
			pea		filename		; create call
			move.w	#$3c,-(sp)
			trap	#1
			lea		8(sp),sp
			move.w	d0,handle
			
			pea		icons
			move.l	#3584,-(sp)
			move.w	handle,-(sp)
			move.w	#$40,-(sp)		; write call
			trap	#1
			lea		12(sp),sp
			
			move.w	handle,-(sp)
			move.w	#$3e,-(sp)		; close call
			trap	#1
			lea		4(sp),sp
			
			clr.w	-(sp)
			trap	#1
			
			
			
filename	dc.b	'menuicon.bin',0
handle		dc.w	0
icons
	dc.w	$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$8001,$8001,$8001,$8001,$8001,$8001,$8001,$8001
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$87E1,$87E1,$87E1,$87E1,$8001,$8001,$8001,$8001
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$8FF1,$8FF1,$8FF1,$8FF1,$8001,$8001,$8001,$8001
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$9C39,$9C39,$9C39,$9C39,$8001,$8001,$8001,$8001
	dc.w	$9FE2,$9FE2,$9FE2,$9FE2,$9FE2,$9FE2,$9FE2,$9FE2
	dc.w	$B81D,$B81D,$B81D,$B81D,$8811,$8811,$8811,$8811
	dc.w	$8002,$8002,$8002,$8002,$8002,$8002,$8002,$8002
	dc.w	$B00D,$B00D,$B00D,$B00D,$9819,$9819,$9819,$9819
	dc.w	$8FE2,$8FE2,$8FE2,$8FE2,$8FE2,$8FE2,$8FE2,$8FE2
	dc.w	$B00D,$B00D,$B00D,$B00D,$BFFD,$BFFD,$BFFD,$BFFD
	dc.w	$9832,$9832,$9832,$9832,$9832,$9832,$9832,$9832
	dc.w	$B00D,$B00D,$B00D,$B00D,$BFFD,$BFFD,$BFFD,$BFFD
	dc.w	$B21A,$B21A,$B21A,$B21A,$B39A,$B39A,$B39A,$B39A
	dc.w	$B00D,$B00D,$B00D,$B00D,$9819,$9819,$9819,$9819
	dc.w	$A20A,$A20A,$A20A,$A20A,$A40A,$A40A,$A40A,$A40A
	dc.w	$B82D,$B82D,$B82D,$B82D,$8811,$8811,$8811,$8811
	dc.w	$A20A,$A20A,$A20A,$A20A,$A30A,$A30A,$A30A,$A30A
	dc.w	$9C3D,$9C3D,$9C3D,$9C3D,$8001,$8001,$8001,$8001
	dc.w	$A20A,$A20A,$A20A,$A20A,$A08A,$A08A,$A08A,$A08A
	dc.w	$8E39,$8E39,$8E39,$8E39,$8001,$8001,$8001,$8001
	dc.w	$A38A,$A38A,$A38A,$A38A,$A70A,$A70A,$A70A,$A70A
	dc.w	$873D,$873D,$873D,$873D,$8001,$8001,$8001,$8001
	dc.w	$A00A,$A00A,$A00A,$A00A,$A00A,$A00A,$A00A,$A00A
	dc.w	$8001,$8001,$8001,$8001,$8001,$8001,$8001,$8001
	dc.w	$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8001,$8001,$8001,$8001,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8181,$8181,$8181,$8181,$1FE1,$1FE1,$1FE1,$1FE1
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$83C1,$83C1,$83C1,$83C1,$2011,$2011,$2011,$2011
	dc.w	$8EE7,$8EE7,$8EE7,$8EE7,$73F9,$73F9,$73F9,$73F9
	dc.w	$87E1,$87E1,$87E1,$87E1,$4009,$4009,$4009,$4009
	dc.w	$8BA5,$8BA5,$8BA5,$8BA5,$D209,$D209,$D209,$D209
	dc.w	$8181,$8181,$8181,$8181,$4FC9,$4FC9,$4FC9,$4FC9
	dc.w	$89A4,$89A4,$89A4,$89A4,$92F9,$92F9,$92F9,$92F9
	dc.w	$8181,$8181,$8181,$8181,$4FC9,$4FC9,$4FC9,$4FC9
	dc.w	$8AA5,$8AA5,$8AA5,$8AA5,$5211,$5211,$5211,$5211
	dc.w	$8181,$8181,$8181,$8181,$4009,$4009,$4009,$4009
	dc.w	$8B25,$8B25,$8B25,$8B25,$D2F1,$D2F1,$D2F1,$D2F1
	dc.w	$8181,$8181,$8181,$8181,$4009,$4009,$4009,$4009
	dc.w	$8BA5,$8BA5,$8BA5,$8BA5,$5281,$5281,$5281,$5281
	dc.w	$8181,$8181,$8181,$8181,$4FC9,$4FC9,$4FC9,$4FC9
	dc.w	$8EE7,$8EE7,$8EE7,$8EE7,$7381,$7381,$7381,$7381
	dc.w	$8181,$8181,$8181,$8181,$4849,$4849,$4849,$4849
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$87E1,$87E1,$87E1,$87E1,$4849,$4849,$4849,$4849
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$83C1,$83C1,$83C1,$83C1,$4849,$4849,$4849,$4849
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8181,$8181,$8181,$8181,$7879,$7879,$7879,$7879
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8001,$8001,$8001,$8001,$0001,$0001,$0001,$0001
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0FFD,$0FFD,$0FFD,$0FFD
	dc.w	$BFF0,$BFF0,$BFF0,$BFF0,$0001,$0001,$0001,$0001
	dc.w	$83C0,$83C0,$83C0,$83C0,$0805,$0805,$0805,$0805
	dc.w	$A010,$A010,$A010,$A010,$03C1,$03C1,$03C1,$03C1
	dc.w	$8420,$8420,$8420,$8420,$8805,$8805,$8805,$8805
	dc.w	$A011,$A011,$A011,$A011,$0421,$0421,$0421,$0421
	dc.w	$89D0,$89D0,$89D0,$89D0,$C805,$C805,$C805,$C805
	dc.w	$A011,$A011,$A011,$A011,$89D1,$89D1,$89D1,$89D1
	dc.w	$8A13,$8A13,$8A13,$8A13,$E805,$E805,$E805,$E805
	dc.w	$A017,$A017,$A017,$A017,$CA11,$CA11,$CA11,$CA11
	dc.w	$8A13,$8A13,$8A13,$8A13,$E805,$E805,$E805,$E805
	dc.w	$A017,$A017,$A017,$A017,$CA11,$CA11,$CA11,$CA11
	dc.w	$89D0,$89D0,$89D0,$89D0,$C805,$C805,$C805,$C805
	dc.w	$A011,$A011,$A011,$A011,$89D1,$89D1,$89D1,$89D1
	dc.w	$8420,$8420,$8420,$8420,$8805,$8805,$8805,$8805
	dc.w	$A011,$A011,$A011,$A011,$0421,$0421,$0421,$0421
	dc.w	$83C0,$83C0,$83C0,$83C0,$0805,$0805,$0805,$0805
	dc.w	$A010,$A010,$A010,$A010,$03C1,$03C1,$03C1,$03C1
	dc.w	$8000,$8000,$8000,$8000,$0FFD,$0FFD,$0FFD,$0FFD
	dc.w	$BFF0,$BFF0,$BFF0,$BFF0,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0001,$0001,$0001,$0001
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$8001,$8001,$8001,$8001,$9819,$9819,$9819,$9819
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$8019,$8019,$8019,$8019,$A425,$A425,$A425,$A425
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$803D,$803D,$803D,$803D,$A425,$A425,$A425,$A425
	dc.w	$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12,$9F12
	dc.w	$803D,$803D,$803D,$803D,$9BD9,$9BD9,$9BD9,$9BD9
	dc.w	$9FE2,$9FE2,$9FE2,$9FE2,$9FE2,$9FE2,$9FE2,$9FE2
	dc.w	$8399,$8399,$8399,$8399,$8521,$8521,$8521,$8521
	dc.w	$8002,$8002,$8002,$8002,$8002,$8002,$8002,$8002
	dc.w	$87C1,$87C1,$87C1,$87C1,$8911,$8911,$8911,$8911
	dc.w	$8FE2,$8FE2,$8FE2,$8FE2,$8FE2,$8FE2,$8FE2,$8FE2
	dc.w	$8F81,$8F81,$8F81,$8F81,$9109,$9109,$9109,$9109
	dc.w	$9832,$9832,$9832,$9832,$9832,$9832,$9832,$9832
	dc.w	$9F01,$9F01,$9F01,$9F01,$9189,$9189,$9189,$9189
	dc.w	$B21A,$B21A,$B21A,$B21A,$B39A,$B39A,$B39A,$B39A
	dc.w	$BE01,$BE01,$BE01,$BE01,$91E9,$91E9,$91E9,$91E9
	dc.w	$A20A,$A20A,$A20A,$A20A,$A40A,$A40A,$A40A,$A40A
	dc.w	$BC01,$BC01,$BC01,$BC01,$9009,$9009,$9009,$9009
	dc.w	$A20A,$A20A,$A20A,$A20A,$A30A,$A30A,$A30A,$A30A
	dc.w	$BC01,$BC01,$BC01,$BC01,$9009,$9009,$9009,$9009
	dc.w	$A20A,$A20A,$A20A,$A20A,$A08A,$A08A,$A08A,$A08A
	dc.w	$9EC1,$9EC1,$9EC1,$9EC1,$8811,$8811,$8811,$8811
	dc.w	$A38A,$A38A,$A38A,$A38A,$A70A,$A70A,$A70A,$A70A
	dc.w	$8F81,$8F81,$8F81,$8F81,$8C31,$8C31,$8C31,$8C31
	dc.w	$A00A,$A00A,$A00A,$A00A,$A00A,$A00A,$A00A,$A00A
	dc.w	$8301,$8301,$8301,$8301,$9BD9,$9BD9,$9BD9,$9BD9
	dc.w	$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC,$7FFC
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0773,$0773,$0773,$0773
	dc.w	$E7E0,$E7E0,$E7E0,$E7E0,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$05D6,$05D6,$05D6,$05D6
	dc.w	$3430,$3430,$3430,$3430,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0495,$0495,$0495,$0495
	dc.w	$D5D0,$D5D0,$D5D0,$D5D0,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0554,$0554,$0554,$0554
	dc.w	$1430,$1430,$1430,$1430,$0001,$0001,$0001,$0001
	dc.w	$83E0,$83E0,$83E0,$83E0,$05D5,$05D5,$05D5,$05D5
	dc.w	$D5E0,$D5E0,$D5E0,$D5E0,$0EE1,$0EE1,$0EE1,$0EE1
	dc.w	$8630,$8630,$8630,$8630,$0555,$0555,$0555,$0555
	dc.w	$5500,$5500,$5500,$5500,$0AA1,$0AA1,$0AA1,$0AA1
	dc.w	$85D0,$85D0,$85D0,$85D0,$0777,$0777,$0777,$0777
	dc.w	$7700,$7700,$7700,$7700,$0BA1,$0BA1,$0BA1,$0BA1
	dc.w	$8410,$8410,$8410,$8410,$0800,$0800,$0800,$0800
	dc.w	$0010,$0010,$0010,$0010,$0821,$0821,$0821,$0821
	dc.w	$85D0,$85D0,$85D0,$85D0,$1800,$1800,$1800,$1800
	dc.w	$0018,$0018,$0018,$0018,$0BA1,$0BA1,$0BA1,$0BA1
	dc.w	$8550,$8550,$8550,$8550,$3FFF,$3FFF,$3FFF,$3FFF
	dc.w	$FFFC,$FFFC,$FFFC,$FFFC,$0AA1,$0AA1,$0AA1,$0AA1
	dc.w	$8770,$8770,$8770,$8770,$3FFF,$3FFF,$3FFF,$3FFF
	dc.w	$FFFC,$FFFC,$FFFC,$FFFC,$0EE1,$0EE1,$0EE1,$0EE1
	dc.w	$8000,$8000,$8000,$8000,$1800,$1800,$1800,$1800
	dc.w	$0018,$0018,$0018,$0018,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0800,$0800,$0800,$0800
	dc.w	$0010,$0010,$0010,$0010,$0001,$0001,$0001,$0001
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$FE70,$FE70,$FE70,$FE70,$7CEE,$7CEE,$7CEE,$7CEE
	dc.w	$FEFE,$FEFE,$FEFE,$FEFE,$7EFF,$7EFF,$7EFF,$7EFF
	dc.w	$C350,$C350,$C350,$C350,$C6AA,$C6AA,$C6AA,$C6AA
	dc.w	$8282,$8282,$8282,$8282,$C283,$C283,$C283,$C283
	dc.w	$DD50,$DD50,$DD50,$DD50,$BABA,$BABA,$BABA,$BABA
	dc.w	$EEBE,$EEBE,$EEBE,$EEBE,$BCEF,$BCEF,$BCEF,$BCEF
	dc.w	$C350,$C350,$C350,$C350,$82D6,$82D6,$82D6,$82D6
	dc.w	$2884,$2884,$2884,$2884,$C629,$C629,$C629,$C629
	dc.w	$DE5E,$DE5E,$DE5E,$DE5E,$BA6C,$BA6C,$BA6C,$BA6C
	dc.w	$28BE,$28BE,$28BE,$28BE,$7A29,$7A29,$7A29,$7A29
	dc.w	$D042,$D042,$D042,$D042,$AA28,$AA28,$AA28,$AA28
	dc.w	$2882,$2882,$2882,$2882,$8629,$8629,$8629,$8629
	dc.w	$F07E,$F07E,$F07E,$F07E,$EE38,$EE38,$EE38,$EE38
	dc.w	$38FE,$38FE,$38FE,$38FE,$FC39,$FC39,$FC39,$FC39
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$FE3E,$FE3E,$FE3E,$FE3E,$3F3F,$3F3F,$3F3F,$3F3F
	dc.w	$773C,$773C,$773C,$773C,$FCFD,$FCFD,$FCFD,$FCFD
	dc.w	$C363,$C363,$C363,$C363,$6161,$6161,$6161,$6161
	dc.w	$5566,$5566,$5566,$5566,$8687,$8687,$8687,$8687
	dc.w	$DD5D,$DD5D,$DD5D,$DD5D,$5F5F,$5F5F,$5F5F,$5F5F
	dc.w	$5D5A,$5D5A,$5D5A,$5D5A,$BABB,$BABB,$BABB,$BABB
	dc.w	$C341,$C341,$C341,$C341,$6363,$6363,$6363,$6363
	dc.w	$555A,$555A,$555A,$555A,$86AB,$86AB,$86AB,$86AB
	dc.w	$DE5D,$DE5D,$DE5D,$DE5D,$7D7D,$7D7D,$7D7D,$7D7D
	dc.w	$495A,$495A,$495A,$495A,$AEBB,$AEBB,$AEBB,$AEBB
	dc.w	$D055,$D055,$D055,$D055,$4343,$4343,$4343,$4343
	dc.w	$5D66,$5D66,$5D66,$5D66,$B287,$B287,$B287,$B287
	dc.w	$F077,$F077,$F077,$F077,$7E7E,$7E7E,$7E7E,$7E7E
	dc.w	$773C,$773C,$773C,$773C,$FEFD,$FEFD,$FEFD,$FEFD
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$8000,$8000,$8000,$8000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0001,$0001
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	dc.w	$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF

