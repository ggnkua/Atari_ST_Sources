help_text	dc.b	"WELCOME TO THE FRED'S FIND EDITOR HELP"
		dc.b	"                                      "
		dc.b	" TO SELECT A TOPIC CLICK ON THE WORD  "
		dc.b	"   IN THE ARROWS, OR USE THE SCROLL   "
		dc.b	"         WINDOW SCROLL ARROWS.        "
		dc.b	"                                      "
		dc.b	"          bMAP MODIFICAIONSa          "
		dc.b	"           bICON SELECTIONa           "
		dc.b	"           bPASSWORD ENTRYa           "
		dc.b	"         bSETTING LEVEL TIMEa         "
		dc.b	"      bVIEWING MAP INFORMATIONa       "
		dc.b	"        bPLAYTESTING A LEVELa         "
		dc.b	"      bVIEWING SCREEN FULLSIZEa       "
		dc.b	"         bTHE FILE SELECTORa          "
		dc.b	"                                      "
		dc.b	"      bCHARACTER MODIFICATIONSa       "
		dc.b	"      bCHARACTER SCROLL ARROWSa       "
		dc.b	"          bCOLOUR SELECTIONa          "
		dc.b	"        bCOLOUR MODIFICATIONa         "
		dc.b	"           bICON SELECTIONa           "
		dc.b	"        bCHARACTER ANIMATIONa         "
		dc.b	"  bCHARACTER ROTATION AND FLIPPINGa   "
		dc.b	"        bCHARACTER COPY/PASTEa        "
		dc.b	"                                      "
		dc.b	"           bPROGRAM CREDITSa          "
		dc.b	"                                      "
		dc.b	"                                      "
		dc.b	"                                      "
		dc.b	"                                      "
		dc.b	"MAP MODIFICATIONS.                    "
		dc.b	"------------------                    "
		dc.b	"THE CURRENTLY SELECTED MAP CAN BE     "
		dc.b	"MODIFIED BY THE USE OF THE LEFT AND   "
		dc.b	"RIGHT MOUSE BUTTONS. JUST MOVE THE    "
		dc.b	"MOUSE POINTER ONTO THE DESIRED UNIT   "
		dc.b	"YOU WISH TO CHANGE, AND PRESS THE     "
		dc.b	"CORRECT BUTTON. THE LEFT MOUSE BUTTON "
		dc.b	"WILL OVERWRITE WITH THE ICON CURRENTLY"
		DC.B	"SELECTED FOR THE LEFT BUTTON, WHILE   "
		DC.B	"THE RIGHT BUTTON WITH THE ONE SELECTED"
		DC.B	"FOR THAT BUTTON.                      "
		DC.B	"THE MAP CAN BE FAST PASTED BY KEEPING "
		DC.B	"A BUTTON PRESSED AND DRAGGING THE     "
		DC.B	"MOUSE OVER THE DISPLAY, CHANGING ALL  "
		DC.B	"UNITS OVER WHICH THE POINTER PASSES.  "
		DC.B	"                                      "
		DC.B	"SOME ICONS HAVE LIMITED NUMBERS AS TO "
		DC.B	"THE MAXIMUM THAT CAN APPEAR IN ANY MAP"
		DC.B	"THESE ARE :                           "
		DC.B	"     FRED..................1          "
		DC.B	"     PULSATORS/CAGES.......8          "
		DC.B	"     EGGS/MONSTERS.........4          "
		DC.B	"     TRANSPORTERS..........4          "
		DC.B	"                                      "
		DC.B	"ANY ATTEMPT TO PLACE THESE WHEN THERE "
		DC.B	"ARE THE MAXIMUM ALREADY PRESENT WILL  "
		DC.B	"RESULT IN NO CHANGE BEING MADE.       "
		DC.B	"                                      "
		DC.B	"WHEN PLACING TRANSPORTERS, IT REQUIRES"
		DC.B	"TWO BUTTON PRESS'S. THE FIRST FOR THE "
		DC.B	"TRANSPORTER LOCATION, AND THE SECOND  "
		DC.B	"FOR THE DESTINATION.                  "
		DC.B	"TRANSPORTERS HAVE THEIR DESTINATIONS  "
		DC.B	"SHOWN BY THE USE OF FLASHING LETTERS  "
		DC.B	"ON THE SOURCE/DESTINATION UNITS.      "
		DC.B	"PULSATORS HAVE FLASHING ARROWS SHOWING"
		DC.B	"THE INITIAL DIRECTION IT WILL TAKE    "
		DC.B	"WHEN PLAY COMMENCES.                  "
		DC.B	"                                      "
