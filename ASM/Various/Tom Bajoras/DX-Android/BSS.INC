  XREF x1
  XREF x2
  XREF x3
  XREF x4
  XREF x5
  XREF y1
  XREF y2
  XREF wkspace
  XREF wksname
  XREF edspace
  XREF wkbank
  XREF wkbname
  XREF wwkbank
  XREF wwkbname
  XREF midich
  XREF midichs
  XREF qustat
  XREF muteflag
  XREF cursory
  XREF filebuf
  XREF diskbuf
  XREF indbuf1
  XREF indbuf2
  XREF namebuf
  XREF synbuf
  XREF catbuf
  XREF fileflg
  XREF fillock
  XREF indflg
  XREF filenam
  XREF nbanks
  XREF bankflg
  XREF banknam
  XREF bslotnm
  XREF bnamflg
  XREF nfiles
  XREF nfillok
  XREF nfilind
  XREF lowascii
  XREF ofstaddr
  XREF fontaddr
  XREF formleng
  XREF formhigh
  XREF vdiaddr
  XREF colorsav
  XREF bwflag
  XREF scrarray
  XREF colarray
  XREF menuaddr
  XREF lastmenu
  XREF lastbank
  XREF midiaddr
  XREF kbaddr
  XREF revtabl
  XREF startrez
  XREF startpal
  XREF startimg
  XREF monws
  XREF monedit
  XREF invtext
  XREF forceinv
  XREF ghostch
  XREF noblank
  XREF mousvec
  XREF vblsave
  XREF prtargs
  XREF toneflag
  XREF testones
  XREF tonestat
  XREF allowlc
  XREF allowms
  XREF edmenflg
  XREF thruflag
  XREF txatten
  XREF currdrv
