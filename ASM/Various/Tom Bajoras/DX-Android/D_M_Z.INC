 XREF xmax
 XREF ymax
 XREF nmline
 XREF ncline
 XREF menuflg
 XREF nmenu
 XREF menufmt
 XREF menuhed
 XREF menuphed
 XREF mhedlen
 XREF menuhedl
 XREF menu1
 XREF menu2
 XREF menu3
 XREF menu4
 XREF menu5
 XREF menu6
 XREF menu7
 XREF menu8
 XREF nmencol1
 XREF nmencol2
 XREF menuprp
 XREF mprlen
 XREF menulen
 XREF maxfile
 XREF maxbank
 XREF maxmidi
 XREF maxslot
 XREF mencol1x
 XREF mencol2x
 XREF mencol3x
 XREF menmargn
 XREF messss
 XREF messsl
 XREF messs2
 XREF messsl2
 XREF versmess
 XREF versmesl
 XREF reason
 XREF reasonl
 XREF prompt
 XREF promptl
 XREF wkbnx
 XREF strtmes
 XREF strtmesl
 XREF startmon
 XREF startcol
 XREF parmess
 XREF parmesl
 XREF parmes2
 XREF parmes2l
 XREF parminfo
 XREF val_lrc
 XREF val_md
 XREF val_cfq1
 XREF val_cfq2
 XREF val_dtn
 XREF val_sync
 XREF val_wave
 XREF val_tr
 XREF val_prt1
 XREF val_prt2
 XREF val_mw
 XREF val_bp
 XREF prttabl
