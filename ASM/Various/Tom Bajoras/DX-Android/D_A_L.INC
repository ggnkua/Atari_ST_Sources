  XREF ascif1
  XREF ascif9
  XREF ascif10
  XREF ascibs
  XREF ascicr
  XREF ascidel
  XREF ascilef
  XREF ascirit
  XREF asciup
  XREF ascidwn
  XREF ascisp
  XREF asciy
  XREF ascin
  XREF ascih
  XREF ascii
  XREF ascil
  XREF asciper
  XREF asci9
  XREF asci0
  XREF ascia
  XREF ascib
  XREF ascic
  XREF asciline
  XREF ascibsl
  XREF asciast
  XREF ascihelp
  XREF ascihome
  XREF asciesc
  XREF asciundo
  XREF asciins
  XREF ascitab
  XREF ascidash
  XREF ascilpr
  XREF ascirpr
  XREF asciplus
  XREF ascis
  XREF asciw
  XREF asciless
  XREF ascie
  XREF ascimlef
  XREF ascimrit
  XREF asciu
  XREF ascid
  XREF ascip
  XREF ascix
  XREF asciz
  XREF ascim
  XREF ascir

  XREF color1a
  XREF color1b
  XREF color2
  XREF colorbw
  XREF cbakgnd
  XREF cecho
  XREF cprompt
  XREF ccurmen
  XREF cmenu
  XREF cmenkey
  XREF cmenhed
  XREF cmessge
  XREF coutlne
  XREF cstart
  XREF catfmt
  XREF catmess
  XREF catmesl
  XREF lprime
  XREF initname
  XREF and1name
  XREF and2name
  XREF initsnd
  XREF bankkey
  XREF bankkeyn
  XREF indmess
  XREF indmesl
  XREF bnkmess
  XREF bnkmesl
  XREF dxosid
  XREF dxmess1
  XREF dxmess2
  XREF dxmess3
  XREF infomess
  XREF infomesl
  XREF editmess
  XREF editmesl
  XREF cursinfo
  XREF cursinf2
  XREF dummycol
  XREF avname
  XREF glname
  XREF distname
  XREF dxsetup
  XREF dxsetl
  XREF dxunset
  XREF dxunl
  XREF disttabl
