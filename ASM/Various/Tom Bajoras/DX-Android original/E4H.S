;*****************************************************************************;
;   module 4h source file    Copyright 1986 Tom Bajoras
;   droid menu command branching routine: br8anch
;*****************************************************************************;

 .text

;*****************************************************************************;
;   br8anch
;      x1 = itemx
;*****************************************************************************;

 .global br8anch

br8anch 	rts
