
* Ein GEM-Demo-Programm

* Sie k”nnen Teile oder alles aus diesem Programm verwenden

* Es soll haupts„chlich der GEM-Aufruf in Assembler
* gezeigt werden. Das Programm selbst tut nicht allzuviel.        

* Letzte Žnderung: 27.1.86

	opt d+				Labels f�r Debugger

* Der Include-File ist wichtig, soll aber nicht
	bra main			ausgef�hrt werden

	include geminc.s

* the program proper
main	do_start			Init. RAM und Stack
	bsr initvdipars			und die VDI-Arrays
	bsr initgempars			und die AES-Arrays
	gem APPL_INIT
	move.w d0,ap_id(a6)		Applikations-ID sichern
* Hole Handle der aktuellen Workstation
	gem GRAF_HANDLE
	move.w d0,contrl+12(a6)         da ist Handle sicher
* und ”ffne damit virtuelle Workstation
	move.l #$00010001,d0
	move.l d0,intin(a6)		Die meisten Parameters = 1
	move.l d0,intin+4(a6)
	move.l d0,intin+8(a6)
	move.l d0,intin+12(a6)
	move.l d0,intin+16(a6)
	move.w #2,intin+20(a6)		RC-System muž sein
	clr.w contrl+2(a6)
	move.w #11,contrl+6(a6)
	vdi V_OPNVWK			Nun ”ffnen
	move.w contrl+12(a6),d0		Die Handle
	move.w d0,ws_handle(a6)		sichern

* Mauszeiger soll Pfeil werden
	clr.w int_in(a6)		0 heižt Pfeil
	clr.l addr_in(a6)
	gem GRAF_MOUSE

* Wir wollen ein Window ”ffnen, ben”tigen daf�r Gr”že der Workstation
	clr.w int_in(a6)		0 = Desktop-Handle
	move.w #4,int_in+2(a6)		Funktion "Bereich holen"
	gem WIND_GET			hole seine Gr”že

* Bits f�r Window-Typ
wtype	equ %000000101111		title, close, full, move, size

* Gr”že ist in int_out(1..4), rechne Window-Gr”že
	move.w #1,int_in(a6)		Bereich festlegen
	move.w #wtype,int_in+2(a6)	Window mit allen Features
	movem.w int_out+2(a6),d0-d3     Gr”že von Workstation
	movem.w d0-d3,int_in+4(a6)	     �bergeben
	gem WIND_CALC                   GEM rechnet f�r uns

* Nun hole Offsets des Windows
	move.w int_out+2(a6),xstart(a6)
	move.w int_out+4(a6),ystart(a6)
	move.w int_out+6(a6),xwidth(a6)
	move.w int_out+8(a6),ywidth(a6)

* und kreiere da Window
	move.w #wtype,int_in(a6)	alle Features
	movem.w int_out+2(a6),d0-d3
	movem.w d0-d3,int_in+2(a6)	die Gr”že
	gem WIND_CREATE			Funktion aufrufen
	move.w d0,w_handle(a6)		Handle sichern

* Fenster-Titel setzen
	move.w d0,int_in(a6)            Handle
	move.w #2,int_in+2(a6)		Titel-String setzen
	lea windowname(pc),a0
	move.l a0,int_in+4(a6)		Die Addresse
	gem WIND_SET

* Nun zeige das Fenster, indem es ge”ffnet wird
	move.w w_handle(a6),int_in(a6)
	movem.w xstart(a6),d0-d3
	add.w #10,d0			X-Start
	add.w #10,d1			Y-Start
	sub.w #20,d2			Breite
	sub.w #20,d3			H”he
	movem.w d0-d3,int_in+2(a6)	Gr”že
	gem WIND_OPEN			™ffne es
	bsr recalcwindow
	bsr setupmode

* Die Hauptschleife
* Wir warten nur auf Events vom Typ Message
waitforevent
	lea messagebuf(a6),a0
	move.l a0,addr_in(a6)
	gem EVNT_MESAG			Hole die  Message
	lea messagebuf(a6),a0
	move.w (a0),d0			Message-Typ
	cmp.w #20,d0
	beq updateit			wenn Redraw
	cmp.w #22,d0
	beq quit			wenn Close-Box
	cmp.w #23,d0
	beq fullit			wenn volle-Gr”že-Box
	cmp.w #27,d0
	beq sizeit			wenn Gr”žen-Box
	cmp.w #28,d0
	beq moveit			wenn Window verschoben

* nichts, was mich interessiert, also von vorn
	bra waitforevent

* Window verschieben
moveit	move.w 6(a0),d0
	cmp.w w_handle(a6),d0
	bne waitforevent		wenn nicht mein Window, nicht
changedwindow
	move.w d0,int_in(a6)
	move.w #5,int_in+2(a6)
	move.w 8(a0),int_in+4(a6)	neues x 
	move.w 10(a0),int_in+6(a6)	neues y 
	move.w 12(a0),d0
	cmp.w #40,d0
	bcc.s widok
	moveq #40,d0			nicht schmaler als 40
widok	move.w d0,int_in+8(a6)		Breite
	move.w 14(a0),d0
	cmp.w #50,d0
	bcc.s hiteok
	moveq #50,d0			nicht flacher als 50
hiteok	move.w d0,int_in+10(a6)		H”he
	gem WIND_SET			setze Window
	movem.w xwidth(a6),d4-d5	alte Gr”že
	bsr recalcwindow
	cmp.w xwidth(a6),d4
	bcs waitforevent
	cmp.w ywidth(a6),d5
	bcs waitforevent
	bne.s forceupdate
	cmp.w xwidth(a6),d4
	beq waitforevent		nicht, wenn das gleiche
* Wenn neue Gr”že kleiner in beiden Dimensionen als alte Gr”že,
* wird ein Update-Event nicht beachtet. Daher  muž "re-draw" 
* programmiert werden!
forceupdate
	bsr drawwindow			zeichne Window
	bra waitforevent		und zur Hauptschleife

* Neue Gr”že f�r Window
sizeit	move.w 6(a0),d0
	cmp.w w_handle(a6),d0
	bne waitforevent		wenn nicht mein Window
	bra.s changedwindow

* Da ist ein  Update-Event
updateit
	move.w 6(a0),d0
	cmp.w w_handle(a6),d0
	bne waitforevent		wenn nicht mein Window
* Es gibt zwei Arten Updates zu behandeln:
* (a) f�r �berlappende  Windows,
* was viele Code braucht, langsam und tricky ist.
* (b) Die M”glichkeit des šberlappens zu ignorieren,
* was wenig Code braucht und einfach ist.
* Wir nehmen Methode (b)! Methode (a) ist im Window-Kapitel
* des DR-GEM-Manuals beschrieben.

* Beginne mit Clipping des Rechtecks
	movem.w 8(a0),d0-d3		das Rechteck
	add.w d0,d2
	add.w d1,d3
	movem.w d0-d3,ptsin(a6)
	move.w #2,contrl+2(a6)
	move.w #1,contrl+6(a6)
	move.w ws_handle(a6),contrl+12(a6)
	st intin(a6)			Clipping an
	vdi VS_CLIP			und "Clippe"
	bsr drawwindow			Window zeichnen
	bra waitforevent

* Die Box "volle Gr”že" wurde angeklickt
* Unser Programm malt dann eine Alarm-Box
fullit
	move.w #1,int_in(a6)		1. Knopf = Return
	lea myalert(pc),a0
	move.l a0,addr_in(a6)		 alert definition
	gem FORM_ALERT
	bra waitforevent

* Nun die R�ckzugsgefechte
* Beginne mit Schliežen des Fensters
quit	move.w w_handle(a6),int_in(a6)
	gem WIND_CLOSE			schliežen
	gem WIND_DELETE			und l”schen
* Nun Schliežen der  virtuellen Workstation
	clr.w contrl+2(a6)
	clr.w contrl+6(a6)
	move.w ws_handle(a6),contrl+12(a6)
	vdi V_CLSVWK			schlieže
	gem APPL_EXIT			sage GEM, wir sind fertig
* Nun zur�ck zum Desk Top
	clr.w -(a7)			Status-Code
	move.w #$4c,-(a7)		P_TERM
	trap  #1		       und Ende

* Rechne Work Žrea des Windows
recalcwindow
	move.w w_handle(a6),int_in(a6)
	move.w #4,int_in+2(a6)		work area ermitteln
	gem WIND_GET
	movem.w int_out+2(a6),d0-d3
	movem.w d0-d3,xstart(a6)
	rts

* Male den Fenster-Inhalt
* Wird ein Oval in einem Rechteck

* Vor dem Zeichnen immer Mauszeiger abschalten
drawwindow
	clr.l contrl+2(a6)
	move.w ws_handle(a6),contrl+12(a6)
	vdi V_HIDE_C			Verstecke Maus
	clr.w contrl+2(a6)
	move.w #1,contrl+6(a6)
	move.w #2,intin(a6)		Pattern bitte
	vdi VSF_INTERIOR
	move.w #2,contrl+2(a6)
	clr.w contrl+6(a6)
	move.w ws_handle(a6),contrl+12(a6)
	movem.w xstart(a6),d0-d3
	add.w d0,d2
	subq.w #1,d2
	add.w d1,d3
	subq.w #1,d3
	movem.w d0-d3,ptsin(a6)		Das Rechteck
	vdi VR_RECFL			Gef�lltes Rechteck
* Das Oval, in das unser Pattern soll
	clr.w contrl+2(a6)
	move.w #1,contrl+6(a6)
	move.w #4,intin(a6)
	vdi VSF_INTERIOR		F�ll-Stil
	move.w #2,contrl+2(a6)
	clr.w contrl+6(a6)
	move.w #5,contrl+10(a6)
	move.w ws_handle(a6),contrl+12(a6)
	movem.w xstart(a6),d0-d3
	asr.w #1,d2			Halbe Breite
	asr.w #1,d3			Halbe H”he
	add.w d2,d0			X-Mitte
	add.w d3,d1			Y-Mitte
	movem.w d0-d3,ptsin(a6)
	vdi V_GDP			GDP-Ellipse
* Zeichnen fertig, also Maus wieder an
	clr.w contrl+2(a6)
	move.w #1,contrl+6(a6)
	clr.w intin(a6)
	vdi V_SHOW_C			Zeige Mauszeiger
	rts

* Hier wird der Zeichenmodus vorbereitet u.s.w.
setupmode
	clr.w contrl+2(a6)
	move.w #16,contrl+6(a6)
	move.w ws_handle(a6),contrl+12(a6)
	move.w #%0000100101000000,intin(a6)
	move.w #%0000100101000000,intin+2(a6)
	move.w #%0000111101000000,intin+4(a6)
	move.w #%0000100101000000,intin+6(a6)
	move.w #%0000100101000000,intin+8(a6)
	move.w #%0000000000000000,intin+10(a6)
	move.w #%0110010011011100,intin+12(a6)
	move.w #%1000101010001000,intin+14(a6)
	move.w #%1100101011001000,intin+16(a6)
	move.w #%0010101010001000,intin+18(a6)
	move.w #%1100010010001000,intin+20(a6)
	clr.l intin+22(a6)
	clr.l intin+26(a6)
	clr.w intin+30(a6)
	vdi VSF_UDPAT			setze unser F�llmuster
	clr.w contrl+2(a6)
	move.w #1,contrl+6(a6)
	move.w #1,intin(a6)
	vdi VSF_COLOR			Nehme "Farbe" 1
	rts

* Alle C-Strings m�ssen 0-terminiert sein
windowname dc.b ' Ein GEM-Beispielprogramm von HiSoft ',0

myalert dc.b "[1][Dieses Programm ist in 68000-|Assembler mit HiSofts|"
	dc.b 'DevpacST Entwicklungssystem|geschrieben worden][ OK ]',0

* globale Variable, Zugriff �ber A6

* Diese m�ssen zusammenbleiben
xstart	rs.w 1
ystart	rs.w 1
xwidth	rs.w 1
ywidth	rs.w 1

w_handle	rs.w 1
ws_handle	rs.w 1
ap_id		rs.w 1
messagebuf	rs.b 16

datalength	rs.w 0			unbedingt erforderlich

* Hier Daten, Zugriff �ber A6
datastart	nop

	end




