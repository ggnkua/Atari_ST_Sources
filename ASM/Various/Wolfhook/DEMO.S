
* Ein einfaches Testprogramm
* Es druckt Text auf den Bildschirm, wartet auf einen Tastendruck
* und kehrt zur�ck zum Desktop
*
* Copyright (c) HiSoft 1987
*

	opt d+				Symbole f�r's debuggen

* Die GemDos Konstanten
	include gemdos.s

* Den Text drucken

	pea string(pc)
	call_bdos c_conws
	addq.l #6,a7			Stack aufr„umen

* Auf eine Taste warten
	
	call_bdos c_conin
	addq.l #2,a7

* und aufh”ren

	call_bdos p_term

string	dc.b "Ein einfaches GemDos Programm",13,10
	dc.b "Dr�cken Sie eine Taste...",0

	even				GEMDOS mag Dateien mit gerader
*					L„nge
