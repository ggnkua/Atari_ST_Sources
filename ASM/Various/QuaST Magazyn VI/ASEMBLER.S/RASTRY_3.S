***************************************************************************
* Q u a s t  V I - programowanie w assemblerze							  *
***************************************************************************
* program  		 - rastry III - rastry migaja w rytm muzyki				  *
* autor    		 - Van Eijk											      *
* typ Atari		 - ST/E												      *
***************************************************************************

START:
	clr.l -(sp)				* supervisor
	move.w #$20,-(sp)
	trap #1
	addq.l #6,-(sp)
	move.w #0,-(sp)

	move.l #$78000,-(sp)	* nowy adres ekranu i niska rozdzielczosc
	move.l #$78000,-(sp)
	move.w #5,-(sp)
	trap #14
	add.l #12,sp

	moveq #1,d0
	jsr MUSIC

	move.w #0,$ff8240		* tlo na kolor czarny
	lea $78000,a0
	add.l #68*160,a0
	move.w #64,d0

MALUJ:						* malowania kawalka ekranu po ktorym bedzie
	move.w #$ffff,32(a0)
	move.w #$ffff,40(a0)
	move.w #$ffff,48(a0)	*  przewijany kolorowy raster
	move.w #$ffff,56(a0)
	move.w #$ffff,64(a0)
	move.w #$ffff,72(a0)
	move.w #$ffff,80+2(a0)
	move.w #$ffff,88+2(a0)
	move.w #$ffff,96+2(a0)
	move.w #$ffff,104+2(a0)
	move.w #$ffff,112+2(a0)
	move.w #$ffff,120+2(a0)
	add.l #160,a0
	dbf d0,MALUJ

	move.l #SAFEREG,a0		* zapamietanie wartsci ukladu Mpf
	move.b $fffa07,(a0)+
	move.b $fffa09,(a0)+
	move.b $fffa0b,(a0)+
	move.b $fffa0f,(a0)+
	move.b $fffa13,(a0)+
	move.b $fffa17,(a0)+
	move.b $fffa1b,(a0)+
	move.b $fffa1d,(a0)+
	move.b $fffa21,(a0)+
	move.l $70,OLDVBL		* zapamietanie wektorow starych przerwan
	move.l $120,OLDTIMB	

	move.b #8,$fffa1b		* nowe waertosci do ukladu Mfp
	move.b #1,$fffa21
	ori.b #%00000001,$fffa07
	andi.b #%11011111,$fffa09
	ori.b #%00000001,$fffa13
	move.l #VBL,$70			* nowe procedury pod przerwania
	move.l #TIMER_B,$120

LOOP:						* oczekiwanie na klawisz
	cmp.b #185,$fffc02
	bne.s LOOP

	move.l #SAFEREG,a0		* zwrocenie wartosci ukladu Mfp
	move.b (a0)+,$fffa07
	move.b (a0)+,$fffa09
	move.b (a0)+,$fffa0b
	move.b (a0)+,$fffa0f
	move.b (a0)+,$fffa13
	move.b (a0)+,$fffa17
	move.b (a0)+,$fffa1b
	move.b (a0)+,$fffa1d
	move.b (a0)+,$fffa21
	move.b #$f7,$fffa23

	moveq #0,d0
	jsr MUSIC
	move.l OLDVBL,$70		* zwrocenie starych wartosci przerwan
	move.l OLDTIMB,$120
	move.w #$777,$ff8240                

	clr.l -(sp)
	trap #1					* wyjscie z programu

VBL:						* procedura VBLa

	move.l #CZERN,KOL1		* zaladowanie i odczytanie wartosci glosnosci
	move.b #8,$ffff8800		  pierwszego kanalu
	move.b $ffff8800,d0

	cmp.b #1,d0				* do odpowiedniej wysokosci dzwieku odpowiedni
	bne D1					  raster
	move.l #KL1,KOL1
D1:
	cmp.b #2,d0
	bne D2
	move.l #KL2,KOL1
D2:
	cmp.b #3,d0
	bne D3
	move.l #KL3,KOL1
D3:
	cmp.b #4,d0
	bne D4
	move.l #KL4,KOL1
D4:
	cmp.b #5,d0
	bne D5
	move.l #KL5,KOL1
D5:
	cmp.b #6,d0
	bne D6
	move.l #KL6,KOL1
D6:
	cmp.b #7,d0
	bne D7
	move.l #KL7,KOL1
D7:
	cmp.b #8,d0
	bne D8
	move.l #KL8,KOL1
D8:
	cmp.b #9,d0
	bne D9
	move.l #KL9,KOL1
D9:
	cmp.b #10,d0
	bne DA
	move.l #KL10,KOL1
DA:
	cmp.b #11,d0
	bne DB
	move.l #KL11,KOL1
DB:
	cmp.b #12,d0
	bne DC
	move.l #KL12,KOL1
DC:
	cmp.b #13,d0
	bne DD
	move.l #KL13,KOL1
DD:
	cmp.b #14,d0
	bne DE
	move.l #KL14,KOL1
DE:
	cmp.b #15,d0
	bne DF
	move.l #KL15,KOL1

DF: 
	clr.l d0
	move.l #CZERN,KOL2		* to samo co w lini 94, tyle ze chodzi o drugi
 	move.b #9,$ffff8800		  kanal
	move.b $ffff8800,d0

	cmp.b #1,d0
	bne DA1
	move.l #KLA1,KOL2
DA1:
	cmp.b #2,d0
	bne DA2
	move.l #KLA2,KOL2
DA2:
	cmp.b #3,d0
	bne DA3
	move.l #KLA3,KOL2
DA3:
	cmp.b #4,d0
	bne DA4
	move.l #KLA4,KOL2
DA4:
	cmp.b #5,d0
	bne DA5
	move.l #KLA5,KOL2
DA5:
	cmp.b #6,d0
	bne DA6
	move.l #KLA6,KOL2
DA6:
	cmp.b #7,d0
	bne DA7
	move.l #KLA7,KOL2
DA7:
	cmp.b #8,d0
	bne DA8
	move.l #KLA8,KOL2
DA8:
	cmp.b #9,d0
	bne DA9
	move.l #KLA9,KOL2
DA9:
	cmp.b #10,d0
	bne DAA
	move.l #KLA10,KOL2
DAA:
	cmp.b #11,d0
	bne DAB
	move.l #KLA11,KOL2
DAB:
	cmp.b #12,d0
	bne DAC
	move.l #KLA12,KOL2
DAC:
	cmp.b #13,d0
	bne DAD
	move.l #KLA13,KOL2
DAD:
	cmp.b #14,d0
	bne DAE
	move.l #KLA14,KOL2
DAE:
	cmp.b #15,d0
	bne DAF
	move.l #KLA15,KOL2
DAF:	
	clr.l d0
	move.l #CZERN,KOL3      		* to samo co w lini 94, tyle ze chodzi o trzeci
	move.b #10,$ffff8800
	move.b $ffff8800,d0

	cmp.b #1,d0
	bne DB1
	move.l #KLB1,KOL3
DB1:
	cmp.b #2,d0
	bne DB2
	move.l #KLB2,KOL3
DB2:
	cmp.b #3,d0
	bne DB3
	move.l #KLB3,KOL3
DB3:
	cmp.b #4,d0
	bne DB4
	move.l #KLB4,KOL3
DB4:
	cmp.b #5,d0
	bne DB5
	move.l #KLB5,KOL3
DB5:
	cmp.b #6,d0
	bne DB6
	move.l #KLB6,KOL3
DB6:
	cmp.b #7,d0
	bne DB7
	move.l #KLB7,KOL3
DB7:
	cmp.b #8,d0
	bne DB8
	move.l #KLB8,KOL3
DB8:
	cmp.b #9,d0
	bne DB9
	move.l #KLB9,KOL3
DB9:
	cmp.b #10,d0
	bne DBA
	move.l #KLB10,KOL3
DBA:
	cmp.b #11,d0
	bne DBB
	move.l #KLB11,KOL3
DBB:
	cmp.b #12,d0
	bne DBC
	move.l #KLB12,KOL3
DBC:
	cmp.b #13,d0
	bne DBD
	move.l #KLB13,KOL3
DBD:
	cmp.b #14,d0
	bne DBE
	move.l #KLB14,KOL3
DBE:
	cmp.b #15,d0
	bne DBF
	move.l #KLB15,KOL3
DBF:
	jsr MUS					* skok do muzyki
	rte

TIMER_B:					* przerwanie Timera B
	move.b #2,$fffa21
	movem.l d0-d3/a0-a3,-(sp)
	move.l kol1,a1
	move.l kol2,a2
	move.l kol3,a3
   	move.w (a2)+,$ff8242	* wyswietlanie rastrow
	move.w (a1)+,$ff8240
  	move.w (a3)+,$ff8244 
	move.l a1,kol1
	move.l a2,kol2
   	move.l a3,kol3
	movem.l (sp)+,d0-d3/a0-a3
	bclr.b #0,$fffa0f
	rte

WYLACZ:		dc.b $12
WLACZ:		dc.b $08,1,1
OLD:		ds.l 1
POINT: 		dc.w 0
KOL:		ds.l 1
OLDVBL:		ds.l 1
OLDTIMB: 	ds.l 1
SAFEREG: 	ds.b 10
	even                          

MUS:						* procedura odgrywa muzyke
	movem.l	d0-d7/a0-a6,-(a7)
	bsr	(music+8)
	movem.l	(a7)+,d0-d7/a0-a6
	rts

MUSIC:	incbin	a:\asembler.s\dane.dat\vcs.mus		* muzyka w pliku
                       

KOL1:	ds.l 1
KOL2:	ds.l 1
KOL3:	ds.l 1
							* ponizej sa tablice kolorow do miganie
KL1:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$001,$001,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL2:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$001,$002,$002,$001,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL3:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$001,$002,$003,$003,$002,$001,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL4:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$001,$002,$003,$004,$004,$003,$002,$001,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL5:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $001,$002,$003,$004,$005,$005,$004,$003,$002,$001
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL6:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$001
	dc.w $002,$003,$004,$005,$006,$006,$005,$004,$003,$002
	dc.w $001,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL7:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$001,$002
	dc.w $003,$004,$005,$006,$007,$007,$006,$005,$004,$003
	dc.w $002,$001,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL8:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$001,$002,$003
	dc.w $004,$005,$006,$007,$117,$117,$007,$006,$005,$004
	dc.w $003,$002,$001,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL9:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$001,$002,$003,$004
	dc.w $005,$006,$007,$117,$227,$227,$117,$007,$006,$005
	dc.w $004,$003,$002,$001,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL10:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$001,$002,$003,$004,$005
	dc.w $006,$007,$117,$227,$337,$337,$227,$117,$007,$006
	dc.w $005,$004,$003,$002,$001,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL11:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$001,$002,$003,$004,$005,$006
	dc.w $007,$117,$227,$337,$447,$447,$337,$227,$117,$007
	dc.w $006,$005,$004,$003,$002,$001,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL12:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$001,$002,$003,$004,$005,$006,$007
	dc.w $117,$227,$337,$447,$557,$557,$447,$337,$227,$117
	dc.w $007,$006,$005,$004,$003,$002,$001,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL13:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$001,$002,$003,$004,$005,$006,$007,$117
	dc.w $227,$337,$447,$557,$667,$667,$557,$447,$337,$227
	dc.w $117,$007,$006,$005,$004,$003,$002,$001,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL14:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$001,$002,$003,$004,$005,$006,$007,$117,$227
	dc.w $337,$447,$557,$667,$777,$777,$667,$557,$447,$337
	dc.w $227,$117,$007,$006,$005,$004,$003,$002,$001,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KL15:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $001,$002,$003,$004,$005,$006,$007,$117,$227,$337
	dc.w $447,$557,$667,$777,$777,$777,$777,$667,$557,$447
	dc.w $337,$227,$117,$007,$006,$005,$004,$003,$002,$001
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even

KLA1:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$101,$101,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA2:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$101,$202,$202,$101,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA3:	
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$101,$202,$303,$303,$202,$101,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA4:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$101,$202,$303,$404,$404,$303,$202,$101,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA5:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $101,$202,$303,$404,$505,$505,$404,$303,$202,$101
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA6:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$101
	dc.w $202,$303,$404,$505,$606,$606,$505,$404,$303,$202
	dc.w $101,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA7:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$101,$202
	dc.w $303,$404,$505,$606,$707,$707,$606,$505,$404,$303
	dc.w $202,$101,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA8:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$101,$202,$303
	dc.w $404,$505,$606,$707,$717,$717,$707,$606,$505,$404
	dc.w $303,$202,$101,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA9:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$101,$202,$303,$404
	dc.w $505,$606,$707,$717,$727,$727,$717,$707,$606,$505
	dc.w $404,$303,$202,$101,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA10:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$101,$202,$303,$404,$505
	dc.w $606,$707,$717,$727,$737,$737,$727,$717,$707,$606
	dc.w $505,$404,$303,$202,$101,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA11:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$101,$202,$303,$404,$505,$606
	dc.w $707,$717,$727,$737,$747,$747,$737,$727,$717,$707
	dc.w $606,$505,$404,$303,$202,$101,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA12:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$101,$202,$303,$404,$505,$606,$707
	dc.w $717,$727,$737,$747,$757,$757,$747,$737,$727,$717
	dc.w $707,$606,$505,$404,$303,$202,$101,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA13:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$101,$202,$303,$404,$505,$606,$707,$717
	dc.w $727,$737,$747,$757,$767,$767,$757,$747,$737,$727
	dc.w $717,$707,$606,$505,$404,$303,$202,$101,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA14:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$101,$202,$303,$404,$505,$606,$707,$717,$727
	dc.w $737,$747,$757,$767,$777,$777,$767,$757,$747,$737
	dc.w $727,$717,$707,$606,$505,$404,$303,$202,$101,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLA15:
   	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $101,$202,$303,$404,$505,$606,$707,$717,$727,$737
	dc.w $747,$757,$767,$777,$777,$777,$777,$767,$757,$747
	dc.w $737,$727,$717,$707,$606,$505,$404,$303,$202,$101
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even

KLB1:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$100,$100,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB2:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$100,$200,$200,$100,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB3:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$100,$200,$300,$300,$200,$100,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB4:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$100,$200,$300,$400,$400,$300,$200,$100,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB5:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $100,$200,$300,$400,$500,$500,$400,$300,$200,$100
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB6:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$100
	dc.w $200,$300,$400,$500,$600,$600,$500,$400,$300,$200
	dc.w $100,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB7:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$100,$200
	dc.w $300,$400,$500,$600,$700,$700,$600,$500,$400,$300
	dc.w $200,$100,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB8:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$100,$200,$300
	dc.w $400,$500,$600,$700,$711,$711,$700,$600,$500,$400
	dc.w $300,$200,$100,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB9:		
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$100,$200,$300,$400
	dc.w $500,$600,$700,$711,$722,$722,$711,$700,$600,$500
	dc.w $400,$300,$200,$100,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB10:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$100,$200,$300,$400,$500
	dc.w $600,$700,$711,$722,$733,$733,$722,$711,$700,$600
	dc.w $500,$400,$300,$200,$100,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB11:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$100,$200,$300,$400,$500,$600
	dc.w $700,$711,$722,$733,$744,$744,$733,$722,$711,$700
	dc.w $600,$500,$400,$300,$200,$100,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB12:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$100,$200,$300,$400,$500,$600,$700
	dc.w $711,$722,$733,$744,$755,$755,$744,$733,$722,$711
	dc.w $700,$600,$500,$400,$300,$200,$100,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB13:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$100,$200,$300,$400,$500,$600,$700,$711
	dc.w $722,$733,$744,$755,$766,$766,$755,$744,$733,$722
	dc.w $711,$700,$600,$500,$400,$300,$200,$100,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB14:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$100,$200,$300,$400,$500,$600,$700,$711,$722
	dc.w $733,$744,$755,$766,$777,$777,$766,$755,$744,$733
	dc.w $722,$711,$700,$600,$500,$400,$300,$200,$100,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
KLB15:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $100,$200,$300,$400,$500,$600,$700,$711,$722,$733
	dc.w $744,$755,$766,$777,$777,$777,$777,$766,$755,$744
	dc.w $733,$722,$711,$700,$600,$500,$400,$300,$200,$100
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
CZERN:
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	even
