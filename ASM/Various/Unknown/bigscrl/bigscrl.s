start	bsr	set_chips
	bsr	make_scroll_rut		
	bsr	conv_text
	bsr	make_add_buf
	lea	scroll_buf,a0
	add.l	#70,a0
	move.l	a0,draw_pek
	move.l	#text_buf,text_pek
	move.l	#scroll_buf,scroll_pek	
	addq.l	#2,scroll_pek
	move.l	#fill_colours,colour_pek

tryck 	move.w	#0,$ff8240
	move.w	#0,wfnc

wait_vbl
	cmp.w	#1,wfnc
	bne	wait_vbl

.l1	tst.b	$ff8209			
	beq.s	.l1

	moveq.l	#0,d0			"synca" med bildpekaren
	move.b	$ff8209,d0
	moveq.l	#32,d1
	sub.w	d0,d1
	lsl.w	d1,d0

	rept	77
	nop
	endr
	
	move.w	pause,d0
	lsr.l	d0,d0
	
	move.l	scroll_pek,a0
	move.l	#$ff8240,a1
	lea	add_buf,a2
	jsr	scroll_rut	
	move.w	#0,$ff8240
	
	move.l	text_pek,a0
	move.l	colour_pek,a1
	move.l	draw_pek,a2
	move.w	bit_nr,d0
	moveq.l	#15,d1	

line_l2	btst	d0,(a0)
	beq	zero_bit

	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	move.w	(a1),(a2)
	move.w	(a1)+,-70(a2)
	add.l	#138,a2
	bra	one_bit

zero_bit			
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	move.w	#0,(a2)
	move.w	#0,-70(a2)
	add.l	#138,a2
	add.l	#24,a1

one_bit	addq.l	#2,a0		
	dbra	d1,line_l2
	move.w	speed,d1

	sub.w	d1,pause
	bge	not_scrb_end

	add.l	#384,colour_pek
 	subq.w	#1,bit_nr
	bge	not_minus

	move.w	#7,bit_nr	
	addq.l	#1,text_pek
	addq.w	#1,byte_count
	
	cmp.w	#2,byte_count
	blt	not_minus

	move.w	#0,byte_count
	add.l	#30,text_pek
	move.l	#fill_colours,colour_pek
	move.l	text_pek,a0

	cmp.l	text_end,a0
	blt	not_minus

	move.l	#text_buf,text_pek	

not_minus			
	move.w	#4,pause
	addq.l	#2,scroll_pek
	addq.l	#2,draw_pek
	lea	scroll_buf,a0
	add.l	#140,a0
	
	cmp.l	draw_pek,a0
	bgt	not_scrb_end

	move.l	#scroll_buf,scroll_pek
	addq.l	#2,scroll_pek
	sub.l	#70,a0
	move.l	a0,draw_pek

not_scrb_end
	move.b	key,d1

	cmp.b	$fffc02,d1
	beq	tryck

	move.b	$fffc02,key

	cmp.b	#$4b,$fffc02
	bne	next_key1

	addq.w	#2,speed

	cmp.w	#4,speed
	blt	tryck

	move.w	#5,speed	
	bra	tryck

next_key1
	cmp.b	#$4d,$fffc02
	bne	next_key2

	subq.w	#3,speed

	cmp.w	#0,speed
	bge	tryck

	move.w	#0,speed
	bra	tryck	

next_key2
	cmp.b	#$39,$fffc02
	bne	tryck
	
sl„pp	cmp.b	#$39,$fffc02
	beq	sl„pp
	
	lea	$ff8240,a1
	lea	save_pal,a0
	movem.l	(a0),d0-d7
	movem.l	d0-d7,(a1)
	bsr	reset_chips
	clr.w	-(sp)
	trap	#1

conv_text	
	lea	scroll_text,a0
	lea	font_data,a1
	lea	text_buf,a2
	
conv_text_l	
	moveq.l	#0,d0
	move.b	(a0)+,d0

	cmp.b	#'�',d0
	bne	check_„

	move.b	#'%',d0

check_„	cmp.b	#'Ž',d0
	bne	check_”

	move.b	#'&',d0

check_”	cmp.b	#'™',d0
	bne	cont

	move.b	#"'",d0	

cont	sub.b	#32,d0
	lsl.w	#5,d0
	move.l	a1,a3
	add.l	d0,a3
	moveq.l	#7,d1

copy_font_data_l
	move.l	(a3)+,(a2)+
	dbra	d1,copy_font_data_l

	add.l	#32,line_length

	tst.b	(a0)
	bne	conv_text_l

	move.l	a2,text_end
	rts	
	

make_add_buf
	lea	add_buf,a0
	move.w	#999,d0

add_l	move.l	#70,(a0)+
	dbra	d0,add_l
	
	rts


make_scroll_rut
	lea	scroll_rut,a0
	move.w	#191,d0

line_l	move.w	#33,d1

move_l	
	move.w	#$3298,(a0)+		
	dbra	d1,move_l

	move.w	#$d1da,(a0)+
	move.w	#21,d1

nop_l	move.w	#$4e71,(a0)+
	dbra	d1,nop_l

	dbra	d0,line_l

	move.w	#$4e75,(a0)
	rts


make_scroller
	lea	text_buf,a0
	lea	fill_colours,a1
	lea	scroll_buf,a2
	moveq.l	#15,d0

char_line_l
	move.w	(a0)+,d7
	swap	d7
	move.w	30(a0),d7
	moveq.l	#31,d1

bit_l	btst	d1,d7
	beq	zero

	move.l	a2,a4
	move.w	#11,d2

colour_l
	move.w	(a1)+,(a4)
	add.l	#136,a4
	dbra	d2,colour_l

	bra	one

zero	add.l	#24,a1
	move.l	a2,a4
	move.w	#11,d2

black_l
	move.w	#0,(a4)
	add.l	#136,a4
	dbra	d2,black_l

one	addq.l	#2,a2

	tst.w	(a1)
	bge	not_end

	lea	fill_colours,a1

not_end	dbra	d1,bit_l
	
	add.l	#1568,a2
	dbra	d0,char_line_l	
	
	rts


vbi	move.w	#1,wfnc
	rte


set_chips
	move.l	#0,-(sp)
	move.w	#$20,-(sp)
	trap	#1
	addq.l	#6,sp
	move.l	d0,save_sp
	
	move.b	#0,$ff8260
	move.l	#screen_buf,d0
	add.l	#255,d0
	move.b	#0,d0
	move.l	d0,screen
	lsr.l	#8,d0
	move.b	d0,$ff8203
	lsr.w	#8,d0
	move.b	d0,$ff8201
	
	move.w	sr,save_sr
	move.w	#$2700,sr
	move.l	$70,save_vbi
	move.b	$fffa13,mfp1
	move.b	$fffa15,mfp2
	move.b	#0,$fffa13
	move.b	#0,$fffa15
	move.l	#vbi,$70
	move.w	#$2300,sr
	rts


reset_chips
	move.w	#$2700,sr
	move.l	save_vbi(pc),$70
	move.b	mfp1,$fffa13
      	move.b	mfp2,$fffa15
	move.w	save_sr(pc),sr

	move.w	#$777,$ff8240

	move.l	save_sp(pc),-(sp)
	move.w	#$20,-(sp)
	trap	#1
	addq.l	#6,sp
	rts

	

mfp1	dc.b	0

mfp2	dc.b	0

counter	dc.w	0

save_vbi	
	dc.l	0

save_hbi
	dc.l	0

save_timb
	dc.l	0

save_sr	dc.w	0

wfnc	dc.w	0

save_sp	dc.l	0

screen	dc.l	0

pause	dc.w	4

scroll_pek	
	dc.l	0

speed	dc.w	2

key	dc.w	0

fill_colours
	dc.w	$777,$767,$757,$747,$737,$727,$717,$707,$616,$525,$434,$343
	dc.w	$676,$666,$656,$646,$636,$626,$616,$606,$515,$424,$333,$242
	dc.w	$575,$565,$555,$545,$535,$525,$515,$505,$414,$323,$232,$141
	dc.w	$474,$464,$454,$444,$434,$424,$414,$404,$313,$222,$131,$040
	dc.w	$373,$363,$353,$343,$333,$323,$313,$303,$212,$121,$030,$041
	dc.w	$272,$262,$252,$242,$232,$222,$212,$202,$111,$020,$031,$042
	dc.w	$171,$161,$151,$141,$131,$121,$111,$101,$010,$021,$032,$043
	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142


	dc.w	$676,$666,$656,$646,$636,$626,$616,$606,$515,$424,$333,$242
	dc.w	$575,$565,$555,$545,$535,$525,$515,$505,$414,$323,$232,$141
	dc.w	$474,$464,$454,$444,$434,$424,$414,$404,$313,$222,$131,$040
	dc.w	$373,$363,$353,$343,$333,$323,$313,$303,$212,$121,$030,$041
	dc.w	$272,$262,$252,$242,$232,$222,$212,$202,$111,$020,$031,$042
	dc.w	$171,$161,$151,$141,$131,$121,$111,$101,$010,$021,$032,$043
	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400

	dc.w	$575,$565,$555,$545,$535,$525,$515,$505,$414,$323,$232,$141
	dc.w	$474,$464,$454,$444,$434,$424,$414,$404,$313,$222,$131,$040
	dc.w	$373,$363,$353,$343,$333,$323,$313,$303,$212,$121,$030,$041
	dc.w	$272,$262,$252,$242,$232,$222,$212,$202,$111,$020,$031,$042
	dc.w	$171,$161,$151,$141,$131,$121,$111,$101,$010,$021,$032,$043
	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410

	dc.w	$474,$464,$454,$444,$434,$424,$414,$404,$313,$222,$131,$040
	dc.w	$373,$363,$353,$343,$333,$323,$313,$303,$212,$121,$030,$041
	dc.w	$272,$262,$252,$242,$232,$222,$212,$202,$111,$020,$031,$042
	dc.w	$171,$161,$151,$141,$131,$121,$111,$101,$010,$021,$032,$043
	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420

	dc.w	$373,$363,$353,$343,$333,$323,$313,$303,$212,$121,$030,$041
	dc.w	$272,$262,$252,$242,$232,$222,$212,$202,$111,$020,$031,$042
	dc.w	$171,$161,$151,$141,$131,$121,$111,$101,$010,$021,$032,$043
	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430

	dc.w	$272,$262,$252,$242,$232,$222,$212,$202,$111,$020,$031,$042
	dc.w	$171,$161,$151,$141,$131,$121,$111,$101,$010,$021,$032,$043
	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440

	dc.w	$171,$161,$151,$141,$131,$121,$111,$101,$010,$021,$032,$043
	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450

	dc.w	$070,$060,$050,$040,$030,$020,$010,$000,$011,$022,$033,$044
	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460

	dc.w	$170,$160,$150,$140,$130,$120,$110,$001,$012,$023,$034,$045
	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470

	dc.w	$270,$260,$250,$240,$230,$220,$211,$102,$013,$024,$035,$046
	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471

	dc.w	$370,$360,$350,$340,$330,$321,$312,$203,$114,$025,$036,$047
	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471
	dc.w	$277,$276,$275,$274,$273,$272,$271,$271,$272,$372,$472,$572

	dc.w	$470,$460,$450,$440,$431,$422,$413,$304,$215,$126,$037,$046
	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471
	dc.w	$277,$276,$275,$274,$273,$272,$271,$271,$272,$372,$472,$572
	dc.w	$377,$376,$375,$374,$373,$372,$371,$371,$372,$473,$573,$673

	dc.w	$570,$560,$550,$541,$532,$523,$514,$405,$316,$227,$136,$045
	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471
	dc.w	$277,$276,$275,$274,$273,$272,$271,$271,$272,$372,$472,$572
	dc.w	$377,$376,$375,$374,$373,$372,$371,$371,$372,$473,$573,$673
	dc.w	$477,$476,$475,$474,$473,$472,$471,$471,$472,$573,$674,$774

	dc.w	$670,$660,$651,$642,$633,$624,$615,$506,$417,$326,$235,$144
	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471
	dc.w	$277,$276,$275,$274,$273,$272,$271,$271,$272,$372,$472,$572
	dc.w	$377,$376,$375,$374,$373,$372,$371,$371,$372,$473,$573,$673
	dc.w	$477,$476,$475,$474,$473,$472,$471,$471,$472,$573,$674,$774
	dc.w	$577,$576,$575,$574,$573,$572,$571,$571,$572,$673,$774,$775

	dc.w	$770,$761,$752,$743,$734,$725,$716,$607,$516,$425,$334,$243
	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471
	dc.w	$277,$276,$275,$274,$273,$272,$271,$271,$272,$372,$472,$572
	dc.w	$377,$376,$375,$374,$373,$372,$371,$371,$372,$473,$573,$673
	dc.w	$477,$476,$475,$474,$473,$472,$471,$471,$472,$573,$674,$774
	dc.w	$577,$576,$575,$574,$573,$572,$571,$571,$572,$673,$774,$775
	dc.w	$677,$676,$675,$674,$673,$672,$671,$671,$672,$773,$774,$775

	dc.w	$671,$662,$653,$644,$635,$626,$617,$506,$415,$324,$233,$142
	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471
	dc.w	$277,$276,$275,$274,$273,$272,$271,$271,$272,$372,$472,$572
	dc.w	$377,$376,$375,$374,$373,$372,$371,$371,$372,$473,$573,$673
	dc.w	$477,$476,$475,$474,$473,$472,$471,$471,$472,$573,$674,$774
	dc.w	$577,$576,$575,$574,$573,$572,$571,$571,$572,$673,$774,$775
	dc.w	$677,$676,$675,$674,$673,$672,$671,$671,$672,$773,$774,$775
	dc.w	$777,$776,$775,$774,$773,$772,$771,$771,$772,$773,$774,$775

	dc.w	$007,$006,$005,$004,$003,$002,$001,$000,$100,$200,$300,$400
	dc.w	$017,$016,$015,$014,$013,$012,$011,$010,$110,$210,$310,$410
	dc.w	$027,$026,$025,$024,$023,$022,$021,$020,$120,$220,$320,$420
	dc.w	$037,$036,$035,$034,$033,$032,$031,$030,$130,$230,$330,$430
	dc.w	$047,$046,$045,$044,$043,$042,$041,$040,$140,$240,$340,$440
	dc.w	$057,$056,$055,$054,$053,$052,$051,$050,$150,$250,$350,$450
	dc.w	$067,$066,$065,$064,$063,$062,$061,$060,$160,$260,$360,$460
	dc.w	$077,$076,$075,$074,$073,$072,$071,$070,$170,$270,$370,$470
	dc.w	$177,$176,$175,$174,$173,$172,$171,$171,$171,$271,$371,$471
	dc.w	$277,$276,$275,$274,$273,$272,$271,$271,$272,$372,$472,$572
	dc.w	$377,$376,$375,$374,$373,$372,$371,$371,$372,$473,$573,$673
	dc.w	$477,$476,$475,$474,$473,$472,$471,$471,$472,$573,$674,$774
	dc.w	$577,$576,$575,$574,$573,$572,$571,$571,$572,$673,$774,$775
	dc.w	$677,$676,$675,$674,$673,$672,$671,$671,$672,$773,$774,$775
	dc.w	$777,$776,$775,$774,$773,$772,$771,$771,$772,$773,$774,$775
	dc.w	-1

line_length
	dc.l	0

bit_nr	dc.w	7

text_pek
	dc.l	0

colour_pek
	dc.l	0

draw_pek	
	dc.l	0

byte_count
	dc.w	0

text_end	
	dc.l	0

font_data
	incbin	\sprid.ej\16_16_1a.fnt

scroll_text	
	dc.b	"DU KAN ŽNDRA HASTIGHETEN MED PILTANGENTERNA.  "
	dc.b	"................."
	dc.b	"                     "
	dc.b	0

	section	bss
	
scroll_rut
	ds.b	100000	

save_pal	
	ds.w	16

screen_buf
	ds.b	70000

scroll_buf
	ds.b	200000

add_buf	ds.b	10000

text_buf	
	ds.b	10000	
