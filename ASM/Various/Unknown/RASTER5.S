	MOVE.W #0,-(SP)
	MOVE.L #-1,-(SP)
	MOVE.L #-1,-(SP)
	MOVE.W #5,-(SP)
	TRAP #14
	ADD.L #12,SP
	CLR.W -(SP)
	MOVE.W #$20,-(SP)
	TRAP #1
	ADDQ.L #6,SP
	MOVE.L D0,SUPER
	MOVE.W #37,-(SP)
	TRAP #14
	ADD.L #2,SP
	MOVE.B $FFFA07,INTSAVE1
	MOVE.B $FFFA09,INTSAVE2
	MOVE.L $70,VSAVE
	MOVE.L $120,TIMERB
	MOVE.W $FF8240,COLOR0
	MOVE.L #DUMB,$70
	MOVE.B #0,$FFFA09
	MOVE.W #0,LINE
	MOVE.W #1,STRT
	MOVE.W #52,STOP
	MOVE.W #1,RLINE
	MOVE.W #0,FLAG
	MOVE.L #RASTER,-(SP)
	MOVE.W #1,-(SP)
	MOVE.W #8,-(SP)
	MOVE.W #1,-(SP)
	MOVE.W #31,-(SP)
	TRAP #14
	ADD.L #12,SP
WAIT:	CMP.B #185,$FFFC02
	BNE WAIT
	DC.W 70,$4E71
	MOVE.B INTSAVE1,$FFFA07
	MOVE.B INTSAVE2,$FFFA09
	MOVE.L VSAVE,$70
	MOVE.L TIMERB,$120
	MOVE.W COLOR0,$FF8240
	MOVE.L SUPER,-(SP)
	MOVE.W #$20,-(SP)
	TRAP #1
	ADDQ.L #6,SP
	CLR.W -(SP)
 	TRAP #1
RASTER: MOVEM.L A0-A3,-(SP)
	MOVE.W COLOR,$FF8240
	ADD.W #1,LINE
	MOVE.W LINE,A1
	CMPA.W STRT,A1
	BLE NOT
	CMPA.W STOP,A1
	BGE NOT
	MOVE.L POINTER,A2
	MOVE.W (A2),COLOR
	ADD.L #2,POINTER
	BRA SLUT
NOT:	MOVE.W #0,COLOR
	CMPI.W #200,LINE
	BNE SLUT
	MOVE.W #0,LINE
	MOVE.L #COLTAB,POINTER
	MOVE.W RLINE,A3
	CMPA.L #146,A3
	BLE MORE
	MOVE.W #1,FLAG
	MOVE.L #COLTAB,POINTER
	MOVE.W #0,COLOR
MORE:	MOVE.L #RLINE,A3
	CMPI.L #1,RLINE
	BGE CONT
	MOVE.W #0,FLAG
CONT:	MOVE.W (A3),STRT
	MOVE.W (A3),STOP
	ADD.W #52,STOP
	CMPI.W #1,FLAG
	BEQ DEC
	ADD.W #2,RLINE
	BRA SLUT
DEC:	SUB.W #2,RLINE
SLUT:	BCLR #0,$FFFA0F
	MOVEM.L (SP)+,A0-A3
	RTE
DUMB:	RTE
SUPER 		DS.L 1
VSAVE		DS.L 1
TIMERB		DS.L 1
INTSAVE1	DS.B 1
INTSAVE2	DS.B 1
LINE		DS.W 1
STRT		DS.W 1
STOP		DS.W 1
COLOR		DS.W 1
COLOR0		DS.W 1
RLINE		DS.L 1
RSTLINE		DS.L 1
FLAG		DS.W 1
POINTER 	DC.L COLTAB
COLTAB 		DC.W $100,$110,$120,$130,$140,$150,$160,$170,$270,$370,$470,$570,$670,$770,$671,$572,$473,$374,$275,$176,$077,$067,$057,$047,$037,$027,$017,$007,$016,$025,$034,$043,$052,$061,$070,$170,$270,$360,$450,$540,$630,$720,$710,$700,$700,$600
		DC.W $500,$400,$300,$200,$100,$100

	END
