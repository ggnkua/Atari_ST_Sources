	move.l	#$C001C001,d0
	lea		8(a1),a1
	and.l	d0,(a1)+
	and.l	d0,(a1)
	move.l	#$FFF0FFF0,d1
	lea		28(a1),a1
	and.l	d1,(a1)+
	and.l	d1,(a1)+
	move.l	#$07FF07FF,d2
	and.l	d2,(a1)+
	and.l	d2,(a1)

	move.l	#$80018001,d3
	lea		116(a1),a1
	and.l	d3,(a1)+
	move.w	#$3FFC,d4
	or.w	d4,-2(a1)
	and.l	d3,(a1)
	or.w	d4,2(a1)
	move.l	#$FFE0FFE0,d5
	lea		28(a1),a1
	and.l	d5,(a1)+
	move.w	#$000F,d6
	or.w	d6,-2(a1)
	and.l	d5,(a1)+
	or.w	d6,-2(a1)
	move.l	#$03FF03FF,d7
	and.l	d7,(a1)+
	move.w	#$F800,d0
	or.w	d0,-2(a1)
	and.l	d7,(a1)
	or.w	d0,2(a1)

	move.l	#$00010001,d1
	lea		116(a1),a1
	and.w	d1,(a1)
	or.w	#$1FF8,(a1)+
	and.w	d1,(a1)
	or.w	#$6004,(a1)+
	and.l	d1,(a1)
	or.w	#$7FFC,2(a1)
	move.l	#$FFC0FFC0,d2
	lea		28(a1),a1
	and.w	d2,(a1)
	or.w	#$0007,(a1)+
	and.w	d2,(a1)
	or.w	#$0018,(a1)+
	and.l	d2,(a1)+
	or.w	#$001F,-2(a1)
	move.l	#$01FF01FF,d3
	and.w	d3,(a1)
	or.w	#$F000,(a1)+
	and.w	d3,(a1)
	or.w	#$0C00,(a1)+
	and.l	d3,(a1)
	or.w	#$FC00,2(a1)

	move.l	#$FFFEFFFE,d4
	lea		108(a1),a1
	and.l	d4,(a1)+
	and.l	d4,(a1)+
	and.w	d1,(a1)
	or.w	#$3FF8,(a1)+
	and.w	d1,(a1)
	or.w	#$C004,(a1)+
	and.l	d1,(a1)
	or.w	#$FFFC,2(a1)
	move.l	#$E00FE00F,d5
	lea		20(a1),a1
	and.l	d5,(a1)+
	and.l	d5,(a1)+
	move.l	#$FF80FF80,d6
	and.w	d6,(a1)
	or.w	#$000F,(a1)+
	and.w	d6,(a1)
	or.w	#$0030,(a1)+
	and.l	d6,(a1)+
	or.w	#$003F,-2(a1)
	move.l	#$00FF00FF,d7
	and.w	d7,(a1)
	or.w	d0,(a1)+
	and.w	d7,(a1)
	or.w	#$0600,(a1)+
	and.l	d7,(a1)+
	or.w	#$FE00,-2(a1)
	move.l	#$FF00FF00,d0
	and.l	d0,(a1)+
	and.l	d0,(a1)+
	move.l	#$7FFF7FFF,d1
	and.l	d1,(a1)+
	and.l	d1,(a1)

	move.l	#$FFFCFFFC,d2
	lea		92(a1),a1
	and.l	d2,(a1)+
	move.l	#$00010001,d3
	or.w	d3,-2(a1)
	and.l	d2,(a1)+
	or.w	d3,-2(a1)
	and.w	d3,(a1)
	or.w	#$7FF8,(a1)+
	and.w	d3,(a1)
	or.w	#$8004,(a1)+
	and.l	d3,(a1)
	or.w	d2,2(a1)
	move.l	#$C007C007,d4
	lea		20(a1),a1
	and.l	d4,(a1)+
	move.w	#$1FF0,d5
	or.w	d5,-2(a1)
	and.l	d4,(a1)+
	or.w	d5,-2(a1)
	and.w	d0,(a1)
	or.w	#$001F,(a1)+
	and.w	d0,(a1)
	or.w	#$0060,(a1)+
	and.l	d0,(a1)+
	move.l	#$007F007F,d6
	or.w	d6,-2(a1)
	and.w	d6,(a1)
	or.w	#$FC00,(a1)+
	and.w	d6,(a1)
	or.w	#$0300,(a1)+
	and.l	d6,(a1)+
	or.w	d0,-2(a1)
	move.l	#$FE00FE00,d7
	and.l	d7,(a1)+
	move.w	#$00FF,d0
	or.w	d0,-2(a1)
	and.l	d7,(a1)+
	or.w	d0,-2(a1)
	move.l	#$3FFF3FFF,d1
	and.l	d1,(a1)+
	move.w	#$8000,d2
	or.w	d2,-2(a1)
	and.l	d1,(a1)
	or.w	d2,2(a1)

	move.l	#$FFFCFFFC,d3
	lea		92(a1),a1
	and.l	d3,(a1)+
	move.l	#$00010001,d4
	or.w	d4,-2(a1)
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	and.w	d4,(a1)
	or.w	#$FFF8,(a1)+
	and.w	d4,(a1)
	or.w	#$0004,(a1)+
	and.l	d4,(a1)
	or.w	d3,2(a1)
	move.l	#$80038003,d5
	lea		20(a1),a1
	and.w	d5,(a1)
	or.w	#$0FE0,(a1)+
	and.w	d5,(a1)
	or.w	#$3018,(a1)+
	and.l	d5,(a1)+
	or.w	#$3FF8,-2(a1)
	move.l	#$FF00FF00,d6
	and.w	d6,(a1)
	or.w	#$003F,(a1)+
	and.w	d6,(a1)
	or.w	#$0040,(a1)+
	and.l	d6,(a1)+
	move.l	#$007F007F,d7
	or.w	d7,-2(a1)
	and.w	d7,(a1)
	or.w	#$FE00,(a1)+
	and.w	d7,(a1)
	or.w	#$0100,(a1)+
	and.l	d7,(a1)+
	or.w	d6,-2(a1)
	move.l	#$FC00FC00,d0
	and.w	d0,(a1)
	or.w	d7,(a1)+
	and.w	d0,(a1)
	or.w	#$0180,(a1)+
	and.l	d0,(a1)+
	or.w	#$01FF,-2(a1)
	move.l	#$1FFF1FFF,d1
	and.l	d1,(a1)+
	move.w	#$C000,d2
	or.w	d2,-2(a1)
	and.l	d1,(a1)
	or.w	d2,2(a1)

	lea		92(a1),a1
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	move.l	#$FC000004,(a1)+
	move.l	#$0000FFFC,(a1)+
	move.l	#$00000000,d3
	move.l	d3,(a1)+
	move.l	d3,(a1)+
	move.l	d3,(a1)+
	move.l	d3,(a1)+
	and.w	d4,(a1)
	or.w	#$1FF0,(a1)+
	and.w	d4,(a1)
	or.w	#$600C,(a1)+
	and.l	d4,(a1)+
	or.w	#$7FFC,-2(a1)
	and.w	d6,(a1)
	or.w	#$003F,(a1)+
	and.w	d6,(a1)
	or.w	#$0040,(a1)+
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$7E000100,(a1)+
	move.l	#$0000FF00,(a1)+
	move.l	#$00FF0300,(a1)+
	move.l	#$000003FF,(a1)+
	move.l	#$08000800,d4
	and.w	d4,(a1)
	or.w	#$8000,(a1)+
	and.w	d4,(a1)
	or.w	#$6000,(a1)+
	and.l	d4,(a1)+
	or.w	#$E000,-2(a1)
	move.l	#$3FFF3FFF,d5
	and.l	d5,(a1)+
	and.l	d5,(a1)

	move.l	#$FFFCFFFC,d6
	lea		84(a1),a1
	and.l	d6,(a1)+
	move.l	#$00010001,d7
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FC000004,(a1)+
	move.l	#$0000FFFC,(a1)+
	move.l	#$0000FFFF,d0
	move.l	d0,(a1)+
	move.l	d0,(a1)+
	move.l	#$0000FFFE,d1
	move.l	d1,(a1)+
	move.l	d1,(a1)+
	and.w	d7,(a1)
	or.w	#$3FF8,(a1)+
	and.w	d7,(a1)
	or.w	#$4004,(a1)+
	and.l	d7,(a1)+
	or.w	#$7FFC,-2(a1)
	move.l	#$FF00FF00,d2
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7E0001FF,(a1)+
	move.l	d0,(a1)+
	move.l	#$01FFFE00,(a1)+
	move.l	d0,(a1)+
	move.l	#$C00027FF,(a1)+
	move.l	#$0000E7FF,(a1)+
	and.l	d5,(a1)+
	move.w	#$8000,d3
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FC0003FD,(a1)+
	move.l	#$0000FFFD,(a1)+
	move.l	#$7FEF8010,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFFC0003,(a1)+
	move.l	d0,(a1)+
	and.w	d7,(a1)
	or.w	#$3FF8,(a1)+
	and.w	d7,(a1)
	or.w	#$4004,(a1)+
	and.l	d7,(a1)+
	or.w	#$7FFC,-2(a1)
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$F9FF0600,(a1)+
	move.l	d0,(a1)+
	move.l	#$C3FF2C00,(a1)+
	move.l	#$0000EFFF,(a1)+
	and.l	d5,(a1)+
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FC0003FF,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFEF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFFE0001,(a1)+
	move.l	d0,(a1)+
	move.l	#$3FF8C006,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$F9FF0600,(a1)+
	move.l	d0,(a1)+
	move.l	#$C7FF3800,(a1)+
	move.l	d0,(a1)+
	and.l	d5,(a1)+
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FC0103FE,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFEF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFFE0001,(a1)+
	move.l	d0,(a1)+
	move.l	#$7EFC8002,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF70400,(a1)+
	move.l	d0,(a1)+
	move.l	#$E7FF1800,(a1)+
	move.l	d0,(a1)+
	and.l	d5,(a1)+
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFEF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFFF0000,(a1)+
	move.l	d0,(a1)+
	move.l	#$7EFC8002,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF70400,(a1)+
	move.l	d0,(a1)+
	move.l	#$EFFF1000,(a1)+
	move.l	d0,(a1)+
	and.l	d5,(a1)+
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF0000,(a1)+
	move.l	d0,(a1)+
	move.l	#$7EFC8102,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF70408,(a1)+
	move.l	d0,(a1)+
	move.l	#$EFC01000,(a1)+
	move.l	d0,(a1)+
	and.l	d5,(a1)+
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF0000,(a1)+
	move.l	d0,(a1)+
	move.l	#$7EFC8102,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF70408,(a1)+
	move.l	d0,(a1)+
	move.l	#$EFC01000,(a1)+
	move.l	d0,(a1)+
	and.l	d5,(a1)+
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0810,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$7EFC8102,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF70408,(a1)+
	move.l	d0,(a1)+
	move.l	#$EFC0103F,(a1)+
	move.l	d0,(a1)+
	and.l	d5,(a1)+
	or.w	d3,-2(a1)
	and.l	d5,(a1)
	or.w	d3,2(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0810,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$7EFC8102,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF70408,(a1)+
	move.l	d0,(a1)+
	move.l	#$EFC01020,(a1)+
	move.l	#$0000FFE0,(a1)+
	and.l	d5,(a1)+
	and.l	d5,(a1)

	lea		84(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0810,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$7FFC8002,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBFF0400,(a1)+
	move.l	d0,(a1)+
	move.l	#$000F000F,d4
	and.w	d4,(a1)
	or.w	#$EFC0,(a1)+
	and.w	d4,(a1)
	or.w	#$1020,(a1)+
	and.l	d4,(a1)
	or.w	#$FFE0,2(a1)

	lea		92(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0810,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$7FFC8002,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBFF0400,(a1)+
	move.l	d0,(a1)+
	and.w	d4,(a1)
	or.w	#$EFC0,(a1)+
	and.w	d4,(a1)
	or.w	#$1020,(a1)+
	and.l	d4,(a1)
	or.w	#$FFE0,2(a1)

	lea		92(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0810,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$7F008002,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF80400,(a1)+
	move.l	d0,(a1)+
	and.w	d4,(a1)
	or.w	#$0FC0,(a1)+
	and.w	d4,(a1)
	or.w	#$1020,(a1)+
	and.l	d4,(a1)
	or.w	#$FFE0,2(a1)

	lea		92(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FDFB0204,(a1)+
	move.l	d0,(a1)+
	move.l	#$F7EF0810,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$7F008002,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$7EFD8102,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF80400,(a1)+
	move.l	d0,(a1)+
	and.w	d4,(a1)
	or.w	#$0FC0,(a1)+
	and.w	d4,(a1)
	or.w	#$1020,(a1)+
	and.l	d4,(a1)
	or.w	#$FFE0,2(a1)

	lea		92(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$FFFB0004,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFEF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$7F0080FE,(a1)+
	move.l	d1,(a1)+
	and.w	d2,(a1)
	or.w	#$003F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$FEFF0100,(a1)+
	move.l	d0,(a1)+
	move.l	#$FBF80407,(a1)+
	move.l	d0,(a1)+
	and.w	d4,(a1)
	or.w	#$0FC0,(a1)+
	and.w	d4,(a1)
	or.w	#$F020,(a1)+
	and.l	d4,(a1)
	or.w	#$FFE0,2(a1)

	lea		92(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$7FF90004,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFEF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$3F008080,(a1)+
	move.l	#$0000FF80,(a1)+
	and.w	d2,(a1)
	or.w	#$001F,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$FCFF0100,(a1)+
	move.l	d0,(a1)+
	move.l	#$F1F80404,(a1)+
	move.l	#$0000FFFC,(a1)+
	and.w	d4,(a1)
	or.w	#$0FC0,(a1)+
	and.w	d4,(a1)
	or.w	#$1020,(a1)+
	and.l	d4,(a1)
	or.w	#$1FE0,2(a1)

	lea		92(a1),a1
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	or.w	d7,-2(a1)
	move.l	#$3FF80004,(a1)+
	move.l	d0,(a1)+
	move.l	#$FFEF0010,(a1)+
	move.l	d0,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d0,(a1)+
	move.l	#$003F003F,d5
	and.w	d5,(a1)
	or.w	#$1F00,(a1)+
	and.w	d5,(a1)
	or.w	#$8080,(a1)+
	and.l	d5,(a1)+
	or.w	#$FF80,-2(a1)
	and.w	d2,(a1)
	or.w	d4,(a1)+
	and.w	d2,(a1)
	or.w	#$0040,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$F8FF0100,(a1)+
	move.l	d0,(a1)+
	and.w	d7,(a1)
	or.w	#$E0F8,(a1)+
	and.w	d7,(a1)
	or.w	#$0404,(a1)+
	and.l	d7,(a1)+
	or.w	d6,-2(a1)
	move.l	#$C00FC00F,d6
	and.w	d6,(a1)
	or.w	#$0FC0,(a1)+
	and.w	d6,(a1)
	or.w	#$1020,(a1)+
	and.l	d6,(a1)
	or.w	#$1FE0,2(a1)

	move.l	#$FFFCFFFC,d7
	lea		92(a1),a1
	and.l	d7,(a1)+
	move.w	#$0001,d0
	or.w	d0,-2(a1)
	and.l	d7,(a1)+
	or.w	d0,-2(a1)
	move.l	#$1FF88006,(a1)+
	move.l	#$0000FFFF,d1
	move.l	d1,(a1)+
	move.l	#$7FEF0010,(a1)+
	move.l	d1,(a1)+
	move.l	#$DFBF2040,(a1)+
	move.l	d1,(a1)+
	and.w	d5,(a1)
	or.w	#$0F00,(a1)+
	and.w	d5,(a1)
	or.w	#$C080,(a1)+
	and.l	d5,(a1)+
	or.w	#$FF80,-2(a1)
	and.w	d2,(a1)
	or.w	#$0007,(a1)+
	and.w	d2,(a1)
	or.w	#$0060,(a1)+
	and.l	d2,(a1)+
	or.w	#$007F,-2(a1)
	move.l	#$F0FF0300,(a1)+
	move.l	d1,(a1)+
	and.w	d0,(a1)
	or.w	#$C078,(a1)+
	and.w	d0,(a1)
	or.w	#$0E04,(a1)+
	and.l	#$00010001,(a1)+
	or.w	d7,-2(a1)
	and.w	d6,(a1)
	or.w	#$0FC0,(a1)+
	and.w	d6,(a1)
	or.w	#$1020,(a1)+
	and.l	d6,(a1)
	or.w	#$1FE0,2(a1)

	move.l	#$FFFEFFFE,d2
	lea		92(a1),a1
	and.l	d2,(a1)+
	and.l	d2,(a1)+
	move.l	#$0000C007,(a1)+
	move.l	d1,(a1)+
	move.l	#$00000010,(a1)+
	move.l	d1,(a1)+
	move.l	#$00002040,(a1)+
	move.l	d1,(a1)+
	and.l	d5,(a1)+
	or.w	#$E080,-2(a1)
	and.l	d5,(a1)+
	move.l	#$FF80FF80,d3
	or.w	d3,-2(a1)
	and.l	d3,(a1)+
	or.w	#$0030,-2(a1)
	and.l	d3,(a1)+
	or.w	d5,-2(a1)
	move.l	#$00000700,(a1)+
	move.l	d1,(a1)+
	move.l	#$00010001,d4
	and.l	d4,(a1)+
	or.w	#$1B04,-2(a1)
	and.l	d4,(a1)+
	or.w	#$FBFC,-2(a1)
	and.l	d6,(a1)+
	or.w	#$1020,-2(a1)
	and.l	d6,(a1)
	or.w	#$1FE0,2(a1)

	lea		100(a1),a1
	move.l	#$00006005,(a1)+
	move.l	#$00007FFD,(a1)+
	move.l	#$00008010,(a1)+
	move.l	d1,(a1)+
	move.l	#$00002040,(a1)+
	move.l	d1,(a1)+
	and.l	d5,(a1)+
	or.w	#$B080,-2(a1)
	and.l	d5,(a1)+
	or.w	#$BF80,-2(a1)
	move.l	#$FFC0FFC0,d5
	and.l	d5,(a1)+
	or.w	#$0018,-2(a1)
	and.l	d5,(a1)+
	or.w	#$001F,-2(a1)
	move.l	#$00000D00,(a1)+
	move.l	#$0000FDFF,(a1)+
	move.l	#$04010401,d6
	and.l	d6,(a1)+
	or.w	#$3184,-2(a1)
	and.l	d6,(a1)+
	or.w	#$F1FC,-2(a1)
	move.l	#$C00FC00F,d7
	and.l	d7,(a1)+
	or.w	#$1020,-2(a1)
	and.l	d7,(a1)
	or.w	#$1FE0,2(a1)

	move.l	#$80008000,d0
	lea		100(a1),a1
	and.l	d0,(a1)+
	move.w	#$3FFC,d1
	or.w	d1,-2(a1)
	and.l	d0,(a1)+
	or.w	d1,-2(a1)
	move.l	#$0000FFFF,d2
	move.l	d2,(a1)+
	move.l	d2,(a1)+
	move.l	d2,(a1)+
	move.l	d2,(a1)+
	move.l	#$003F003F,d3
	and.l	d3,(a1)+
	move.w	#$9F80,d4
	or.w	d4,-2(a1)
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	move.l	#$FFE0FFE0,d5
	and.l	d5,(a1)+
	move.w	#$000F,d6
	or.w	d6,-2(a1)
	and.l	d5,(a1)+
	or.w	d6,-2(a1)
	move.l	#$0000F9FF,d7
	move.l	d7,(a1)+
	move.l	d7,(a1)+
	move.l	#$0E010E01,d0
	and.l	d0,(a1)+
	move.w	#$E0FC,d1
	or.w	d1,-2(a1)
	and.l	d0,(a1)+
	or.w	d1,-2(a1)
	move.l	#$C00FC00F,d2
	and.l	d2,(a1)+
	move.w	#$1FE0,d3
	or.w	d3,-2(a1)
	and.l	d2,(a1)
	or.w	d3,2(a1)

	move.l	#$C000C000,d4
	lea		100(a1),a1
	and.l	d4,(a1)+
	and.l	d4,(a1)+
	move.l	#$00000000,d5
	move.l	d5,(a1)+
	move.l	d5,(a1)+
	move.l	d5,(a1)+
	move.l	d5,(a1)+
	move.l	#$003F003F,d6
	and.l	d6,(a1)+
	and.l	d6,(a1)+
	move.l	#$FFF0FFF0,d7
	and.l	d7,(a1)+
	and.l	d7,(a1)+
	move.l	d5,(a1)+
	move.l	d5,(a1)+
	move.l	#$1F011F01,d0
	and.l	d0,(a1)+
	and.l	d0,(a1)+
	and.l	d2,(a1)+
	and.l	d2,(a1)
