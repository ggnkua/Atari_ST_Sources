 TEXT 
Begin:
      LEA     L0008(PC),A0
      CMPI.L  #$594554,(A0) 
      BEQ.S   L0001 
      LEA     L0007(PC),A0
      MOVE.W  #$FF,D0 
L0000:MOVE.B  5(A0),6(A0) 
      MOVE.B  5(A0),7(A0) 
      MOVE.B  4(A0),5(A0) 
      LEA     8(A0),A0
      DBF     D0,L0000
      LEA     L0008(PC),A0
      MOVE.L  #$594554,(A0) 
L0001:LEA     L0004(PC),A0
      MOVE.L  4(A7),2(A0) 
      MOVE.L  8(A7),8(A0) 
      MOVE.B  12(A7),D3 
      MOVE.B  13(A7),D4 
      PEA     L0002(PC) 
      MOVE.W  #$26,-(A7)
      TRAP    #$E 
      ADDQ.L  #6,A7 
      RTS 
L0002:MOVE    #$2700,SR 
      MOVE.L  #0,$FFFF8800.L
      MOVE.L  #$1010000,$FFFF8800.L 
      MOVE.L  #$2020000,$FFFF8800.L 
      MOVE.L  #$3030000,$FFFF8800.L 
      MOVE.L  #$4040000,$FFFF8800.L 
      MOVE.L  #$5050000,$FFFF8800.L 
      MOVE.L  #$6060000,$FFFF8800.L 
      MOVE.L  #$707FFFF,$FFFF8800.L 
      MOVE.L  #$8080000,$FFFF8800.L 
      MOVE.L  #$9090000,$FFFF8800.L 
      MOVE.L  #$A0A0000,$FFFF8800.L 
      LEA     L0003(PC),A0
      MOVE.L  A0,$00000120.L
      BSET    #0,$FFFFFA13.L
      BSET    #0,$FFFFFA07.L
      MOVE.B  D3,$FFFFFA1B.L
      MOVE.B  D4,$FFFFFA21.L
      MOVE    #$2300,SR 
      RTS 
L0003:MOVEM.L A0/D0,-(A7) 
L0004:MOVEA.L #0,A0 
L0005 EQU L0004+2 
      CMPA.L  #0,A0 
      BGE     L0006 
      CLR.W   D0
      MOVE.B  (A0),D0 
      LEA     L0005(PC),A0
      ADDQ.L  #1,(A0) 
      LSL.W   #3,D0 
      LEA     L0007(PC,D0.W),A0 
      MOVE.L  (A0)+,D0
      ADD.B   #128,D0
      MOVE.L  (A0),$FFFF8800.L
      LEA     $FFFF8800.L,A0
      MOVEP.L D0,0(A0)
      MOVEM.L (A7)+,A0/D0 
      BCLR    #0,$FFFFFA0F.L
      RTE 
L0006:MOVEM.L (A7)+,A0/D0 
      BCLR    #0,$FFFFFA07.L
      BCLR    #0,$FFFFFA0F.L
      RTE 
L0007:DC.B   $08,$0E,$09,$0D,$0A,$0A,$0C,$0C
      DC.B   $08,$0F,$09,$03,$0A,$0A,$00,$00
      DC.B   $08,$0F,$09,$03,$0A,$0A,$00,$00
      DC.B   $08,$0F,$09,$03,$0A,$0A,$00,$00
      DC.B   $08,$0F,$09,$03,$0A,$0A,$00,$00
      DC.B   $08,$0F,$09,$03,$0A,$0A,$00,$00
      DC.B   $08,$0F,$09,$03,$0A,$0A,$00,$00
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0C,$0C
      DC.B   $08,$0E,$09,$0D,$0A,$0A,$00,$00
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0D,$0D
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0D,$0D
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0D,$0D
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0D,$0D
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0D,$0D
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0D,$0D
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0C,$0C
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0C,$0C
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$09,$09
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$09,$09
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$05,$05
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$00,$00
      DC.B   $08,$0E,$09,$0C,$0A,$0A,$00,$00
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$0C,$0C
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$07,$07
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$00,$00
      DC.B   $08,$0E,$09,$0B,$0A,$0A,$00,$00
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$09,$09
      DC.B   $08,$0E,$09,$0A,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$08,$08
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$07,$07
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$04,$04
      DC.B   $08,$0D,$09,$0D,$0A,$0A,$00,$00
      DC.B   $08,$0E,$09,$0A,$0A,$0A,$04,$04
      DC.B   $08,$0E,$09,$09,$0A,$0A,$09,$09
      DC.B   $08,$0E,$09,$09,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0E,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0E,$09,$09,$0A,$0A,$07,$07
      DC.B   $08,$0E,$09,$08,$0A,$0A,$08,$08
      DC.B   $08,$0E,$09,$09,$0A,$0A,$01,$01
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$0C,$0C
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0E,$09,$08,$0A,$0A,$06,$06
      DC.B   $08,$0E,$09,$07,$0A,$0A,$07,$07
      DC.B   $08,$0E,$09,$08,$0A,$0A,$00,$00
      DC.B   $08,$0E,$09,$07,$0A,$0A,$05,$05
      DC.B   $08,$0E,$09,$06,$0A,$0A,$06,$06
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$09,$09
      DC.B   $08,$0E,$09,$05,$0A,$0A,$05,$05
      DC.B   $08,$0E,$09,$04,$0A,$0A,$04,$04
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$08,$08
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$0B,$0B
      DC.B   $08,$0E,$09,$00,$0A,$0A,$00,$00
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$06,$06
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$05,$05
      DC.B   $08,$0D,$09,$0C,$0A,$0A,$02,$02
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$0B,$0B
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$0A,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0A,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0A,$0A,$0A,$0A,$0A
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$09,$09
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$09,$09
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$06,$06
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$0B,$0B
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$08,$08
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$00,$00
      DC.B   $08,$0D,$09,$0B,$0A,$0A,$00,$00
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$07,$07
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$06,$06
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$05,$05
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$03,$03
      DC.B   $08,$0C,$09,$0C,$0A,$0A,$01,$01
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0D,$09,$0A,$0A,$0A,$05,$05
      DC.B   $08,$0D,$09,$0A,$0A,$0A,$04,$04
      DC.B   $08,$0D,$09,$0A,$0A,$0A,$02,$02
      DC.B   $08,$0D,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0D,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$08,$0A,$0A,$08,$08
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$0B,$0B
      DC.B   $08,$0D,$09,$09,$0A,$0A,$05,$05
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$08,$08
      DC.B   $08,$0D,$09,$09,$0A,$0A,$02,$02
      DC.B   $08,$0D,$09,$08,$0A,$0A,$06,$06
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$07,$07
      DC.B   $08,$0D,$09,$07,$0A,$0A,$07,$07
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$06,$06
      DC.B   $08,$0C,$09,$0A,$0A,$0A,$09,$09
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$0A,$0A
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$02,$02
      DC.B   $08,$0C,$09,$0B,$0A,$0A,$00,$00
      DC.B   $08,$0C,$09,$0A,$0A,$0A,$08,$08
      DC.B   $08,$0D,$09,$06,$0A,$0A,$04,$04
      DC.B   $08,$0D,$09,$05,$0A,$0A,$05,$05
      DC.B   $08,$0D,$09,$05,$0A,$0A,$04,$04
      DC.B   $08,$0C,$09,$09,$0A,$0A,$09,$09
      DC.B   $08,$0D,$09,$04,$0A,$0A,$03,$03
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$09,$09
      DC.B   $08,$0C,$09,$0A,$0A,$0A,$05,$05
      DC.B   $08,$0B,$09,$0A,$0A,$0A,$0A,$0A
      DC.B   $08,$0C,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$08,$08
      DC.B   $08,$0C,$09,$0A,$0A,$0A,$00,$00
      DC.B   $08,$0C,$09,$0A,$0A,$0A,$00,$00
      DC.B   $08,$0C,$09,$09,$0A,$0A,$07,$07
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$07,$07
      DC.B   $08,$0C,$09,$09,$0A,$0A,$06,$06
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$06,$06
      DC.B   $08,$0B,$09,$0A,$0A,$0A,$09,$09
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$05,$05
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$0A,$0A
      DC.B   $08,$0B,$09,$0B,$0A,$0A,$02,$02
      DC.B   $08,$0B,$09,$0A,$0A,$0A,$08,$08
      DC.B   $08,$0C,$09,$07,$0A,$0A,$07,$07
      DC.B   $08,$0C,$09,$08,$0A,$0A,$04,$04
      DC.B   $08,$0C,$09,$07,$0A,$0A,$06,$06
      DC.B   $08,$0B,$09,$09,$0A,$0A,$09,$09
      DC.B   $08,$0C,$09,$06,$0A,$0A,$06,$06
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$09,$09
      DC.B   $08,$0C,$09,$07,$0A,$0A,$03,$03
      DC.B   $08,$0B,$09,$0A,$0A,$0A,$05,$05
      DC.B   $08,$0B,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0B,$09,$0A,$0A,$0A,$03,$03
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$08,$08
      DC.B   $08,$0B,$09,$0A,$0A,$0A,$00,$00
      DC.B   $08,$0B,$09,$09,$0A,$0A,$07,$07
      DC.B   $08,$0B,$09,$08,$0A,$0A,$08,$08
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$07,$07
      DC.B   $08,$0A,$09,$09,$0A,$0A,$09,$09
      DC.B   $08,$0C,$09,$01,$0A,$0A,$01,$01
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$06,$06
      DC.B   $08,$0B,$09,$08,$0A,$0A,$07,$07
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$05,$05
      DC.B   $08,$0A,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$02,$02
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$01,$01
      DC.B   $08,$0A,$09,$0A,$0A,$0A,$00,$00
      DC.B   $08,$09,$09,$09,$0A,$0A,$09,$09
      DC.B   $08,$0A,$09,$08,$0A,$0A,$08,$08
      DC.B   $08,$0B,$09,$08,$0A,$0A,$01,$01
      DC.B   $08,$0A,$09,$09,$0A,$0A,$06,$06
      DC.B   $08,$0B,$09,$07,$0A,$0A,$04,$04
      DC.B   $08,$0A,$09,$09,$0A,$0A,$05,$05
      DC.B   $08,$09,$09,$09,$0A,$0A,$08,$08
      DC.B   $08,$0A,$09,$09,$0A,$0A,$03,$03
      DC.B   $08,$0A,$09,$08,$0A,$0A,$06,$06
      DC.B   $08,$0A,$09,$09,$0A,$0A,$00,$00
      DC.B   $08,$09,$09,$09,$0A,$0A,$07,$07
      DC.B   $08,$09,$09,$08,$0A,$0A,$08,$08
      DC.B   $08,$0A,$09,$08,$0A,$0A,$04,$04
      DC.B   $08,$09,$09,$09,$0A,$0A,$06,$06
      DC.B   $08,$0A,$09,$08,$0A,$0A,$01,$01
      DC.B   $08,$09,$09,$09,$0A,$0A,$05,$05
      DC.B   $08,$09,$09,$08,$0A,$0A,$07,$07
      DC.B   $08,$08,$09,$08,$0A,$0A,$08,$08
      DC.B   $08,$09,$09,$09,$0A,$0A,$02,$02
      DC.B   $08,$09,$09,$08,$0A,$0A,$06,$06
      DC.B   $08,$09,$09,$09,$0A,$0A,$00,$00
      DC.B   $08,$09,$09,$07,$0A,$0A,$07,$07
      DC.B   $08,$08,$09,$08,$0A,$0A,$07,$07
      DC.B   $08,$09,$09,$07,$0A,$0A,$06,$06
      DC.B   $08,$09,$09,$08,$0A,$0A,$02,$02
      DC.B   $08,$08,$09,$08,$0A,$0A,$06,$06
      DC.B   $08,$09,$09,$06,$0A,$0A,$06,$06
      DC.B   $08,$08,$09,$07,$0A,$0A,$07,$07
      DC.B   $08,$08,$09,$08,$0A,$0A,$04,$04
      DC.B   $08,$08,$09,$07,$0A,$0A,$06,$06
      DC.B   $08,$08,$09,$08,$0A,$0A,$02,$02
      DC.B   $08,$07,$09,$07,$0A,$0A,$07,$07
      DC.B   $08,$08,$09,$06,$0A,$0A,$06,$06
      DC.B   $08,$08,$09,$07,$0A,$0A,$04,$04
      DC.B   $08,$07,$09,$07,$0A,$0A,$06,$06
      DC.B   $08,$08,$09,$06,$0A,$0A,$05,$05
      DC.B   $08,$08,$09,$06,$0A,$0A,$04,$04
      DC.B   $08,$07,$09,$06,$0A,$0A,$06,$06
      DC.B   $08,$07,$09,$07,$0A,$0A,$04,$04
      DC.B   $08,$08,$09,$05,$0A,$0A,$04,$04
      DC.B   $08,$06,$09,$06,$0A,$0A,$06,$06
      DC.B   $08,$07,$09,$06,$0A,$0A,$04,$04
      DC.B   $08,$07,$09,$05,$0A,$0A,$05,$05
      DC.B   $08,$06,$09,$06,$0A,$0A,$05,$05
      DC.B   $08,$06,$09,$06,$0A,$0A,$04,$04
      DC.B   $08,$06,$09,$05,$0A,$0A,$05,$05
      DC.B   $08,$06,$09,$06,$0A,$0A,$02,$02
      DC.B   $08,$06,$09,$05,$0A,$0A,$04,$04
      DC.B   $08,$05,$09,$05,$0A,$0A,$05,$05
      DC.B   $08,$06,$09,$05,$0A,$0A,$02,$02
      DC.B   $08,$05,$09,$05,$0A,$0A,$04,$04
      DC.B   $08,$05,$09,$04,$0A,$0A,$04,$04
      DC.B   $08,$05,$09,$05,$0A,$0A,$02,$02
      DC.B   $08,$04,$09,$04,$0A,$0A,$04,$04
      DC.B   $08,$04,$09,$04,$0A,$0A,$03,$03
      DC.B   $08,$04,$09,$04,$0A,$0A,$02,$02
      DC.B   $08,$04,$09,$03,$0A,$0A,$03,$03
      DC.B   $08,$03,$09,$03,$0A,$0A,$03,$03
      DC.B   $08,$03,$09,$03,$0A,$0A,$02,$02
      DC.B   $08,$03,$09,$02,$0A,$0A,$02,$02
      DC.B   $08,$02,$09,$02,$0A,$0A,$02,$02
      DC.B   $08,$02,$09,$02,$0A,$0A,$01,$01
      DC.B   $08,$01,$09,$01,$0A,$0A,$01,$01
      DC.B   $08,$02,$09,$01,$0A,$0A,$00,$00
      DC.B   $08,$01,$09,$01,$0A,$0A,$00,$00
      DC.B   $08,$01,$09,$00,$0A,$0A,$00,$00
      DC.B   $08,$00,$09,$00,$0A,$0A,$00,$00
L0008:DC.B   $00,$59,$45,$54,$00,$00,$00,$00  
      END

