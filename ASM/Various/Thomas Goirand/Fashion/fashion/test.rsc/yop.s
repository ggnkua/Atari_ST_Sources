______________________________	EQU	000	; 

