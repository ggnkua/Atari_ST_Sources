ARBRE1	EQU	000	; 

OBJET1_0	EQU	000	; 

OBJET1_2	EQU	002	; 

ARBRE2	EQU	001	; 

OBJET2_0	EQU	000	; 

