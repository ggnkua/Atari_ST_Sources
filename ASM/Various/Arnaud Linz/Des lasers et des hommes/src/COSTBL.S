COSTBL
	DC.W	$7FFF,$7FFD,$7FFA,$7FF3,$7FEB,$7FDF,$7FD2,$7FC1,$7FAF,$7F99,$7F82,$7F68,$7F4B,$7F2C,$7F0A,$7EE6,$7EC0,$7E97
	DC.W	$7E6B,$7E3D,$7E0D,$7DDA,$7DA4,$7D6D,$7D32,$7CF6,$7CB7,$7C75,$7C31,$7BEB,$7BA2,$7B57,$7B09,$7AB9,$7A67,$7A12
	DC.W	$79BB,$7961,$7905,$78A7,$7846,$77E3,$777E,$7716,$76AD,$7640,$75D2,$7561,$74EE,$7478,$7400,$7387,$730A,$728C
	DC.W	$720B,$7188,$7103,$707C,$6FF2,$6F66,$6ED9,$6E49,$6DB6,$6D22,$6C8B,$6BF3,$6B58,$6ABB,$6A1D,$697C,$68D9,$6834
	DC.W	$678D,$66E3,$6638,$658B,$64DC,$642B,$6378,$62C3,$620C,$6154,$6099,$5FDD,$5F1E,$5E5E,$5D9C,$5CD8,$5C12,$5B4B
	DC.W	$5A81,$59B6,$58E9,$581B,$574B,$5679,$55A5,$54D0,$53F9,$5320,$5246,$516A,$508C,$4FAD,$4ECD,$4DEB,$4D07,$4C22
	DC.W	$4B3B,$4A53,$496A,$487F,$4793,$46A5,$45B6,$44C5,$43D3,$42E0,$41EC,$40F6,$3FFF,$3F07,$3E0D,$3D13,$3C17,$3B1A
	DC.W	$3A1B,$391C,$381C,$371A,$3617,$3514,$340F,$3309,$3203,$30FB,$2FF2,$2EE9,$2DDE,$2CD3,$2BC6,$2AB9,$29AB,$289D
	DC.W	$278D,$267D,$256C,$245A,$2347,$2234,$2120,$200C,$1EF7,$1DE1,$1CCA,$1BB4,$1A9C,$1984,$186C,$1753,$1639,$1520
	DC.W	$1405,$12EB,$11D0,$10B4,$0F99,$0E7D,$0D61,$0C44,$0B27,$0A0A,$08ED,$07D0,$06B2,$0595,$0477,$0359,$023B,$011D
	DC.W	$0000,$FEE3,$FDC5,$FCA7,$FB89,$FA6B,$F94E,$F830,$F713,$F5F6,$F4D9,$F3BC,$F29F,$F183,$F067,$EF4C,$EE30,$ED15
	DC.W	$EBFB,$EAE0,$E9C7,$E8AD,$E794,$E67C,$E564,$E44C,$E336,$E21F,$E109,$DFF4,$DEE0,$DDCC,$DCB9,$DBA6,$DA94,$D983
	DC.W	$D873,$D763,$D655,$D547,$D43A,$D32D,$D222,$D117,$D00E,$CF05,$CDFD,$CCF7,$CBF1,$CAEC,$C9E9,$C8E6,$C7E4,$C6E4
	DC.W	$C5E5,$C4E6,$C3E9,$C2ED,$C1F3,$C0F9,$C001,$BF0A,$BE14,$BD20,$BC2D,$BB3B,$BA4A,$B95B,$B86D,$B781,$B696,$B5AD
	DC.W	$B4C5,$B3DE,$B2F9,$B215,$B133,$B053,$AF74,$AE96,$ADBA,$ACE0,$AC07,$AB30,$AA5B,$A987,$A8B5,$A7E5,$A717,$A64A
	DC.W	$A57F,$A4B5,$A3EE,$A328,$A264,$A1A2,$A0E2,$A023,$9F67,$9EAC,$9DF4,$9D3D,$9C88,$9BD5,$9B24,$9A75,$99C8,$991D
	DC.W	$9873,$97CC,$9727,$9684,$95E3,$9545,$94A8,$940D,$9375,$92DE,$924A,$91B7,$9127,$909A,$900E,$8F84,$8EFD,$8E78
	DC.W	$8DF5,$8D74,$8CF6,$8C79,$8C00,$8B88,$8B12,$8A9F,$8A2E,$89C0,$8953,$88EA,$8882,$881D,$87BA,$8759,$86FB,$869F
	DC.W	$8645,$85EE,$8599,$8547,$84F7,$84A9,$845E,$8415,$83CF,$838B,$8349,$830A,$82CE,$8293,$825C,$8226,$81F3,$81C3
	DC.W	$8195,$8169,$8140,$811A,$80F6,$80D4,$80B5,$8098,$807E,$8067,$8051,$803F,$802E,$8021,$8015,$800D,$8006,$8003
	DC.W	$8001,$8003,$8006,$800D,$8015,$8021,$802E,$803F,$8051,$8067,$807E,$8098,$80B5,$80D4,$80F6,$811A,$8140,$8169
	DC.W	$8195,$81C3,$81F3,$8226,$825C,$8293,$82CE,$830A,$8349,$838B,$83CF,$8415,$845E,$84A9,$84F7,$8547,$8599,$85EE
	DC.W	$8645,$869F,$86FB,$8759,$87BA,$881D,$8882,$88EA,$8953,$89C0,$8A2E,$8A9F,$8B12,$8B88,$8C00,$8C79,$8CF6,$8D74
	DC.W	$8DF5,$8E78,$8EFD,$8F84,$900E,$909A,$9127,$91B7,$924A,$92DE,$9375,$940D,$94A8,$9545,$95E3,$9684,$9727,$97CC
	DC.W	$9873,$991D,$99C8,$9A75,$9B24,$9BD5,$9C88,$9D3D,$9DF4,$9EAC,$9F67,$A023,$A0E2,$A1A2,$A264,$A328,$A3EE,$A4B5
	DC.W	$A57F,$A64A,$A717,$A7E5,$A8B5,$A987,$AA5B,$AB30,$AC07,$ACE0,$ADBA,$AE96,$AF74,$B053,$B133,$B215,$B2F9,$B3DE
	DC.W	$B4C5,$B5AD,$B696,$B781,$B86D,$B95B,$BA4A,$BB3B,$BC2D,$BD20,$BE14,$BF0A,$C001,$C0F9,$C1F3,$C2ED,$C3E9,$C4E6
	DC.W	$C5E5,$C6E4,$C7E4,$C8E6,$C9E9,$CAEC,$CBF1,$CCF7,$CDFD,$CF05,$D00E,$D117,$D222,$D32D,$D43A,$D547,$D655,$D763
	DC.W	$D873,$D983,$DA94,$DBA6,$DCB9,$DDCC,$DEE0,$DFF4,$E109,$E21F,$E336,$E44C,$E564,$E67C,$E794,$E8AD,$E9C7,$EAE0
	DC.W	$EBFB,$ED15,$EE30,$EF4C,$F067,$F183,$F29F,$F3BC,$F4D9,$F5F6,$F713,$F830,$F94E,$FA6B,$FB89,$FCA7,$FDC5,$FEE3
	DC.W	$0000,$011D,$023B,$0359,$0477,$0595,$06B2,$07D0,$08ED,$0A0A,$0B27,$0C44,$0D61,$0E7D,$0F99,$10B4,$11D0,$12EB
	DC.W	$1405,$1520,$1639,$1753,$186C,$1984,$1A9C,$1BB4,$1CCA,$1DE1,$1EF7,$200C,$2120,$2234,$2347,$245A,$256C,$267D
	DC.W	$278D,$289D,$29AB,$2AB9,$2BC6,$2CD3,$2DDE,$2EE9,$2FF2,$30FB,$3203,$3309,$340F,$3514,$3617,$371A,$381C,$391C
	DC.W	$3A1B,$3B1A,$3C17,$3D13,$3E0D,$3F07,$3FFF,$40F6,$41EC,$42E0,$43D3,$44C5,$45B6,$46A5,$4793,$487F,$496A,$4A53
	DC.W	$4B3B,$4C22,$4D07,$4DEB,$4ECD,$4FAD,$508C,$516A,$5246,$5320,$53F9,$54D0,$55A5,$5679,$574B,$581B,$58E9,$59B6
	DC.W	$5A81,$5B4B,$5C12,$5CD8,$5D9C,$5E5E,$5F1E,$5FDD,$6099,$6154,$620C,$62C3,$6378,$642B,$64DC,$658B,$6638,$66E3
	DC.W	$678D,$6834,$68D9,$697C,$6A1D,$6ABB,$6B58,$6BF3,$6C8B,$6D22,$6DB6,$6E49,$6ED9,$6F66,$6FF2,$707C,$7103,$7188
	DC.W	$720B,$728C,$730A,$7387,$7400,$7478,$74EE,$7561,$75D2,$7640,$76AD,$7716,$777E,$77E3,$7846,$78A7,$7905,$7961
	DC.W	$79BB,$7A12,$7A67,$7AB9,$7B09,$7B57,$7BA2,$7BEB,$7C31,$7C75,$7CB7,$7CF6,$7D32,$7D6D,$7DA4,$7DDA,$7E0D,$7E3D
	DC.W	$7E6B,$7E97,$7EC0,$7EE6,$7F0A,$7F2C,$7F4B,$7F68,$7F82,$7F99,$7FAF,$7FC1,$7FD2,$7FDF,$7FEB,$7FF3,$7FFA,$7FFD
