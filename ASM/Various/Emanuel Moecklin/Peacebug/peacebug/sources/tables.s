*-------------------------------------------------------------------------------

		.EXPORT		KeyTable_1,KeyTable_2,Convert
		.EXPORT		MouseData,MouseMask,MouseData2,MouseMask2
		.EXPORT		ResolutionTT,ResolutionST,Hardware_ST,Hardware_TT,Hardware_STE_TT

		.INCLUDE	'EQU.S'

*-------------------------------------------------------------------------------

		.DATA
* Tabelle zum wandeln der Scancodes in Asciicodes
; -1 sind Steuertasten (Return, Delete etc.) und Funktionstasten
; Code 0 sind alle Umschalttasten (Shift, Alternate etc.) und nichtexistierende
; Tasten (Scancode 73, 79 etc.)
; die restlichen sind Asciicodes
			dc.b	0
KeyTable_1:	dc.b	-1,'1','2','3','4','5','6','7','8','9','0','ž',"'",-1
			dc.b	-1,'q','w','e','r','t','z','u','i','o','p','�','+',-1
			dc.b	0,'a','s','d','f','g','h','j','k','l','”','„','#'
			dc.b	0,'~','y','x','c','v','b','n','m',',','.','-',0,0
			dc.b	0,32,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0,-1,-1,0,'-',-1,0,-1,'+'
			dc.b	0,-1,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0
			dc.b	'<',-1,-1,'(',')','/','*','7','8','9','4','5','6','1','2','3','0','.'
			dc.b	-1,0,0,0,0,0,'1','2','3','4','5','6','7','8','9','0','ž',"'",0
			dc.b	0

KeyTable_2:	dc.b	-1,'!','"','Ý','$','%','&','/','(',')','=','?',"`",-1
			dc.b	-1,'Q','W','E','R','T','Z','U','I','O','P','š','*',-1
			dc.b	0,'A','S','D','F','G','H','J','K','L','™','Ž','^'
			dc.b	0,'|','Y','X','C','V','B','N','M',';',':','_',0,0
			dc.b	0,32,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0,-1,-1,0,'-',-1,0,-1,'+'
			dc.b	0,-1,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0
			dc.b	'<',-1,-1,'(',')','/','*','7','8','9','4','5','6','1','2','3','0','.'
			dc.b	-1,0,0,0,0,0,'1','2','3','4','5','6','7','8','9','0','ž',"'",0
			dc.b	0
		.EVEN

*-------------------------------------------------------------------------------

* Tabelle zum konvertieren von Klein nach Gross (ASCII)
Convert:	dc.b	0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19
			dc.b	20,21,22,23,24,25,26,27,28,29,30,31,0,33,34,35,36
			dc.b	37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53
			dc.b	54,55,56,57,58,59,60,61,62,63,64,65,66,67,68,69,70
			dc.b	71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87
			dc.b	88,89,90,91,92,93,94,95,96
			dc.b	65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81
			dc.b	82,83,84,85,86,87,88,89,90,123
			dc.b	124,125,126,127,128,129,130,131,132,133,134,135,136
			dc.b	137,138,139,140,141,142,143,144,145,146,147,148,149
			dc.b	150,151,152,153,154,155,156,157,158,159,160,161,162
			dc.b	163,164,165,166,167,168,169,170,171,172,173,174,175
			dc.b	176,177,178,179,180,181,182,183,184,185,186,187,188
			dc.b	189,190,191,192,193,194,195,196,197,198,199,200,201
			dc.b	202,203,204,205,206,207,208,209,210,211,212,213,214
			dc.b	215,216,217,218,219,220,221,222,223,224,225,226,227
			dc.b	228,229,230,231,232,233,234,235,236,237,238,239,240
			dc.b	241,242,243,244,245,246,247,248,249,250,251,252,253
			dc.b	254,255
		.EVEN

*-------------------------------------------------------------------------------

MouseData:	dc.w	%0000000000000000
			dc.w	%0100000000000000
			dc.w	%0110000000000000
			dc.w	%0111000000000000
			dc.w	%0111100000000000
			dc.w	%0111110000000000
			dc.w	%0111111000000000
			dc.w	%0111111100000000
			dc.w	%0111111110000000
			dc.w	%0111110000000000
			dc.w	%0110110000000000
			dc.w	%0100011000000000
			dc.w	%0000011000000000
			dc.w	%0000001100000000
			dc.w	%0000001100000000
			dc.w	%0000000000000000

*-------------------------------------------------------------------------------

MouseMask:	dc.w	%1100000000000000
			dc.w	%1110000000000000
			dc.w	%1111000000000000
			dc.w	%1111100000000000
			dc.w	%1111110000000000
			dc.w	%1111111000000000
			dc.w	%1111111100000000
			dc.w	%1111111110000000
			dc.w	%1111111111000000
			dc.w	%1111111111100000
			dc.w	%1111111000000000
			dc.w	%1110111100000000
			dc.w	%1100111100000000
			dc.w	%1000011110000000
			dc.w	%0000011110000000
			dc.w	%0000001110000000

*-------------------------------------------------------------------------------

MouseData2:	dc.w	-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,0,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,0,0,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,0,0,0,0,0,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,0,0,0,0,0,0,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,0,0,0-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,0,-1,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,0,-1,-1,-1,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,-1,-1,-1,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,-1,-1,-1,-1,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,-1,-1,-1,-1,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1
			dc.w	-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1

*-------------------------------------------------------------------------------

MouseMask2:	dc.w	-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0
			dc.w	-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0
			dc.w	-1,-1,-1,0,-1,-1,-1,-1,0,0,0,0,0,0,0,0
			dc.w	-1,-1,0,0,-1,-1,-1,-1,0,0,0,0,0,0,0,0
			dc.w	-1,0,0,0,0,-1,-1,-1,-1,0,0,0,0,0,0,0
			dc.w	0,0,0,0,0,-1,-1,-1,-1,0,0,0,0,0,0,0
			dc.w	0,0,0,0,0,0,-1,-1,-1,0,0,0,0,0,0,0

*-------------------------------------------------------------------------------

ResolutionTT:
			dc.w	320/8,200,4,$00			; ST-Low
			dc.w	640/8,200,2,$0100		; ST-Mid
			dc.w	640/8,400,1,$0200		; ST-High
			dc.w	0,0,0,0
			dc.w	640/8,480,4,$0400		; TT-Mid
			dc.w	0,0,0,0
			dc.w	1280/8,960,1,$0600		; TT-High
			dc.w	320/8,480,8,$0700		; TT-Low
ResolutionST:
			dc.w	320/8,200,4,0			; ST-Low
			dc.w	640/8,200,2,1			; ST-Mid
			dc.w	640/8,400,1,2			; ST-High

*-------------------------------------------------------------------------------

Hardware_ST:dc.w	MEMCONF,ST_GPIP,ST_AER,ST_DDR,ST_IERA,ST_IERB
			dc.w	ST_IMRA,ST_IMRB,ST_VR,ST_TACR,ST_TBCR,ST_TCDCR
Hardware_TT:dc.w	TT_GPIP,TT_AER,TT_DDR,TT_IERA,TT_IERB
			dc.w	TT_IMRA,TT_IMRB,TT_VR,TT_TACR,TT_TBCR,TT_TCDCR
Hardware_STE_TT:
			dc.w	SYS_MASK,VME_MASK,SYS_INIT,VME_INIT,SCU_GP1,SCU_GP2
