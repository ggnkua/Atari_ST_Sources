VERSION				EQU '0132'					; Versionsnummer
KENNUNG				EQU	'PBUG'

BETATEST			EQU -1

COOKIE_LENGTH		EQU 25
CACHE_LAENGE		EQU 162+108					; inklusive der beiden Pointer
GENAUIGKEIT			EQU 8
ANZAHL_BREAKPOINTS	EQU 10
ANZAHL_SHOW			EQU 10
ANZAHL_VEKTOREN 	EQU 48
ANZAHL_BEFEHLE		EQU 58
ANZAHL_REGISTER 	EQU 41
ANZAHL_ADRESSEN 	EQU 20						; Fehler
MENUE_LENGTH		EQU 240
LINES_NUMBER		EQU 16						; Anzahl Zeilen f�r Load, Lexecute, List
DISSTRING_DISTANZ	EQU 3						; minimale Distanz zwischen Opcode und Operanden
FALCONREGLENGTH 	EQU 40
SCREEN				EQU 2						; Screendevice

ILLEGAL_OPCODE		EQU $4AFC					; $4AFA/B/C oder $4848

* Tracemodi f�r Trace_modus_1
TRACE_68020			EQU 0
TRACE_PLUS			EQU 1
TRACE_MINUS			EQU 2
TRACE_ANZAHL		EQU 3
TRACE_ALL			EQU 4
TRACE_ONE			EQU 5
* Tracemodi f�r Trace_modus_2
TRACE_EXCEPT		EQU 1
TRACE_TO_TOS		EQU 2
TRACE_RTS			EQU 3
TRACE_NOT			EQU 4

MEMVALID			EQU $0420
MEMVAL2 			EQU $043A
MEMVAL3 			EQU $051A
RESVALID			EQU $0426
RESVECTOR			EQU $042A
FLOCK				EQU $043E
_FRCLOCK			EQU $0466
_HZ_200 			EQU $04BA
_SYSBASE			EQU $04F2
_SHELL_P			EQU $04F6
PUN_PTR 			EQU $0512
_P_COOKIES			EQU $05A0

MEMCONF 			EQU $FFFF8001

VIDEO_BASE_HIGH 	EQU $FFFF8201					; Video Hardware
VIDEO_BASE_LOW		EQU $FFFF820D
SYNC_MODE			EQU $FFFF820A
SHIFTMD_ST			EQU $FFFF8260
SHIFTMD_TT			EQU $FFFF8262					; Word
HSCROLL 			EQU $FFFF8265
LINEWID 			EQU $FFFF820F
F_REGISTER_ST		EQU $FFFF8240					; Word
F_REGISTER_TT		EQU $FFFF8400					; Word
F_REGISTER_F030 	EQU $FFFF9800					; Long

ST_GPIP 			EQU $FFFFFA01					; ST-MFP
ST_AER				EQU $FFFFFA03
ST_DDR				EQU $FFFFFA05
ST_IERA 			EQU $FFFFFA07
ST_IERB 			EQU $FFFFFA09
ST_IPRA 			EQU $FFFFFA0B
ST_IPRB 			EQU $FFFFFA0D
ST_ISRA 			EQU $FFFFFA0F
ST_ISRB 			EQU $FFFFFA11
ST_IMRA 			EQU $FFFFFA13
ST_IMRB 			EQU $FFFFFA15
ST_VR				EQU $FFFFFA17
ST_TACR 			EQU $FFFFFA19
ST_TBCR 			EQU $FFFFFA1B
ST_TCDCR			EQU $FFFFFA1D
ST_TBDR 			EQU $FFFFFA21
ST_TSR				EQU $FFFFFA2D
ST_UDR				EQU $FFFFFA2F

TT_GPIP 			EQU $FFFFFA81					; TT-MFP
TT_AER				EQU $FFFFFA83
TT_DDR				EQU $FFFFFA85
TT_IERA 			EQU $FFFFFA87
TT_IERB 			EQU $FFFFFA89
TT_IPRA 			EQU $FFFFFA8B
TT_IPRB 			EQU $FFFFFA8D
TT_ISRA 			EQU $FFFFFA8F
TT_ISRB 			EQU $FFFFFA91
TT_IMRA 			EQU $FFFFFA93
TT_IMRB 			EQU $FFFFFA95
TT_VR				EQU $FFFFFA97
TT_TACR 			EQU $FFFFFA99
TT_TBCR 			EQU $FFFFFA9B
TT_TCDCR			EQU $FFFFFA9D

ACIA_STATUS_IKBD	EQU $FFFFFC00					; Acia IKBD
ACIA_DATA_IKBD		EQU $FFFFFC02
ACIA_STATUS_MIDI	EQU $FFFFFC04					; Acia MIDI
ACIA_DATA_MIDI		EQU $FFFFFC06

GISELECT			EQU $FFFF8800
GIREAD				EQU $FFFF8800
GIWRITE 			EQU $FFFF8802

FIFO				EQU $FFFF8606					; DMA

S_ICR				EQU $FFFF8783					; SCSI-Controller
S_INIRCV			EQU $FFFF878F

SCCCTL_A			EQU $FFFF8C81					; SCC-Register
SCCCTL_B			EQU $FFFF8C85

SYS_MASK			EQU $FFFF8E01					; SCU-Register
VME_MASK			EQU $FFFF8E0D
SYS_INIT			EQU $FFFF8E05
VME_INIT			EQU $FFFF8E07
SCU_GP1 			EQU $FFFF8E09
SCU_GP2 			EQU $FFFF8E0B

SNDMACTL			EQU $FFFF8900					; DMA-Sound Word

MWDATA				EQU $FFFF8922					; Microwire
MWMASK				EQU $FFFF8924

FPSTAT				EQU $FFFFFA40
