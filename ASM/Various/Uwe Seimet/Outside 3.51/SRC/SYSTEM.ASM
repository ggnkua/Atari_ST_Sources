*GEMDOS-Aufrufe
GEMDOS	= 1
PTERM0	= 0
CCONIN	= 1
CCONOUT	= 2
CAUXIN	= 3
CAUXOUT	= 4
CPRNOUT	= 5
CRAWIO	= 6
CRAWCIN	= 7
CNECIN	= 8
CCONWS	= 9
CCONRS	= 10
CCONIS	= 11
DSETDRV	= 14
CCONOS	= 16
CPRNOS	= 17
CAUXIS	= 18
CAUXOS	= 19
MADDALT	= 20
DGETDRV	= 25
FSETDTA	= 26
SUPER	= 32
TGETDATE	= 42
TSETDATE	= 43
TGETTIME	= 44
TSETTIME	= 45
FGETDTA	= 47
SVERSION	= 48
PTERMRES	= 49
DFREE	= 54
DCREATE	= 57
DDELETE	= 58
DSETPATH	= 59
FCREATE	= 60
FOPEN	= 61
FCLOSE	= 62
FREAD	= 63
FWRITE	= 64
FDELETE	= 65
FSEEK	= 66
FATTRIB	= 67
MXALLOC	= 68
FDUP	= 69
FFORCE	= 70
DGETPATH	= 71
MALLOC	= 72
MFREE	= 73
MSHRINK	= 74
PEXEC	= 75
PTERM	= 76
FSFIRST	= 78
FSNEXT	= 79
FRENAME	= 86
FDATIME	= 87
FLOCK	= 92

SYIELD	= 255
FPIPE	= 256
FCNTL	= 260
FINSTAT	= 261
FOUTSTAT	= 262
FGETCHAR	= 263
FPUTCHAR	= 264
PWAIT	= 265
PNICE	= 266
PGETPID	= 267
PGETPPID	= 268
PGETPGRP	= 269
PSETPGRP	= 270
PGETUID	= 271
PSETUID	= 272
PKILL	= 273
PSIGNAL	= 274
PVFORK	= 275
PGETGID	= 276
PSETGID	= 277
PSIGBLOCK= 278
PSIGSETMASK= 279
PUSRVAL	= 280
PDOMAIN	= 281
PSIGRETURN= 282
PFORK	= 283
PWAIT3	= 284
FSELECT	= 285
PRUSAGE	= 286
PSETLIMIT= 287
TALARM	= 288
PAUSE	= 289
SYSCONF	= 290
PSIGPENDING= 291
DPATHCONF= 292
PMSG	= 293
FMIDIPIPE= 294
PRENICE	= 295
DOPENDIR	= 296
DREADDIR	= 297
DREWINDDIR= 298
DCLOSEDIR= 299
FXATTR	= 300
FLINK	= 301
FSYMLINK	= 302
FREADLINK= 303
DCNTL	= 304
FCHOWN	= 305
FCHMOD	= 306
PUMASK	= 307
PSEMAPHORE= 308
DLOCK	= 309

*BIOS-Aufrufe
BIOS	= 13
GETMPB	= 0
BCONSTAT	= 1
BCONIN	= 2
BCONOUT	= 3
RWABS	= 4
SETEXC	= 5
TICKCAL	= 6
GETBPB	= 7
BCOSTAT	= 8
MEDIACH	= 9
DRVMAP	= 10
KBSHIFT	= 11

*XBIOS-Aufrufe
XBIOS	= 14
INITMOUS	= 0
SSBRK	= 1
PHYSBASE	= 2
LOGBASE	= 3
GETREZ	= 4
SETSCREEN= 5
SETPALETTE= 6
SETCOLOR	= 7
FLOPRD	= 8
FLOPWR	= 9
FLOPFMT	= 10
MIDIWS	= 12
MFPINT	= 13
IOREC	= 14
RSCONF	= 15
KEYTBL	= 16
RANDOM	= 17
PROTOBT	= 18
FLOPVER	= 19
SCRDMP	= 20
CURSCONF	= 21
SETTIME	= 22
GETTIME	= 23
BIOSKEYS	= 24
IKBDWS	= 25
JDISINT	= 26
JENABINT	= 27
GIACCESS	= 28
OFFGIBIT	= 29
ONGIBIT	= 30
XBTIMER	= 31
DOSOUND	= 32
SETPRT	= 33
KBDVBASE	= 34
KBRATE	= 35
PRTBLK	= 36
VSYNC	= 37
SUPEXEC	= 38
PUNTAES	= 39
FLOPRATE	= 41
DMAREAD	= 42
DMAWRITE	= 43
BCONMAP	= 44
NVMACCESS= 46
METAINIT	= 48
BLITMODE	= 64
_ESETSHIFT = 80
_EGETSHIFT = 81
_ESETBANK = 82
_ESETCOLOR = 83
_ESETPALETTE = 84
_EGETPALETTE = 85
_ESETGREY = 86
_ESETSMEAR = 87
VSETMODE	= 88
MON_TYPE	= 89
VSETSYNC	= 90
VGETSIZE	= 91
VSETRGB	= 93
VGETRGB	= 94
VGETMASK	= 150
*GEMDOS-Fehler
EINVFN	= -32
EFILNF	= -33
EPTHNF	= -34
ENHNDL	= -35
EACCDN	= -36
EIHNDL	= -37
EINVHDL = -37
ENSMEM	= -39
EIMBA	= -40
EDRIVE	= -46
EXDEV	= -48
ENMFIL	= -49
ELOCKED = -58
ENSLOCK	= -59
ERANGE	= -64
EINTRN	= -65
EPLFMT	= -66
ENOEXEC	= -66
EGSBF	= -67

*AES-Aufrufe
APPL_INIT= 10
APPL_READ= 11
APPL_WRITE= 12
APPL_FIND= 13
APPL_TPLAY= 14
APPL_TRECORD= 15
APPL_BVSET= 16
APPL_YIELD= 17
APPL_SEARCH= 18
APPL_EXIT= 19
EVNT_KEYBD= 20
EVNT_BUTTON= 21
EVNT_MOUSE= 22
EVNT_MESAG= 23
EVNT_TIMER= 24
EVNT_MULTI= 25
EVNT_DCLICK= 26
MENU_BAR	= 30
MENU_ICHECK= 31
MENU_IENABLE= 32
MENU_TNORMAL= 33
MENU_TEXT= 34
MENU_REGISTER=35
MENU_POPUP=36
MENU_ATTACH=37
MENU_ISTART=38
MENU_SETTINGS=39
OBJC_ADD	= 40
OBJC_DELETE= 41
OBJC_DRAW= 42
OBJC_FIND= 43
OBJC_OFFSET= 44
OBJC_ORDER= 45
OBJC_EDIT= 46
OBJC_CHANGE= 47
OBJC_SYSVAR= 48
FORM_DO	= 50
FORM_DIAL= 51
FORM_ALERT= 52
FORM_ERROR= 53
FORM_CENTER= 54
FORM_KEYBD= 55
FORM_BUTTON= 56
GRAF_RUBBERBOX=70
GRAF_DRAGBOX= 71
GRAF_MOVEBOX= 72
GRAF_GROWBOX= 73
GRAF_SHRINKBOX= 74
GRAF_WATCHBOX= 75
GRAF_SLIDEBOX= 76
GRAF_HANDLE= 77
GRAF_MOUSE= 78
GRAF_MKSTATE= 79
SCRP_READ= 80
SCRP_WRITE= 81
SCRP_CLEAR= 82
FSEL_INPUT= 90
FSEL_EXINPUT= 91
WIND_CREATE= 100
WIND_OPEN= 101
WIND_CLOSE= 102
WIND_DELETE= 103
WIND_GET	= 104
WIND_SET	= 105
WIND_FIND= 106
WIND_UPDATE= 107
WIND_CALC= 108
WIND_NEW	= 109
RSRC_LOAD= 110
RSRC_FREE= 111
RSRC_GADDR= 112
RSRC_SADDR= 113
RSRC_OBFIX= 114
RSRC_RCFIX= 115
SHEL_READ= 120
SHEL_WRITE= 121
SHEL_GET	= 122
SHEL_PUT	= 123
SHEL_FIND= 124
SHEL_ENVRN= 125
SHEL_RDEF= 126
SHEL_WDEF= 127
APPL_GETINFO= 130
WDLG_CREATE= 160
WDLG_OPEN= 161
WDLG_CLOSE= 162
WDLG_EVNT= 163
WDLG_REDRAW= 164
WDLG_GET_TREE= 165
WDLG_GET_EDIT= 166
WDLG_SET_EDIT= 167
WDLG_GET_UDATA= 168

*XHDI-Definitionen
XHGetVersion= 0
XHInqTarget= 1
XHReserve= 2
XHLock	= 3
XHStop	= 4
XHEject	= 5
XHDrvMap	= 6
XHInqDev	= 7
XHInqDriver= 8
XHNewCookie= 9
XHReadWrite= 10
XHITarget2= 11
XHInqDev2	= 12
XHDriverSpecial=13
XHGetCapacity= 14
XHMediumChanged= 15
XHMiNTInfo= 16
XHDOSLimits= 17
XHLastAccess= 18
XHReaccess= 19

*Systemvariablen
proc_lives= $380
proc_regs= $384
proc_pc	= $3c4
proc_usp	= $3c8
proc_stk	= $3cc
etv_timer= $400
etv_critic= $404
etv_term	= $408
etv_xtra	= $40c
memvalid	= $420
memcntrl	= $424
resvalid	= $426
resvector= $42a
phystop	= $42e
_membot	= $432
_memtop	= $436
memval2	= $43a
flock	= $43e
seekrate	= $440
_timr_ms	= $442
_fverify	= $444
_bootdev	= $446
palmode	= $448
defshiftmd= $44a
sshiftmd	= $44c
_v_bas_ad= $44e
vblsem	= $452
nvbls	= $454
_vblqueue= $456
colorptr	= $45a
screenpt	= $45e
_vbclock	= $462
_frclock	= $466
hdv_init	= $46a
swv_vec	= $46e
hdv_bpb	= $472
hdv_rw	= $476
hdv_boot	= $47a
hdv_mediach= $47e
_cmdload	= $482
conterm	= $484
trp14ret	= $486
criticret= $48a
themd	= $48e
_____md	= $49e
savptr	= $4a2
_nflops	= $4a6
con_state= $4a8
sav_row	= $4ac
sav_context= $4ae
_bufl	= $4b2
_hz_200	= $4ba
the_env	= $4be
_drvbits	= $4c2
_dskbufp	= $4c6
_autopath= $4ca
_vbl_list= $4ce
_dumpflg	= $4ee
_prtabt	= $4f0
_sysbase	= $4f2
_shell_p	= $4f6
end_os	= $4fa
exec_os	= $4fe
dump_vec	= $502
scr_dump	= $502
prv_lsto	= $506
prv_lst	= $50a
prv_auxo	= $50e
prv_aux	= $512
pun_ptr	= $516
memval3	= $51a
xconstat	= $51e
xconin	= $53e
xcostat	= $55e
xconout	= $57e
_longframe= $59e
_p_cookies= $5a0
_ramtop	= $5a4
_ramvalid= $5a8
bell_hook= $5ac
kcl_hook	= $5b0

*BPB
recsiz	=  0
clsiz	=  2
clsizb	=  4
rdlen	=  6
fsiz	=  8
fatrec	= 10
datrec	= 12
numcl	= 14
bflags	= 16
dntracks= 18
dnsides	= 20
dspc	= 22
dspt	= 24
dhid	= 26
dserial	= 28
