; This file is automatically generated from the voice file 'h:greet.voi'

	section Speech

	xdef speech,endspe

speech
	dc $000695,$91c2f5
	dc $000485,$cdd4f6
	dc $000493,$6d34d5
	dc $000383,$b5b514
	dc $0005a4,$2da6f5
	dc $000484,$2d2556
	dc $000475,$6da4d5
	dc $000475,$49a4f6
	dc $000486,$91b534
	dc $000395,$b14136
	dc $000383,$912714
	dc $000574,$8cb6f6
	dc $000385,$712535
	dc $000685,$552517
	dc $000395,$b0b716
	dc $000586,$4d2354
	dc $000495,$8da715
	dc $000594,$29a335
	dc $000395,$85a736
	dc $000496,$512535
	dc $000485,$751516
	dc $0003a5,$4d24b8
	dc $000477,$693714
	dc $000395,$a5a516
	dc $000486,$b144f5
	dc $0003a4,$b12713
	dc $005374,$29b2d5
	dc $000486,$31b2d5
	dc $0004a5,$4d42d6
	dc $000596,$8d22d4
	dc $000496,$71a6d4
	dc $000394,$5132d5
	dc $000487,$71b336
	dc $000493,$8d92d5
	dc $000493,$b0a517
	dc $0004b5,$8534d5
	dc $000684,$4644f5
	dc $005ba4,$85c4b4
	dc $00b684,$4646d6
	dc $00c883,$2ec4d7
	dc $00fa95,$0764b7
	dc $011685,$46c717
	dc $019447,$a056ee
	dc $7dc574,$84c94c
	dc $7dd499,$c4454a
	dc $7dd39c,$a8b329
	dc $79d37d,$a4a70b
	dc $71d68b,$a4b8e9
	dc $6dd8a9,$a4c567
	dc $6dd8a5,$815728
	dc $71c8ab,$666246
	dc $75d9c8,$8e5485
	dc $7dc8c8,$95c2a5
	dc $85a8ba,$926404
	dc $8dc6ac,$b6d047
	dc $95d4ad,$96b06a
	dc $95fbc8,$6ee427
	dc $960abb,$92e228
	dc $9dce94,$8de666
	dc $9dbea4,$6a6826
	dc $9d9e93,$66d846
	dc $a1ccc4,$76c467
	dc $a59db5,$4b4826
	dc $a59cb7,$135246
	dc $a96ca9,$0f5406
	dc $a9a8ba,$ba22a7
	dc $ad79ba,$5ac266
	dc $b14ba9,$1f4425
	dc $b959ba,$7eb285
	dc $bd49ba,$7eb265
	dc $bd1aba,$5ea265
	dc $bd37b8,$be2287
	dc $bcfba5,$9eb046
	dc $0095b4,$b6a082
	dc $0094b7,$9510a8
	dc $005276,$75232e
	dc $000498,$b0b530
	dc $0002a5,$b1b753
	dc $000393,$b144f5
	dc $000696,$723315
	dc $000497,$6e4494
	dc $0007b6,$71c475
	dc $0006a6,$91d454
	dc $0007d5,$8e4274
	dc $005659,$6a24dc
	dc $000392,$ad36d7
	dc $000595,$69a4f6
	dc $000496,$4d34f6
	dc $000495,$7a4333
	dc $0005a3,$8dc6d4
	dc $0053a2,$a6b478
	dc $005293,$86b4b6
	dc $01048a,$815786
	dc $014473,$625928
	dc $0112a8,$49c944
	dc $00b6b7,$61a941
	dc $d50173,$71c4cd
	dc $d50253,$89a473
	dc $b0b141,$ee468e
	dc $7d2274,$c9b4af
	dc $757368,$c5d948
	dc $71825e,$c95947
	dc $6d927d,$c5d987
	dc $65828c,$e55987
	dc $65a29a,$d24989
	dc $65738a,$ccd9a6
	dc $655259,$89d76a
	dc $654285,$91b4f3
	dc $010284,$b5b8f1
	dc $00b693,$aa3299
	dc $00f9a5,$4e34ba
	dc $010ab9,$8a50d9
	dc $014076,$81d7ac
	dc $61536e,$a0eb67
	dc $61826b,$a9e789
	dc $61a268,$b2576c
	dc $61635e,$895b88
	dc $65826c,$aa578a
	dc $657266,$ae456c
	dc $651124,$a65532
	dc $651473,$a642b9
	dc $64c595,$51b65a
	dc $00e886,$8da2f9
	dc $0107c8,$8e22da
	dc $00c885,$a9d139
	dc $00b398,$6f632b
	dc $0056a2,$d776eb
	dc $00f8dc,$65a974
	dc $005486,$be16f9
	dc $000583,$99151a
	dc $000276,$a9b357
	dc $0163e7,$cf4690
	dc $01c7e2,$a6d88d
	dc $81ed92,$ce472a
	dc $81ecb2,$8e46ca
	dc $81ebc4,$72548a
	dc $7daf64,$8cd8e9
	dc $7dae85,$acea69
	dc $79ada6,$a8e648
	dc $796e84,$a86a47
	dc $797ca5,$65e446
	dc $756ba4,$8de665
	dc $7587c7,$9644a6
	dc $755aa8,$867624
	dc $7588a7,$ae54a5
	dc $75bb75,$a95888
	dc $75bb74,$c4eae9
	dc $75d697,$65e6ab
	dc $75b796,$8566ca
	dc $75c498,$81e4ec
	dc $75c498,$86450b
	dc $759497,$425509
	dc $755364,$2e42ad
	dc $752263,$4a96d5
	dc $bce685,$9a9499
	dc $9d1597,$723297
	dc $011595,$b216b8
	dc $00f7a5,$99b4d8
	dc $0108a6,$ae24f9
	dc $011ac3,$95a658
	dc $954284,$7646ca
	dc $7d07b7,$45d6e2
	dc $814298,$7244e7
	dc $8105ba,$896483
	dc $8116b6,$8dc502
	dc $819385,$d5c4ab
	dc $8187a5,$8dd867
	dc $81a7b4,$765487
	dc $817c82,$52ca66
	dc $7d8ab2,$76c666
	dc $7da6c6,$ba32a8
	dc $7d6bc2,$9a4684
	dc $7d68d7,$ba3265
	dc $7d6ad5,$9a4445
	dc $7d3bc5,$36ba04
	dc $7d48d9,$56ca04
	dc $7d77c8,$7e4626
	dc $7d5aa6,$4eea05
	dc $7db4b7,$ba22ca
	dc $7d6995,$b6e266
	dc $7d5699,$96d286
	dc $7d1889,$56e806
	dc $8534a9,$bf52c7
	dc $8cd49c,$9ae2c6
	dc $8c5899,$b278c3
	dc $00c396,$d6d4cb
	dc $005683,$7656c8
	dc $009285,$91c4ee
	dc $70b284,$91c709
	dc $74e175,$91c708
	dc $78538d,$6dc341
	dc $88c164,$91b4cb
	dc $889163,$91b4c9
	dc $853795,$48a2b7
	dc $85607a,$ca5b2a
	dc $857189,$c9dd26
	dc $85607b,$cddd28
	dc $85704a,$a66eed
	dc $85806a,$d1db0b
	dc $85406e,$a5db4a
	dc $85a168,$d5c8cc
	dc $856169,$f1dd09
	dc $857256,$d95b2b
	dc $897145,$c5ecee
	dc $897135,$a36cb1
	dc $896334,$c2ecaf
	dc $898347,$a2ed2c
	dc $89945a,$c9fb09
	dc $899358,$a6690b
	dc $8d5367,$a6690a
	dc $8d1365,$89c2ae
	dc $8c9355,$6d929b
	dc $8cc295,$8da4b6
	dc $005474,$4a429a
	dc $005696,$8ea299
	dc $009146,$ae469b
	dc $000276,$8da496
	dc $000584,$50b496
	dc $000495,$70b6b5
	dc $000384,$b12716
	dc $000385,$ad3495
	dc $013116,$92bb13
	dc $818038,$86fd30
	dc $857046,$c9eece
	dc $896048,$ed7cce
	dc $89606c,$f65aec
	dc $89108d,$e95d08
	dc $89308a,$b54d27
	dc $893258,$cd4f67
	dc $891316,$c64f4c
	dc $8cb600,$6a4f11
	dc $8cd274,$71b4d1
	dc $000382,$8db4d2
	dc $000363,$6d94d4
	dc $000293,$29b4b4
	dc $000363,$9224d3
	dc $00f8db,$75b76f
	dc $011cf6,$b2a88b
	dc $a0c9fa,$ad864c
	dc $8539c5,$be1827
	dc $856da5,$baa427
	dc $896ca6,$9e84a7
	dc $8d8baa,$f99488
	dc $8d6db5,$fa22a7
	dc $8d2e75,$9f04a6
	dc $8d7cb8,$d99667
	dc $8d7bc6,$d9a4a8
	dc $8d5ea4,$fd92c7
	dc $8d4f77,$be94a7
	dc $8daad8,$d522c9
	dc $8d8db5,$fda2c8
	dc $898d94,$da24c7
	dc $895e37,$9ea367
	dc $8998a3,$b6446c
	dc $88ea91,$ad3688
	dc $889a63,$6dc487
	dc $885393,$524469
	dc $845284,$71b2ca
	dc $8453a6,$8d22ef
	dc $000594,$a9b330
	dc $000484,$68b2f2
	dc $013894,$ad26b3
	dc $00d6a8,$d126f7
	dc $00d7a8,$d1b6d8
	dc $00e7aa,$a9b4f8
	dc $00c7b7,$8e3517
	dc $00e6aa,$51a6d7
	dc $00f7a9,$7622f8
	dc $00f6a8,$91db37
	dc $00f76b,$d13897
	dc $0148e5,$519764
	dc $7db4b8,$91b529
	dc $7d7cdb,$f992a4
	dc $757ce4,$d61304
	dc $7de3b8,$b1b72c
	dc $7d9ae5,$b59545
	dc $815ee6,$d5a0a4
	dc $8dc3a9,$91c74d
	dc $913fe4,$de2264
	dc $9d7ce9,$b5a2e4
	dc $a53fc4,$b9b284
	dc $a95dda,$d5a2c4
	dc $b16bea,$d5a2e5
	dc $b51fe6,$dea064
	dc $011ee7,$ba2264
	dc $0149ea,$b12526
	dc $dc9fd5,$7ec603
	dc $dc9fd4,$bec263
	dc $e09fe6,$9b3423
	dc $005be8,$b1a0c4
	dc $0058d7,$b11085
	dc $0059d6,$d92244
	dc $0003a9,$51056e
	dc $005286,$71c511
	dc $000384,$cd2732
	dc $0002a7,$55c512
	dc $000296,$75c8d4
	dc $0006c8,$965310
	dc $000996,$b22270
	dc $0006b6,$7244b2
	dc $0058b7,$563473
	dc $0006b6,$95b4b2
	dc $0005a7,$5152d3
	dc $000596,$b234f4
	dc $0006b5,$95c474
	dc $0005a6,$4db4d2
	dc $000595,$49d4d4
	dc $000696,$b64694
	dc $0006a4,$724293
	dc $0007b6,$2a44b3
	dc $000495,$51b4f3
	dc $000395,$71c533
	dc $000295,$aa3494
	dc $0003a5,$7238b5
	dc $000393,$563495
	dc $0003b5,$8ca4d5
	dc $000475,$95b315
	dc $000386,$31b714
	dc $000484,$71a4d4
	dc $000395,$913315
	dc $000495,$a936b6
	dc $000474,$b13516
	dc $000484,$522355
	dc $0004a5,$69b516
	dc $0127db,$991724
	dc $6d94da,$713747
	dc $7977ea,$8d2525
	dc $794ae9,$b0a304
	dc $7d74ca,$6d3747
	dc $b193c9,$6d4749
	dc $b13be6,$b522a3
	dc $b1c3a8,$91c72d
	dc $b169e9,$d592c4
	dc $ad4eb3,$d2a263
	dc $658be7,$da2065
	dc $657de4,$d6a245
	dc $658be5,$b6a245
	dc $65a6e9,$9a2467
	dc $6999d7,$9a4245
	dc $698ac5,$d65284
	dc $696a9a,$be5244
	dc $6986b9,$dac0e4
	dc $69a4b9,$ba2307
	dc $69a4c8,$b5a4a8
	dc $6d25c9,$b2a322
	dc $7108d8,$8db561
	dc $7104da,$6d3562
	dc $7133ca,$714763
	dc $718186,$b6472a
	dc $7158e6,$962463
	dc $756cd0,$61cc06
	dc $759bd1,$45da28
	dc $75c9d3,$52444a
	dc $75a9d3,$4a562a
	dc $759ac1,$855828
	dc $7188c3,$a1c628
	dc $7187c3,$853867
	dc $7195b4,$a5b6a8
	dc $6d9396,$8546ea
	dc $6d54b8,$6636c5
	dc $6d2496,$2e3705
	dc $710045,$d6a874
	dc $74f474,$8db074
	dc $74c485,$69a256
	dc $00b6a7,$ad24d6
	dc $00d7b8,$6624f8
	dc $010497,$8db6f8
	dc $014ce0,$2f1a86
	dc $7dacd3,$3324a8
	dc $89ccc6,$92b26a
	dc $89c8f5,$92a82c
	dc $85abe3,$72b82b
	dc $858c91,$6eb86a
	dc $8556c1,$4e46a9
	dc $7d45a6,$923667
	dc $7d25a7,$4e52e5
	dc $7d1389,$322566
	dc $850175,$75b50b
	dc $850394,$91b4f1
	dc $840398,$b0a291
	dc $010ab6,$ba3311
	dc $0124ed,$b1a2da
	dc $00f6cb,$d614fb
	dc $0115db,$cd94da
	dc $00f5b8,$99a2fc
	dc $00e7c9,$5134ba
	dc $0107b9,$8da6fb
	dc $0116c7,$b1953c
	dc $010484,$b632f6
	dc $7582c5,$6e42c9
	dc $7d64d1,$4ab8c9
	dc $8192a4,$b244cd
	dc $8172b6,$764509
	dc $817296,$71c70a
	dc $8106c5,$89c4e2
	dc $84f6d8,$6d42c2
	dc $8530a5,$8e370b
	dc $84d077,$763671
	dc $84d053,$adb6f8
	dc $849354,$aa229c
	dc $009687,$6e24be
	dc $005876,$6626fc
	dc $009498,$89a71d
	dc $009597,$d126fe
	dc $00b265,$f9a89d
	dc $0059d3,$f6d26c
	dc $0102e9,$5bb272
	dc $0146ca,$b6c52a
	dc $0156e6,$16da6a
	dc $995cc0,$6a4cea
	dc $89acc1,$8a28ab
	dc $89b7e5,$4db42b
	dc $857e91,$2948a9
	dc $857db0,$45a909
	dc $856cc0,$4626c9
	dc $8189c3,$6db28b
	dc $816cd0,$26b6c9
	dc $cd5bc2,$6ad2ca
	dc $0136e5,$b6b4ac
	dc $00cae2,$6f56c9
	dc $ecccd3,$975489
	dc $64bcd4,$9fc6c6
	dc $00cad7,$df2507
	dc $0098d7,$daa4a7
	dc $00e6da,$b1b547
	dc $7958e8,$da22a7
	dc $7997e8,$b994c8
	dc $7d9be5,$b5b286
	dc $853f83,$36d284
	dc $856dc4,$963085
	dc $8578d8,$b522c5
	dc $80b8b5,$71a084
	dc $8174a7,$91c734
	dc $8002b9,$b9274d
	dc $0053b7,$a8b52e
	dc $0004a7,$724730
	dc $012285,$6db711
	dc $018d54,$32c6c6
	dc $7dab93,$3246e8
	dc $818d39,$6254e8
	dc $85ab66,$0f3508
	dc $85ab83,$55b727
	dc $856c38,$123726
	dc $857b62,$75b747
	dc $856c27,$ba2729
	dc $855c33,$9a2568
	dc $857a72,$b146c8
	dc $85a7a3,$95c48b
	dc $85b9b2,$ad466d
	dc $857b16,$3a172b
	dc $85d972,$7a470c
	dc $8dba54,$1ac8ad
	dc $8dc575,$0eb8ae
	dc $85c664,$46caee
	dc $85c654,$4358b0
	dc $85c454,$46caf0
	dc $8da347,$825b2f
	dc $d17338,$a1db2c
	dc $d19235,$826930
	dc $8d7237,$a56b2d
	dc $8d7256,$8e34ef
	dc $d0f157,$a9d94a
	dc $d11385,$b134d5
	dc $d00483,$693712
	dc $000273,$4dc2f1
	dc $000284,$adb4f3
	dc $000393,$6632d5
	dc $000475,$7124d4
	dc $000394,$4622d3
	dc $005576,$adb6b8
	dc $0096a5,$a2251a
	dc $00e894,$8a871b
	dc $00baa3,$8688fc
	dc $013057,$ea574c
	dc $01406c,$a627ab
	dc $855049,$c9398e
	dc $85406d,$cdb749
	dc $85307c,$b22909
	dc $853268,$523767
	dc $85243b,$a9c586
	dc $853248,$723587
	dc $84f32d,$a94586
	dc $85032c,$893585
	dc $851248,$69b5a6
	dc $857264,$75a50f
	dc $84e367,$5227a4
	dc $891174,$95b708
	dc $885154,$5633a6
	dc $889273,$6d24b1
	dc $845273,$5132b1
	dc $000283,$712314
	dc $000493,$5536f5
	dc $000485,$6da4f4
	dc $000383,$31a4f5
	dc $000463,$8934d4
	dc $00f898,$91b4b2
	dc $01a5a5,$91c6e9
	dc $85b8a4,$564707
	dc $858a84,$5248e6
	dc $c988a4,$56c8e5
	dc $c9b6a4,$7646c9
	dc $c98983,$16c726
	dc $c9d3b6,$9a44ea
	dc $c98983,$36c926
	dc $c9b695,$5a4907
	dc $c98b54,$16bb26
	dc $85c3b6,$3e56ab
	dc $858a55,$16c747
	dc $85e594,$9a44cc
	dc $898b42,$32c708
	dc $8d93a4,$96428c
	dc $912262,$ae2673
	dc $dd2585,$d596b4
	dc $dd0788,$923298
	dc $00f7b6,$d218f7
	dc $011897,$b144d8
	dc $012788,$75b518
	dc $012994,$b22499
	dc $adc863,$32372b
	dc $920964,$36c6ce
	dc $9617a3,$7648d0
	dc $99f946,$46c70f
	dc $99f946,$66d6f0
	dc $a1e945,$86d8d1
	dc $a1fa43,$86d6d3
	dc $a1c932,$46c733
	dc $ad5b30,$46c714
	dc $ad1772,$7246d4
	dc $a0c772,$5a3894
	dc $000a93,$56c6d3
	dc $000693,$8dc8b3
	dc $000793,$b244f3
	dc $00b896,$95b4f4
	dc $000674,$75a512
	dc $000594,$5234f3
	dc $000696,$95b294
	dc $0005a5,$75b2f4
	dc $0007a3,$723494
	dc $0003a4,$7952b4
	dc $0003a5,$69a514
	dc $0115a6,$9146d3
	dc $016345,$f996d6
	dc $8d57b9,$92d445
	dc $a166bb,$da2466
	dc $a517dd,$a7d405
	dc $b137db,$d93245
	dc $b955ca,$b12307
	dc $bd09da,$ba4424
	dc $c127ca,$f9c266
	dc $c184aa,$4b448b
	dc $c1748a,$63c6ed
	dc $c19457,$6b4af1
	dc $c57246,$634cd3
	dc $dd4256,$a2ec92
	dc $dd2354,$a26cb0
	dc $dd1254,$866cf0
	dc $cd1336,$c9d695
	dc $b50223,$2a58b3
	dc $90e134,$4938af
	dc $905332,$6d98d0
	dc $905254,$9114b1
	dc $000376,$8932d2
	dc $000484,$6d2334
	dc $000394,$71b4f6
	dc $000586,$55c4d5
	dc $000594,$69b2f7
	dc $0005a5,$8d2135
	dc $000483,$ada515
	dc $000593,$7126f3
	dc $000394,$91b515
	dc $000494,$ad3513
	dc $000295,$d1a4f5
	dc $0004b5,$49b4d5
	dc $000394,$69b334
	dc $000385,$ca3535
	dc $000486,$4db6f5
	dc $0004a7,$692556
	dc $0003c5,$2db6b5
	dc $0005a5,$6942f5
	dc $000394,$553535
	dc $0005a3,$7126f5
	dc $000595,$70b534
	dc $0003a4,$b5b716
	dc $000492,$cd3355
	dc $000386,$91a515
	dc $0003a4,$71b4f4
	dc $000696,$71a4f5
	dc $0003b4,$91a2f6
	dc $000576,$753515
	dc $000385,$4e3554
	dc $0005a6,$4d3315
	dc $000387,$6534b6
	dc $000495,$8d32f5
	dc $0002a4,$adc716
	dc $d80385,$911735
	dc $d80486,$70a4d7
	dc $000584,$4ca335
	dc $000575,$3144d6
	dc $000694,$b12516
	dc $000395,$6d4515
	dc $151515,$151515
endspe

	endsec
