; Output multirate raised cosine filter
; Produced by MATLAB (17-Jul-94)
oftaps	equ	11
ofbnks	equ	5

ocoeffs dc	1.644457e-04,-1.504433e-03,2.385762e-03,1.674666e-02
	dc	-1.088596e-01,5.989722e-01,3.432659e-01,-5.464372e-02
	dc	5.612879e-05,4.056970e-03,-7.251839e-04

	dc	5.203691e-04,-1.647690e-03,-2.131887e-03,3.241543e-02
	dc	-1.269868e-01,8.030427e-01,9.854408e-02,3.074350e-03
	dc	-9.180722e-03,2.196331e-03,2.954776e-04

	dc	6.201181e-04,-3.993065e-04,-7.471807e-03,3.183892e-02
	dc	-6.504636e-02,8.817981e-01,-6.707127e-02,3.399076e-02
	dc	-8.337602e-03,-4.715450e-04,7.199058e-04

	dc	2.479836e-04,1.881502e-03,-8.309344e-03,2.901430e-03
	dc	9.617447e-02,8.078832e-01,-1.317905e-01,3.488017e-02
	dc	-2.404078e-03,-1.965893e-03,5.765207e-04

	dc	-6.027904e-04,3.516846e-03,5.127770e-05,-5.194205e-02
	dc	3.370923e-01,6.062329e-01,-1.137336e-01,1.817043e-02
	dc	2.720424e-03,-1.807943e-03,0.000000e+00
