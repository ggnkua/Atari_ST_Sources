* resource set indicies for PRG_500

TEST500    EQU   0	/* menu tree */
ABOUT      EQU   7	/* STRING in tree TEST500 */
CERCLE     EQU   16	/* STRING in tree TEST500 */
RECTANGL   EQU   17	/* STRING in tree TEST500 */
CLEARSCR   EQU   18	/* STRING in tree TEST500 */
QUITTER    EQU   20	/* STRING in tree TEST500 */
