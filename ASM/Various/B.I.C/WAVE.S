*************************************
*   CRACKED BY B.I.C & THE BANDIT   *
*              22/4/90              *
*        AT 1:50 AM ,SUNDAY         *
*************************************

	MOVE.L	#COLPAL,-(A7)		;SET COLOUR PALETTE FOR PIC
	MOVE.W	#6,-(A7)
	TRAP	#14
	ADDQ.L	#6,A7

	MOVE.W	#4,-(A7)		;GET SCREEN RES.
	TRAP	#14
	ADDQ.L	#2,A7
	MOVE.W	D0,SAVERES

	MOVE.W	#2,-(A7)		;GET SCREEN PHYS BASE
	TRAP	#14
	ADDQ.L	#2,A7
	MOVE.L	D0,SAVEBASE

	CLR.W	-(A7)			;SET SCREEN PARAMS
	MOVE.L	SAVEBASE,-(A7)
	MOVE.L	SAVEBASE,-(A7)
	MOVE.W	#5,-(A7)
	TRAP	#14
	ADDA.L	#$C,A7

	PEA	MOUSEOFF		;WRITE STRING TO INT KBRD
	MOVE.W	#0,-(A7)
	MOVE.W	#$19,-(A7)
	TRAP	#14
	ADDQ.L	#8,A7

	CLR.L	-(A7)			;SUPER MODE
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.L	D0,SAVESTK

	MOVEA.L	SAVEBASE,A0		;CLEAR SCREEN
	MOVE.L	#$1FFF,D0
LOOP01	CLR.L	(A0)+
	DBF	D0,LOOP01


	ANDI.B	#$FC,$484		;TURN BELL & KEY REPT OFF
	
	BSR	SET_INT

WAITFORKEY	MOVE.W	#$FF,-(A7)
	MOVE.W	#6,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	TST.W	D0
	BNE	QUIT
	BRA.S	WAITFORKEY
	
QUIT	BSR	INT_OFF

	MOVE.L	#MOUSEON,-(A7)		;WRITE STRING TO INT KBRD
	MOVE.W	#0,-(A7)
	MOVE.W	#$19,-(A7)
	TRAP	#14
	ADDQ.L	#8,A7

	MOVE.W	SAVERES,-(A7)		;SET SCREEN PARAMS BACK
	MOVE.L	SAVEBASE,-(A7)
	MOVE.L	SAVEBASE,-(A7)
	MOVE.W	#5,-(A7)
	TRAP	#14
	ADDA.L	#$C,A7

	ORI.B	#3,$484			;TURN BELL & KEY REPT ON

	MOVE.L	SAVESTK,-(A7)		;BACK TO USER MODE
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDA.L	#6,A7

	CLR.W	-(A7)			;QUIT
	TRAP	#1

MOUSEOFF	DC.B	$12,0
MOUSEON		DC.B	8,0
SAVEBASE	DS.L	1
SAVESTK	DS.L	1
SET_INT	MOVEA.L	#SAVEINTREG,A1
	MOVE.B	$FFFA07,(A1)+
	MOVE.B	$FFFA09,(A1)+
	MOVE.B	$FFFA0B,(A1)+
	MOVE.B	$FFFA0D,(A1)+
	MOVE.B	$FFFA0F,(A1)+
	MOVE.B	$FFFA11,(A1)+
	MOVE.B	$FFFA13,(A1)+
	MOVE.B	$FFFA15,(A1)+
	MOVE.B	$FFFA1B,(A1)+
	MOVE.B	$FFFA21,(A1)+
	MOVE.L	$70,(A1)+
	MOVE.L	$120,(A1)+
	MOVE.L	$118,(A1)+
	MOVE.L	$70,SAVEVBL
	MOVE.L	$118,SAVEKINT
	MOVE.W	$FF8240,(A1)+
	ANDI.B	#$DF,$FFFA09
	ANDI.B	#$FE,$FFFA07
	MOVE.L	#HBL,$120
	MOVE.L	#KINT,$118
	MOVE.L	#VBL,$70
	ORI.B	#1,$FFFA07
	ORI.B	#1,$FFFA13
	RTS
INT_OFF	MOVE	SR,-(A7)
	MOVE.W	#$2700,SR
	MOVEA.L	#SAVEINTREG,A1
	MOVE.B	(A1)+,$FFFA07
	MOVE.B	(A1)+,$FFFA09
	MOVE.B	(A1)+,$FFFA0B
	MOVE.B	(A1)+,$FFFA0D
	MOVE.B	(A1)+,$FFFA0F
	MOVE.B	(A1)+,$FFFA11
	MOVE.B	(A1)+,$FFFA13
	MOVE.B	(A1)+,$FFFA15
	MOVE.B	(A1)+,$FFFA1B
	MOVE.B	(A1)+,$FFFA21
	MOVE.L	(A1)+,$70
	MOVE.L	(A1)+,$120
	MOVE.L	(A1)+,$118
	MOVE.W	(A1)+,$FF8240
	MOVE.W	(A7)+,SR
	RTS
VBL	CLR.B	$FFFA1B
	MOVE.B	#1,$FFFA21
	MOVE.B	#8,$FFFA1B
	CLR.W	$FF8240
	MOVEM.L	D0-D3/A0-A2,-(A7)

	MOVEA.L	#RASTD3,A1
	MOVE.L	#$63,D0
LOOP10	CLR.L	(A1)+
	DBF	D0,LOOP10
	
	MOVEA.L	#RASTD6,A0		;SHOW BACK RASTER 1 (BLUE)
	MOVEA.L	#RASTD7,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC4,A0
	MOVE.W	(A0),D0
	ADDA.W	D0,A2
	MOVEQ	#$D,D0
LOOP12	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP12
	
	MOVEA.L	#RASTD6,A0		;SHOW BACK RASTER 2 (GREEN)
	MOVEA.L	#RASTD8,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC5,A0
	MOVE.W	(A0),D0
	ADDA.W	D0,A2
	MOVEQ	#$D,D0
LOOP13	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP13
	
	MOVEA.L	#RASTD6,A0		;SHOW BACK RASTER 3 (RED)
	MOVEA.L	#RASTD9,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC6,A0
	MOVE.W	(A0),D0
	ADDA.W	D0,A2
	MOVEQ	#$D,D0
LOOP14	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP14
	
	MOVEA.L	#RASTD6,A0		;SHOW BACK RASTER 4 (WHITE)
	MOVEA.L	#RASTDA,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC7,A0
	MOVE.W	(A0),D0
	ADDA.W	D0,A2
	MOVEQ	#$D,D0
LOOP15	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP15

	MOVEA.L	#RASTD6,A0		;FRONT RASTER 1 (WHITE)
	MOVEA.L	#RASTDA,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC7,A0
	MOVE.W	(A0),D0
	MOVE.W	#$17C,D2
	SUB.W	D0,D2
	ADDA.W	D2,A2
	MOVEQ	#$D,D0
LOOP16	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP16
	
	MOVEA.L	#RASTD6,A0		;FRONT RASTER 2 (RED)
	MOVEA.L	#RASTD9,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC6,A0
	MOVE.W	(A0),D0
	MOVE.W	#$17C,D2
	SUB.W	D0,D2
	ADDA.W	D2,A2
	MOVEQ	#$D,D0
LOOP17	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP17

	MOVEA.L	#RASTD6,A0		;FRONT RASTER 3 (GREEN)
	MOVEA.L	#RASTD8,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC5,A0
	MOVE.W	(A0),D0
	MOVE.W	#$17C,D2
	SUB.W	D0,D2
	ADDA.W	D2,A2
	MOVEQ	#$D,D0
LOOP18	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP18
	
	MOVEA.L	#RASTD6,A0		;FRON RASTER 4 (BLUE)
	MOVEA.L	#RASTD7,A1
	MOVEA.L	#RASTD3,A2
	ADDA.W	RASTC4,A0
	MOVE.W	(A0),D0
	MOVE.W	#$17C,D2
	SUB.W	D0,D2
	ADDA.W	D2,A2
	MOVEQ	#$D,D0
LOOP19	MOVE.W	(A1)+,(A2)+
	DBF	D0,LOOP19
	
	ADDQ.W	#2,RASTC4		;BLUE RASTER
	ADDQ.W	#2,RASTC5		;GREEN RASTER
	ADDQ.W	#2,RASTC6		;RED RASTER
	ADDQ.W	#2,RASTC7		;WHITE RASTER
	MOVEA.L	#RASTC4,A0
	MOVEQ	#3,D0
LOOP20	CMPI.W	#$16A,(A0)
	BNE	RASTERS2B
	CLR.W	(A0)
RASTERS2B	ADDQ.W	#2,A0
	DBF	D0,LOOP20
SYS_HBL	CLR.W	$FF8240
	MOVEM.L	(A7)+,D0-D3/A0-A2
	DC.W	$4EF9			;JMP 0
SAVEVBL	DS.L	1
KINT	MOVE.W	#$2500,SR
	DC.W	$4EF9			;JMP 0
SAVEKINT	DS.L	1
HBL	CLR.B	$FFFA1B
	MOVEM.L	D0-D3/A3-A4,-(A7)
	MOVEA.L	#$FFFA21,A4
	MOVE.B	#$F0,(A4)
	MOVE.B	#8,$FFFA1B
	MOVE.W	#$C6,D0
	MOVEA.L	#RASTD3,A3
LOOP23	MOVE.B	(A4),D1
HBLOOP	CMP.B	(A4),D1
	BEQ.S	HBLOOP
	MULU	D3,D3
	MOVE.W	(A3)+,$FF8240
	DBF	D0,LOOP23
	CLR.W	$FF8240
	MOVEM.L	(A7)+,D0-D3/A3-A4
	BCLR	#0,$FFFA0F
	RTE
SAVEINTREG	DS.L	6
RASTC4	DC.W	0
RASTC5	DC.W	$A
RASTC6	DC.W	$14
RASTC7	DC.W	$1E
RASTDA	DC.B	0,$11,1,$22,2,$33,3,$44
	DC.B	4,$55,5,$66,6,$77,6,$77
	DC.B	5,$66,4,$55,3,$44,2,$33
	DC.B	1,$22,0,$11
RASTD9	DC.B	1,0,2,0
	DC.B	3,0,4,0,5,0,6,0
	DC.B	7,0,7,0,6,0,5,0
	DC.B	4,0,3,0,2,0,1,0
RASTD8	DC.B	0,$10,0,$20,0,$30,0,$40
	DC.B	0,$50,0,$60,0,$70,0,$70
	DC.B	0,$60,0,$50,0,$40,0,$30
	DC.B	0,$20,0,$10
RASTD7	DC.B	0,1,0,2
	DC.B	0,3,0,4,0,5,0,6
	DC.B	0,7,0,7,0,6,0,5
	DC.B	0,4,0,3,0,2,0,1
RASTD3	DS.L	100
RASTD6	DC.B	0,$BE,0,$C4,0,$CA
	DC.B	0,$D0,0,$D6,0,$DC,0,$E2
	DC.B	0,$E8,0,$EC,0,$F2,0,$F8
	DC.B	0,$FE,1,4,1,8,1,$E
	DC.B	1,$14,1,$18,1,$1E,1,$22
	DC.B	1,$26,1,$2C,1,$30,1,$34
	DC.B	1,$38,1,$3C,1,$40,1,$44
	DC.B	1,$48,1,$4A,1,$4E,1,$52
	DC.B	1,$54,1,$56,1,$5A,1,$5C
	DC.B	1,$5E,1,$60,1,$62,1,$62
	DC.B	1,$64,1,$66,1,$66,1,$68
	DC.B	1,$68,1,$68,1,$68,1,$68
	DC.B	1,$68,1,$68,1,$66,1,$66
	DC.B	1,$64,1,$62,1,$62,1,$60
	DC.B	1,$5E,1,$5C,1,$5A,1,$56
	DC.B	1,$54,1,$52,1,$4E,1,$4A
	DC.B	1,$48,1,$44,1,$40,1,$3C
	DC.B	1,$38,1,$34,1,$30,1,$2C
	DC.B	1,$26,1,$22,1,$1E,1,$18
	DC.B	1,$14,1,$E,1,8,1,4
	DC.B	0,$FE,0,$F8,0,$F2,0,$EC
	DC.B	0,$E8,0,$E2,0,$DC,0,$D6
	DC.B	0,$D0,0,$CA,0,$C4,0,$BE
	DC.B	0,$B8,0,$B2,0,$AC,0,$A6
	DC.B	0,$A0,0,$9A,0,$94,0,$90
	DC.B	0,$8A,0,$84,0,$7E,0,$78
	DC.B	0,$74,0,$6E,0,$68,0,$64
	DC.B	0,$5E,0,$5A,0,$56,0,$50
	DC.B	0,$4C,0,$48,0,$44,0,$40
	DC.B	0,$3C,0,$38,0,$34,0,$32
	DC.B	0,$2E,0,$2A,0,$28,0,$26
	DC.B	0,$22,0,$20,0,$1E,0,$1C
	DC.B	0,$1A,0,$1A,0,$18,0,$16
	DC.B	0,$16,0,$14,0,$14,0,$14
	DC.B	0,$14,0,$14,0,$14,0,$14
	DC.B	0,$16,0,$16,0,$18,0,$1A
	DC.B	0,$1A,0,$1C,0,$1E,0,$20
	DC.B	0,$22,0,$26,0,$28,0,$2A
	DC.B	0,$2E,0,$32,0,$34,0,$38
	DC.B	0,$3C,0,$40,0,$44,0,$48
	DC.B	0,$4C,0,$50,0,$56,0,$5A
	DC.B	0,$5E,0,$64,0,$68,0,$6E
	DC.B	0,$74,0,$78,0,$7E,0,$84
	DC.B	0,$8A,0,$90,0,$94,0,$9A
	DC.B	0,$A0,0,$A6,0,$AC,0,$B2
	DC.B	0,$B8,0,$BE,0,0,0,0
	DC.B	0,0
SAVERES	DC.B	0,1
COLPAL	DC.W	$000,$464,$333,$363
	DC.W	$302,$503,$252,$402
	DC.W	$142,$020,$131,$725
	DC.W	$614,$770,$555,$777
