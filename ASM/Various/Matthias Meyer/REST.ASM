  MODULE MONST
  SECTION S.GLOB


* Disassembler, Fullscreen-Editor <<<
*   Matthias Meyer, Rosenwinkel 36,2380 Schleswig
*


DISASS:
 MOVEM.L D0-D7/A1-A6,-(SP)  * ab (a0) disassemblieren
 MOVE.L A0,D0
 BCLR #0,D0
 MOVE.L D0,A1
 JSR ZEILANF
 JSR RESTZLSH
 JSR CLRWBUF
 JSR PUNKT
 JSR KOMMA
 MOVE.L A1,D0
 JSR ADRHEX
 JSR TWOSPACE
 MOVE.W (A1)+,D1 * Befehlswort holen
 MOVEQ #1,D7     * Default Wortl„nge
 MOVE.W D1,D0
 JSR WORDHEX
 MOVEQ #36,D0
 JSR SPACETAB
 MOVE.W D1,D0
 AND.W #$F000,D0
 ROL.W #5,D0      * oberstes Nibble * 2
 LEA M,A0
 ADD.W DHINIBBS(PC,D0.W),A0
 JSR (A0)
 BRA.S DEXIT
DHINIBBS:
 DC.W DNIBB0-M,DMOVEB-M,DMOVEL-M,DMOVEW-M,DNIBB4-M,DNIBB5-M,DNIBB6-M,DNIBB7-M
 DC.W DNIBB8-M,DNIBB9-M,DILLEG-M,DNIBBB-M,DNIBBC-M,DNIBBD-M,DNIBBE-M,DILLEG-M

DEXIT:
 MOVEQ #15,D1
 MOVE.W CRSY,D2
 JSR RCRSET
 MOVE.W WBUFPTR,D1 * zum Opcode geh”rende Worte ausg.
 BEQ.S DRESTA0
 MOVEQ #2,D2
DWBUFPRT:
 MOVE.W WBUFPTR(PC,D2.W),D0
 JSR WORDHEX
 JSR ONESPACE
 ADDQ.W #2,D2
 SUBQ.W #2,D1
 BNE.S DWBUFPRT
DRESTA0:
 MOVE.L A1,A0    * Zeiger auf n„chsten Befehl
 MOVEM.L (SP)+,D0-D7/A1-A6
 RTS

CLRWBUF:
 LEA WBUFPTR,A0
 CLR.W (A0)
 RTS
WBUFPTR: DC.W 0   * Anzahl Worte im Buffer MAL 2
 DS.W 4

WINBUF:
 LEA WBUFPTR,A0   * Wort in d0 in Zwischenspeicher
 ADDQ.W #2,(A0)
 ADD.W (A0),A0
 MOVE.W D0,(A0) *
 RTS


* Opcodes nach oberstem Nibble sortiert

DNIBB0:
 MOVE.W D1,D2   * ADDI.X # ,...
 BTST #8,D1
 BNE DVBITTER
 AND.W #$0E00,D2
 ROL.W #7,D2
 MOVE.B DIMMAR(PC,D2.W),D0
 BMI DILLEG
 BEQ.S DIMMBIT
 MOVE.W D1,D2
 AND.W #$00C0,D2
 LSR.W #6,D2
 CMP.B #3,D2
 BEQ DILLEG
 JSR DMNEOUT
 JSR DOPLNG
 JSR DIMMED
 JSR KOMMA
 MOVE.W D1,D2
 AND.W #$3F,D2
 CMP.B #$3C,D2  * Sonderfall: statt #  "sr"
 BEQ.S DIARSR
 JMP DEFFADR
DIARSR:
 MOVEQ #'s',D0 * "SR" ausg.
 JSR PRINT
 MOVEQ #'r',D0
 JMP PRINT
DIMMAR: DC.B 33,5,43,2,0,17,13,-1
DIMMBIT:
 BSR.S DBITMN   * Einzelbitbefehle
 JSR DOPPELKR
 JSR DFOLGWO
 AND.W #31,D0 * hier egal ob Dn !
 EXT.L D0
 JSR DEZOUT
DBITEA:
 JSR KOMMA
 JMP DEFFALG

DVBITTER:
 MOVE.W D1,D2
 AND.B #%00111000,D2  * MODUS "An" ?
 CMP.B #%00001000,D2
 BEQ.S DMOVEP
 BSR.S DBITMN
 JSR DATAROB
 BRA.S DBITEA

DBITMN:
 MOVE.W D1,D2
 AND.W #$00C0,D2
 LSR.W #6,D2
 MOVE.B DBITOPS(PC,D2.W),D0
 JMP DMNEMITSP
DBITOPS: DC.B 10,7,8,9

DMOVEP:
 MOVEQ #25,D0  * MOVEP.X ...
 JSR DMNEOUT
 MOVEQ #'p',D0
 JSR PRINT
 JSR DBIT6LNG
 MOVE.W D1,D2
 TST.B D1
 BMI.S DMOPRM
 JSR DMOD5
 JSR KOMMA
 BRA.S DATAROB
DMOPRM:
 BSR.S DATAROB
 JSR KOMMA
 JMP DMOD5

DADROB:
 MOVEQ #'a',D0  * An in Bit 9-11 ausg.
 DC.W $6002 * BRA+2
DATAROB:
 MOVEQ #'d',D0  * Dn ,,
 JSR PRINT
 MOVE.W D1,D0
 AND.W #$0E00,D0
 ROL.W #7,D0
 ADD.B #'0',D0
 JMP PRINT

*

DMOVEB:
 MOVEQ #0,D2       * einfache MOVE's
 BRA.S DMOVEWAT
DMOVEL:
 MOVEQ #2,D2
 BRA.S DMOVEWAT
DMOVEW:
 MOVEQ #1,D2
DMOVEWAT:
 MOVE.L D2,D7 * falls #
 MOVEQ #25,D0
 JSR DMNEOUT
 JSR DOPLNG
 JSR DEFFALG
 JSR KOMMA
 MOVE.W D1,D2     * Zieladresse
 AND.W #$0E00,D2
 ROL.W #7,D2
 MOVE.W D1,D3
 AND.W #$01C0,D3
 LSR.W #3,D3
 OR.W D3,D2
 JMP DEFFADR

*

* Opcodes $4xxx am zahlreichsten ! <<<

DNIBB4:
 MOVE.W D1,D2
 BTST #8,D1
 BEQ D4RAUSW

 MOVE.W D1,D2
 AND.B #$C0,D2
 CMP.B #$C0,D2
 BEQ.S DLEA
 CMP.B #$80,D2
 BNE DILLEG
 MOVEQ #11,D0 * CHK.W
 JSR DMNEOUT
 MOVEQ #1,D2
 JSR DOPLNG
 JSR DEFFALG
 JSR KOMMA
 JMP DATAROB

DLEA:
 MOVEQ #22,D0 * LEA "ea",An
 JSR DMNEMITSP
 JSR DEFFALG
 JSR KOMMA
 JMP DADROB


D4RAUSW:
 MOVE.W D1,D2     * zahlreich!
 AND.W #$0E00,D2
 LSR.W #8,D2
 LEA M,A0
 ADD.W D4GRPS(PC,D2.W),A0
 JMP (A0)
D4GRPS:
 DC.W DG40-M,DG42-M,DG44-M,DG46-M,DG48-M,DG4A-M,DG4C-M,DG4E-M


DG40:
 MOVEQ #30,D0 * NEGX
 BRA.S DNMOV
DG44:
 MOVEQ #29,D0 * NEG
 BRA.S DNMOV
DG46:
 MOVEQ #32,D0 * NOT
DNMOV:
 MOVE.W D0,D3
 MOVE.W D1,D2
 AND.B #$C0,D2
 CMP.B #$C0,D2
 BNE DMULTSIMP
 MOVEQ #25,D0 * MOVE  ?
 JSR DMNEMITSP
 CMP.W #30,D3
 BEQ.S DMVFSR
 JSR DEFFALG * MOVE "EA",SR/CCR
 JSR KOMMA      * MOVE from CCR im 68000 noch nicht implementiert!
 CMP.W #29,D3
 BEQ DCCRO
 JMP DIARSR
DMVFSR:
 JSR DIARSR * MOVE SR,"EA"
 JSR KOMMA
 JMP DEFFALG

DG42:
 MOVEQ #12,D0 * CLR
 JMP DMULTSIMP

DG48:
 MOVE.W D1,D2
 TST.B D1
 BMI.S DVEXT  * Bit 7 =1
 BTST #6,D1
 BEQ.S DNBCD * Bit 6 =0
 AND.W #$38,D2
 BEQ.S DSWAP
 MOVEQ #34,D0 * PEA
DEASY:
 JSR DMNEMITSP
 JMP DEFFALG
DSWAP:
 MOVEQ #46,D0 * SWAP Dx
 BRA.S DEASY
DNBCD:
 MOVEQ #28,D0 * NBCD
 BRA.S DEASY
DVEXT:
 AND.W #$38,D2
 BNE.S DMOVEM
 MOVEQ #19,D0 * EXT.X
 JSR DMNEOUT
 JSR DBIT6LNG
 MOVE.W D1,D2
 JMP DMOD0

DMOVEM:
DG4C:
 TST.B D1
 BPL DILLEG
 MOVEQ #25,D0  * MOVEM.X -Befehle
 JSR DMNEOUT
 MOVEQ #'m',D0
 JSR PRINT
 JSR DBIT6LNG
 JSR DFOLGWO
 MOVE.W D0,D3 * Registerliste
 BTST #10,D1
 BNE.S DMMEA
DMMRL:
 MOVE.W D1,D2
 AND.W #$38,D2 * -(An) ?
 CMP.W #$20,D2
 BNE.S DMMNR
 MOVEQ #15,D0
DMMRLSWP:
 LSR.W #1,D3   * Registerliste umdrehen
 ROXL.W #1,D2
 DBF D0,DMMRLSWP
 MOVE.W D2,D3
DMMNR:
 CLR.W D2
 MOVEQ #'d',D0 * Registerliste ausg.
DMMRLO:
 JSR PRINT
 MOVEQ #7,D4
DMMRLP:
 LSR.W #1,D3
 BCC.S DMMXLP
 MOVEQ #7,D0
 SUB.B D4,D0
 ADD.B #'0',D0
 JSR PRINT
DMMXLP:
 DBF D4,DMMRLP
 TST.W D2
 BNE.S DMMFR
 MOVEQ #1,D2
 MOVEQ #'/',D0
 JSR PRINT
 MOVEQ #'a',D0
 BRA.S DMMRLO
DMMFR:
 BTST #10,D1
 BNE.S DMMXT
 JSR KOMMA
DMMEA:
 JSR DEFFALG
 BTST #10,D1
 BEQ.S DMMXT
 JSR KOMMA
 BRA.S DMMRL
DMMXT:
 RTS

DG4A:
 CMP.W #$4AFC,D1
 BEQ DILLEG
 MOVEQ #50,D0 * TST
 MOVE.W D1,D2
 AND.B #$C0,D2
 CMP.B #$C0,D2
 BNE DMULTSIMP
 MOVEQ #47,D0 * TAS
 JSR DMNEMITSP
 JMP DEFFALG

DG4E:
 TST.B D1
 BPL.S D4KL8
 MOVEQ #20,D0  * JMP EA
 BTST #6,D1
 BNE.S DJXY
 MOVEQ #21,D0  * JSR EA
DJXY:
 JSR DMNEMITSP
 JMP DEFFALG

D4KL8:
 MOVE.W D1,D2
 AND.W #$F0,D2
 CMP.B #$40,D2
 BEQ.S DTRAP
 CMP.B #$50,D2
 BEQ.S DLINKER
 CMP.B #$60,D2
 BEQ DMVUSP
 CMP.B #$70,D2
 BEQ.S DOP47
 JMP DILLEG 

DTRAP:
 MOVEQ #48,D0  * TRAP
 JSR DMNEOUT
 JSR ONESPACE
 JSR DOPPELKR
 MOVE.W D1,D0
 AND.W #$0F,D0
 EXT.L D0
 JMP DEZOUT
DLINKER:
 MOVE.W D1,D2
 BTST #3,D1
 BNE.S DUNLK
 MOVEQ #23,D0  * LINK
 JSR DMNEMITSP
 JSR DMOD1
 JSR KOMMA
 JSR DOPPELKR
 JSR DFOLGWO
 TST.W D0
 BPL.S DLNKPOS
 JSR MINUS 
 NEG.W D0
DLNKPOS:
 JMP WORDHEX

DUNLK:
 MOVEQ #51,D0 * UNLK
 JSR DMNEMITSP
 JMP DMOD1

DMVUSP:
 MOVEQ #25,D0 * MOVE USP
 JSR DMNEMITSP
 MOVE.W D1,D2
 BTST #3,D1
 BNE.S DGETUSP
 JSR DMOD1
 JSR KOMMA
 JMP DUSPO
DGETUSP:
 JSR DUSPO
 JSR KOMMA
 JMP DMOD1

DOP47:
 BTST #3,D1
 BNE DILLEG
 MOVE.W D1,D2
 AND.W #$07,D2
 MOVE.B DOP4E7TB(PC,D2.W),D0
 BMI DILLEG
 JSR DMNEOUT
 CMP.B #42,D0
 BEQ.S DSTOP
 RTS
DOP4E7TB: DC.B 35,31,42,38,-1,40,49,39

* RESET,NOP,STOP,RTE,ILLEG,RTS,TRAPV,RTR

DSTOP:
 JSR ONESPACE
 JSR DOPPELKR * STOP #1234
 JSR DFOLGWO
 JMP WORDHEX


DMULTSIMP:
 MOVE.W D1,D2  * Mnem. Nr. in D0
 AND.W #$C0,D2
 LSR.W #6,D2
 CMP.B #3,D2
 BEQ DILLEG
 JSR DMNEOUT
 JSR DOPLNG
 JMP DEFFALG

DCCRO:
 LEA DCCRTX,A0
 JMP STROUT
DUSPO:
 LEA DUSPTX,A0
 JMP STROUT
DCCRTX: DC.B 'ccr',0
DUSPTX: DC.B 'usp',0

*

DNIBB5:
 MOVE.W D1,D2
 AND.W #$C0,D2
 CMP.W #$C0,D2
 BEQ.S DVSCC
 MOVEQ #3,D0 * ADDQ
 BTST #8,D1
 BEQ.S DXXXQ
 MOVEQ #44,D0 * SUBQ
DXXXQ:
 JSR DMNEOUT
 LSR.W #6,D2
 JSR DOPLNG
 JSR DQ3BIT
 JMP DEFFALG

DVSCC:
 MOVE.W D1,D2
 AND.B #$38,D2
 CMP.B #$08,D2
 BEQ.S DDBCC
 MOVE.W D1,D2
 AND.W #$0F00,D2
 CMP.W #$0100,D2 * CC = FALSE?
 BEQ DILLEG
 MOVEQ #'s',D0  * SCC EA
 JSR PRINT
 JSR DCCOUT
 MOVEQ #44,D0
 JSR SPACETAB
 JMP DEFFALG

DDBCC:
 MOVE.W D1,D2
 AND.W #$0F00,D2
 BEQ DILLEG
 CMP.W #$0100,D2
 BNE.S DNDBRA
 AND.W #$0F,D1
DNDBRA:
 MOVEQ #'d',D0  * DBcc-Befehle
 JSR PRINT
 MOVEQ #'b',D0
 JSR PRINT
 JSR DCCOUT
 JSR ONESPACE
 MOVE.W D1,D2
 JSR DMOD0
 JSR KOMMA
 JSR DFOLGWO
 EXT.L D0
 ADD.L A1,D0
 SUBQ.L #2,D0
 JMP ADRHEX

DQ3BIT:
 JSR DOPPELKR  * #7,
 MOVE.W D1,D0   * 3-Bit-Wert in 9-11 ausg.
 AND.W #$0E00,D0
 ROL.W #7,D0
 ADD.B #'0',D0
 CMP.B #'0',D0
 BNE.S DNULLKS
 MOVEQ #'8',D0
DNULLKS:
 JSR PRINT
 JMP KOMMA

*

DNIBB6:
 MOVEQ #'b',D0  * BRANCH-Befehle
 JSR PRINT
 JSR DCCOUT
 MOVE.W D1,D2
 AND.W #$FF,D2
 BNE.S DSHORTBR
 JSR DFOLGWO  * Offset bei langem Sprung ab Versatzwort!
 MOVE.W D0,D2
 BRA.S DBRPC
DSHORTBR:
 EXT.W D2
DBRPC:
 MOVEQ #44,D0
 JSR SPACETAB
 MOVE.L A1,D0
 EXT.L D2
 ADD.L D2,D0
 AND.W #$FF,D1
 BNE.S DSHRTNA
 SUBQ.L #2,D0
DSHRTNA:
 JMP ADRHEX


DCCOUT:
 MOVE.W D1,D2
 AND.W #$0F00,D2 * CC
 LSR.W #7,D2
 MOVE.B DCCTAB(PC,D2.W),D0 * Bedingungscodes
 JSR PRINT
 MOVE.B DCCTAB+1(PC,D2.W),D0
 JMP PRINT
DCCTAB: DC.B 'rasrhilscccsneeqvcvsplmigeltgtle'

*

DNIBB7:
 BTST #8,D1
 BNE DILLEG
 MOVEQ #25,D0 * MOVEQ #XY,Dn
 JSR DMNEOUT
 MOVEQ #'q',D0
 JSR PRINT
 MOVEQ #2,D2 * .L
 JSR DOPLNG
 JSR DOPPELKR
 MOVE.B D1,D0
 JSR BYTEHEX
 JSR KOMMA
 JMP DATAROB

*

DNIBB8:
 LEA DOP8TB,A3

DNBGM8C:
 MOVE.W D1,D2  * Op's $8 u. $c analog ! (bis auf exg)
 AND.W #$C0,D2
 CMP.W #$C0,D2
 BEQ.S DDIVIS
 MOVE.W D1,D2
 AND.W #$01F0,D2
 CMP.W #$0100,D2
 BEQ.S DXBCD
 MOVE.B (A3),D0 * OR(AND).X EA <=> Dn
DADDSUB:
 JSR DMNEOUT
 JSR DOPLG76
 BTST #8,D1
 BNE.S DOBOOLD
 JSR DEFFALG
 JSR KOMMA
 JMP DATAROB
DOBOOLD:
 JSR DATAROB
 JSR KOMMA
 JMP DEFFALG

DDIVIS:
 MOVE.B 1(A3),D0  * DIVS/MULS EA,DX
DMULIS:
 BTST #8,D1
 BNE.S DDIVW
 ADDQ.W #1,D0  * DIVU/MULU
DDIVW:
 JSR DMNEMITSP
 JSR DEFFALG
 JSR KOMMA
 JMP DATAROB

DXBCD:
 MOVE.B 2(A3),D0  * SBCD/ABCD
 JSR DMNEMITSP
DADDELSE:
 MOVE.W D1,D2
 BTST #3,D1
 BNE.S DDCADR
 JSR DMOD0  * Dx,Dy
 JSR KOMMA
 JMP DATAROB
DDCADR:
 JSR DMOD4  * -(Ax),-(Ay)
 JSR KOMMA
 ROL.W #7,D2
 JMP DMOD4


DNIBBC:
 LEA DOPCTB,A3
 BTST #8,D1
 BEQ DNBGM8C
 MOVE.W D1,D3
 MOVE.W D1,D2
 MOVEQ #18,D0   * EXG Rx,Ry
 AND.W #$F8,D3
 CMP.B #$40,D3
 BEQ.S DEXGDD
 CMP.B #$48,D3
 BEQ.S DEXGAA
 CMP.B #$88,D3
 BNE DNBGM8C
 JSR DMNEMITSP
 JSR DATAROB  * D,A
 JSR KOMMA
 JMP DMOD1
DEXGDD:
 JSR DMNEMITSP * D,D
 JSR DATAROB
 JSR KOMMA
 JMP DMOD0
DEXGAA:
 JSR DMNEMITSP * A,A
 JSR DADROB
 JSR KOMMA
 JMP DMOD1

DOP8TB:
 DC.B 33,15,41 * OR,DIV.,SBCD
DOPCTB:
 DC.B 5,26,1   * AND,MUL.,ABCD

*

DNIBB9:
 MOVEQ #43,D0 * SUB
 DC.W $6002

DNIBBD:
 MOVEQ #2,D0  * ADD
 MOVE.W D1,D2
 AND.W #$C0,D2
 CMP.B #$C0,D2
 BNE.S DAREVX
DALCMPA:
 MOVEQ #1,D2 * W    * Ziel An
 BTST #8,D1
 BEQ.S DXALO
 MOVEQ #2,D2 * L
DXALO:
 JSR DMNEOUT * ADDA,SUBA (CMPA)
 JSR DOPLNG
 JSR DEFFALG
 JSR KOMMA
 JMP DADROB
DAREVX:
 BTST #8,D1
 BEQ DADDSUB
 MOVE.W D1,D3
 AND.B #$30,D3
 BNE DADDSUB
 JSR DMNEOUT
 MOVEQ #'x',D0  * ADD/SUB mit Extensionflag
 JSR PRINT
 JSR DOPLG76
 JMP DADDELSE * Register wie bei ABCD/SBCD

DNIBBB:
 MOVEQ #13,D0 * CMP
 MOVE.W D1,D2
 AND.W #$C0,D2
 CMP.W #$C0,D2
 BEQ.S DALCMPA
 BTST #8,D1
 BEQ DADDSUB  * norm. CMP

 MOVE.W D1,D2
 AND.W #$38,D2 * Modusfeld = 001?
 CMP.W #$08,D2
 BEQ.S DCMPM
 MOVEQ #17,D0 * EOR.X Dn,EA
 JSR DMNEOUT
 JSR DOPLG76
 JSR DATAROB
 JSR KOMMA
 JMP DEFFALG
DCMPM:
 JSR DMNEOUT * CMPM.X (Ax)+,(Ay)+
 MOVEQ #'m',D0
 JSR PRINT
 JSR DOPLG76
 MOVE.W D1,D2
 JSR DMOD3
 JSR KOMMA
 MOVE.W D1,D2
 ROL.W #7,D2
 JMP DMOD3 

*

DNIBBE:
 MOVE.W D1,D2     * Schiebe-,Rotationsbefehle
 AND.W #$C0,D2
 CMP.W #$C0,D2
 BEQ.S DMEMSH * Wortoper. auf dem RAM
 MOVE.W D1,D2
 LSR.W #3,D2
 JSR DMEMSHNR
 JSR DOPLG76
 BTST #5,D1
 BEQ.S DSHDIR * Direktwert
 JSR DATAROB * Datenreg.
 JSR KOMMA
DSHDR:
 MOVE.W D1,D2
 JMP DMOD0
DSHDIR:
 JSR DQ3BIT
 BRA.S DSHDR

DMEMSH:
 MOVE.W D1,D2
 ROL.W #7,D2
 JSR DMEMSHNR
 MOVEQ #1,D2 * .W
 JSR DOPLNG
 JMP DEFFALG

DMEMSHNR:
 AND.W #3,D2
 MOVE.B DMSHTB(PC,D2.W),D0
 JSR DMNEOUT
 MOVEQ #'r',D0 * Verschiebungsrichtung
 BTST #8,D1
 BEQ.S DMSHR
 MOVEQ #'l',D0
DMSHR:
 JMP PRINT 
DMSHTB: DC.B 6,24,37,36
*  AS,LS,ROX,RO


*


DILLEG:
 LEA DILLTX,A0  * illegaler Opcode
 JMP STROUT
DILLTX: DC.B '???',0

*

DMNEOUT:
 MOVEM.L D0-D1/A0,-(SP) * Mnemonic Nr. (d0) ausg.
 MOVE.W D0,D1
 LEA DMNETAB,A0
 BRA.S DWMNE
DMNSUCH:
 MOVE.B (A0)+,D0
 CMP.B #'a',D0
 BCS.S DWMNE
 BRA.S DMNSUCH
DWMNE:
 SUBQ.W #1,D1
 BNE.S DMNSUCH
DMNEFND:
 MOVE.B (A0)+,D0
 CMP.B #'a',D0
 BCS.S DMNLL
 JSR PRINT
 BRA.S DMNEFND
DMNLL:
 ADD.B #$20,D0
 JSR PRINT
 MOVEM.L (SP)+,D0-D1/A0
 RTS

DMNETAB:
 DC.B 'abcDadDaddQaddXanDaSbchGbclRbseTbtsTchKclRcmPcmpMdivS'
 DC.B 'divUeoRexGexTjmPjsRleAlinKlSmovEmulSmulUnbcDneGnegXnoP'
 DC.B 'noToRpeAreseTrOroXrtErtRrtSsbcDstoPsuBsubQsubXswaP'
 DC.B 'taStraPtrapVtsTunlK'
 DC.W 0

DMNEMITSP:
 JSR DMNEOUT  * Mnem. und Spaces
 MOVE.W D0,-(SP)
 MOVEQ #44,D0
 JSR SPACETAB
 MOVE.W (SP)+,D0
 RTS

DEFFALG:
 MOVE.W D1,D2
 AND.W #$003F,D2

DEFFADR:
 MOVEM.L D1-D7,-(SP) * effektive Adresse in d2 ausg.
 MOVE.W D2,D1
 AND.W #$0038,D1 * Modusfeld
 LSR.W #2,D1
 LEA M,A0
 ADD.W DADRMODI(PC,D1.W),A0
 JSR (A0)
 MOVEM.L (SP)+,D1-D7
 RTS
DADRMODI:
 DC.W DMOD0-M,DMOD1-M,DMOD2-M,DMOD3-M,DMOD4-M,DMOD5-M,DMOD6-M,DMOD7-M

DMOD0:
 MOVEQ #'d',D0  * dn
 DC.W $6002 * JMP +2
DMOD1:
 MOVEQ #'a',D0  * an
 JSR PRINT
 MOVE.W D2,D0
 AND.W #$0007,D0
 ADD.B #'0',D0 * Nummer des Reg. ausg.
 JMP PRINT
DMOD2:
 MOVEQ #'(',D0 * (an)
 JSR PRINT
 BSR.S DMOD1
DKLMZU:
 MOVEQ #')',D0
 JMP PRINT
DMOD3:
 BSR.S DMOD2  * (an)+
 MOVEQ #'+',D0
 JMP PRINT
DMOD4:
 JSR MINUS  * -(an)
 BRA.S DMOD2
DMOD5:
 JSR DFOLGWO * d16(an)
 TST.W D0
 BPL.S DDISPOS
 JSR MINUS * Offset negativ, s.u.
 NEG.W D0
DDISPOS:
 JSR WORDHEX
 BRA.S DMOD2
DMOD6:
 JSR DFOLGWO * d8(an,rn.x)
 MOVE.W D0,D3
 TST.B D0
 BPL.S DKDSPOS
 JSR MINUS
 NEG.B D0
DKDSPOS:
 JSR BYTEHEX
 MOVEQ #'(',D0
 JSR PRINT
 JSR DMOD1
DINDEXR:
 JSR KOMMA
 MOVEQ #'a',D0
 TST.W D3
 BMI.S DINDRO
 MOVEQ #'d',D0
DINDRO:
 JSR PRINT
 MOVE.W D3,D0
 AND.W #$7000,D0
 ROL.W #4,D0
 ADD.B #'0',D0
 JSR PRINT
 JSR PUNKT
 MOVEQ #'l',D0
 BTST #11,D3
 BNE.S DINDLNG
 MOVEQ #'w',D0
DINDLNG:
 JSR PRINT
 JMP DKLMZU

DMOD7:
 AND.W #$0007,D2 * Registerfeld
 LSL.W #1,D2
 LEA M,A0
 ADD.W DM7RG(PC,D2.W),A0
 JMP (A0)
DM7RG: DC.W DABSKU-M,DABSLG-M,DPCIA-M,DPCIB-M,DIMMED-M,ILL-M,ILL-M,ILL-M

DABSKU:
 JSR DFOLGWO * abs. kurz
 EXT.L D0
 JMP ADRHEX
DABSLG:
 JSR DFOLGWO * abs. lang
 MOVE.W D0,D2
 JSR DFOLGWO
 SWAP D2
 MOVE.W D0,D2
 MOVE.L D2,D0
 JMP ADRHEX

DPCIA:
 JSR DFOLGWO * d16(pc)
 MOVE.L A1,A0
 ADD.W D0,A0
 MOVE.L A0,D0
 SUBQ.L #2,D0
 JSR ADRHEX
 LEA DPCTX,A0
 JSR STROUT
 JMP DKLMZU
DPCTX: DC.B '(pc',0

DPCIB:
 JSR DFOLGWO * d8(pc,rn.x)
 MOVE.W D0,D3
 MOVE.L A1,A0
 EXT.W D0
 ADD.W D0,A0
 MOVE.L A0,D0
 SUBQ.L #2,D0
 JSR ADRHEX
 LEA DPCTX,A0
 JSR STROUT
 JMP DINDEXR

DIMMED:
 JSR DOPPELKR  * #DATA
 JSR DFOLGWO
 TST.B D7      *!
 BEQ BYTEHEX
 SUBQ.B #1,D7
 BEQ WORDHEX
 MOVE.W D0,D2
 JSR DFOLGWO
 SWAP D2
 MOVE.W D0,D2
 MOVE.L D2,D0
 JMP LONGHEX

DFOLGWO:
 MOVE.W (A1)+,D0 * Auf Opcode folgendes Wort holen
 JMP WINBUF

*

DOPLG76:
 MOVE.W D1,D2
 LSR.W #6,D2
 AND.W #3,D2
 BRA.S DOPLNG

DBIT6LNG:
 MOVE.W D1,D2   * Bit 6: 0-word, 1-long
 AND.W #$40,D2
 LSR.W #6,D2
 ADDQ.W #1,D2

DOPLNG:
 JSR PUNKT     * Operandenl„nge in d2 ausg.
* 0 -Byte, 1 -Word, 2 -Long
 MOVE.W D2,D7
 TST.B D2
 BEQ.S DOPLBY
 CMP.B #1,D2
 BEQ.S DOPLWO
 MOVEQ #'l',D0
DOPLXT:
 JSR PRINT
 MOVEQ #44,D0
 JMP SPACETAB
DOPLBY:
 MOVEQ #'b',D0
 BRA.S DOPLXT
DOPLWO:
 MOVEQ #'w',D0
 BRA.S DOPLXT

* Disassembler ENDE



* Spezielle h„ufige Zeichen ausg.

PUNKT:
 MOVE.W #'.',-(SP)
 BRA.S ZWPRINT

KOMMA:
 MOVE.W #',',-(SP)
 BRA.S ZWPRINT

DOPPELKR:
 MOVE.W #'#',-(SP)
 BRA.S ZWPRINT

MINUS:
 MOVE.W #'-',-(SP)
 BRA.S ZWPRINT

CARRET:
 MOVE.W #CR,-(SP)

ZWPRINT:
 MOVE.W D0,-(SP)
 MOVE.W 2(SP),D0
 JSR PRINT
 MOVE.W (SP)+,D0
 ADDQ.L #2,SP
 RTS

FOURSPACE:
 MOVEQ #32,D0
 BSR.S ZPRINT
THREESPACE:
 MOVEQ #32,D0
 BSR.S ZPRINT
TWOSPACE:
 MOVEQ #32,D0
 BSR.S ZPRINT
ONESPACE:
 MOVEQ #32,D0
ZPRINT:
 JMP PRINT


*

EXIT:
 JSR NACHFRAG     * Programm verlassen
 BEQ.S MONEXOK
 RTS
MONEXOK:
 LEA FRSTFLAG,A0
 MOVE.W (A0),D0
 BEQ.S KEEPMON
 CLR.W -(SP)
 TRAP #1    * TERM

KEEPMON:
 MOVE.W #1,(A0)   * Flag f�r Speicher schon reserviert
 LEA START,A0
 LEA VRAM+2340,A1 * 2000 Bytes f�r Text + 80 Eingpuf. + BASE PAGE
 SUB.L A0,A1
 CLR.W -(SP)
 PEA (A1)
 MOVE.W #$31,-(SP) * KEEP PROCESS, Speicher reservieren
 TRAP #1



* Unterprogramme

* Hex-Ausgabe eines Longs,
* Words oder Bytes oder einer Adresse in D0

LONGHEX:
 MOVEM.L D0-D2,-(SP)
 MOVEQ #7,D1  * 8 Nibbles
OTHRS:
 MOVE.L D0,D2
HNIBBS:
 ROL.L #4,D2
 MOVE.L D2,D0
 AND.W #$0F,D0
 CMP.B #$0A,D0
 BCS.S HEXZIFF    * D0 < $0A
 ADD.B #'a'-$0A,D0
 BRA.S HEXB
HEXZIFF:
 ADD.B #'0',D0
HEXB:
 JSR PRINT
 DBF D1,HNIBBS
 MOVEM.L (SP)+,D0-D2
 RTS

ADRHEX:
 MOVEM.L D0-D2,-(SP)
 MOVEQ #5,D1    * 6 Nibbles
 LSL.L #8,D0
 BRA.S OTHRS
WORDHEX:
 MOVEM.L D0-D2,-(SP)
 MOVEQ #3,D1    * 4 Nibbles
 SWAP D0
 BRA.S OTHRS
BYTEHEX:
 MOVEM.L D0-D2,-(SP)
 MOVEQ #1,D1    * 2 Nibbles
 SWAP D0
 LSL.L #8,D0
 BRA.S OTHRS


BYTEBIN:
 MOVEM.L D0-D3,-(SP) * Byte in D0 bin„r ausg.
 MOVE.B D0,D2
 MOVEQ #7,D1 * 8 Bits
 MOVEQ #'0',D3
BINLP:
 CLR.L D0
 LSL.B #1,D2
 ADDX.B D3,D0 * X zu d0 add.
 JSR PRINT
 DBF D1,BINLP
 MOVEM.L (SP)+,D0-D3
 RTS


READLONG:
 MOVEQ #7,D0  * 8 Nibbles
 BRA.S RHEX     * Hexwert vom Bildsch. nach d0 lesen
READADR:
 MOVEQ #5,D0
 BRA.S RHEX
READWORD:
 MOVEQ #3,D0
 BRA.S RHEX
READBYTE:
 MOVEQ #1,D0
RHEX:
 MOVEM.L D1-D2,-(SP)
 MOVE.L D0,D2
 CLR.L D1
RHLP:
 JSR MUSTREAD
 JSR KLEINERBU
 CMP.B #'0',D0
 BCS ERRO
 CMP.B #'9'+1,D0
 BCS.S RHZF
 CMP.B #'a',D0
 BCS ERRO
 CMP.B #'g',D0
 BCS.S RHBUCHST
 JMP ERRO
RHZF:
 SUB.B #'0',D0
 BRA.S RHLEX
RHBUCHST:
 SUB.B #'a'-10,D0
RHLEX:
 LSL.L #4,D1
 OR.B D0,D1
 DBF D2,RHLP
 MOVE.L D1,D0
 MOVEM.L (SP)+,D1-D2
 RTS

READBINBYT:
 MOVEM.L D1-D2,-(SP) * 8 Bits vom Bildschirm lesen nach d0
 MOVEQ #7,D1
 CLR.L D2
RBLP:
 JSR MUSTREAD
 LSL.B #1,D2
 CMP.B #'0',D0
 BEQ.S RBIN
 CMP.B #'1',D0
 BNE ERRO
 BSET #0,D2
RBIN:
 DBF D1,RBLP
 MOVE.L D2,D0
 MOVEM.L (SP)+,D1-D2
 RTS


READDEZ:
 MOVEM.L D1-D3/A0,-(SP) * Dez.zahl vom Bi. nach d0 lesen
 CLR.L D1
GETDZ:
 JSR READCHAR
 BEQ.S DZXT
 CMP.B #32,D0
 BEQ.S GETDZ
 CMP.B #'0',D0
 BCS.S DZNE
 CMP.B #'9'+1,D0
 BCC.S DZNE
 MOVE.W D0,-(SP)
 ADD.B #1,D1
 BRA.S GETDZ
DZNE:
 JSR READBACK
DZXT:
 TST.B D1
 BEQ ERRO
 LEA ZEHNPOT,A0
 ADD.W #40,A0 * 10 LONGS
 SUBQ.B #1,D1
 CLR.L D0
DEZSTELL:
 MOVE.W (SP)+,D3
 MOVE.L -(A0),D2 * Zehnerpotenz holen
 SUB.B #'0',D3
 BEQ DMUXT
DEZMULT:
 ADD.L D2,D0
 SUBQ.B #1,D3
 BNE.S DEZMULT
DMUXT:
 DBF D1,DEZSTELL
 MOVEM.L (SP)+,D1-D3/A0
 RTS


DEZOUT:
 MOVEM.L D0-D3/A0,-(SP) * dezimale Ausg. von d0
 MOVE.L D0,D1
 BNE.S NODNU
 MOVEQ #'0',D0
 JSR PRINT
 BRA.S DZOXT
NODNU:
 MOVEQ #10,D3
 LEA ZEHNPOT,A0
DEZHI:
 MOVE.L (A0)+,D2
 SUBQ.B #1,D3
 CMP.L D2,D1
 BCS.S DEZHI
DZLP:
 CLR.W D0
DZSUB:
 CMP.L D2,D1
 BCS.S DZOUT
 SUB.L D2,D1 * Zehnerpot. subtrahieren
 ADDQ.B #1,D0
 BRA.S DZSUB
DZOUT:
 ADD.B #'0',D0
 JSR PRINT
 MOVE.L (A0)+,D2
 DBF D3,DZLP
DZOXT:
 MOVEM.L (SP)+,D0-D3/A0
 RTS

ZEHNPOT:
 DC.L 1000000000,100000000,10000000,1000000,100000,10000,1000,100,10,1


NACHFRAG:
 MOVEM.L D0/A0,-(SP) * Sicherheitsabfrage
 LEA NACHFRTXT,A0
 JSR STROUT
 JSR CRSON
 JSR CONIN
 JSR CRSOFF
 JSR PRINT
 JSR KLEINERBU
 CMP.B #'y',D0
 MOVEM.L (SP)+,D0/A0
 RTS
NACHFRTXT: DC.B CR,' are you sure ?',0
 DC.W 0


*<<<<<<<
* Zeile in Eingabepuffer holen, Full-Screen-Editor

INPLINE:
 JSR CRSON * Cursor auf Blinken

 JSR CONIN * auf Tastendruck warten

 CMP.B #$20,D0   * Steuerzeichen?
 BCS.S CTRLZCH   * ja

 CMP.W #$7F,D0
 BEQ DELETE
 CMP.L #$0071002E,D0
 BEQ BACKSPACE
 CMP.L #$00470037,D0 * SHIFT-CLEAR
 BEQ BLOESCH

 SWAP D0
 MOVEQ #-1,D1
BL10LP:
 ADDQ.W #1,D1
 MOVE.B ZEHNBLC(PC,D1.W),D2 * Auf Scancodes aus Zehnerblock pr�fen
 BEQ.S NO10BL
 CMP.B D2,D0
 BNE.S BL10LP
 ADD.W #'a',D1
 MOVE.W D1,D0
 BRA.S ILZOK
NO10BL:
 SWAP D0
ILZOK:
 JSR PRINT   * normales Zeichen ausg.
 BRA.S INPLINE * weiter

ZEHNBLC:
 DC.B $63,$64,$65,$66,$4A,$4E,0,0

CTRLZCH:
 TST.W D0
 BEQ NULLTAST
 CMP.B #CR,D0
 BEQ EINGAB
 CMP.B #8,D0
 BEQ BACKSPACE
 CMP.B #4,D0 * ctrl-d
 BEQ FRESSZL
 CMP.L #$000F0009,D0 * TAB
 BEQ TABVER
 CMP.B #9,D0 * ctrl-i
 BEQ LEINF
 CMP.B #10,D0
 BEQ TLINEFEED
 CMP.B #1,D0
 BEQ CTRLA
* Erweiterungen
 BSR.S UNKEY
 JMP INPLINE * kein erkennbares Steuerzeichen

UNKEY:
 MOVE.W CRSX,D0 * nicht belegte Taste
 CMP.B #67,D0
 BCC ILL
 PEA NOKEY(PC)
 MOVE.W #9,-(SP) * print line
 TRAP #1
 ADDQ.L #6,SP
 MOVE.W #50000,D0
UKPAU:
 SUBQ.W #1,D0
 BNE.S UKPAU
 MOVE.W CRSY,D0
 JMP RESTLN
NOKEY:
 DC.B '{KEY IGNORED}',0

NULLTAST:
 SWAP D0 * ASCII-Code Null, also Scancode nach unten
 CMP.W #$48,D0 * Cursor up
 BNE.S N10
 MOVE.W CRSY,D0 * wenn Zeile =0, dann auf memory o. kontroll pr�fen
 BNE.S NRMSCRUP
 JSR EINGAB
 JSR READCHAR
 CMP.B #'.',D0
 BNE.S NRMSCRUP
 JSR READCHAR
 CMP.B #':',D0
 BNE.S VLTEXTSCR
 LEA MEMOUT,A3
 MOVEQ #16,D3
 BRA.S UPWORK
VLTEXTSCR:
 CMP.B #$27,D0
 BNE.S NRMSCRUP
 LEA KONTROUT,A3
 MOVEQ #64,D3
UPWORK:
 JSR CRSOFF
 MOVE.W CRSX,D4
 JSR READADR
 MOVE.L D0,D5
 CLR.L D0
 JSR INSLINE
 JSR ZEILANF
 MOVE.L D5,A0
 SUB.L D3,A0
 JSR (A3)
 MOVE.W D4,D1
 CLR.W D2 
 JSR RCRSET
 JMP INPLINE
NRMSCRUP:
 JSR CRSUP
 JMP INPLINE
N10:
 CMP.W #$50,D0 * C. down
 BNE.S N20
 MOVE.W CRSY,D0
 CMP.B #24,D0
 BNE.S NRMDWN
 JSR EINGAB
 JSR READCHAR
 CMP.B #'.',D0
 BNE.S NRMDWN
 JSR READCHAR
 CMP.B #':',D0
 BNE.S VLTEXTDWN
 LEA MEMOUT,A3
 MOVEQ #16,D3
 BRA.S DWNWORK
VLTEXTDWN:
 CMP.B #$27,D0
 BNE.S NRMDWN
 LEA KONTROUT,A3
 MOVEQ #64,D3
DWNWORK:
 JSR CRSOFF
 MOVE.W CRSX,D4
 JSR READADR
 MOVE.L D0,D5
 MOVEQ #10,D0 * LF
 JSR CONOUT
 CLR.W D0
 JSR DELLINE
 JSR ZEILANF
 MOVE.L D5,A0
 ADD.L D3,A0
 JSR (A3)
 MOVE.W D4,D1
 MOVEQ #24,D2
 JSR RCRSET
 JMP INPLINE
NRMDWN:
 JSR CRSDOWN
 JMP INPLINE
N20:
 CMP.W #$4D,D0
 BNE.S N30
 JSR CRSRIGHT
 JMP INPLINE
N30:
 CMP.W #$4B,D0
 BNE.S N40
 JSR CRSLEFT
 JMP INPLINE
N40:
 CMP.W #$52,D0
 BNE.S N45
 JSR CINSERT
 BRA.S ILWT
N45:
 CMP.W #$47,D0
 BNE.S N50
 JSR HOME
 BRA.S ILWT
N50:
 CMP.W #$61,D0 * UNDO
 BNE.S N60
 CLR.W D1 * Cursor auf 0,24
 MOVE.W #24,D2
 JSR RCRSET
 BRA.S ILWT
N60:
 CMP.W #$62,D0 * HELP
 BEQ SCREENTEST
* Erweit.
 JSR UNKEY
 BRA.S ILWT

BLOESCH:
 JSR SCRCLR
 BRA.S ILWT

BACKSPACE:
 JSR CBACKSPC
 BRA.S ILWT

DELETE:
 JSR CDELETE
ILWT:
 JMP INPLINE

FRESSZL:
 MOVEQ #'M',D0  * Zeile deleten
 JSR ESCOUT
 MOVE.W CRSY,D0
 JSR DELLINE
ISAME:
 LEA CRSX,A0
 CLR.W (A0) * Spalte = 0
 JSR CRSET
 BRA.S ILWT

LEINF:
 MOVE.W CRSY,D0
 JSR INSLINE
 BRA.S ISAME

TLINEFEED:
 JSR CARRET * entspricht SHIFT-RETURN
 BRA.S ILWT

TABVER:
 MOVEQ #9,D0 * 10 Cursor right
TABVLP:
 JSR CRSRIGHT
 DBF D0,TABVLP
 BRA.S ILWT

CTRLA:
 JSR RESTZLSH
 BRA.S ILWT

SCREENTEST:
 BSR.S SCRNEW
 BRA.S ILWT

SCRNEW:
 MOVE.L #1998,D1 * Textbildschirm neu ausgeben
 LEA VRAM,A0
 MOVEQ #'E',D0
 JSR ESCOUT * sichtbaren Bildschirm l”schen
SCRTLP:
 MOVE.B (A0)+,D0
 JSR CONOUT
 DBF D1,SCRTLP
 JSR CRSET
 RTS


EINGAB:
 JSR CRSOFF
 LEA NEXTCHR,A0    * RETURN-TASTE wurde gedr�ckt
 LEA VRAM,A1      * Zeiger auf aktuelle Zeile setzen
 MOVEQ #80,D0
 MULU CRSY,D0
 ADD.L D0,A1
 MOVE.L A1,(A0)+  * Zeiger auf zu holendes Z.
 CLR.W (A0)+      * noch keins geholt
 MOVEQ #80,D0     * endst„ndige Leerzeichen eliminieren
 ADD.L D0,A1
ENDSLP:
 CMP.B #32,-(A1)
 BNE.S ELINE
 SUBQ.B #1,D0
 BNE.S ENDSLP
ELINE:
 MOVE.W D0,(A0) * Anzahl g�ltiger Z./Zeile
 RTS

READCHAR:
 MOVEM.L D1-D2/A0-A1,-(SP)  * Z. vom Bildschirm nach d0
 CLR.L D0
 LEA NEXTCHR,A0
 MOVE.L (A0)+,A1
 MOVE.W (A0)+,D1
 CMP.W (A0),D1   * Zeilenende erreicht?
 BEQ.S RCEND
 ADDQ.W #1,-(A0) * EINGPTR
 ADDQ.L #1,-(A0) * NEXTCHR
 MOVE.B (A1),D0  *<<<
RCEND:
 MOVEM.L (SP)+,D1-D2/A0-A1
 RTS

MUSTREAD:
 JSR READCHAR
 BEQ ERRO
 CMP.B #32,D0    * Spaces �berlesen
 BEQ.S MUSTREAD
 RTS

READBACK:
 MOVE.L A0,-(SP)   * Zeichenpointer einen zur�ck
 LEA NEXTCHR,A0
 SUBQ.L #1,(A0)+
 SUB.W #1,(A0)
 MOVE.L (SP)+,A0
 RTS

KLEINERBU:
 CMP.B #'A',D0  * Grožbuchstaben in kleine umwandeln
 BCS.S NOBUCHST
 CMP.B #'Z'+1,D0
 BCC.S NOBUCHST
 ADD.B #$20,D0
NOBUCHST:
 RTS



* Bildschirmeditor <<<
*
* Routinen zur Steuerung des gesamten Bildschirms
* und des Textpuffers

RCRSET:
 LEA CRSX,A0      * Cursor auf D1,D2
 MOVE.W D1,(A0)+
 MOVE.W D2,(A0)

CRSET:
 MOVEM.L D0/A0,-(SP)
 LEA CRSY,A0
 MOVEQ #'Y',D0    * sichtbaren Cursor = unsichtbaren
 JSR ESCOUT
 MOVE.W (A0),D0
 ADD.W #32,D0
 JSR CONOUT
 MOVE.W -(A0),D0
 ADD.W #32,D0
 JSR CONOUT
 MOVEM.L (SP)+,D0/A0
 RTS

CRSUP:
 LEA CRSY,A0
 MOVE.W (A0),D0
 BNE.S NOTFRST
 JSR INSLINE * Zeile einf�gen, Scrolling nach unten
 BRA.S CRSET
NOTFRST:
 SUBQ.W #1,(A0)
 BRA.S CRSET

CRSDOWN:
 LEA CRSY,A0
 CMP.W #24,(A0)
 BNE.S NOTLST
 MOVEQ #10,D0 * Scroll up
 JSR CONOUT
 CLR.L D0
 JSR DELLINE
 BRA.S CRSET
NOTLST:
 ADDQ.W #1,(A0)
 BRA.S CRSET

CRSRIGHT:
 LEA CRSX,A0
 CMP.W #79,(A0)
 BEQ.S LSPALT
 ADDQ.W #1,(A0)
 BRA.S CRSET
LSPALT:
 CLR.W (A0)+
 CMP.W #24,(A0) * CRSY
 BEQ.S CRSET
 ADDQ.W #1,(A0)
 BRA.S CRSET

CRSLEFT:
 LEA CRSX,A0
 CMP.W #0,(A0)
 BEQ.S FSPALT
 SUBQ.W #1,(A0)
 BRA.S CRSET
FSPALT:
 MOVE.W #79,(A0)+
 CMP.W #0,(A0) * CRSY
 BEQ CRSET
 SUB.W #1,(A0)
 JMP CRSET

SCRCLR:
 MOVEM.L D0-D1/A0,-(SP)  * Bildsch. l”schen
 MOVEQ #'E',D0
 JSR ESCOUT
 LEA VRAM,A0
 MOVE.L #$20202020,D1
 MOVE.L #499,D0 * 500 Longs
CLRLP:
 MOVE.L D1,(A0)+
 DBF D0,CLRLP
 BRA.S XYNULL

HOME:
 MOVEM.L D0-D1/A0,-(SP)
 MOVEQ #'H',D0 * Cursor Home
 JSR ESCOUT
XYNULL:
 LEA CRSX,A0 *xy-Koord. auf Null
 CLR.L (A0)
 MOVEM.L (SP)+,D0-D1/A0
 RTS

SPACETAB:
 MOVEM.L D0-D1,-(SP)  * Spaces bis Spalte d0 ausg. (Tabellen)
 MOVE.W D0,D1
 MOVEQ #32,D0
STBLP:
 CMP.W CRSX,D1
 BCS.S STBXT
 BEQ.S STBXT
 JSR PRINT
 BRA.S STBLP
STBXT: 
 MOVEM.L (SP)+,D0-D1
 RTS

DELLINE:
 LEA VRAM,A0 * deleten Zeile D0.W OHNE ŽNDERN DES SICHTBAREN BILDSCHIRMS!!!
 CMP.B #24,D0
 BEQ.S CLRLINE
 MOVE.L A0,D2
 ADD.L #2000,D2
 MOVEQ #80,D1
 MULU D0,D1
 ADD.L D1,A0
 MOVE.L A0,A1
 ADD.L #80,A1
USCRLP:
 MOVE.L (A1)+,(A0)+ 
 CMP.L A1,D2
 BNE.S USCRLP
 MOVEQ #24,D0 * letzte Zeile l”schen
 BRA.S CLRLINE

INSLINE:
 MOVE.W D0,D1 * Zeile D0 einf�gen
 MOVEQ #'L',D0
 JSR ESCOUT
 MOVE.W D1,D0
 CMP.B #24,D0 * letzte Zeile
 BEQ.S CLRLINE
 LEA VRAM,A0
 MOVE.L A0,A2
 ADD.L #2000,A2
 MOVE.L A2,A1
 MOVEQ #80,D1
 SUB.L D1,A1
 MULU D0,D1
 ADD.L D1,A0
LINS:
 MOVE.L -(A1),-(A2)
 CMP.L A1,A0
 BNE.S LINS

CLRLINE:
 MOVEM.L D0-D2/A0,-(SP) * Zeile D0 im VRAM l”schen
 LEA VRAM,A0
 MOVEQ #80,D1
 MULU D0,D1
 ADD.L D1,A0
 MOVEQ #19,D2
 MOVE.L #$20202020,D1
LICL:
 MOVE.L D1,(A0)+
 DBF D2,LICL
 MOVEM.L (SP)+,D0-D2/A0
ILL:
 RTS

CBACKSPC:
 LEA VRAM,A0
 LEA CRSX,A1
 CMP.W #0,(A1)+
 BEQ.S ILL * Spalte 0
 MOVE.W (A1),D0 * CRSY
 MOVEQ #80,D1
 MULU D0,D1
 ADD.L D1,A0
 MOVE.W -(A1),D1 * CRSX
 SUBQ.W #1,(A1)
 ADD.L D1,A0
 MOVE.L A0,A1
 SUBQ.L #1,A0
BCKLP:
 MOVE.B (A1)+,(A0)+
 ADDQ.W #1,D1
 CMP.W #80,D1
 BNE.S BCKLP
 MOVE.B #32,(A0)
 MOVE.W CRSY,D0
 JMP RESTLN

CDELETE:
 LEA VRAM,A0
 LEA CRSY,A1
 MOVE.W (A1),D0
 MOVEQ #80,D1
 MULU D0,D1
 ADD.L D1,A0
 MOVE.W -(A1),D1 * CRSX
 ADD.L D1,A0
 MOVE.L A0,A1
 ADD.L #1,A1
CDELLP:
 MOVE.B (A1)+,(A0)+
 ADDQ.W #1,D1
 CMP.W #80,D1
 BNE.S CDELLP
 MOVE.B #32,-(A0)
 MOVE.W CRSY,D0
 JMP RESTLN

CINSERT:
 LEA VRAM,A0 * Space einf�gen, Rest der Zeile nach rechts hinaus
 LEA CRSY,A1
 MOVE.W (A1),D0
 ADDQ.W #1,D0
 MOVEQ #80,D1
 MULU D0,D1
 ADD.L D1,A0
 MOVE.L A0,A2
 SUBQ.L #1,A0
 MOVE.W -(A1),D0 * CRSX
 MOVEQ #79,D1
 SUB.W D0,D1
CINSLP:
 MOVE.B -(A0),-(A2)
 DBF D1,CINSLP
 MOVE.B #32,(A2)
 MOVE.W CRSY,D0

RESTLN:
 JSR CRSOFF
 MOVEM.L D0-D2/A0,-(SP) * Zeile d0 neu ausg.
 MOVE.W D0,D2
 MOVEQ #'Y',D0
 JSR ESCOUT
 MOVE.W D2,D0
 ADD.W #32,D0
 JSR CONOUT
 MOVE.W #32,D0 * Spalte = 0
 JSR CONOUT
 LEA VRAM,A0
 MOVEQ #80,D1
 MULU D2,D1
 ADD.L D1,A0
 MOVEQ #79,D1
 MOVE.W CRSY,D0 * untere rechte Ecke kann nicht beschrieben werden!
 CMP.W #24,D0
 BNE.S RSTLP
 MOVEQ #78,D1
RSTLP:
 MOVE.B (A0)+,D0
 JSR CONOUT
 DBF D1,RSTLP
 JSR CRSET  * Cu. auf alte Pos.
 MOVEM.L (SP)+,D0-D2/A0
 RTS

RESTZLSH:
 MOVEM.L D0-D1/A0,-(SP) *  Rest d. Zl. ab C.pos. incl. l”schen 
 MOVEQ #'K',D0
 JSR ESCOUT
 LEA VRAM,A0
 MOVE.W CRSY,D0
 MOVEQ #80,D1
 MULU D0,D1
 ADD.L D1,A0
 MOVE.W CRSX,D1
 ADD.L D1,A0
 MOVEQ #79,D0
 SUB.B D1,D0
 MOVEQ #32,D1
RLSCH:
 MOVE.B D1,(A0)+
 DBF D0,RLSCH
 MOVEM.L (SP)+,D0-D1/A0
 RTS

ZEILANF:
 MOVEM.L D0-D3/A0-A3,-(SP) * C. an Anfang der Zeile
 CLR.W D1
 MOVE.W CRSY,D2
 JSR RCRSET
 MOVEM.L (SP)+,D0-D3/A0-A3
 RTS

STOPTEST:
 JSR RAWCONIN
 CMP.B #$1B,D0 * ESC
 RTS

*
LINEOUT:
 BSR.S PRINTLINE
 JMP CARRET

PRINTLINE:
 MOVEM.L D0-D2/A0-A1,-(SP) * aktuelle Zeile (auf Drucker) ausg.
 MOVE.W PRINTNR,D1
 BEQ.S PRLXT
 SUBQ.W #1,D1
 EOR.W #1,D1
 ADDQ.W #4,D1
 MOVEQ #80,D0
 MULU CRSY,D0
 LEA VRAM,A1
 ADD.W D0,A1
 MOVEQ #78,D2
PRLNLP:
 MOVE.B (A1)+,D0
 BSR.S BOUTP
 TST.W D0
 BEQ.S PRLXT
 DBF D2,PRLNLP
 MOVEQ #CR,D0
 BSR.S BOUTP
 MOVEQ #10,D0
 BSR.S BOUTP
PRLXT:
 MOVEM.L (SP)+,D0-D2/A0-A1
 RTS

BOUTP:
 AND.W #$FF,D0
 MOVE.W D0,-(SP)
 MOVE.W D1,-(SP)
 TRAP #1    * OUTPUT
 ADDQ.L #4,SP
 RTS

*

NCPRINT:
 CMP.B #32,D0
 BCC.S PRINT * kein Controlzeichen
 MOVEQ #'.',D0

PRINT:
 MOVEM.L D0-D2/A0-A2,-(SP) * Ausgabe eines Zeichens in D0 <<<
 CMP.B #CR,D0
 BEQ.S ZCR
 CMP.B #32,D0 * keine anderen Steuerzeichen
 BCS.S EPR
 JSR CONOUT
 LEA VRAM,A0
 MOVEQ #80,D1
 LEA CRSY,A1  * plus Cursorzeile mal 80
 MOVE.W (A1),D2
 MULU D2,D1
 ADD.L D1,A0
 LEA CRSX,A1  * plus Cursorspalte
 CLR.L D2
 MOVE.W (A1),D2
 ADD.L D2,A0
 MOVE.B D0,(A0)   * und Zeichen ins VRAM
 MOVE.W D2,D0     * CRSX
 CMP.B #79,D0
 BEQ.S NLINE * letzte Spalte
 ADDQ.W #1,D0
 MOVE.W D0,(A1)
EPR:
 MOVEM.L (SP)+,D0-D2/A0-A2
 RTS
NLINE:
 CLR.W (A1)+
 CMP.W #24,(A1) * CRSY
 BEQ.S UPSCROLL * untere rechte Ecke
 ADDQ.W #1,(A1)
 BRA.S EPR
ZCR:
 JSR CONOUT
 MOVEQ #10,D0 * LINEFEED
 JSR CONOUT
 LEA CRSX,A0
 CLR.W (A0)+  * Spalte =0
 CMP.W #24,(A0) * letzte Zeile ?
 BEQ.S UPSCROLL
 ADDQ.W #1,(A0)
 BRA.S EPR
UPSCROLL:
 CLR.L D0
 JSR DELLINE
 BRA.S EPR

*

STROUT:
 MOVE.L D0,-(SP) * String nach (a0) ausg. <<<
STRLP:
 MOVE.B (A0)+,D0
 BEQ.S STREND
 JSR PRINT
 BRA.S STRLP
STREND:
 MOVE.L (SP)+,D0
 RTS

CRSON:
 MOVE.L D0,-(SP) * Cursorblinken ein
 MOVEQ #'e',D0
 BSR.S ESCOUT
 MOVE.L (SP)+,D0
 RTS

CRSOFF:
 MOVE.L D0,-(SP) * Cursorblinken aus
 MOVEQ #'f',D0
 BSR.S ESCOUT
 MOVE.L (SP)+,D0
 RTS

ESCOUT:
 MOVE.L D0,-(SP)
 MOVEQ #27,D0  * escape
 BSR.S CONOUT
 MOVE.L (SP)+,D0
 BRA.S CONOUT

RAWCONIN:
 MOVE.L A0,-(SP)         * D0:=INKEY$
 MOVE.L #$000600FF,-(SP) * Trick
 TRAP #1
 ADDQ.L #4,SP
 MOVE.L (SP)+,A0
 RTS

CONOUT:
 MOVEM.L D0/A0,-(SP)
 AND.W #$00FF,D0
 MOVE.W D0,-(SP)
 MOVE.W #2,-(SP)
 TRAP #1
 ADDQ.L #4,SP
 MOVEM.L (SP)+,D0/A0
 RTS

CONIN:
 MOVE.L A0,-(SP) * direct con in without echo
 MOVE.W #7,-(SP)
 TRAP #1    * Zeichen von Tastatur holen
 ADDQ.L #2,SP
 MOVE.L (SP)+,A0
 RTS

*

REGIST:
 DS.L 8+7  * Ablage der Register D0-D7,A0-A6
PSTAT:
 DC.W 0    * f�r Statusreg.
PCOUNTER:
 DC.L 0    * f�r Programmz„hler
USERSTP:
 DC.L 0    * f�r User-Stackpointer
SUPVSTP:
 DC.L 0    * f�r Supervisor-Stackpointer

CRSX:
 DC.W 0    * Cursorkoord.
CRSY:
 DC.W 0

NEXTCHR:
 DC.L 0   * Zeiger auf n„chstes Eingabezeichen
EINGPTR:
 DC.W 0   * bereits geholte Zeichen
EINGLAENG:
 DC.W 0   * L„nge der Eing.zeile

 DC.B 'VRAM' * Anfang des Textpuffers kenntlich machen

VRAM:
 DC.W 0   * 2000 Bytes Bildschirmspeicher

 END

