  MODULE MONST
  SECTION S.GLOB

* einfacher Diskmonitor
* Erg„nzung zum "MonST"


DISKMON:
 LEA DMBUFTX,A0   * Pufferadresse erfragen
 JSR STROUT
 MOVE.W CRSX,D1
 MOVE.W CRSY,D2
 MOVE.L DMBUFF,D0
 JSR ADRHEX
 JSR RCRSET
 JSR INPLINE
 MOVEQ #15,D1
DM100:
 JSR READCHAR
 BEQ ERRO
 DBF D1,DM100
 JSR READADR
 LEA DMBUFF,A0
 MOVE.L D0,(A0)
 MOVE.W DMTRK,D4  *  Startposition
 MOVE.W DMSECT,D5

DMLOOP:
 JSR CARRET
 MOVEQ #'*',D0
 JSR PRINT
DMNOST:
 LEA DMTRK,A0
 MOVE.W D4,(A0)+
 MOVE.W D5,(A0)+
 JSR INPLINE
DM200:
 MOVE.W DMTRK,D4  * T
 MOVE.W DMSECT,D5 * S
 JSR READCHAR
 BEQ.S DMLOOP
 CMP.B #'*',D0
 BEQ.S DM200
 CMP.B #'.',D0
 BEQ.S DM200
 CMP.B #32,D0
 BEQ.S DM200
 JSR KLEINERBU
 CMP.B #'x',D0
 BEQ ILL
 CMP.B #'b',D0
 BEQ DISKMON
 CMP.B #'r',D0
 BEQ.S DMREAD
 CMP.B #'w',D0
 BEQ.S DMWRITE
 CMP.B #'m',D0
 BEQ.S DMMEPA
 CMP.B #':',D0
 BEQ.S DMCHG
 CMP.B #'p',D0
 BEQ DMPGW
 CMP.B #'+',D0
 BEQ DMNEXT
 CMP.B #'-',D0
 BEQ DMPREV
 BRA.S DMLOOP

DMMEPA:
 JSR DMTSO
DMMEM:
 LEA MEMOUT,A3    * Hexdump
 MOVEQ #16,D3
 MOVE.L DMBUFF,A0
 MOVE.L A0,A1
 ADD.W #$0200,A1
 JSR MEMSHLP
 JMP DMLOOP
DMCHG:
 JSR MEMMOD
 JSR CARRET
 JMP DMNOST

DMREAD:
 MOVEQ #8,D3
 BRA.S DMRW
DMWRITE:
 MOVEQ #9,D3
DMRW:
 JSR READCHAR
 BEQ.S DMPARA
 JSR READBACK
 JSR READBYTE
 MOVE.W D0,D4
 JSR READBYTE
 MOVE.W D0,D5
 CMP.W #9,D3
 BNE.S DMFLOP
 JSR NACHFRAG
 BNE DMLOOP

DMFLOP:
 MOVE.W #1,-(SP)     * einen Sektor LESEN/SCHREIBEN
 MOVE.W DMPAGE,-(SP) * Seite
 MOVE.W D4,-(SP)     * Track
 MOVE.W D5,-(SP)     * Sector
 CLR.W -(SP)         * DRIVE A
 CLR.L -(SP)         * (DUMMY)
 MOVE.L DMBUFF,-(SP)
 MOVE.W D3,-(SP)    * FLOPRD/FLOPWR
 TRAP #14
 ADD.W #20,SP
 TST.L D0
 BMI.S DMERR
 CMP.W #8,D3
 BEQ.S DMMEM
 JMP DMLOOP
DMERR:
 JSR DISKERR
 JMP DMLOOP

DMPARA:
 BSR.S DMTSO
 JMP DMNOST

DMPGW:
 LEA DMPAGE,A0 * Diskettenseite wechseln
 EOR.W #1,(A0)
 MOVE.W (A0),D0
 ADD.B #'0',D0
 JSR PRINT
 JSR RESTZLSH
 JMP DMLOOP

DMTSO:
 JSR ONESPACE
 MOVE.W D4,D0 * aktuelle Tr/Se ausg.
 JSR BYTEHEX
 JSR ONESPACE
 MOVE.W D5,D0
 JMP BYTEHEX

DMNEXT:
 MOVEQ #8,D3 * n„chsten Sektor lesen
 ADDQ.W #1,D5
 CMP.W #10,D5
 BCS.S DMNPA
 MOVEQ #1,D5
 ADDQ.W #1,D4
 BRA.S DMNPA
DMPREV:
 MOVEQ #8,D3 * vorigen S. lesen
 SUBQ.W #1,D5
 BNE.S DMNPA
 TST.W D4
 BEQ DMLOOP * schon Spur Null
 MOVEQ #9,D5
 SUBQ.W #1,D4
DMNPA:
 BSR.S DMTSO
 JMP DMFLOP

DMBUFF:
 DC.L $050000 * normalerweise freies RAM
DMPAGE:
 DC.W 0
DMTRK:
 DC.W 0
DMSECT:
 DC.W 1

DMBUFTX:
 DC.B CR,'buffer adress:  ',0

 INCLUDE REST.ASM

