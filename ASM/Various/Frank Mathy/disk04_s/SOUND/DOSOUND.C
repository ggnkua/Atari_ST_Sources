#define dosound(a) sxbios(32,a)

char snd[] = { 0,222,1,1,8,16,11,0,12,64,13,9,7,254,
               0xff,30,0,170,13,9,0xff,10,
               0,123,13,9,0xff,20,0,170,13,9,0xff,20,
               0,102,13,9,0xff,20,0,123,13,9,0xff,20,
               0,170,13,9,0xff,10,0,250,13,9,0xff,10,
               0,222,13,9,0xff,30,7,255,0xff,0 };

main()
     {
     dosound(snd);
     pause(800);
     }

