extern long sgemdos(),sxbios();

int clip[] = { 0,0,319,199 };

int sprite[] = { 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x001F,
                 0x001F,0x001F,0x001F,0x001F,0x00FF,
                 0x00FF,0x00FF,0x00FF,0x00FF,0x03FF,
                 0x03FF,0x03FF,0x03FF,0x03FF,0x07FF,
                 0x03FF,0x03FF,0x03FF,0x03FF,0x07FF,
                 0x07FF,0x07FF,0x07FF,0x07FF,0x0FFF,
                 0x0FC0,0x0FC0,0x0FC0,0x0FFF,0x1FFF,
                 0x0FC0,0x0FC0,0x0FC0,0x0FFF,0x1FFF,
                 0x1F80,0x1F80,0x1F80,0x1FFF,0x3FFF,
                 0x3F03,0x3F03,0x3F03,0x3FFC,0x7FFF,
                 0x3E03,0x3E03,0x3E03,0x3FFC,0x7FFF,
                 0x7E07,0x7E07,0x7E07,0x7FF8,0xFFFF,
                 0x7C07,0x7C07,0x7C07,0x7FF8,0xFFFF,
                 0x3C07,0x3C07,0x3C07,0x3FF8,0x7FFF,
                 0x7F07,0x7F07,0x7F07,0x7FF8,0xFFFF,
                 0x7F00,0x7F00,0x7F00,0x7FFF,0xFFFF,
                 0x7FC0,0x7FC0,0x7FC0,0x7FFF,0xFFFF,
                 0x7FC0,0x7FC0,0x7FC0,0x7FFF,0xFFFF,
                 0x3FE0,0x3FE0,0x3FE0,0x3FFF,0xFFFF,
                 0x1FF0,0x1FF0,0x1FF0,0x1FFF,0x7FFF,
                 0x01FC,0x01FC,0x01FC,0x01FF,0x0FFF,
                 0x007F,0x007F,0x007F,0x007F,0x01FF,
                 0x000F,0x000F,0x000F,0x000F,0x00FF,
                 0x000F,0x000F,0x000F,0x000F,0x001F,
                 0x0007,0x0007,0x0007,0x0007,0x000F,
                 0x0000,0x0000,0x0000,0x0000,0x0007,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0x0000,
                 0x0000,0x0000,0x0000,0x0000,0xFFC0,
                 0xFFC0,0xFFC0,0xFFC0,0xFFC0,0xFFE0,
                 0xFFE0,0xFFE0,0xFFE0,0xFFE0,0xFFF0,
                 0xFFE0,0xFFE0,0xFFE0,0xFFE0,0xFFF0,
                 0xFFF0,0xFFF0,0xFFF0,0xFFF0,0xFFF8,
                 0x87F8,0x87F8,0x87F8,0xFFF8,0xFFFC,
                 0x01FC,0x01FC,0x01FC,0xFFFC,0xFFFE,
                 0x00FE,0x00FE,0x00FE,0xFFFE,0xFFFF,
                 0x00FE,0x00FE,0x00FE,0xFFFE,0xFFFF,
                 0xC0FE,0xC0FE,0xC0FE,0x3FFE,0xFFFF,
                 0xE0FE,0xE0FE,0xE0FE,0x1FFE,0xFFFF,
                 0xC0FE,0xC0FE,0xC0FE,0x3FFE,0xFFFF,
                 0x83FC,0x83FC,0x83FC,0x7FFC,0xFFFE,
                 0x87FC,0x87FC,0x87FC,0x7FFC,0xFFFE,
                 0x8FF8,0x8FF8,0x8FF8,0x7FF8,0xFFFC,
                 0x1FF8,0x1FF8,0x1FF8,0xFFF8,0xFFFC,
                 0x1FE0,0x1FE0,0x1FE0,0xFFE0,0xFFF8,
                 0x0FC0,0x0FC0,0x0FC0,0xFFC0,0xFFE0,
                 0x0F80,0x0F80,0x0F80,0xFF80,0xFFC0,
                 0x0F00,0x0F00,0x0F00,0xFF00,0xFF80,
                 0x0F00,0x0F00,0x0F00,0xFF00,0xFF80,
                 0xFF00,0xFF00,0xFF00,0xFF00,0xFF80,
                 0xFE00,0xFE00,0xFE00,0xFE00,0xFF00,
                 0xFE00,0xFE00,0xFE00,0xFE00,0xFF00,
                 0xFE00,0xFE00,0xFE00,0xFE00,0xFF00,
                 0xFE00,0xFE00,0xFE00,0xFE00,0xFF00,
                 0x1C00,0x1C00,0x1C00,0x1C00,0xFE00,
                 0x0000,0x0000,0x0000,0x0000,0x1C00,
                 0x0000,0x0000,0x0000,0x0000,0x0000 };

int s1[262],s2[262];
int i,x,res;
long phys,car;

main()
     {
     offmouse();
     phys=sxbios(2);
     res= (int) sxbios(4);
     sxbios(5,-1L,-1L,0);
     
     for(x= -32;x<360;x+=3)
          {
          fsetsprite(x-16,100,sprite,s1,phys,clip,31);
          fsetsprite(x,100,&(sprite[160]),s2,phys,clip,31);
          sxbios(37);
          fclrsprite(s2,phys,31);
          fclrsprite(s1,phys,31);
          }
     car=sgemdos(0x48,3840L);
     binload("sprite.img",car,3840L);
     for(x=0;x<10;x++)
       for(i=0;i<24;i++)
          {
          fsetsprite(160,100,car+i*160,s1,phys,clip,15);
          sxbios(37);
          sxbios(37);
          fclrsprite(s1,phys,15);
          }
     sgemdos(0x49,car);
     sxbios(5,-1L,-1L,res);
     onmouse();
     }

