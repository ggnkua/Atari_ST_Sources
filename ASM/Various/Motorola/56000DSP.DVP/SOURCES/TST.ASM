 	TST.B	SUP
	BNE.S	TSTINF
	TST.W	D0
	BMI.S	CONT
	CMP.W	#$0,D0
	SHI	SUP
	BRA.S	CONT
	
TSTINF	TST.B	INF
	BNE.S	AFF
	TST.W	D0
	BPL.S	CONT
	CMP.W	#$FFFE,D0
	SLS	INF

VBL	MOVE.L	$466,D7
VBL0	CMP.L	$466,D7
	BEQ.S	VBL0

	BRA.S	AFF
CONT	ADD.L	#2,A0		; AMPLITUDE SUIVANTE
	BRA.S	LOOP

AFF	MULS.W	#640/8,D0		; TAILLE D'UNE LIGNE ECRAN
