  ORG       Y:$0000
  DC $022ACC
  DC $022AC3
  DC $022AAA
  DC $022A80
  DC $022A3D
  DC $0229F1
  DC $022995
  DC $022928
  DC $0228A2
  DC $022813
  DC $022774
  DC $0226BB
  DC $0225FA
  DC $022520
  DC $02243E
  DC $02234B
  DC $02223E
  DC $022129
  DC $021FFB
  DC $021EC5
  DC $021D7E
  DC $021C1D
  DC $021AB5
  DC $02193B
  DC $0217B1
  DC $021616
  DC $02146A
  DC $0212AE
  DC $0210E0
  DC $020F02
  DC $020D1B
  DC $020B24
  DC $02091C
  DC $020703
  DC $0204DA
  DC $02029F
  DC $02005C
  DC $01FE09
  DC $01FBA4
  DC $01F92F
  DC $01F6B2
  DC $01F423
  DC $01F184
  DC $01EEDD
  DC $01EC25
  DC $01E95B
  DC $01E68A
  DC $01E3A8
  DC $01E0B5
  DC $01DDBA
  DC $01DAB6
  DC $01D7A1
  DC $01D47C
  DC $01D14E
  DC $01CE18
  DC $01CAD1
  DC $01C77A
  DC $01C422
  DC $01C0B1
  DC $01BD40
  DC $01B9BF
  DC $01B635
  DC $01B2A2
  DC $01AEFF
  ORG       X:$0080
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $59999A
  DC $7FFFAC
  ORG       P:$0000
 P:0000 JMP $0200
  ORG       P:$000C
 P:000C JSR $023D
  ORG       P:$000E
 P:000E MOVEP X:<<$FFEE,A
 P:000F JSR $023D
  ORG       P:$0010
 P:0010 JSR $0265
  ORG       P:$0012
 P:0012 MOVEP X:<<$FFEE,A
 P:0013 JSR $0265
  ORG       P:$0200
 P:0200 MOVEP X:<<$FFEB,X0
 P:0201 MOVEC #<00,SP
 P:0202 MOVEP #>$004100,X:<<$FFEC
 P:0204 MOVEP #>$0001F8,X:<<$FFE1
 P:0206 BTST #$04,X:<<$FFEE
 P:0207 MOVEP #>$00F800,X:<<$FFED
 P:0209 MOVEP #>$000000,X:<<$FFFE
 P:020B MOVEP #>$003000,X:<<$FFFF
 P:020D MOVEP #>$000001,X:<<$FFE0
 P:020F ANDI #$FC,MR
 P:0210 BSET #$02,OMR
 P:0211 MOVE  #$00,R0
 P:0212 MOVEC #<3F,M0
 P:0213 MOVE  #$40,R1
 P:0214 MOVEC #<3F,M1
 P:0215 MOVE  #$00,R4
 P:0216 MOVEC #<3F,M4
 P:0217 MOVE  #$8A,R2
 P:0218 JCLR #$00,X:<<$FFE9,$021E
 P:021A MOVEP X:<<$FFEB,N2
 P:021B JCLR #$00,X:<<$FFE9,$021B
 P:021D MOVEP X:<<$FFEB,X:(R2+N2)
 P:021E MOVE  X:$0080,X0
 P:0220 MOVE  X:$0081,B
 P:0222 MOVE  X:$008B,X1
 P:0224 MPY +X1,X0,A 
 P:0225 SUB A,B 
 P:0226 MOVE  X:$008A,X1
 P:0228 MOVE  X:$0083,X0
 P:022A MAC +X1,X0,B 
 P:022B MOVE  B,X:$0085
 P:022D MOVE  X:$0080,B
 P:022F MOVE  X:$0081,X0
 P:0231 MOVE  X:$008B,X1
 P:0233 MPY +X1,X0,A 
 P:0234 SUB A,B 
 P:0235 MOVE  X:$008A,X1
 P:0237 MOVE  X:$0082,X0
 P:0239 MAC +X1,X0,B 
 P:023A MOVE  B,X:$0084
 P:023C JMP <$0218
 P:023D MOVE  X0,X:$0086
 P:023F MOVE  Y0,X:$0087
 P:0241 MOVE  X:$0088,X0
 P:0243 JCLR #$00,X0,$0255
 P:0245 MOVEP X:<<$FFEF,X0
 P:0246 MOVE  X0,X:$0081
 P:0248 BCLR #$00,X:$0088
 P:024A CLR A X0,X:(R0)+ Y:(R4)+,Y0
 P:024B REP #$03F
 P:024C MAC +Y0,X0,A X:(R0)+,X0 Y:(R4)+,Y0
 P:024D MACR +Y0,X0,A (R0)-
 P:024E MOVE  A,X:$0083
 P:0250 MOVE  X:$0087,Y0
 P:0252 MOVE  X:$0086,X0
 P:0254 RTI 
 P:0255 MOVEP X:<<$FFEF,X0
 P:0256 MOVE  X0,X:$0080
 P:0258 BSET #$00,X:$0088
 P:025A CLR A X0,X:(R1)+ Y:(R4)+,Y0
 P:025B REP #$03F
 P:025C MAC +Y0,X0,A X:(R1)+,X0 Y:(R4)+,Y0
 P:025D MACR +Y0,X0,A (R1)-
 P:025E MOVE  A,X:$0082
 P:0260 MOVE  X:$0087,Y0
 P:0262 MOVE  X:$0086,X0
 P:0264 RTI 
 P:0265 MOVE  X0,X:$0086
 P:0267 MOVE  X1,X:$0087
 P:0269 MOVE  X:$0089,X0
 P:026B JCLR #$00,X0,$0277
 P:026D MOVE  X:$0085,X1
 P:026F MOVEP X1,X:<<$FFEF
 P:0270 BCLR #$00,X:$0089
 P:0272 MOVE  X:$0086,X0
 P:0274 MOVE  X:$0087,X1
 P:0276 RTI 
 P:0277 MOVE  X:$0084,X0
 P:0279 MOVEP X0,X:<<$FFEF
 P:027A BSET #$00,X:$0089
 P:027C MOVE  X:$0086,X0
 P:027E MOVE  X:$0087,X1
 P:0280 RTI 
