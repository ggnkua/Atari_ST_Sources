  ORG       X:$0000
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000000
  ORG       P:$0000
 P:0000 JMP $0040
  ORG       P:$000C
 P:000C JSR $0076
  ORG       P:$0010
 P:0010 JSR $0087
  ORG       P:$0040
 P:0040 MOVEP X:<<$FFEB,X0
 P:0041 MOVEC #<00,SP
 P:0042 MOVEP #>$004100,X:<<$FFEC
 P:0044 MOVEP #>$0001F8,X:<<$FFE1
 P:0046 BTST #$04,X:<<$FFEE
 P:0047 MOVEP #>$00F800,X:<<$FFED
 P:0049 MOVEP #>$000000,X:<<$FFFE
 P:004B MOVEP #>$003000,X:<<$FFFF
 P:004D MOVEP #>$000001,X:<<$FFE0
 P:004F JSR $00D5
 P:0051 ANDI #$FC,MR
 P:0052 JCLR #$00,X:<$08,$0052
 P:0054 JCLR #$00,X:<<$FFE9,$0070
 P:0056 MOVEP X:<<$FFEB,X1
 P:0057 JCLR #$00,X:<<$FFE9,$0057
 P:0059 MOVEP X:<<$FFEB,X0
 P:005A MOVE  #>$000014,A
 P:005C CMP X1,A 
 P:005D JCC $0066
 P:005F MOVE  X0,N1
 P:0060 MOVE  #>$001060,R1
 P:0062 NOP 
 P:0063 MOVE  X:(R1+N1),X0
 P:0064 JMP $006B
 P:0066 MOVE  X0,N1
 P:0067 MOVE  #>$001040,R1
 P:0069 NOP 
 P:006A MOVE  X:(R1+N1),X0
 P:006B MOVE  X1,N1
 P:006C MOVE  #>$001000,R1
 P:006E NOP 
 P:006F MOVE  X0,X:(R1+N1)
 P:0070 JSR $0097
 P:0072 JSR $00B6
 P:0074 BCLR #$00,X:<$08
 P:0075 JMP <$0052
 P:0076 BSET #$00,X:<$08
 P:0077 MOVE  X0,X:<$04
 P:0078 MOVE  X1,X:<$05
 P:0079 JCLR #$00,X:<$06,$0081
 P:007B MOVEP X:<<$FFEF,X1
 P:007C MOVE  X1,X:<$01
 P:007D BCLR #$00,X:<$06
 P:007E MOVE  X:<$04,X0
 P:007F MOVE  X:<$05,X1
 P:0080 RTI 
 P:0081 MOVEP X:<<$FFEF,X0
 P:0082 MOVE  X0,X:<$00
 P:0083 BSET #$00,X:<$06
 P:0084 MOVE  X:<$04,X0
 P:0085 MOVE  X:<$05,X1
 P:0086 RTI 
 P:0087 MOVE  X0,X:<$04
 P:0088 MOVE  X1,X:<$05
 P:0089 JCLR #$00,X:<$07,$0091
 P:008B MOVE  X:<$03,X1
 P:008C MOVEP X1,X:<<$FFEF
 P:008D BCLR #$00,X:<$07
 P:008E MOVE  X:<$04,X0
 P:008F MOVE  X:<$05,X1
 P:0090 RTI 
 P:0091 MOVE  X:<$02,X0
 P:0092 MOVEP X0,X:<<$FFEF
 P:0093 BSET #$00,X:<$07
 P:0094 MOVE  X:<$04,X0
 P:0095 MOVE  X:<$05,X1
 P:0096 RTI 
 P:0097 MOVE  X:<$00,B
 P:0098 MOVE  B,Y0
 P:0099 MOVEC #<02,M4
 P:009A MOVE  #>$00100A,R1
 P:009C CLR A X:$1016,X0
 P:009E MPY +Y0,X0,B (R4)+
 P:009F MOVE  B1,Y:(R5)
 P:00A0 ORI #$08,MR
 P:00A1 DO #$00A,$00AA
 P:00A3 CLR B X:(R0)+,X0 Y:(R4)+,Y0
 P:00A4 MAC -Y0,X0,B X:(R0)+,X0 Y:(R5)+,Y0
 P:00A5 MAC +Y0,X0,B Y:(R5)-,Y0
 P:00A6 MAC -Y0,X0,B X:(R0)+,X0 Y:(R4)+,Y0
 P:00A7 MACR +Y0,X0,B X:(R1)+,Y0
 P:00A8 MOVE  B,X0 B,Y:(R4)+
 P:00A9 MAC +Y0,X0,A (R4)+N4
 P:00AA ANDI #$F7,MR
 P:00AB MOVEC #<2B,M4
 P:00AC MOVE  X:<$1D,X0
 P:00AD MOVE  Y:(R5)+,Y0
 P:00AE MAC +Y0,X0,A X:$1015,Y0
 P:00B0 MOVE  A,X0
 P:00B1 MPY +Y0,X0,B 
 P:00B2 ASL B (R4)+N4
 P:00B3 ASL B 
 P:00B4 MOVE  B,X:<$02
 P:00B5 RTS 
 P:00B6 MOVE  X:<$01,B
 P:00B7 MOVE  B,Y0
 P:00B8 MOVEC #<02,M6
 P:00B9 MOVE  #>$001000,R1
 P:00BB CLR A X:$1016,X0
 P:00BD MPY +Y0,X0,B (R6)+
 P:00BE MOVE  B1,Y:(R7)
 P:00BF ORI #$08,MR
 P:00C0 DO #$00A,$00C9
 P:00C2 CLR B X:(R0)+,X0 Y:(R6)+,Y0
 P:00C3 MAC -Y0,X0,B X:(R0)+,X0 Y:(R7)+,Y0
 P:00C4 MAC +Y0,X0,B Y:(R7)-,Y0
 P:00C5 MAC -Y0,X0,B X:(R0)+,X0 Y:(R6)+,Y0
 P:00C6 MACR +Y0,X0,B X:(R1)+,Y0
 P:00C7 MOVE  B,X0 B,Y:(R6)+
 P:00C8 MAC +Y0,X0,A (R6)+N6
 P:00C9 ANDI #$F7,MR
 P:00CA MOVEC #<2B,M6
 P:00CB MOVE  X:<$1D,X0
 P:00CC MOVE  Y:(R7)+,Y0
 P:00CD MAC +Y0,X0,A X:$1015,Y0
 P:00CF MOVE  A,X0
 P:00D0 MPY +Y0,X0,B 
 P:00D1 ASL B (R6)+N6
 P:00D2 ASL B 
 P:00D3 MOVE  B,X:<$03
 P:00D4 RTS 
 P:00D5 MOVE  #>$7FFFFF,X0
 P:00D7 MOVE  X0,X:$1015
 P:00D9 MOVE  #>$7FFFFF,X0
 P:00DB MOVE  X0,X:$1016
 P:00DD MOVE  #$20,X0
 P:00DE MOVE  X0,X:$001D
 P:00E0 CLR A 
 P:00E1 MOVE  #>$001020,R2
 P:00E3 DO #$0A0,$00E6
 P:00E5 MOVE  A,Y:(R2)+
 P:00E6 CLR A 
 P:00E7 MOVE  #>$001000,R2
 P:00E9 DO #$015,$00EC
 P:00EB MOVE  A,X:(R2)+
 P:00EC CLR A 
 P:00ED MOVE  #>$001080,R2
 P:00EF DO #$015,$00F2
 P:00F1 MOVE  A,X:(R2)+
 P:00F2 MOVE  #>$001040,R4
 P:00F4 MOVE  #$04,N4
 P:00F5 MOVE  #>$001080,R6
 P:00F7 MOVE  #$04,N6
 P:00F8 MOVE  #>$001020,R5
 P:00FA MOVEC #<02,M5
 P:00FB MOVE  #>$001030,R7
 P:00FD MOVEC #<02,M7
 P:00FE MOVE  #>$001020,R0
 P:0100 MOVEC #<1D,M0
 P:0101 MOVE  #>$001000,R3
 P:0103 MOVEC #<14,M3
 P:0104 MOVE  #$80,N3
 P:0105 RTS 
  ORG       X:$1020
  DC $3FCD7F
  DC $001941
  DC $7FCD2E
  DC $3F99A2
  DC $00332F
  DC $7F9859
  DC $3F32E4
  DC $00668E
  DC $7F2DAF
  DC $3E6AD9
  DC $00CA94
  DC $7E564D
  DC $3CE4A9
  DC $018DAB
  DC $7C9380
  DC $3A024C
  DC $02FEDA
  DC $78C581
  DC $34D84E
  DC $0593D9
  DC $7022AF
  DC $2C7AA6
  DC $09C2AD
  DC $5B582F
  DC $214B31
  DC $0F5A67
  DC $28A767
  DC $172AD0
  DC $146A98
  DC $C73AD4
  ORG       X:$1040
  DC $E66666
  DC $E81062
  DC $EA1CAC
  DC $EB851F
  DC $ECCCCD
  DC $EE76C9
  DC $F16873
  DC $F2D0E5
  DC $F43958
  DC $F5C28F
  DC $F76C8B
  DC $F978D5
  DC $FB020C
  DC $FC8B44
  DC $FE147B
  DC $000000
  DC $000000
  DC $03D70A
  DC $07AE14
  DC $0B851F
  DC $0F5C29
  DC $133333
  DC $170A3D
  DC $1AE148
  DC $200000
  DC $251EB8
  DC $2B851F
  DC $30A3D7
  DC $3AE148
  DC $451EB8
  DC $600000
  DC $7FDF3B
  ORG       X:$1060
  DC $000000
  DC $000000
  DC $00068E
  DC $001062
  DC $0020C5
  DC $00624E
  DC $0147AE
  DC $01EB85
  DC $028F5C
  DC $03D70A
  DC $051EB8
  DC $07AE14
  DC $0A3D71
  DC $0CCCCD
  DC $0F5C29
  DC $133333
  DC $19999A
  DC $200000
  DC $266666
  DC $2CCCCD
  DC $333333
  DC $39999A
  DC $400000
  DC $4CCCCD
  DC $59999A
  DC $666666
  DC $733333
  DC $7FFCB9
  DC $7FFCB9
  DC $7FFCB9
  DC $7FFCB9
  DC $7FFCB9
