  ORG       P:$01A0
 P:01A0 MOVE  X:<$00,X0
 P:01A1 MOVE  X0,X:(R2)
 P:01A2 MOVE  X:<$01,X0
 P:01A3 MOVE  X0,Y:(R2)+
 P:01A4 MOVE  X:<$0E,B
 P:01A5 MOVE  Y:<$0E,Y0
 P:01A6 SUB Y0,B #>$0003E9,Y1
 P:01A8 JGT $01AB
 P:01AA ADD Y1,B X:(R6)+,X0
 P:01AB MOVE  #$01,X0
 P:01AC MOVE  B,X:<$0E
 P:01AD MOVE  R6,B
 P:01AE MOVE  R2,X1
 P:01AF SUB X1,B #>$00003F,Y0
 P:01B1 JLE $01C6
 P:01B3 JSET #$00,X:<$0F,$01B9
 P:01B5 CMP Y0,B 
 P:01B6 JGT $01CA
 P:01B8 BSET #$00,X:<$0F
 P:01B9 MOVE  #>$800000,X1 B,Y0
 P:01BB MPY +Y0,X0,B 
 P:01BC MOVE  B0,B1
 P:01BD ADD X1,B B1,X0
 P:01BE NEG B X:(R6),X1
 P:01BF MPY +X1,X0,A X:(R6+N6),X1
 P:01C0 MOVE  B,Y0
 P:01C1 MACR +X1,Y0,A Y:(R6),X1
 P:01C2 MPY +X1,X0,B Y:(R6+N6),X1
 P:01C3 MACR +X1,Y0,B A,X:<$00
 P:01C4 MOVE  B,X:<$01
 P:01C5 RTS 
 P:01C6 JCLR #$00,X:<$0F,$01CA
 P:01C8 MOVE  (R6)+N6
 P:01C9 BCLR #$00,X:<$0F
 P:01CA MOVE  X:(R6),X0
 P:01CB MOVE  X0,X:<$00
 P:01CC MOVE  Y:(R6),Y0
 P:01CD MOVE  Y0,X:<$01
 P:01CE RTS 
 P:01CF MOVE  L:<$00,A10
  ORG       P:$03D0
 P:03D0 JSET #$0E,Y:<$01,$03E7
 P:03D2 JSET #$06,Y:<$00,$03E7
 P:03D4 MOVE  #>$000400,R6
 P:03D6 MOVE  #>$000200,N6
 P:03D8 MOVEC #>$0003FF,M6
 P:03DA MOVE  #>$000400,R2
 P:03DC MOVEC #>$0003FF,M2
 P:03DE MOVE  #>$0003E9,Y0
 P:03E0 MOVE  Y0,X:<$0E
 P:03E1 MOVE  #>$0001F4,Y0
 P:03E3 MOVE  Y0,Y:<$0E
 P:03E4 BCLR #$00,X:<$0F
 P:03E5 BSET #$06,Y:<$00
 P:03E6 RTS 
 P:03E7 BCLR #$06,Y:<$00
 P:03E8 RTS 
 P:03E9 MOVE  L:<$00,A10
 P:03EA MOVE  Y:<$01,B
 P:03EB MOVE  #>$00FFFF,Y0
 P:03ED AND Y0,B 
 P:03EE MOVE  B,Y:<$0E
 P:03EF CLR B 
 P:03F0 MOVE  B,Y:<$01
 P:03F1 RTS 
 P:03F2 MOVE  L:<$00,A10
