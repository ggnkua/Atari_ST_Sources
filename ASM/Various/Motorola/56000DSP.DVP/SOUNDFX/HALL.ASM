  ORG       X:$0010
  DC $400000
  DC $59999A
  DC $000000
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000000
  ORG       P:$0000
 P:0000 JMP $0040
  ORG       P:$000C
 P:000C JSR $0090
  ORG       P:$0010
 P:0010 JSR $00A1
  ORG       P:$0040
 P:0040 MOVEP X:<<$FFEB,X0
 P:0041 MOVEC #<00,SP
 P:0042 MOVEP #>$004100,X:<<$FFEC
 P:0044 MOVEP #>$0001F8,X:<<$FFE1
 P:0046 BTST #$04,X:<<$FFEE
 P:0047 MOVEP #>$00F800,X:<<$FFED
 P:0049 MOVEP #>$000000,X:<<$FFFE
 P:004B MOVEP #>$003000,X:<<$FFFF
 P:004D MOVEP #>$000001,X:<<$FFE0
 P:004F MOVE  #$40,Y0
 P:0050 MOVE  #>$59999A,Y1
 P:0052 MOVE  #$00,X1
 P:0053 MOVE  #>$001000,R3
 P:0055 MOVEC #>$000FFF,M3
 P:0057 MOVE  #$10,R1
 P:0058 MOVEC #<02,M1
 P:0059 CLR A 
 P:005A DO #$FFF,$005E
 P:005C MOVE  A,X:(R3)
 P:005D MOVE  A,Y:(R3)+
 P:005E ANDI #$FC,MR
 P:005F JCLR #$00,X:<$1B,$005F
 P:0061 JCLR #$00,X:<<$FFE9,$0067
 P:0063 MOVEP X:<<$FFEB,X:(R1)+
 P:0064 MOVE  X:<$10,Y0
 P:0065 MOVE  X:<$11,Y1
 P:0066 MOVE  X:<$12,X1
 P:0067 CLR A 
 P:0068 CLR B 
 P:0069 MOVE  X:<$13,X0
 P:006A MPY +Y0,X0,B 
 P:006B MOVE  X:(R3),X0
 P:006C MPY +X0,Y1,A 
 P:006D MOVE  #>$000200,N3
 P:006F ADD A,B 
 P:0070 MOVE  X:(R3+N3),X0
 P:0071 MPY +X1,X0,A 
 P:0072 MOVE  #>$000300,N3
 P:0074 ADD A,B 
 P:0075 MOVE  X:(R3+N3),X0
 P:0076 MPY +X1,X0,A 
 P:0077 ADD A,B 
 P:0078 MOVE  B,X:<$15
 P:0079 MOVE  B,X:(R3)
 P:007A CLR A 
 P:007B CLR B 
 P:007C MOVE  X:<$14,X0
 P:007D MPY +Y0,X0,B 
 P:007E MOVE  Y:(R3),X0
 P:007F MPY +X0,Y1,A 
 P:0080 MOVE  #>$000200,N3
 P:0082 ADD A,B 
 P:0083 MOVE  Y:(R3+N3),X0
 P:0084 MPY +X1,X0,A 
 P:0085 MOVE  #>$000300,N3
 P:0087 ADD A,B 
 P:0088 MOVE  Y:(R3+N3),X0
 P:0089 MPY +X1,X0,A 
 P:008A ADD A,B 
 P:008B MOVE  B,X:<$16
 P:008C MOVE  B,Y:(R3)
 P:008D BCLR #$00,X:<$1B
 P:008E MOVE  (R3)+
 P:008F JMP <$005F
 P:0090 BSET #$00,X:<$1B
 P:0091 MOVE  X0,X:<$17
 P:0092 MOVE  X1,X:<$18
 P:0093 JCLR #$00,X:<$19,$009B
 P:0095 MOVEP X:<<$FFEF,X1
 P:0096 MOVE  X1,X:<$14
 P:0097 BCLR #$00,X:<$19
 P:0098 MOVE  X:<$17,X0
 P:0099 MOVE  X:<$18,X1
 P:009A RTI 
 P:009B MOVEP X:<<$FFEF,X0
 P:009C MOVE  X0,X:<$13
 P:009D BSET #$00,X:<$19
 P:009E MOVE  X:<$17,X0
 P:009F MOVE  X:<$18,X1
 P:00A0 RTI 
 P:00A1 MOVE  X0,X:<$17
 P:00A2 MOVE  X1,X:<$18
 P:00A3 JCLR #$00,X:<$1A,$00AB
 P:00A5 MOVE  X:<$16,X1
 P:00A6 MOVEP X1,X:<<$FFEF
 P:00A7 BCLR #$00,X:<$1A
 P:00A8 MOVE  X:<$17,X0
 P:00A9 MOVE  X:<$18,X1
 P:00AA RTI 
 P:00AB MOVE  X:<$15,X0
 P:00AC MOVEP X0,X:<<$FFEF
 P:00AD BSET #$00,X:<$1A
 P:00AE MOVE  X:<$17,X0
 P:00AF MOVE  X:<$18,X1
 P:00B0 RTI 
