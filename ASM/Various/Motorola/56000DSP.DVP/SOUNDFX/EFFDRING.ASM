  ORG       Y:$0000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  ORG       P:$0000
 P:0000 JMP $0055
  ORG       P:$000C
 P:000C JSR <$0040
  ORG       P:$000E
 P:000E JSR <$0046
  ORG       P:$0010
 P:0010 JSR <$0047
  ORG       P:$0012
 P:0012 JSR <$004D
  ORG       P:$0020
 P:0020 JSR <$004E
  ORG       P:$0026
 P:0026 JSR <$0050
  ORG       P:$0028
 P:0028 JSR <$0052
  ORG       P:$0040
 P:0040 JCLR #$03,X:<<$FFEE,$0044
 P:0042 MOVE  #$00,R4
 P:0043 NOP 
 P:0044 MOVEP X:<<$FFEF,Y:(R4)+
 P:0045 RTI 
 P:0046 JMP <$0040
 P:0047 JCLR #$02,X:<<$FFEE,$004B
 P:0049 MOVE  #$03,R1
 P:004A NOP 
 P:004B MOVEP Y:(R1)+,X:<<$FFEF
 P:004C RTI 
 P:004D JMP <$0047
 P:004E MOVEP X:<<$FFEB,X:(R3)+
 P:004F RTI 
 P:0050 MOVE  #$00,R3
 P:0051 RTI 
 P:0052 JSR $0082
 P:0054 RTI 
 P:0055 ORI #$03,MR
 P:0056 MOVEP #>$000000,X:<<$FFFE
 P:0058 MOVEP #>$003800,X:<<$FFFF
 P:005A MOVEP #>$000001,X:<<$FFE0
 P:005C MOVEP #>$000005,X:<<$FFE8
 P:005E MOVE  #$00,R3
 P:005F MOVEC #<03,M3
 P:0060 MOVE  #$00,R4
 P:0061 MOVEC #<01,M4
 P:0062 MOVE  #$02,R1
 P:0063 MOVEC #<01,M1
 P:0064 MOVEP #>$004100,X:<<$FFEC
 P:0066 MOVEP #>$0001F8,X:<<$FFE1
 P:0068 BTST #$04,X:<<$FFEE
 P:0069 MOVEP X:(R1)+,X:<<$FFEF
 P:006A MOVEP #>$00F800,X:<<$FFED
 P:006C ORI #$04,OMR
 P:006D ANDI #$F0,MR
 P:006E JSR $0082
 P:0070 MOVE  #$00,B
 P:0071 MOVE  R4,A
 P:0072 CMP B,A 
 P:0073 JNE <$0071
 P:0074 MOVE  R4,A
 P:0075 CMP B,A 
 P:0076 JEQ <$0074
 P:0077 MOVE  Y:<$00,X0
 P:0078 MOVE  X0,Y:<$04
 P:0079 MOVE  Y:<$01,X0
 P:007A MOVE  X0,Y:<$05
 P:007B JSR $009C
 P:007D MOVE  Y:<$06,X0
 P:007E MOVE  X0,Y:<$02
 P:007F MOVE  Y:<$07,X0
 P:0080 MOVE  X0,Y:<$03
 P:0081 JMP <$0070
 P:0082 JSR $0093
 P:0084 MOVE  #$00,A
 P:0085 MOVEC #>$00FFFF,M2
 P:0087 MOVEC #>$00FFFF,M6
 P:0089 DO X0,$008C
 P:008B MOVE  A,X:(R2)+
 P:008C NOP 
 P:008D NOP 
 P:008E NOP 
 P:008F DO Y0,$0092
 P:0091 MOVE  A,Y:(R6)+
 P:0092 RTI 
  ORG       X:$0000
  DC $2CCCCD
  DC $008312
  DC $000000
  DC $000000
  ORG       X:$0040
  DC $533333
  DC $001000
  DC $000000
  DC $000000
  DC $000000
  ORG       P:$0093
 P:0093 MOVE  #>$001000,R2
 P:0095 MOVE  #>$000001,X0
 P:0097 MOVE  #>$001000,R6
 P:0099 MOVE  #>$000001,Y0
 P:009B RTS 
 P:009C MOVE  #>$7FDF3B,A
 P:009E MOVE  X:<$00,B
 P:009F SUB B,A 
 P:00A0 MOVE  A,X:$0040
 P:00A2 MOVE  X:$0042,A
 P:00A4 MOVE  X:<$01,X0
 P:00A5 ADD X0,A 
 P:00A6 MOVE  #$01,A2
 P:00A7 MOVE  A1,X:$0042
 P:00A9 REP #$010
 P:00AA ASR A 
 P:00AB MOVE  A1,R5
 P:00AC MOVE  X:$0043,B
 P:00AE MOVE  Y:<$04,A
 P:00AF MOVE  A,X:$0043
 P:00B1 SUB B,A Y:(R5),X0
 P:00B2 MOVE  A,X1
 P:00B3 MPYR +X1,X0,A 
 P:00B4 MOVE  A,Y0
 P:00B5 MOVE  X:<$00,Y1
 P:00B6 MPYR +Y1,Y0,A X:$0040,Y0
 P:00B8 MOVE  Y:<$04,Y1
 P:00B9 MACR +Y1,Y0,A 
 P:00BA MOVE  A,Y:<$06
 P:00BB MOVE  X:$0044,B
 P:00BD MOVE  Y:<$05,A
 P:00BE MOVE  A,X:$0044
 P:00C0 SUB B,A Y:(R5),X0
 P:00C1 MOVE  A,X1
 P:00C2 MPYR +X1,X0,A 
 P:00C3 MOVE  A,Y0
 P:00C4 MOVE  X:<$00,Y1
 P:00C5 MPYR +Y1,Y0,A X:$0040,Y0
 P:00C7 MOVE  Y:<$05,Y1
 P:00C8 MACR +Y1,Y0,A 
 P:00C9 MOVE  A,Y:<$07
 P:00CA RTS 
