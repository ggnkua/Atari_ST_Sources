  ORG       Y:$000E
  DC $000001
  ORG       X:$0020
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000000
  DC $000000
  DC $000000
  ORG       P:$0000
 P:0000 JMP $0200
  ORG       P:$000C
 P:000C JSR $0281
  ORG       P:$000E
 P:000E MOVEP X:<<$FFEE,A
 P:000F JSR $0281
  ORG       P:$0010
 P:0010 JSR $0292
  ORG       P:$0012
 P:0012 MOVEP X:<<$FFEE,A
 P:0013 JSR $0292
  ORG       P:$0200
 P:0200 MOVEP X:<<$FFEB,X0
 P:0201 MOVEC #<00,SP
 P:0202 MOVEP #>$004100,X:<<$FFEC
 P:0204 MOVEP #>$0001F8,X:<<$FFE1
 P:0206 BTST #$04,X:<<$FFEE
 P:0207 MOVEP #>$00F800,X:<<$FFED
 P:0209 MOVEP #>$000000,X:<<$FFFE
 P:020B MOVEP #>$003000,X:<<$FFFF
 P:020D MOVEP #>$000001,X:<<$FFE0
 P:020F ANDI #$FC,MR
 P:0210 JSR $026F
 P:0212 MOVE  #$0E,R3
 P:0213 JCLR #$00,X:<<$FFE9,$0219
 P:0215 MOVEP X:<<$FFEB,N3
 P:0216 JCLR #$00,X:<<$FFE9,$0216
 P:0218 MOVEP X:<<$FFEB,Y:(R3+N3)
 P:0219 JCLR #$00,X:<$28,$0213
 P:021B MOVE  X:<$20,X0
 P:021C MOVE  X0,X:<$00
 P:021D MOVE  X:<$21,X0
 P:021E MOVE  X0,X:<$01
 P:021F JSR $0227
 P:0221 MOVE  X:<$00,X0
 P:0222 MOVE  X0,X:<$22
 P:0223 MOVE  X:<$01,X0
 P:0224 MOVE  X0,X:<$23
 P:0225 BCLR #$00,X:<$28
 P:0226 JMP <$0213
 P:0227 MOVE  X:<$00,X0
 P:0228 MOVE  X0,X:(R2)
 P:0229 MOVE  X:<$01,X0
 P:022A MOVE  X0,Y:(R2)+
 P:022B MOVE  X:<$0E,B
 P:022C MOVE  Y:<$0E,A
 P:022D MOVE  #>$0003E8,Y1
 P:022F CMP Y1,A 
 P:0230 JLT $0238
 P:0232 MOVE  #>$0007D0,Y1
 P:0234 SUB Y1,A 
 P:0235 NEG A 
 P:0236 JMP $0244
 P:0238 MOVE  A,Y0
 P:0239 SUB Y0,B #>$0003E9,Y1
 P:023B JGT $023E
 P:023D ADD Y1,B X:(R6)+,X0
 P:023E MOVE  #$01,X0
 P:023F MOVE  B,X:<$0E
 P:0240 MOVE  R6,B
 P:0241 MOVE  R2,X1
 P:0242 JMP $024F
 P:0244 MOVE  A,Y0
 P:0245 SUB Y0,B #>$0007D2,Y1
 P:0247 JLT $024B
 P:0249 MOVE  (R6)+
 P:024A JMP <$0244
 P:024B ADD Y1,B #$01,X0
 P:024C MOVE  B,X:<$0E
 P:024D MOVE  R2,B
 P:024E MOVE  R6,X1
 P:024F SUB X1,B #>$00003F,Y0
 P:0251 JLE $0266
 P:0253 JSET #$00,X:<$0F,$0259
 P:0255 CMP Y0,B 
 P:0256 JGT $026A
 P:0258 BSET #$00,X:<$0F
 P:0259 MOVE  #>$800000,X1 B,Y0
 P:025B MPY +Y0,X0,B 
 P:025C MOVE  B0,B1
 P:025D ADD X1,B B1,X0
 P:025E NEG B X:(R6),X1
 P:025F MPY +X1,X0,A X:(R6+N6),X1
 P:0260 MOVE  B,Y0
 P:0261 MACR +X1,Y0,A Y:(R6),X1
 P:0262 MPY +X1,X0,B Y:(R6+N6),X1
 P:0263 MACR +X1,Y0,B A,X:<$00
 P:0264 MOVE  B,X:<$01
 P:0265 RTS 
 P:0266 JCLR #$00,X:<$0F,$026A
 P:0268 MOVE  (R6)+N6
 P:0269 BCLR #$00,X:<$0F
 P:026A MOVE  X:(R6),X0
 P:026B MOVE  X0,X:<$00
 P:026C MOVE  Y:(R6),Y0
 P:026D MOVE  Y0,X:<$01
 P:026E RTS 
 P:026F MOVE  #>$000400,R6
 P:0271 MOVE  #>$000200,N6
 P:0273 MOVEC #>$0003FF,M6
 P:0275 MOVE  #>$000400,R2
 P:0277 MOVEC #>$0003FF,M2
 P:0279 MOVE  #>$0003E9,Y0
 P:027B MOVE  Y0,X:<$0E
 P:027C MOVE  #>$0003E8,Y0
 P:027E MOVE  Y0,Y:<$0E
 P:027F BCLR #$00,X:<$0F
 P:0280 RTS 
 P:0281 MOVE  X0,X:<$24
 P:0282 MOVE  X1,X:<$25
 P:0283 JCLR #$00,X:<$26,$028C
 P:0285 MOVEP X:<<$FFEF,X1
 P:0286 MOVE  X1,X:<$21
 P:0287 BCLR #$00,X:<$26
 P:0288 MOVE  X:<$24,X0
 P:0289 MOVE  X:<$25,X1
 P:028A BSET #$00,X:<$28
 P:028B RTI 
 P:028C MOVEP X:<<$FFEF,X0
 P:028D MOVE  X0,X:<$20
 P:028E BSET #$00,X:<$26
 P:028F MOVE  X:<$24,X0
 P:0290 MOVE  X:<$25,X1
 P:0291 RTI 
 P:0292 MOVE  X0,X:<$24
 P:0293 MOVE  X1,X:<$25
 P:0294 JCLR #$00,X:<$27,$029C
 P:0296 MOVE  X:<$23,X1
 P:0297 MOVEP X1,X:<<$FFEF
 P:0298 BCLR #$00,X:<$27
 P:0299 MOVE  X:<$24,X0
 P:029A MOVE  X:<$25,X1
 P:029B RTI 
 P:029C MOVE  X:<$22,X0
 P:029D MOVEP X0,X:<<$FFEF
 P:029E BSET #$00,X:<$27
 P:029F MOVE  X:<$24,X0
 P:02A0 MOVE  X:<$25,X1
 P:02A1 RTI 
