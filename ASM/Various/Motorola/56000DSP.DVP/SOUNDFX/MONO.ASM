  ORG       P:$00E0
 P:00E0 MOVE  X:<$00,X0
 P:00E1 MOVE  X:<$01,A
 P:00E2 ADD X0,A 
 P:00E3 MOVE  A,X:<$00
 P:00E4 MOVE  A,X:<$01
 P:00E5 RTS 
 P:00E6 MOVE  L:<$00,A10
  ORG       P:$0370
 P:0370 JSET #$0C,Y:<$01,$0376
 P:0372 JSET #$04,Y:<$00,$0376
 P:0374 BSET #$04,Y:<$00
 P:0375 RTS 
 P:0376 BCLR #$04,Y:<$00
 P:0377 RTS 
 P:0378 MOVE  L:<$00,A10
 P:0379 CLR B 
 P:037A MOVE  B,Y:<$01
 P:037B RTS 
 P:037C MOVE  L:<$00,A10
