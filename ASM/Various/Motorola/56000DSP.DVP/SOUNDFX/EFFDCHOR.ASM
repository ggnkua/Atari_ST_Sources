	ORG	Y:$0000
	DC	$000000
	DC	$000000
	DC	$000000
	DC	$000000
	DC	$000000
	DC	$000000
	DC	$000000
	DC	$000000
	ORG	P:$0000
P:0000	JMP	$0055
	ORG	P:$000C
P:000C	JSR	<$0040
	ORG	P:$000E
P:000E	JSR	<$0046
	ORG	P:$0010
P:0010	JSR	<$0047
	ORG	P:$0012
P:0012	JSR	<$004D
	ORG	P:$0020
P:0020	JSR	<$004E
	ORG	P:$0026
P:0026	JSR	<$0050
	ORG	P:$0028
P:0028	JSR	<$0052
	ORG	P:$0040
P:0040	JCLR	#$03,X:<<$FFEE,$0044
P:0042	MOVE	#$00,R4
P:0043	NOP
P:0044	MOVEP	X:<<$FFEF,Y:(R4)+
P:0045	RTI
P:0046	JMP	<$0040
P:0047	JCLR	#$02,X:<<$FFEE,$004B
P:0049	MOVE	#$03,R1
P:004A	NOP
P:004B	MOVEP	Y:(R1)+,X:<<$FFEF
P:004C	RTI
P:004D	JMP	<$0047
P:004E	MOVEP	X:<<$FFEB,X:(R3)+
P:004F	RTI
P:0050	MOVE	#$00,R3
P:0051	RTI
P:0052	JSR	$0082
P:0054	RTI
P:0055	ORI	#$03,MR
P:0056	MOVEP	#>$000000,X:<<$FFFE
P:0058	MOVEP	#>$003800,X:<<$FFFF
P:005A	MOVEP	#>$000001,X:<<$FFE0
P:005C	MOVEP	#>$000005,X:<<$FFE8
P:005E	MOVE	#$00,R3
P:005F	MOVEC	#<03,M3
P:0060	MOVE	#$00,R4
P:0061	MOVEC	#<01,M4
P:0062	MOVE	#$02,R1
P:0063	MOVEC	#<01,M1
P:0064	MOVEP	#>$004100,X:<<$FFEC
P:0066	MOVEP	#>$0001F8,X:<<$FFE1
P:0068	BTST	#$04,X:<<$FFEE
P:0069	MOVEP	X:(R1)+,X:<<$FFEF
P:006A	MOVEP	#>$00F800,X:<<$FFED
P:006C	ORI	#$04,OMR
P:006D	ANDI	#$F0,MR
P:006E	JSR	$0082
P:0070	MOVE	#$00,B
P:0071	MOVE	R4,A
P:0072	CMP	B,A
P:0073	JNE	<$0071
P:0074	MOVE	R4,A
P:0075	CMP	B,A
P:0076	JEQ	<$0074
P:0077	MOVE	Y:<$00,X0
P:0078	MOVE	X0,Y:<$04
P:0079	MOVE	Y:<$01,X0
P:007A	MOVE	X0,Y:<$05
P:007B	JSR	$00A6
P:007D	MOVE	Y:<$06,X0
P:007E	MOVE	X0,Y:<$02
P:007F	MOVE	Y:<$07,X0
P:0080	MOVE	X0,Y:<$03
P:0081	JMP	<$0070
P:0082	JSR	$0093
P:0084	MOVE	#$00,A
P:0085	MOVEC	#>$00FFFF,M2
P:0087	MOVEC	#>$00FFFF,M6
P:0089	DO	X0,$008C
P:008B	MOVE	A,X:(R2)+
P:008C	NOP
P:008D	NOP
P:008E	NOP
P:008F	DO	Y0,$0092
P:0091	MOVE	A,Y:(R6)+
P:0092	RTI
	ORG	X:$0000
	DC	$333333
	DC	$000032
	DC	$000D1B
	DC	$00012C
	RG	X:$0040
	DC	$000000
	DC	$4CCCCD
	DC	$FFFFFE
	ORG	P:$0093
P:0093	MOVE	#>$002000,R0
P:0095	MOVE	#>$002000,R7
P:0097	MOVEC	#>$001FFF,M0
P:0099	MOVEC	#>$001FFF,M7
P:009B	MOVE	#>$000600,N7
P:009D	MOVE	#>$001000,R2
P:009F	MOVE	#>$000001,X0
P:00A1	MOVE	#>$002000,R6
P:00A3	MOVE	#>$002000,Y0
P:00A5	RTS
P:00A6	MOVE	#>$7FDF3B,A
P:00A8	MOVE	X:<$00,B
P:00A9	SUB	B,A
P:00AA	MOVE	A,X:$0041
P:00AC	MOVE	X:$0040,A
P:00AE	MOVE	X:<$02,X0
P:00AF	ADD	X0,A
P:00B0	MOVE	#$01,A2
P:00B1	MOVE	A1,X:$0040
P:00B3	REP	#$010
P:00B4	ASR	A
P:00B5	MOVE	A1,R2
P:00B6	MOVE	X:<$01,X1
P:00B7	MOVE	Y:(R2),X0
P:00B8	MPYR	-X1,X0,A
P:00B9	MOVE	X:<$03,B
P:00BA	SUB	B,A	X:$0042,X0
P:00BC	AND	X0,A
P:00BD	MOVE	A,N7
P:00BE	NOP
P:00BF	MOVE	Y:(R7+N7),X0
P:00C0	MOVE	X:<$00,X1
P:00C1	MPYR	+X1,X0,A
P:00C2	MOVE	Y:<$04,X0
P:00C3	MOVE	X0,Y:(R0)+
P:00C4	MOVE	X:$0041,X1
P:00C6	MACR	+X1,X0,A	(R7)+
P:00C7	MOVE	A,Y:<$06
P:00C8	MOVE	Y:(R7+N7),X0
P:00C9	MOVE	X:<$00,X1
P:00CA	MPYR	+X1,X0,A
P:00CB	MOVE	Y:<$05,X0
P:00CC	MOVE	X0,Y:(R0)+
P:00CD	MOVE	X:$0041,X1
P:00CF	MACR	+X1,X0,A	(R7)+
P:00D0	MOVE	A,Y:<$07
P:00D1	RTS
