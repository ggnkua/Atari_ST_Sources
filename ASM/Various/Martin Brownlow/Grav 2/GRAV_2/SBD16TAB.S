*	SBD16TAB.S
* data for baddies that's not supplied in
* level description.

* there are 2 lines per "bad guy"
* 1st line (dc.w):
*		xmin ( collision displacement )
*		xmax
*		ymin
*		ymax
*		firex ( fire from displacement )
*		firey
*		type (*4)
* 2nd line (dc.b):
*		score
*		explosion size
*		no explosion points -1
*		value ( credits for destryoing )
*		fire direction
*		no lines to print -1 ( height of sprite -1 )


	dc.w	0,14,-1,8,7,-2,0		*pyramid
	dc.b	5,0,5,0,0,8
	dc.w	6,15,-1,13,5,6,0
	dc.b	5,0,5,0,12,13
	dc.w	0,14,-1,8,7,9,0
	dc.b	5,0,5,0,8,8
	dc.w	-1,8,-1,13,9,6,0
	dc.b	5,0,5,0,4,13
	dc.w	0,14,-1,10,0,0,8		*spherical
	dc.b	100,1,10,4,0,10
	dc.w	0,14,-1,10,0,0,8
	dc.b	100,1,10,4,0,10
	dc.w	0,14,0,10,0,0,8
	dc.b	100,1,10,4,0,10
	dc.w	0,14,0,10,0,0,8
	dc.b	100,1,10,4,0,10
	dc.w	0,14,2,10,0,0,8
	dc.b	100,1,10,4,0,10
	dc.w	0,14,4,10,0,0,8
	dc.b	100,1,10,4,0,10
	
	dc.w	0,14,3,10,7,2,8
	dc.b	100,1,10,4,0,10
	dc.w	-1,15,3,15,0,0,4		*fuel dump
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,2,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,0,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,1,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,-1,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,1,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,0,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,0,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,0,15,0,0,4
	dc.b	10,1,15,1,0,15
	
	dc.w	-1,15,1,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,0,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,0,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,1,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,2,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	-1,15,1,15,0,0,4
	dc.b	10,1,15,1,0,15
	dc.w	0,14,-1,12,0,0,12		*Attractor
	dc.b	50,0,10,2,0,12
	dc.w	0,14,-1,12,0,0,12
	dc.b	50,0,10,2,0,12
	dc.w	0,14,-1,12,0,0,12
	dc.b	50,0,10,2,0,12
	dc.w	0,14,-1,12,0,0,12
	dc.b	50,0,10,2,0,12

	dc.w	0,14,-1,12,0,0,20		*Repulsor
	dc.b	50,0,10,2,0,12
	dc.w	0,14,-1,12,0,0,20
	dc.b	50,0,10,2,0,12
	dc.w	0,14,-1,12,0,0,20
	dc.b	50,0,10,2,0,12
	dc.w	0,14,-1,12,0,0,20
	dc.b	50,0,10,2,0,12
	dc.w	0,14,-1,10,7,9,0		*Bomb dropper
	dc.b	15,0,15,1,8,10	
	dc.w	-1,15,0,14,0,0,16		*Door (left)
	dc.b	50,1,9,2,0,15
	dc.w	-1,13,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	-1,11,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	-1,9,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	-1,7,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	
	dc.w	-1,5,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	-1,3,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	-1,1,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	-1,15,0,14,0,0,16		*Door (right)
	dc.b	50,1,9,2,0,15
	dc.w	1,15,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	3,15,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	5,15,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	7,15,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	9,15,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	11,15,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	
	dc.w	13,15,0,14,0,0,16
	dc.b	50,1,9,2,0,15
	dc.w	-4,-4,4,4,0,0,16		*Door fully open
	dc.b	0,0,0,0,0,0
	dc.w	1,13,-1,11,0,0,24		*Steering thingy
	dc.b	50,1,10,2,0,11
	dc.w	1,13,-1,11,0,0,24
	dc.b	50,1,10,2,0,11
	dc.w	1,13,-1,11,0,0,24
	dc.b	50,1,10,2,0,11
	dc.w	1,13,-1,11,0,0,24
	dc.b	50,1,10,2,0,11
	dc.w	1,13,-1,15,0,0,24
	dc.b	50,1,10,2,0,15
	dc.w	1,13,-1,15,0,0,24
	dc.b	50,1,10,2,0,15
	dc.w	1,13,-1,15,0,0,24
	dc.b	50,1,10,2,0,15
	dc.w	1,13,-1,15,0,0,24
	dc.b	50,1,10,2,0,15

	dc.w	1,13,-1,11,0,0,24
	dc.b	50,1,10,2,0,11
	dc.w	1,13,-1,11,0,0,24
	dc.b	50,1,10,2,0,11
	dc.w	1,13,-1,11,0,0,24
	dc.b	50,1,10,2,0,11
	dc.w	1,13,-1,11,0,0,24
	dc.b	50,1,10,2,0,11
	dc.w	-1,7,0,7,0,0,28		*ff generator
	dc.b	15,0,5,1,0,7
	dc.w	-1,7,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	-1,7,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	-1,7,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	7,15,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	-1,7,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	-1,7,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	-1,7,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	dc.w	-1,7,0,7,0,0,28
	dc.b	15,0,5,1,0,7
	
	dc.w	1,14,-1,9,0,0,32	*Ammo dump
	dc.b	10,1,15,1,0,9
	dc.w	1,14,-1,9,0,0,32
	dc.b	10,1,15,1,0,9
	dc.w	1,14,-1,9,0,0,32
	dc.b	10,1,15,1,0,9
	dc.w	1,14,-1,9,0,0,32
	dc.b	10,1,15,1,0,9
	dc.w	1,13,-1,6,0,0,36	*Computer
	dc.b	5,0,5,2,0,6
	dc.w	1,13,-1,6,0,0,36
	dc.b	5,0,5,2,0,6
	dc.w	1,13,-1,6,0,0,36
	dc.b	5,0,5,2,0,6
	dc.w	1,13,-1,6,0,0,36
	dc.b	5,0,5,2,0,6
	dc.w	1,13,-1,6,0,0,36
	dc.b	5,0,5,2,0,6
	dc.w	1,13,-1,6,0,0,36
	dc.b	5,0,5,2,0,6

	dc.w	0,14,2,13,-1,2,40	* Aimy thing
	dc.b	10,0,5,0,13,13
	dc.w	0,14,0,13,0,-1,40
	dc.b	10,0,5,0,14,13
	dc.w	0,14,-1,13,4,-2,40
	dc.b	10,0,5,0,15,13
	dc.w	0,14,-1,13,7,-2,40
	dc.b	10,0,5,0,0,13
	dc.w	0,14,-1,13,10,-2,40
	dc.b	10,0,5,0,1,13
	dc.w	0,14,0,13,14,-1,40
	dc.b	10,0,5,0,2,13
	dc.w	0,14,2,13,15,2,40
	dc.b	10,0,5,0,3,13
	dc.w	-1,15,-1,11,0,0,44	* Conveyor
	dc.b	5,0,5,0,0,11
	dc.w	-1,15,-1,11,0,0,44
	dc.b	5,0,5,0,0,11
	dc.w	-1,15,-1,11,0,0,44
	dc.b	5,0,5,0,0,11

	dc.w	-1,15,-1,11,0,0,44
	dc.b	5,0,5,0,0,11
	dc.w	0,14,-1,8,0,0,48	* Container
	dc.b	15,1,15,1,0,8
	dc.w	-1,14,-1,9,0,0,44	* Drill
	dc.b	10,0,5,1,0,13
	dc.w	-1,14,-1,9,0,0,44
	dc.b	10,0,5,1,0,13
	dc.w	-1,14,-1,9,0,0,44
	dc.b	10,0,5,1,0,13
	dc.w	-1,15,-1,13,0,0,44	* Work thingy
	dc.b	10,0,5,2,0,13
	dc.w	-1,15,-1,9,0,0,44	* Work thingy
	dc.b	5,0,5,0,0,9
	dc.w	-1,15,-1,31,0,0,44	* Tower
	dc.b	25,1,15,4,0,31
	dc.w	-1,15,-1,31,0,0,44
	dc.b	25,1,15,4,0,31
	dc.w	5,15,-1,15,4,16,40	* "Gun 1"
	dc.b	10,1,15,2,10,15
	
	dc.w	5,15,-1,15,4,16,40
	dc.b	10,1,15,2,10,15
	dc.w	5,15,-1,15,4,16,40
	dc.b	10,1,15,2,10,15
	dc.w	5,15,-1,15,4,16,40
	dc.b	10,1,15,2,10,15
	dc.w	5,15,-1,15,4,16,40
	dc.b	10,1,15,2,10,15
	dc.w	-1,15,-1,15,0,0,52	* "booster 1"
	dc.b	25,1,15,2,0,15	
	dc.w	4,15,-1,15,2,7,0	* "Gun 2"
	dc.b	10,1,15,2,12,15
	dc.w	7,15,-1,15,7,7,0
	dc.b	25,1,15,2,12,15
	dc.w	-1,15,-1,15,0,0,56	* Reactor
	dc.b	50,2,0,5,0,15
	dc.w	-1,15,-1,15,0,0,56
	dc.b	50,2,0,5,0,15
	dc.w	-1,15,-1,15,0,0,56
	dc.b	50,2,0,5,0,15
	
	dc.w	-1,15,-1,15,0,0,56
	dc.b	50,2,0,5,0,15
	dc.w	-1,15,-1,15,-1,-1,52	* "booster 2"
	dc.b	25,1,15,2,0,15
	dc.w	5,15,3,15,5,16,40	* "Gun 3"
	dc.b	10,0,5,1,9,15
	dc.w	3,15,3,13,2,13,40
	dc.b	10,0,5,1,10,15
	dc.w	2,15,3,11,1,11,40
	dc.b	10,0,5,1,11,15
	dc.w	1,15,3,11,0,7,40
	dc.b	10,0,5,1,12,15
	dc.w	2,15,3,11,1,2,40
	dc.b	10,0,5,1,13,15
	dc.w	3,15,1,11,2,0,40
	dc.b	10,0,5,1,14,15
	dc.w	5,15,-1,11,4,-2,40
	dc.b	10,0,5,1,15,15
	dc.w	-1,9,-1,11,9,-2,40	* "Gun 4"
	dc.b	10,0,5,1,1,15
	
	dc.w	-1,11,2,11,12,0,40
	dc.b	10,0,5,1,2,15
	dc.w	-1,12,3,11,13,3,40
	dc.b	10,0,5,1,3,15
	dc.w	-1,13,3,11,14,7,40
	dc.b	10,0,5,1,4,15
	dc.w	-1,12,3,11,13,11,40
	dc.b	10,0,5,1,5,15
	dc.w	-1,11,3,13,12,14,40
	dc.b	10,0,5,1,6,15
	dc.w	-1,9,3,15,9,16,40
	dc.b	10,0,5,1,7,15
	dc.w	-1,15,-1,15,0,0,20	* Repulse
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,20
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,20
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,20
	dc.b	0,0,0,0,0,15
	
	dc.w	-1,15,-1,15,0,0,20
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,20
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,20
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,20
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,12	* Attract
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,12
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,12
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,12
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,12
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,12
	dc.b	0,0,0,0,0,15
	
	dc.w	-1,15,-1,15,0,0,12
	dc.b	0,0,0,0,0,15
	dc.w	-1,15,-1,15,0,0,12
	dc.b	0,0,0,0,0,15
	dc.w	2,12,-1,15,0,0,44	* Door
	dc.b	5,0,5,0,0,15
	dc.w	2,12,-1,15,0,0,44
	dc.b	5,0,5,0,0,15
		