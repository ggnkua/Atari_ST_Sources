/* Resource Datei Indizes f�r HALL */

#define FORM1    0   /* Formular/Dialog */
#define P_M      1   /* BOX in Baum FORM1 */
#define PS_M     2   /* BOX in Baum FORM1 */
#define V_M      4   /* BOX in Baum FORM1 */
#define VS_M     5   /* BOX in Baum FORM1 */
#define L_BUTT_M 6   /* BOXTEXT in Baum FORM1 */
#define UNLOCK_M 7   /* ICON in Baum FORM1 */
#define AMPL_M   8   /* BOX in Baum FORM1 */
#define AMPLS_M  9   /* BOX in Baum FORM1 */
#define TEXT     11  /* TEXT in Baum FORM1 */
#define SELECHO  12  /* BOXTEXT in Baum FORM1 */
#define SOLO     13  /* BOXTEXT in Baum FORM1 */
#define DB_M     14  /* IBOX in Baum FORM1 */
