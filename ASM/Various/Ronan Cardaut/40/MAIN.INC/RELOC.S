Reloc
	MOVE.L	2(A0),D0
	ADD.L	6(A0),D0
	ADD.L	14(A0),D0
	LEA	$1C(A0),A0
	MOVE.L	A0,A1
	MOVE.L	A0,A2
	MOVE.L	A0,D1
	ADD.L	D0,A1
	MOVE.L	(A1)+,D0
	tst.b	d0
	beq.s	FIN_RELOC
	ADD.L	D0,A2
	ADD.L	D1,(A2)
	MOVEQ.L	#0,D0
BOUCLE
	MOVE.B	(A1),D0
	CLR.B	(A1)+
	TST.B	D0
	BEQ.S	FIN_RELOC
	CMP.B	#1,D0
	BEQ.S	SPECIAL_BRANCH
	ADD.L	D0,A2
	ADD.L	D1,(A2)
	BRA.S	BOUCLE
 
SPECIAL_BRANCH
	LEA	$FE(A2),A2
	BRA.S	BOUCLE
FIN_RELOC
	RTS	
