;**********************************************************
;*** AVEC PARALLEL MOVE                             *******
;**********************************************************

MULTIPLY
	DW	0,0,%10000000
	DW	0,0,%10000000
	dc.b	'M       '
	dc.l	MUL	
	DW	0,0,$ff
	DW	0,0,0
	dc.b	'MOVE    '
	dc.l	NULL
	DW	0,0,%11110111
	DW	0,0,%00010011
	dc.b	'CLR     '
	dc.l	D	
	DW	0,0,%10000111
	DW	0,0,%00000111
	dc.b	'CMPM    '	
	dc.l	JD
	DW	0,0,%11110111
	DW	0,0,%00110110
	dc.b	'NEG     '
	dc.l	D		;;;
	DW	0,0,%10000111
	DW	0,0,%00000110
	dc.b	'AND     '	
	dc.l	JD
	DW	0,0,%10000111
	DW	0,0,%00000101
	dc.b	'CMP     '	
	dc.l	JD
	DW	0,0,%10000111
	DW	0,0,%00000100
	dc.b	'SUB     '	
	dc.l	JD
	DW	0,0,%11110111
	DW	0,0,%00000011
	dc.b	'TST     '
	dc.l	D	
	DW	0,0,%10000111
	DW	0,0,%00000011
	dc.b	'EOR     '	
	dc.l	JD
	DW	0,0,%11000111
	DW	0,0,%01000010
	dc.b	'OR      '	
	dc.l	JD
	DW	0,0,%10000111
	DW	0,0,%00000001
	dc.b	'TFR     '	
	dc.l	JD
	DW	0,0,%10000111
	DW	0,0,%00000000
	dc.b	'ADD     '	
	dc.l	JD
	DW	0,0,%11100111
	DW	0,0,%00100101
	dc.b	'SBC     '	
	dc.l	JD
	DW	0,0,%11100111
	DW	0,0,%00100001
	dc.b	'ADC     '	
	dc.l	JD
	
	DW	0,0,%11110111
	DW	0,0,%00110111
	dc.b	'ROL     '
	dc.l	D	

	DW	0,0,%11110111
	DW	0,0,%00110011
	dc.b	'LSL     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00110010
	dc.b	'ASL     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00100111
	dc.b	'ROR     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00100110
	dc.b	'ABS     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00100011
	dc.b	'LSR     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00100010
	dc.b	'ASR     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00010111
	dc.b	'NOT     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00010110
	dc.b	'SUBL    '
	dc.l	D_inv_D
	DW	0,0,%11110111
	DW	0,0,%00010110
	dc.b	'ADDL    '
	dc.l	D_inv_D
	DW	0,0,%11110111
	DW	0,0,%00010001
	dc.b	'RND     '
	dc.l	D	
	DW	0,0,%11110111
	DW	0,0,%00000110
	dc.b	'SUBR    '
	dc.l	D_inv_D
	DW	0,0,%11110111
	DW	0,0,%00000010
	dc.b	'ADDR    '
	dc.l	D_inv_D
	DW	0,0,0
	DW	0,0,0
	DC.B	'ILLEGAL '
	DC.L	NULL
END_MULT


LIST_PAR
	DW	$ff,$ff,0
	DW	%00100000,0,0
	dc.l	P_NOP
	DW	%10000000,0,0
	DW	%10000000,0,0
	dc.l	P_XY
	DW	%11001000,%01000000,0
	DW	%01000000,%01000000,0
	dc.l	P_X
	DW	%11001000,%01000000,0
	DW	%01000000,%00000000,0
	dc.l	P_Xaa
	DW	%11001000,%01000000,0
	DW	%01001000,%01000000,0
	dc.l	P_Y
	DW	%11001000,%01000000,0
	DW	%01001000,%00000000,0
	dc.l	P_Yaa
	DW	%11110100,%01000000,0
	DW	%01000000,%01000000,0
	dc.l	P_L	
	DW	%11110100,%01000000,0
	DW	%01000000,%00000000,0
	dc.l	P_Laa
	DW	%11111111,%11100000,0
	DW	%00100000,%01000000,0
	dc.l	P_U
	DW	%11111100,0,0
	DW	%00100000,0,0
	dc.l	P_R
	DW	%11110000,%01000000,0
	DW	%00010000,%01000000,0
	dc.l	P_RYI
	DW	$fe,%11000000,0
	DW	%00001000,%10000000,0
	dc.l	P_RYII
	DW	%11110000,%01000000,0
	DW	%00010000,%00000000,0
	dc.l	P_XRI
	DW	%11111110,%11000000,0
	DW	%00001000,%00000000,0
	dc.l	P_XRII
	DW	%11100000,0,0
	DW	%00100000,0,0
	dc.l	P_I

	DW	0,0,0
	DW	0,0,0
	dc.l	NULL	
	
	