/* Indice du ressource pour FRAC_ICN */

#define FORM1    0   /* Formulaire/Dialogue */
