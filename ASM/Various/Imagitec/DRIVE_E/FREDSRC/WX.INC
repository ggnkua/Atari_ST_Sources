WX		DC.W	0,100,201,301,402,502,603,703,803
		DC.W	904,1004,1105,1205,1305,1405,1505,1605,1705,1805
		DC.W	1905,2005,2105,2204,2304,2404,2503,2602,2701,2801
		DC.W	2900,2998,3097,3196,3294,3393,3491,3589,3687,3785
		DC.W	3883,3980,4078,4175,4272,4369,4466,4563,4659,4756
		DC.W	4852,4948,5043,5139,5234,5329,5424,5519,5614,5708
		DC.W	5802,5896,5990,6083,6176,6269,6362,6455,6547,6639
		DC.W	6731,6822,6914,7005,7095,7186,7276,7366,7456,7545
		DC.W	7634,7723,7811,7900,7988,8075,8162,8249,8336,8423
		DC.W	8509,8594,8680,8765,8850,8934,9018,9102,9185,9268
		DC.W	9351,9434,9516,9597,9679,9759,9840,9920,10000,10079
		DC.W	10159,10237,10315,10393,10471,10548,10625,10701,10777,10853
		DC.W	10928,11002,11077,11150,11224,11297,11370,11442,11513,11585
		DC.W	11656,11726,11796,11866,11935,12003,12072,12139,12207,12273
		DC.W	12340,12406,12471,12536,12600,12665,12728,12791,12854,12916
		DC.W	12977,13039,13099,13159,13219,13278,13337,13395,13452,13510
		DC.W	13566,13622,13678,13733,13788,13842,13895,13948,14001,14053
		DC.W	14104,14155,14205,14255,14304,14353,14401,14449,14496,14543
		DC.W	14589,14634,14679,14723,14767,14810,14853,14895,14937,14978
		DC.W	15018,15058,15098,15136,15175,15212,15249,15286,15322,15357
		DC.W	15392,15426,15459,15492,15525,15557,15588,15618,15649,15678
		DC.W	15707,15735,15763,15790,15817,15842,15868,15892,15917,15940
		DC.W	15963,15985,16007,16028,16049,16069,16088,16107,16125,16142
		DC.W	16159,16175,16191,16206,16221,16234,16248,16260,16272,16284
		DC.W	16294,16305,16314,16323,16331,16339,16346,16353,16359,16364
		DC.W	16368,16372,16376,16379,16381,16382,16383,16384,16383,16382
		DC.W	16381,16379,16376,16372,16368,16364,16359,16353,16346,16339
		DC.W	16331,16323,16314,16305,16294,16284,16272,16260,16248,16234
		DC.W	16221,16206,16191,16175,16159,16142,16125,16107,16088,16069
		DC.W	16049,16028,16007,15985,15963,15940,15917,15892,15868,15842
		DC.W	15817,15790,15763,15735,15707,15678,15649,15618,15588,15557
		DC.W	15525,15492,15459,15426,15392,15357,15322,15286,15249,15212
		DC.W	15175,15136,15098,15058,15018,14978,14937,14895,14853,14810
		DC.W	14767,14723,14679,14634,14589,14543,14496,14449,14401,14353
		DC.W	14304,14255,14205,14155,14104,14052,14001,13948,13895,13842
		DC.W	13788,13733,13678,13622,13566,13510,13452,13395,13337,13278
		DC.W	13219,13159,13099,13038,12977,12916,12854,12791,12728,12664
		DC.W	12600,12536,12471,12406,12340,12273,12206,12139,12071,12003
		DC.W	11935,11866,11796,11726,11656,11585,11513,11442,11369,11297
		DC.W	11224,11150,11077,11002,10928,10852,10777,10701,10625,10548
		DC.W	10471,10393,10315,10237,10158,10079,10000,9920,9840,9759
		DC.W	9678,9597,9515,9433,9351,9268,9185,9102,9018,8934
		DC.W	8850,8765,8680,8594,8509,8422,8336,8249,8162,8075
		DC.W	7987,7900,7811,7723,7634,7545,7456,7366,7276,7186
		DC.W	7095,7004,6913,6822,6731,6639,6547,6455,6362,6269
		DC.W	6176,6083,5990,5896,5802,5708,5614,5519,5424,5329
		DC.W	5234,5139,5043,4947,4852,4755,4659,4563,4466,4369
		DC.W	4272,4175,4078,3980,3883,3785,3687,3589,3491,3393
		DC.W	3294,3196,3097,2998,2899,2800,2701,2602,2503,2403
		DC.W	2304,2204,2105,2005,1905,1805,1705,1605,1505,1405
		DC.W	1305,1205,1104,1004,904,803,703,602,502,401
		DC.W	301,200,100,0,-100,-201,-301,-402,-502,-603
		DC.W	-703,-804,-904,-1004,-1105,-1205,-1305,-1405,-1505,-1606
		DC.W	-1706,-1805,-1905,-2005,-2105,-2205,-2304,-2404,-2503,-2602
		DC.W	-2702,-2801,-2900,-2999,-3097,-3196,-3295,-3393,-3491,-3589
		DC.W	-3687,-3785,-3883,-3981,-4078,-4175,-4272,-4369,-4466,-4563
		DC.W	-4659,-4756,-4852,-4948,-5043,-5139,-5234,-5330,-5424,-5519
		DC.W	-5614,-5708,-5802,-5896,-5990,-6083,-6177,-6270,-6362,-6455
		DC.W	-6547,-6639,-6731,-6822,-6914,-7005,-7095,-7186,-7276,-7366
		DC.W	-7456,-7545,-7634,-7723,-7811,-7900,-7988,-8075,-8163,-8250
		DC.W	-8336,-8423,-8509,-8594,-8680,-8765,-8850,-8934,-9018,-9102
		DC.W	-9185,-9269,-9351,-9434,-9516,-9597,-9679,-9760,-9840,-9920
		DC.W	-10000,-10080,-10159,-10237,-10316,-10394,-10471,-10548,-10625,-10701
		DC.W	-10777,-10853,-10928,-11002,-11077,-11151,-11224,-11297,-11370,-11442
		DC.W	-11514,-11585,-11656,-11726,-11796,-11866,-11935,-12003,-12072,-12139
		DC.W	-12207,-12273,-12340,-12406,-12471,-12536,-12601,-12665,-12728,-12791
		DC.W	-12854,-12916,-12977,-13039,-13099,-13159,-13219,-13278,-13337,-13395
		DC.W	-13453,-13510,-13566,-13622,-13678,-13733,-13788,-13842,-13895,-13948
		DC.W	-14001,-14053,-14104,-14155,-14205,-14255,-14304,-14353,-14401,-14449
		DC.W	-14496,-14543,-14589,-14634,-14679,-14723,-14767,-14811,-14853,-14895
		DC.W	-14937,-14978,-15018,-15058,-15098,-15136,-15175,-15212,-15249,-15286
		DC.W	-15322,-15357,-15392,-15426,-15459,-15492,-15525,-15557,-15588,-15619
		DC.W	-15649,-15678,-15707,-15735,-15763,-15790,-15817,-15842,-15868,-15893
		DC.W	-15917,-15940,-15963,-15985,-16007,-16028,-16049,-16069,-16088,-16107
		DC.W	-16125,-16142,-16159,-16175,-16191,-16206,-16221,-16234,-16248,-16260
		DC.W	-16272,-16284,-16294,-16305,-16314,-16323,-16331,-16339,-16346,-16353
		DC.W	-16359,-16364,-16368,-16372,-16376,-16379,-16381,-16382,-16383,-16383
		DC.W	-16383,-16382,-16381,-16379,-16376,-16372,-16368,-16364,-16359,-16353
		DC.W	-16346,-16339,-16331,-16323,-16314,-16305,-16294,-16284,-16272,-16260
		DC.W	-16248,-16234,-16221,-16206,-16191,-16175,-16159,-16142,-16125,-16107
		DC.W	-16088,-16069,-16049,-16028,-16007,-15985,-15963,-15940,-15917,-15892
		DC.W	-15868,-15842,-15816,-15790,-15763,-15735,-15707,-15678,-15648,-15618
		DC.W	-15588,-15557,-15525,-15492,-15459,-15426,-15392,-15357,-15321,-15286
		DC.W	-15249,-15212,-15174,-15136,-15098,-15058,-15018,-14978,-14937,-14895
		DC.W	-14853,-14810,-14767,-14723,-14679,-14634,-14589,-14542,-14496,-14449
		DC.W	-14401,-14353,-14304,-14255,-14205,-14155,-14104,-14052,-14000,-13948
		DC.W	-13895,-13841,-13787,-13733,-13678,-13622,-13566,-13509,-13452,-13395
		DC.W	-13337,-13278,-13219,-13159,-13099,-13038,-12977,-12916,-12854,-12791
		DC.W	-12728,-12664,-12600,-12536,-12471,-12405,-12340,-12273,-12206,-12139
		DC.W	-12071,-12003,-11935,-11865,-11796,-11726,-11655,-11585,-11513,-11442
		DC.W	-11369,-11297,-11224,-11150,-11076,-11002,-10927,-10852,-10777,-10701
		DC.W	-10625,-10548,-10471,-10393,-10315,-10237,-10158,-10079,-10000,-9920
		DC.W	-9840,-9759,-9678,-9597,-9515,-9433,-9351,-9268,-9185,-9102
		DC.W	-9018,-8934,-8849,-8765,-8680,-8594,-8508,-8422,-8336,-8249
		DC.W	-8162,-8075,-7987,-7899,-7811,-7723,-7634,-7545,-7455,-7366
		DC.W	-7276,-7186,-7095,-7004,-6913,-6822,-6731,-6639,-6547,-6454
		DC.W	-6362,-6269,-6176,-6083,-5989,-5896,-5802,-5708,-5613,-5519
		DC.W	-5424,-5329,-5234,-5139,-5043,-4947,-4851,-4755,-4659,-4563
		DC.W	-4466,-4369,-4272,-4175,-4078,-3980,-3883,-3785,-3687,-3589
		DC.W	-3491,-3393,-3294,-3196,-3097,-2998,-2899,-2800,-2701,-2602
		DC.W	-2503,-2403,-2304,-2204,-2105,-2005,-1905,-1805,-1705,-1605
		DC.W	-1505,-1405,-1305,-1205,-1104,-1004,-904,-803,-703,-602
		DC.W	-502,-401,-301,-200,-100,0,100,201,301,402
		DC.W	502,603,703,804,904,1004,1105,1205,1305,1405
		DC.W	1506,1606,1706,1806,1906,2005,2105,2205,2304,2404
		DC.W	2503,2602,2702,2801,2900,2999,3097,3196,3295,3393
		DC.W	3491,3590,3688,3785,3883,3981,4078,4175,4273,4370
		DC.W	4466,4563,4659,4756,4852,4948,5044,5139,5234,5330
		DC.W	5425,5519,5614,5708,5802,5896,5990,6083,6177,6270
		DC.W	6362,6455,6547,6639,6731,6823,6914,7005,7096,7186
		DC.W	7276,7366,7456,7545,7634,7723,7812,7900,7988,8075
		DC.W	8163,8250,8336,8423,8509,8595,8680,8765,8850,8934
		DC.W	9018,9102,9186,9269,9351,9434,9516,9597,9679,9760
		DC.W	9840,9920,10000,10080,10159,10237,10316,10394,10471,10548
		DC.W	10625,10701,10777,10853,10928,11003,11077,11151,11224,11297
		DC.W	11370,11442,11514,11585,11656,11726,11796,11866,11935,12004
		DC.W	12072,12139,12207,12274,12340,12406,12471,12536,12601,12665
		DC.W	12728,12791,12854,12916,12978,13039,13099,13159,13219,13278
		DC.W	13337,13395,13453,13510,13566,13622,13678,13733,13788,13842
		DC.W	13895,13948,14001,14053,14104,14155,14205,14255,14304,14353
		DC.W	14401,14449,14496,14543,14589,14634,14679,14724,14767,14811
		DC.W	14853,14895,14937,14978,15018,15058,15098,15136,15175,15212
		DC.W	15249,15286,15322,15357,15392,15426,15459,15492,15525,15557
		DC.W	15588,15619,15649,15678,15707,15735,15763,15790,15817,15843
		DC.W	15868,15893,15917,15940,15963,15985,16007,16028,16049,16069
		DC.W	16088,16107,16125,16142,16159,16175,16191,16206,16221,16234
		DC.W	16248,16260,16272,16284,16294,16305,16314,16323,16331,16339
		DC.W	16346,16353,16359,16364,16368,16372,16376,16379,16381,16382
		DC.W	16383,16384

