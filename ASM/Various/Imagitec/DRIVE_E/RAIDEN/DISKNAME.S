End_Screen_Name	Dc.b	"Gamedata\STAGEEND.BIN",0
End_Screen_PalName	Dc.b	"Gamedata\STAGEEND.PAL",0
Event_Name	Dc.b	"Event.Bin",0
Map_Name	Dc.b	"Map.Bin",0
Blockset_Name	Dc.b	"Blocks.Bin",0
Pallete_Name	Dc.b	"Pal.Bin",0
Sprites_Name	Dc.b	"Sprites.Bin",0
Music_Name	Dc.b	"Music.Mod",0
Level_Dir_Name	Dc.b	"Level_"
Level_Load_Num	Dc.b	"1\              "		16 chars available
		Even

