Live_Add	Dc.l	$00100000
Bomb_Bonus	Dc.l	$00000150
Medal_Bonus	Dc.l	$00000300

ScoreTable
	Dcb.l	16,$00000150		Alien sprites
	Dcb.l	16,$00000050		Tank base
	Dcb.l	16,$00000150		Tank turret
	Dcb.l	16,$00000000		Tank missle
	Dcb.l	02,$00000000		Energy bolt
	Dcb.l	14,$00001000		Power ups + Bomb ups!
	Dcb.l	06,$00000000		Explosion
	Dcb.l	02,$00010000		Angel
	Dcb.l	02,$00000000		Crater
	Dcb.l	02,$00000000		Tree
	Dcb.l	03,$00002500		Big tank (1-3)
	Dcb.l	01,$00000000		Wheel of tank
	Dcb.l	01,$00005000		Big plane
	Dcb.l	03,$00000000		Wheels of tank
	Dcb.l	01,$00010000		Medal(1)
	Dcb.l	01,$00007500		Big power up ship !	
	Dcb.l	03,$00000000		Wheels of the tank
	Dcb.l	03,$00000000		Explosions64
	Dcb.l	01,$00001000		Medal(2)
	Dcb.l	05,$00000000		Power ups
	Dcb.l	02,$00000000		Explosion16/32
	Dcb.l	01,$00000000		Wheel of tank
	Dcb.l	01,$00000000		Crator64
	Dcb.l	03,$00000000		Explosion64(4-6)
	Dcb.l	16,$00000100		Alien sprites
	Dcb.l	16,$00001000		Tank turret (pump)
	Dcb.l	02,$00000000		Boosts for aliens
	Dcb.l	07,$00000000		Power up bits
	Dcb.l	01,$00005000		Big plane (up)
	Dcb.l	01,$00002500		8-way bomb
	Dcb.l	03,$00000000		Rotary for 8-bomb
	Dcb.l	03,$00000000		1-ups
	Dcb.l	04,$00000000		Explosion48
	Dcb.l	03,$00000000		Death anims!
	Dcb.l	02,$00000000		Up rockets
	Dcb.l	04,$00000000		Bits for end level (top level)!
	Dcb.l	01,$00100000		End level guardian
	Dcb.l	04,$00000000		End level whirry bits
	Dcb.l	12,$00000000		Cannons for end level big thing
	Dcb.l	01,$00000000		Cannon base
	Dcb.l	16,$00000300		Cannons !
	Dcb.l	01,$00005000		Enlarged alien
	Dcb.l	02,$00000000		Boosters for enlarged alien
	Dcb.l	04,$00000000		Caskets (all 4!)
	Dcb.l	02,$00003000		Pig (1-2)
	Dcb.l	04,$00000050		Enlarged bolts

	Dcb.l	32,$00000150		Zooming alien
	Dcb.l	02,$00000300		Zoomer
	Dcb.l	01,$00000500		Powerup-boat
	Dcb.l	01,$00000000		Bit for power up boat
	Dcb.l	04,$00000200		Boat Left/Right/Up/Down
	Dcb.l	02,$00000100		Car
	Dcb.l	02,$00000500		Bulldozer
	Dcb.l	02,$00000750		Train (Front)
	Dcb.l	01,$00000000		Train (Back)
	Dcb.l	02,$00000500		Front carraige
	Dcb.l	01,$00000000		Carraige
	Dcb.l	08,$00000000		Fire anims for train/Carraige
;Diagonal		
	Dcb.l	02,$00000750		Train (Front)
	Dcb.l	01,$00000000		Train (Back)
	Dcb.l	02,$00000500		Front carraige
	Dcb.l	01,$00000000		Carraige
	Dcb.l	08,$00000000		Fire anims for train/Carraige
	Dcb.l	01,$00100000		End-level guard Left main (2)
	Dcb.l	14,$00000000		Bits for end level (2)
	Dcb.l	06,$00000300		Zoomer transforms
	Dcb.l	03,$00000000		Trendy bolts
;325
	Dcb.l	02,$00000050
	Dcb.l	01,$00002500	
	Dcb.l	01,$00000000	
	Dcb.l	01,$00002500	
	Dcb.l	01,$00000000	
	Dcb.l	01,$00003000
	Dcb.l	08,$00000000
;340
	Dcb.l	01,$00001000
	Dcb.l	16,$00000000
	Dcb.l	03,$00000000
	Dcb.l	01,$00001000
	Dcb.l	04,$00000000
;365
	Dcb.l	01,$00050000
	Dcb.l	03,$00005000
	Dcb.l	04,$00005000
	Dcb.l	20,$00001000
	Dcb.l	04,$00001000
	Dcb.l	04,$00005000
	Dcb.l	04,$00005000
	Dcb.l	03,$00005000

	Dcb.l	40,$00005000

	Dcb.l	514-418,$00001000

