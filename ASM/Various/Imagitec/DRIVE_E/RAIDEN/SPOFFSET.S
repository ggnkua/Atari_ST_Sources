Vectortab
	Dc.w	0,-4,2,-4,4,-4,4,-2,4,0,4,2,4,4,2,4
	Dc.w	0,4,-2,4,-4,4,-4,2,-4,0,-4,-2,-4,-4,-2,-4

Explosion_Offsets
	Dc.b	-00,-00
	Dc.b	-48,-00
	Dc.b	-42,+26
	Dc.b	-32,+16
	Dc.b	+22,-36
	Dc.b	-48,+12
	Dc.b	+20,-32
	Dc.b	+26,+00
	Dc.b	+16,-30
	Dc.b	-30,+20

**********************************************************
	Excrt	01,-06,-08
Explosion_And_Crator_Offset_Table
	Excrt	16,+00,+00
	Excrt	16,-02,-02
	Excrt	16,-02,-02
	Excrt	16,-10,-10
	Excrt	28,+00,+00
;92
	Excrt	03,-10,-10
	Excrt	01,-00,-00
	Excrt	01,-05,-05
	Excrt	04,-00,-00
;101
	Excrt	01,-06,-06
	Excrt	19,-00,-00
	Excrt	16,+00,+00
	Excrt	16,-02,-02
;153
	Excrt	09,-00,-00
	Excrt	01,-05,-05

	Excrt	01,-24,-26
	Excrt	19,-00,-00
	Excrt	01,-00,-00
;184
	Excrt	04,-00,-00
	Excrt	12,-06,-06
	Excrt	01,-00,-00
	Excrt	16,-01,-01

	Excrt	01,-05,-20
	Excrt	02,-00,-00
	Excrt	04,-02,-02
	Excrt	06,-00,-00
;230
	Excrt	32,-02,-02
	Excrt	02,-02,-02
	Excrt	01,-10,-10
	Excrt	01,-00,-00
	Excrt	04,-04,-04
	Excrt	02,-04,-04
	Excrt	02,-03,-03
;274
	Excrt	27,-26,-26
;301
	Excrt	24,-04,-04
;325
	Excrt	02,-02,-02
	Excrt	04,-12,-06
	Excrt	09,-06,-06
	Excrt	01,-13,-13		;;
	Excrt	16,+00,+00
	Excrt	08,-16,-30
;365
	Excrt	08,+00,+00
	Excrt	20,-16,-20
	Excrt	04,-17,-22
	Excrt	08,-02,-02	
	Excrt	03,-12,-12	
	Excrt	09,+00,+00

	Excrt	513-418,+00,+000



**********************************************************
Tank_Adj
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0
	Dc.w	+0,+0

**********************************************************
Turret_Adj
	Dc.w	+0,-6
	Dc.w	+0,-6
	Dc.w	+0,-5
	Dc.w	+3,-3
	Dc.w	+3,-2
	Dc.w	+1,-0
	Dc.w	+1,-0
	Dc.w	+1,+1
	Dc.w	+0,+2
	Dc.w	+0,+2
	Dc.w	-2,+1
	Dc.w	-4,-0
	Dc.w	-5,-0
	Dc.w	-4,-2
	Dc.w	-3,-3
	Dc.w	-2,-4
	Dc.w	-1,-5
	

**********************************************************
Cannon_Adj
	Dc.w	+3,+2
	Dc.w	+3,+3
	Dc.w	+3,+3
	Dc.w	+3,+1
	Dc.w	+4,+2
	Dc.w	+3,+2
	Dc.w	+3,+3
	Dc.w	+2,+2
	Dc.w	+3,+2
	Dc.w	+3,+2
	Dc.w	+3,+3
	Dc.w	+3,+2
	Dc.w	+3,+3
	Dc.w	+3,+2
	Dc.w	+3,+3
	Dc.w	+2,+2

