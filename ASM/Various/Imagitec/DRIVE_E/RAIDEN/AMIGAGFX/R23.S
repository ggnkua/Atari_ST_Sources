	dc.w	$0030,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0000,$0F90,$0B30,$0A00,$0000,$0344,$0799,$0ACC
	dc.w	$000D,$000A,$0007,$05A6,$0272,$0040,$0D00,$0600
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0F0F