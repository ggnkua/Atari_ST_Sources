; Raiden Sprite numbers (c) Freddy !

;000-015		Alien sprite(1)
;016-031		Tank sprite
;032-047		Turret sprite(1)
;048-049		Top Whirry Bits for Second mid level baddie
;50			Mid Second level Main baddie
;51-53			Back bits for second Main Baddie
;54-56			Fron bits "			"
;57			Left Slidey Bit
;58			Left Slidey Bit
;59-60			Traction Left
;61-62			Traction Right

;63			Bottom Whirry Bits for Second mid level baddie
;064-065		Energy bolt
;066-067		Splatter
;068-069		Lazer
;070-071		Sidewinder
;072-073		Homing
;074-075		Full power
;076-079		Bomb

;080-082		Explosion 16(1-3)
;083-085		Explosion 32(1-3)
;086-087		Angel
;088			Crater 32(1)
;089			Crater 32(2)

;90			Bottom Whirry Bits for Second mid level baddie

;091			Tree 32
;092-094		Tank (1-3)
;095			Top left wheel(1)
;096			Big plane down
;097			Top right wheel(1)
;098			Bottom left wheel(1)
;099			Bottom right wheel(1)
;100			Medal(1)

;101			Power-up ship (main)
;102			TLW(1)
;103			TRW(1)
;104			BLW(1)
;105-107		Explosion 64 (1-3)
;108			Medal(2)
;109			Splatter up(3)
;110			Lazer up(3)
;111			Big power up(3)
;112			Home up(3)
;113			Sidewinder up(3)
;114			Explosion 16 (4)
;115			Explosion 32 (4)
;116			BRW(2)
;117			Crator(64)
;118-120		Explosion 64 (4-6)
;121-136		Rotating(2)
;137-152		Tank recoil
;153-154		Power up boost(1-2) (any!)
;155-157		Powerup middle bits (1-3)
;158-159		Power up rockets
;160-161		Power up whirrers

;162			Big plane (up)
;163			8 way bomb
;164-166		Rotar arm for bomb (1-3)
;167-169		1-UP		(1-3)
;170-173		48x48 explosion (1-4)
;174-176		Player ship explosion (1-3)
;177-178		Up boosters
;179-182		Mask for end of level
;183			End of level guardian
;184-187		Whirry bits for guardian
;188-199		Cannons for guardian
;200			Cannon base
;201-216		Cannons
;217			Enlarged alien 
;218-219		Enlarged alien boosters
;220-221		Casket 1
;222-223		Casket 2
;224-225		Pig (1-2)
;226-229		Bolt for enlarged alien

;230-245		Zooming alien 1(level2)
;246-261		Zooming alien 1(level2)
;262-263		Zoomer (1-2,Level2)
;264			Power up boat
;265			Bit for power up boat
;266			Boat cannon up
;267			Boat cannon Right
;268			Boat cannon Down
;269			Boat cannon Left
;270-271		Car (1-2)
;272-273		Bulldozer(1-2)
;274-275		Front train (1-2)
;276			Back train
;277-278		Front carraige (1-2)
;279			Back carraige
;280-287		Train front fire anims
;288-289		Diagonal train front
;290			Diagonal train back
;291-292		Diagonal carraige
;293-300		Carraige shot diagonal

;301			End level guard left
;302			End level guard right
;303-304		Wings Left/Right
;305-306		Guard boosters 1-2
;307-311		Bits for guardian
;312-315		Bits for shooting guard ??
;316-318		Left transforms
;319-321		Right "   "
;322-324		Trendy bolts !

;325-			Little Truck
;326-			Little Jeep
;327-328		Scafolding RIGHT+Link
;329-330		Scafolding Left+Link
;331-332		Hovercraft going up+ Link for its cannon thingy
;333-339		Back bits for hovercraft
;340			Some type of tank
;341-356		Cannon bits for the some type of tank
;357-359		Back of some kind of tank
;360			Front of "
;361-364		Fire frames "

;365-368		End level 3 base quadsprites
;369-372		End level 3 top quadsprites
;373-392		Cannon bits "
;393-396		Fire bits "
;397-404		Side bits "
;405			Middle bit for level 3
;406-407		? "
;408-416		Open and shut cannons
;417			Grid system !

;418-420		Floating thing
;421			Hugous type tank
;422-424		Left  " " Wheel
;425-427		Right " " Wheel
;428-432		Side  " " Left
;433-437		Side  " " Right
;438-445		Circle Shots
;446			Terrain Vehicle Up
;447			Terrain Vehicle Right
;448-449		Terrain Vehicle Right (Shots)
;450-451		Terrain Vehicle Up (Shots)
;452-453		Terrain Vehicle Left (Wheels)
;454-455		Terrain Vehicle Right (Wheels)
;456-457		Terrain Vehicle Down (Wheels)
;458-459		Terrain Vehicle Up (Wheels)
;460-467		Spinning ship
;468-478		Rocky bits
;479-482		End baddy 4 normal
;483-486		End baddy 4 OK
;487-490		End baddy 4 Fucked
;491			Power up hold mid
;492			Power up hold mid Shot
;493-494		Left/Right hold
;495-496		Left/Right Arm
;497			Endlev4 Right Extension
;498			Endlev4 Right Extension
;499-500		2 ?? Bits for end lev4
;501-512		Shooting bits for end lev4
;513			Alien Plane type thingy

;514-516		Tank on tracks
;517-520		Bits ""
;521			Left plane from garage
;522			Right plane from garage
;523-527		Firing bits left ""
;528-531		Firing bits Right ""
;532-533		Gunny bits
;534			Level 5 mainbit
;535-537		Cannon bits ""
;538-539		Left/Right wing ""
;540-543		Right wing gun turrets ""
;544-547		Left wing gun turrets ""
;548-551		Bits (A) ""
;552-555		Bits (B) ""
;556-559		Bits (C) ""
;560-566		Spinny bits ""
;567			Mask for train track tanks