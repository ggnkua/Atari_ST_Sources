Shot_Sfx
	Dc.w	-2,Shote_Sfx-Shot_Sfx
	Incbin	E:\Raiden\SFX\Shot
Shote_Sfx
Laser_Sfx	
	Dc.w	-2,Lasere_Sfx-Laser_Sfx
	Incbin	E:\Raiden\SFX\Laser
Lasere_Sfx	
Home_Sfx
	Dc.w	-2,Homee_Sfx-Home_Sfx
	Incbin	E:\Raiden\SFX\Home
Homee_Sfx
Rocket_Sfx
	Dc.w	-2,Rockete_Sfx-Rocket_Sfx
	Incbin	E:\Raiden\SFX\Rocket
Rockete_Sfx
Collect_Sfx
	Dc.w	3,Collecte_sfx-Collect_Sfx
	Incbin	E:\Raiden\SFX\Collect
Collecte_Sfx
Explosion_Sfx
	Dc.w	4,Explosione_Sfx-Explosion_Sfx
	Incbin	E:\Raiden\SFX\Explosin
Explosione_Sfx
