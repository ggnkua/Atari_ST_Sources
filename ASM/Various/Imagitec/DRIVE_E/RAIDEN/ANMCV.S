; CONVERTS MARVS SPRITES > ANIM EQUIVALENT!
Anim_Convert_Table
	Dcb.b	16,0		;0-15
	Dcb.b	16,7		;16-31
	Dcb.b	18,0
	Dcb.b	01,14		;50
	Dcb.b	40,0
	Dcb.b	1,45		;91
	Dcb.b	3,39		;92
	Dcb.b	1,0
	Dc.b	32		;96
	Dcb.b	4,0
	Dc.b	10		;101
	Dcb.b	60,0		;102
	Dc.b	33		;162
	Dc.b	54		;163
	Dcb.b	3,0		;164
	Dcb.b	3,44		;167
	Dcb.b	12,58		;170
	Dcb.b	18,58		;183
	Dc.b	66		;200
	Dcb.b	16,0
	Dc.b	64		;217
	Dcb.b	2,0
	Dcb.b	2,34		;220
	Dcb.b	2,35		;222
	Dcb.b	6,0
	Dcb.b	32,51		;230
	Dcb.b	2,68		;262-263
	Dcb.b	2,69		;264
	Dc.b	71,72,73,74	;265-269
	Dcb.b	2,75		;270-271
	Dc.b	76,77		;272-273
	Dc.b	78,78		;274-275
	Dc.b	79		;276
	Dc.b	80,80		;277-278
	Dc.b	0		;279
	Dcb.b	8,0
	Dcb.b	2,83		;288-289
	Dc.b	1
	Dcb.b	2,85		;291-292
	Dcb.b	8,0
	Dc.b	87		;301

	Ds.b	325-301-1
	Dc.b	97,98		;325-326
	Dc.b	99,100		;327,328
	Dc.b	101,102		;329,330
	Dc.b	103		;331
	Ds.b	340-331-1
	Dc.b	106		;340
	Ds.b	357-340-1
	DCb.B	365-357-1,108	;357
	Dcb.b	408-365+1,111	; HUMM!-End lev3 guard !
	Dcb.b	09,119		; Open & shut cannons 
	Dcb.b	1,129

	Dcb.b	3,131
	Dcb.b	438-421,133
	Dcb.b	446-438,0
	Dcb.b	1,138
	Dcb.b	1,139

	Ds.b	479-448
	Dc.b	160
	Dcb.b	491-480,0
	Dc.b	146
	Dcb.b	497-492,0
	Dc.b	172
	Dc.b	173
	Ds.b	513-499
	Dcb.b	1,130
	Dcb.b	1,177
	Ds.b	521-515
	Dcb.b	1,179
	Ds.b	534-522
	Dcb.b	1,186

	EVEN