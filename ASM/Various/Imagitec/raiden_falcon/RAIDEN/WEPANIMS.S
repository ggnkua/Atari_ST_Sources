Wep_Anims
	Dc.l	.Wep_1,.Wep_2,.Wep_3,.Wep_4,.Wep_5,.Wep_6,.Wep_7
	Dc.l	.Wep_8,.Wep_9,.Wep_10,.Wep_11,.Wep_12
	Dc.l	.Wep_13,.Wep_14,.Wep_15,.Wep_16,.Wep_17
	Dc.l	.Wep_18,.Wep_19,.Wep_20,.Wep_21,.Wep_22
	Dc.l	.Wep_23
	Dc.w	-1
.Wep_1	Dc.b	127,8,-1
.Wep_2	Dc.b	127,7,-1
.Wep_3	Dc.b	127,6,-1
.Wep_4	Dc.b	127,9,-1
.Wep_5	Dc.b	127,10,-1
.Wep_6	Dc.b	4,5,-1
.Wep_7	Dc.b	4,11,-1

.Wep_8	Dc.b	4,12,-1
.Wep_9	Dc.b	4,13,-1
.Wep_10	Dc.b	4,14,-1
.Wep_11	Dc.b	4,15,-1
.Wep_12	Dc.b	4,16,-1

.Wep_13	Dc.b	4,17,18,-1
.Wep_14	Dc.b	4,17,18,-1
.Wep_15	Dc.b	4,78,79,-1
.Wep_16	Dc.b	4,78,79,-1
.Wep_17	Dc.b	4,80,81,-1

.Wep_18	Dc.b	4,19,-1
.Wep_19	Dc.b	4,19,-1
.Wep_20	Dc.b	4,35,-1
.Wep_21	Dc.b	4,35,-1
.Wep_22	Dc.b	4,62,-1

.Wep_23 Dc.b	2,84,85,86,87,-1
	Even
