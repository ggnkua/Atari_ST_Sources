Power_Up_Event_Table
; Level 1
	Dc.b	0,6,2,7
	Dc.b	6,6,6,6,6,6
	Dc.b	1,0,6,8,0,2
; Level 2
Lv2	Dc.b	6,6
	Dc.b	6,6,5,6
	Dc.b	1,3
	Dc.b	6,6,6,6
	Dc.b	6,2
	Dc.b	1
; Level 3
Lv3
	Dc.b	6,6,6,0,2,0,2,1,3
	Even
