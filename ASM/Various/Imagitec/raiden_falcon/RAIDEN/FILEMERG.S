; Assemble to link one or more files !
; Save from S>E

S
	Incbin	E:\Raiden\Level_4\Palletes\Pal0.Pal
	Incbin	E:\Raiden\Level_4\Palletes\Pal1.Pal
F
E=F-1