Anmneg	Dc.w	$7fff,-1,-1
	Dc.l	Anmneg
Alien_Anim_Table
	Dc.l	.Anm0,.Anm1,.Anm2,.Anm3,.Anm4,.Anm5,.Anm6,.Anm7,.Anm8,.Anm9
	Dc.l	.Anm10,.Anm11,.Anm12,.Anm13,.Anm14,.Anm15,.Anm16,.Anm17,.Anm18,.Anm19
	Dc.l	.Anm20,.Anm21,.Anm22,.Anm23,.Anm24,.Anm25,.Anm26,.Anm27,.Anm28,.Anm29
	Dc.l	.Anm30,.Anm31,.Anm32,.Anm33,.Anm34,.Anm35,.Anm36,.Anm37,.Anm38,.Anm39
	Dc.l	.Anm40,.Anm41,.Anm42,.Anm43,.Anm44,.Anm45,.Anm46,.Anm47,.Anm48,.Anm49
	Dc.l	.Anm50,.Anm51,.Anm52,.Anm53,.Anm54,.Anm55,.Anm56,.Anm57,.Anm58,.Anm59
	Dc.l	.Anm60,.Anm61,.Anm62,.Anm63,.Anm64,.Anm65,.Anm66,.Anm67,.Anm68,.Anm69
	Dc.l	.Anm70,.Anm71,.Anm72,.Anm73,.Anm74,.Anm75,.Anm76,.Anm77,.Anm78,.Anm79
	Dc.l	.Anm80,.Anm81,.Anm82,.Anm83,.Anm84,.Anm85,.Anm86,.Anm87,.Anm88,.Anm89
	Dc.l	.Anm90,.Anm91,.Anm92,.Anm93,.Anm94,.Anm95,.Anm96,.Anm97,.Anm98,.Anm99
	Dc.l	.Anm100,.Anm101,.Anm102,.Anm103,.Anm104,.Anm105,.Anm106,.Anm107,.Anm108,.Anm109
	Dc.l	.Anm110,.Anm111,.Anm112,.Anm113,.Anm114,.Anm115,.Anm116,.Anm117,.Anm118,.Anm119
	Dc.l	.Anm120,.Anm121,.Anm122,.Anm123,.Anm124,.Anm125,.Anm126,.Anm127,.Anm128,.Anm129
	Dc.l	.Anm130,.Anm131,.Anm132,.Anm133,.Anm134,.Anm135,.Anm136,.Anm137,.Anm138,.Anm139
	Dc.l	.Anm140,.Anm141,.Anm142,.Anm143,.Anm144,.Anm145,.Anm146,.Anm147,.Anm148,.Anm149
	Dc.l	.Anm150,.Anm151,.Anm152,.Anm153,.Anm154,.Anm155,.Anm156,.Anm157,.Anm158,.Anm159
	Dc.l	.Anm160,.Anm161,.Anm162,.Anm163,.Anm164,.Anm165,.Anm166,.Anm167,.Anm168,.Anm169
	Dc.l	.Anm170,.Anm171,.Anm172,.Anm173,.Anm174,.Anm175,.Anm176,.Anm177,.Anm178,.Anm179
	Dc.l	.Anm180,.Anm181,.Anm182,.Anm183,.Anm184,.Anm185,.Anm186,.Anm187,.Anm188,.Anm189
	Dc.l	.Anm190,.Anm191,.Anm192,.Anm193,.Anm194,.Anm195,.Anm196,.Anm197,.Anm198,.Anm199


.Anm0	Dc.w	4,0,121,-1				ROTATING SHIP BASE !
.Anm1	Dc.w	2,80,81,82,-1			EXPLOSION
.Anm2	Dc.w	3,64,65,-1			ENERGY BOLT
.Anm3	Dc.w	5,66,67,109,-1			Red - Weapon
.Anm4	Dc.w	5,68,69,110,-1			Blue - Weapon
.Anm5	Dc.w	5,70,71,113,-1			Sidewinder
.Anm6	Dc.w	5,72,73,112,-1			Homing Missle
.Anm7	Dc.w	123,16,-1			Tank anims
.Anm8	Dc.w	113,32,-1			Turret anims !
.Anm9	Dc.w	76,48,-1			Tank missle
.Anm10	Dc.w	10,101,-1			Big power-up ship
.Anm11	Dc.w	2,153,154,-1			Boosters (down)
.Anm12	Dc.w	2,177,178,-1			Boosters (up)
.Anm13	Dc.w	3,160,161,-1			Whirry bits
;-----------
.Anm14	Dc.w	39,50,-1			Second level Mid baddie
.Anm15	Dc.w	39,57,-1			Left bit of mid
.Anm16	Dc.w	39,58,-1			Right bit of mid!
.Anm17	Dc.w	2,59,60,-1			Left Traction
.Anm18	Dc.w	2,61,62,-1			Right Tractiion
.Anm19	Dc.w	2,48,49,-1			Up spinner
.Anm20	Dc.w	2,63,90,-1			Down Spinner
.Anm21	Dc.w	2,179,180,-1			BONUS 5000
.Anm22	Dc.w	2,181,182,-1			BONUS 10000
.Anm23	Dc.w	$7fff,158,-1			Boost down for power-up ship
.Anm24	Dc.w	$7fff,159,-1			Tween boost down for power-up ship
.Anm25	Dc.w	39,59,-1			Tank missle !
.Anm26	Dc.w	39,60,-1			Tank missle !
.Anm27	Dc.w	39,61,-1			Tank missle !
.Anm28	Dc.w	39,62,-1			Tank missle !
.Anm29	Dc.w	39,63,-1			Tank missle !
;-----------
.Anm30	Dc.w	2,80,81,82,114,-1		Explosion 16
.Anm31	Dc.w	3,83,84,85,-1			Explosion 32
.Anm32	Dc.w	9,96,-1				Plane down
.Anm33	Dc.w	9,162,-1			Plane up
.Anm34	Dc.w	3,220,221,-1			Casket1
.Anm35	Dc.w	3,222,223,-1			Casket2
.Anm36	Dc.w	3,76,77,78,79,-1		Bomb pickup!
.Anm37	Dc.w	2,100,108,-1			Medal!
.Anm38	Dc.w	3,74,75,111,-1			Full power !
.Anm39	Dc.w	2,92,93,94,-1			Huge tank
.Anm40	Dc.w	3,95,102,-1			TLW
.Anm41	Dc.w	3,97,103,-1			TRW
.Anm42	Dc.w	3,98,104,-1			BLW
.Anm43	Dc.w	4,86,87,-1			Angel!
.Anm44	Dc.w	127,167,168,169,-1		1-UP POWERUP
.Anm45	Dc.w	127,91,-1			Tree!!
.Anm46	Dc.w	126,89,-1			Crater (32)1
.Anm47	Dc.w	125,88,-1			Crater (32)2 
.Anm48	Dc.w	126,117,-1			Crator (64)
.Anm49	Dc.w	2,226,227,228,229,-1		Enlarged bolts
.Anm50	Dc.w	2,224,225,-1			Pig anm set
.Anm52	Dc.w	2,105,106,107,118,119,120,-1	Explosion64
.Anm53	Dc.w	2,170,171,172,173,-1		Explosion48
.Anm54	Dc.w	$7fff,163,-1			8-way bomb
.Anm55	Dc.w	2,164,165,166,-1		Anims for rotary of bomb
.Anm56	Dc.w	3,155,156,157,156,-1		Middle power-ups
.Anm57	Dc.w	3,99,116,-1			BRW
.Anm58	Dc.w	3,183,-1			End-level guardian
.Anm59	Dc.w	2,184,185,186,-1		Wirry bits for end level guardian
.Anm60	Dc.w	1,188,189,190,-1		Bottom left cannon
.Anm61	Dc.w	1,191,192,193,-1		Left cannon
.Anm62	Dc.w	1,194,195,196,-1		Right cannon
.Anm63	Dc.w	1,199,198,197,-1		Bottom right cannon
.Anm64	Dc.w	3,217,-1			Enlarged ship
.Anm65	Dc.w	3,218,219,-1			Boost for enlarged ship
.Anm66	Dc.w	3,200,-1			Base of cannon
.Anm67	Dc.w	3,201,-1			Base of cannon rotations

;----------- LEVEL 2!!!!!!!!!!!!

.Anm51	Dc.w	2,230,246,-1			
.Anm68	Dc.w	2,262,263,-1			Zoomer !
.Anm69	Dc.w	213,264,-1			Tank boat
.Anm70	Dc.w	3,265,-1,-1			Tank boat bit
.Anm71	Dc.w	200,266,-1
.Anm72	Dc.w	200,267,-1
.Anm73	Dc.w	200,268,-1
.Anm74	Dc.w	200,269,-1			Boat Up/Right/Down/Left
.Anm75	Dc.w	2,270,271,-1			Car
.Anm76	Dc.w	200,272,-1			Buildozer 1
.Anm77	Dc.w	200,273,-1			Bulldozer 2
.Anm78	Dc.w	3,274,275,-1			Front train 1-2
.Anm79	Dc.w	200,276,-1			Back train
.Anm80	Dc.w	3,277,278,-1			Front carraige 1-2
.Anm81	Dc.w	200,279,-1			Back carraige
.Anm82	Dc.w	2,280,281,282,283,284,285,286,287,-1	Train front fire
.Anm83	Dc.w	2,288,289,-1			Diagonal train front
.Anm84	Dc.w	2,290,-1			Diagonal train back
.Anm85	Dc.w	2,291,292,-1			Diagonal carraige
.Anm86	Dc.w	2,293,294,295,296,297,298,299,300,-1	 Train diagonal fire
.Anm87	Dc.w	200,301,-1			End level guardian left
.Anm88	Dc.w	200,302,-1			End level guardian right
.Anm89	Dc.w	200,303,-1			Guardian wing left
.Anm90	Dc.w	200,304,-1			Guardian wing right
.Anm91	Dc.w	2,305,306,-1			Guardian boosters
.Anm92	Dc.w	2,307,308,309,310,311,310,309,308,307,-1	Bits for End guardian
.Anm93	Dc.w	2,312,313,314,315,-1		Bits for shooting end-guard
.Anm94	Dc.w	4,316,317,318,-1		Left transform
.Anm95	Dc.w	4,319,320,321,-1		Right transform
.Anm96	Dc.w	2,322,323,324,-1		Trendy bolts

;----------- LEVEL 3!!!!!!!!!!!!

.Anm97	Dc.w	$7fff,325,-1			Uptruck
.Anm98	Dc.w	$7fff,326,-1			Upcar
.Anm99	Dc.w	$7fff,327,-1
.Anm100	Dc.w	$7fff,328,-1			Scafolding right
.Anm101	Dc.w	$7fff,329,-1
.Anm102	Dc.w	$7fff,330,-1			Scafolding left
.Anm103	Dc.w	$7fff,331,-1			Traveling boat
.Anm104	Dc.w	$7fff,332,-1			Bit for !!
.Anm105	Dc.w	3,333,334,335,336,337,338,339,-1 Back bits for boat
.Anm106	Dc.w	$7fff,340,-1			Monstrous tank
.Anm107	Dc.w	$7fff,341,-1			Base for cannon on monstrous
.Anm108	Dc.w	$7fff,360,-1			Front bit for jeep
.Anm109	Dc.w	2,357,358,359,-1		Back bit for jeep
.Anm110	Dc.w	2,361,362,363,364,-1		Bits for jeep
.Anm111	Dc.w	$7fff,365,-1
.Anm112	Dc.w	$7fff,366,-1
.Anm113	Dc.w	$7fff,367,-1
.Anm114	Dc.w	$7fff,368,-1
.Anm115	Dc.w	$7fff,369,-1			End baddy3 stuff !
.Anm116	Dc.w	$7fff,370,-1
.Anm117	Dc.w	$7fff,371,-1
.Anm118	Dc.w	$7fff,372,-1
.Anm119	Dc.w	$3,408,409,410,411,412,413,412,411,410,409,408,-1	; Open & shut cannon
.Anm120	Dc.w	$3,393,394,395,396,395,394,393,-1
.Anm121	Dc.w	$3,397,398,399,400,399,398,397,-1
.Anm122	Dc.w	$3,401,402,403,404,403,402,401,-1
.Anm123	DC.W	$7fff,405,-1
.Anm124	Dc.w	$3,373,378,383,388,-1
.Anm125	Dc.w	$3,374,379,384,389,-1
.Anm126	Dc.w	$3,375,380,385,390,-1
.Anm127	Dc.w	$3,376,381,386,391,-1
.Anm128	Dc.w	$3,377,382,387,392,-1
.Anm129	DC.W	$7fff,417,-1

;----------- LEVEL 4!!!!!!!!!!!!

.Anm130	Dc.w	$7fff,513,-1
.Anm131	Dc.w	4,418,419,420,-1
.Anm132	Dc.w	3,468,469,470,471,472,473,474,475,-1
.Anm133	Dc.w	$7fff,421,-1
.Anm134	Dc.w	4,422,423,424,-1
.Anm135	Dc.w	4,425,426,427,-1
.Anm136	Dc.w	4,428,429,430,431,432,-1
.Anm137	Dc.w	4,433,434,435,436,437,-1
.Anm138	Dc.w	$7fff,446,-1
.Anm139	Dc.w	$7fff,447,-1

.Anm140	Dc.w	4,450,451,-1
.Anm142	Dc.w	4,452,453,-1
.Anm141	Dc.w	4,454,455,-1
.Anm143	Dc.w	4,448,449,-1
.Anm144	Dc.w	4,456,457,-1
.Anm145	Dc.w	4,458,459,-1
.Anm146	Dc.w	$7fff,491,-1
.Anm147	Dc.w	$7fff,492,-1
.Anm148	Dc.w	$7fff,493,-1
.Anm149	Dc.w	$7fff,494,-1

.Anm150	Dc.w	$7fff,495,-1
.Anm151	Dc.w	$7fff,496,-1
.Anm152	Dc.w	4,454,455,-1
.Anm153	Dc.w	4,448,449,-1
.Anm154	Dc.w	4,456,457,-1
.Anm155	Dc.w	4,458,459,-1
.Anm156	Dc.w	$7fff,491,-1
.Anm157	Dc.w	$7fff,492,-1
.Anm158	Dc.w	$7fff,493,-1
.Anm159	Dc.w	$7fff,494,-1

.Anm160	Dc.w	$7fff,479,-1
.Anm161	Dc.w	$7fff,480,-1
.Anm162	Dc.w	$7fff,481,-1
.Anm163	Dc.w	$7fff,482,-1
.Anm164	Dc.w	$7fff,483,-1
.Anm165	Dc.w	$7fff,484,-1
.Anm166	Dc.w	$7fff,485,-1
.Anm167	Dc.w	$7fff,486,-1
.Anm168	Dc.w	$7fff,487,-1
.Anm169	Dc.w	$7fff,488,-1

.Anm170	Dc.w	$7fff,489,-1
.Anm171	Dc.w	$7fff,490,-1
.Anm172	Dc.w	$7fff,497,-1
.Anm173	Dc.w	$7fff,498,-1
.Anm174	Dc.w	$7fff,483,-1
.Anm175	Dc.w	3,501,502,503,504,505,506,507,508,509,511,512,-1
.Anm176	Dc.w	$7,499,-1

;------Level 5

.Anm177	Dc.w	4,514,515,516,-1
.Anm178	Dc.w	3,517,518,519,520,519,518,-1
.Anm179	Dc.w	$7fff,521,-1

.Anm180	Dc.w	$7fff,522,-1
.Anm181	Dc.w	$3,523,524,-1
.Anm182	Dc.w	$3,526,527,-1
.Anm183	Dc.w	$3,529,528,-1
.Anm184	Dc.w	$3,530,531,-1
.Anm185	Dc.w	$3,532,533,-1
.Anm186	Dc.w	$7fff,534,-1
.Anm187	Dc.w	$3,535,536,537,536,-1
.Anm188	Dc.w	$7fff,538,-1
.Anm189	Dc.w	$7fff,539,-1

.Anm190	Dc.w	3,540,541,542,543,542,541,-1
.Anm191	Dc.w	3,544,545,546,547,546,545,-1
.Anm192	Dc.w	3,548,549,550,551,-1
.Anm193	Dc.w	3,552,553,554,555,-1
.Anm194	Dc.w	3,556,557,558,559,-1
.Anm195	Dc.w	2,560,561,562,563,-1
.Anm196	Dc.w	5,564,565,566,565,564,-1
.Anm197	
.Anm198	
.Anm199	

