	dc.w	$0030,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0000,$0000,$0344,$0799,$0ACC,$0040,$0272,$05A6
	dc.w	$0F90,$0B30,$0600,$0A00,$0D00,$0007,$000A,$000D
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0707
	dc.w	$0707,$0707,$0707,$0707,$0707,$0707,$0707,$0F0F