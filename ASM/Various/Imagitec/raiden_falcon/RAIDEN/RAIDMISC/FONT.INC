	DC.B	$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$18,$18,$18,$18,$00,$18,$18,$00
	DC.B	$6C,$6C,$48,$00,$00,$00,$00,$00
	DC.B	$6C,$6C,$FE,$6C,$FE,$6C,$6C,$00
	DC.B	$10,$7C,$D0,$7C,$16,$7C,$10,$00
	DC.B	$62,$66,$0C,$18,$30,$66,$46,$00
	DC.B	$38,$6C,$68,$76,$DC,$CC,$76,$00
	DC.B	$18,$18,$30,$00,$00,$00,$00,$00
	DC.B	$0C,$18,$30,$30,$30,$18,$0C,$00
	DC.B	$30,$18,$0C,$0C,$0C,$18,$30,$00
	DC.B	$00,$6C,$38,$FE,$38,$6C,$00,$00
	DC.B	$00,$18,$18,$7E,$18,$18,$00,$00
	DC.B	$00,$00,$00,$00,$00,$18,$18,$10
	DC.B	$00,$00,$00,$7E,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$18,$18,$00
	DC.B	$02,$06,$0C,$18,$30,$60,$40,$00
	DC.B	$3C,$66,$6E,$76,$66,$66,$3C,$00
	DC.B	$18,$18,$38,$18,$18,$18,$3C,$00
	DC.B	$7C,$06,$06,$3C,$60,$60,$7E,$00
	DC.B	$7C,$06,$06,$1C,$06,$06,$7C,$00
	DC.B	$66,$66,$66,$7E,$06,$06,$06,$00
	DC.B	$7E,$60,$60,$7C,$06,$06,$7C,$00
	DC.B	$3E,$60,$60,$7C,$66,$66,$3C,$00
	DC.B	$7E,$06,$0C,$18,$18,$18,$18,$00
	DC.B	$3C,$66,$66,$3C,$66,$66,$3C,$00
	DC.B	$3C,$66,$66,$3E,$06,$06,$7C,$00
	DC.B	$00,$18,$18,$00,$18,$18,$00,$00
	DC.B	$00,$00,$18,$18,$00,$18,$18,$10
	DC.B	$0C,$18,$30,$60,$30,$18,$0C,$00
	DC.B	$00,$00,$7E,$00,$7E,$00,$00,$00
	DC.B	$30,$18,$0C,$06,$0C,$18,$30,$00
	DC.B	$3C,$66,$06,$1C,$18,$00,$18,$00
	DC.B	$3C,$66,$6E,$6E,$6E,$60,$3E,$00
	DC.B	$3C,$66,$66,$7E,$66,$66,$66,$00
	DC.B	$7C,$66,$66,$7C,$66,$66,$7C,$00
	DC.B	$3C,$66,$60,$60,$60,$66,$3C,$00
	DC.B	$7C,$66,$66,$66,$66,$66,$7C,$00
	DC.B	$7E,$60,$60,$78,$60,$60,$7E,$00
	DC.B	$7E,$60,$60,$78,$60,$60,$60,$00
	DC.B	$3C,$66,$60,$6E,$66,$66,$3C,$00
	DC.B	$66,$66,$66,$7E,$66,$66,$66,$00
	DC.B	$7E,$18,$18,$18,$18,$18,$7E,$00
	DC.B	$0E,$06,$06,$06,$06,$66,$3C,$00
	DC.B	$66,$6C,$78,$70,$78,$6C,$66,$00
	DC.B	$60,$60,$60,$60,$60,$60,$7E,$00
	DC.B	$C6,$EE,$FE,$D6,$C6,$C6,$C6,$00
	DC.B	$66,$76,$7E,$6E,$66,$66,$66,$00
	DC.B	$3C,$66,$66,$66,$66,$66,$3C,$00
	DC.B	$7C,$66,$66,$7C,$60,$60,$60,$00
	DC.B	$3C,$66,$66,$66,$6E,$6E,$3E,$00
	DC.B	$7C,$66,$66,$7C,$66,$66,$66,$00
	DC.B	$3E,$60,$60,$3C,$06,$06,$7C,$00
	DC.B	$7E,$18,$18,$18,$18,$18,$18,$00
	DC.B	$66,$66,$66,$66,$66,$66,$3C,$00
	DC.B	$66,$66,$66,$66,$3C,$3C,$18,$00
	DC.B	$C6,$C6,$C6,$D6,$FE,$EE,$C6,$00
	DC.B	$66,$66,$3C,$18,$3C,$66,$66,$00
	DC.B	$66,$66,$66,$3C,$18,$18,$18,$00
	DC.B	$7E,$06,$0C,$18,$30,$60,$7E,$00
	DC.B	$3C,$30,$30,$30,$30,$30,$3C,$00
	DC.B	$40,$60,$30,$18,$0C,$06,$02,$00
	DC.B	$3C,$0C,$0C,$0C,$0C,$0C,$3C,$00
	DC.B	$10,$38,$6C,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$FF
	DC.B	$18,$18,$08,$00,$00,$00,$00,$00
	DC.B	$00,$00,$3C,$06,$3E,$66,$3E,$00
	DC.B	$60,$60,$7C,$66,$66,$66,$7C,$00
	DC.B	$00,$00,$3C,$66,$60,$66,$3C,$00
	DC.B	$06,$06,$3E,$66,$66,$66,$3E,$00
	DC.B	$00,$00,$3C,$66,$7C,$60,$3E,$00
	DC.B	$0E,$18,$18,$3C,$18,$18,$3C,$00
	DC.B	$00,$00,$3E,$66,$66,$3E,$06,$7C
	DC.B	$60,$60,$7C,$66,$66,$66,$66,$00
	DC.B	$18,$00,$18,$18,$18,$18,$18,$00
	DC.B	$18,$00,$18,$18,$18,$18,$18,$70
	DC.B	$60,$60,$66,$6C,$78,$6C,$66,$00
	DC.B	$30,$30,$30,$30,$30,$30,$1C,$00
	DC.B	$00,$00,$CC,$FE,$D6,$C6,$C6,$00
	DC.B	$00,$00,$7C,$66,$66,$66,$66,$00
	DC.B	$00,$00,$3C,$66,$66,$66,$3C,$00
	DC.B	$00,$00,$7C,$66,$66,$7C,$60,$60
	DC.B	$00,$00,$3E,$66,$66,$3E,$06,$06
	DC.B	$00,$00,$36,$38,$30,$30,$30,$00
	DC.B	$00,$00,$3E,$60,$3C,$06,$7C,$00
	DC.B	$18,$18,$18,$3C,$18,$18,$0C,$00
	DC.B	$00,$00,$66,$66,$66,$66,$3C,$00
	DC.B	$00,$00,$66,$66,$3C,$3C,$18,$00
	DC.B	$00,$00,$C6,$C6,$D6,$FE,$EC,$00
	DC.B	$00,$00,$66,$3C,$18,$3C,$66,$00
	DC.B	$00,$00,$66,$66,$66,$3E,$06,$7C
	DC.B	$00,$00,$7E,$0C,$18,$30,$7E,$00
	DC.B	$04,$0C,$18,$30,$18,$0C,$04,$00
	DC.B	$20,$30,$18,$0C,$18,$30,$20,$00
	DC.B	$00,$00,$18,$3C,$66,$42,$00,$00
	DC.B	$00,$00,$42,$66,$3C,$18,$00,$00
	DC.B	$AA,$55,$AA,$55,$AA,$55,$AA,$55
