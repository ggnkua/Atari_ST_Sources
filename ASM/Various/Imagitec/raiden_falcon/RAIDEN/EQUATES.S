; RAIDEN EQUATES AND DATA STRUCTURE RESERVES

Height		Equ	240
Load_Buff_Size	Equ	340000
Null_Sprite	Equ	-1
Maximum_Amount_Of_Sprites	Equ	500	;600
Spit_Out_Delay	Equ	1
Frame_Rate	Equ	2
Consistancy_Frame_Rate	Equ	2
Max_Aliens	Equ 	90
Max_Buffer	Equ 	(1+Max_Aliens)*4
Byteswide	Equ	480		
Max_Ship_Anims	Equ	50		
Txt_X1		Equ	20
Txt_Line	Equ	10		
Max_Weapons	Equ	50		
Xplayarea	Equ	480-32
Yplayarea	Equ	240
Text_Height	Equ	25
Ded_Delay	Equ	240
Pow_Del		Equ	150
Track_Amount1	Equ	2
Track_Amount2	Equ	3
Max_Homes	Equ	16
Tank_Anm_Set	Equ	7
Turret_Anm_Set	Equ	8
Bomb8_Anm_Set	Equ	54
Rotary_Anm_Set	Equ	55
Powerup_Anm_Set0	Equ	10
Powerup_Anm_Set1	Equ	56
Player_Explosion_Delay	Equ	300
Boosterdn_anm_set	Equ	11
Boosterup_anm_set	Equ	12
Whirry_anm_set		Equ	13
PlaneDn_anm_Set		Equ	32
Planeup_anm_Set		Equ	33
Big_Tank_Anm_Set	Equ	39
Wheel_Anm_Set1		Equ	40
Wheel_Anm_Set2		Equ	41
Wheel_Anm_Set3		Equ	42
Wheel_Anm_Set4		Equ	57
End_Level_Anm_Set	Equ	58
End_Level_Wirry_anm_Set	Equ	59
Cannon_Anm_Set1		Equ	60
Cannon_Anm_Set2		Equ	61
Cannon_Anm_Set3		Equ	62
Cannon_Anm_Set4		Equ	63
Enlarged_Ship_Anm_Set	Equ	64
Enlarged_Boost_Anm_Set	Equ	65
Cannon_Base_Anm_Set	Equ	66
Cannon_Anm_Set		Equ	67
Casket1_Anm_Set		Equ	34
Casket2_Anm_Set		Equ	35
Bolt_Anm_Set		Equ	49
Pig_Anm_Set		Equ	50
Guardian_Xpl_delay	Equ	4
Bomb_Kill_Delay		Equ	6
Zooming_Anm_Set		Equ	51
Zoomer_Anm_Set		Equ	68
Tankboat_Anm_Set	Equ	69
Tankboat_bit_Anm_Set	Equ	70
Boatup_Anm_Set		Equ	71
Boatrt_Anm_Set		Equ	72
Boatdn_Anm_Set		Equ	73
Boatlt_Anm_Set		Equ	74
Car_Anm_Set		Equ	75
Bull1_Anm_set		Equ	76
Bull2_Anm_set		Equ	77
Front_Train_Anm_Set	Equ	78
Back_Train_Anm_Set	Equ	79
Front_Carraige_Anm_Set	Equ	80
Back_Carraige_Anm_Set	Equ	81
Front_Fire_Anm_Set	Equ	82
Diagonal_Front_Anm_Set	Equ	83
Diagonal_Back_Anm_Set	Equ	84
Diagonal_Carraige_Anm_Set	Equ	85
Diagpnal_Fire_Anm_Set_Anm_Set	Equ	86
End_Level_Guardian_Left_Anm_Set	Equ	87
End_Level_Guardian_Right_Anm_Set	Equ	88
End_Level_Wing_Left_Anm_Set	Equ	89
End_Level_Wing_Right_Anm_Set	Equ	90
End_Level_Boosters_Anm_Set	Equ	91
Guardian_Bits_Anm_Set		Equ	92
Guardian_Shoots_Anm_Set		Equ	93
Left_Transform_Anm_Set		Equ	94
Right_Transform_Anm_Set		Equ	95
Trendy_Bolts_Anm_Set		Equ	96
Scafolding_Right_Anm_Set1	Equ	99
Scafolding_Right_Anm_Set2	Equ	100
Scafolding_Left_Anm_Set1	Equ	101
Scafolding_Left_Anm_Set2	Equ	102
Travel_boat_Anmset		Equ	103
Travel_boat_Anmset1		Equ	104
Travel_boat_Anmset2		Equ	105
Monstrous_Anmset1		Equ	106
Monstrous_Anmset2		Equ	107
Jeep_Anmset1			Equ	108
Jeep_Anmset2			Equ	109
Jeep_Anmset3			Equ	110
Guardian_Lev3_Anmset1		Equ	111
Guardian_Lev3_Anmset2		Equ	112
Guardian_Lev3_Anmset3		Equ	113
Guardian_Lev3_Anmset4		Equ	114
Guardian_Lev3_Anmset5		Equ	115
Guardian_Lev3_Anmset6		Equ	116
Guardian_Lev3_Anmset7		Equ	117
Guardian_Lev3_Anmset8		Equ	118
Mid_Anmset			Equ	14

	Rsreset
Wep_Dmg		Rs.b	1
Wep_Sprite_Num	Rs.b	1
Wep_Anim	Rs.b	1
Wep_Delay	Rs.b	1
Wep_X		Rs.w	1
Wep_Y		Rs.w	1
Wep_XV		Rs.w	1		; Weapon structure
Wep_YV		Rs.w	1
Wep_Sprite	Rs.b	1
Wep_Sine_Val	Rs.b	1
Wep_Sine_Scale	Rs.b	1
Wep_Sine_Speed	Rs.b	1
Wep_End		Rs.b	0

	Rsreset
Aln_Dmg		Rs.w	1
Aln_Anim	Rs.b	1
Aln_Delay	Rs.b	1
Aln_AnmSet	Rs.w	1
Aln_Wave	Rs.w	1
Aln_X		Rs.w	1
Aln_Y		Rs.w	1
Aln_Shite	Rs.b	24

Aln_Pauseflag	Rs.b	1
Aln_AnimFlipdel	Rs.b	1
Aln_AnimFlipFlg	Rs.b	1
Aln_Reserve	Rs.b	1
Aln_AnimFlag	Rs.b	1
Aln_AnimCont	Rs.b	1
Aln_POWNUM	Rs.b	1
Aln_Track_val	Rs.b	1
Aln_Linkoffsets	Rs.l	1
Aln_PrevLink	Rs.l	1
Aln_Link	Rs.l	1
Aln_Seqdec	Rs.w	1
Aln_Seqp	Rs.l	1
Aln_Replocate	Rs.l	1
Aln_Repeat	Rs.w	1
Aln_Stack	Rs.l	1
Aln_Sprite	Rs.w	1
Aln_Coardkill	Rs.b	1
Aln_Prevsprite	Rs.b	1
Aln_End		Rs.b	0

	Rsreset
Spr_Use		Rs.w	1
Spr_Yadd	Rs.w	1
spr_Addr	Rs.l	1		; Weapon sprite structure
Spr_Height	Rs.w	1
Spr_Plane	Rs.w	1
Spr_Width	Rs.w	1
Spr_MaxShift	Rs.w	1
Spr_E		Rs.w	0
