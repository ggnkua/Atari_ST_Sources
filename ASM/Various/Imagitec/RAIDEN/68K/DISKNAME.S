Explosion_Patch_Header_Name
	Dc.b	"EXPPATCH.JHD",0
Explosion_Patch_Gfx_Name
	Dc.b	"EXPPATCH.JSP",0
BULLETS_HEADER
	Dc.b	"BULLETS.JHD",0
BULLETS_GFX
	Dc.b	"BULLETS.JSP",0
Options_Palette
	Dc.b	"OPTIONS.CPL",0
Options_Header
	Dc.b	"OPTIONS.JHD",0
Options_Gfx
	Dc.b	"OPTIONS.JSP",0
Continue_Mod_Name
	Dc.b	"CONTINUE.MOD",0
Interm_Mod_Name
	Dc.b	"INTERM.MOD",0
Guardian_Mod_Name
	Dc.b	"EOLG.MOD",0
Endgame_Mod_Name
	Dc.b	"ENDGAME.MOD",0
Gameover_Mod_Name
	Dc.b	"GAMEOVER.MOD",0
Title_Pal
	Dc.b	"TITLE.CPL",0
End_Screen_Pal
	Dc.b	"END-LEV.CPL",0
Atari_Pal
	Dc.b	"ATARI.CPL",0
IDL_Pal
	Dc.b	"IDL.CPL",0
Hi_Score_Name_Pal
	Dc.b	"HI_SCORE.CPL",0
Intro_Mod_Name
	Dc.b	"REGISTER.MOD",0
Hi_Mod_Name
	Dc.b	"INTRO.MOD",0
Intro_Header_Name
	Dc.b	"INTRO.JHD",0
Intro_Sprites_Name
	Dc.b	"INTRO.JSP",0
PLATES_Header_Name
	Dc.b	"PLATES.JHD",0
PLATES_Sprites_Name
	Dc.b	"PLATES.JSP",0
PLATES_Header_NameUK
	Dc.b	"PLATESUK.JHD",0
PLATES_Sprites_NameUK
	Dc.b	"PLATESUK.JSP",0
Player_HEADER_NAME
	Dc.b	"PLAYER.JHD",0
Player_SPRITES_NAME
	Dc.b	"PLAYER.JSP",0
	Even
Carrier_HEADER_NAME
	Dc.b	"CARRIER.JHD",0
Carrier_SPRITES_NAME
	Dc.b	"CARRIER.JSP",0
	Even

Rom_File_List
	Dc.l	Level1	
	Dc.l	Level2d
	Dc.l	Level3
	Dc.l	Level4
	Dc.l	Level5
	Dc.l	Level6
	Dc.l	Level7
	Dc.l	Level8

Level1
	Dc.b	"LEV1.CPL",0
	Dc.b	"EVENT1.BIN",0
	Dc.b	"BLOCKS1.BIN",0
	Dc.b	"SPRITES1.JHD",0
	Dc.b	"SPRITES1.JSP",0
	Dc.b	"RAIDEN1.MOD",0
	Dc.b	"LEV1.MAP",0
	Dc.b	"LEV1_MSK.MAP",0
	Dc.b	-1
Level2d
	Dc.b	"LEV2.CPL",0
	Dc.b	"EVENT2.BIN",0
	Dc.b	"BLOCKS2.BIN",0
	Dc.b	"SPRITES2.JHD",0
	Dc.b	"SPRITES2.JSP",0
	Dc.b	"RAIDEN2.MOD",0
	Dc.b	"LEV2.MAP",0
	Dc.b	"LEV2_PX1.MAP",0
	Dc.b	"LEV2_PX2.MAP",0
	Dc.b	-1

Level3
	Dc.b	"LEV3.CPL",0
	Dc.b	"EVENT3.BIN",0
	Dc.b	"BLOCKS3.BIN",0
	Dc.b	"SPRITES3.JHD",0
	Dc.b	"SPRITES3.JSP",0
	Dc.b	"RAIDEN3.MOD",0
	Dc.b	"LEV3.MAP",0
	Dc.b	"LEV3_MSK.MAP",0
	Dc.b	-1

Level4
	Dc.b	"LEV4.CPL",0
	Dc.b	"EVENT4.BIN",0
	Dc.b	"BLOCKS4.BIN",0
	Dc.b	"SPRITES4.JHD",0
	Dc.b	"SPRITES4.JSP",0
	Dc.b	"RAIDEN4.MOD",0
	Dc.b	"LEV4.MAP",0
	Dc.b	"LEV4_MSK.MAP",0
	Dc.b	-1


Level5
	Dc.b	"LEV5.CPL",0
	Dc.b	"EVENT5.BIN",0
	Dc.b	"BLOCKS5.BIN",0
	Dc.b	"SPRITES5.JHD",0
	Dc.b	"SPRITES5.JSP",0
	Dc.b	"RAIDEN5.MOD",0
	Dc.b	"LEV5.MAP",0
	Dc.b	"LEV5_MSK.MAP",0
	Dc.b	-1

Level6
	Dc.b	"LEV6.CPL",0
	Dc.b	"EVENT6.BIN",0
	Dc.b	"BLOCKS6.BIN",0
	Dc.b	"SPRITES6.JHD",0
	Dc.b	"SPRITES6.JSP",0
	Dc.b	"RAIDEN6.MOD",0
	Dc.b	"LEV6.MAP",0
	Dc.b	"LEV6_MSK.MAP",0
	Dc.b	-1

Level7
	Dc.b	"LEV7.CPL",0
	Dc.b	"EVENT7.BIN",0
	Dc.b	"BLOCKS7.BIN",0
	Dc.b	"SPRITES7.JHD",0
	Dc.b	"SPRITES7.JSP",0
	Dc.b	"RAIDEN7.MOD",0
	Dc.b	"LEV7.MAP",0
	Dc.b	"LEV7_MSK.MAP",0
	Dc.b	-1

Level8
	Dc.b	"LEV8.CPL",0
	Dc.b	"EVENT8.BIN",0
	Dc.b	"BLOCKS8.BIN",0
	Dc.b	"SPRITES8.JHD",0
	Dc.b	"SPRITES8.JSP",0
	Dc.b	"RAIDEN8.MOD",0
	Dc.b	"LEV8.MAP",0
	Dc.b	"LEV8_MSK.MAP",0
	Dc.b	-1,0
	Dc.b	"WASH.BIN",0
	Even
