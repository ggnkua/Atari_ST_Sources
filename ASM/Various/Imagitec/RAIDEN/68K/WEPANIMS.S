	Cnop	0,4
Wep_Anims
	Dc.l	.Wep_0,.Wep_1,.Wep_2,.Wep_3,.Wep_4,.Wep_5,.Wep_6
	Dc.l	.Wep_7,.Wep_8,.Wep_9,.Wep_10,.Wep_11
	Dc.l	.Wep_12,.Wep_13,.Wep_14,.Wep_15,.Wep_16
	Dc.l	.Wep_17,.Wep_18,.Wep_19,.Wep_20,.Wep_21
	Dc.l	.Wep_22
	Dc.l	.Wep_23
	Dc.l	.Wep_24

	Dc.l	.Wep_25,.Wep_26,.Wep_27
	Dc.l	.Wep_28,.Wep_29,.Wep_30
	Dc.l	.Wep_31,.Wep_32,.Wep_33,.Wep_34
	Dc.l	.Wep_35

	Dc.w	-1


.Wep_0	Dc.b	127,8,-1
.Wep_1	Dc.b	127,227,-1
.Wep_2	Dc.b	127,228,-1
.Wep_3	Dc.b	127,226,-1
.Wep_4	Dc.b	127,223,-1
.Wep_5	Dc.b	127,229,-1
.Wep_6	Dc.b	127,7,-1

.Wep_7	Dc.b	127,12,-1
.Wep_8	Dc.b	127,13,-1
.Wep_9	Dc.b	127,14,-1
.Wep_10	Dc.b	127,15,-1
.Wep_11	Dc.b	127,16,105,-1

.Wep_12	Dc.b	3,17,18,-1
.Wep_13	Dc.b	3,17,18,-1
.Wep_14	Dc.b	3,78,79,-1
.Wep_15	Dc.b	3,78,79,-1
.Wep_16	Dc.b	3,80,81,-1

.Wep_17	Dc.b	127,19,-1
.Wep_18	Dc.b	127,19,-1
.Wep_19	Dc.b	127,35,-1
.Wep_20	Dc.b	127,35,-1
.Wep_21	Dc.b	127,62,-1

.Wep_22 Dc.b	1,84,85,86,87,-1
.Wep_23	Dc.b	1,168,169,170,171,-1
.Wep_24	Dc.b	1,176,177,178,-1

.Wep_25	Dc.b	127,9,-1
.Wep_26	Dc.b	127,6,-1
.Wep_27	Dc.b	127,10,-1
.Wep_28	Dc.b	127,233,-1
.Wep_29	Dc.b	127,225,-1
.Wep_30	Dc.b	127,224,-1
.Wep_31	Dc.b	127,230,-1
.Wep_32	Dc.b	127,234,-1
.Wep_33	Dc.b	127,5,-1
.Wep_34	Dc.b	127,11,-1

.Wep_35	Dc.b	1,193,194,195,-1
	Even
