
Bomb_Bonus	Dc.l	$00000150
Medal_Bonus	Dc.l	$00000300
Score_Added_When_Ya_Hit	Dc.l	$00000010

	Dc.l	$00000000
ScoreTable
	Dcb.l	16,$150
	Dcb.l	16,$100
	Dcb.l	16,$100
;48
	Dcb.l	02,$0
	Dcb.l	01,$1000
;51
	Dcb.l   13,$0
;64
	Dcb.l   28,$0
;92
	Dcb.l   03,$500
	Dcb.l   01,$0
	Dcb.l   01,$500
	Dcb.l   03,$0
	Dcb.l   01,$500
	Dcb.l   01,$500
;102
	Dcb.l	108-102,$0
	Dc.l	$500
	Dcb.l	121-109,$0
;121
	Dcb.l   16,$150
	Dcb.l   16,$100
;153
	Dcb.l   09,$0
	Dcb.l   01,$500
	Dcb.l   01,$250
;164
	Dcb.l   19,$0
;183
	Dcb.l   01,$10000
	Dcb.l   16,$0
;200
	Dcb.l   17,$100
	Dcb.l   01,$500
	Dcb.l   02,$0
;220
	Dcb.l   04,$150
	Dcb.l	2,$3000
	Dcb.l   04,$0
;230
	Dcb.l   32,$150
	Dcb.l   02,$100
	Dcb.l   01,$500
;265
	Dcb.l   01,$0
	Dcb.l   04,$100
	Dcb.l   02,$10000
;272
	Dcb.l   02,$500
	Dcb.l   02,$0
	Dcb.l   01,$300
	Dcb.l   01,$0
	Dcb.l   02,$100
;280
	Dcb.l	10,$0
	Dcb.l	01,$300
;291
	Dcb.l   02,$200
	Dcb.l   08,$0
	Dcb.l   02,$15000
	Dcb.l   02,$1000
;305
	Dcb.l   20,$0
	Dcb.l   01,$200
	Dcb.l   01,$300
	Dcb.l   04,$250
;331
	Dcb.l   01,$500
	Dcb.l   33,$0
;365
	Dcb.l   08,$20000
	Dcb.l   24,$500
;397
	Dcb.l   08,$750
	Dcb.l   03,$0
;408
	Dcb.l  	09,$400
	Dcb.l  	01,$0
	Dcb.l  	03,$500
;421
	Dcb.l   01,$2000
	Dcb.l	5,$400
	Dcb.l	3,$0
	Dcb.l   24-8,$0
;446
	Dcb.l   02,$1000
	Dcb.l   12,$0
;460
	Dcb.l   08,$150
	Dcb.l   04,$100
	Dcb.l   07,$0
;479
	Dcb.l   08,$25000
;487
	Dcb.l	04,$0
	Dcb.l	01,$1500
	Dcb.l	05,$0
;497   
        Dcb.l   02,$2500
        Dcb.l   02,$0
        Dcb.l   12,$250
;513
	Dcb.l   01,$500
	Dcb.l   03,$400
	Dcb.l   04,$0
;521
	Dcb.l   02,$1000
	Dcb.l   11,$0
	Dcb.l   01,$30000
;535
	Dcb.l   03,$0
	Dcb.l   02,$2500
	Dcb.l   20,$0
;560
	Dcb.l   07,$2500
	Dcb.l   01,$0
;568
        Dcb.l   16,$500
;584
 	Dcb.l   32,$150
 	Dcb.l   01,$200
 	Dcb.l   02,$250
;619
	Dcb.l   04,$2500
	Dcb.l   05,$0
	Dcb.l   02,$1500
;630
	Dcb.l   50,$0
	Dcb.l   01,$3000
;681
	Dcb.l   19,$0
	Dcb.l   09,$150
;709
	Dcb.l   17,$0
	Dcb.l   02,$150
;728
	Dcb.l   12,$0
	Dcb.l   02,$150
;742
	Dcb.l   48,$100
	Dcb.l   01,$1000
;791
        Dcb.l   02,$0
        Dcb.l   01,$2000
        Dcb.l   05,$0
        Dcb.l   01,$500
        Dcb.l   01,$100
;801
        Dcb.l   20,$100
        Dcb.l   60,$0
;881
	Dcb.l   01,$10000
	Dcb.l   50,$0
	Dcb.l   50,$0
	Dcb.l   01,$40000
;983
	Dcb.l   02,$0
	Dcb.l   48,$100
;1033
	Dcb.l   03,$150
	Dcb.l   22,$0
;1058
   	Dcb.l   01,$2000
   	Dcb.l   48,$0
;1107
  	Dcb.l	01,$12500
  	Dcb.l	10,$0
;1118

	Dcb.l   27,$2500
;1145
 	Dcb.l   25,$0
 	Dcb.l   02,$1000
;1172
	Dcb.l   65,$0
	Dcb.l   50,$0
;1287
	Dcb.l   02,$50000
	Dcb.l   02,$2500
	Dcb.l   09,$0
;1300
	Dcb.l   10,$1000
 	Dcb.l   58,$0
 	Dcb.l   58,$0
;1426
	Dcb.l   02,$1000
	Dcb.l   01,$0
	Dcb.l   25,$250
;1454
	Dcb.l   23,$0
 










 









	





 







         








        



























  



