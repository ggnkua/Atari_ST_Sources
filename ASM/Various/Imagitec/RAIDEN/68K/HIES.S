
High_Score_Table_Rom
	Dc.b	"FRD"
	Dc.b	$00,$40,$00,$30
	Dc.b	$10,$30

	Dc.b	"KEV"
	Dc.b	$00,$35,$00,$00
	Dc.b	$10,$30

	Dc.b	"IAN"
	Dc.b	$00,$30,$00,$00
	Dc.b	$10,$30

	Dc.b	"COL"
	Dc.b	$00,$25,$00,$00
	Dc.b	$10,$30

	Dc.b	"ROD"
	Dc.b	$00,$20,$00,$00
	Dc.b	$10,$30

	Dc.b	"STV"
	Dc.b	$00,$15,$00,$00
	Dc.b	$10,$30

	Dc.b	"JOE"
	Dc.b	$00,$10,$00,$00
	Dc.b	$10,$30

	Dc.b	"JON"
	Dc.b	$00,$05,$00,$00
	Dc.b	$10,$30

	Dc.b	"TRV"
	Dc.b	$00,$02,$50,$00
	Dc.b	$10,$30

	Dc.b	"MRV"
	Dc.b	$00,$01,$00,$00
	Dc.b	$10,$30
	Even
High_Score_Table_Rome

High_Score_Table
	Dc.b	"FRD"
	Dc.b	$00,$40,$00,$10
	Dc.b	$10,$30

	Dc.b	"KEV"
	Dc.b	$00,$35,$00,$00
	Dc.b	$10,$30

	Dc.b	"IAN"
	Dc.b	$00,$30,$00,$00
	Dc.b	$10,$30

	Dc.b	"COL"
	Dc.b	$00,$25,$00,$00
	Dc.b	$10,$30

	Dc.b	"ROD"
	Dc.b	$00,$20,$00,$00
	Dc.b	$10,$30

	Dc.b	"STV"
	Dc.b	$00,$15,$00,$00
	Dc.b	$10,$30

	Dc.b	"JOE"
	Dc.b	$00,$10,$00,$00
	Dc.b	$10,$30

	Dc.b	"JON"
	Dc.b	$00,$05,$00,$00
	Dc.b	$10,$30

	Dc.b	"TRV"
	Dc.b	$00,$02,$50,$00
	Dc.b	$10,$30

	Dc.b	"MRV"
	Dc.b	$00,$01,$00,$00
	Dc.b	$10,$30
	Even
High_Score_Tablee
