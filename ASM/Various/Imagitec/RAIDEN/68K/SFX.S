; Sound fx

Powerup_SFX
	Dc.w	.Dataend-.Datastart
	Dc.w	15
	Dc.w	$3fff
	Dc.w	$1a0

.Datastart
	Incbin	D:\raiden\gamedata\Powerup2
.Dataend

Misc_Weapon_Hit_SFX
	Dc.w	.Dataend-.Datastart
	Dc.w	4
	Dc.w	$3fff
	Dc.w	$120

.Datastart
	Incbin	D:\raiden\gamedata\Misshit
.Dataend


PlayerExplosion_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	14
	Dc.w	$3fff
	Dc.w	$a0

.Datastart
	Incbin	D:\raiden\gamedata\Playexpl
.Dataend


BabyExplosion_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	4
	Dc.w	$3fff
	Dc.w	$80

.Datastart
	Incbin	D:\raiden\gamedata\Babyexpl
.Dataend

BigExplosion_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	10
	Dc.w	$3fff
	Dc.w	$70

.Datastart
	Incbin	D:\raiden\gamedata\BigExplo
.Dataend

Collect_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	5
	Dc.w	$3fff
	Dc.w	$300

.Datastart
	Incbin	D:\raiden\gamedata\Collect3
.Dataend


Laser_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	3
	Dc.w	$3fff
	Dc.w	$50

.Datastart
	Incbin	D:\raiden\gamedata\Lazer2
.Dataend

Shot_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	3
	Dc.w	$3fff
	Dc.w	$100

.Datastart
	Incbin	D:\raiden\gamedata\Shots
.Dataend

Bomb_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	15
	Dc.w	$3fff
	Dc.w	$d0

.Datastart
	Incbin	D:\raiden\gamedata\Drop
.Dataend

Massive_Explosion_Sfx
	Dc.w	.Dataend-.Datastart
	Dc.w	15
	Dc.w	$3fff
	Dc.w	$100-$a0

.Datastart
	Incbin	D:\raiden\gamedata\BigExplo
.Dataend

Name_Reg_Samp
	Dc.w	.Dataend-.Datastart
	Dc.w	14
	Dc.w	$3fff
	Dc.w	$100

.Datastart
	Incbin	D:\raiden\gamedata\Name
.Dataend

High_Score_Beep_Samp
	Dc.w	.Dataend-.Datastart
	Dc.w	14
	Dc.w	$3fff
	Dc.w	$d0

.Datastart
	Incbin	D:\raiden\gamedata\Counter
.Dataend

Shot_Hit_SFX
	Dc.w	.Dataend-.Datastart
	Dc.w	4
	Dc.w	$3fff
	Dc.w	$d0

.Datastart
	Incbin	D:\raiden\gamedata\Shothit
.Dataend

Lazer_Hit_SFX
	Dc.w	.Dataend-.Datastart
	Dc.w	4
	Dc.w	$3fff
	Dc.w	$d0

.Datastart
	Incbin	D:\raiden\gamedata\Lazhit
.Dataend

