	Dc.b	0
Alien_Track_Numbers
	Dc.b	1
	Dcb.b	7-1,0
	Dc.b	2,2
	Dcb.b	51-9,0
	Dc.b	2
	Dcb.b	67-52,0
	Dc.b	2
	Dcb.b	107-68,0
	Dc.b	2
	Dcb.b	206-108,0
	Dc.b	2,0,2,2
	Dcb.b	254-210,0
	Dc.b	2,2
	Dcb.b	282-256,0
	Dc.b	2
	Dcb.b	295-283,0
	Dc.b	2
	Dcb.b	308-296,0
	Dc.b	2
	Dcb.b	317-309,0
	Dc.b	3
	Dcb.b	386-318,0
	Dc.b	2
	Dcb.b	200,0

	Dc.b	0
Alien_Power_Numbers
	Dcb.b	10-0,0
	Dc.b	1
	Dcb.b	34-11,0
	Dc.b	1,1
	Dcb.b	45-36,0
	Dc.b	1
	Dcb.b	99-46,0
	Dc.b	1,0,1
	Dcb.b	207-102,0
	Dc.b	1
	Dcb.b	222-208,0
	Dc.b	1
	Ds.b	300
	Even