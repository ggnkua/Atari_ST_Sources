	Dc.b	0
Search_Prev_Alien_Table
	Dcb.b	8-0,0
	Dc.b	1
	Dcb.b	67-9,0
	Dc.b	1
	Dcb.b	89-68,0
	Dc.b	1,1
	Dcb.b	120-91,0
	Dc.b	1,1,1
	Dcb.b	124-123,0
	Dc.b	1
	Dc.b	1
	Dc.b	1
	Dc.b	1
	Dc.b	1
	Dcb.b	175-129,0
	Dc.b	1
	Dcb.b	188-176,0
	Dc.b	1,1
	Dcb.b	203-190,0
	Dc.b	1
	Dcb.b	206-204,0
	Dc.b	1
	Dcb.b	277-207,0
	Dc.b	1
	Dcb.b	280-278,0
	Dc.b	1
	Dcb.b	295-281,0
	Dc.b	1
	Dcb.b	317-296,0
	Dc.b	1
	Dc.b	1
	Dc.b	1
	Dcb.b	330-320,0
	Dc.b	1
	Dc.b	1
	Dcb.b	343-332,0
	Dc.b	1,1,1
	Dcb.b	360-346,0
	Dc.b	1,1
	Dc.b	0
	Dc.b	1,1
	Dcb.b	371-365,0
	Dc.b	1,1
	Dcb.b	500-373,0	
	Even
	
