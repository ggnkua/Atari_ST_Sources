	DC.L	$00404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040,$40404040
	DC.L	$00202D32,$3637393A,$3A3B3B3C,$3C3C3D3D,$3D3D3D3D,$3D3E3E3E,$3E3E3E3E,$3E3E3E3E,$3E3E3E3E,$3E3E3E3E,$3E3F3F3F,$3F3F3F3F,$3F3F3F3F,$3F3F3F3F,$3F3F3F3F,$3F3F3F3F
	DC.L	$00122028,$2D303234,$36373738,$39393A3A,$3A3B3B3B,$3B3C3C3C,$3C3C3C3C,$3D3D3D3D,$3D3D3D3D,$3D3D3D3D,$3D3E3E3E,$3E3E3E3E,$3E3E3E3E,$3E3E3E3E,$3E3E3E3E,$3E3E3E3E
	DC.L	$000D1720,$25292D2F,$31323435,$36363737,$38383939,$393A3A3A,$3A3B3B3B,$3B3B3B3C,$3C3C3C3C,$3C3C3C3C,$3C3D3D3D,$3D3D3D3D,$3D3D3D3D,$3D3D3D3D,$3D3D3D3D,$3D3D3E3E
	DC.L	$0009121A,$2024282A,$2D2E3031,$32333435,$36363737,$37383838,$3939393A,$3A3A3A3A,$3A3B3B3B,$3B3B3B3B,$3B3C3C3C,$3C3C3C3C,$3C3C3C3C,$3C3C3C3D,$3D3D3D3D,$3D3D3D3D
	DC.L	$00080F16,$1B202326,$292B2D2E,$2F313232,$33343435,$36363637,$37373838,$38393939,$39393A3A,$3A3A3A3A,$3A3B3B3B,$3B3B3B3B,$3B3B3B3C,$3C3C3C3C,$3C3C3C3C,$3C3C3C3C
	DC.L	$00060D12,$171C2023,$2528292B,$2D2E2F30,$31323233,$34343535,$36363637,$37373738,$38383839,$39393939,$393A3A3A,$3A3A3A3A,$3A3B3B3B,$3B3B3B3B,$3B3B3B3B,$3B3C3C3C
	DC.L	$00050B10,$15191C20,$22252728,$2A2B2D2E,$2F303031,$32323333,$34343535,$36363636,$37373737,$38383838,$38393939,$39393939,$3A3A3A3A,$3A3A3A3A,$3A3B3B3B,$3B3B3B3B
	DC.L	$0005090E,$12161A1D,$20222426,$28292A2C,$2D2E2E2F,$30313132,$32333334,$34353535,$36363636,$37373737,$37383838,$38383839,$39393939,$39393A3A,$3A3A3A3A,$3A3A3A3A
	DC.L	$0004080D,$1114171A,$1D202224,$25272829,$2B2C2D2D,$2E2F3030,$31313232,$33333434,$34353535,$36363636,$36373737,$37373838,$38383838,$39393939,$39393939,$393A3A3A
	DC.L	$0004080B,$0F121618,$1B1D2021,$23252628,$292A2B2C,$2D2D2E2F,$2F303131,$32323233,$33343434,$34353535,$36363636,$36373737,$37373738,$38383838,$38383939,$39393939
	DC.L	$0003070A,$0E111417,$191B1E20,$21232426,$2728292A,$2B2C2D2D,$2E2F2F30,$30313132,$32323333,$33343434,$35353535,$36363636,$36373737,$37373737,$38383838,$38383838
	DC.L	$00030609,$0D101215,$171A1C1E,$20212324,$25262829,$292A2B2C,$2D2D2E2E,$2F303030,$31313232,$32333333,$34343434,$35353535,$36363636,$36363737,$37373737,$37383838
	DC.L	$00030609,$0C0E1114,$16181A1C,$1E202122,$24252627,$28292A2B,$2B2C2D2D,$2E2E2F2F,$30303131,$31323232,$33333334,$34343435,$35353535,$36363636,$36363737,$37373737
	DC.L	$00020508,$0B0D1012,$1517191B,$1C1E2021,$22232526,$27282829,$2A2B2B2C,$2D2D2E2E,$2F2F3030,$30313131,$32323233,$33333334,$34343435,$35353535,$36363636,$36363637
	DC.L	$00020508,$0A0D0F11,$13161719,$1B1D1E20,$21222324,$25262728,$29292A2B,$2B2C2D2D,$2E2E2F2F,$2F303031,$31313232,$32323333,$33333434,$34343435,$35353535,$36363636
	DC.L	$00020507,$090C0E10,$12141618,$1A1B1D1E,$20212223,$24252627,$2828292A,$2A2B2C2C,$2D2D2E2E,$2E2F2F30,$30303131,$31323232,$32333333,$33343434,$34343535,$35353535
	DC.L	$00020407,$090B0D0F,$11131517,$191A1C1D,$1E202122,$23242526,$26272829,$292A2A2B,$2C2C2D2D,$2E2E2E2F,$2F2F3030,$30313131,$32323232,$33333333,$33343434,$34343535
	DC.L	$00020406,$080B0D0F,$11121416,$17191A1C,$1D1E2021,$22232424,$25262728,$2829292A,$2B2B2C2C,$2D2D2D2E,$2E2F2F2F,$30303031,$31313132,$32323233,$33333333,$34343434
	DC.L	$00020406,$080A0C0E,$10121315,$1618191B,$1C1D1E20,$21222223,$24252627,$27282829,$2A2A2B2B,$2C2C2D2D,$2D2E2E2F,$2F2F3030,$30303131,$31313232,$32323333,$33333334
	DC.L	$00020406,$08090B0D,$0F111214,$1617181A,$1B1C1D1E,$20202122,$23242526,$26272828,$29292A2A,$2B2B2C2C,$2D2D2D2E,$2E2E2F2F,$2F303030,$31313131,$32323232,$32333333
	DC.L	$00010305,$07090B0D,$0E101213,$15161719,$1A1B1C1D,$1F202021,$22232425,$25262727,$28282929,$2A2A2B2B,$2C2C2D2D,$2D2E2E2E,$2F2F2F30,$30303031,$31313132,$32323232
	DC.L	$00010305,$07090A0C,$0E0F1112,$14151718,$191A1B1D,$1E1F2020,$21222324,$24252626,$27282829,$292A2A2B,$2B2B2C2C,$2D2D2D2E,$2E2E2F2F,$2F2F3030,$30303131,$31313232
	DC.L	$00010305,$07080A0C,$0D0F1012,$13141617,$18191B1C,$1D1E1F20,$20212223,$23242525,$26272728,$2829292A,$2A2B2B2B,$2C2C2D2D,$2D2E2E2E,$2F2F2F2F,$30303030,$31313131
	DC.L	$00010305,$0608090B,$0D0E1011,$12141516,$17191A1B,$1C1D1E1F,$20202122,$23232425,$25262627,$28282929,$292A2A2B,$2B2C2C2C,$2D2D2D2E,$2E2E2E2F,$2F2F3030,$30303031
	DC.L	$00010304,$0608090B,$0C0E0F10,$12131416,$1718191A,$1B1C1D1E,$1F202021,$22232324,$24252626,$27272828,$29292A2A,$2A2B2B2C,$2C2C2D2D,$2D2E2E2E,$2E2F2F2F,$2F303030
	DC.L	$00010304,$0607090A,$0C0D0E10,$11121415,$16171819,$1A1B1C1D,$1E1F2020,$21222223,$24242525,$26272728,$28282929,$2A2A2B2B,$2B2C2C2C,$2D2D2D2E,$2E2E2E2F,$2F2F2F30
	DC.L	$00010304,$0507080A,$0B0D0E0F,$11121314,$15161718,$191A1B1C,$1D1E1F20,$20212222,$23242425,$25262627,$27282829,$29292A2A,$2B2B2B2C,$2C2C2D2D,$2D2D2E2E,$2E2F2F2F
	DC.L	$00010204,$05070809,$0B0C0D0F,$10111214,$15161718,$191A1B1C,$1C1D1E1F,$20202122,$22232324,$25252626,$27272828,$2829292A,$2A2A2B2B,$2B2C2C2C,$2D2D2D2D,$2E2E2E2E
	DC.L	$00010204,$05060809,$0A0C0D0E,$0F111213,$14151617,$18191A1B,$1C1C1D1E,$1F202021,$22222323,$24242525,$26262727,$28282929,$292A2A2A,$2B2B2B2C,$2C2C2D2D,$2D2D2E2E
	DC.L	$00010204,$05060809,$0A0B0D0E,$0F101112,$13151617,$1718191A,$1B1C1D1D,$1E1F2020,$21212223,$23242425,$25262627,$27282828,$2929292A,$2A2B2B2B,$2B2C2C2C,$2D2D2D2D
	DC.L	$00010203,$05060709,$0A0B0C0D,$0F101112,$13141516,$1718191A,$1A1B1C1D,$1D1E1F20,$20212122,$23232424,$25252626,$26272728,$28292929,$2A2A2A2B,$2B2B2C2C,$2C2C2D2D
	DC.L	$00010203,$05060708,$090B0C0D,$0E0F1011,$12131415,$16171819,$1A1B1B1C,$1D1D1E1F,$20202121,$22222324,$24242525,$26262727,$28282829,$29292A2A,$2A2B2B2B,$2C2C2C2C
	DC.L	$00010203,$04060708,$090A0B0D,$0E0F1011,$12131415,$16171718,$191A1B1B,$1C1D1E1E,$1F202021,$21222223,$23242425,$25262627,$27272828,$28292929,$2A2A2A2B,$2B2B2C2C
	DC.L	$00010203,$04050708,$090A0B0C,$0D0E0F10,$11121314,$15161718,$19191A1B,$1C1C1D1E,$1E1F2020,$21212222,$23232424,$25252626,$26272728,$28282929,$292A2A2A,$2A2B2B2B
	DC.L	$00010203,$04050608,$090A0B0C,$0D0E0F10,$11121314,$15161617,$18191A1A,$1B1C1C1D,$1E1E1F20,$20212122,$22232324,$24252525,$26262727,$27282828,$2929292A,$2A2A2B2B
	DC.L	$00010203,$04050607,$08090B0C,$0D0E0F10,$11111213,$14151617,$1718191A,$1A1B1C1C,$1D1E1E1F,$20202121,$22222323,$24242425,$25262626,$27272828,$28292929,$292A2A2A
	DC.L	$00010203,$04050607,$08090A0B,$0C0D0E0F,$10111213,$14151516,$17181819,$1A1B1B1C,$1D1D1E1E,$1F202021,$21222223,$23232424,$25252626,$26272727,$28282829,$29292A2A
	DC.L	$00010203,$04050607,$08090A0B,$0C0D0E0F,$10111212,$13141516,$16171819,$191A1B1B,$1C1D1D1E,$1E1F2020,$21212222,$22232324,$24252525,$26262727,$27282828,$28292929
	DC.L	$00010203,$04050607,$08090A0B,$0C0D0E0E,$0F101112,$13141415,$16171718,$191A1A1B,$1B1C1D1D,$1E1E1F20,$20212121,$22222323,$24242525,$25262626,$27272728,$28282929
	DC.L	$00010203,$04050607,$0809090A,$0B0C0D0E,$0F101112,$12131415,$16161718,$18191A1A,$1B1C1C1D,$1D1E1E1F,$20202021,$21222223,$23242424,$25252626,$26272727,$28282828
	DC.L	$00000102,$03040506,$0708090A,$0B0C0D0E,$0F101011,$12131414,$15161717,$1819191A,$1B1B1C1C,$1D1D1E1E,$1F202020,$21212222,$23232424,$24252525,$26262627,$27272828
	DC.L	$00000102,$03040506,$0708090A,$0B0C0D0D,$0E0F1011,$12121314,$15151617,$17181919,$1A1B1B1C,$1C1D1D1E,$1F1F2020,$20212122,$22232323,$24242525,$25262626,$27272728
	DC.L	$00000102,$03040506,$0708090A,$0B0B0C0D,$0E0F1010,$11121314,$14151616,$17181819,$1A1A1B1B,$1C1C1D1E,$1E1F1F20,$20202121,$22222323,$23242424,$25252626,$26262727
	DC.L	$00000102,$03040506,$07080909,$0A0B0C0D,$0E0F0F10,$11121213,$14151516,$17171819,$191A1A1B,$1B1C1D1D,$1E1E1F1F,$20202021,$21222222,$23232424,$24252525,$26262627
	DC.L	$00000102,$03040506,$07080809,$0A0B0C0D,$0D0E0F10,$11111213,$13141516,$16171718,$19191A1A,$1B1C1C1D,$1D1E1E1F,$1F202020,$21212222,$22232324,$24242525,$25262626
	DC.L	$00000102,$03040506,$07070809,$0A0B0C0C,$0D0E0F0F,$10111212,$13141415,$16161718,$1819191A,$1B1B1C1C,$1D1D1E1E,$1F1F2020,$20212122,$22222323,$23242425,$25252526
	DC.L	$00000102,$03040506,$06070809,$0A0A0B0C,$0D0E0E0F,$10111112,$13131415,$15161717,$1818191A,$1A1B1B1C,$1C1D1D1E,$1E1F1F20,$20202121,$22222223,$23232424,$24252525
	DC.L	$00000102,$03040505,$06070809,$090A0B0C,$0D0D0E0F,$10101112,$12131414,$15161617,$17181919,$1A1A1B1B,$1C1C1D1D,$1E1E1F1F,$20202021,$21222222,$23232324,$24242525
	DC.L	$00000102,$03040405,$06070808,$090A0B0C,$0C0D0E0F,$0F101111,$12131314,$15151616,$17181819,$191A1A1B,$1B1C1C1D,$1D1E1E1F,$1F202020,$21212122,$22232323,$24242425
	DC.L	$00000102,$03040405,$06070808,$090A0B0B,$0C0D0E0E,$0F101011,$12121314,$14151616,$17171818,$19191A1A,$1B1B1C1C,$1D1D1E1E,$1F1F2020,$20212121,$22222323,$23242424
	DC.L	$00000102,$03030405,$06070708,$090A0A0B,$0C0D0D0E,$0F0F1011,$11121313,$14151516,$16171718,$19191A1A,$1B1B1C1C,$1D1D1D1E,$1E1F1F20,$20202121,$21222222,$23232324
	DC.L	$00000102,$03030405,$06060708,$09090A0B,$0C0C0D0E,$0E0F1010,$11121213,$14141515,$16171718,$1819191A,$1A1B1B1C,$1C1D1D1D,$1E1E1F1F,$20202021,$21212222,$22232323
	DC.L	$00000102,$03030405,$06060708,$09090A0B,$0B0C0D0E,$0E0F1010,$11111213,$13141415,$16161717,$18181919,$1A1A1B1B,$1C1C1D1D,$1D1E1E1F,$1F202020,$21212122,$22222323
	DC.L	$00000102,$03030405,$05060708,$08090A0B,$0B0C0D0D,$0E0F0F10,$11111212,$13141415,$15161617,$17181819,$191A1A1B,$1B1C1C1D,$1D1E1E1E,$1F1F2020,$20212121,$22222223
	DC.L	$00000102,$02030405,$05060708,$08090A0A,$0B0C0C0D,$0E0E0F10,$10111112,$13131414,$15161617,$17181819,$191A1A1B,$1B1B1C1C,$1D1D1E1E,$1E1F1F20,$20202121,$21222222
	DC.L	$00000102,$02030405,$05060707,$0809090A,$0B0C0C0D,$0D0E0F0F,$10111112,$12131414,$15151616,$17171818,$19191A1A,$1B1B1C1C,$1C1D1D1E,$1E1E1F1F,$20202021,$21212222
	DC.L	$00000102,$02030404,$05060707,$0809090A,$0B0B0C0D,$0D0E0F0F,$10101112,$12131314,$14151516,$16171718,$1819191A,$1A1B1B1C,$1C1C1D1D,$1E1E1E1F,$1F202020,$21212122
	DC.L	$00000102,$02030404,$05060607,$0808090A,$0A0B0C0C,$0D0E0E0F,$0F101111,$12121313,$14151516,$16171718,$18191919,$1A1A1B1B,$1C1C1C1D,$1D1E1E1E,$1F1F2020,$20212121
	DC.L	$00000102,$02030404,$05060607,$0808090A,$0A0B0C0C,$0D0D0E0F,$0F101011,$12121313,$14141515,$16161717,$18181919,$1A1A1A1B,$1B1C1C1D,$1D1D1E1E,$1E1F1F20,$20202121
	DC.L	$00000102,$02030404,$05060607,$08080909,$0A0B0B0C,$0D0D0E0E,$0F101011,$11121213,$13141515,$16161717,$17181819,$191A1A1B,$1B1B1C1C,$1D1D1D1E,$1E1E1F1F,$20202020
	DC.L	$00000102,$02030304,$05050607,$07080909,$0A0B0B0C,$0C0D0E0E,$0F0F1010,$11121213,$13141415,$15161617,$17181819,$19191A1A,$1B1B1B1C,$1C1D1D1D,$1E1E1E1F,$1F202020
	DC.L	$00000101,$02030304,$05050607,$07080909,$0A0A0B0C,$0C0D0D0E,$0F0F1010,$11111212,$13131414,$15151616,$17171818,$19191A1A,$1A1B1B1C,$1C1C1D1D,$1D1E1E1E,$1F1F2020
	DC.L	$00000101,$02030304,$05050607,$07080809,$0A0A0B0B,$0C0D0D0E,$0E0F0F10,$11111212,$13131414,$15151616,$17171718,$1819191A,$1A1A1B1B,$1C1C1C1D,$1D1D1E1E,$1F1F1F20
