; CONVERTS MARVS SPRITES > ANIM EQUIVALENT!
	Even
	Dc.w	-1
Anim_Convert_Table
	Dcb.w	16,0		;0-15
	Dcb.w	16,7		;16-31
	Dcb.w	18,0
	Dcb.w	01,14		;50

	Dcb.w	64-51
	Dc.w	205		; 64		; 2nd cannon
	Dc.w	208		; 65		; Hi priority tank !
	Dc.w	207		; 66		; Hi priority grey casket !
	Dc.w	223		; 67		; Silly tank up
	Dc.w	224		; 68		; Silly tank right

	Dc.w	97		; Truck 
	Dc.w	98		; Car!

	Ds.w	91-71				; 91-Gret tank!

	Dcb.w	1,45		;91
	Dcb.w	3,39		;92
	Dcb.w	1,0
	Dc.w	32		;96
	Dcb.w	3,0
	Dcb.w	1,45		; 100 - Medal > Tree !
	Dc.w	10		;101
	Dcb.w	105-102		;102
	Dc.w	207
	Dc.w	294		;106
	Dcb.w	118-107,0
	Dc.w	208,208

	Dcb.w	162-120,0
	Dc.w	33		;162
	Dc.w	54		;163
	Dcb.w	3,0		;164
	Dcb.w	3,44		;167
	Dcb.w	13,58		;170
	
	Dcb.w	01,58		;183
	Dcb.w	01,197		;184
	Dcb.w	15,58		;185

	Dc.w	66		;200
	Dcb.w	16,0		;201
	Dc.w	64		;217
	Dcb.w	2,0		;218
	Dcb.w	2,34		;220
	Dcb.w	2,35		;222
	Dcb.w	6,0		;224
	Dcb.w	32,51		;230
	Dcb.w	2,68		;262
	Dcb.w	2,69		;264
	Dc.w	71,72,73,74	;266
	Dcb.w	2,75		;270
	Dc.w	76,77		;272
	Dc.w	78,78		;274
	Dc.w	79		;276
	Dc.w	80,80		;277
	Dc.w	0		;279
	Dcb.w	8,0		;280
	Dcb.w	2,83		;288
	Dc.w	1		;290
	Dcb.w	2,85		;291
	Dcb.w	8,0		;293
	Dc.w	87		;301

	Ds.w	325-302
	Dc.w	97,98		;325
	Dc.w	99,100		;327
	Dc.w	101,102		;329
	Dc.w	103		;331
	Ds.w	340-332		;332
	Dc.w	106		;340
	Ds.w	357-341		;341
	Dcb.w	365-357-1,108	;357

	Dcb.w	408-365+1,111	; HUMM!-End lev3 guard !
	Dcb.w	09,119		; Open & shut cannons 
	Dcb.w	1,129

	Dcb.w	3,131
	Dcb.w	438-421,133
	Dcb.w	446-438,280
	Dcb.w	1,138
	Dcb.w	1,139

	Ds.w	460-448
	Dcb.w	8,281
	Dcb.w	4,291	

	Ds.w	479-472
	Dc.w	160
	Dcb.w	491-480,0
	Dc.w	146
	Dcb.w	497-492,0
	Dc.w	172
	Dc.w	173
	Ds.w	513-499
	
	Dcb.w	1,130
	Dcb.w	1,177
	Ds.w	521-515
	Dcb.w	1,179
	Ds.w	534-522
	Dcb.w	1,186

	Ds.w	568-535
	Dcb.w	4,223
	Dcb.w	4,224
	Dcb.w	4,278
	Ds.w	584-580
	Dcb.w	32,282
	Dc.w	307		;!!!!!!!!!1239

	Dcb.w	2,283
	Dc.w	284

	Dcb.w	628-620
	Dc.w	296
	Ds.w	680-629
	Dc.w	238

	Ds.w	700-681
	Dcb.w	3,243
	Dcb.w	3,244
	Ds.w	723-706
	Dc.w	240
	Ds.w	726-724
	Dc.w	243,244
	Ds.w	790-728
	Dc.w	222
	Dc.w	0,0
	Dc.w	230,237
	Ds.w	861-795
	Dc.w	197
	Ds.w	870-862
	Ds.w	881-870
	Dc.w	212

	Ds.w	927-882
	Dc.w	199
	Ds.w	929-928
	Dc.w	200

	Ds.w	931-930
	Dc.w	201

	Ds.w	940-932
	Dc.w	218
	Ds.w	981-941
	Dc.w	270
	Ds.w	1001-982
	Dcb.w	32,254
	Ds.w	1058-1033
	Dc.w	290
	Dcb.w	1107-1059
	Dc.w	311
	Dcb.w	1170-1108
	Dc.w	289
	Dcb.w	1287-1171
	Dc.w	358
	Ds.w	1
	Dc.w	373,374
	Dc.w	369,370,360,361
	Ds.w	1302-1295
	Dc.w	368

	Ds.w	1426-1303
	Dc.w	371,372,0

	Ds.w	1454-1429
	Dc.w	320
	Dc.w	321
	Ds.w	1477-1456
	Dc.w	375
	EVEN