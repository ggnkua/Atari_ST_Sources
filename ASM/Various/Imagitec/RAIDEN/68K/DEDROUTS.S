Dead_End_Level1_Seq
	Abs_Move	0,1,5
	Fire_Ship	85
	Abs_Move	0,1,5
	Fire_Ship	81
	Abs_Move	0,1,5
	Fire_Ship	83
	Abs_Move	0,1,5
	Fire_Ship	85
	Abs_Move	0,1,5
	Fire_Ship	82
	Abs_Move	0,1,5
	Fire_Ship	86
	Abs_Move	0,1,5
	Fire_Ship	84
	Abs_Move	0,1,5
	Fire_Ship	85
	Abs_Move	0,1,5
	Fire_Ship	124
	End_Seq	
	

Dead_End_Level2_Seq
	Abs_Move	0,1,5
	Fire_Ship	98
	Abs_Move	0,1,5
	Fire_Ship	94
	Abs_Move	0,1,5
	Fire_Ship	96
	Abs_Move	0,1,5
	Fire_Ship	98
	Abs_Move	0,1,5
	Fire_Ship	95
	Abs_Move	0,1,5
	Fire_Ship	99
	Abs_Move	0,1,5
	Fire_Ship	97
	Abs_Move	0,1,5
	Fire_Ship	98
	Abs_Move	0,1,5
	Change_Anim	324
	Change_Link_Anim	1,325
	Unpause_Anim
	Unpause_link_Anim	1
	Abs_Move	0,1,40
	Rep		100
	Abs_Move	0,1,1
	Abs_Move	0,2,1
	RepEnd
	End_Seq	


Dead_End_Level3_Seq
	Abs_Move	0,1,5
	Fire_Ship	98
	Abs_Move	0,1,5
	Fire_Ship	94
	Abs_Move	0,1,5
	Fire_Ship	96
	Abs_Move	0,1,5
	Fire_Ship	98
	Abs_Move	0,1,5
	Fire_Ship	95
	Abs_Move	0,1,5
	Fire_Ship	99
	Abs_Move	0,1,5
	Fire_Ship	97
	Abs_Move	0,1,5
	Fire_Ship	98


	Change_Anim		382
	Change_Link_Anim	1,383
	Change_Link_Anim	2,384
	Change_Link_Anim	3,385

	Unpause_Anim
	Unpause_Link_Anim	1
	Unpause_Link_Anim	2
	Unpause_Link_Anim	3

	Abs_Move	0,1,300
	End_Seq	

;94=138

Dead_End_Level4_Seq
	Abs_Move	0,1,5
	Fire_Ship	142
	Abs_Move	0,1,5
	Fire_Ship	138
	Abs_Move	0,1,5
	Fire_Ship	140
	Abs_Move	0,1,5
	Fire_Ship	142
	Abs_Move	0,1,5
	Fire_Ship	139
	Abs_Move	0,1,5
	Fire_Ship	143
	Abs_Move	0,1,5
	Fire_Ship	141
	Abs_Move	0,1,5
	Unpause_Anim
	Unpause_Link_Anim	1
	Unpause_Link_Anim	2
	Unpause_Link_Anim	3
	Change_Anim		348
	Change_Link_Anim	1,349
	Change_Link_Anim	2,350
	Change_Link_Anim	3,351
	Fire_Ship	142
	Abs_Move	0,1,$7fff
	End_Seq	



Dead_End_Level5_Seq
	Abs_Move	0,1,5
	Fire_Ship	85
	Abs_Move	0,1,5
	Fire_Ship	81
	Abs_Move	0,1,5
	Fire_Ship	83
	Abs_Move	0,1,5
	Fire_Ship	85
	Abs_Move	0,1,5
	Fire_Ship	82
	Abs_Move	0,1,5
	Fire_Ship	86
	Abs_Move	0,1,5
	Fire_Ship	84
	Abs_Move	0,1,5
	Fire_Ship	85
	Abs_Move	0,1,5
	Fire_Ship	124
	End_Seq	

Dead_End_Level6_Seq
	Abs_Move	0,1,5


	Rep		5
	Fire_Ship	190
	Fire_Ship	191
	Fire_Ship	192
	Fire_Ship	191
	Fire_Ship	193
	Fire_Ship	194
	Fire_Ship	199
	Fire_Ship	192
	Fire_Ship	195
	Fire_Ship	196
	Fire_Ship	197
	Fire_Ship	195
	Fire_Ship	198
	Fire_Ship	199
	Repend

	Fire_Ship	152
	Abs_Move	0,1,5
	Fire_Ship	148
	Abs_Move	0,1,5
	Fire_Ship	150
	Abs_Move	0,1,5
	Fire_Ship	152
	Abs_Move	0,1,5
	Fire_Ship	149
	Abs_Move	0,1,5
	Fire_Ship	153
	Abs_Move	0,1,5
	Fire_Ship	151
	Abs_Move	0,1,5
	Fire_Ship	152
	Abs_Move	0,1,2
	Fire_Ship	154
	End_Seq	

Power4_Blowup_Seq
	Abs_Move	0,1,1
	Fire_Ship	133
	Abs_Move	0,1,3
	Fire_Ship	134
	Abs_Move	0,1,3
	Fire_Ship	135
	Abs_Move	0,1,3
	Fire_Ship	136
	Abs_Move	0,1,3
	Fire_Ship	137
	Abs_Move	0,1,3
	Fire_Ship	200
	Change_Anim	-1
	Change_Link_Anim	4,380
	Change_Link_Anim	5,381
	Change_Link_Anim	7,378
	Change_Link_Anim	6,379
	Abs_Move	0,1,300
	End_Seq	
	
Dead_7	Fire_Ship	168
	Abs_Move	0,1,8
	Unpause_Anim	
	Unpause_Link_Anim	1
	Change_Anim	388
	Change_Link_Anim	1,387
	Abs_Move	0,1,60
	Abs_Move	0,2,50
	Abs_Move	0,3,60
	Abs_Move	0,4,70
	End_Seq
	
Dead_8	Abs_Move	0,1,5
	Fire_Ship	182
	Abs_Move	0,1,5
	Fire_Ship	178
	Abs_Move	0,1,5
	Fire_Ship	180
	Abs_Move	0,1,5
	Fire_Ship	182
	Abs_Move	0,1,5
	Fire_Ship	179
	Abs_Move	0,1,5
	Fire_Ship	183
	Abs_Move	0,1,5
	Fire_Ship	181
	Abs_Move	0,1,5
	Fire_Ship	182
	Abs_Move	0,1,2
	Fire_Ship	184
	End_Seq	
	


Dead_Plane_Fuxter_Knuckles
	Fire_Ship	155
	Abs_Move	0,1,20
	End_Seq
