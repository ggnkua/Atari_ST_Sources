	Cnop	0,4
; Flames offsets
Flame_Offset_Table
	Dcb.l	50-0,0
	Dc.l	Flame_Fat_Tank
	Dcb.l	92-51,0
	Dc.l	Flame_Spintank
	Dc.l	Flame_Spintank
	Dcb.l	96-94,0
	Dc.l	Flame_Planedown
	Dcb.l	101-97,0
	Dc.l	Flame_Hover
	Dcb.l	162-102,0
	Dc.l	Flame_Planeup
	Ds.l	1
;	Dc.l	Flame_Bomb
	Dcb.l	183-164,0
	Dc.l	Flame_Baddy1
	Dcb.l	217-184,0
	Dc.l	Flame_Smallhover
	Dcb.l	264-218,0
	Dc.l	Flame_Midboat
	Dcb.l	301-265,0
	Dc.l	Flame_Baddy2
	Dc.l	Flame_Baddy2a
	Dc.l	Flame_Lwing2
	Dc.l	Flame_Rwing2
	Dcb.l	331-305,0
	Dc.l	Flame_Hovercraft1
	Dcb.l	365-332,0
	Ds.l	4
;	Dc.l	Flame_Baddy3
;	Dc.l	Flame_Baddy3
;	Dc.l	Flame_Baddy3
;	Dc.l	Flame_Baddy3
	Dcb.l	406-369
	Dc.l	Flame_Baddy3bit
	Dcb.l	421-407,0
	Dc.l	Flame_Grasstank
	Dcb.l	431-422,0
	Dc.l	Flame_Hovercraft
	Dcb.l	446-432,0
	Dc.l	Flame_Multi_Gun
	Dc.l	Flame_Multi_Gun2
	Dcb.l	479-448,0
	Dc.l	Flame_Baddy4a
	Dc.l	Flame_Baddy4b
	Dc.l	Flame_Baddy4c
	Dc.l	Flame_Baddy4d
	Dcb.l	497-483,0
	Dc.l	Flame_Lev4l
	Dc.l	Flame_Lev4r
	Dcb.l	513-499,0
	Dc.l	Flame_Fatplane
	Dcb.l	521-514,0
	Dc.l	Flame_Flyingthing
	Dcb.l	534-522,0
	Dc.l	Flame_Baddy5
	Dcb.l	538-535,0
	Dc.l	Flame_Baddy5wingl
	Dc.l	Flame_Baddy5wingr
	Dcb.l	619-540,0
	Dc.l	Flame_Hugeplanea
	Dc.l	Flame_Hugeplaneb
	Dc.l	Flame_Hugeplanec
	Dc.l	Flame_Hugeplaned
	Dcb.l	680-623,0
	Dc.l	Flame_Blur_Rod
	Dcb.l	881-681,0
	Dc.l	Flame_Baddy1
	Dcb.l	982-882,0
	Dc.l	0 
	Dcb.l	1058-983,0
	Dc.l	Flame_Grasstank
	Dcb.l	1118-1059,0
	Rept	27
	Dc.l	Flame_Lev6head
	Endr
	Dcb.l	1170-1145,0
	Dc.l	Flame_Flyingthing
	Dcb.l	1242-1171,0
	Dc.l	Flame_Bad7
	Dcb.l	1287-1243,0
	Dc.l	Flame_Baddy8
	Dc.l	Flame_Baddy8b
	Dcb.l	1540-1289,0
Flame_Offset_Tablee

Flame_Bad7
	Dc.w	.E-.S
.S	Dc.w	20,10,30,30,10,10,10,20
.E


Flame_Hovercraft1
	Dc.w	.E-.S
.S	Dc.w	20,10,30,40,20,20
.E


Flame_Bomb
	Dc.w	.E-.S
.S	Dc.w	0,8,12,30
.E

Flame_Fat_Tank
	Dc.w	.E-.S
.S	Dc.w	10,20,30,30,30,40,16,30
.E

Flame_Lev4l
	Dc.w	.E-.S
.S	Dc.w	39,44-10,11,27-10,40,21-10,15,45-10,25,30-10
.E

Flame_Lev4r
	Dc.w	.E-.S
.S	Dc.w	12,24-10,40,51-10,14,38-10,36,24-10,24,46-10
.E

Flame_Blur_Rod
	Dc.w	.E-.S
.S	Dc.w	38,45,17,15,12,48,26,31,29,15,8,33
.E

Flame_Lev6head
	Dc.w	.E-.S
.S	Dc.w	10,10,15,17
.E


Flame_Flyingthing
	Dc.w	.E-.S
.S	Dc.w	29,30,40,21,58,25,26,13,45,8
.E

Flame_Baddy4a
	Dc.w	.E-.S
.S	Dc.w	30,10,10,30,30,30,20,20
.E

Flame_Baddy4b
	Dc.w	.E-.S
.S	Dc.w	10,10,10,30,30,30,20,20
.E

Flame_Baddy4c
	Dc.w	.E-.S
.S	Dc.w	30,10,40,20,30,30,20,20
.E

Flame_Baddy4d
	Dc.w	.E-.S
.S	Dc.w	10,10,20,30,30,30,20,20
.E

Flame_Baddy5
	Dc.w	.E-.S
.S	Dc.w	43,85,15,34,51,58,17,78,35,44,12,66,55,25,34,65
.E

Flame_Baddy3
	Dc.w	.E-.S
.S	Dc.w	29,10,10,30,40,20,10,50
.E

Flame_Baddy5wingl
	Dc.w	.E-.S
.S	Dc.w	13,14,52,22,32,12
.E

Flame_Baddy5wingr
	Dc.w	.E-.S
.S	Dc.w	12,11,45,14,28,19
.E



Flame_Baddy8
	Dc.w	.E-.S
.S	Dc.w	30,11,37,42,20,26,20,50
.E

Flame_Baddy8b
	Dc.w	.E-.S
.S	Dc.w	10,11,27,32,30,56,10,10
.E

Flame_Smallhover
	Dc.w	.E-.S
.S	Dc.w	11,10,42,10,38,24,22,20
.E

Flame_Fatplane
	Dc.w	.E-.S
.S	Dc.w	45,10,23,10,41,28,29,31,35,17
.E

Flame_Grasstank
	Dc.w	.E-.S
.S	Dc.w	43,52,25,47,21,57
.E

Flame_Midboat
	Dc.w	.E-.S
.S	Dc.w	10,7,21,4,19,18,13,32
.E

Flame_Hovercraft
	Dc.w	.E-.S
.S	Dc.w	15,13,31,15,23,34,16,42,32,44
.E

Flame_Lwing2
	Dc.w	.E-.S
.S	Dc.w	13,9,42,9,30,4
.E

Flame_Rwing2
	Dc.w	.E-.S
.S	Dc.w	38,8,7,10,21,6
.E

Flame_Baddy2
	Dc.w	.E-.S
.S	Dc.w	16,26,21,44,38,29
.E

Flame_Baddy2a
	Dc.w	.E-.S
.S	Dc.w	16,26,21,44,38,29
.E

Flame_Baddy1
	Dc.w	.E-.S
.S	Dc.w	28,13,57,18,25,69,56,66,52,39,33,45
.E

Flame_Hugeplanea
	Dc.w	.E-.S
.S	Dc.w	10,24,56,5
.E

Flame_Hugeplaneb
	Dc.w	.E-.S
.S	Dc.w	0,10,48,24
.E

Flame_Hugeplanec
	Dc.w	.E-.S
.S	Dc.w	48,28
.E

Flame_Hugeplaned
	Dc.w	.E-.S
.S	Dc.w	3,35
.E


Flame_Hover
	Dc.w	.E-.S
.S	Dc.w	31,16,14,17,18,46,30,43,24,38
.E

Flame_Planeup
	Dc.w	.E-.S
.S	Dc.w	16,39,51,37,43,31,31,36,32,22
.E

Flame_Planedown
	Dc.w	.E-.S
.S	Dc.w	12,27,27,31,40,31,48,26,32,43
.E

Flame_Multi_Gun
	Dc.w	.E-.S
.S	Dc.w	15,3,31,13,13,13,32,38
.E

Flame_Multi_Gun2
	Dc.w	.E-.S
.S	Dc.w	09,2,54,2,11,23,54,24
.E

Flame_Spintank
	Dc.w	.E-.S
.S	Dc.w	9,12,30,8,37,28,14,34
.E
Flame_Baddy3bit
	Dc.w	.E-.S
.S	Dc.w	9,12,30,8,37,0,54,14,40,26
.E
