Anmneg	Dc.w	$7fff,-1,-1
	Cnop	0,4
	Dc.l	Anmneg
Alien_Anim_Table
	Dc.l	.Anm0,.Anm1,.Anm2,.Anm3,.Anm4,.Anm5,.Anm6,.Anm7,.Anm8,.Anm9
	Dc.l	.Anm10,.Anm11,.Anm12,.Anm13,.Anm14,.Anm15,.Anm16,.Anm17,.Anm18,.Anm19
	Dc.l	.Anm20,.Anm21,.Anm22,.Anm23,.Anm24,.Anm25,.Anm26,.Anm27,.Anm28,.Anm29
	Dc.l	.Anm30,.Anm31,.Anm32,.Anm33,.Anm34,.Anm35,.Anm36,.Anm37,.Anm38,.Anm39
	Dc.l	.Anm40,.Anm41,.Anm42,.Anm43,.Anm44,.Anm45,.Anm46,.Anm47,.Anm48,.Anm49
	Dc.l	.Anm50,.Anm51,.Anm52,.Anm53,.Anm54,.Anm55,.Anm56,.Anm57,.Anm58,.Anm59
	Dc.l	.Anm60,.Anm61,.Anm62,.Anm63,.Anm64,.Anm65,.Anm66,.Anm67,.Anm68,.Anm69
	Dc.l	.Anm70,.Anm71,.Anm72,.Anm73,.Anm74,.Anm75,.Anm76,.Anm77,.Anm78,.Anm79
	Dc.l	.Anm80,.Anm81,.Anm82,.Anm83,.Anm84,.Anm85,.Anm86,.Anm87,.Anm88,.Anm89
	Dc.l	.Anm90,.Anm91,.Anm92,.Anm93,.Anm94,.Anm95,.Anm96,.Anm97,.Anm98,.Anm99
	Dc.l	.Anm100,.Anm101,.Anm102,.Anm103,.Anm104,.Anm105,.Anm106,.Anm107,.Anm108,.Anm109
	Dc.l	.Anm110,.Anm111,.Anm112,.Anm113,.Anm114,.Anm115,.Anm116,.Anm117,.Anm118,.Anm119
	Dc.l	.Anm120,.Anm121,.Anm122,.Anm123,.Anm124,.Anm125,.Anm126,.Anm127,.Anm128,.Anm129
	Dc.l	.Anm130,.Anm131,.Anm132,.Anm133,.Anm134,.Anm135,.Anm136,.Anm137,.Anm138,.Anm139
	Dc.l	.Anm140,.Anm141,.Anm142,.Anm143,.Anm144,.Anm145,.Anm146,.Anm147,.Anm148,.Anm149
	Dc.l	.Anm150,.Anm151,.Anm152,.Anm153,.Anm154,.Anm155,.Anm156,.Anm157,.Anm158,.Anm159
	Dc.l	.Anm160,.Anm161,.Anm162,.Anm163,.Anm164,.Anm165,.Anm166,.Anm167,.Anm168,.Anm169
	Dc.l	.Anm170,.Anm171,.Anm172,.Anm173,.Anm174,.Anm175,.Anm176,.Anm177,.Anm178,.Anm179
	Dc.l	.Anm180,.Anm181,.Anm182,.Anm183,.Anm184,.Anm185,.Anm186,.Anm187,.Anm188,.Anm189
	Dc.l	.Anm190,.Anm191,.Anm192,.Anm193,.Anm194,.Anm195,.Anm196,.Anm197,.Anm198,.Anm199
	Dc.l	.Anm200,.Anm201,.Anm202,.Anm203,.Anm204,.Anm205,.Anm206,.Anm207,.Anm208,.Anm209
	Dc.l	.Anm210,.Anm211,.Anm212,.Anm213,.Anm214,.Anm215,.Anm216,.Anm217,.Anm218,.Anm219
	Dc.l	.Anm220,.Anm221,.Anm222,.Anm223,.Anm224,.Anm225,.Anm226,.Anm227,.Anm228,.Anm229
	Dc.l	.Anm230,.Anm231,.Anm232,.Anm233,.Anm234,.Anm235,.Anm236,.Anm237,.Anm238,.Anm239
	Dc.l	.Anm240,.Anm241,.Anm242,.Anm243,.Anm244,.Anm245,.Anm246,.Anm247,.Anm248,.Anm249
	Dc.l	.Anm250,.Anm251,.Anm252,.Anm253,.Anm254,.Anm255,.Anm256,.Anm257,.Anm258,.Anm259
	Dc.l	.Anm260,.Anm261,.Anm262,.Anm263,.Anm264,.Anm265,.Anm266,.Anm267,.Anm268,.Anm269
	Dc.l	.Anm270,.Anm271,.Anm272,.Anm273,.Anm274,.Anm275,.Anm276,.Anm277,.Anm278,.Anm279
	Dc.l	.Anm280,.Anm281,.Anm282,.Anm283,.Anm284,.Anm285,.Anm286,.Anm287,.Anm288,.Anm289
	Dc.l	.Anm290,.Anm291,.Anm292,.Anm293,.Anm294,.Anm295,.Anm296,.Anm297,.Anm298,.Anm299
	Dc.l	.Anm300,.Anm301,.Anm302,.Anm303,.Anm304,.Anm305,.Anm306,.Anm307,.Anm308,.Anm309
	Dc.l	.Anm310,.Anm311,.Anm312,.Anm313,.Anm314,.Anm315,.Anm316,.Anm317,.Anm318,.Anm319
	Dc.l	.Anm320,.Anm321,.Anm322,.Anm323,.Anm324,.Anm325,.Anm326,.Anm327,.Anm328,.Anm329
	Dc.l	.Anm330,.Anm331,.Anm332,.Anm333,.Anm334,.Anm335,.Anm336,.Anm337,.Anm338,.Anm339
	Dc.l	.Anm340,.Anm341,.Anm342,.Anm343,.Anm344,.Anm345,.Anm346,.Anm347,.Anm348,.Anm349
	Dc.l	.Anm350,.Anm351,.Anm352,.Anm353,.Anm354,.Anm355,.Anm356,.Anm357,.Anm358,.Anm359
	Dc.l	.Anm360,.Anm361,.Anm362,.Anm363,.Anm364,.Anm365,.Anm366,.Anm367,.Anm368,.Anm369
	Dc.l	.Anm370,.Anm371,.Anm372,.Anm373,.Anm374,.Anm375,.Anm376,.Anm377,.Anm378,.Anm379
	Dc.l	.Anm380,.Anm381,.Anm382,.Anm383,.Anm384,.Anm385,.Anm386,.Anm387,.Anm388	,.Anm379

.Anm0	Dc.w	4,0,121,-1				ROTATING SHIP BASE !
.Anm1	Dc.w	2,80,81,82,-1			EXPLOSION
.Anm2	Dc.w	4,64,65,-1			ENERGY BOLT
.Anm3	Dc.w	5,66,67,109,-1			Red - Weapon
.Anm4	Dc.w	5,68,69,110,-1			Blue - Weapon
.Anm5	Dc.w	5,70,71,113,-1			Sidewinder
.Anm6	Dc.w	5,72,73,112,-1			Homing Missle
.Anm7	Dc.w	4,16,137,-1			Tank anims
.Anm8	Dc.w	113,32,-1			Turret anims !
.Anm9	Dc.w	76,48,-1			Tank missle
.Anm10	Dc.w	10,101,-1			Big power-up ship
.Anm11	Dc.w	2,153,154,-1			Boosters (down)
.Anm12	Dc.w	2,177,178,-1			Boosters (up)
.Anm13	Dc.w	3,160,161,-1			Whirry bits
;-----------
.Anm14	Dc.w	39,50,-1			Second level Mid baddie
.Anm15	Dc.w	39,57,-1			Left bit of mid
.Anm16	Dc.w	39,58,-1			Right bit of mid!
.Anm17	Dc.w	2,59,60,-1			Left Traction
.Anm18	Dc.w	2,61,62,-1			Right Tractiion
.Anm19	Dc.w	2,48,49,-1			Up spinner
.Anm20	Dc.w	2,63,90,-1			Down Spinner
.Anm21	Dc.w	2,179,180,-1			BONUS 5000
.Anm22	Dc.w	2,181,182,-1			BONUS 10,000
.Anm23	Dc.w	$7fff,158,-1			Boost down for power-up ship
.Anm24	Dc.w	$7fff,159,-1			Tween boost down for power-up ship
.Anm25	Dc.w	39,59,-1			Tank missle !
.Anm26	Dc.w	39,60,-1			Tank missle !
.Anm27	Dc.w	39,61,-1			Tank missle !
.Anm28	Dc.w	39,62,-1			Tank missle !
.Anm29	Dc.w	39,63,-1			Tank missle !
;-----------
.Anm30	Dc.w	2,80,81,82,114,-1		Explosion 16
.Anm31	Dc.w	3,83,84,85,-1			Explosion 32
.Anm32	Dc.w	9,96,-1				Plane down
.Anm33	Dc.w	9,162,-1			Plane up
.Anm34	Dc.w	3,220,221,-1			Casket1
.Anm35	Dc.w	3,222,223,-1			Casket2
.Anm36	Dc.w	3,76,77,78,79,-1		Bomb pickup!
.Anm37	Dc.w	2,100,108,-1			Medal!
.Anm38	Dc.w	3,74,75,111,-1			Full power !
.Anm39	Dc.w	2,92,93,-1			Huge tank		(94! spare!)
.Anm40	Dc.w	1,95,97,98,-1			Wheels up !
.Anm41	Dc.w	1,99,102,103,-1			Wheels side !
.Anm42	Dc.w	1,104,-1			Wheels tween!
.Anm43	Dc.w	4,86,87,-1			Angel!
.Anm44	Dc.w	3,168,169,-1			BOOLLTT!
.Anm45	Dc.w	127,91,-1			Tree!!
.Anm46	Dc.w	126,89,-1			Crater (32)1
.Anm47	Dc.w	125,88,-1			Crater (32)2 
.Anm48	Dc.w	126,117,-1			Crator (64)
.Anm49	Dc.w	2,226,227,228,229,-1		Enlarged bolts
.Anm50	Dc.w	2,224,225,-1			Pig anm set
.Anm52	Dc.w	2,105,106,107,118,119,120,-1	Explosion64
.Anm53	Dc.w	2,170,171,172,173,-1		Explosion48
.Anm54	Dc.w	$7fff,163,-1			8-way bomb
.Anm55	Dc.w	2,164,165,166,-1		Anims for rotary of bomb
.Anm56	Dc.w	3,155,156,157,156,-1		Middle power-ups
.Anm57	Dc.w	3,116,-1			Shadow for spin tank!
.Anm58	Dc.w	3,183,-1			End-level guardian
.Anm59	Dc.w	2,184,185,186,187,-1		Wirry bits for end level guardian
.Anm60	Dc.w	1,188,189,190,-1		Bottom left cannon
.Anm61	Dc.w	1,191,192,193,-1		Left cannon
.Anm62	Dc.w	1,194,195,196,-1		Right cannon
.Anm63	Dc.w	1,199,198,197,-1		Bottom right cannon
.Anm64	Dc.w	3,217,-1			Enlarged ship
.Anm65	Dc.w	3,218,219,-1			Boost for enlarged ship
.Anm66	Dc.w	3,200,-1			Base of cannon
.Anm67	Dc.w	3,201,-1			Base of cannon rotations

;----------- LEVEL 2!!!!!!!!!!!!

.Anm51	Dc.w	4,230,246,-1			
.Anm68	Dc.w	2,262,263,-1			Zoomer !
.Anm69	Dc.w	213,264,-1			Tank boat
.Anm70	Dc.w	3,265,-1,-1			Tank boat bit
.Anm71	Dc.w	2,266,817,-1
.Anm72	Dc.w	2,267,818,-1
.Anm73	Dc.w	2,268,819,-1
.Anm74	Dc.w	2,269,820,-1			Boat Up/Right/Down/Left
.Anm75	Dc.w	2,270,271,-1			Car
.Anm76	Dc.w	200,272,-1			Buildozer 1
.Anm77	Dc.w	200,273,-1			Bulldozer 2
.Anm78	Dc.w	3,274,275,-1			Front train 1-2
.Anm79	Dc.w	200,276,-1			Back train
.Anm80	Dc.w	3,277,278,-1			Front carraige 1-2
.Anm81	Dc.w	200,279,-1			Back carraige
.Anm82	Dc.w	2,280,281,282,283,284,285,286,287,286,285,284,283,282,281,280,-1	Train front fire
.Anm83	Dc.w	2,288,289,-1			Diagonal train front
.Anm84	Dc.w	2,290,-1			Diagonal train back
.Anm85	Dc.w	2,291,292,-1			Diagonal carraige
.Anm86	Dc.w	2,293,294,295,296,297,298,299,300,299,298,297,296,295,294,293,-1	 Train diagonal fire
.Anm87	Dc.w	200,301,-1			End level guardian left
.Anm88	Dc.w	200,302,-1			End level guardian right
.Anm89	Dc.w	200,303,-1			Guardian wing left
.Anm90	Dc.w	200,304,-1			Guardian wing right
.Anm91	Dc.w	2,305,306,-1			Guardian boosters
.Anm92	Dc.w	2,307,308,309,310,311,310,309,308,307,-1	Bits for End guardian
.Anm93	Dc.w	2,312,313,314,315,-1		Bits for shooting end-guard
.Anm94	Dc.w	4,316,317,318,-1		Left transform
.Anm95	Dc.w	4,319,320,321,-1		Right transform
.Anm96	Dc.w	3,322,323,324,-1		Trendy bolts

;----------- LEVEL 3!!!!!!!!!!!!

.Anm97	Dc.w	$7fff,325,-1			Uptruck
.Anm98	Dc.w	$7fff,326,-1			Upcar
.Anm99	Dc.w	$7fff,327,-1
.Anm100	Dc.w	$7fff,330,-1			Scafolding right
.Anm101	Dc.w	$7fff,329,-1
.Anm102	Dc.w	$7fff,328,-1			Scafolding left
.Anm103	Dc.w	$7fff,331,-1			Traveling boat
.Anm104	Dc.w	$7fff,332,-1			Bit for !!
.Anm105	Dc.w	3,333,334,335,336,337,338,339,-1 Back bits for boat
.Anm106	Dc.w	$7fff,340,-1			Monstrous tank
.Anm107	Dc.w	$7fff,341,-1			Base for cannon on monstrous
.Anm108	Dc.w	$7fff,360,-1			Front bit for jeep
.Anm109	Dc.w	2,357,358,359,-1		Back bit for jeep
.Anm110	Dc.w	2,361,362,363,364,-1		Bits for jeep
.Anm111	Dc.w	$7fff,365,-1
.Anm112	Dc.w	$7fff,366,-1
.Anm113	Dc.w	$7fff,367,-1
.Anm114	Dc.w	$7fff,368,-1
.Anm115	Dc.w	$7fff,369,-1			End baddy3 stuff !
.Anm116	Dc.w	$7fff,370,-1
.Anm117	Dc.w	$7fff,371,-1
.Anm118	Dc.w	$7fff,372,-1
.Anm119	Dc.w	$3,408,409,410,411,412,413,414,415,411,410,409,408,-1		; Open & shut cannon
.Anm120	Dc.w	$3,393,394,395,396,1482,1483,1484,1483,1482,395,394,393,-1
.Anm121	Dc.w	$3,397,398,399,400,399,398,397,-1
.Anm122	Dc.w	$3,401,402,403,404,403,402,401,-1
.Anm123	DC.W	$7fff,405,-1
.Anm124	Dc.w	$3,373,378,383,388,-1
.Anm125	Dc.w	$3,374,379,384,389,-1
.Anm126	Dc.w	$3,375,380,385,390,-1
.Anm127	Dc.w	$3,376,381,386,391,-1
.Anm128	Dc.w	$3,377,382,387,392,-1
.Anm129	DC.W	$7fff,417,-1

;----------- LEVEL 4!!!!!!!!!!!!

.Anm130	Dc.w	$7fff,513,-1
.Anm131	Dc.w	4,418,419,420,-1
.Anm132	Dc.w	3,468,469,470,471,472,473,474,475,-1
.Anm133	Dc.w	$7fff,421,-1
.Anm134	Dc.w	4,422,423,424,-1
.Anm135	Dc.w	4,425,426,427,-1
.Anm136	Dc.w	4,428,429,430,431,432,431,430,429,428,-1
.Anm137	Dc.w	4,437,436,435,434,433,434,435,436,437,-1
.Anm138	Dc.w	$7fff,446,-1
.Anm139	Dc.w	$7fff,447,-1

.Anm140	Dc.w	4,450,451,-1
.Anm141	Dc.w	4,452,453,-1
.Anm142	Dc.w	4,454,455,-1
.Anm143	Dc.w	4,448,449,-1
.Anm145	Dc.w	4,456,457,-1
.Anm144	Dc.w	4,458,459,-1
.Anm146	Dc.w	$7fff,491,-1
.Anm147	Dc.w	$7fff,492,-1
.Anm148	Dc.w	$7fff,493,-1
.Anm149	Dc.w	$7fff,494,-1

.Anm150	Dc.w	$7fff,495,-1
.Anm151	Dc.w	$7fff,496,-1
.Anm152	Dc.w	4,454,455,-1
.Anm153	Dc.w	4,448,449,-1
.Anm154	Dc.w	4,456,457,-1
.Anm155	Dc.w	4,458,459,-1
.Anm156	Dc.w	$7fff,491,-1
.Anm157	Dc.w	$7fff,492,-1
.Anm158	Dc.w	$7fff,493,-1
.Anm159	Dc.w	$7fff,494,-1

.Anm160	Dc.w	$7fff,479,-1
.Anm161	Dc.w	$7fff,480,-1
.Anm162	Dc.w	$7fff,481,-1
.Anm163	Dc.w	$7fff,482,-1
.Anm164	Dc.w	$7fff,483,-1
.Anm165	Dc.w	$7fff,484,-1
.Anm166	Dc.w	$7fff,485,-1
.Anm167	Dc.w	$7fff,486,-1
.Anm168	Dc.w	$7fff,487,-1
.Anm169	Dc.w	$7fff,488,-1

.Anm170	Dc.w	$7fff,489,-1
.Anm171	Dc.w	$7fff,490,-1
.Anm172	Dc.w	$7fff,497,-1
.Anm173	Dc.w	$7fff,498,-1
.Anm174	Dc.w	$7fff,483,-1
.Anm175	Dc.w	3,501,501,502,503,504,-1
.Anm176	Dc.w	$7,499,-1

;------Level 5

.Anm177	Dc.w	4,514,515,516,-1
.Anm178	Dc.w	3,517,518,519,520,519,518,-1
.Anm179	Dc.w	$7fff,521,-1

.Anm180	Dc.w	$7fff,522,-1
.Anm181	Dc.w	$3,523,524,-1
.Anm182	Dc.w	$3,526,527,-1
.Anm183	Dc.w	$3,529,528,-1
.Anm184	Dc.w	$3,530,531,-1
.Anm185	Dc.w	$3,532,533,-1
.Anm186	Dc.w	$7fff,534,-1
.Anm187	Dc.w	$3,535,536,537,536,-1
.Anm188	Dc.w	$7fff,538,-1
.Anm189	Dc.w	$7fff,539,-1

.Anm190	Dc.w	3,540,541,542,543,542,541,-1
.Anm191	Dc.w	3,544,545,546,547,546,545,-1
.Anm192	Dc.w	3,548,549,550,551,-1
.Anm193	Dc.w	3,552,553,554,555,-1
.Anm194	Dc.w	2,556,557,558,559,558,557,556,-1
.Anm195	Dc.w	1,560,561,562,563,-1
.Anm196	Dc.w	2,564,564,565,566,565,564,560,561,562,563,-1

;-------Level 1 end baddy 2!
.Anm197	Dc.w	2,861,879,-1			Cow right
.Anm198	Dc.w	2,914,915,916,917,918,919,-1	Debri
.Anm199	Dc.w	2,927,928,-1			Cow bottom left


.Anm200	Dc.w	2,929,930,-1			Cow left
.Anm201	Dc.w	2,931,932,-1			Men jumping up and down
.Anm202	Dc.w	3,933,934,-1			laser remains
.Anm203	Dc.w	$0,412,413,414,415,-1
.Anm204	Dc.w	$3,411,410,409,408,408,-1
.Anm205	Dc.w	$7fff,800,-1
.Anm206	Dc.w	$7fff,801,-1
.Anm207	Dc.w	3,790-50,790-49,-1		Casket2 (Hi prioority !)
.Anm208	Dc.w	2,790-48,790-32,-1		Hi priority tank!)
.Anm209	Dc.w	3,790-16,-1			Hi priority turret !

.Anm210	Dc.w	2,853,854,853,855,856,857,858,859,860,859,860,859,860,859,860,859,860,859,860,859,858,857,-1	; Explosion    MMMMMMEEEEEEEEEEEGGGGGGGGGGGGGGAAAAAAAAAAAAA!!!!!!!!!!!!1

.Anm211	Dc.w	3,898,-1			; Shot from enemy


.Anm212	Dc.w	3,881,-1			End-level guardian(B)
.Anm213	Dc.w	2,882,883,884,885,-1		Wirry bits for end level guardian
.Anm214	Dc.w	1,886,887,888,-1		Bottom left cannon
.Anm215	Dc.w	1,889,890,891,-1		Left cannon
.Anm216	Dc.w	1,894,893,892,-1		Right cannon
.Anm217	Dc.w	1,897,896,895,-1		Bottom right cannon

.Anm218	Dc.w	3,940,941,942,943,944,-1	Small tank bunker
.Anm219	Dc.w	2,938,939,-1			Angel blast
.Anm220	Dc.w	3,935,936,937,-1		Shot remains !!


.Anm221	Dc.w	2,830,831,832,833,834,835,-1
.Anm222	Dc.w	$7fff,790,-1
.Anm223	Dc.w	$7fff,568,-1			; Silly tank Down
.Anm224	Dc.w	$7fff,572,-1			; Silly tank Right
.Anm225	Dc.w	$3,580,581,582,583,-1		; Silly tank flashing bit !
.Anm226	Dc.w	$3,569,570,571,-1		; Wheels for tank Down
.Anm227	Dc.w	$3,573,574,575,-1		; Wheels for tank right
.Anm228	Dc.w	$3,571,570,569,-1		; Wheels for tank Down (reverse!)
.Anm229	Dc.w	$3,575,574,573,-1		; Wheels for tank right (reverse!)


.Anm230	Dc.w	$7fff,793,-1			; Massive boat main (right)
.Anm231	Dc.w	$7fff,794,-1			; Boat bit right
.Anm232	Dc.w	$7fff,795,-1			; Boat bit left
.Anm233	Dc.w	$7fff,796,-1			; Back boat going right
.Anm234	Dc.w	$7fff,797,-1			; Back boat going left
.Anm235	Dc.w	$7fff,798,-1			; Smashed up massive boat
.Anm236	Dc.w	$7fff,799,-1			; Center bit of boat
.Anm237	Dc.w	$7fff,793,-1			; Massive boat main (left)
.Anm238	Dc.w	$7fff,680,-1			; square JOINT!
.Anm239	Dc.w	$7fff,616,-1			; Asteroid !

.Anm240	Dc.w	$7fff,723,-1
.Anm241	Dc.w	$7fff,724,-1			; Bit that goes up !
.Anm242	Dc.w	$7fff,725,-1
.Anm243	Dc.w	$2,700,701,702,-1		; Up/Down spider
.Anm244	Dc.w	$2,703,704,705,-1		; Left/Right
.Anm245	Dc.w	$2,696,697,698,698,697,696,-1		; Fire bit for Square JOINT!
.Anm246	Dc.w	$2,681,682,-1			; Boost for square JOINT!
.Anm247	Dc.w	$1,683,684,-1			; Down boost
.Anm248	Dc.w	$1,685,687,-1			; Right boost
.Anm249	Dc.w	$1,686,688,-1			; Left boost

.Anm250	Dc.w	$1,689,690,-1			; Up boost


.Anm251	Dc.w	$1,94,729,730,731,732,731,730,729,94,-1		; Up/down shot bits for spider !
.Anm252	Dc.w	$1,94,733,734,735,736,735,734,733,94,-1		; Left/Right shot bits for spider !
.Anm253	Dc.w	$2,696,-1					; Closed joint
.Anm254	Dc.w	$2,1001,1001+16,-1				; Grey tank !
.Anm255	Dc.w	$7fff,985,-1

.Anm256	Dc.w	2,716,717,718,719,-1				; Animations for horizontal under-tween
.Anm257	Dc.w	2,720,721,722,-1				; Animations for horizontal under - Move
.Anm258	Dc.w	2,719,718,717,716,-1				; Animations for horizontal top tween

.Anm259	Dc.w	2,709,710,711,712,-1				; Animations for Vertical under-tween
.Anm260	Dc.w	2,713,714,715,-1				; Animations for Vecrtial under - Move
.Anm261	Dc.w	2,712,711,710,709,-1				; Animations for Vertical top tween

.Anm262	Dc.w	2,706,707,708,-1				; Tweens from 000 to 090 degrees
.Anm263	Dc.w	2,1035,1034,1033,-1				; Tweens from 090 to 180 degrees
.Anm264	Dc.w	2,706,707,708,-1				; Tweens from 180 to 270 degrees
.Anm265	Dc.w	2,1035,1034,1033,-1				; Tweens from 270 to 000 degrees

.Anm266	Dc.w	2,1033,1034,1035,-1				; Tweens from 000 to 270 degrees
.Anm267	Dc.w	2,708,707,706,-1				; Tweens from 270 to 180 degrees
.Anm268	Dc.w	2,1033,1034,1033,-1				; Tweens from 180 to 090 degrees
.Anm269	Dc.w	2,708,707,706,-1				; Tweens from 090 to 000 degrees

.Anm270	Dc.w	$7fff,981,-1					; Front bit for end baddy
.Anm271	Dc.w	$7fff,982,-1					; Main birt for end baddy
.Anm272	Dc.w	$7fff,1036,-1					; Mask bit left for end baddy (7)
.Anm273	Dc.w	$7fff,1037,-1					; Main bit right 
.Anm274	Dc.w	4,1043,1044,-1					; Flaps left
.Anm275	Dc.w	4,1041,1042,-1					; Flaps right
.Anm276	Dc.w	2,1040,1039,1038,-1				; Flamey bits !
.Anm277	Dc.w	2,691,692,693,694,695,695,694,693,692,691,-1	; Shot bits !

.Anm278	Dc.w	$7fff,576,-1					; Tank left
.Anm279	Dc.w	$3,577,578,579,-1				; Wheels for tank left

.Anm280	Dc.w	2,438,439,440,441,442,441,440,439,438,-1	; The eyes have it!
.Anm281	Dc.w	1,460,461,462,463,464,465,466,467,-1

.Anm282	Dc.w	1,584,584+16,-1
.Anm283	Dc.w	1,617,618,-1
.Anm284	Dc.w	$7fff,619,-1
.Anm285	Dc.w	$7fff,620,-1
.Anm286	Dc.w	$7fff,621,-1
.Anm287	Dc.w	$7fff,622,-1
.Anm288	Dc.w	1,623,624,625,626,627,626,625,624,623,-1
.Anm289	Dc.w	$7fff,1170,-1
.Anm290	Dc.w	1,1058,-1				
.Anm291	Dc.w	2,468,468,469,470,471,-1			
.Anm292	Dc.w	5,1264,1265,1266,-1			
.Anm293	Dc.w	5,1267,1268,1269,-1
.Anm294	Dc.w	$7fff,1270,-1
.Anm295	Dc.w	3,1271,-1

.Anm296	Dc.w	$7fff,628,-1
.Anm297	Dc.w	$7fff,629,-1
.Anm298	Dc.w	2,630,631,632,-1
.Anm299	Dc.w	2,633,634,635,-1
.Anm300	Dc.w	2,636,637,638,639,-1

.Anm301	Dc.w	$7fff,1172,-1
.Anm302	Dc.w	$3,1173,1174,-1
.Anm303	Dc.w	$3,1175,1176,-1
.Anm305	Dc.w	$3,1178,1177,-1
.Anm304	Dc.w	$3,1179,1180,-1
.Anm306	Dc.w	$3,1181,1182,-1
.Anm307	Dc.w	$1,1429,1430,1431,1432,1433,1434,1435,1436,1437,1438,1439,1440,1441,1442,1443,1444,1445,1446,1447,1448,1449,1450,1451,1452,1453,-1
.Anm308	Dc.w	$7fff,1222,-1
.Anm309	Dc.w	$7fff,1238,-1
.Anm310	Dc.w	$7fff,1239,-1

.Anm311	Dc.w	$7fff,1107,-1
.Anm312	Dc.w	1,1108,1109,-1

.Anm313	Dc.w	3,1113,1112,1111,1110,1111,1112,-1
.Anm314	Dc.w	3,1110,1111,1112,1113,1112,1111,-1
.Anm315	Dc.w	3,1114,1115,1116,1117,1116,1115,-1
.Anm316	Dc.w	3,1117,1116,1115,1114,1115,1116,-1

.Anm317	Dc.w	3,1118,-1
.Anm318	Dc.w	3,9+1118,-1
.Anm319	Dc.w	3,18+1118,-1

.Anm320	Dc.w	$7fff,1454,-1			; Main bunker
.Anm321	Dc.w	$7fff,1455,-1			; "2" bunker
.Anm322	Dc.w	$7fff,1456,-1			; "2" shadow
.Anm323	Dc.w	$7fff,1457,-1			; Main shadow

.Anm324	Dc.w	$7fff,1240,-1			; Dead2	a
.Anm325	Dc.w	$7fff,1241,-1			; dead2	b

.Anm326	Dc.w	$7fff,1465,-1			; Hi-Pri-Crator!


.Anm327	Dc.w	$7fff,1108,-1
.Anm328	Dc.w	2,1117,1116,1115,-1
.Anm329	Dc.w	2,1113,1112,1111,-1

.Anm330	Dc.w	$7fff,1118,-1
.Anm331	Dc.w	$7fff,1118+8,-1
.Anm332	Dc.w	$7fff,1464,-1

.Anm333	Dc.w	$7fff,1467,-1
.Anm334	Dc.w	$7fff,1468,-1
.Anm335	Dc.w	$7fff,1470,-1
.Anm336	Dc.w	$7fff,1469,-1
.Anm337	Dc.w	$7fff,1471,-1
.Anm338	Dc.w	$7fff,1472,-1
.Anm339	Dc.w	$7fff,1183,-1

.Anm340	Dc.w	$7fff,1474,-1
.Anm341	Dc.w	$7fff,1475,-1
.Anm342	Dc.w	$7fff,1476,-1

.Anm343	Dc.w	3,504,504,503,502,501,-1
.Anm344	Dc.w	0,505,506,-1

.Anm345	Dc.w	2,507,508,509,510,511,512,512,511,510,509,508,507,-1

.Anm346	Dc.w	5,1264,1265,1266,-1
.Anm347	Dc.w	5,1267,1268,1269,-1
.Anm348	Dc.w	$7fff,487,-1
.Anm349	Dc.w	$7fff,488,-1

.Anm350	Dc.w	$7fff,489,-1
.Anm351	Dc.w	$7fff,490,-1
.Anm352	Dc.w	$7fff,1090,-1
.Anm353	Dc.w	$7fff,1091,-1
.Anm354	Dc.w	$7fff,1092,-1
.Anm355	Dc.w	3,1110,1111,1112,1113,-1
.Anm356	Dc.w	3,1114,1115,1116,1117,-1
.Anm357	Dc.w	$7fff,1242,-1
.Anm358	Dc.w	$7fff,1287,-1			; Body
.Anm359	Dc.w	$7fff,1288,-1			; Body2

.Anm360	Dc.w	$7fff,1293,-1
.Anm361	Dc.w	$7fff,1294,-1			; Left/Right wing bits
.Anm362	Dc.w	1,1297,1296,1295,1298,1299,-1	; Wheel bit
.Anm363	Dc.w	$7fff,1300,-1
.Anm364	Dc.w	$7fff,1301,-1			; Left/right spin hold
.Anm365	Dc.w	2,1323,1324,1325,1326,-1	; Wheels backward
.Anm366	Dc.w	2,1326,1325,1324,1323,-1	; Wheels forward
.Anm367	Dc.w	1,1316,1317,1318,1319,1320,1321,1322,-1	; Small spinny bits
.Anm368	Dc.w	0,1302,1303,1304,1305,1306,1307,1308,1309,1308,1307,1306,1305,1304,1303,1302,-1		;Cannon bits
.Anm369	Dc.w	$7fff,1291,-1			; Pusher bit right
.Anm370	Dc.w	$7fff,1292,-1			; Pusher bit left

.Anm371	Dc.w	$7fff,1426,-1			; Pusher bit right
.Anm372	Dc.w	$7fff,1427,-1			; Pusher bit left

.Anm373	Dc.w	$7fff,1289,-1			; Overhanging bits left
.Anm374	Dc.w	$7fff,1290,-1			; Overhanging bits right

.Anm375	Dc.w	2,1477,1478,1479,1480,-1			; Overhanging bits right


.Anm376	Dc.w	2,908,909,-1			; 3000 bonus!

.Anm377	Dc.w	$7fff,406,-1

.Anm378	Dc.w	$7fff,1501,-1
.Anm379	Dc.w	$7fff,1502,-1
.Anm380	Dc.w	$7fff,1503,-1
.Anm381	Dc.w	$7fff,1504,-1

.Anm382	Dc.w	$7fff,1505,-1
.Anm383	Dc.w	$7fff,1506,-1
.Anm384	Dc.w	$7fff,1507,-1
.Anm385	Dc.w	$7fff,1508,-1

.Anm386	Dc.w	$7fff,1485,-1

.Anm387	Dc.w	$7fff,1510,-1
.Anm388	Dc.w	$7fff,1511,-1
