term_texts1	
	dc.b	-2,0,$fc
	dc.b	"----- fed-net uplink on line   ",0
	dc.b	"point-counterpoint encyclopedia",0
	dc.b	"    of federation worlds       ",0
	dc.b	"entry no - 38g95-3554m4403d74  ",0
	dc.b	"system   - carrion             ",0
	dc.b	"world    - swampworld          ",0 
	dc.b	"-------------------------------",0
	dc.b	-2,0,$fe
	dc.b	"ernie says - this valuable and ",0
	dc.b	"uninhabited world is a noted   ",0
	dc.b	"preserve for several spieces of",0
	dc.b	"rare wading birds. this is one ",0
	dc.b	"of the few unspoilt landscapes ",0
	dc.b	"of the federation and its      ",0
	dc.b	"beauty is unsurpassed          ",0
	dc.b	-2,0,$fc
	dc.b	"----- click now.               ",0
	dc.b	-1
	even
term_texts2
	dc.b	-2,0,$fd
	dc.b	"wallace says - swampworld is a ",0
	dc.b	"stinking little hole with no   ",0
	dc.b	"redeeming features. there are  ",0
	dc.b	"no bars no strip joints and the",0
	dc.b	"whole place is living evidence ",0
	dc.b	"that mother nature is a bitch  ",0
	dc.b	"of the first degree.           ",0
	dc.b	-2,0,$fc
	dc.b	"----- fed-net uplink closed.   ",0
	dc.b	-1
	even
