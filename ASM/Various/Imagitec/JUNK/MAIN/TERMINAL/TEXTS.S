Intro_Text
	Dc.b	"Hello and welcome to Space Junk !",0
	Dc.b	"This is our hero Randolf",0
	Dc.b	"A planet data terminal",0
	Dc.b	"Pick up the data terminal",0
	Dc.b	"Richtoffen Bader A DROOG pilot",0
	Dc.b	"Talk to Ritchoffen Bader",0
	Even