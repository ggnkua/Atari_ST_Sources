	DC.W	$0102
	DC.L	$2740,$E4F,$C76,$26E6,$27A8,$E22,$E8A
	
	DC.W	$0100
	DC.L	$26A0,$E09,$DB0,$2686,$2748,$DDC,$E44
	
	DC.W	$0101
	DC.L	$26A0,$E09,$DB0,$2686,$2748,$DDC,$E44
	
	DC.W	$0104
	DC.L	$2882,$E6B,$C92,$2828,$28EA,$E3E,$EA6
	
	DC.W	$0106
	DC.L	$28C2,$EAB,$CD2,$2868,$292A,$E7E,$EE6
	
	DC.W	-1
	DS.W	14
	DC.W	-1
	DS.W	227
	
	DC.B	27,$66,0
	DC.B	"\STOS"
	
	DS.W	64
	DC.B	0
	DC.B	"PIC.PI1",0
	DC.B	"PIC.PI3",0
	DC.B	"SPRITE???.BIN",0
	DC.B	"WINDO???.BIN",0
	DC.B	"FLOAT???.BIN",0
	DC.B	"MUSIC???.BIN",0
	DC.B	"BASIC???.BIN",0
	DC.B	"*.EX",0,0
	DC.B	27,"Y",$37,$30,"TOS 1.04",0
	DC.B	27,"Y",$37,$44,"TOS 1.06",0