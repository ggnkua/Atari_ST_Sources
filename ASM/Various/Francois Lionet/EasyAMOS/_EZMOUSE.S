	SECTION DATA
	dc.l	kiki-koko
koko	Incbin Mouse.Abk
kiki
	END
