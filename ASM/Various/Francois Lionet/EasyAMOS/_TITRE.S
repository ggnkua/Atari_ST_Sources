;---------------------------------------------------------------------
;  ******   **    *** **  **          **   **   **  ***   *** 
;  **      ****  **    ****          ****  *** *** ** ** **   
;  **     **  **  ***   **          **  ** ** * ** ** **  *** 
;  ****   ******    **  **    ***   ****** **   ** ** **    **
;  **     **  ** *  **  **          **  ** **   ** ** ** *  **
;  ****** **  **  ***   **          **  ** **   **  ***   *** 
;---------------------------------------------------------------------
;  TUTOR Shell
;---------------------------------------------------------------------

