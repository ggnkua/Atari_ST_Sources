
		SECTION CODE

***************************************************************************
*
*
*	TRAPPE GRAPHIQUE EASY AMOS
*
*
***************************************************************************

EzFlag		equ 	1
		INCDIR	":AMOS.s/Common/"
		Include "_w.s"

***************************************************************************

		END
