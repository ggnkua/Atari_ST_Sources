#ifndef SYSCALLS_H
#define SYSCALLS_H

extern long MySuper(long old_ssp);

#endif /* SYSCALLS_H */
