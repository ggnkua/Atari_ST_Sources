#ifndef INPUT_H
#define INPUT_D

int CheckInputStatus(void);
int ReadCharNoEcho(void);

#endif
