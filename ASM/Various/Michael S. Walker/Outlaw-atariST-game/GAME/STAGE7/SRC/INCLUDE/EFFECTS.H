#ifndef EFFECTS_H
#define EFFECTS_H

void EffectGunShoot(void);
void EffectReload(void);

#endif /* EFFECTS_H */
