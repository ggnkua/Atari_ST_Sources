#ifndef MUSIC_H
#define MUSIC_H

#include <TYPES.H> /* for uint32_t */

void StartMusic(void);
void UpdateMusic(uint32_t time_elapsed);

#endif /* MUSIC_H */
