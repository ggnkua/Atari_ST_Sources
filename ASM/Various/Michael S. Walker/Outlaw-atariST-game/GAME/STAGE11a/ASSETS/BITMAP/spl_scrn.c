/*	BitRip Copyleft !(c) 2020, Michael S. Walker <mwalk762@mtroyal.ca>
 *	All Rights Unreserved in all Federations, including Alpha Centauris.
 *
 *	.--. https://github.com/heapsmash/Monochrome-Bitmap-Converter ---------.
 *	|  |    Header Name    | Value |              Description              |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | type:             | 4d42  | (Magic identifier: 0x4d42)            |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | size:             | 32130 | (File size in bytes)                  |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | reserved1:        | 0     | (NOT USED)                            |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | reserved2:        | 0     | (NOT USED)                            |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | offset:           | 130   | (Offset to image data [54 bytes])     |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | dib_header_size:  | 108   | (DIB Header size in bytes [40 bytes]) |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | width_px:         | 640   | (Width of the image)                  |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | height_px:        | 400   | (Height of the image)                 |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | num_planes:       | 1     | (Number of color planes)              |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | bits_per_pixel:   | 1     | (Bits per pixel)                      |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | compression:      | 0     | (Compression type)                    |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | image_size_bytes: | 32000 | (Image size in bytes)                 |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | x_resolution_ppm: | 11811 | (Pixels per meter)                    |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | y_resolution_ppm: | 11811 | (Pixels per meter)                    |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | num_colors:       | 2     | (Number of colors)                    |
 *	:--+-------------------+-------+---------------------------------------:
 *	|  | important_colors: | 2     | (Important colors)                    |
 *	:--+-------------------+-------+---------------------------------------:
 */

const uint32_t splscrn[] = {
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0003FFFF, 0xFF000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00FE0FE0, 0x03E00000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0181F800, 0x00F80000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x03000000, 0x003E0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0E000000, 0x000FC000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x38000000, 0x0003F000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0xE0000000, 0x0001FC0F, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003,
	0x80000000, 0x00003FFF, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000000C,
	0x00000000, 0x00100000, 0xC3DC0000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000018,
	0x00000000, 0x00200000, 0x001FF000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000010,
	0x00000000, 0x03C00000, 0x0000FFE0, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000030,
	0x00000003, 0xFE180000, 0x000003E0, 0x3F000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000060,
	0x0000403C, 0x0FF00000, 0x0000007F, 0x1F800000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000000E0,
	0x000019C0, 0xF8000000, 0x0000007F, 0xFF000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000000C0,
	0x001FFE07, 0x00000000, 0x00000007, 0xE0000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000001C0,
	0x006007F8, 0x00000000, 0x0000001C, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000001C0,
	0x0003FC00, 0x00000000, 0x00000070, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000700,
	0x00000000, 0x00000000, 0x000003C0, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001C00,
	0x00000000, 0x00000000, 0x00000E00, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00003000,
	0x00000000, 0x00000000, 0x00003800, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000C000,
	0x00000000, 0x00000000, 0x0001C000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00038000,
	0x00000000, 0x00000000, 0x000F0000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000E0008,
	0x00000000, 0x80000000, 0x07F80000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00380000,
	0x00000000, 0x00000000, 0x1FE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00600000,
	0x00000000, 0x00000000, 0x7F800000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00C00000,
	0x00000000, 0x00000001, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x03000000,
	0x00000000, 0x00000007, 0xF0000000, 0x00000000, 0x00000000,
	0x000F3F00, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0C000000,
	0x00000000, 0x8000001F, 0xC0000000, 0x00000300, 0x00000000,
	0x000007FF, 0xE0000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00001FC0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x0000007E, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x1FFF8000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00007070, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x40000000,
	0x00000000, 0x000001FC, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00007F00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x000F801E, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000001, 0x00000000,
	0x00000000, 0x00003FC0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x0000001E, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x0010007F, 0xFFFC0000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000006, 0x03000000,
	0x00000000, 0x0003F800, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00100000, 0x00070000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000000C, 0x1C000000,
	0x00000000, 0x007F8000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00FF8010, 0x000F8000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000038, 0x60000000,
	0x00000000, 0x03C00000, 0x0000E000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x03800060, 0x0004E000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000000F0, 0x00000000,
	0x00000000, 0x00000000, 0x00078000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x0C0007C0, 0x00003000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000001F8, 0x00000000,
	0x000000C0, 0x00000000, 0x007C0000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x303E3C00, 0x00001FFF, 0xF8000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000001E0, 0x00000000,
	0x00FF8000, 0x00000000, 0x03C00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x4003C000, 0x0000007C, 0x0FFE0000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000003E0, 0x00067FFE,
	0x07E00000, 0x00000000, 0x08000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x80000000, 0x00000000, 0x03FFFE00, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000003FF, 0xFFFFF9F8,
	0x00000000, 0x00000000, 0x00006000, 0x03800000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000007, 0x00000000, 0x00000000, 0x000003FF, 0x80000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00007800, 0x0FC00000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00400000, 0x00000000,
	0x0000003C, 0x00000000, 0x00000000, 0x00000003, 0xBFC00000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001E00, 0x18E00000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000018, 0x00000000, 0x001C0000, 0x00000000, 0x007FF800,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00010F00, 0x30700000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000010, 0x00000000, 0x00710000, 0x00000000, 0x000007C0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00030380, 0x30300000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000060, 0x00000000, 0x03870000, 0x00000000, 0x40000078,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000201C0, 0x60180000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000600, 0x00000000,
	0x000000E0, 0x00000000, 0x0C1C0000, 0x00000001, 0x8010001C,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00040060, 0xC0080000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000040, 0x00000000,
	0x000001C0, 0x00000000, 0x70300000, 0x00000003, 0x00100038,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00040071, 0xFF7E0000, 0x00000000,
	0x00000000, 0x00000000, 0x00040000, 0x00000000, 0x00000000,
	0x000003C0, 0x00000001, 0xC0C00000, 0x000000FC, 0x007003C0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000C007F, 0xFFFF8000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00001F80, 0x0000000F, 0x03000000, 0x000007F0, 0x31800F80,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00080700, 0x000C07FF, 0xFFFFFC00, 0x00000000,
	0x00000000, 0x00000000, 0x00020000, 0x00000000, 0x00000000,
	0x00003000, 0x000000F0, 0x0E000000, 0x00003B41, 0xEE003C00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x003007E0, 0x001FFFFF, 0xFFFFFFFE, 0x00000000,
	0x00000000, 0x00001000, 0x00020000, 0x00000000, 0x00000000,
	0x0000E000, 0x00000F80, 0xF8000000, 0x0001EF87, 0x3800F000,
	0x00000000, 0x00000000, 0x00000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x000003FE, 0x003FFC03, 0xFFFF01FF, 0xF8000000,
	0x00000000, 0x00001000, 0x00020000, 0x00000000, 0x00000000,
	0x0003C000, 0x000FF007, 0x00000000, 0x000F1E0C, 0x6007C000,
	0x00000000, 0x00000000, 0x00000000, 0x0003FFFF, 0xE0000000,
	0x00000000, 0x000000FF, 0xF3FF0003, 0xE0F00003, 0xFE000000,
	0x00000000, 0x00001000, 0x00020000, 0x00000000, 0x00000000,
	0x001F0000, 0x0000003C, 0x00000000, 0x00F06001, 0x801F8000,
	0x00000000, 0x00000000, 0x00000000, 0x000F2001, 0xF0000000,
	0x00000000, 0x0000003F, 0xFFF00007, 0x03F80800, 0x7F800000,
	0x00000000, 0x00000800, 0x00020000, 0x00000000, 0x00000000,
	0x00780000, 0x000007C0, 0x00000000, 0x0701C033, 0x00FE0000,
	0x00000000, 0x00000000, 0x00000000, 0x003E0000, 0xF8000000,
	0x00000000, 0x0000000F, 0xFFC0030E, 0x1FFF8C00, 0x3FE00000,
	0x00000000, 0x00000400, 0x00040000, 0x00000000, 0x00000000,
	0x01E00000, 0x0001FC00, 0x00000000, 0x7C0E0064, 0x07800000,
	0x00000000, 0x00000000, 0x00000000, 0x003E0000, 0x7C000000,
	0x00000000, 0x0000003F, 0xFF800F0E, 0x3FFFDE00, 0x03FC0000,
	0x00000000, 0x00000200, 0x00000000, 0x00000000, 0x00000000,
	0x07800000, 0x00000000, 0x00000003, 0xC0300180, 0x1C000000,
	0x00000000, 0x00000000, 0x00000000, 0x003F8000, 0x7C000000,
	0x00000000, 0x00000000, 0xFF807E1F, 0xFFFFFE0F, 0xC0781800,
	0x00000000, 0x00000000, 0x00000000, 0x00000700, 0x00000000,
	0x0E000000, 0x00000000, 0x0000001E, 0x03C00700, 0xF8000000,
	0x00000000, 0x00000000, 0x00000000, 0x007E8000, 0x7C000000,
	0x00000000, 0x00000000, 0x7FCFFE1F, 0xBFFFFE1F, 0xE03FC300,
	0x00000000, 0x00000000, 0x00000000, 0x000003E0, 0x00000C00,
	0xF0000000, 0x00000000, 0x000000E0, 0x04001C0F, 0xF0000000,
	0x00000000, 0x00000000, 0x00000000, 0x007E8000, 0x7C000000,
	0x00000000, 0x00000003, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0F00,
	0x00000000, 0x00000000, 0x00000000, 0x00000078, 0x00000303,
	0x80000000, 0x00000000, 0x00000F80, 0x0000E03F, 0x80000000,
	0x00000000, 0x00000000, 0x00000000, 0x007D8000, 0x7C000000,
	0x00000000, 0x0000000F, 0xFFFFFFFF, 0xFFFFFF80, 0x0707FF00,
	0x00000000, 0x00000000, 0x00000000, 0x0000003E, 0x000001FC,
	0x00000000, 0x00000000, 0x0000F800, 0x38038078, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x007F8001, 0xF8000000,
	0x00000000, 0x0000000F, 0xFFFFFFFF, 0x87F86000, 0x078FE0C0,
	0x00000000, 0x00000000, 0x00000004, 0x0000000F, 0x000000F0,
	0x00000000, 0x00000000, 0x000F8000, 0xC01E0060, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x007F0001, 0xF8000000,
	0x00000180, 0x0010000F, 0xFFFFFE06, 0x1F000000, 0x000FFEF0,
	0x00000000, 0x00000000, 0x0000000C, 0x00000003, 0x800001E0,
	0x00000000, 0x00000000, 0x03F80007, 0x81F80780, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x007F0003, 0xF8000000,
	0x00000300, 0x0000030F, 0xFFC7F00C, 0x38000000, 0x00007FFC,
	0x00000000, 0x00000000, 0x00000018, 0x00000001, 0x80000380,
	0x00000000, 0x00000003, 0xFE00003C, 0x09C03E00, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x007C0000, 0xF0000000,
	0x00000C00, 0x0000031F, 0xFF1FE01F, 0x00000000, 0x0000001F,
	0xE0000000, 0x00000000, 0x00000018, 0x00000001, 0xC0000E00,
	0x00000000, 0x0000001C, 0x000003E0, 0x1E00E180, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x004C0000, 0x70000000,
	0x00001800, 0x000003FF, 0xF9FF801F, 0x00000000, 0x00000007,
	0xFE000000, 0x00000000, 0x00000038, 0x00000000, 0xC0003800,
	0x0003FFFF, 0xFFFFFFE0, 0x00000000, 0x000780C0, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x004C0000, 0x70000000,
	0x00004003, 0x800001FF, 0xF3FE0000, 0x00000000, 0x00000003,
	0xFE00F000, 0x00000000, 0x00000018, 0x00000000, 0x8001E000,
	0x00000000, 0x00000000, 0x00000000, 0x001E0020, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00580000, 0x60000000,
	0x00008007, 0xE0000FFF, 0xFFFC0000, 0x00018000, 0x00000003,
	0xFE00FF00, 0x00000000, 0x00000018, 0x00000000, 0x8007C000,
	0x00000000, 0x00000000, 0x00000000, 0x00780018, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00580000, 0xE0000000,
	0x0000000E, 0xF8003FFF, 0xFFFC0000, 0x00060000, 0x00000000,
	0xFF00F000, 0x00000000, 0x00000018, 0x00000000, 0x800E8000,
	0x00000000, 0x00000000, 0x00000000, 0x01E0000E, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00180000, 0xE0000000,
	0x0004001E, 0x7F00FFFE, 0x77F80000, 0x000C0000, 0x00000000,
	0x3FF0E000, 0x00000000, 0x0700000C, 0x00000001, 0x001C0000,
	0x00000000, 0x00000000, 0x00000000, 0x0F800001, 0x80000000,
	0x00000000, 0x00000000, 0x00000000, 0x00380000, 0xE0000000,
	0x0008003E, 0x3F81FE7C, 0x03F80020, 0x00180000, 0x00000000,
	0x03FC2000, 0x00000000, 0x03C00004, 0x00000002, 0x000C4000,
	0x00000000, 0x00000000, 0x00000000, 0x0E000000, 0xC0000000,
	0x00000000, 0x00000000, 0x00000000, 0x00780000, 0xE0000000,
	0x0020007F, 0x9C77FFFC, 0x81FE01C0, 0x00000000, 0x00000000,
	0x007F1800, 0x00000000, 0x03E00000, 0x00000004, 0x000FF000,
	0x00000000, 0x00000000, 0x00000004, 0x78000000, 0x20000000,
	0x00000000, 0x00000000, 0x00000000, 0x007C0003, 0xE0000000,
	0x004000E7, 0xC77FFFF9, 0x0DFE0780, 0x00030000, 0x00000000,
	0x000F8F00, 0x00000000, 0x00F00001, 0x00000000, 0x000FFF00,
	0x00000000, 0x00000000, 0x00000001, 0xC0000000, 0x10000000,
	0x00000000, 0x00000000, 0x00000000, 0x007E0003, 0xE0000000,
	0x00800081, 0xE3FFFFF3, 0x0FFC5F00, 0x00080000, 0x00000000,
	0x0001F780, 0x00000000, 0x00700000, 0x00000000, 0x00007FE1,
	0xFFFE0000, 0x00000000, 0x00000007, 0x00000000, 0x08000000,
	0x00000000, 0x00000000, 0x00000000, 0x003C0001, 0xE0000000,
	0x01000100, 0x63FFFFF1, 0xBFFCFE00, 0x01F80000, 0x00000000,
	0x0001FE00, 0x00000000, 0x00780000, 0x00000000, 0x00000F80,
	0x03FF8000, 0x00000000, 0x00000078, 0x00003800, 0x0F000000,
	0x00000000, 0x00000000, 0x00000000, 0x003C0001, 0xE0000000,
	0x02000300, 0x3FFFFFE1, 0x7FFFFE00, 0xC3C01F07, 0x80000000,
	0x3001FC00, 0x00002000, 0x00380000, 0x00000000, 0x00000280,
	0x001FF000, 0x00000000, 0x003C03C0, 0x00000800, 0x00800000,
	0x00000000, 0x00000000, 0x00000000, 0x00380001, 0xF0000000,
	0x0000063E, 0x3FFFFFC6, 0x7FFFFC83, 0x3C00FC1E, 0x00000000,
	0x03007F00, 0x00000000, 0x00100000, 0x00000000, 0x00000000,
	0x00071E06, 0x00000007, 0xC0003E00, 0x00000400, 0x00E00000,
	0x00000000, 0x00000000, 0x00000000, 0x00380001, 0xF0000000,
	0x18000E7E, 0x3FFFFFCF, 0xCFFFFE03, 0x700FF020, 0x00000000,
	0x00000780, 0x00001000, 0x00000000, 0x00000000, 0x00000000,
	0x000381FF, 0xE03DFFFF, 0xFFFFC000, 0x00000300, 0x00200000,
	0x00000000, 0x00000000, 0x00000000, 0x00380001, 0xFC000000,
	0x38001C66, 0x7FFFFFFF, 0xEFFFFC0F, 0x73FFF1C0, 0x00000F00,
	0x00000270, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0001C008, 0x3FFFF000, 0x00000000, 0x00000080, 0x001C0000,
	0x00000000, 0x00000000, 0x00000000, 0x00380001, 0xFE000000,
	0x70003CC0, 0xFFFFFFFF, 0xFFFFFC0F, 0x7FFF3FFC, 0x0001F800,
	0x0000037C, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0000C010, 0x00000000, 0x00000000, 0x000000C0, 0x00020000,
	0x00000000, 0x00000000, 0x00000000, 0x00380003, 0xDE000000,
	0xE000F9C1, 0xFFFFFFFF, 0xFFFFFC1F, 0xFFF8FFF0, 0x001FC000,
	0x0000007F, 0x80000000, 0x00000000, 0x00000000, 0x00000000,
	0x00006030, 0x00000000, 0x00000000, 0x00000020, 0x00038000,
	0x00000000, 0x00000000, 0x00000000, 0x00780003, 0xCF000001,
	0x8001F1FF, 0xFFFFFBFF, 0xFFFFFF7F, 0xFFFFFFC0, 0x00FF0380,
	0x0000003F, 0xC0000004, 0x00000000, 0x00000000, 0x00000000,
	0x00003020, 0x00000000, 0x00000000, 0x00000010, 0x00006000,
	0x00000000, 0x00000000, 0x00000000, 0x007FC007, 0xCF800003,
	0x8001F0FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x0FFE7FC0,
	0x0000001F, 0xC3000000, 0x00000000, 0x00004008, 0x00000008,
	0x00003820, 0x00000000, 0x00000000, 0x00000010, 0x00003800,
	0x00000000, 0x00000000, 0x00000000, 0x007F8007, 0xFFC00007,
	0x0000FC1F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFEFF0, 0xFFFFFFC0,
	0x30000007, 0xE3F00000, 0x00000000, 0x00002004, 0x00000000,
	0x00001C40, 0x00000000, 0x00000000, 0x0000000C, 0x00000800,
	0x00000000, 0x00000000, 0x00000000, 0x007C0007, 0xFFE00006,
	0x00000FFF, 0xFFFFFF7F, 0xFFFFFFFF, 0xFFFF9FFF, 0xFFFFFFE0,
	0x00000001, 0xFBC00000, 0x00000000, 0x00001804, 0x00000000,
	0x00000C40, 0x00000000, 0x00000000, 0x00000004, 0x00000E00,
	0x00000000, 0x00000000, 0x00000000, 0x00780003, 0xF9F0000C,
	0x000000FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0,
	0x00000000, 0x7F000000, 0x00000000, 0x00000C03, 0x00000000,
	0x00000600, 0x00000004, 0x0000000E, 0x00000002, 0x00000200,
	0x00000000, 0x00000000, 0x00000000, 0x00780003, 0xF8F80018,
	0x0000003F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF800,
	0x00000000, 0x1FC00000, 0x00000000, 0x00000601, 0x80000000,
	0x00000700, 0x00000004, 0x00000002, 0x00000001, 0x00000180,
	0x00000000, 0x00000000, 0x00000000, 0x00780003, 0xF87C0030,
	0x0000003F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000,
	0x00000200, 0x3DF00000, 0x00002000, 0x00000600, 0x60000000,
	0x00000380, 0x00000004, 0x00000001, 0x80000001, 0x000000C0,
	0x00000000, 0x00000000, 0x00000000, 0x00780003, 0xF87C0020,
	0x000003FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF000C,
	0x00000300, 0x3DF80000, 0x00000000, 0x00000200, 0x18000000,
	0x000001C0, 0x00000004, 0x00000000, 0x40000001, 0x80000020,
	0x00000000, 0x00000000, 0x00000000, 0x00700003, 0xFC7E0060,
	0x000003FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFE,
	0x4E07C1E0, 0x1CFC0000, 0x00000000, 0x00000200, 0x001F0000,
	0x000000C0, 0x00000004, 0x00000000, 0x20000000, 0x80000030,
	0x00000000, 0x00000000, 0x00000000, 0x00F00003, 0xFC3F00C0,
	0x000001FF, 0xFFFFFFFF, 0xFFFBFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFF0018, 0x1FFC0000, 0x00000000, 0x00000600, 0x00000000,
	0x000000E0, 0x00000004, 0x00000000, 0x10000000, 0x40000008,
	0x00000000, 0x00000000, 0x00000000, 0x00F00003, 0xFE3F8080,
	0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFC1C00, 0xFFFFFFFF, 0xC0000000, 0x00000400, 0x00000000,
	0x000000E0, 0x00000004, 0x00000000, 0x0C000000, 0x20000006,
	0x00000000, 0x00000000, 0x00000000, 0x00F00007, 0xFE2FC180,
	0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFE,
	0x00000000, 0x3FFF003F, 0xF0000000, 0x00000C00, 0x00000000,
	0x00000070, 0x00000004, 0x00400000, 0x02000000, 0x20000002,
	0x00000000, 0x00000000, 0x00000000, 0x01F80007, 0xFF07FF00,
	0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFC,
	0x00000030, 0x0FFF0003, 0xFC000000, 0x00001800, 0x00000000,
	0x00000070, 0x00000008, 0x00800200, 0x01800000, 0x10000002,
	0x00000000, 0x00000000, 0x00000000, 0x01F0001F, 0xFFE3FF00,
	0x0000F1FF, 0xFFFF3FFF, 0xFFFFFFFF, 0xFFFE1FFF, 0xE7FFFFFC,
	0x0000001F, 0xFFFF8000, 0x7E000000, 0x00007000, 0x00000000,
	0x00000038, 0x00000008, 0x00800200, 0x00800000, 0x0C000003,
	0x00000000, 0x00000000, 0x00000000, 0x01F0000F, 0xF7E3BE00,
	0x0001FFFF, 0xFFFC0FFF, 0xFFFFFFFF, 0xFF00007F, 0xFF1FFFFF,
	0xFFFE0000, 0x00E7C000, 0x1F000000, 0x0001E000, 0x00000000,
	0x00000038, 0x00000018, 0x00800100, 0x00400000, 0x02000000,
	0x00000000, 0x00000000, 0x00000000, 0x01F0001F, 0xBFE3DC00,
	0x0003FFFF, 0xFFF8007F, 0xFFFFFFFF, 0xF0000000, 0x7E0DFFFF,
	0xF0000000, 0x00E3C000, 0x0F800380, 0x00478000, 0x00000000,
	0x0000001C, 0x00000020, 0x008000C0, 0x00200000, 0x01000000,
	0x00000000, 0x00000000, 0x00000000, 0x01E0000F, 0xBFF1F600,
	0x0007FFFF, 0xFFF00007, 0xFFFFF800, 0x00000000, 0x7C0FFF00,
	0x00000000, 0x0003E000, 0x07800060, 0x03FE0000, 0x00000002,
	0x0000000C, 0x00000020, 0x00800020, 0x00300000, 0x00C00000,
	0x00000000, 0x00000000, 0x00000000, 0x01E00007, 0xB9F1F300,
	0x000FFFFF, 0xFFF00000, 0x0FFF0000, 0x00003FFF, 0xF8000000,
	0x00000060, 0x0007F000, 0x03C0000F, 0xFFF00000, 0x00000001,
	0x8000000C, 0x00000020, 0x00800010, 0x00080000, 0x00300000,
	0x00000000, 0x00000000, 0x00000000, 0x01E00007, 0x38F93380,
	0x001FFFFF, 0xFFFE7C03, 0xFFFFC03F, 0xFFFFFF01, 0xF0000000,
	0x00400087, 0x0007F000, 0x03C00000, 0x00000000, 0x00000000,
	0xC000000C, 0x00000040, 0x0080000E, 0x00040000, 0x007E0000,
	0x00000000, 0x00000000, 0x00000000, 0x01C00007, 0x1C7C3FC0,
	0x001FFFFF, 0xFFFFFFFF, 0xFFFE0007, 0x00000F80, 0x3C000038,
	0x00800101, 0x800FF000, 0x03C00000, 0x00000000, 0x00000000,
	0x20000006, 0x00000080, 0x01800001, 0x80020000, 0x007E0000,
	0x00000000, 0x00000000, 0x00000000, 0x03C00007, 0x1C3E27C0,
	0x003FFFFF, 0xFF800000, 0xFFF80038, 0x000001E0, 0x1E000006,
	0x01008301, 0x807FE000, 0x03C00000, 0x00000000, 0x00000000,
	0x00000006, 0x00000100, 0x02000000, 0x80010007, 0xFFFFFFC0,
	0x00000000, 0x00000000, 0x00000000, 0x03C00007, 0x0E3F03E0,
	0x003FFFFF, 0xFF007800, 0xFFFC07F8, 0x00000070, 0x0F000101,
	0x83008001, 0x00FFC001, 0x01C00000, 0x00000000, 0x00000000,
	0x10000002, 0x00000100, 0x02000000, 0xC0018000, 0x1FFFF000,
	0x00000000, 0x00000000, 0x00000000, 0x03C00007, 0x0E1F83F0,
	0x007FF3FF, 0xFE007FFF, 0xFFFFFFF8, 0x0000001C, 0x03800300,
	0xC1000003, 0x03FF8001, 0x03C00000, 0x00000000, 0x00000000,
	0x10000002, 0x00000600, 0x02000000, 0x20004000, 0x0223C000,
	0x00000000, 0x00000000, 0x00000000, 0x03C00006, 0x0E0F83F8,
	0x00FFFFFF, 0xFE0067FF, 0xFFFFFFF0, 0x0000000F, 0x01C00100,
	0x8060003F, 0xFFFC0001, 0x03C00000, 0x00000000, 0x00000000,
	0x10000003, 0x00000400, 0x06000000, 0x18002000, 0x03FFC000,
	0x00000000, 0x00000000, 0x00000000, 0x03800006, 0x070FE4F8,
	0x01FFFFFF, 0xFC007FFF, 0xFFFFFFF0, 0x00000007, 0x03C00020,
	0x803F3FFF, 0xFF8C0001, 0x03C00000, 0x00000000, 0x00000000,
	0x10000003, 0x00000800, 0x04000000, 0x04001800, 0x01FF8000,
	0x00000000, 0x00000000, 0x00000000, 0x03800006, 0x070FF47C,
	0x01FFFFFF, 0xFC007803, 0xFFF80FF0, 0x0000000E, 0x0780001F,
	0xFFFFFFFE, 0x7FFE0001, 0x03C00000, 0x00000000, 0x00000000,
	0x00000001, 0x00001800, 0x04007E00, 0x04000400, 0x009F0000,
	0x00000000, 0x00000000, 0x00000000, 0x03800006, 0x038FF83C,
	0x03FFFFFF, 0xFC000003, 0xFFF00070, 0x0000001C, 0x0F8007FF,
	0xFE7FF000, 0x1FFE0000, 0x03800000, 0x00000000, 0x00000000,
	0x00000001, 0x00002000, 0x08007E00, 0x02000200, 0x00FF0000,
	0x00000000, 0x00000000, 0x00000000, 0x03800006, 0x03C7F83E,
	0x077FFFFF, 0xFE000007, 0xF3F80010, 0x00000038, 0x1FFFFFFF,
	0xFFF80030, 0x03FF0002, 0x03800000, 0x00000080, 0x00000000,
	0x20000001, 0x80002000, 0x13FFFFFF, 0xE3000100, 0x003F0000,
	0x00000000, 0x00000000, 0x00000000, 0x03C0000E, 0x03E7FC1E,
	0x067FFFFF, 0xFF000003, 0xF3F80000, 0x00000078, 0x7FFFFFFF,
	0x801C003F, 0xB8FF0002, 0x07000000, 0x00000000, 0x00000000,
	0x40000001, 0x80002000, 0x100FFFF8, 0x01000080, 0x000F0000,
	0x00000000, 0x00000000, 0x00000000, 0x03C0000E, 0x01E7FE1F,
	0x0C0003FF, 0xFF800000, 0x00000000, 0x000000FF, 0xFFF8007F,
	0xC0FFC01F, 0xFF3F8006, 0x0F000000, 0x00000040, 0x00000000,
	0x80000001, 0x80006000, 0x2003C440, 0x008000C1, 0xF80F0000,
	0x00000000, 0x00000000, 0x00000000, 0x0380001E, 0x00E3FE0F,
	0x1C00001F, 0xFFFF8000, 0x00000000, 0x0003FFFF, 0xFC00003F,
	0xE0FFFFFF, 0xFF9F8004, 0x0E000000, 0x00000030, 0x00000001,
	0x00000000, 0x80004000, 0x2003FFC0, 0x00800060, 0x380F0000,
	0x00000000, 0x00000000, 0x00000000, 0x0780001C, 0x00E3FF07,
	0x9F80000F, 0xFF001F9F, 0xC0001FFF, 0xFFC00000, 0xFC00003F,
	0xF8FFFFE1, 0xFFFF800C, 0x1C000000, 0x00000010, 0x00000000,
	0x00000000, 0x8000C000, 0x6001FF80, 0x00C00030, 0x3FFF0000,
	0x00000000, 0x00000000, 0x00000000, 0x0780001C, 0x0063E387,
	0xC1F8000F, 0xFF000000, 0x00000000, 0x00000003, 0xF000003F,
	0xFFFFF800, 0x7FFFC018, 0x18000000, 0x00000000, 0x00000000,
	0x00000000, 0x80008000, 0xC000F900, 0x00200008, 0x0FFF0000,
	0x00000000, 0x00000000, 0x00000000, 0x0780001C, 0x0073E0E7,
	0xC000001F, 0xFF800000, 0x00000000, 0x00000003, 0xE000001F,
	0xFFFFC01F, 0xFFFFC010, 0x30000000, 0x00000000, 0x00000000,
	0x00000000, 0x80008001, 0x0000FE00, 0x0020000C, 0x001F0000,
	0x00000000, 0x00000000, 0x00000000, 0x0700001C, 0x003FE07F,
	0xC0000007, 0xFF000000, 0x30000000, 0x00000003, 0xF000000F,
	0xFFFFFBFF, 0xFFFFE030, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x80018003, 0x0000FC00, 0x00180004, 0x001F0000,
	0x00000000, 0x00000000, 0x00000000, 0x0700001C, 0x003FF01F,
	0xE0000003, 0xFE000000, 0x00000000, 0x00000000, 0xF0000007,
	0xFFFFE7E0, 0xFFFFE021, 0xC0000000, 0x00000000, 0x00000000,
	0x00000001, 0x80030004, 0x0000F000, 0x00080006, 0x003F0000,
	0x00000000, 0x00000000, 0x00000000, 0x0700001C, 0x001FF00F,
	0xE0000003, 0xFC000000, 0x00000000, 0x00000000, 0x00000003,
	0xFF87FE3F, 0xFFFFE041, 0xC0000000, 0x00000000, 0x00000000,
	0x00000001, 0x80020004, 0x0000F000, 0x000C0001, 0x003F1F00,
	0x00000000, 0x00000000, 0x00000000, 0x0700001C, 0x001FF803,
	0xE0000003, 0xF8000000, 0x00000000, 0x00000000, 0x00000001,
	0xCFBFFC7F, 0xC3FFF003, 0xC0000000, 0x00000060, 0x00000000,
	0x00000001, 0x80020004, 0x0000F000, 0x00040001, 0x007FF1FF,
	0x00000000, 0x00000000, 0x00000000, 0x0700001C, 0x000FF000,
	0xC000000F, 0xD0000000, 0x00000000, 0x00000000, 0x00000001,
	0xE7FC0FC1, 0xE0FFF183, 0x80007000, 0x0000001C, 0x00000000,
	0x00000001, 0x80060008, 0x000FFFC0, 0x00020000, 0x80FF8000,
	0x00000000, 0x00000000, 0x00000000, 0x0300001C, 0x0007F000,
	0x0000000F, 0xE0000000, 0x000C0000, 0x00000000, 0x00000000,
	0xE3F01E0F, 0xFC1FF300, 0x00001800, 0x00000006, 0x00000000,
	0x00000001, 0x80040008, 0x0019F860, 0x00020000, 0x80FF0000,
	0x00000000, 0x00000000, 0x00000000, 0x0300003C, 0x0007F000,
	0x0000001F, 0xE0000000, 0x00100000, 0x00000000, 0x00080000,
	0x7BF03819, 0xFFFFF700, 0x00000800, 0x00000001, 0x80000000,
	0x00000001, 0x80080010, 0x0019F860, 0x00020000, 0x83FF0000,
	0x00000000, 0x00000000, 0x00000000, 0x03800038, 0x0003F800,
	0x0000001F, 0xF0000000, 0x00000000, 0x001FF800, 0x000E0000,
	0x38E07878, 0xE7FFFF80, 0x00000800, 0x80000000, 0xC0000000,
	0x00000001, 0xC0080030, 0x0019F860, 0x00010000, 0xDEFF0000,
	0x00000000, 0x00000000, 0x00000000, 0x03800078, 0x0001F800,
	0x0000001F, 0xFFE00000, 0x20000000, 0x00FFFE00, 0x00060000,
	0x00F0F0FF, 0xC3EFFEE0, 0x00000801, 0x00000000, 0x40000000,
	0x00000001, 0xC0100020, 0x0019FC60, 0x0000803F, 0xF0FF0000,
	0x00000000, 0x00000000, 0x00000000, 0x03800078, 0x0000F800,
	0x080000FF, 0xFFFFFFC0, 0x701E03E0, 0xFFFFFFF0, 0x00040000,
	0x07FFF1EF, 0x80FFFEE0, 0x80300801, 0x00000000, 0x40000000,
	0x00000001, 0xC0200040, 0x0019FC60, 0x000081C0, 0x40FF0000,
	0x00000000, 0x00000000, 0x00000000, 0x03800078, 0x0000FC03,
	0xF80001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFC000000,
	0x07FFF1FF, 0x00FFF600, 0x00100801, 0x00000000, 0x40000000,
	0x00000003, 0x80200080, 0x0019FE60, 0x000083C0, 0x40FF8010,
	0x00000000, 0x00000000, 0x00000000, 0x03800070, 0x0000FE7F,
	0xF80003FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF000000,
	0x0FFFF0FF, 0xE07FF400, 0x00100801, 0x00000000, 0x40000000,
	0x00000003, 0x80200080, 0x0019FF60, 0x0000C700, 0x60F78008,
	0x00000000, 0x00000000, 0x00000000, 0x03800070, 0x00007FFF,
	0xF000039F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF000000,
	0x0F8FF861, 0xE07FFC00, 0x00180801, 0x00000000, 0xC0000000,
	0x00000003, 0x80400100, 0x0019FF60, 0x0000BE00, 0x20E38006,
	0x00000000, 0x00000000, 0x00000000, 0x07800070, 0x0000FFFC,
	0x6000071F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFF8, 0x3F000000,
	0x0F9BF831, 0xE07FF800, 0x00180801, 0x00000001, 0xC0000000,
	0x00000003, 0x80400200, 0x0019FF60, 0x7E00F000, 0x30E38001,
	0x00000000, 0x00000000, 0x00000000, 0x07800070, 0x0001FFF8,
	0x60000E3F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x00000000,
	0x0F993038, 0xE07FF800, 0x00300800, 0x00000003, 0x80000000,
	0x00000007, 0x00C00400, 0x001DFF47, 0x81FF0800, 0x13E78000,
	0x00000000, 0x00000000, 0x00000000, 0x07800070, 0xC01FFFE0,
	0xC0000FFF, 0xFFFFFFFF, 0xF001FFF8, 0x00FFE000, 0x00000000,
	0x1FBF1038, 0xC0FFF000, 0x00000800, 0x00000007, 0x00000000,
	0x00000007, 0x00800400, 0x000FFFF8, 0x00000C00, 0x1FE78000,
	0x00000000, 0x00000000, 0x00000000, 0x0380007F, 0xFFFC0FC0,
	0xC0001FFF, 0xFFFFFFFF, 0xE001F9FC, 0x007F8000, 0xC0000000,
	0x0F360078, 0xC1FFE000, 0x00000800, 0x0000000E, 0x00000000,
	0x00000007, 0x00800C00, 0x0003FF80, 0x00000600, 0x00800000,
	0x00000000, 0x00000000, 0x00000000, 0x0380007C, 0x1FE01F81,
	0x80001FFF, 0xFF9CFFFF, 0xE001D87F, 0x000FFCFF, 0x80000000,
	0x07C624FD, 0xC3FFC07F, 0xFC000800, 0x00000018, 0x00000000,
	0x00000006, 0x01800800, 0x000DFF00, 0x00000200, 0x00C00000,
	0x00000000, 0x00000000, 0x00000000, 0x03800070, 0x18E07E03,
	0x80003FFF, 0xFF3FFFFF, 0xC0018C3F, 0xC0007FF0, 0x00000001,
	0x008FE60F, 0x877FC070, 0x0FFE1C00, 0x00000060, 0x00000000,
	0x00000006, 0x02000800, 0x0079EF00, 0x00000100, 0x007C1800,
	0x00000000, 0x00000000, 0x00000000, 0x078000F8, 0x0060F007,
	0x00003FFF, 0xFF0FFFFB, 0xC001C01F, 0xC0000000, 0x00000003,
	0x819FE007, 0x87FFE070, 0x003FFC00, 0x00000600, 0x00000000,
	0x0000000E, 0x02001800, 0x0FC1C700, 0x00000103, 0xFFFFF000,
	0x00000000, 0x00000000, 0x00000000, 0x078000F8, 0x001BC007,
	0x00007FFF, 0xFF01FFE3, 0x8001E01C, 0x00000000, 0x00000007,
	0x0FFFE007, 0x87FFF830, 0x0001F800, 0x00001000, 0x00000000,
	0x0000387C, 0x04001000, 0x38018700, 0x00000087, 0xFFFFFC00,
	0x00000000, 0x00000000, 0x00000000, 0x078000F8, 0x000F800F,
	0x0000E7FF, 0xFF003F03, 0x8000701C, 0x00000000, 0x0000001E,
	0x07FFB803, 0x8797FC30, 0x00000000, 0x00000000, 0x00000000,
	0x0001F01C, 0x0C003000, 0xE007CFC0, 0x00000063, 0xFFFFFC00,
	0x00000000, 0x00000000, 0x00000000, 0x078000F9, 0x801E001E,
	0x0000C7FF, 0xFF003E01, 0x8000101C, 0x00000000, 0x0000003C,
	0x0E7FF800, 0x1F03FFF0, 0x00000000, 0x00000000, 0x00001F00,
	0x0000E018, 0x08002003, 0x800F83E0, 0x0000002F, 0xFFFFF000,
	0x00000000, 0x00000000, 0x00000000, 0x07C001F1, 0x8038001E,
	0x000183FF, 0xFF007801, 0x8000000E, 0x00000000, 0x000000E0,
	0x1CFBFC00, 0x3E03FFFC, 0x00000040, 0x00000000, 0x60003F80,
	0x0001E038, 0x1800200C, 0x00000000, 0x0000003F, 0xFFFFF000,
	0x00000000, 0x00000000, 0x00000000, 0x078001F8, 0x0060403E,
	0x0003801F, 0xFF000003, 0x8000000C, 0x001C0000, 0x00000380,
	0x18F3FC00, 0x3C0FFFFF, 0xF0000040, 0x00000001, 0xE0E0FBE0,
	0x0003C030, 0x10006030, 0x000007FF, 0xC0000010, 0x0FFFF800,
	0x00000000, 0x00000000, 0x00000000, 0x078000F8, 0x0380403C,
	0x0001E007, 0xFF800003, 0x80000018, 0x0007E020, 0x00003E00,
	0x387BFE00, 0x781FFFFF, 0xFE000040, 0x00000008, 0x67FFC0E0,
	0x00038030, 0x2000C0E0, 0x00003FFF, 0xF0000008, 0x0FFFF000,
	0x00000000, 0x00000000, 0x00000000, 0x0F0000F0, 0x0600423C,
	0x00000E01, 0xFF000003, 0x80000000, 0x0003FF78, 0x0007F800,
	0x387FFF81, 0xF01FFFFF, 0xFFF80000, 0x00000010, 0x7C0000E0,
	0x00078060, 0x40010080, 0x0007FFFF, 0xFFFFE008, 0x001E6000,
	0x00000000, 0x00000000, 0x00000000, 0x0F0000F0, 0x0E00027C,
	0x000000E1, 0xFF000703, 0x00000000, 0x00007FFF, 0x00038000,
	0x38FFFFE7, 0xE01FFFFF, 0xFFFFF000, 0x00000030, 0x780001C0,
	0x000300E0, 0x40010100, 0x007FFFFF, 0xFFF00008, 0x00002000,
	0x00000000, 0x00000000, 0x00000000, 0x0F0000F0, 0x38000078,
	0x0000000F, 0xFF001F03, 0x00000020, 0x00001FC0, 0x00000000,
	0x31FFF3C3, 0xC01FFFFF, 0xFFFFFF80, 0x00000030, 0x78006380,
	0x004300C0, 0x40020200, 0x000EFFFF, 0xFFF80004, 0x00001000,
	0x00000000, 0x00000000, 0x00000000, 0x0F0000F8, 0x700000FC,
	0x00000003, 0xFF80FFB7, 0x000019F8, 0x00000F00, 0x00000000,
	0x73F7E003, 0x801FFFFF, 0xFFFFFFF0, 0x00000010, 0x70042780,
	0x010601C0, 0x80020400, 0x0001FFFF, 0xFFFF8004, 0x00001000,
	0x00000000, 0x00000000, 0x00000000, 0x1F0000F9, 0xC00001FC,
	0x00000001, 0xFF80FFFE, 0x0040007E, 0x00000780, 0x00000000,
	0x7FC3E007, 0x001FFFFF, 0xFFFFFFFE, 0x00000010, 0x700C07C0,
	0x1C040180, 0x80000800, 0x00001FFF, 0xFFFFC002, 0x00000800,
	0x00000000, 0x00000000, 0x00000000, 0x0F0000FB, 0x800279FE,
	0x00000001, 0xFFE019C0, 0x0000001F, 0x000001C0, 0x00000000,
	0x7807E00C, 0x000FFFFF, 0xFFFFFFFF, 0xC0000018, 0x300413F1,
	0xC0080300, 0x80001000, 0x0000001F, 0xFFFFC002, 0x00000800,
	0x00000000, 0x00000000, 0x00000000, 0x1F0000FF, 0x00020F9E,
	0x00000007, 0xFFF81B80, 0x0000000F, 0xE00000C0, 0x00000000,
	0x000F8018, 0x000FFFFF, 0xFFFFFFFF, 0xFC00000C, 0x3F83F0F8,
	0x00080300, 0x80003000, 0x0000001F, 0xFFFF0001, 0x00000400,
	0x00000000, 0x00000000, 0x00000000, 0x3F0000FC, 0x00000E0F,
	0x0000001F, 0xFFFC3F80, 0x0000000F, 0xF8000040, 0x00000000,
	0x00078030, 0x000FFFFF, 0xFFFFFFFF, 0xFFE00006, 0x2FE07000,
	0x00100600, 0x80006000, 0x00000000, 0x7FE00001, 0x00000200,
	0x00000000, 0x00000000, 0x00000000, 0x3F0000F8, 0x00001C07,
	0x800000FF, 0xFFFF6780, 0x0000001F, 0x3C000010, 0x00000000,
	0x00038C60, 0x000FFFFF, 0xFFFFFFFF, 0xFFFE0003, 0xC0180000,
	0x00300E01, 0x8000C000, 0x00000000, 0x00000000, 0x80000200,
	0x00000000, 0x00000000, 0x00000000, 0x3F8001F0, 0x00007007,
	0x800003FF, 0xFFFFE7E0, 0x00007FFE, 0x0E000008, 0x00000000,
	0x0007C5C0, 0x000FFFFF, 0xFFFFFFFF, 0xFFFFE001, 0xC00C0000,
	0x00600C01, 0x00038000, 0x00000000, 0x00000000, 0x80000200,
	0x00000000, 0x00000000, 0x00000000, 0x3F0301E0, 0x0001E003,
	0xC0001FFF, 0xFFFFC7FC, 0x0001FFFE, 0x03800000, 0x00000000,
	0x003F0FC0, 0x000FFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00060000,
	0x00E01801, 0x00060000, 0x00000000, 0x00000000, 0x40000180,
	0x00000000, 0x00000000, 0x00000000, 0x3F0301E0, 0x0001C001,
	0xE0007FFF, 0xFFFFC7FF, 0xF8FFFFFC, 0x00C00000, 0x00000000,
	0x007E1F80, 0x001FFFFF, 0xFFFFFFFF, 0xFFFFFFF8, 0x0007000F,
	0x01C03801, 0x00180000, 0x00000000, 0x00000000, 0x60000080,
	0x00000000, 0x00000000, 0x00000000, 0x7E0000E0, 0x00070000,
	0xF000FFFF, 0xFFFFC4FF, 0xFFFFFFFF, 0x80000000, 0x00000000,
	0x007C3F00, 0x001FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xC007001F,
	0x03803001, 0x00200000, 0x00000000, 0x00000000, 0x10000000,
	0x00000000, 0x00000000, 0x00000000, 0x7E0000E0, 0x001E0000,
	0x7801FFFF, 0xFFFFC07F, 0xFFFFFFFF, 0xE0080001, 0x00000000,
	0x00F83800, 0x003FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFE060011,
	0x06006001, 0x00400000, 0x00000000, 0x00000000, 0x10000000,
	0x00000000, 0x00000000, 0x00000000, 0x7E0003E0, 0x00380000,
	0x3C00FFFF, 0xFFFFFFFF, 0xFFFF90F9, 0xFC0C0000, 0x00000000,
	0x01F03000, 0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE0000,
	0x8C00C001, 0x00800000, 0x00000000, 0x00000000, 0x08000000,
	0x00000000, 0x00000000, 0x00000000, 0x7E0003F0, 0x07F00000,
	0x1E00FFFF, 0xFFFFFFF0, 0x07FC9CFC, 0xFFFE0000, 0x00000000,
	0x03E06000, 0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE0001,
	0xF000C001, 0x01800000, 0x00000000, 0x00000000, 0x08000000,
	0x00000000, 0x00000000, 0x00000000, 0x7E0003FF, 0xFF800000,
	0x0F01FFFF, 0xFFFFFFFF, 0x01CC1C7E, 0xFFFF0000, 0x00000000,
	0x07C04000, 0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0081,
	0xC0018001, 0x01000000, 0x00000000, 0x00000000, 0x04000000,
	0x00000000, 0x00000000, 0x00000000, 0x7C0001FF, 0xFC000000,
	0x0781FFFF, 0xFFFFFFFF, 0x01C47E43, 0xFFFFC000, 0x00000000,
	0x03C08000, 0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE0303,
	0x00030001, 0x02000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xFC0003FF, 0xF0000000,
	0x03C3FFFF, 0xFFFFFFFF, 0xFF903FE7, 0xFFFFE000, 0x00000000,
	0x07810000, 0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0400,
	0x00020003, 0x02000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000001, 0xFC0007FC, 0x00000000,
	0x01FFFFFF, 0xFFFFFFFF, 0xFF31FFFF, 0xFFFFF000, 0x00000000,
	0x0F000000, 0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF8000,
	0x00040002, 0x06000000, 0x00000000, 0x000003C0, 0x00000000,
	0x00000000, 0x00000000, 0x00000003, 0xFC0003C0, 0x00000000,
	0x00FFFFFF, 0xFFFFFFFF, 0xFE07FFFF, 0xFFFFF800, 0x00000000,
	0x0C000000, 0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000,
	0x00080002, 0x04000000, 0x00000000, 0x000007F0, 0x00000000,
	0x00000000, 0x00000000, 0x00000003, 0xFE0003C0, 0x00000000,
	0x00FFFFFF, 0xFFFFFFFF, 0x7F3FFFFF, 0xFFFFFC00, 0x00000000,
	0x18000000, 0x01FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF8000,
	0x00180004, 0x0C000000, 0x00000000, 0x00000FF8, 0x00000000,
	0x00000000, 0x00000000, 0x00000007, 0xFF0007C0, 0x00000000,
	0x03FFBFFF, 0xFFFFFFFB, 0x80FF3C3F, 0xFFFFFC00, 0x00000000,
	0x30200000, 0x01FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000,
	0x00300004, 0x08000000, 0x00000000, 0x00000FF8, 0x00000000,
	0x00000000, 0x00000000, 0x00000007, 0xFE100780, 0x00000000,
	0x0FE31FFF, 0xFFFFFFE3, 0xC0020000, 0x00FFFE00, 0x00000000,
	0x00E00000, 0x01FFFFFF, 0xFFFFFFFF, 0xFFFFFFFE, 0x07FFF000,
	0x00600008, 0x10000000, 0x00000000, 0x00001FF8, 0x00000000,
	0x00000000, 0x00000000, 0x00000005, 0xF8180780, 0x00000000,
	0xFF001FFF, 0xFFFFFFC1, 0xE0000000, 0x000FFE00, 0x00000000,
	0x07C00000, 0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFFC, 0x0181FC00,
	0x00400008, 0x20000000, 0x00000000, 0x00001FFC, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x78000780, 0x00000007,
	0xFC001FFF, 0xFFFFFFC0, 0xF0000080, 0x0001FE00, 0x00000000,
	0x0F000000, 0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x00009F80,
	0x00000038, 0x40000003, 0xC0000000, 0x00001FFC, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x78000780, 0x0000001F,
	0xC0001FFF, 0xFFFFFFE0, 0x7C000780, 0x0000FE00, 0x00000000,
	0x0E000000, 0x07FFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00000CF8,
	0x00000000, 0xC0000007, 0xC0000000, 0x00001FFC, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x70000780, 0x000000FE,
	0x00001FFF, 0xFFFFFFF0, 0x3FF3F800, 0x0001FFE0, 0x00000000,
	0x1C000000, 0x07FFFFFF, 0xFFFFFFFF, 0xFFFFFC00, 0x0000041E,
	0x00000000, 0x80000007, 0xE0000000, 0x00001FFC, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x78000700, 0x000003F8,
	0x00001FFF, 0xFFFFFFF0, 0x3FFFE000, 0x00070E00, 0x00000000,
	0x30000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFFFF000, 0x00000007,
	0x80000001, 0x80000007, 0xE0000000, 0x00001FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x70000700, 0x00000FC0,
	0x00001FFF, 0xFFFFFFFC, 0x3C03E000, 0x001F8000, 0x00000000,
	0x60000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000003,
	0xF8000002, 0x00000007, 0xE0000000, 0x00001FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x70000700, 0x00003F00,
	0x00001FFF, 0xFFFFFFFC, 0x00000004, 0x11FE0000, 0x00000001,
	0xC0000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0xFC000004, 0x00000007, 0xE0000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x70000300, 0x0000FC00,
	0x00001FFF, 0xFFFFFFFC, 0x0000000F, 0xFFC00000, 0x00000003,
	0x80000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFFF0000, 0x00000000,
	0x7E000008, 0x00000007, 0xE0000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x70000300, 0x0007F000,
	0x00001FFF, 0xFFFFFFF8, 0x00000000, 0x00000000, 0x00000007,
	0x00000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFF80000, 0x00000000,
	0x1F000030, 0x00000007, 0xE7000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x70000200, 0x001F8000,
	0x00001FFF, 0xFFFFFFF8, 0x00000000, 0x00000000, 0x01C0001E,
	0x00000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFE00000, 0x00000000,
	0x0FC000E0, 0x00000007, 0xF7000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xF0000200, 0x007F0000,
	0x00001FFF, 0xFFFFFFF8, 0x00000000, 0x00000000, 0x0FC00038,
	0x00000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFC00000, 0x00000000,
	0x03E00380, 0x00000007, 0xF7000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xF0000200, 0x01FC0000,
	0x00001FFF, 0xFFFFFFFC, 0x00000000, 0x00000018, 0xFE0000F0,
	0x00000000, 0x1FFFFFFF, 0xFFFFFFFF, 0xFF000000, 0x00000000,
	0x01F01E00, 0x00000007, 0xF7000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xF8000200, 0x07F00000,
	0x00001FFF, 0xFFFFFFFC, 0x00000000, 0x0000007F, 0xE00003E0,
	0x00000000, 0x1FFFFFFF, 0xFFFFFFFF, 0xFF800000, 0x00000000,
	0x0079F000, 0x00000007, 0xF7000000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xF3800600, 0x0FE00000,
	0x00003FFF, 0xFFFFFFFE, 0x00000000, 0x000001FF, 0x00000FC0,
	0x00000000, 0x3FFFFFFF, 0xFFFFFFFF, 0xFC000000, 0x00000000,
	0x003F0000, 0x00000007, 0xF7800000, 0x00003FFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xE0000600, 0x1FC00000,
	0x00003FFF, 0xFFFFFFFF, 0xC0000000, 0x000007F8, 0x00007F80,
	0x00000000, 0x3FFFFFFF, 0xFFFFFFFF, 0xF0000000, 0x00000000,
	0x001E0000, 0x00000007, 0xF3800000, 0x00003FFE, 0x1C000000,
	0x00000000, 0x00000000, 0x00000000, 0xC0000600, 0x3F000000,
	0x00001FFF, 0xFFFFFFFF, 0xFF000000, 0x00003F80, 0x0000FF00,
	0x00000000, 0x7FFFFFFF, 0xFFFFFFFF, 0xC0000000, 0x00000000,
	0x007F8000, 0x00000007, 0xF3800000, 0x00003FFE, 0x3E000000,
	0x00000000, 0x00000000, 0x00000000, 0xC0000600, 0x7E000000,
	0x00000FFF, 0xFFFFFFFF, 0xFFFE0000, 0x0007FC00, 0x0003FF00,
	0x00000000, 0x7FFFFFFF, 0xFFFFFFFF, 0x80000000, 0x00000000,
	0x0007F000, 0x0000000F, 0xF3800000, 0x00003FFE, 0x3E000000,
	0x00000000, 0x00000000, 0x00000001, 0xC0000600, 0xFC000000,
	0x00000FFF, 0xFFFFFFC0, 0xFFFFFFFF, 0xFFFFC000, 0x001FFE00,
	0x00000000, 0xFFFFFFFF, 0xFFFFFFFE, 0x00000000, 0x00000000,
	0x00038C00, 0x000000CF, 0xF3800000, 0x00003FFF, 0x3F000000,
	0x00000000, 0x00000000, 0x00000001, 0x80000E01, 0xF0000000,
	0x00000FFF, 0xFFFFFFC0, 0x00FFFFFF, 0xFFF80000, 0x007FFC00,
	0x00000000, 0xFFFFFFFF, 0xFFFFFFFC, 0x00000000, 0x00000000,
	0x0001C200, 0x000000CF, 0xF3800000, 0x00003FFF, 0x3F000000,
	0x00000000, 0x00000000, 0x00000001, 0x80000E01, 0xC0000000,
	0x00000FFF, 0xFFFFFF80, 0x0007FFE0, 0x00000000, 0x01FFF000,
	0x00000001, 0xFFFFFFFF, 0xFFFFFFF8, 0x00000000, 0x00000000,
	0x0001C300, 0x000001CF, 0xFF800000, 0x00003FFF, 0x3F000000,
	0x00000000, 0x00000000, 0x00000001, 0x80000E03, 0xC0000000,
	0x00000FFF, 0xFFFFFF80, 0x0001FFF8, 0x00000000, 0x0FFFE000,
	0x00000001, 0xFFFFFFFF, 0xFFFFFFE0, 0x00000000, 0x00000000,
	0x0000E080, 0x000001CF, 0xFF800000, 0x00003FFF, 0x7F000000,
	0x00000000, 0x00000000, 0x00000001, 0x80000E0F, 0x80000000,
	0x000007FF, 0xFFFFFFC0, 0x000003FE, 0x00000000, 0x3FFFC000,
	0x00000003, 0xFFFFFFFF, 0xFFFFFFC0, 0x00000000, 0x00000000,
	0x00006040, 0x000001CF, 0xF0000000, 0x00003FFF, 0x7F000000,
	0x00000000, 0x00000000, 0x00000003, 0x80000F3F, 0x00000000,
	0x000007FF, 0xFFFFFF80, 0x000003FF, 0x80000001, 0xFFFF8000,
	0x00000007, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000,
	0x00007020, 0x000001CF, 0xF0000000, 0x00003FFF, 0x7F000000,
	0x00000000, 0x00000000, 0x00000003, 0x80000FFF, 0x00000000,
	0x000007FF, 0xFFFFFF80, 0x000003FF, 0xE0000007, 0xFFFF8000,
	0x0000000F, 0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000,
	0x00003818, 0x000001CF, 0xF0000000, 0x00003FFF, 0x3F000000,
	0x00000000, 0x00000000, 0x00000003, 0x80000FFE, 0x00000000,
	0x000007FF, 0xFFFFFF00, 0x000001FF, 0xFF00007F, 0xFCFF01FF,
	0xC000000F, 0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000,
	0x00003808, 0x000001CF, 0xF0000000, 0x00003FFF, 0x3F000000,
	0x00000000, 0x00000000, 0x00000007, 0xC0001FFE, 0x00000000,
	0x000007FF, 0xFFFFFE0C, 0x000001FF, 0xFFF03FFF, 0xFFFE0FFF,
	0xF000001F, 0xFFFFFFFF, 0xFFFFF800, 0x00000000, 0x00000000,
	0x00003804, 0x000003CF, 0xF0000000, 0x00003FFF, 0x3F000000,
	0x00000000, 0x00000000, 0x00000007, 0x80001FFE, 0x00000000,
	0x000007FF, 0xFFFFFE0C, 0x000000FF, 0xFFFFFFFE, 0x7FFE7FFF,
	0xFF80003F, 0xFFFFFFFF, 0xFFFFE000, 0x00000000, 0x00000000,
	0x00001802, 0x000003C7, 0xF0000000, 0x00003FFF, 0x3F000000,
	0x00000000, 0x00000000, 0x00000007, 0x00001FFE, 0x00000000,
	0x00000FFF, 0xFFFFFEFF, 0xFF0000FF, 0xFFFFFF83, 0xFFFFFFFF,
	0xFFF0003F, 0xFFFFFFFF, 0xFFFFE000, 0x00000000, 0x00000000,
	0x00001C02, 0x000003C7, 0xF0000000, 0x00003FFF, 0x3F800000,
	0x00000000, 0x00000000, 0x00000007, 0x00001FFC, 0x00000000,
	0x00000FFF, 0xFFFFFFFF, 0xFFF000FF, 0xFFFFFE0F, 0xFFC3FFFF,
	0xFFFE007F, 0xFFFFFFFF, 0xFFFFC000, 0x00000000, 0x00000000,
	0x00000C01, 0x000003C7, 0xF0800000, 0x00003FFF, 0x3F800000,
	0x00000000, 0x00000000, 0x00000007, 0x00001FFC, 0x00000000,
	0x00000FFF, 0xFFFFFFFF, 0xFFFC00FF, 0xFF1FF87F, 0xFFBFFF9F,
	0xFFFF007F, 0xFFFFFFFF, 0xFFFF8000, 0x00000000, 0x00000000,
	0x00000C01, 0x000003C7, 0xF1C00000, 0x00003FFF, 0x3F800000,
	0x00000000, 0x00000000, 0x0000000F, 0x00001FFC, 0x00000000,
	0x00001FFF, 0xFFFFFFFF, 0xFFFF00FF, 0xFF09FFFF, 0xFFFFFF1F,
	0xFFFF80FF, 0xFFFFFFFF, 0xFFFF0000, 0x00000000, 0x00000000,
	0x00000601, 0x000003C7, 0xF3C00000, 0x00003FFF, 0x3F800000,
	0x00000000, 0x00000000, 0x0000000F, 0x00001FFC, 0x00000000,
	0x00001FFF, 0xFFFFFFFE, 0x3FFF81FF, 0xFFE3FFFF, 0xFFF9FE1F,
	0xFFFFC1FF, 0xFFFFFFFF, 0xFFFE0000, 0x00000000, 0x00000000,
	0x00000600, 0xC00003EF, 0xF3C00000, 0x00003FFF, 0x3F800000,
	0x00000000, 0x00000000, 0x0000000F, 0x00001CFC, 0x00000000,
	0x00001FFF, 0xFFFFFC7E, 0x33FFE0FF, 0xFFFFFFFF, 0xFFC3FC1F,
	0xFFFFE3FF, 0xFFFFFFFF, 0xFFFE0000, 0x00000000, 0x00000000,
	0x00000300, 0x600003FF, 0xF3C00000, 0x00003FFF, 0x1F800000,
	0x00000000, 0x00000000, 0x0000000F, 0x000018FC, 0x00000000,
	0x00001FFF, 0xFFFFFC3F, 0xF38FF0FD, 0xFFFFFDFF, 0xFF03FC1F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC0000, 0x00000000, 0x00000000,
	0x00000300, 0x20000007, 0xF3C00000, 0x00003FFF, 0x1F800000,
	0x00000000, 0x00000000, 0x0000000F, 0x000078FC, 0x00000000,
	0x00003FFF, 0xFFFFF81F, 0xC386FC7F, 0x39FFF1FF, 0xFC03F81F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFF80000, 0x00000000, 0x00000000,
	0x00000100, 0x20000007, 0xF3C00000, 0x00003FFF, 0x1F800000,
	0x00000000, 0x00000000, 0x0000000F, 0x000078FE, 0x00000000,
	0x01C07FFF, 0xFFFFF03F, 0xC18C3F7E, 0x20FFE0FF, 0xF807383F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFF80000, 0x00000000, 0x00000000,
	0x00000180, 0x10000007, 0xF3C00000, 0x00007FFF, 0x1F800000,
	0x00000000, 0x00000000, 0x0000000F, 0x800078FE, 0x00000008,
	0x21E07FFF, 0xFFFFF070, 0x60FC1FFE, 0x80FFE3FF, 0xE00E187F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFF00000, 0x00000000, 0x00000000,
	0x00000180, 0x10000007, 0xF3C00000, 0x00007FFF, 0x1FC00000,
	0x00000000, 0x00000000, 0x0000001F, 0xF00078FE, 0x00000006,
	0x19E07FFF, 0xFFFFE070, 0x60F10FFF, 0x007FC3FF, 0x800F187F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFF00000, 0x00000000, 0x00000000,
	0x000000C0, 0x10000007, 0xF3800000, 0x00007FFF, 0x1FC00000,
	0x00000000, 0x00000000, 0x0000001F, 0xC00070FE, 0x00000000,
	0xFFF07FFF, 0xFFFFE070, 0xE0E187FE, 0xC0FF0FFE, 0x000FF0FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x000000C0, 0x08000007, 0xFB800000, 0x00187FFF, 0x1FC00000,
	0x00000000, 0x00000000, 0x0000001F, 0x0000F0FF, 0x00000000,
	0x7FF9FFFF, 0xFFFFE01F, 0xC0E183FF, 0xC2FE1FFC, 0x001FE0FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x000000E0, 0x08000007, 0xFF800000, 0x003C7FFF, 0x1FC00000,
	0x00000000, 0x00000000, 0x0000001E, 0x000070FF, 0x00000000,
	0x3FFDFFFF, 0xFFFFC01F, 0x007F00FF, 0xC0FFFFF8, 0x003860FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000070, 0x08000007, 0xFF800000, 0x007E7FFF, 0x1FC00000,
	0x00000000, 0x00000000, 0x0000001E, 0x000070FF, 0x80000000,
	0x7FFFFFFF, 0xFFFFC03F, 0x003F807F, 0xE0FFFFE0, 0x001800FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000070, 0x08000007, 0xF0000000, 0x007E7FFF, 0x1FC00000,
	0x00000000, 0x00000000, 0x0000003E, 0x000060FF, 0x80000001,
	0xFFFFFFFF, 0xFFFFC030, 0xC038003F, 0xE0FFFF80, 0x001F01FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000070, 0x04000007, 0xF0000000, 0x007E7FFF, 0xFFC00000,
	0x00000000, 0x00000000, 0x0000003E, 0x000060FF, 0xC8000001,
	0xFFFFFFFF, 0xFFFF8030, 0x4010001F, 0xF3FFFF00, 0x000001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000038, 0x04000007, 0xF0000000, 0x00FE7FFF, 0xFFC00000,
	0x00000000, 0x00000000, 0x0000003E, 0x0000E0FF, 0xC0000001,
	0xFFFFFFFF, 0xFFFF803F, 0xC0100007, 0xFFFFFC00, 0x000001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000038, 0x02000007, 0xF0000000, 0x00FE7FFF, 0xFFC00000,
	0x00000000, 0x00000000, 0x0000003E, 0x0000E0FF, 0xC0000000,
	0x0FFFFFFF, 0xFFFF801F, 0x80078001, 0xFFFFF800, 0x003001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFC60000, 0x00000000, 0x00000000,
	0x00000018, 0x0300C007, 0xF0000000, 0x00FE7FFF, 0xFFC00000,
	0x00000000, 0x00000000, 0x0000003E, 0x0000C1FF, 0xE0000000,
	0x0FFFFFFF, 0xFFFF801B, 0xC0078000, 0xFFFFF000, 0x000807FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000, 0x00000000, 0x00000000,
	0x0000001C, 0x01C02007, 0xF0000000, 0x00FE7FFF, 0xFFC00000,
	0x00000000, 0x00000000, 0x0000007F, 0xC001C1FF, 0xC0000001,
	0xFFFFFFFF, 0xFFFF8030, 0x400C0000, 0x7FFFE000, 0x000007FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFE000, 0x00000000, 0x00000000,
	0x0000000C, 0x00401007, 0xF0000000, 0x00FE7FFF, 0xFFC00000,
	0x00000000, 0x00000000, 0x0000007C, 0xC003C1FF, 0xC0000000,
	0x01FFFFFF, 0xFFFF0030, 0xC01C0000, 0x7FFF8000, 0x018013FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFE000, 0x00000000, 0x00000000,
	0x0000000E, 0x003E1007, 0xFC000000, 0x00FE7FFF, 0xFF800000,
	0x00000000, 0x00000000, 0x0000007C, 0x001B83FF, 0xC0000000,
	0x00FFFFFF, 0xFFFF001B, 0x801C0000, 0x3FFE0000, 0x03D033FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF000, 0x00000000, 0x00000000,
	0x00000006, 0x00001C07, 0xFC000000, 0x00FE7FFF, 0x8F000000,
	0x00000000, 0x00000000, 0x000000F8, 0x000383FE, 0x40000000,
	0x00FFFFFF, 0xFFFF8003, 0x00078000, 0x7FFC0000, 0x070033FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF800, 0x00000000, 0x00000000,
	0x00000007, 0x00000403, 0xFF800000, 0x00FE7FFF, 0x00000000,
	0x00000000, 0x00000000, 0x000000F8, 0x000383F8, 0x20000000,
	0x003FFFFF, 0xFFFF0001, 0x0007C001, 0x3FF80000, 0x02003FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFEFF870, 0x00000000, 0x00000000,
	0x00000003, 0x00000401, 0xFF800000, 0x01FE7FFF, 0x00000000,
	0x00000000, 0x00000000, 0x000000F8, 0x000707F8, 0x20000000,
	0x001FFFFF, 0xFFFE0001, 0x00060403, 0xF9F00000, 0x03C03FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE7FC38, 0x00000000, 0x00000000,
	0x00000001, 0x80000401, 0xFFC00000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x000000F8, 0x00070FE0, 0x00000000,
	0x001FFFFF, 0xFFFE0001, 0x00060407, 0xF3F00000, 0x00C187FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE3FE00, 0x00000000, 0x00000000,
	0x00000000, 0x80000400, 0xFFE00000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x000000F8, 0x000F0FC0, 0x00000000,
	0x001FFFFF, 0xFFFE0001, 0xC007F807, 0xE7E00000, 0x180303FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE3F800, 0x00000000, 0x00000000,
	0x00000000, 0xC0000200, 0xFFF00000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x000001F8, 0x000FCF80, 0x00000000,
	0x001FFFFF, 0xFFFE0003, 0xF003F007, 0xC7C00000, 0x180103FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFF1F800, 0x00000000, 0x00000000,
	0x00000000, 0x60000200, 0x7FF00000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x000001F0, 0x000FFFC0, 0x00000000,
	0x001FFFFF, 0xFFFE0007, 0x18030407, 0x0F800000, 0x3F01C7FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFF0E000, 0x00000000, 0x00000000,
	0x00000000, 0x30000100, 0x7FF00000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x000001F0, 0x000FFFC0, 0x00000000,
	0x001FFFFF, 0xFFFE000E, 0x08010400, 0x0F800000, 0x6201FFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFF8F000, 0x00000000, 0x00000000,
	0x00000000, 0x18000100, 0x3FF80000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x000003F0, 0x001FFE00, 0x00000000,
	0x001FFFFF, 0xFFFE0006, 0x3800C800, 0x07000000, 0xC0001FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFCF800, 0x00000000, 0x00000000,
	0x00000000, 0x0C000080, 0x1FFC0000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x000003E0, 0x000FFE40, 0x00000000,
	0x001FFFFF, 0xFFFE0001, 0xF0001800, 0x07000000, 0xC0080FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF800, 0x00000000, 0x00000000,
	0x00000000, 0x02000080, 0x0FFC0000, 0x01FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x0003FFE0, 0x0007FC20, 0x00000000,
	0x003FFFFF, 0xFFFE0001, 0x80000C00, 0x06000000, 0xE0000FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000,
	0x00000000, 0x01000080, 0x0FFC0000, 0x03FE7FFF, 0x80000000,
	0x00000000, 0x00000000, 0x01FE03C0, 0x000FF800, 0x00000000,
	0x003FFFFF, 0xFFFC0001, 0x04000C00, 0x0E000001, 0x8001C3FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000,
	0x00000000, 0x00000040, 0x07FC0000, 0x03FE7FFF, 0x80000000,
	0x00000000, 0x000007FF, 0xFE0003C0, 0x000FF004, 0x00000000,
	0x003FFFFF, 0xFFFC0000, 0x0C003800, 0x0C000003, 0x000183FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000,
	0x00000000, 0x00200020, 0x01FC0000, 0x03FE3FFF, 0x80000000,
	0x00000000, 0x0000FC00, 0x00000380, 0x000FF000, 0x00000000,
	0x003FFFFF, 0xFFFC0000, 0x78003844, 0x1C000006, 0x000103FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000,
	0x00000000, 0x00100030, 0x00F80000, 0x03FC3FFF, 0x80000000,
	0x00000000, 0x00FF8000, 0x00000380, 0x000F8000, 0x00000000,
	0x003FFFFF, 0xFFFC0000, 0xF800304F, 0x9C0000E6, 0x000103FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000,
	0x00000000, 0x00080008, 0x00000000, 0x03FC3FFF, 0x80000000,
	0x00000000, 0x0F800000, 0x000007C0, 0x001F0000, 0x00000000,
	0x007FFFFF, 0xFFFC0000, 0x84001DCF, 0x9C0001C0, 0x000303FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF80, 0x00000000, 0x00000000,
	0x00000000, 0x00060008, 0x00000000, 0x03FC3FFF, 0x80000000,
	0x00000000, 0xF8000000, 0x000007E0, 0x001F0000, 0x00000000,
	0x003FFFFF, 0xFFFC0001, 0x00000FCF, 0x9C0003C0, 0x000383FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x00000000, 0x00000000,
	0x00000000, 0x00010008, 0x00000000, 0x03FC3FFF, 0x81000000,
	0x0000003F, 0x00000000, 0x000007F0, 0x003F0000, 0x00000000,
	0x007FFFFF, 0xFFF80000, 0x0000073F, 0x0C0018E0, 0x000FE3FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x00000000, 0x00000000,
	0x00000000, 0x00008004, 0x00000000, 0x03FC3FFF, 0x83C00000,
	0x000003E0, 0x00000000, 0x00000780, 0x00FF0000, 0x00000000,
	0x00FFFFFF, 0xFFF80000, 0x3C00041F, 0x0C001800, 0x003063FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE0, 0x00000000, 0x00000000,
	0x00000000, 0x00004003, 0x00000000, 0x03FC3FFF, 0x83C00000,
	0x00007C00, 0x00000000, 0x00000700, 0x00FE0000, 0x00000000,
	0x01FFFFFF, 0xFFF80000, 0x3E00021E, 0x0C001800, 0x003073FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFF0, 0x00000000, 0x00000000,
	0x00000000, 0x00003001, 0x00000000, 0x03FC3FFF, 0x87E00000,
	0x00078000, 0x00000000, 0x00000700, 0x00FE0000, 0x00000000,
	0x01FFFFFF, 0xFFF80000, 0x7B0000FC, 0x04010800, 0x0030E3FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFF8, 0x00000000, 0x00000000,
	0x00000000, 0x00001801, 0x00000000, 0x03FC3FFF, 0x87E00000,
	0x1FFC0000, 0x00000000, 0x00000F00, 0x00FE0000, 0x00000000,
	0x01FFFFFF, 0xFFF00000, 0x81000062, 0x04030000, 0x003FE3FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFC78, 0x00000000, 0x00000000,
	0x00000000, 0x00001C00, 0xC0000000, 0x07FC3FFF, 0x87E00000,
	0x70000000, 0x00000000, 0x00000F00, 0x00FE0000, 0x00000000,
	0x01FFFFFF, 0xFFF00000, 0x81000043, 0x0C218000, 0x002047FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFC3C, 0x00000000, 0x00000000,
	0x00000000, 0x00000C00, 0x40000000, 0x07FC3FFF, 0x8FE00000,
	0xC0000000, 0x00000000, 0x00000F80, 0x00FE4000, 0x00000000,
	0x01FFFFFF, 0xFFF00000, 0x0E000047, 0x87E00000, 0x0060C7FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE1E, 0x00000000, 0x00000000,
	0x00000000, 0x00000E00, 0x60000000, 0x07FE3FFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x00000F80, 0x01FE4000, 0x00000000,
	0x03FFFFFF, 0xFFF00000, 0x3800000F, 0x00700000, 0x007987FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF0F, 0x00000000, 0x00000000,
	0x00000000, 0x00000600, 0x20000000, 0x07FE3FFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x00000F00, 0x03FEE000, 0x00000000,
	0x07FFFFFF, 0xFFF00000, 0x1000000C, 0x00380000, 0x00FF07FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC7, 0x00000000, 0x00000000,
	0x00000000, 0x00000600, 0x18000000, 0x07FF3FFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x00001F80, 0x07FFC000, 0x00000000,
	0x07FFFFFF, 0xFFF00000, 0x00200018, 0x00100000, 0x018207FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE3, 0x80000000, 0x00000000,
	0x00000000, 0x00000600, 0x0C000000, 0x07FFFFFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x00001FF8, 0x0FFC4000, 0x00000000,
	0x0FFFFFFF, 0xFFF00000, 0x0E400010, 0x00080000, 0x010207FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFF9, 0xC0000000, 0x00000000,
	0x00000000, 0x00000700, 0x06000000, 0x07FFFFFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x00003FFE, 0x7FF84200, 0x00000000,
	0x0FFFFFFF, 0xFFF00000, 0x0C000020, 0x00080000, 0x038807FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xE0000000, 0x00000000,
	0x00000000, 0x00000700, 0x01C00000, 0x03FFFFFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x00003FFF, 0xF1F00100, 0x00000000,
	0x1FFFFFFF, 0xFFF00000, 0x04000000, 0x00080000, 0x03F807FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xF0000000, 0x00000000,
	0x00000000, 0x00000700, 0x00300000, 0x03FFFFFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x00003F98, 0x01FC2000, 0x00000000,
	0x3FFFFFFF, 0xFFF00000, 0x00080040, 0x00080000, 0x07B807FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFC000000, 0x00000000,
	0x00000000, 0x00000300, 0x000C0000, 0x01FFFFFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x0600FF00, 0x00F7F000, 0x00000000,
	0x3FFFFFFF, 0xFFF00000, 0x00700040, 0x00080000, 0x0C1007FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF800000, 0x00000000,
	0x00000000, 0x00000380, 0x00030000, 0x007C3FFF, 0x8FE00000,
	0x00000000, 0x00000000, 0x3FFFFF00, 0x00F1F800, 0x00000000,
	0x7FFFFFFF, 0xFFF00000, 0x00E00040, 0x00080000, 0x1C7007FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFC00000, 0x00000000,
	0x00000000, 0x00000380, 0x00010000, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x00000000, 0xFFFFFF00, 0x00F0FE00, 0x00000000,
	0x7FFFFFFF, 0xFFF00000, 0x01C20040, 0x00000000, 0x3FC003FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00000, 0x00000000,
	0x00000000, 0x000001C0, 0x00008000, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x00000001, 0xFE7FFF00, 0x01F0CFF2, 0x00000000,
	0xFFFFFFFF, 0xFFF00000, 0x01C20020, 0x00100000, 0xC18003FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF80000, 0x00000000,
	0x00000000, 0x000000C0, 0x00004000, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x00000003, 0xFE0FFF00, 0x01F883FF, 0x00000000,
	0xFFFFFFFF, 0xFFF80000, 0x01C00000, 0x00200000, 0xC08003FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC0000, 0x00000000,
	0x00000000, 0x00000060, 0x00006000, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x00000007, 0xFF0FFF00, 0x01FF81FF, 0x00000001,
	0xFFFFFFFF, 0xFFFC0000, 0x00FC0000, 0x00400000, 0xC00001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000, 0x00000000,
	0x00000000, 0x00000030, 0x00002000, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x0000000F, 0xFFFFFF00, 0x01FB80FF, 0x80000001,
	0xFFFFFFFF, 0xFFF40000, 0x000C0000, 0x01800001, 0xE00001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0x00000000, 0x00000018, 0x00002000, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x0000001F, 0xFFFFFF80, 0x03F083FF, 0x80000001,
	0xFFFFFFFF, 0xFFE00000, 0x000C0001, 0xFE000006, 0x1C0001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0x00000000, 0x00000018, 0x00003000, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x0000003F, 0xE00FFFC0, 0x03F007FF, 0x80000003,
	0xFFFFFFFF, 0xFFE00000, 0x001C000B, 0xF800000C, 0x080000FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFE000, 0x00000000,
	0x00000000, 0x0000000C, 0x00000800, 0x00003FFF, 0x8FE00000,
	0x00000000, 0x0000003F, 0x00007F00, 0x07FC3FFF, 0xF7000003,
	0xFFFFFFFF, 0xFFE00000, 0x001C001F, 0xF000001C, 0x180001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00000000,
	0x00000000, 0x00000006, 0x40000800, 0x00003FFF, 0x8FC00000,
	0x00000000, 0x0000007C, 0x00003FFE, 0x3FFFF83F, 0xE3800007,
	0xFFFFFFFF, 0xFFE00000, 0x0008201F, 0xF000001E, 0x300000FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000,
	0x00000000, 0x00000003, 0x60000800, 0x00003FFF, 0x8FC00000,
	0x00000000, 0x000000FC, 0x00003E00, 0x0FFFC00F, 0xE1C00007,
	0xFFFFFFFF, 0xFFE00000, 0x0004201F, 0xF000003F, 0x000000FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000,
	0x00000000, 0x00000003, 0xF0000800, 0x00003FFF, 0x8FC00000,
	0x00000000, 0x000001E8, 0x18007E00, 0x07FF0007, 0xF3F0000F,
	0xFFFFFFFF, 0xFFE00030, 0x0003C01F, 0xE0000070, 0x000000FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000,
	0x00000000, 0x00000001, 0xF0000400, 0x00003FFF, 0x8FC00000,
	0x00000000, 0x000003CF, 0x80007C00, 0x07FF0003, 0xFFF8000F,
	0xFFFFFFFF, 0xFFE00070, 0x0003000E, 0xC0000C30, 0x0000027F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00000000,
	0x00000000, 0x00000001, 0xF0000400, 0x00003FFF, 0xFFC00000,
	0x00000000, 0x00000780, 0x00007C00, 0x07E18003, 0xFFFC001F,
	0xFFFFFFFF, 0xFFC00780, 0x00030000, 0x40000830, 0x0000003F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFCC0, 0x00000000,
	0x00000000, 0x00000001, 0xF8000200, 0x00003FFF, 0xFFC00000,
	0x00000000, 0x00000F00, 0x00007C00, 0x03E00000, 0xFFFF001F,
	0xFFFFFFFF, 0xFFC07E00, 0x00001000, 0x00000C10, 0x0000001F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFCC0, 0x00000000,
	0x00000000, 0x00000000, 0xF8000200, 0x00003FFF, 0xFFC00000,
	0x00000000, 0x00001E00, 0x0000F800, 0x03C00000, 0x7FBF803F,
	0xFFFFFFFF, 0xFFE3F000, 0x00007800, 0x00001F30, 0x0000001F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF8C0, 0x00000000,
	0x00000000, 0x00000000, 0xFC000100, 0x00003FFF, 0xFFC00000,
	0x00000000, 0x00003C02, 0x0001F800, 0x07C00000, 0x7F9FE0FF,
	0xFFFFFFFF, 0xFFC7E000, 0x00006000, 0x000307E0, 0x0000001F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF8E0, 0x00000000,
	0x00000000, 0x00000000, 0xFC000100, 0x00003FFF, 0xFFC00000,
	0x00000000, 0x00007800, 0x0000F800, 0x07800000, 0x3FCFF9FF,
	0xFFFFFFFF, 0xFFCFC000, 0x00004000, 0x00070300, 0x0000000F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFDE0, 0x00000000,
	0x00000000, 0x00000000, 0x7C000180, 0x00003FFF, 0xFFC00000,
	0x00000000, 0x0000F800, 0x0000F800, 0x07808000, 0x0FFFFFFF,
	0xFFFFFFFF, 0xFFCF8000, 0x00000000, 0x000E0600, 0x0000000F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x00000000,
	0x00100000, 0x00000000, 0x3E000080, 0x00003FFF, 0xFFC00000,
	0x00000000, 0x0001F800, 0x0000FE00, 0x0F800000, 0x07FFFFFF,
	0xFFFFFFFF, 0xFFCF0000, 0x00000600, 0x60C30400, 0x00000007,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF80, 0x00000000,
	0x00C00000, 0x00000000, 0x3F000080, 0x00003FFF, 0x9F800000,
	0x00000000, 0x0001E000, 0x0000FF80, 0x1F800000, 0x03FFFFFF,
	0xFFFFFFFF, 0xFFCC0000, 0x00000300, 0x73C0C000, 0x00000007,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000,
	0x01800000, 0x00000000, 0x3F800080, 0x00003FFF, 0x82000000,
	0x00000000, 0x0003C000, 0x0001E3F8, 0x8F800000, 0x01FFFFFF,
	0xFFFFFFFF, 0xFFC80000, 0x00000100, 0xE1C08000, 0x00000007,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000,
	0x70000000, 0x00000000, 0x1FC00080, 0x00003FFF, 0x80000000,
	0x00000000, 0x00078000, 0x0001C000, 0x07800000, 0x00FFFFFF,
	0xFFFFFFFF, 0xFFE00000, 0x00000008, 0xF1E00000, 0x00000007,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00000001,
	0x80000000, 0x00000003, 0xFFE00080, 0x00003FFF, 0x80000000,
	0x00000000, 0x001F80FE, 0x0003C000, 0x07000000, 0x003FFFFF,
	0xFFFFFFFF, 0xFFC00000, 0x0000007F, 0xF9800000, 0x00000003,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x0000000F,
	0x00001800, 0x00000000, 0xFFF00080, 0x00003FFF, 0x80000000,
	0x00000000, 0x003F83FC, 0x0003C000, 0x07000000, 0x001FFFFF,
	0xFFFFFFFF, 0xFF800000, 0x0000007E, 0x00800000, 0x00000003,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x0000007C,
	0x0003E000, 0x00000000, 0x07F80080, 0x00003FFF, 0x80000000,
	0x00000000, 0x003FCFE0, 0x00038000, 0x07000000, 0x001FFFFF,
	0xFFFFFFFF, 0xFF800000, 0x00000040, 0x00000000, 0x00000001,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00002180,
	0x001FC000, 0x00000000, 0x03FF8080, 0x00003FFF, 0x80000000,
	0x00000000, 0x003FDFC0, 0x0C038000, 0x0FF00000, 0x000FFFFF,
	0xFFFFFFFF, 0xFFC00000, 0x000000C0, 0x00000000, 0x00000001,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x0000FE00,
	0x00FFC001, 0xE0000000, 0x00FFC080, 0x00003FFF, 0x80000000,
	0x00000000, 0x007FFFFE, 0x7FC78000, 0x0FFC0000, 0x000FFFFF,
	0xFFFFFFFF, 0xFF800000, 0x000000C0, 0x00000000, 0x00000001,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x0003F000,
	0x1FFF0001, 0xF8000000, 0x007FE080, 0x00003FFF, 0x80000000,
	0x00000000, 0x00FFF87F, 0xFFFF8000, 0x1FFF0000, 0x0007FFFF,
	0xFFFFFFFF, 0xFF000000, 0x000000C0, 0x00000000, 0x00000000,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x000F8001,
	0xFF600000, 0x00000000, 0x001F3080, 0x00003FFF, 0x80000000,
	0x00000000, 0x01FFE1FF, 0xFF0F8000, 0x3F3FE000, 0x000FFFFF,
	0xFFFFFFFF, 0xFF000000, 0x00000080, 0x00000000, 0x00000000,
	0x7FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF80, 0x001C007F,
	0x80000000, 0x00000000, 0x000F0080, 0x00003FFF, 0x80000000,
	0x00000000, 0x01FF83FE, 0x0007F800, 0x3F1FF800, 0x0007FFFF,
	0xFFFFFFFF, 0xFE000000, 0x00000180, 0x01000000, 0x00000000,
	0x7FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF80, 0x00E007F0,
	0x00008000, 0x00000000, 0x00038880, 0x00003FFF, 0x80000000,
	0x00000000, 0x03FF8FF0, 0x0007FC00, 0x1F1FFE00, 0x0003FFFF,
	0xFFFFFFFF, 0xFE000000, 0x000001C0, 0x00000000, 0x00000000,
	0x3FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE0, 0x0F81F01F,
	0x0001E000, 0x00000000, 0x0001C840, 0x00003FFF, 0x80000000,
	0x00000000, 0x03FFFE00, 0x0007BE00, 0x1F0DFF80, 0x0003FFFF,
	0xFFFFFFFF, 0xFC000000, 0x000001C0, 0x00000000, 0x00000000,
	0x1FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF0FFFFF,
	0x8003F800, 0x00000000, 0x0000F840, 0x00003FFF, 0x80000000,
	0x00000000, 0x07FFFC00, 0x00070000, 0x1F00FFC0, 0x0003FFFF,
	0xFFFFFFFF, 0xFC000000, 0x000001C0, 0x00000000, 0x00000000,
	0x0FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xF07F3E00,
	0x000FFF00, 0x00000000, 0x00003840, 0x00003FFF, 0x80000000,
	0x00000000, 0x07FFFFB0, 0x00070000, 0x1F00FBE0, 0x0007FFFF,
	0xFFFFFFFF, 0xFC000000, 0x000001C0, 0x04000000, 0x00000000,
	0x07FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xF1FE0000,
	0x007C0040, 0x00000000, 0x00003840, 0x00003FFF, 0x80000000,
	0x00000000, 0x07FF3FFC, 0x000F0000, 0x1F003CE0, 0x0007FFFF,
	0xFFFFFFFF, 0xF8000000, 0x000001C0, 0x04000000, 0x00000000,
	0x07FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE0000,
	0x01F00000, 0x00000000, 0x00003C20, 0x00003FFF, 0x80000000,
	0x00000000, 0x0FFFFFFF, 0x00FF0000, 0x1F001E70, 0x0007FFFF,
	0xFFFFFFFF, 0xF8000000, 0x000001C0, 0x08000000, 0x00000000,
	0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFE1C0000,
	0x0FC00000, 0x60000000, 0x00003C20, 0x00003FFF, 0x80000000,
	0x00000000, 0x0FFFF801, 0xFFBF8000, 0x3FF01F7C, 0x000FFFFF,
	0xFFFFFFFF, 0xF8000000, 0x000001C0, 0x18000000, 0x00000000,
	0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xF83C0000,
	0x1E000000, 0x1E000000, 0x00001C10, 0x00003FFF, 0xC0000000,
	0x00000000, 0x0FFF8000, 0xFFFFC000, 0x3FFF9FFF, 0x001FFFFF,
	0xFFFFFFFF, 0xF0000000, 0x000000C0, 0x18000000, 0x00000000,
	0x01FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xC03C0000,
	0x78000000, 0x01C00000, 0x00001C10, 0x00003FFF, 0xC0000000,
	0x00000000, 0x1FFC0000, 0x3FFFF800, 0x7FFFFFFF, 0x801FFFFF,
	0xFFFFFFFF, 0xF0000000, 0x000000C0, 0x30000000, 0x00000000,
	0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0x001E0001,
	0xE0000000, 0x00380000, 0x00001C08, 0x00003FFF, 0x80000000,
	0x00000000, 0x3FFC0000, 0xFFFF3FE0, 0xFFFE7FFF, 0xE01FFFFF,
	0xFFFFFFFF, 0xF0000000, 0x000000C0, 0x30000000, 0x00000000,
	0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFC, 0x001F0007,
	0x80000000, 0x000E0000, 0x00001C08, 0x00001FFF, 0x80000000,
	0x00000000, 0x3FF8000F, 0xFFFF0FFF, 0xFC001FFF, 0xF03FFFFF,
	0xFFFFFFFF, 0xE0000000, 0x00000040, 0x60000000, 0x00000000,
	0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE0, 0x001F001F,
	0x00000000, 0x0001C000, 0x00003C06, 0x00001FFF, 0x80000000,
	0x00000000, 0x3FF8003F, 0xFFFE0000, 0xFC0001FF, 0xF0FFFFFF,
	0xFFFFFFFF, 0xC0000000, 0x00000060, 0x60000000, 0x00000000,
	0x003FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x001F003C,
	0x00000000, 0x00007000, 0x00003C01, 0x00000FFF, 0x80000000,
	0x00000000, 0x7FF000FF, 0xFFFE0000, 0x7C40007F, 0xF8FFFFFF,
	0xFFFFFFFF, 0xC0000000, 0x00000060, 0xC0000000, 0x00000000,
	0x001FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x001B00F8,
	0x00000000, 0x00000C00, 0x00007800, 0x800007FF, 0x00000000,
	0x00000000, 0x7FF003FF, 0xFFFE0000, 0x7FF0007F, 0xF8FFFFFF,
	0xFFFFFFFF, 0xC0000000, 0x00000021, 0xC0000000, 0x00000000,
	0x001FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x000301E0,
	0x00000000, 0x00000100, 0x00007000, 0x60000000, 0x00000000,
	0x00000000, 0x7FF0FFFF, 0xFFFC0000, 0xFFF8001F, 0xFDFFFFFF,
	0xFFFFFFFF, 0x80000000, 0x00001071, 0xC0000000, 0x00000000,
	0x000FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00, 0x00010380,
	0x00000000, 0x00000060, 0x0000E000, 0x18000000, 0x00000000,
	0x00000000, 0x7FE3FFFF, 0xFFFF000F, 0xFFFC000F, 0xFFFFFFFF,
	0xFFFFFFFF, 0x80000000, 0x000078F1, 0x80000000, 0x00000000,
	0x0007FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFC00, 0x00010F00,
	0x00000000, 0x00000008, 0x0000C000, 0x07001FFF, 0x80000000,
	0x00000000, 0xFFC7FFFF, 0xFFFFFFFF, 0xFFFC000F, 0xFFFFFFFF,
	0xFFFFFFFF, 0x00000000, 0x0000787B, 0x80000000, 0x00000000,
	0x0003FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF800, 0x00059E00,
	0x00000000, 0x00000003, 0x0001C000, 0x00E03FFF, 0xF8000000,
	0x00000001, 0xFFFFFFFC, 0x7FFFF000, 0xE7FE0007, 0xFFFFFFFF,
	0xFFFFFFFF, 0x00000000, 0x0000789F, 0x00000000, 0x00000000,
	0x0003FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF000, 0x0005FC00,
	0x00000000, 0x00000000, 0x8001C000, 0x00180FFF, 0xC0000000,
	0x00000003, 0xFFFFF800, 0x00000000, 0x03FE0003, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000000, 0x00000C0F, 0x00000000, 0x00000000,
	0x0001FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFE000, 0x0003F000,
	0x00000000, 0x00000000, 0x7803C000, 0x000703FF, 0xC0000000,
	0x00000007, 0xFF7FE000, 0x00000000, 0x03FE0000, 0xFFFFFFFF,
	0xFFFFFFFC, 0x00000000, 0x0000000E, 0x00000000, 0x00000000,
	0x0000FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFE000, 0x0003F000,
	0x00000000, 0x00000000, 0x1E078000, 0x0000C1FF, 0xC0000000,
	0x00000007, 0xFD7F8000, 0x00000000, 0x03FF0000, 0x7FFFFFFF,
	0xFFFFFFFC, 0x00000000, 0x00000008, 0x00000000, 0x00000000,
	0x00007FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0x00000000, 0x00000000, 0x0F0F8000, 0x0000307F, 0xE0000000,
	0x00000007, 0xF9FF0000, 0x00000000, 0x01FF0000, 0x7FFFFFFF,
	0xFFFFFFF8, 0x00000000, 0x00000008, 0x00000000, 0x00000000,
	0x00003FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0x00000000, 0x00000000, 0x039F0000, 0x0000081F, 0xE0000000,
	0x00000007, 0xF9FE0000, 0x00000000, 0x03FFC07E, 0x7FFFFFFF,
	0xFFFFFFF0, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x00001FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF8000, 0x00000000,
	0xC0000000, 0x00000000, 0x01FE0008, 0x00000607, 0xE0000000,
	0x00000003, 0xFFFE0000, 0x00000000, 0x03FFFFF8, 0x3FFFFFFF,
	0xFFFFFFF0, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x00000FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF8000, 0x000003FF,
	0xDFF80000, 0x00000000, 0x01FC0004, 0x00000180, 0x70000000,
	0x00000003, 0xFFFF007F, 0x8C000000, 0x07FFFFE0, 0x3FFFFFFF,
	0xFFFFFFE0, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x00000FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000, 0x00007FC0,
	0x001F8000, 0x00000000, 0x00F80002, 0x00000040, 0x3C000000,
	0x00000001, 0xFFFB83FF, 0xFFFF8000, 0x07FFFFFC, 0x1F7FFFFF,
	0xFFFFFFC0, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x000007FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000, 0x003FDE00,
	0x00007E00, 0x00000000, 0x00780001, 0x00000040, 0x00000000,
	0x00000000, 0xFFF9FFFF, 0xFFFFFE1F, 0xFFFFFFFF, 0x3FFFFFFF,
	0xFFFFFF80, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x000003FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE0000, 0x03FE0000,
	0x00000FE0, 0x00000000, 0x00780000, 0x80000030, 0x00000001,
	0x00000000, 0xFFFCFFC3, 0xFFFFFFFF, 0xFFFFFFF0, 0xEFFFFFFF,
	0xFFFFFF00, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x000003FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC0000, 0x0FB00000,
	0x000000FC, 0x00000000, 0x00780000, 0x7000000E, 0x0000003F,
	0x00000000, 0x7FFFC007, 0xFFFFFFFF, 0xC3FFFEF8, 0x07FFFFFF,
	0xFFFFFF00, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF80000, 0x78000000,
	0x0000003F, 0x80000000, 0x00380000, 0x18000001, 0xC0001FE0,
	0x00000000, 0x3FFE0087, 0xC038FFF8, 0x00FFFE7C, 0x0FFFFFFF,
	0xFFFFFE00, 0x00000000, 0x00000038, 0x00000000, 0x00000000,
	0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF00003, 0xE0000000,
	0x00000007, 0xF0000000, 0x00300000, 0x0C000000, 0x3FFFF000,
	0x00000000, 0x3FFE003F, 0x00200000, 0x003FFE7F, 0xFFFFFFFF,
	0xFFFFFE00, 0x00000000, 0x00000038, 0x00000000, 0x00000000,
	0x000000FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF0000F, 0xC0000000,
	0x003FE380, 0x3C000000, 0x00300000, 0x03C00000, 0x00000000,
	0x00000000, 0x1FFC0000, 0x00000000, 0x000FFFFF, 0xFFFFFFFF,
	0xFFFFFE00, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x0000007F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFE0001F, 0x80000000,
	0x003FFFC0, 0x0F000000, 0x00300000, 0x00400000, 0x00000000,
	0x00000000, 0x1FF80000, 0x00000000, 0x001FFFFF, 0xFFFFFFFF,
	0xFFFFFC00, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x0000003F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFC0007F, 0x00000000,
	0x00000000, 0x03800000, 0x00300000, 0x00400000, 0x00000000,
	0x00000000, 0x0FF80000, 0x00000000, 0x001FFFFF, 0xFFFFFFFF,
	0xFFFFF000, 0x00000000, 0x00000018, 0x00000000, 0x00000000,
	0x0000001F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFC0007E, 0x00000000,
	0x00000000, 0x00E00000, 0x00700000, 0x00700000, 0x00000000,
	0x00000000, 0x1FF80000, 0x00000000, 0x000FFFFF, 0xFC3FFFFF,
	0xFFFFF000, 0x00000000, 0x00007C18, 0x00000000, 0x00000000,
	0x0000000F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF8100FC, 0x00000000,
	0x00000000, 0x00700000, 0x00700000, 0x000C0000, 0x00000000,
	0x00000000, 0x1FF80000, 0x00000000, 0x001FFFFF, 0xF03FFFFF,
	0xFFFFE000, 0x00000000, 0x00007F18, 0x00000000, 0x00000000,
	0x0000000F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF8301F8, 0x00000000,
	0x00000000, 0x00380000, 0x00700000, 0x00020000, 0x00000000,
	0x00000000, 0x0FF80000, 0x0F000000, 0x003FFFFF, 0xE03FFFFF,
	0xFFFFE000, 0x00000000, 0x00007998, 0x00000000, 0x00000000,
	0x00000007, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF8201F0, 0x00000000,
	0x00000000, 0x001C0000, 0x00700000, 0x0003C000, 0x00000000,
	0x00000000, 0x07FCE0FF, 0xFFFEC000, 0x007FFFCF, 0x807FFFFF,
	0xFFFFE080, 0x00000000, 0x00007F10, 0x00000000, 0x00000000,
	0x000001F7, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFC203F0, 0x00000000,
	0x00000000, 0x000E0000, 0x00600000, 0x00002000, 0x00000000,
	0x00000000, 0x03FEF7FF, 0xFFFFFFF0, 0x00FFFF1E, 0x003FFFFF,
	0xFFFFE080, 0x00000000, 0x00001E10, 0x00000000, 0x00000000,
	0x000007FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC03F0, 0x00000000,
	0x00000000, 0x000F0000, 0x00E00000, 0x00001000, 0x00000000,
	0x00000000, 0x01FF7FFF, 0xFC1FFF00, 0x01FFFFF8, 0x001FFFFF,
	0xFFFFF000, 0x00000000, 0x00000010, 0x00000000, 0x00000000,
	0x00003FF9, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC03E0, 0x00000000,
	0x00000000, 0x00078000, 0x00C00000, 0x00000C00, 0x00000000,
	0x00000000, 0x01FFFFFF, 0xFE1FFFE0, 0x27FFFFF0, 0x001FFFFF,
	0xFFFFF880, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00007FF1, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC07E3, 0x00000000,
	0x00000000, 0x00078000, 0x01C00000, 0x00000200, 0x00000000,
	0x00000000, 0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFE0, 0x001FFFFF,
	0xFFFFFEC0, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0001FFE0, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC07E0, 0x00000000,
	0x00000000, 0x0387C000, 0x03800000, 0x00000180, 0x00000000,
	0x00000000, 0x00FFE0CF, 0xFC01FFFF, 0xFFFFFEE0, 0x003FFFFF,
	0xFFFFFFC0, 0x00000000, 0x00000008, 0x00000000, 0x00000000,
	0x0007FFC3, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE07C0, 0x00000000,
	0x00000000, 0x1F0F0000, 0x07800000, 0x00000040, 0x00000000,
	0x00000000, 0x007FF807, 0xF0003FFF, 0xFFFFC0E0, 0x003FFFFF,
	0xFFFFFFC0, 0x00000000, 0x00000008, 0x00000000, 0x00000000,
	0x000FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFB07C0, 0x00000000,
	0x00000000, 0x040F8000, 0x0F000000, 0x0000003F, 0x00000000,
	0x00000000, 0x003FFC00, 0xE0000000, 0x3FFF80E0, 0x001FFFFF,
	0xFFFFFFE0, 0x00000000, 0x00000008, 0x00000000, 0x00000000,
	0x003FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0FC0, 0x00000000,
	0x00000000, 0x007FF000, 0x1E000000, 0x00000000, 0xE0000000,
	0x00000000, 0x001F8000, 0xE0000000, 0x37FF00E0, 0x001FFFFF,
	0xFFFFFFF0, 0x00000000, 0x00000008, 0x00000000, 0x00000000,
	0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0FC0, 0x00000000,
	0x00000000, 0x005FF800, 0x7C000000, 0x00000000, 0x3FC00000,
	0x00000000, 0x001F8001, 0xE3000000, 0x37FF0060, 0x001FFFFF,
	0xFFFFFFF8, 0x00000000, 0x0000000C, 0x00000000, 0x00000000,
	0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF1FE0, 0x00000000,
	0x00000000, 0x001FF800, 0xF8000000, 0x00000000, 0x00000000,
	0x00000000, 0x000FC003, 0xFF800000, 0x27FF0060, 0x001FFFFF,
	0xFFFFFFFC, 0x00000000, 0x0000000C, 0x00000000, 0x00000000,
	0x1FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE0, 0x00000000,
	0x00000000, 0x001FF003, 0xF0000000, 0x00000000, 0x00000000,
	0x00000000, 0x000FE03F, 0xFF000000, 0x3FFF0060, 0x003FFFFF,
	0xFFFFFFFF, 0x00000000, 0x0000000C, 0x00000000, 0x00000000,
	0xFFFFFFFF, 0xFFC1FFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x00000000,
	0x00000000, 0x001FF00F, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x0007F87F, 0xFF1C0307, 0xFFFF0070, 0x003FFFFF,
	0xFFFFFFFF, 0xC0000000, 0x0000000C, 0x00000000, 0x00000007,
	0xFFFFFFFF, 0xFC001FFF, 0xFFFFFFFF, 0xFFFFFF80, 0x00000000,
	0x00000000, 0x003FE01F, 0xC0000000, 0x00000000, 0x00000000,
	0x00000000, 0x0003FFFF, 0xFFFFFFFF, 0xFFFF0070, 0x003FFFFF,
	0xFFFFFFFF, 0xE0000000, 0x0000000C, 0x00000000, 0x0000007F,
	0xFFFFFFFF, 0xC00007FF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000,
	0x00000000, 0x007F807E, 0x80000000, 0x00000000, 0x00000000,
	0x00000000, 0x0000FFFF, 0xFFFFFF00, 0x03CF0070, 0x003FFFFF,
	0xFFFFFFFF, 0xFC000000, 0x0000000C, 0x00000000, 0x000003FF,
	0xFFFFFFFE, 0x000000FF, 0xFFFFFFFF, 0xFFFFFE00, 0x00000000,
	0x00000000, 0x007E01F8, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00003FFF, 0xFFFC0000, 0x00FF0070, 0x0027FFFF,
	0xFFFFFFFF, 0xFF800000, 0x00000004, 0x00000000, 0x00000FFF,
	0xFFFFFFF0, 0x00C0003F, 0xFFFFFFFF, 0xFFFFF800, 0x00000000,
	0x00000000, 0x00780FE0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000FFF, 0xE1E00000, 0x01FFC070, 0x0027FFFF,
	0xFFFFFFFF, 0xFFC00000, 0x00000006, 0x00000000, 0x00001FFF,
	0xFFFFFC20, 0x01E0000F, 0xFFFFFFFF, 0xFFFFF000, 0x00000000,
	0x00000000, 0x01F07E00, 0x00000000, 0x000001FF, 0xFF800000,
	0x00000000, 0x000003FF, 0xF0000000, 0x013FC070, 0x0007FFFF,
	0xFFFFFFFF, 0xDFE00000, 0x00000006, 0x00000000, 0x00003FFF,
	0xFFFFF810, 0x01F00007, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0x00000000, 0x63FFF800, 0x00000000, 0x00000100, 0x00000000,
	0x00000000, 0x000000FF, 0xB0000000, 0x01FFC060, 0x0003FFFF,
	0xFFFFFFFF, 0x87F00000, 0x00000002, 0x00000000, 0x00001FFF,
	0xFFF80C18, 0xE1F80001, 0xFFFFFFFF, 0xFFFF8000, 0x00000000,
	0x00000000, 0xCFFFE000, 0x0003FF80, 0x00000F00, 0x00000000,
	0x00000000, 0x0000003F, 0x00000000, 0x0FFF8060, 0x0003FFFF,
	0xFFFFFFFF, 0x07FE0000, 0x000007C3, 0x00000000, 0x00003FFF,
	0xFF80060C, 0xF1C00000, 0xFFFFFFFF, 0xFFFE0000, 0x00000000,
	0x00000001, 0xFFFF8000, 0x00060070, 0x00001800, 0x00000000,
	0x00000000, 0x0000001F, 0x8003E000, 0x7FFF0070, 0x0003FFFF,
	0xFFE7FFFF, 0x07FF8000, 0x00000FFB, 0x80000000, 0x00003FFF,
	0xF0000206, 0x7FC00000, 0x7FFFFFFF, 0xFFF80000, 0x00000000,
	0x0000000F, 0xFFFC0600, 0x0008000E, 0x00003000, 0x00000000,
	0x00000000, 0x0000000F, 0xC07FFFFF, 0xFFFC0070, 0x0003DFFF,
	0xFFC7FFFE, 0x0FFFF000, 0x00000FFF, 0x80000000, 0x00003FF0,
	0x00004107, 0xFFEC0000, 0x3FFFFFFF, 0xFFE00000, 0x00000000,
	0x0000003F, 0xFFC00C00, 0x00180001, 0x0001E000, 0x00000000,
	0x00000000, 0x00000007, 0xFBFFFFFF, 0xFFFC0070, 0x00038FFF,
	0xFFC3FFFE, 0x0FFFFF00, 0x000007FF, 0x80000000, 0x00001F00,
	0x007861C7, 0xF0004000, 0x1FFFFFFF, 0xFF800000, 0x00000000,
	0x0000007F, 0xE0003800, 0x00300001, 0xFFFF0000, 0x00000000,
	0x00000000, 0x00000003, 0xFFFFFFFF, 0xFFF00070, 0x00038FFF,
	0xFF81FFFC, 0x0FFFFFF0, 0x000001FD, 0xC0000000, 0x00001C00,
	0x03FE3DE6, 0x00001E00, 0x03FFFFFF, 0xFF000000, 0x00000000,
	0x000001FC, 0x00007000, 0x00200000, 0x00000000, 0x00000000,
	0x00000000, 0x00000001, 0xFFFFFFFF, 0xFF000070, 0x0001C7FF,
	0xFF80FFFC, 0x1FFFFFFF, 0x00000060, 0xC0000000, 0x00001C00,
	0x03F3FCE0, 0x00007FC0, 0x01FFFFFF, 0xF8000000, 0x00000000,
	0x000007F0, 0x0001C000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0xFFFFF003, 0xFC000060, 0x000187FF,
	0xFF803FFC, 0x1FFFFFFF, 0xFFC00000, 0x40000000, 0x0007FC00,
	0x03FBFF80, 0x0000FFF0, 0x00F0FFFF, 0xF0180000, 0x00000000,
	0x00001F80, 0x00078000, 0x00000000, 0x00000000, 0x0000003F,
	0x00000000, 0x00000000, 0x06FFC001, 0xFC000060, 0x008183FF,
	0xFF8007FC, 0x1FFFFFFF, 0xFFFE0000, 0x20000000, 0x007FFC00,
	0x019CCC00, 0x0007FFF8, 0x00F00FFF, 0xF8600000, 0x00000000,
	0x00007800, 0x000F0000, 0x00000000, 0x00000000, 0x000007C0,
	0x00000000, 0x00000000, 0x007F8001, 0xFC000020, 0x008183FF,
	0xFF0000FC, 0x1FFFFFFF, 0xFFFFC000, 0x10000000, 0x0FFFF800,
	0x00FC4000, 0x6007FFFE, 0x00F0007E, 0xFC000000, 0x00000000,
	0x0000E000, 0x003C0000, 0x00000000, 0x00000000, 0x0007F800,
	0x00000000, 0x00000000, 0x007FC001, 0xFC000020, 0x000183FF,
	0xFF00001E, 0x3FFFFFFF, 0xFFFFFC00, 0x3FFFFFFF, 0xFFFFF800,
	0x00F80003, 0xF007FE0F, 0x01F00000, 0x0F000000, 0x00000000,
	0x00030000, 0x00F80000, 0x00000000, 0x00000000, 0x00080000,
	0x00000000, 0x00000000, 0x007FF801, 0xFC000020, 0x0001C7FF,
	0xFF00000C, 0x3FFFFFFF, 0xFFF3FFFF, 0xFFFFFFFF, 0xFFFFF000,
	0x01E00001, 0xF003F807, 0x87E00000, 0x00000000, 0x00000000,
	0x000C0000, 0x01E00000, 0x00000000, 0x00000000, 0x03F80000,
	0x00000000, 0x00000000, 0x007FC001, 0xFC000030, 0x0000C7FF,
	0xFF00001C, 0x3FFFFFFF, 0xFFC7F800, 0x0000000F, 0xFFFFF000,
	0x02000000, 0x7803E003, 0xFFC00000, 0x00000000, 0x00000000,
	0x00300000, 0x07800000, 0x00000000, 0x00000000, 0x04000000,
	0x00000000, 0x00000000, 0x00FFC003, 0xFC000030, 0x00C0C7FF,
	0xFF00001E, 0x3FFFFFFF, 0xFFCFFFFF, 0xCC0FF007, 0xFFFFF000,
	0x04000000, 0x3C7DE000, 0x7FC00000, 0x00000000, 0x00000000,
	0x00800000, 0x0F000000, 0x00000000, 0x00000000, 0x78000000,
	0x00000000, 0x00000000, 0x00FFC003, 0xFC000030, 0x00C0C7FF,
	0xFF00001E, 0x7FFFFFFF, 0xFFDFFFFF, 0xFFFFFFC7, 0xFFFFF800,
	0x04001800, 0x1FF86000, 0x7F000000, 0x00000000, 0x00000000,
	0x03000000, 0x3C100000, 0x00000000, 0x0000003F, 0x80000000,
	0x00000000, 0x00000000, 0x00EF8003, 0xDC000030, 0x00C7C7FF,
	0xFF00001C, 0x7FFFFFFF, 0xFFDFFFFF, 0xFFFFFFF3, 0xFFFFF800,
	0x08003800, 0x3FC03800, 0xE0000000, 0x00006000, 0x00000000,
	0x0C000000, 0x78100000, 0x00000000, 0x0001FFC0, 0x00000000,
	0x00000000, 0x00000000, 0x00EF8003, 0xCC000030, 0x00C7EFF0,
	0xFE00000C, 0x7FFFFFFF, 0xFF9FFFFF, 0xFFFFFFF3, 0xFFFFFC00,
	0x18001801, 0xFF800FC7, 0x00000000, 0x00000000, 0x00000001,
	0x78000000, 0xF0000000, 0x000003FF, 0xFFFE0000, 0x00000000,
	0x00000000, 0x00000000, 0x00FFC003, 0xCC000030, 0x00C7FFFF,
	0xFE000004, 0x18FFFFFF, 0xFF9FFFFF, 0xFFFFFFF3, 0xFFFFFE00,
	0x18000003, 0xC78007FC, 0x00000000, 0x00000000, 0x0000000F,
	0xF0000003, 0xC0000000, 0x00001E00, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00FFC003, 0xCC000030, 0x00E7FFFF,
	0xFC000004, 0x007FFFFF, 0xFF9FFFFF, 0xFFFFFFF3, 0xFFFFFE00,
	0x3F8000E1, 0x03C007C0, 0x00000000, 0x00000000, 0x0000001F,
	0xC0000007, 0x80200000, 0x0000E000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01FFC003, 0xCC000030, 0x00C7FFFF,
	0xFC000002, 0x600FFFFF, 0xFFFC1FFF, 0xFFFFFFF3, 0xFFFFFF00,
	0x3FC001F0, 0x00E07E00, 0x00000000, 0x00000000, 0x0000003F,
	0x0000000E, 0x00000000, 0x00010000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01FFC003, 0x8C000020, 0x00C7FFFF,
	0xFE000001, 0xE001FFFF, 0xFFFF83FF, 0xFFFFFFE3, 0xFFFFFF00,
	0x33E001F8, 0x007FFC00, 0x00000000, 0x00000000, 0x0000007E,
	0x0000001C, 0x00000000, 0x000E0000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01FFC003, 0x84000020, 0x01FF0FFE,
	0x00000000, 0x00007FFF, 0xFFDFFFFF, 0xFFFFFFE3, 0xFFFFFF80,
	0x20F000FC, 0x007FFC00, 0x00000000, 0x00000000, 0x000000FC,
	0x00000078, 0x00000000, 0x00100000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01FFE007, 0x84000020, 0x0FFE1C00,
	0x00000000, 0x000007FF, 0xFF9FFFFF, 0xFFFFFFE3, 0xFFFFFFC0,
	0x6078003E, 0x007F8000, 0x00000000, 0x00000000, 0x000001F0,
	0x000000B8, 0x00000000, 0x00600000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01FFFC27, 0x04000060, 0x1FE00000,
	0x00000000, 0x000000FF, 0xFF9FFFFF, 0xFFFFFFE3, 0xFFFFFFE0,
	0x303C001F, 0x01FC0000, 0x00000000, 0x00000000, 0x000003E0,
	0x00000318, 0x00000000, 0x00800000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01FFC007, 0x04000040, 0x1FC00000,
	0x00000000, 0x0000001F, 0xFF9FFFFF, 0xFFFFFFC3, 0xFFFFFFF0,
	0x300E0007, 0x8FE00000, 0x00000000, 0x00000000, 0x00000F80,
	0x00000610, 0x00000000, 0x03000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01C7C007, 0x04000040, 0x7F800000,
	0x00000000, 0x00000001, 0xFF8FFFFF, 0xFFFFFF87, 0xFFFFFFF8,
	0x38070003, 0xFE000000, 0x00000000, 0x00000000, 0x00001F00,
	0x00001C10, 0x00000000, 0x0C000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01C1C007, 0x000000C3, 0xF8000000,
	0x00000000, 0x00000000, 0x0FCFFFFF, 0xFFFFFF87, 0xFFFFFFFC,
	0x1803C001, 0xE0000000, 0x00000000, 0x00000000, 0x00007C00,
	0x00003010, 0x00000000, 0x30000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01C18007, 0x000000CF, 0xE0000000,
	0x00000000, 0x00000000, 0x07FFFFFF, 0xFFFFFF9F, 0xFFFFFFFF,
	0x0C01E003, 0x00000000, 0x10000000, 0x00000000, 0x0001F000,
	0x00006000, 0x00000000, 0x40000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x01C18006, 0x000000FF, 0x80000000,
	0x00000000, 0x00000000, 0x07FE003F, 0xFFFFFF7F, 0xFFFFFE0F,
	0xFE00F820, 0x00000000, 0x00000000, 0x00000000, 0x000FC000,
	0x00018000, 0x00000001, 0x80000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x03C18006, 0x000001FE, 0x00000000,
	0x00000000, 0x00000000, 0x03FFF87F, 0xF8000EFF, 0xFFFE000F,
	0xFF00F000, 0x00000000, 0x00000000, 0x00000000, 0x01FF0000,
	0x00000000, 0x00000006, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x03FD800E, 0x000003F0, 0x00000000,
	0x00000000, 0x00000000, 0x01FFFFFF, 0xFC0FFFFB, 0x8000000F,
	0xFF800000, 0x00000000, 0x00000000, 0x00000000, 0x3FFC0000,
	0x00080000, 0x00000008, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x03FFC07E, 0x00001FC0, 0x00000000,
	0x00000000, 0x00000000, 0x000F81FF, 0x8FFFFFE0, 0x0000000F,
	0x80000000, 0x00000000, 0x00000000, 0x00000000, 0xFFF00000,
	0x00000010, 0x00000038, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x03FFF1FE, 0x00007F00, 0x00000000,
	0x00000000, 0x00000000, 0x000001F0, 0x003C0000, 0x0000000F,
	0x00000000, 0x00000000, 0x00000000, 0x00000061, 0xFF800000,
	0x00000030, 0x000000E0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x03FFFFFE, 0x0003FE00, 0x00000000,
	0x00000000, 0x00000000, 0x000001E0, 0x00380000, 0x00000007,
	0x80000000, 0x00000000, 0x00000000, 0x00000063, 0xF0000000,
	0x00000010, 0x00000100, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x03FFFFFE, 0x0207F800, 0x00000000,
	0x00000000, 0x00000000, 0x000001C0, 0x00300000, 0x00000007,
	0x00000000, 0x00000000, 0x00000000, 0x00000407, 0xC0000000,
	0x00000030, 0x01000200, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x039FFE0E, 0x021FE000, 0x00000000,
	0x00000000, 0x00000000, 0x000003C0, 0x00200000, 0x00000003,
	0x01000000, 0x6001F000, 0x00000000, 0x00000C1F, 0x00000C00,
	0x00000030, 0x01000200, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0381C00E, 0x03FFC000, 0x00000000,
	0x00000000, 0x00000000, 0x00000380, 0x00000000, 0x00000003,
	0x01800000, 0x00FFF000, 0x00000000, 0x0000001C, 0x00007000,
	0x00000030, 0x01000200, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0380C00C, 0x03FF0000, 0x00000000,
	0x00000000, 0x00000000, 0x00000300, 0x00000000, 0x00000001,
	0x80800000, 0x07FC0000, 0x00000000, 0x00007870, 0x0007C000,
	0x00000020, 0x01000200, 0x00000000, 0x00000000, 0x0000000C,
	0x00000000, 0x00000000, 0x0780800E, 0x07FC0000, 0x00000000,
	0x00000000, 0x00000000, 0x00000600, 0x00000000, 0x00000000,
	0xC5800000, 0x1FE00000, 0x00000000, 0x0000F8E0, 0x007E0003,
	0x80000020, 0x00000000, 0x00000000, 0x00000000, 0x00000078,
	0x00000000, 0x00000000, 0x0780800C, 0x07F80000, 0x00000000,
	0x00000000, 0x00080000, 0x00000600, 0x00000000, 0x00000000,
	0x7FF80001, 0xFFC00000, 0x01800000, 0x4001F380, 0x07F0003E,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000001F0,
	0x00000000, 0x00000000, 0x0780800C, 0x07F00000, 0x00000000,
	0x00000000, 0x00040000, 0x00000C00, 0x00000000, 0x00000000,
	0x3FF8031F, 0xFFC00000, 0x07000000, 0x801FE780, 0x7FC000F8,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000000F0,
	0x00000000, 0x00000000, 0x0790800E, 0x07C00000, 0x00000000,
	0x00000000, 0x00000000, 0x00000C00, 0x00000000, 0x00000000,
	0x1FFFFFFC, 0x00400000, 0x3800000C, 0x003FFF87, 0xE1800700,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000060,
	0x00000000, 0x00000000, 0x0FF0801E, 0x0F800000, 0x00000000,
	0x00000000, 0x00000000, 0x00000800, 0x00000000, 0x00000000,
	0x0FFF0000, 0x00000000, 0x40000008, 0x00EFFFFF, 0xC0007E00,
	0x000F0017, 0xF01F9FFF, 0xFF8FE000, 0x001FC003, 0xF8060060,
	0x00000000, 0x00000000, 0x0FFFC03F, 0x3E000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001800, 0x00000000, 0x00000000,
	0x07000000, 0x00080000, 0x00000040, 0x01CFFFF8, 0x0007E400,
	0x007FC013, 0xE00F1FFF, 0xFF07C000, 0x000F8001, 0xF0060060,
	0x00000000, 0x00000000, 0x0783C03F, 0xFC000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001800, 0x00000000, 0x00000000,
	0x0E000000, 0x001E0000, 0x00000000, 0x01FFFC00, 0x007E0000,
	0x01E07001, 0xC0060E0E, 0x07038000, 0x000F8000, 0xF0070040,
	0x00000000, 0x00000000, 0x03C1807F, 0xF0000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001800, 0x00000000, 0x00000000,
	0x1E000000, 0x000EC00C, 0x00007000, 0x03FFB000, 0x07C00000,
	0x03C73801, 0xC0040C6E, 0x32038000, 0x000F8000, 0xF00700C0,
	0x00000000, 0x00000000, 0x01E0003F, 0xE0000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001000, 0x00000000, 0x00000000,
	0x3E000000, 0x0001E1F8, 0x0000E000, 0x03FF0003, 0xFE000000,
	0x03901C01, 0xC004080E, 0x02038000, 0x001B8000, 0x700F0080,
	0x00000000, 0x00000000, 0x0180003F, 0xC0000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001000, 0x00000000, 0x00000000,
	0x18000000, 0x0000FFF0, 0x00018001, 0x0FFF807F, 0xE0000000,
	0x07201C01, 0xC004000E, 0x00038000, 0x0013C000, 0x700F0080,
	0x00000000, 0x00000000, 0x0000007F, 0x80000000, 0x00000000,
	0x00000000, 0x00000100, 0x00001000, 0x00000000, 0x00000000,
	0x18600000, 0x0001FFE0, 0x00030002, 0x1FFFFFC7, 0xE0000800,
	0x0F001E01, 0xC004000E, 0x00038000, 0x0013C000, 0x780F8080,
	0x00000000, 0x00000000, 0x0000001F, 0x00000000, 0x00000000,
	0x00000000, 0x00000080, 0x00001000, 0x00000000, 0x00000000,
	0x1C700000, 0x003FFBC0, 0x000C0000, 0x3FDE0003, 0xE0000C00,
	0x0F000E01, 0xC004000E, 0x00038000, 0x0031E000, 0x781F8180,
	0x00000000, 0x00000000, 0x0000003F, 0x00000000, 0x00000000,
	0x00000000, 0x00000060, 0x00000000, 0x00000000, 0x00000000,
	0x0FF80001, 0xFFFFE000, 0x00380001, 0xFC0E0203, 0xE0001C00,
	0x0E000E01, 0xC004000E, 0x00038000, 0x0021E000, 0x38138100,
	0x00000000, 0x00000000, 0x0000007E, 0x00000000, 0x00000000,
	0x00000000, 0x00600060, 0x00000000, 0x00000000, 0x00000000,
	0x03F8001F, 0xFF01C000, 0x00700007, 0xF00E0303, 0xE0001800,
	0x0E000F01, 0xC004000E, 0x00038000, 0x0060E200, 0x38138100,
	0x00000000, 0x00000000, 0x0000007E, 0x00000000, 0x00000000,
	0x00000000, 0x00780078, 0x00000000, 0x00000000, 0x00000000,
	0x00FFE0FF, 0xC0000000, 0x00E0001F, 0xC00E0701, 0xE0000800,
	0x1E000F01, 0xC004000E, 0x00038000, 0x0340F600, 0x3C13C100,
	0x00000000, 0x00000000, 0x000000E0, 0x00000000, 0x00000000,
	0x00000000, 0x0000003C, 0x00000000, 0x00000000, 0x00000000,
	0x001FFFC0, 0x00000000, 0x01C0007F, 0x00070701, 0xE0000800,
	0x1E000F01, 0xC004000E, 0x00038000, 0x07C0FF00, 0x1C31C200,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x0000000E, 0x00000000, 0x00000000, 0x00000000,
	0x0007FC00, 0x00000000, 0x038007FC, 0x00070701, 0xE0000800,
	0x1E000F01, 0xC004000E, 0x00038000, 0x01C07F00, 0x1C21C200,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x0000000F, 0x80020000, 0x00000000, 0x00000000,
	0x0000FC00, 0x00000400, 0x3F000FF0, 0x00070703, 0xE0000800,
	0x1E000F01, 0xC004000E, 0x00038000, 0x00E07800, 0x1C21E200,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000007, 0x80030000, 0x04000000, 0x00000000,
	0x00007C00, 0x00000300, 0xFE001FE0, 0x00070201, 0xE0000000,
	0x3E000F01, 0xC004000E, 0x00038000, 0x00B0F980, 0x1E21E200,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000003, 0xC0010000, 0x04000000, 0x00000000,
	0x00007C00, 0x0000C61F, 0xFC0E1F80, 0x00038200, 0xE0000000,
	0x7E000F01, 0xC004000E, 0x00038000, 0x01B9FC00, 0x0E40E400,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000001, 0xFE000003, 0xE001C000, 0x0C000000, 0x00000000,
	0x00007F00, 0x0000CFFF, 0xE0707C00, 0x00038200, 0xE0000001,
	0xCE000F01, 0xC004000E, 0x00038000, 0x010B3C00, 0x0E40E400,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x3FF00003, 0xF001C000, 0x18000000, 0x00000000,
	0x00007FC0, 0x0001FFFF, 0xC181F000, 0x00038200, 0xE000100E,
	0x0E000E01, 0xC004000E, 0x00038000, 0x010E1C00, 0x0F40F400,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00FE0003, 0xF000C000, 0x18000000, 0x00000000,
	0x00003FF0, 0x000FFFFF, 0x060F8000, 0x0003C000, 0xE0001018,
	0x0E000E01, 0xC004000E, 0x00038000, 0x03061E00, 0x0FC07C00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x000FC001, 0xF800C000, 0x18000000, 0x00003000,
	0x00000FF0, 0x03FFFFFF, 0x1DFE0000, 0x0003C000, 0x60000060,
	0x0F001E01, 0xC004000E, 0x00038010, 0x02001E00, 0x07807800,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00007C0D, 0xFE01C000, 0x10000000, 0x0000C000,
	0x000003F0, 0x7FFFFC0F, 0xFFF00000, 0x0001C000, 0x600001C0,
	0x07001C01, 0xC004000E, 0x00038010, 0x06000E00, 0x07807800,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x000007EF, 0xFF03C000, 0x10000000, 0x003F0000,
	0x0000007F, 0xFFFF000F, 0xFE000000, 0x0001C000, 0x60000300,
	0x03803D01, 0xC00C000E, 0x00038038, 0x0E000F00, 0x07807800,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x000000FF, 0xFF81E000, 0x30000000, 0x00FC001F,
	0x00000007, 0xEF80000F, 0xF8000000, 0x0001C000, 0x20001400,
	0x03803800, 0xE00C000E, 0x00038038, 0x0F000F00, 0x03803800,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x0000001F, 0xFFC9E000, 0x30000000, 0x07F00000,
	0x00000001, 0xC700001F, 0xC0000000, 0x0001E000, 0x20001800,
	0x00E0F000, 0xF018001F, 0x000780FC, 0x1F000F80, 0x07C07C00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000007, 0xFFFDE000, 0x30000000, 0x1FC00000,
	0x00000000, 0xFF807FFC, 0x00000000, 0x0000E000, 0x20003000,
	0x007FE800, 0x3FF0003F, 0x800FFFFC, 0xFF801FC0, 0x0FE0FE00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000003, 0xFFFDE000, 0x38000000, 0x7E000000,
	0x00000000, 0x1FFFF000, 0x00000000, 0x0000E000, 0x2000E000,
	0x003FF000, 0x1FE80000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000001, 0xFBFDF000, 0x38000001, 0xC8000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000F000, 0x30012000,
	0x000F8000, 0x07C0003F, 0xF00FFFFF, 0x7FE01FFC, 0x0FF8FFC0};
