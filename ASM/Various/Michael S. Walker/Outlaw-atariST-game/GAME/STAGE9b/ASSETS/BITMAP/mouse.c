const uint8_t mouse_ptr[] = {
	0xaa,
	0x55,
	0xaa,
	0x55,
	0xaa,
	0x55,
	0xaa,
	0x55,
};
