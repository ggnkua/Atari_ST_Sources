const uint32_t menu[] = {
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFFFFFFF, 0xFFFFF800,
	0x07FFFFC3, 0xFFFFFFFF, 0xFFFFF000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFF00,
	0x1FFFFFFF, 0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFC0,
	0x7FFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x07FFFFFF, 0xFFFFFFFF, 0xFFFFFFF1,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF80, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFC0, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x1FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE0, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x3FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFF0, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x7FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFF8, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x000001FF, 0xFFF80000, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFC, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x000007FF, 0xFFFF0001, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFE, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00003FFF, 0xFFFFC003, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0000FFFF, 0xFFFFF007, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0x80000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0003FFFF, 0xFFFFFC07, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xC1800000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0007FFFF, 0xFFFFFE0F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF00000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x001FFFFF, 0xFFFFFFBF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF80000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x003FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC0000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE0000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF8000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x01FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF8000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x07FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFE000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x1FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x7FFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF800, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000003,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFC00, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000007,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF00, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000000F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE0, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000003F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFC, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000007F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xE0000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000000FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFC000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000003FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000007FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFC00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFE00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFF00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00003FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFF80,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00003FFF,
	0xFFFFFE7E, 0x3F1F7FFF, 0xFF00060E, 0x0E0C0018, 0x3FE000FF,
	0xE00083FF, 0xC0E0E0C0, 0x018003FF, 0xFFFFFFFF, 0xFFFFFFC0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00007FFF,
	0xFFFF7E3E, 0x3F1F7FFF, 0xFF000606, 0x040C0018, 0x1FE000FF,
	0xE00081FF, 0xC06040C0, 0x018003FF, 0xFF7FFFFF, 0xFFFFFFC0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000FFFF,
	0xFFFF7EBE, 0x3F1F7FFF, 0xFF000606, 0x040C0018, 0x1FE000FF,
	0xE00081FF, 0xC06040C0, 0x018003FF, 0xFF7FFFFF, 0xFFFFFFE0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000FFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF000606, 0x040C0018, 0x1FE000FF,
	0xE00081FF, 0xC06040C0, 0x018003FF, 0xFFFFFFFF, 0xFFFFFFF0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0003FFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF870F0F, 0x061E1C3C, 0x3FF0E1FF,
	0xF0E1C3FF, 0xC0F041E1, 0xC3C387FF, 0xFFFFFFFF, 0xFFFFFFF0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0007FFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF870F0F, 0x061E1C3C, 0x3FF0E1FF,
	0xF0E1C3FF, 0xC0F843E1, 0xC3C387FF, 0xFFFFFFFF, 0xFFFFFFF8,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000FFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF870F0F, 0x021E1C3C, 0x3FF0E1FF,
	0xF0E1C3FF, 0xC07843E1, 0xC3C207FF, 0xFFFFFFFF, 0xFFFFFFFC,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x003FFFFF,
	0xFFFFFCBE, 0x3F1F7FFF, 0xFF87FF0F, 0x021E1FFC, 0x3FF0FFFF,
	0xF081C3FF, 0xC07843E1, 0xFFC007FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00FFFFFF,
	0xFFFF7C3E, 0x3F1F3FFF, 0xFF87FF0F, 0x001E1FFC, 0x3FF0FFFF,
	0xF001C3FF, 0x807C07E1, 0xFFC007FF, 0xFF7FFFFF, 0xFFFFFFFF,
	0xFFC00000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000001F, 0xFFFFFFFF,
	0xFFFF7D3E, 0x3F1F3FFF, 0xFF80FF0F, 0x001E1FFC, 0x3FF003FF,
	0xF001C3FF, 0x807C07E0, 0x07C007FF, 0xFF7FFFFF, 0xFFFFFFFF,
	0xFFFFF003, 0xF0000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000007F, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF800F0F, 0x001E181C, 0x3FF003FF,
	0xF007C3FF, 0x807C07E0, 0x07C03FFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFE000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000001FF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF800F0F, 0x001E181C, 0x3FF003FF,
	0xF01FC3FF, 0x803C07E0, 0x07C07FFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFF800000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000007FF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF800F0F, 0x001E181C, 0x3FF003FF,
	0xF07FC3FF, 0x843E0FE0, 0x07C01FFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFC00000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000FFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00F0F, 0x001E1C1C, 0x3FF0FFFF,
	0xF0FFC3FF, 0x843E0FE1, 0xFFC007FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFE00000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00001FFF, 0xFFFFFFFF,
	0xFEFEFF7E, 0x7F1F7FFF, 0xFFFE0F0F, 0x081E1C3C, 0x3FF0FFFF,
	0xF0FFC3FF, 0x803E0FE1, 0xFFC007FF, 0xFF7FFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFF80000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00003FFF, 0xFFFFFFFF,
	0xF8FC7C3E, 0x3E1F3FFF, 0xFFFF0F0F, 0x081E1C3C, 0x3FF0FFFF,
	0xF0FFC3FF, 0x003E0FE1, 0xFFC387FF, 0xFF3FFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFC0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00007FFF, 0xFFFFFFFF,
	0xF8FC7C3E, 0x3E1F3FFF, 0xFFFF0F0F, 0x0C1E1C3C, 0x3FF0EDFF,
	0xF0FFC3FF, 0x001E0FE1, 0xDBC387FF, 0xFF3FFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFE0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000FFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF870F0F, 0x0C1E1C3C, 0x3870E1FF,
	0xF0FFC387, 0x001E0FE1, 0xC3C387FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFF0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0001FFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF870F0F, 0x0C1E1C3C, 0x3870E1FF,
	0xF0FFC387, 0x0E1E0FE1, 0xC3C387FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFF0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0003FFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF870E06, 0x040E1C3C, 0x3870E1FF,
	0xE07FC386, 0x040C07E1, 0xC38103FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFF8000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0007FFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF000606, 0x040C0018, 0x002000FF,
	0xE07F8002, 0x040C07C0, 0x018103FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFC000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000FFFFF, 0xFFFFFFFF,
	0xFFFFFEFE, 0x3F1F7FFF, 0xFF000606, 0x040C0018, 0x002000FF,
	0xE07F8002, 0x040E0FC0, 0x018103FF, 0xFF7EFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFE000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x001FFFFF, 0xFFFFFFF0,
	0xF8FC7C3E, 0x3E1F3FFF, 0xFF00060E, 0x0E0C0018, 0x002000FF,
	0xE0FF8002, 0x0E0E0FC0, 0x018383FF, 0xFF7E3E1F, 0x1FCFDFFF,
	0xFFFFFFFF, 0xFFFFF000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x003FFFFF, 0xFFFFFFF0,
	0xF8FC7C3E, 0x3E1F3FFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFF7E3E1F, 0x1FCFDFFF,
	0xFFFFFFFF, 0xFFFFF000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x007FFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFF800, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00FFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x01FFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x0000007F,
	0xC0000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x03FFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x07FFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFC0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFE0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x3FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFF0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x7FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFF8, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFE, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000001, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000003, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0x80000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000007, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000000F, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xF0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000001F, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xF8000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000003F, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000007F, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000000FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFE7F, 0xFF9FFFFF, 0xFFFFFFEF, 0xFE7FFFCF, 0xFF7FFFFF,
	0x1FFFE7FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFF000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000003FF, 0xFFFFFFC0, 0x03FC007F,
	0xFFFFFC00, 0x0001FC0F, 0x01FFFF80, 0x00000000, 0x000FFFE0,
	0x00000007, 0xFFFFFFFF, 0xFFFB4000, 0x1FFFFFF8, 0x00000FF0,
	0x000003F8, 0x07FFFFFF, 0xFF800000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000007FF, 0xFFFFFF00, 0x00000003,
	0xFFFF8000, 0x00006000, 0x001FF800, 0x00000000, 0x0001FFC0,
	0x00000007, 0xFFFFFFFF, 0xFFD30000, 0x03FFFE00, 0x000000C0,
	0x000000C0, 0x007FFFFF, 0xFF800000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000FFF, 0xFFFFFF00, 0x00000000,
	0x7FFF8000, 0x00006000, 0x001FF800, 0x00000000, 0x0000FFC0,
	0x00000007, 0xFFFFFFFF, 0xFFD10000, 0x03FFFE00, 0x000000C0,
	0x000000C0, 0x007FFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001FFF, 0xFFFFFF00, 0x00000000,
	0x3FFF8000, 0x0000E000, 0x001FF800, 0x00000000, 0x0000FFE0,
	0x0000000F, 0xFFFFFFFF, 0xFFD80000, 0x03FFFE00, 0x000000E0,
	0x000000C0, 0x00FFFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00003FFF, 0xFFFFFF00, 0x00000000,
	0x1FFFC000, 0x0000E000, 0x001FF800, 0x00000000, 0x0000FFE0,
	0x0000000F, 0xFFFFFFFF, 0xFFF80000, 0x03FFFF00, 0x000001E0,
	0x000001C0, 0x007FFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00003FFF, 0xFFFFFE00, 0x01F80000,
	0x0FFFC000, 0x0000E000, 0x001FF800, 0x18000001, 0x0000FFE0,
	0x0000001F, 0xFFFFFFFF, 0xFFF80000, 0x03FFFF80, 0x000001E0,
	0x000001E0, 0x027FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00007FFF, 0xFFFFFC00, 0x0FFF0000,
	0x0FFFE300, 0x0018E000, 0x001FF800, 0x3E00000F, 0xE000FFE3,
	0x8000061F, 0xFFFFFFFF, 0xFFF40000, 0x01FFFFBE, 0x000001E0,
	0x000019E0, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000FFFF, 0xFFFFF800, 0x1FFF8000,
	0x0FFFE700, 0x001CF700, 0x033FF800, 0x7F00000F, 0xE000FFF3,
	0x8000073F, 0xFFFFFFFF, 0xFFF00000, 0x01FFFFFF, 0x000039E6,
	0x000039E6, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000FFFF, 0xFFFFF800, 0x1FFF8000,
	0x07FFF700, 0x001DF700, 0x03BFF800, 0x7F00000F, 0xE000FFF7,
	0x8000073F, 0xFFFFFFFF, 0xFFF80000, 0x01FFFFFF, 0x000039EC,
	0x00003DEE, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0001FFFF, 0xFFFFF000, 0x1FFF8000,
	0x07FFF700, 0x001DF700, 0x03BFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFFF00000, 0x01FFFFFF, 0x80003BEC,
	0x00003FFC, 0x01FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0003FFFF, 0xFFFED000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFFC00000, 0x00FFFFFF, 0x80003FFC,
	0x00003FFC, 0x01FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0003FFFF, 0xFFFE4000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFF800000, 0x00FFFFFF, 0x00003FFC,
	0x00001FFC, 0x01FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0003FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFC800000, 0x00FFFFFF, 0x00003FFC,
	0x00001FFC, 0x019FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFC000000, 0x00FFFFFF, 0x00001FFC,
	0x00001FFC, 0x019FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFC000000, 0x00FFFFFF, 0x80001FF8,
	0x00001FFC, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFC000000, 0x007FFFFF, 0x80001FF8,
	0x00001FF8, 0x003FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF800, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xFC000000, 0x007FFFFF, 0x80001FF8,
	0x00001FF8, 0x003FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF000, 0x7F00000F, 0xE000FFFF,
	0x800007FF, 0xFFFFFFFF, 0xF8000000, 0x007FFFFF, 0x80001FF8,
	0x00001FF8, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF000, 0x7F00000F, 0xE0007FFF,
	0x800007FF, 0xFFFFFFFF, 0xF8000000, 0x007FFFFF, 0x80001FF9,
	0x00001FF8, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFE000, 0x3F00000F, 0xE0003FFF,
	0x800007FF, 0xFFFFFFFF, 0xF8000000, 0x003FFFFF, 0x80001FF8,
	0x00001FF8, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFC000, 0x3F00000F, 0xC0001FFF,
	0x800007FF, 0xFFFFFFFF, 0xF0000000, 0x003FFFFF, 0x80001FFE,
	0x10000FF8, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFC000, 0x3F00000F, 0xC0001FFF,
	0x800007FF, 0xFFFFFFFF, 0xF0001800, 0x003FFFFF, 0x80001FFB,
	0x00000FF0, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFC000, 0x3F00000F, 0xC0003FFF,
	0x800007FF, 0xFFFFFFFF, 0xF0001800, 0x003FFFFF, 0x80001FFB,
	0xC0000FF0, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFF803, 0xFF00000F, 0xFC01FFFF,
	0x800007FF, 0xFFFFFFFF, 0xF0003C00, 0x003FFFFF, 0x80001FFD,
	0xC0000FF0, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFE0F, 0xFF00000F, 0xFF07FFFF,
	0x800007FF, 0xFFFFFFFF, 0xF0003C00, 0x001FFFFF, 0x80001FFC,
	0x00000FF0, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFF0F, 0xFF00000F, 0xFF8FFFFF,
	0x800007FF, 0xFFFFFFFF, 0xE0003C00, 0x001FFFFF, 0x80000FFC,
	0x00000FF0, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFF9F, 0xFF00000F, 0xFF8FFFFF,
	0x800007FF, 0xFFFFFFFF, 0xE0003C00, 0x001FFFFF, 0x80000FFC,
	0x00000FF0, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFF9F, 0xFF00000F, 0xFF8FFFFF,
	0x800007FF, 0xFFFFFFFF, 0xE0003C00, 0x001FFFFF, 0x80000FFC,
	0x00000FE0, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFF9F, 0xFF00000F, 0xFFDFFFFF,
	0x800007FF, 0xFFFFFFFF, 0xC0003C00, 0x001FFFFF, 0xC0000FF8,
	0x00000FE0, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFDFFFFF,
	0x000007FF, 0xFFFFFFFF, 0xC0003800, 0x000FFFFF, 0xC0000FF8,
	0x00000FE0, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x0FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x000007FF, 0xFFFFFFFF, 0xC0003800, 0x000FFFFF, 0xC0000FEC,
	0x000007E0, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x0FFF0000,
	0x07FFFE00, 0x001FFF00, 0x03FFFFFF, 0xFE00000F, 0xFFFFFFFE,
	0x000007FF, 0xFFFFFFFF, 0xC0003800, 0x0007FFFF, 0xC00007E4,
	0x000007E0, 0x01FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x0FFF0000,
	0x03FFFE00, 0x000FFF00, 0x01FFFFFF, 0xFC000007, 0xFFFFFFFE,
	0x000003FF, 0xFFFFFFFF, 0x80003800, 0x0003FFFF, 0xC00007E0,
	0x000007C0, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFFC0000, 0x07FE0000,
	0x01FFFC00, 0x0007FE00, 0x00FFFFFF, 0xF8000003, 0xFFFFFFFC,
	0x000003FF, 0xFFFFFFFC, 0x00001800, 0x0001FFFF, 0x800007C0,
	0x000003C0, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFF80000, 0x03FC0000,
	0x007FF800, 0x0003F800, 0x003FFFFF, 0xF0000001, 0xFFFFFFF8,
	0x000000FF, 0xFFFFFFF8, 0x00001800, 0x00007FFF, 0x000003C0,
	0x00000380, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFF80000, 0x03FC0000,
	0x007FF800, 0x0003F800, 0x003FFFFF, 0xF0000001, 0xFFFFFFF8,
	0x000000FF, 0xFFFFFFF8, 0x00003C00, 0x00007FFF, 0x00000380,
	0x00000380, 0x007FFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFF80000, 0x07FE0000,
	0x00FFFC00, 0x0007FE00, 0x00FFFFFF, 0xFC000003, 0xFFFFFFFE,
	0x000003FF, 0xFFFFFFFE, 0x00007E20, 0x0001FFFF, 0x00000380,
	0x00000380, 0x00FFFFFF, 0xFFE00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFFC0000, 0x0FFE0000,
	0x03FFFE00, 0x000FFF00, 0x00FFFFFF, 0xFE000007, 0xFFFFFFFF,
	0x000003FF, 0xFFFFFFFE, 0x00007F00, 0x0001FFFF, 0xC0000780,
	0x000007C0, 0x01FFFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFF80000, 0x0FFC0000,
	0x01FFFE00, 0x0007FE00, 0x007FFFFF, 0xFC000003, 0xFFFFFFFC,
	0x000001FF, 0xFFFFFFF0, 0x00003E40, 0x0000FFFF, 0x800007C0,
	0x000007C0, 0x00FFFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFF00000, 0x03F80000,
	0x00FFF800, 0x0003F800, 0x003FFFFF, 0xF8000001, 0xFFFFFFFC,
	0x000000FF, 0xFFFFFFF0, 0x00003EC0, 0x00003FFF, 0x00000380,
	0x00000100, 0x007FFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFF00000, 0x03F80000,
	0x00FFF800, 0x0003F800, 0x003FFFFF, 0xF8000001, 0xFFFFFFFC,
	0x000000FF, 0xFFFFFFF8, 0x00007FC0, 0x00003FFF, 0x00000100,
	0x00000100, 0x007FFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFF80000, 0x07FC0000,
	0x01FFFC00, 0x0007FC00, 0x007FFFFF, 0xFC000003, 0xFFFFFFFE,
	0x000001FF, 0xFFFFFFFE, 0x0000FF80, 0x00007FFF, 0xC0000100,
	0x00000100, 0x00FFFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFFC0000, 0x0FFE0000,
	0x03FFFF00, 0x000FFE00, 0x00FFFFFF, 0xFE000007, 0xFFFFFFFF,
	0x000003FF, 0xFFFFFFFF, 0x0000FF80, 0x0000FFFF, 0xE0000300,
	0x1E000380, 0x01FFFFFF, 0xFFC00000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x001FFFFF, 0xFFFE0000, 0x0FFF0000,
	0x07FFFF00, 0x000FFF00, 0x01FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFFFFFFE, 0x0001FF80, 0x0001FFFF, 0xF0000380,
	0x1E000380, 0x03FFFFFF, 0xFF800000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFF8000,
	0x0FFFFF00, 0x001FFF00, 0x01FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFFFFFFE, 0x0001FFC0, 0x0001FFFF, 0xF8000300,
	0x1E000380, 0x07FFFFFF, 0xFF800000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFF8000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFFFFFFE, 0x0003FF80, 0x0000FFFF, 0xF8000100,
	0x1E000100, 0x07FFFFFF, 0xFF000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFF8000,
	0x07FFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFFFFFFE, 0x0003FF80, 0x0000FFFF, 0xF8000100,
	0x3F000000, 0x07FFFFFF, 0xFF000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFFC000,
	0x07FFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFE7FFFE, 0x0003FF80, 0x0000FFFF, 0xF8000000,
	0x3F000000, 0x07FFFFFF, 0xFF000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFFE000,
	0x07FFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFE7FFFE, 0x0000FE00, 0x0000FFFF, 0xF8000000,
	0x3F000000, 0x0FFFFFFF, 0xFE000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0000, 0x1FFFE400,
	0x07FFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFE7FFFE, 0x00000000, 0x0000FFFF, 0xF8000000,
	0x3F000000, 0x0FFFFFFF, 0xFE000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000FFFFF, 0xFFFE0010, 0x1FFFFE00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFE3FFFE, 0x00000000, 0x0000FFFF, 0xF8000000,
	0x7F800000, 0x0FFFFFFF, 0xFE000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0014, 0x1FFFFE00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFFC3FFFE, 0x00000000, 0x0000FFFF, 0xFC000000,
	0x7F800000, 0x0FFFFFFF, 0xFE000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFFC00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFF82FFFE, 0x00000000, 0x0000FFFF, 0xFC000000,
	0x7F844000, 0x0FFFFFFF, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFFC00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFC027FFE, 0x00000000, 0x00007FFF, 0xFC000000,
	0x7F8C0000, 0x0FFFFFFF, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0010, 0x1FFFFE00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xF80067FE, 0x00000000, 0x00007FFF, 0xFC000000,
	0x7F910000, 0x0FFFFFFF, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFFE00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xF808A7FE, 0x00000000, 0x00007FFF, 0xFC000000,
	0x7FF14000, 0x1FFFFFFF, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFFE00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFC00BFFE, 0x00000000, 0x00007FFF, 0xFC000000,
	0x7FF34000, 0x1FFFFFFF, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFFC00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFC009FFE, 0x001FFF80, 0x00007FFF, 0xFE040000,
	0xFFFF4000, 0x1FFFFFFF, 0xFC000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFFC00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFE009FFE, 0x001FFFF0, 0x00007FFF, 0xFE000000,
	0xFFFE4000, 0x1FFFFFFF, 0xF8000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFFC00,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFE001FFE, 0x001FFFF0, 0x00007FFF, 0xFE080000,
	0xFFFE4000, 0x1FFFFFFF, 0xF8000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFE000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFE001FFC, 0x003FFFF8, 0x00007FFF, 0xFE0F0000,
	0xFFFC0000, 0x3FFFFFFF, 0xF8000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFFE000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFE001FFC, 0x003FFFF8, 0x00003FFF, 0xFE030000,
	0xFFFC0000, 0x3FFFFFFF, 0xF8000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFE001FFC, 0x003FFFF0, 0x00003FFF, 0xFE030000,
	0xFFFE0000, 0x3FFFFFFF, 0xF8000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFE0000, 0x1FFF8000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFE001FFC, 0x003FFFF0, 0x00003FFF, 0xFF000000,
	0xFFFA0000, 0x3FFFFFFF, 0xF0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0007FFFF, 0xFFFF0000, 0x1FFFC000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xFF00000F, 0xFFFFFFFF,
	0x800007FF, 0xFE001FFC, 0x003FFFF8, 0x00003FFF, 0xFF000000,
	0xFFF80000, 0x3FFFFFFF, 0xF0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0003FFFF, 0xFFFF0000, 0x1FFF8000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xE700000F, 0x3FFFFFF3,
	0x800007FF, 0xFE001FFC, 0x003DFFF8, 0x00003EFF, 0xFF000000,
	0xFFF80000, 0x3FFFFFFF, 0xF0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0003FFFF, 0xFFFF0000, 0x1FFF8000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xE700000F, 0x3FFFFFF3,
	0x800007FF, 0xFE001DFC, 0x003DFF70, 0x00003EFF, 0xFF000000,
	0xFFF80000, 0x7FFFFFFF, 0xF0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0003FFFF, 0xFFFF0000, 0x1FFF8000,
	0x0FFFFF00, 0x001FFF00, 0x03FFFFFF, 0xC700000F, 0x3FFFFFE3,
	0x800027FF, 0xFE001CF8, 0x0039FF30, 0x00003C7F, 0xFF000000,
	0xFFE00000, 0x7FFFFFFF, 0xF0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0003FFFF, 0xFFFF0000, 0x0FFFC200,
	0x1FFFFF00, 0x000FFE00, 0x03FFFFFF, 0xC3000006, 0x1FFFFFE1,
	0x000007FF, 0xF80018F8, 0x0031FF10, 0x0000187F, 0xFF800000,
	0xFFE00000, 0x7FFFFFFF, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0001FFFF, 0xFFFF8000, 0x07FF8C60,
	0x3FFFFF80, 0x0003F800, 0x07FFFFFF, 0xC0000000, 0x1FFFFFE0,
	0x000007FF, 0xF0001830, 0x0031FF80, 0x0000183F, 0xFF800000,
	0xFFE00000, 0x7FFFFFFF, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0001FFFF, 0xFFFFC000, 0x00FA8C61,
	0x7FFFFFC0, 0x00000000, 0x0FFFFFFF, 0xC0000000, 0x1FFFFFE0,
	0x00010E00, 0x00001800, 0x0001FF80, 0x0000003F, 0xFF800000,
	0xFFE00000, 0x7FFFFFFF, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000FFFF, 0xFFFFE000, 0x00029CE3,
	0xFFFFFFE0, 0x00000000, 0x1FFFFFFF, 0x80008000, 0x0FFFFFC0,
	0x00011C00, 0x00000800, 0x0001FF80, 0x0000001F, 0xFF800000,
	0xFFE00000, 0x7FFFFFFF, 0xE0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00007FFF, 0xFFFFF800, 0x0004BFAF,
	0xFFFFFFF8, 0x00000000, 0x3FFFFFFF, 0x80000000, 0x0FFFFFC0,
	0x0003DC00, 0x00000000, 0x0001FF80, 0x0000001F, 0xFF800000,
	0xFFE00000, 0xFFFFFFFF, 0xC0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00007FFF, 0xFFFFFE00, 0x001CFFBF,
	0xFFFFFFFE, 0x00000000, 0xFFFFFFFF, 0xC0460000, 0x0FFFFFC0,
	0x0003DA00, 0x00000000, 0x0001FFC0, 0x0000001F, 0xFF800001,
	0xFFE00000, 0xFFFFFFFF, 0xC0000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00003FFF, 0xFFFFFFC0, 0x07FFFFFF,
	0xFFFFFFFF, 0xC0000007, 0xFFFFFFFF, 0xFF4E0000, 0x3FFFFFFC,
	0x005FFA00, 0x00000300, 0x0007FFFC, 0x01FF00FF, 0xFFF0000F,
	0xFFFC0003, 0xFFFFFFFF, 0x80000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00001FFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFC3F, 0xFFFFFFFF, 0xFFFFFFE3, 0xFFFFFFFF,
	0xE7FFFFC0, 0x07C1FFE7, 0xFE3FFFFF, 0xBFFFF7FF, 0xFFFCFFBF,
	0xFFFFBFEF, 0xFFFFFFFF, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000FFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFE, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000007FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFE, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000003FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFC, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFF8, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x000000FF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFF0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000003F, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFE0, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000001F, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFF80, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x0000000F, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000007, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000003, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000001, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x7FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x3FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x00001800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x3FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x00001800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x00001800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x00001800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFC, 0x007FE003, 0x00000000, 0x00000000, 0x000FFFE0,
	0x00000800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF, 0x8F83C1E0,
	0xF879FFFC, 0x007FE003, 0xC03C0780, 0x7FC00007, 0x807FFFE0,
	0x00000E01, 0xFFFFC03E, 0x01E03C00, 0x00780000, 0xFFCF0F87,
	0x8787C7CF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0FFFFFFF, 0x8F83C1E0,
	0xF879FFFC, 0x003FE001, 0xC03C0780, 0x7FC00007, 0x807FFFE0,
	0x00000601, 0xFFFFC01E, 0x01E03C00, 0x00780000, 0xFFCF0F87,
	0x8787C7CF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFC, 0x003FE001, 0xC0380780, 0x7FC00007, 0x807FFFE0,
	0x00000601, 0xFFFF801E, 0x01C03C00, 0x00780000, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0FFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x007FE007, 0xC0380780, 0x7FC00003, 0x807FFFF0,
	0x07C01E01, 0xFFFF801E, 0x01C03C00, 0x00380000, 0x7FFFFFFF,
	0xFFFFFFFF, 0xFFFFFF00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x07FFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x007FE007, 0x80180300, 0x3F800003, 0x003FFFF0,
	0x07C01C00, 0xFFFF800C, 0x00C01800, 0x00300000, 0x7FFFFFFF,
	0xFFFFFFFF, 0xFFFFFE00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x03FFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x003FE007, 0x80180300, 0x3F800003, 0x003FFFF0,
	0x07C01C00, 0xFFFF800C, 0x00C01800, 0x00300000, 0x7FFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x03FFFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x003FC007, 0xC0380380, 0x7F810103, 0xC0FFFFF0,
	0x07C01E01, 0xFFFFC03F, 0x01E07E07, 0xC07C0F80, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x01FFFFFF, 0xFFC7C1E0,
	0xF07DFFFE, 0x003FC007, 0xE07C07C0, 0xFFC30187, 0xC0FFFFF0,
	0x07C01F03, 0xFFFFC01F, 0x81C07E07, 0xC07C0F80, 0xFFCF0F87,
	0x87C7DFFF, 0xFFFFF800, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00FFFFFF, 0xFFC7C1E0,
	0xF07DFFFE, 0x001FC007, 0xE07C07C0, 0xFFC701C7, 0xC0FFFFF0,
	0x07C01F03, 0xFFFF801F, 0x81C0FE07, 0xC07C0F80, 0xFFCF0F87,
	0x87C7DFFF, 0xFFFFF000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x007FFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x001F8007, 0xE07C07C0, 0xFFE701CF, 0xC0FFFFF0,
	0x07C01F03, 0xFFFF801F, 0x81C0FE07, 0xC07C0F80, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFE000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x003FFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x001F8007, 0xE07C07C0, 0xFFE701CF, 0xC0FFFFF0,
	0x06001F03, 0xFFFF801F, 0xC0C0FE07, 0xCE7C0F80, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFC000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x001FFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x001F8007, 0xE07C07C0, 0xFFE701CF, 0xC0FFFFF0,
	0x04001F03, 0xFFFF801F, 0xC081FE07, 0xFFFC0E00, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFF0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000FFFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x000F0007, 0xE07C07C0, 0xFFE701EF, 0xC0FFFFF0,
	0x00001F03, 0xFFFF800F, 0xC081FE07, 0xFFFC0800, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFE0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0007FFFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x000F0007, 0xE07C07C0, 0xFFEF01EF, 0xC0FFFFF0,
	0x00001F03, 0xFFFF800F, 0xC081FE07, 0xFFFC0000, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFC0000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0001FFFF, 0xFFFFE3E0,
	0xF87DFFFE, 0x000F0007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x00001F03, 0xFFFF800F, 0xE003FE07, 0xFFFC0000, 0xFFCF8F87,
	0x8FFFFFFF, 0xFFF00000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000FFFF, 0xFFFFE3E0,
	0xF87DFFFE, 0x00060007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x0000FF03, 0xFFFF000F, 0xE003FE00, 0x03FC0001, 0xFFCF8F87,
	0x8FFFFFFF, 0xFFE00000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00007FFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00060007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x000FFF03, 0xFFFF000F, 0xE003FE00, 0x03FC001F, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFC00000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00003FFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00060007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x003FFF03, 0xFFFF0207, 0xF003FE00, 0x03FC007F, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFF800000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00001FFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x007FFF03, 0xFFFF0207, 0xF007FE00, 0x03FC007F, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFF000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000FFF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x00FFFF03, 0xFFFF0207, 0xF007FE00, 0x03FC003F, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFE000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000007FF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x03FFFF03, 0xFFFF0207, 0xF807FE00, 0x03FC0007, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFC000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000003FF, 0xFFFFFFF1,
	0xF8FDFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x03FFFF03, 0xFFFE0607, 0xF80FFE07, 0xFFFC0000, 0xFFCF8F8F,
	0xFFFFFFFF, 0xFC000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000001FF, 0xFFFFFFF1,
	0xF8FDFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xFFFE0703, 0xF80FFE07, 0xFFFC0000, 0xFFCF8F8F,
	0xFFFFFFFF, 0xF8000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000001FF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xFFFE0003, 0xF80FFE07, 0xFFFC0800, 0xFFFFFFFF,
	0xFFFFFFFF, 0xF0000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x000000FF, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xFFFE0003, 0xF80FFE07, 0xFFFC0E00, 0xFFFFFFFF,
	0xFFFFFFFF, 0xF0000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000007F, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xFFFE0003, 0xF80FFE07, 0xFFFC0F80, 0xFFFFFFFF,
	0xFFFFFFFF, 0xE0000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000003F, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00801007, 0xE07C07C0, 0xFFFF01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xFFFE0003, 0xF80FFE07, 0xFFFC0F80, 0xFFFFFFFF,
	0xFFFFFFFF, 0xC0000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000001F, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00801007, 0xE07C07C0, 0xF80F01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xE03E0003, 0xF80FFE07, 0xC07C0F80, 0xFFFFFFFF,
	0xFFFFFFFF, 0x80000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x0000000F, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00801007, 0xE07C07C0, 0xF80F01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xE03C0001, 0xF80FFE07, 0xC07C0F80, 0xFFFFFFFF,
	0xFFFFFFFF, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000007, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00C03007, 0xE07C07C0, 0xF80F01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xE03C0F81, 0xF80FFE07, 0xC07C0F80, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000003, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00DFB007, 0xE07C07C0, 0xF80F01FF, 0xC0FFFFF0,
	0x07FFFF03, 0xE03C0F81, 0xF80FFE07, 0xC07C0F80, 0xFFFFFFFF,
	0xFFFFFFF8, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000001, 0xFFFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0xE07C07C0, 0xF80E00FF, 0x003FFFF0,
	0x07FFFF03, 0xE0380700, 0x7007FE07, 0xC0700300, 0x7FFFFFFF,
	0xFFFFFFF0, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x7FFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x80000300, 0x000600FF, 0x003FFFF0,
	0x07FFFC00, 0x00100300, 0x7007F800, 0x00300300, 0x7FFFFFFF,
	0xFFFFFFC0, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x3FFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x80000300, 0x000600FF, 0x803FFFF0,
	0x07FFFC00, 0x00100300, 0x7007F800, 0x00300300, 0x7FFFFFFF,
	0xFFFFFF80, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFFFFFE, 0x00FFF007, 0xC0000780, 0x000E00FF, 0x807FFFF0,
	0x07FFFE00, 0x00380700, 0xF007FC00, 0x00780700, 0xFFFFFFFF,
	0xFFFFFE00, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0FFFFFFF,
	0xFFFFFFFC, 0x003FE001, 0xC0000780, 0x000F01FF, 0x807FFFE0,
	0x01FFFE00, 0x00380700, 0xF80FFC00, 0x00780700, 0xFFFFFFFF,
	0xFFFFFC00, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x03FFFFFF,
	0xFFFFFFFC, 0x003FE001, 0xC0000780, 0x000F01FF, 0x807FFFE0,
	0x01FFFE00, 0x00380780, 0xF80FFC00, 0x00780780, 0xFFFFFFFF,
	0xFFFFF000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x01FFFFFF,
	0xFFFFFFFC, 0x007FE003, 0xE00007C0, 0x000F01FF, 0xC07FFFE0,
	0x03FFFF00, 0x003C0780, 0xF80FFE00, 0x007C0780, 0xFFFFFFFF,
	0xFFFFC000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00FFFFFF,
	0xFFFFFFFC, 0x007FE003, 0x00000000, 0x00000000, 0x000FFFE0,
	0x03FFF800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFF0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x003FFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x07FFF800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFFC0000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x001FFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x07FFF800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFF80000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000FFFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x07FFF800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFE00000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0003FFFF,
	0xFFFFFFFE, 0x00FFF007, 0x00000000, 0x00000000, 0x000FFFF0,
	0x07FFF800, 0x00000000, 0x00000000, 0x00000000, 0x1FFFFFFF,
	0xFFC00000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0001FFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFF800000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000FFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFF000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00007FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFE000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00001FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFC000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000FFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xF0000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000003FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xE0000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x000001FF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xC0000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000007F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x0000003F,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFE,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000007,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFF8,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x03FFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFE0,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x007FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFF80,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x001FFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFE00,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0007FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF800,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0003FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFF000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0001FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0000FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF8000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00007FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00003FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF0000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00001FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE0000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC0000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF80000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x000007FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF80000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x000003FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF00000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x000001FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFC00000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x000000FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF,
	0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF800000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0000007F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFC3FF,
	0xFFE1FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFF000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0000003F, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFF01FF,
	0xFFC07FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFE000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x0000001F, 0xFFF9FFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFE00FF,
	0xFF803FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFC000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000007, 0xFFE07FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFC007F,
	0xFF001FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xF8000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000003, 0xFF801FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFF8001F,
	0xFC000FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xF0000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0xFF000FFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFE00007,
	0xF80003FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFF, 0xC0000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x000000E0, 0x3FFFFFFF, 0xFFFFFFFF, 0xFF000000,
	0x000000FF, 0xFFFFFFFF, 0xFFFFFFFF, 0xFFFFFFFE, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000,
	0x00000000, 0x00000000, 0x00000000, 0x00000000, 0x00000000

};
