#ifndef UTIL_H
#define UTIL_H

int WrapInteger(int x, int min, int range);
void TrimLine(int *x, int min, int max);

#endif /* UTIL_H */
