* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *
*			data_01.s                                   *
*		A data file for Part 3                              *
* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *

* A large ST in perspective.

my_datax	dc.w	115,115,25,25,100,100,40,40,92,92,81,81
		dc.w	70,70,55,55,100,100,81,81,81,81,40,40
my_datay	dc.w	-100,100,100,-100,-80,-20,-20,-80,-60
		dc.w	-20,-20,-60,-80,-40,-40,-80,0,80,80
		dc.w	0,25,55,55,25
my_dataz	dc.w	120,120,0,0,100,100,20,20,90,90,75,75
		dc.w	60,60,40,40,100,100,75,75,75,75,20,20
my_edglst	dc.w	0,1,2,3,0,4,5,6,7,4,8,9,10,11,8,12,13,14,15,12
		dc.w	16,17,18,19,16,20,21,22,23,20
my_nedges	dc.w	4,4,4,4,4,4
my_npoly	dc.w	6
my_colour	dc.w	1,4,1,1,4,4
my_xmin		dc.w	0
my_xmax		dc.w	319
my_ymin		dc.w	0
my_ymax		dc.w	199

