* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * 
* Copyright A.Tyler 1991 data_04.s                          *
* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *

ill_vecx	dc.w	0
ill_vecy	dc.w	-16384	light shining from +y to -y
ill_vecz	dc.w	0
vwpointz	dc.w	-100
illkey		dc.w	1
intr_col	dc.w	0,1,0,0,1,1	
palette	dc.w	0,$557,$446,$336,$226,$225,$114,$113
	dc.w	$756,$745,$734,$723,$713,$702,$502,$401
