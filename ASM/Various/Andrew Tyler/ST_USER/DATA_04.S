* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * * 
*			data_04.s                           *
* * * * * * * * * * * * * * * * * * * * * * * * * * * * * * *

ill_vecx	dc.w	0
ill_vecy	dc.w	-16384	light shining from +y to -y
ill_vecz	dc.w	0
vwpointz	dc.w	-100
illkey		dc.w	1
intr_col	dc.w	0,1,0,0,1,1
* first palette colour is black for the border	
palette		dc.w	0,$557,$446,$336,$226,$225,$114,$113
		dc.w	$756,$745,$734,$723,$713,$702,$502,$401
sarealst	dc.w	30000,6000,720,1000,2400,2100
