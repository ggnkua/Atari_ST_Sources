NO_SPRITE	EQU	0
LINE_SPRT	EQU	0
L	EQU	224
H	EQU	112
XMAX	EQU	640
YMAX	EQU	480

	DATA
FNAME	DC.B	'pause.spr',0
	EVEN

BLOC1	INCBIN	pause.BIN
	EVEN
	TEXT
	
	LEA	BLOC1,A0
	ADD.L	#(32*NO_SPRITE)+(LINE_SPRT*XMAX),A0
	LEA	BLOC,A1
	MOVE.L	#0,SIZE
	MOVE.L	#H-1,D0	* nb ligne
LOOP
	MOVE.L	#L/4-1,D1
LOOP_INT
	MOVE.L	(A0)+,(A1)+
	ADD.L	#4,SIZE
	DBRA	D1,LOOP_INT
	LEA	XMAX-L(A0),A0
	DBRA	D0,LOOP

FCREATE	MOVE.W	#0,-(A7)
	PEA	FNAME
	MOVE.W	#$3C,-(A7)
	TRAP	#1
	ADDQ.L	#8,A7
	TST.L	D0
	BMI.S	ERROR
	MOVE.W	D0,FHANDLE
	
	
FWRITE	MOVE.L	#BLOC,-(A7)
	MOVE.L	SIZE,-(A7)
	MOVE.W	FHANDLE,-(A7)
	MOVE.W	#$40,-(A7)
	TRAP	#1
	ADDA.L	#12,A7
	MOVE.W	FHANDLE,-(A7)
	MOVE.W	#$3E,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	
	MOVE.W	#0,-(A7)
	TRAP	#1
	
ERROR
	PEA	TXT
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	MOVE.W	#0,-(A7)
	TRAP	#1
	

	DATA
FHANDLE	DC.W	0
SIZE	DC.L	0
	EVEN
TXT
	DC.B	$1B,'EERROR',0
	EVEN
BLOC
	DS.B	640*480
