	dc.l	151<<16,165<<16,96787,-17202
	dc.l	159<<16,2<<16,-58838,-78751
	dc.l	9<<16,38<<16,51456,-83761
	dc.l	44<<16,134<<16,20946,-96047
	dc.l	247<<16,101<<16,-75512,62941
	dc.l	217<<16,4<<16,-42279,-88748
	dc.l	90<<16,43<<16,-60383,-77573
	dc.l	1<<16,179<<16,70239,-68776
	dc.l	198<<16,21<<16,-16554,96900
	dc.l	285<<16,41<<16,65286,73494
	dc.l	82<<16,20<<16,71264,67713
	dc.l	268<<16,192<<16,39783,-89894
	dc.l	66<<16,108<<16,-6768,-98071
	dc.l	107<<16,79<<16,96860,16790
	dc.l	232<<16,150<<16,-97516,12423
	dc.l	72<<16,71<<16,90309,38833
	dc.l	176<<16,66<<16,-27147,94481
	dc.l	216<<16,96<<16,-96010,21111
	dc.l	125<<16,58<<16,-89055,-41627
	dc.l	31<<16,141<<16,8306,-97952
	dc.l	187<<16,66<<16,-81048,55632
	dc.l	150<<16,33<<16,-2814,-98264
	dc.l	86<<16,47<<16,29188,93871
	dc.l	220<<16,176<<16,74196,64487
