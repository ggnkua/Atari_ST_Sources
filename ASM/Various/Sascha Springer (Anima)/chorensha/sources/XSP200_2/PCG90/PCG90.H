
void	pcg_roll90(void *,int) ;
void	bgpcg_roll90(void *,int) ;

