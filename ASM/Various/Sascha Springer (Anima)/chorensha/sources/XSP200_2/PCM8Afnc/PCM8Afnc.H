
void	pcm8a_vsyncint_on() ;
void	pcm8a_vsyncint_off() ;

