#define DIALOG 0  	/* TREE */
#define REBOOT 5  	/* OBJECT in TREE #0 */
#define OK 7  	/* OBJECT in TREE #0 */
#define ABBRUCH 8  	/* OBJECT in TREE #0 */
#define MON 10  	/* OBJECT in TREE #0 */
#define MMODE 12  	/* OBJECT in TREE #0 */
#define CNAME 14  	/* OBJECT in TREE #0 */
#define VERSION 15  	/* OBJECT in TREE #0 */
#define VMODE 17  	/* OBJECT in TREE #0 */
#define VON 19  	/* OBJECT in TREE #0 */
