#define INFOBOX1 176  	/* OBJECT in TREE #118 */
#define INFOBOX 0  	/* TREE */
#define DONE 3  	/* OBJECT in TREE #0 */
#define OBJ2 193  	/* OBJECT in TREE #18 */
#define OBJ23 110  	/* OBJECT in TREE #107 */
#define EDITBOX 230  	/* OBJECT in TREE #15 */
#define OBJ1 1  	/* OBJECT in TREE #42 */
#define OBJ3 230  	/* OBJECT in TREE #15 */
#define OBJ4 159  	/* OBJECT in TREE #106 */
#define OB1 7  	/* OBJECT in TREE #0 */
#define TREE2 1  	/* TREE */
#define TB1 1  	/* OBJECT in TREE #1 */
