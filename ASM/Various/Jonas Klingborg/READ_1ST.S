*** Hall†!

Mycket av det som kommer h„r, kan du s„kert redan!
Men jag skickade ner det iallafall!

Det finns iallafall en del sm†tt och gott!

Du b”r titta i medel-uppl”sning, annars missar du mycket!

Om du vill veta mer s† „r det bara att skriva, jag ska svara
om jag kan!

mvh Jonas Klingborg TSM

