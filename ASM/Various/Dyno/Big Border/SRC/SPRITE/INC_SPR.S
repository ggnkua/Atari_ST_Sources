;########################################
;# SOMMARHACK_NONMASKED
;########################################
;# CYCLES 
;#   Minimum :  248
;#   Average :  316
;#   Maximum :  456
;########################################
;# Cycle[sommarhack_nonmasked_0_left|G:248]
;# Cycle[sommarhack_nonmasked_0_right|G:0]
;# Cycle[sommarhack_nonmasked_1_left|G:248]
;# Cycle[sommarhack_nonmasked_1_right|G:0]
;# Cycle[sommarhack_nonmasked_2_left|G:248]
;# Cycle[sommarhack_nonmasked_2_right|G:0]
;# Cycle[sommarhack_nonmasked_3_left|G:248]
;# Cycle[sommarhack_nonmasked_3_right|G:0]
;# Cycle[sommarhack_nonmasked_4_left|G:248]
;# Cycle[sommarhack_nonmasked_4_right|G:0]
;# Cycle[sommarhack_nonmasked_5_left|G:248]
;# Cycle[sommarhack_nonmasked_5_right|G:0]
;# Cycle[sommarhack_nonmasked_6_left|G:248]
;# Cycle[sommarhack_nonmasked_6_right|G:0]
;# Cycle[sommarhack_nonmasked_7_left|G:248]
;# Cycle[sommarhack_nonmasked_7_right|G:0]
;# Cycle[sommarhack_nonmasked_8_left|G:248]
;# Cycle[sommarhack_nonmasked_8_right|G:0]
;# Cycle[sommarhack_nonmasked_9_left|G:248]
;# Cycle[sommarhack_nonmasked_9_right|G:88]
;# Cycle[sommarhack_nonmasked_10_left|G:248]
;# Cycle[sommarhack_nonmasked_10_right|G:160]
;# Cycle[sommarhack_nonmasked_11_left|G:236]
;# Cycle[sommarhack_nonmasked_11_right|G:220]
;# Cycle[sommarhack_nonmasked_12_left|G:224]
;# Cycle[sommarhack_nonmasked_12_right|G:224]
;# Cycle[sommarhack_nonmasked_13_left|G:212]
;# Cycle[sommarhack_nonmasked_13_right|G:236]
;# Cycle[sommarhack_nonmasked_14_left|G:144]
;# Cycle[sommarhack_nonmasked_14_right|G:248]
;# Cycle[sommarhack_nonmasked_15_left|G:88]
;# Cycle[sommarhack_nonmasked_15_right|G:248]
;########################################

;========================================
; SOMMARHACK_NONMASKED #0
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_0:

sommarhack_nonmasked_0_left:
	or.l #%00100000000000000101111000000000,160*1(a1) ; 32
	or.l #%01110000000000001010111100000000,160*2(a1) ; 32
	or.l #%00100010000000001101110100000000,160*3(a1) ; 32
	or.l #%00000110000000001111100100000000,160*4(a1) ; 32
	or.l #%00001110000000001111000100000000,160*5(a1) ; 32
	or.l #%00011100000000000110001000000000,160*6(a1) ; 32
	move.b  #%00111100,d1 ; 8
	or.b d1,+2(a1) ; 16
	or.b d1,160*7+2(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #1
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_1:

sommarhack_nonmasked_1_left:
	or.l #%00010000000000000010111100000000,160*1(a1) ; 32
	or.l #%00111000000000000101011110000000,160*2(a1) ; 32
	or.l #%00010001000000000110111010000000,160*3(a1) ; 32
	or.l #%00000011000000000111110010000000,160*4(a1) ; 32
	or.l #%00000111000000000111100010000000,160*5(a1) ; 32
	or.l #%00001110000000000011000100000000,160*6(a1) ; 32
	move.b  #%00011110,d1 ; 8
	or.b d1,+2(a1) ; 16
	or.b d1,160*7+2(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #2
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_2:

sommarhack_nonmasked_2_left:
	or.l #%00001000000000000001011110000000,160*1(a1) ; 32
	or.l #%00011100000000000010101111000000,160*2(a1) ; 32
	or.l #%00001000100000000011011101000000,160*3(a1) ; 32
	or.l #%00000001100000000011111001000000,160*4(a1) ; 32
	or.l #%00000011100000000011110001000000,160*5(a1) ; 32
	or.l #%00000111000000000001100010000000,160*6(a1) ; 32
	move.b  #%00001111,d1 ; 8
	or.b d1,+2(a1) ; 16
	or.b d1,160*7+2(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #3
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_3:

sommarhack_nonmasked_3_left:
	or.l #%00000100000000000000101111000000,160*1(a1) ; 32
	or.l #%00001110000000000001010111100000,160*2(a1) ; 32
	or.l #%00000100010000000001101110100000,160*3(a1) ; 32
	or.l #%00000000110000000001111100100000,160*4(a1) ; 32
	or.l #%00000001110000000001111000100000,160*5(a1) ; 32
	or.l #%00000011100000000000110001000000,160*6(a1) ; 32
	move.w  #%0000011110000000,d1 ; 8
	or.w d1,+2(a1) ; 16
	or.w d1,160*7+2(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #4
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_4:

sommarhack_nonmasked_4_left:
	or.l #%00000010000000000000010111100000,160*1(a1) ; 32
	or.l #%00000111000000000000101011110000,160*2(a1) ; 32
	or.l #%00000010001000000000110111010000,160*3(a1) ; 32
	or.l #%00000000011000000000111110010000,160*4(a1) ; 32
	or.l #%00000000111000000000111100010000,160*5(a1) ; 32
	or.l #%00000001110000000000011000100000,160*6(a1) ; 32
	move.w  #%0000001111000000,d1 ; 8
	or.w d1,+2(a1) ; 16
	or.w d1,160*7+2(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #5
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_5:

sommarhack_nonmasked_5_left:
	or.l #%00000001000000000000001011110000,160*1(a1) ; 32
	or.l #%00000011100000000000010101111000,160*2(a1) ; 32
	or.l #%00000001000100000000011011101000,160*3(a1) ; 32
	or.l #%00000000001100000000011111001000,160*4(a1) ; 32
	or.l #%00000000011100000000011110001000,160*5(a1) ; 32
	or.l #%00000000111000000000001100010000,160*6(a1) ; 32
	move.w  #%0000000111100000,d1 ; 8
	or.w d1,+2(a1) ; 16
	or.w d1,160*7+2(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #6
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_6:

sommarhack_nonmasked_6_left:
	or.l #%00000000100000000000000101111000,160*1(a1) ; 32
	or.l #%00000001110000000000001010111100,160*2(a1) ; 32
	or.l #%00000000100010000000001101110100,160*3(a1) ; 32
	or.l #%00000000000110000000001111100100,160*4(a1) ; 32
	or.l #%00000000001110000000001111000100,160*5(a1) ; 32
	or.l #%00000000011100000000000110001000,160*6(a1) ; 32
	move.b  #%11110000,d1 ; 8
	or.b d1,+3(a1) ; 16
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #7
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_7:

sommarhack_nonmasked_7_left:
	or.l #%00000000010000000000000010111100,160*1(a1) ; 32
	or.l #%00000000111000000000000101011110,160*2(a1) ; 32
	or.l #%00000000010001000000000110111010,160*3(a1) ; 32
	or.l #%00000000000011000000000111110010,160*4(a1) ; 32
	or.l #%00000000000111000000000111100010,160*5(a1) ; 32
	or.l #%00000000001110000000000011000100,160*6(a1) ; 32
	move.b  #%01111000,d1 ; 8
	or.b d1,+3(a1) ; 16
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #8
;========================================
; Total cycles : 248
;========================================

; Total cycles : 0
sommarhack_nonmasked_8:

sommarhack_nonmasked_8_left:
	or.l #%00000000001000000000000001011110,160*1(a1) ; 32
	or.l #%00000000011100000000000010101111,160*2(a1) ; 32
	or.l #%00000000001000100000000011011101,160*3(a1) ; 32
	or.l #%00000000000001100000000011111001,160*4(a1) ; 32
	or.l #%00000000000011100000000011110001,160*5(a1) ; 32
	or.l #%00000000000111000000000001100010,160*6(a1) ; 32
	move.b  #%00111100,d1 ; 8
	or.b d1,+3(a1) ; 16
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #9
;========================================
; Total cycles : 364
;========================================

; Total cycles : 28
sommarhack_nonmasked_9:
	lea 8(a1),a2 ; 8
	lea sommarhack_nonmasked_9_right(pc),a3 ; 8
	move.l a3,-(sp) ; 12

sommarhack_nonmasked_9_left:
	or.l #%00000000000100000000000000101111,160*1(a1) ; 32
	or.l #%00000000001110000000000001010111,160*2(a1) ; 32
	or.l #%00000000000100010000000001101110,160*3(a1) ; 32
	or.l #%00000000000000110000000001111100,160*4(a1) ; 32
	or.l #%00000000000001110000000001111000,160*5(a1) ; 32
	or.l #%00000000000011100000000000110001,160*6(a1) ; 32
	move.b  #%00011110,d1 ; 8
	or.b d1,+3(a1) ; 16
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

sommarhack_nonmasked_9_right:
	move.b  #%10000000,d1 ; 8
	or.b d1,160*2+2(a2) ; 16
	or.b d1,160*3+2(a2) ; 16
	or.b d1,160*4+2(a2) ; 16
	or.b d1,160*5+2(a2) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #10
;========================================
; Total cycles : 436
;========================================

; Total cycles : 28
sommarhack_nonmasked_10:
	lea 8(a1),a2 ; 8
	lea sommarhack_nonmasked_10_right(pc),a3 ; 8
	move.l a3,-(sp) ; 12

sommarhack_nonmasked_10_left:
	or.l #%00000000000010000000000000010111,160*1(a1) ; 32
	or.l #%00000000000111000000000000101011,160*2(a1) ; 32
	or.l #%00000000000010000000000000110111,160*3(a1) ; 32
	or.l #%00000000000000010000000000111110,160*4(a1) ; 32
	or.l #%00000000000000110000000000111100,160*5(a1) ; 32
	or.l #%00000000000001110000000000011000,160*6(a1) ; 32
	move.b  #%00001111,d1 ; 8
	or.b d1,+3(a1) ; 16
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

sommarhack_nonmasked_10_right:
	move.l  #%10000000000000000100000000000000,d1 ; 12
	or.l d1,160*3(a2) ; 24
	or.l d1,160*4(a2) ; 24
	or.l d1,160*5(a2) ; 24
	move.b  #%10000000,d1 ; 8
	or.b d1,160*1+2(a2) ; 16
	or.b #%11000000,160*2+2(a2) ; 20
	or.b d1,160*6+2(a2) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #11
;========================================
; Total cycles : 484
;========================================

; Total cycles : 28
sommarhack_nonmasked_11:
	lea 8(a1),a2 ; 8
	lea sommarhack_nonmasked_11_right(pc),a3 ; 8
	move.l a3,-(sp) ; 12

sommarhack_nonmasked_11_left:
	or.l #%00000000000001000000000000001011,160*1(a1) ; 32
	or.l #%00000000000011100000000000010101,160*2(a1) ; 32
	or.l #%00000000000001000000000000011011,160*3(a1) ; 32
	or.l #%00000000000000010000000000011110,160*5(a1) ; 32
	or.l #%00000000000000110000000000001100,160*6(a1) ; 32
	move.b  #%00000111,d1 ; 8
	or.b d1,+3(a1) ; 16
	or.b #%00011111,160*4+3(a1) ; 20
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

sommarhack_nonmasked_11_right:
	move.l  #%11000000000000000010000000000000,d1 ; 12
	or.l #%01000000000000001010000000000000,160*3(a2) ; 32
	or.l d1,160*4(a2) ; 24
	or.l d1,160*5(a2) ; 24
	or.l #%10000000000000000100000000000000,160*6(a2) ; 32
	move.b  #%10000000,d1 ; 8
	or.b d1,+2(a2) ; 16
	or.b #%11000000,160*1+2(a2) ; 20
	or.b #%11100000,160*2+2(a2) ; 20
	or.b d1,160*7+2(a2) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #12
;========================================
; Total cycles : 476
;========================================

; Total cycles : 28
sommarhack_nonmasked_12:
	lea 8(a1),a2 ; 8
	lea sommarhack_nonmasked_12_right(pc),a3 ; 8
	move.l a3,-(sp) ; 12

sommarhack_nonmasked_12_left:
	or.l #%00000000000000100000000000000101,160*1(a1) ; 32
	or.l #%00000000000001110000000000001010,160*2(a1) ; 32
	or.l #%00000000000000100000000000001101,160*3(a1) ; 32
	or.l #%00000000000000010000000000000110,160*6(a1) ; 32
	move.b  #%00000011,d1 ; 8
	move.b  #%00001111,d2 ; 8
	or.b d1,+3(a1) ; 16
	or.b d2,160*4+3(a1) ; 16
	or.b d2,160*5+3(a1) ; 16
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

sommarhack_nonmasked_12_right:
	or.l #%00100000000000001101000000000000,160*3(a2) ; 32
	or.l #%01100000000000001001000000000000,160*4(a2) ; 32
	or.l #%11100000000000000001000000000000,160*5(a2) ; 32
	or.l #%11000000000000000010000000000000,160*6(a2) ; 32
	move.b  #%11000000,d1 ; 8
	or.b d1,+2(a2) ; 16
	or.b #%11100000,160*1+2(a2) ; 20
	or.b #%11110000,160*2+2(a2) ; 20
	or.b d1,160*7+2(a2) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #13
;========================================
; Total cycles : 476
;========================================

; Total cycles : 28
sommarhack_nonmasked_13:
	lea 8(a1),a2 ; 8
	lea sommarhack_nonmasked_13_right(pc),a3 ; 8
	move.l a3,-(sp) ; 12

sommarhack_nonmasked_13_left:
	or.l #%00000000000000010000000000000010,160*1(a1) ; 32
	or.l #%00000000000000110000000000000101,160*2(a1) ; 32
	or.l #%00000000000000010000000000000110,160*3(a1) ; 32
	move.b  #%00000001,d1 ; 8
	move.b  #%00000111,d2 ; 8
	or.b d1,+3(a1) ; 16
	or.b d2,160*4+3(a1) ; 16
	or.b d2,160*5+3(a1) ; 16
	or.b #%00000011,160*6+3(a1) ; 20
	or.b d1,160*7+3(a1) ; 16
	rts ; 16

sommarhack_nonmasked_13_right:
	or.l #%10000000000000000111100000000000,160*2(a2) ; 32
	or.l #%00010000000000001110100000000000,160*3(a2) ; 32
	or.l #%00110000000000001100100000000000,160*4(a2) ; 32
	or.l #%01110000000000001000100000000000,160*5(a2) ; 32
	or.l #%11100000000000000001000000000000,160*6(a2) ; 32
	move.b  #%11100000,d1 ; 8
	or.b d1,+2(a2) ; 16
	or.b #%11110000,160*1+2(a2) ; 20
	or.b d1,160*7+2(a2) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #14
;========================================
; Total cycles : 420
;========================================

; Total cycles : 28
sommarhack_nonmasked_14:
	lea 8(a1),a2 ; 8
	lea sommarhack_nonmasked_14_right(pc),a3 ; 8
	move.l a3,-(sp) ; 12

sommarhack_nonmasked_14_left:
	or.l #%00000000000000010000000000000010,160*2(a1) ; 32
	move.b  #%00000001,d1 ; 8
	move.b  #%00000011,d2 ; 8
	or.b d1,160*1+3(a1) ; 16
	or.b d2,160*3+3(a1) ; 16
	or.b d2,160*4+3(a1) ; 16
	or.b d2,160*5+3(a1) ; 16
	or.b d1,160*6+3(a1) ; 16
	rts ; 16

sommarhack_nonmasked_14_right:
	or.l #%10000000000000000111100000000000,160*1(a2) ; 32
	or.l #%11000000000000001011110000000000,160*2(a2) ; 32
	or.l #%10001000000000000111010000000000,160*3(a2) ; 32
	or.l #%00011000000000001110010000000000,160*4(a2) ; 32
	or.l #%00111000000000001100010000000000,160*5(a2) ; 32
	or.l #%01110000000000001000100000000000,160*6(a2) ; 32
	move.b  #%11110000,d1 ; 8
	or.b d1,+2(a2) ; 16
	or.b d1,160*7+2(a2) ; 16
	rts ; 16

;========================================
; SOMMARHACK_NONMASKED #15
;========================================
; Total cycles : 364
;========================================

; Total cycles : 28
sommarhack_nonmasked_15:
	lea 8(a1),a2 ; 8
	lea sommarhack_nonmasked_15_right(pc),a3 ; 8
	move.l a3,-(sp) ; 12

sommarhack_nonmasked_15_left:
	move.b  #%00000001,d1 ; 8
	or.b d1,160*2+3(a1) ; 16
	or.b d1,160*3+3(a1) ; 16
	or.b d1,160*4+3(a1) ; 16
	or.b d1,160*5+3(a1) ; 16
	rts ; 16

sommarhack_nonmasked_15_right:
	or.l #%01000000000000001011110000000000,160*1(a2) ; 32
	or.l #%11100000000000000101111000000000,160*2(a2) ; 32
	or.l #%01000100000000001011101000000000,160*3(a2) ; 32
	or.l #%00001100000000001111001000000000,160*4(a2) ; 32
	or.l #%00011100000000001110001000000000,160*5(a2) ; 32
	or.l #%00111000000000001100010000000000,160*6(a2) ; 32
	move.b  #%01111000,d1 ; 8
	or.b d1,+2(a2) ; 16
	or.b d1,160*7+2(a2) ; 16
	rts ; 16

