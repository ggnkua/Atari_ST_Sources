BACK	=	$001	; Background
BRDR	=	$012	; Border

palette1:	dc.w $000,BACK,$520,$650,BRDR,$640,$540,$530,$410,$770,$420,$200,$310,$300,$760,$775

	dc.w $000,$000,$410,$540,$001,$530,$430,$420,$300,$660,$310,$100,$200,$200,$650,$664
	dc.w $000,$000,$300,$430,$000,$420,$320,$310,$200,$550,$200,$000,$100,$100,$540,$553
	dc.w $000,$000,$200,$320,$000,$310,$210,$200,$100,$440,$100,$000,$000,$000,$430,$442
	dc.w $000,$000,$100,$210,$000,$200,$100,$100,$000,$330,$000,$000,$000,$000,$320,$331
	dc.w $000,$000,$000,$100,$000,$100,$000,$000,$000,$220,$000,$000,$000,$000,$210,$220
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$110,$000,$000,$000,$000,$100,$110
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000

paltitle:	dc.w $000,$000,$120,$445,$231,$201,$102,$213,$312,$666,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$010,$334,$120,$100,$001,$102,$201,$555,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$223,$010,$000,$000,$001,$100,$444,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$112,$000,$000,$000,$000,$000,$333,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$001,$000,$000,$000,$000,$000,$222,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$111,$000,$000,$000,$000,$000,$000
	dc.w $000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000

;palette2: dc.w $000,BACK,$410,$530,BRDR,$530,$430,$420,$400,$650,$410,$200,$300,$300,$640,$664
;palette3: dc.w $000,BACK,$400,$530,BRDR,$520,$420,$410,$400,$640,$410,$201,$300,$301,$630,$664
;palette4: dc.w $000,BACK,$400,$520,BRDR,$510,$410,$400,$401,$630,$400,$201,$300,$301,$620,$654
;palette5: dc.w $000,BACK,$401,$510,BRDR,$500,$410,$400,$401,$620,$401,$201,$301,$302,$610,$654
