	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 42
	dc.w 39
	dc.w 35
	dc.w 32
	dc.w 29
	dc.w 26
	dc.w 23
	dc.w 20
	dc.w 17
	dc.w 15
	dc.w 12
	dc.w 10
	dc.w 8
	dc.w 6
	dc.w 5
	dc.w 3
	dc.w 2
	dc.w 1
	dc.w 1
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
