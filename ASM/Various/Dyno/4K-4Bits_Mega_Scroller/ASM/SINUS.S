; Based on 32 bytes sinus table generator
; by ray//.tSCc.
; http://s390174849.online.de/ray.tscc.de/code.htm#singen

;@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@
 SECTION TEXT
;@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@

;#====================#
;# Generate sinus LUT #
;#====================#

gen_sine:	moveq	#11,d7
	lea	sinus(pc),a0
	move.w	#512-1,d0
.gen:	move.w	d0,d1		; Approximate the sinus curve
	subi.w	#256,d1		; using a parabolic graph
	muls.w	d1,d1
	subi.l	#$10000,d1		; -sin d0 ~ (d0 - 1) ^ 2 - 1
	asr.l	d7,d1
	sub.w	d1,(a0)+		; 1st & 2nd quadrant
	dbra	d0,.gen

;@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@
 SECTION BSS
;@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@

; Current position in sinus table

pos_sine:	ds.w 1

; Half sinus LUT

sinus:	ds.w 512

;@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@
 SECTION TEXT
;@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@
