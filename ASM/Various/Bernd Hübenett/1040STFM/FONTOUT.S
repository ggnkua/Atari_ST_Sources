cnecin    equ 8
logbase   equ 3
super     equ 32
vsync     equ 37

start:    pea       0
          move.w    #super,-(sp)
          trap      #1
          addq.l    #6,sp
          move.l    d0,ssp
          move.w    #logbase,-(sp)
          trap      #14
          addq.l    #2,sp
          move.l    d0,oldscr
          movea.l   d0,a0
          move.w    #7999,d1
clear:    move.l    #0,(a0)+
          dbf       d1,clear
          movem.l   $ff8240,d0-d7
          movem.l   d0-d7,farbtab
          move.w    #vsync,-(sp)
          trap      #14
          addq.l    #2,sp
          move.b    $ff8260,res
          move.b    $ff820a,mode
          move.b    #0,$ff8260
          move.b    #2,$ff820a
          move.w    #$0000,$ff8240
          move.w    #$0700,$ff8242

          move.l    oldscr,d0
          movea.l   #null,a0
          movea.l   d0,a2
          move.l    #17,d3    ; anzahl der zeichen /2-1
lop:      move.w    #1,d2
loop:     movea.l   a2,a1
          move.w    #8,d1
looop:    move.b    (a0),(a1)
          move.b    3(a0),3(a1)
          move.b    5(a0),5(a1)
          move.b    7(a0),7(a1)
          adda.l    #4,a0
          adda.l    #160,a1
          dbf       d1,looop
          adda.l    #1,a2
          dbf       d2,loop
          adda.l    #6,a2
          dbf       d3,lop

          move.w    #cnecin,-(sp)
          trap      #1
          addq.l    #2,sp
          move.w    #vsync,-(sp)
          trap      #14
          addq.l    #2,sp
          move.b    res,$ff8260
          move.b    mode,$ff820a
          movem.l   farbtab,d0-d7
          movem.l   d0-d7,$ff8240
          clr.w     -(sp)
          trap      #1

          .DATA 
null:     .DC.b $18,$00,$00,$00,$24,$00,$00,$00
          .DC.b $42,$00,$00,$00,$46,$00,$00,$00
          .DC.b $4a,$00,$00,$00,$52,$00,$00,$00
          .DC.b $62,$00,$00,$00,$24,$00,$00,$00
          .DC.b $18,$00,$00,$00
eins:     .DC.b $18,$00,$00,$00,$08,$00,$00,$00
          .DC.b $08,$00,$00,$00,$08,$00,$00,$00
          .DC.b $08,$00,$00,$00,$08,$00,$00,$00
          .DC.b $08,$00,$00,$00,$08,$00,$00,$00
          .DC.b $1c,$00,$00,$00
zwei:     .DC.b $38,$00,$00,$00,$44,$00,$00,$00
          .DC.b $44,$00,$00,$00,$04,$00,$00,$00
          .DC.b $08,$00,$00,$00,$10,$00,$00,$00
          .DC.b $24,$00,$00,$00,$44,$00,$00,$00
          .DC.b $7c,$00,$00,$00
drei:     .DC.b $38,$00,$00,$00,$44,$00,$00,$00
          .DC.b $04,$00,$00,$00,$18,$00,$00,$00
          .DC.b $04,$00,$00,$00,$04,$00,$00,$00
          .DC.b $44,$00,$00,$00,$44,$00,$00,$00
          .DC.b $38,$00,$00,$00
vier:     .DC.b $08,$00,$00,$00,$18,$00,$00,$00
          .DC.b $28,$00,$00,$00,$28,$00,$00,$00
          .DC.b $48,$00,$00,$00,$7e,$00,$00,$00
          .DC.b $08,$00,$00,$00,$08,$00,$00,$00
          .DC.b $1c,$00,$00,$00
fuenf:    .DC.b $3c,$00,$00,$00,$24,$00,$00,$00
          .DC.b $40,$00,$00,$00,$78,$00,$00,$00
          .DC.b $04,$00,$00,$00,$04,$00,$00,$00
          .DC.b $04,$00,$00,$00,$44,$00,$00,$00
          .DC.b $38,$00,$00,$00
sechs:    .DC.b $10,$00,$00,$00,$20,$00,$00,$00
          .DC.b $40,$00,$00,$00,$78,$00,$00,$00
          .DC.b $44,$00,$00,$00,$44,$00,$00,$00
          .DC.b $44,$00,$00,$00,$44,$00,$00,$00
          .DC.b $38,$00,$00,$00
sieben:   .DC.b $7c,$00,$00,$00,$44,$00,$00,$00
          .DC.b $08,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $38,$00,$00,$00
acht:     .DC.b $38,$00,$00,$00,$44,$00,$00,$00
          .DC.b $44,$00,$00,$00,$38,$00,$00,$00
          .DC.b $44,$00,$00,$00,$44,$00,$00,$00
          .DC.b $44,$00,$00,$00,$44,$00,$00,$00
          .DC.b $38,$00,$00,$00
neun:     .DC.b $38,$00,$00,$00,$44,$00,$00,$00
          .DC.b $44,$00,$00,$00,$44,$00,$00,$00
          .DC.b $44,$00,$00,$00,$3c,$00,$00,$00
          .DC.b $04,$00,$00,$00,$08,$00,$00,$00
          .DC.b $10,$00,$00,$00
A:        .DC.b $3c,$00,$00,$00,$18,$00,$00,$00
          .DC.b $18,$00,$00,$00,$24,$00,$00,$00
          .DC.b $24,$00,$00,$00,$3c,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $66,$00,$00,$00
B:        .DC.b $78,$00,$00,$00,$24,$00,$00,$00
          .DC.b $24,$00,$00,$00,$24,$00,$00,$00
          .DC.b $38,$00,$00,$00,$24,$00,$00,$00
          .DC.b $24,$00,$00,$00,$24,$00,$00,$00
          .DC.b $78,$00,$00,$00
C:        .DC.b $1a,$00,$00,$00,$26,$00,$00,$00
          .DC.b $42,$00,$00,$00,$40,$00,$00,$00
          .DC.b $40,$00,$00,$00,$40,$00,$00,$00
          .DC.b $40,$00,$00,$00,$22,$00,$00,$00
          .DC.b $1c,$00,$00,$00
D:        .DC.b $7c,$00,$00,$00,$22,$00,$00,$00
          .DC.b $22,$00,$00,$00,$22,$00,$00,$00
          .DC.b $22,$00,$00,$00,$22,$00,$00,$00
          .DC.b $22,$00,$00,$00,$22,$00,$00,$00
          .DC.b $7c,$00,$00,$00
E:        .DC.b $7c,$00,$00,$00,$24,$00,$00,$00
          .DC.b $20,$00,$00,$00,$28,$00,$00,$00
          .DC.b $38,$00,$00,$00,$28,$00,$00,$00
          .DC.b $20,$00,$00,$00,$24,$00,$00,$00
          .DC.b $7c,$00,$00,$00
F:        .DC.b $7c,$00,$00,$00,$24,$00,$00,$00
          .DC.b $20,$00,$00,$00,$28,$00,$00,$00
          .DC.b $38,$00,$00,$00,$28,$00,$00,$00
          .DC.b $20,$00,$00,$00,$20,$00,$00,$00
          .DC.b $70,$00,$00,$00
G:        .DC.b $1a,$00,$00,$00,$26,$00,$00,$00
          .DC.b $40,$00,$00,$00,$40,$00,$00,$00
          .DC.b $4e,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$24,$00,$00,$00
          .DC.b $18,$00,$00,$00
H:        .DC.b $66,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $7e,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $66,$00,$00,$00
I:        .DC.b $38,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $38,$00,$00,$00
J:        .DC.b $18,$00,$00,$00,$08,$00,$00,$00
          .DC.b $08,$00,$00,$00,$08,$00,$00,$00
          .DC.b $08,$00,$00,$00,$08,$00,$00,$00
          .DC.b $08,$00,$00,$00,$08,$00,$00,$00
          .DC.b $30,$00,$00,$00
K:        .DC.b $76,$00,$00,$00,$24,$00,$00,$00
          .DC.b $28,$00,$00,$00,$30,$00,$00,$00
          .DC.b $30,$00,$00,$00,$28,$00,$00,$00
          .DC.b $28,$00,$00,$00,$24,$00,$00,$00
          .DC.b $76,$00,$00,$00
L:        .DC.b $70,$00,$00,$00,$20,$00,$00,$00
          .DC.b $20,$00,$00,$00,$20,$00,$00,$00
          .DC.b $20,$00,$00,$00,$20,$00,$00,$00
          .DC.b $24,$00,$00,$00,$24,$00,$00,$00
          .DC.b $7c,$00,$00,$00
M:        .DC.b $c3,$00,$00,$00,$c3,$00,$00,$00
          .DC.b $c3,$00,$00,$00,$c3,$00,$00,$00
          .DC.b $a5,$00,$00,$00,$a5,$00,$00,$00
          .DC.b $a5,$00,$00,$00,$99,$00,$00,$00
          .DC.b $db,$00,$00,$00
N:        .DC.b $66,$00,$00,$00,$32,$00,$00,$00
          .DC.b $32,$00,$00,$00,$2a,$00,$00,$00
          .DC.b $2a,$00,$00,$00,$2a,$00,$00,$00
          .DC.b $26,$00,$00,$00,$26,$00,$00,$00
          .DC.b $72,$00,$00,$00
O:        .DC.b $18,$00,$00,$00,$24,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$24,$00,$00,$00
          .DC.b $18,$00,$00,$00
P:        .DC.b $78,$00,$00,$00,$24,$00,$00,$00
          .DC.b $24,$00,$00,$00,$24,$00,$00,$00
          .DC.b $38,$00,$00,$00,$20,$00,$00,$00
          .DC.b $20,$00,$00,$00,$20,$00,$00,$00
          .DC.b $70,$00,$00,$00
Q:        .DC.b $18,$00,$00,$00,$24,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$24,$00,$00,$00
          .DC.b $18,$00,$00,$00,$18,$00,$00,$00
          .DC.b $0c,$00,$00,$00
R:        .DC.b $78,$00,$00,$00,$24,$00,$00,$00
          .DC.b $24,$00,$00,$00,$24,$00,$00,$00
          .DC.b $38,$00,$00,$00,$28,$00,$00,$00
          .DC.b $28,$00,$00,$00,$24,$00,$00,$00
          .DC.b $76,$00,$00,$00
S:        .DC.b $14,$00,$00,$00,$2c,$00,$00,$00
          .DC.b $20,$00,$00,$00,$20,$00,$00,$00
          .DC.b $18,$00,$00,$00,$04,$00,$00,$00
          .DC.b $04,$00,$00,$00,$34,$00,$00,$00
          .DC.b $28,$00,$00,$00
T:        .DC.b $7c,$00,$00,$00,$54,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $38,$00,$00,$00
U:        .DC.b $66,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $3c,$00,$00,$00
V:        .DC.b $66,$00,$00,$00,$42,$00,$00,$00
          .DC.b $42,$00,$00,$00,$42,$00,$00,$00
          .DC.b $24,$00,$00,$00,$24,$00,$00,$00
          .DC.b $24,$00,$00,$00,$18,$00,$00,$00
          .DC.b $18,$00,$00,$00
W:        .DC.b $6b,$00,$00,$00,$49,$00,$00,$00
          .DC.b $49,$00,$00,$00,$55,$00,$00,$00
          .DC.b $55,$00,$00,$00,$55,$00,$00,$00
          .DC.b $55,$00,$00,$00,$22,$00,$00,$00
          .DC.b $22,$00,$00,$00
X:        .DC.b $6c,$00,$00,$00,$44,$00,$00,$00
          .DC.b $28,$00,$00,$00,$28,$00,$00,$00
          .DC.b $10,$00,$00,$00,$28,$00,$00,$00
          .DC.b $28,$00,$00,$00,$44,$00,$00,$00
          .DC.b $6c,$00,$00,$00
Y:        .DC.b $6c,$00,$00,$00,$44,$00,$00,$00
          .DC.b $28,$00,$00,$00,$28,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $10,$00,$00,$00,$10,$00,$00,$00
          .DC.b $38,$00,$00,$00
Z:        .DC.b $7c,$00,$00,$00,$44,$00,$00,$00
          .DC.b $44,$00,$00,$00,$08,$00,$00,$00
          .DC.b $10,$00,$00,$00,$20,$00,$00,$00
          .DC.b $44,$00,$00,$00,$44,$00,$00,$00
          .DC.b $7c,$00,$00,$00
          .BSS 
ssp:      .DS.l 1
oldscr:   .DS.l 1
farbtab:  .DS.l 8
res:      .DS.b 1
mode:     .DS.b 1
          .END 



