          ; 16 Pixel Font
          ; Hoehe 17 Zeilen

cnecin    equ 8
logbase   equ 3
super     equ 32
vsync     equ 37

start:    pea       0
          move.w    #super,-(sp)
          trap      #1
          addq.l    #6,sp
          move.l    d0,ssp
          move.w    #logbase,-(sp)
          trap      #14
          addq.l    #2,sp
          move.l    d0,oldscr
          movea.l   d0,a0
          move.w    #7999,d1
clear:    move.l    #0,(a0)+
          dbf       d1,clear
          movem.l   $ff8240,d0-d7
          movem.l   d0-d7,farbtab
          move.w    #vsync,-(sp)
          trap      #14
          addq.l    #2,sp
          move.b    $ff8260,res
          move.b    $ff820a,mode
          move.b    #0,$ff8260
          move.b    #2,$ff820a
          move.w    #$0000,$ff8240
          move.w    #$0700,$ff8242

          move.l    oldscr,d0
          movea.l   #null,a0

          move.w    #9,d2
looop:    movea.l   d0,a2
          move.w    #16,d1
loop:     move.l    (a0),(a2)
          move.l    4(a0),4(a2)
          adda.l    #8,a0
          adda.l    #160,a2
          dbf       d1,loop
          addi.l    #8,d0
          dbf       d2,looop

          movea.l   oldscr,a0
          move.w    #200,d5
scr_2:    move.l    #0,d2
          move.w    #16,d4
scr_1:    move.l    d2,d0
          move.w    #19,d3
scroll:   move.w    8(a0,d0.w),d1
          swap.w    d1
          move.w    0(a0,d0.w),d1
          rol.l     #1,d1
          move.w    d1,0(a0,d0.w)
          addi.w    #8,d0
          dbf       d3,scroll
          addi.l    #160,d2
          dbf       d4,scr_1
          dbf       d5,scr_2

          move.w    #cnecin,-(sp)
          trap      #1
          addq.l    #2,sp
          move.w    #vsync,-(sp)
          trap      #14
          addq.l    #2,sp
          move.b    res,$ff8260
          move.b    mode,$ff820a
          movem.l   farbtab,d0-d7
          movem.l   d0-d7,$ff8240
          clr.w     -(sp)
          trap      #1


          .DATA 
farbpal:  .DC.w $0000,$0700,$0730,$0750,$0770,$0470,$0070,$0075
          .DC.w $0077,$0057,$0027,$0007,$0507,$0707,$0704,$0777

null:     .DC.w $0600,$0000,$0000,$0000,$1f80,$0000,$0000,$0000
          .DC.w $3fc0,$0000,$0000,$0000,$59e0,$0000,$0000,$0000
          .DC.w $fe70,$0000,$0000,$0000,$b9b0,$0000,$0000,$0000
          .DC.w $b0b0,$0000,$0000,$0000,$b0b0,$0000,$0000,$0000
          .DC.w $b0b0,$0000,$0000,$0000,$b0b0,$0000,$0000,$0000
          .DC.w $b170,$0000,$0000,$0000,$baf0,$0000,$0000,$0000
          .DC.w $bff0,$0000,$0000,$0000,$5fe0,$0000,$0000,$0000
          .DC.w $2640,$0000,$0000,$0000,$1980,$0000,$0000,$0000
          .DC.w $0600,$0000,$0000,$0000
eins:     .DC.w $1e00,$0000,$0000,$0000,$2f00,$0000,$0000,$0000
          .DC.w $3f00,$0000,$0000,$0000,$3300,$0000,$0000,$0000
          .DC.w $1b00,$0000,$0000,$0000,$0b00,$0000,$0000,$0000
          .DC.w $0b00,$0000,$0000,$0000,$0b00,$0000,$0000,$0000
          .DC.w $0b00,$0000,$0000,$0000,$0b00,$0000,$0000,$0000
          .DC.w $0b00,$0000,$0000,$0000,$0b00,$0000,$0000,$0000
          .DC.w $0b00,$0000,$0000,$0000,$0b00,$0000,$0000,$0000
          .DC.w $0b00,$0000,$0000,$0000,$0900,$0000,$0000,$0000
          .DC.w $0600,$0000,$0000,$0000
zwei:     .DC.w $0c00,$0000,$0000,$0000,$3f00,$0000,$0000,$0000
          .DC.w $7f80,$0000,$0000,$0000,$b380,$0000,$0000,$0000
          .DC.w $fdc0,$0000,$0000,$0000,$92c0,$0000,$0000,$0000
          .DC.w $62c0,$0000,$0000,$0000,$05c0,$0000,$0000,$0000
          .DC.w $0b80,$0000,$0000,$0000,$1700,$0000,$0000,$0000
          .DC.w $2e00,$0000,$0000,$0000,$5c00,$0000,$0000,$0000
          .DC.w $b800,$0000,$0000,$0000,$bf80,$0000,$0000,$0000
          .DC.w $bf40,$0000,$0000,$0000,$9040,$0000,$0000,$0000
          .DC.w $7f80,$0000,$0000,$0000
drei:     .DC.w $0c00,$0000,$0000,$0000,$3f00,$0000,$0000,$0000
          .DC.w $7f80,$0000,$0000,$0000,$b3c0,$0000,$0000,$0000
          .DC.w $fdc0,$0000,$0000,$0000,$93c0,$0000,$0000,$0000
          .DC.w $65c0,$0000,$0000,$0000,$0f80,$0000,$0000,$0000
          .DC.w $0a80,$0000,$0000,$0000,$0b40,$0000,$0000,$0000
          .DC.w $65c0,$0000,$0000,$0000,$b2c0,$0000,$0000,$0000
          .DC.w $bdc0,$0000,$0000,$0000,$bfc0,$0000,$0000,$0000
          .DC.w $9d80,$0000,$0000,$0000,$6300,$0000,$0000,$0000
          .DC.w $1c00,$0000,$0000,$0000
vier:     .DC.w $00c0,$0000,$0000,$0000,$0160,$0000,$0000,$0000
          .DC.w $03e0,$0000,$0000,$0000,$05e0,$0000,$0000,$0000
          .DC.w $0b60,$0000,$0000,$0000,$1760,$0000,$0000,$0000
          .DC.w $2f60,$0000,$0000,$0000,$5d60,$0000,$0000,$0000
          .DC.w $5970,$0000,$0000,$0000,$bff8,$0000,$0000,$0000
          .DC.w $bfe8,$0000,$0000,$0000,$a0c8,$0000,$0000,$0000
          .DC.w $7f70,$0000,$0000,$0000,$0160,$0000,$0000,$0000
          .DC.w $0160,$0000,$0000,$0000,$0120,$0000,$0000,$0000
          .DC.w $00c0,$0000,$0000,$0000
fuenf:    .DC.w $1f80,$0000,$0000,$0000,$2fc0,$0000,$0000,$0000
          .DC.w $3f40,$0000,$0000,$0000,$2840,$0000,$0000,$0000
          .DC.w $2f80,$0000,$0000,$0000,$2800,$0000,$0000,$0000
          .DC.w $2f00,$0000,$0000,$0000,$2f80,$0000,$0000,$0000
          .DC.w $2b80,$0000,$0000,$0000,$1dc0,$0000,$0000,$0000
          .DC.w $02c0,$0000,$0000,$0000,$72c0,$0000,$0000,$0000
          .DC.w $fdc0,$0000,$0000,$0000,$bfc0,$0000,$0000,$0000
          .DC.w $9f80,$0000,$0000,$0000,$6300,$0000,$0000,$0000
          .DC.w $1c00,$0000,$0000,$0000
sechs:    .DC.w $0c00,$0000,$0000,$0000,$1600,$0000,$0000,$0000
          .DC.w $1e00,$0000,$0000,$0000,$2c00,$0000,$0000,$0000
          .DC.w $2c00,$0000,$0000,$0000,$5800,$0000,$0000,$0000
          .DC.w $5e00,$0000,$0000,$0000,$5f00,$0000,$0000,$0000
          .DC.w $b380,$0000,$0000,$0000,$bdc0,$0000,$0000,$0000
          .DC.w $b2c0,$0000,$0000,$0000,$b2c0,$0000,$0000,$0000
          .DC.w $bcc0,$0000,$0000,$0000,$bfc0,$0000,$0000,$0000
          .DC.w $9f80,$0000,$0000,$0000,$6300,$0000,$0000,$0000
          .DC.w $1c00,$0000,$0000,$0000
sieben:   .DC.w $7f80,$0000,$0000,$0000,$bfc0,$0000,$0000,$0000
          .DC.w $ffc0,$0000,$0000,$0000,$83c0,$0000,$0000,$0000
          .DC.w $7dc0,$0000,$0000,$0000,$0580,$0000,$0000,$0000
          .DC.w $0580,$0000,$0000,$0000,$0b00,$0000,$0000,$0000
          .DC.w $0b00,$0000,$0000,$0000,$0b00,$0000,$0000,$0000
          .DC.w $1600,$0000,$0000,$0000,$1600,$0000,$0000,$0000
          .DC.w $1600,$0000,$0000,$0000,$2c00,$0000,$0000,$0000
          .DC.w $2c00,$0000,$0000,$0000,$2400,$0000,$0000,$0000
          .DC.w $1800,$0000,$0000,$0000
acht:     .DC.w $1e00,$0000,$0000,$0000,$2f00,$0000,$0000,$0000
          .DC.w $5380,$0000,$0000,$0000,$5d80,$0000,$0000,$0000
          .DC.w $5580,$0000,$0000,$0000,$5580,$0000,$0000,$0000
          .DC.w $5f80,$0000,$0000,$0000,$2f00,$0000,$0000,$0000
          .DC.w $5380,$0000,$0000,$0000,$bdc0,$0000,$0000,$0000
          .DC.w $b2c0,$0000,$0000,$0000,$b2c0,$0000,$0000,$0000
          .DC.w $bdc0,$0000,$0000,$0000,$bfc0,$0000,$0000,$0000
          .DC.w $9fc0,$0000,$0000,$0000,$6180,$0000,$0000,$0000
          .DC.w $1e00,$0000,$0000,$0000
neun:     .DC.w $0e00,$0000,$0000,$0000,$3f80,$0000,$0000,$0000
          .DC.w $5fc0,$0000,$0000,$0000,$73c0,$0000,$0000,$0000
          .DC.w $adc0,$0000,$0000,$0000,$b2c0,$0000,$0000,$0000
          .DC.w $b2c0,$0000,$0000,$0000,$bdc0,$0000,$0000,$0000
          .DC.w $5fc0,$0000,$0000,$0000,$2780,$0000,$0000,$0000
          .DC.w $1f80,$0000,$0000,$0000,$0b80,$0000,$0000,$0000
          .DC.w $0b00,$0000,$0000,$0000,$1700,$0000,$0000,$0000
          .DC.w $1600,$0000,$0000,$0000,$1200,$0000,$0000,$0000
          .DC.w $0c00,$0000,$0000,$0000

          .BSS 
ssp:      .DS.l 1
oldscr:   .DS.l 1
farbtab:  .DS.l 8
res:      .DS.b 1
mode:     .DS.b 1
          .END 




