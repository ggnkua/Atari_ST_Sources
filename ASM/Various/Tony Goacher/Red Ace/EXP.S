
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0200,$0000,$0200,$0000,$0000,$0000,$0000,$0000
	DC.W $0020,$0000,$0020,$0000,$0000,$0000,$0000,$0000
	DC.W $0100,$0100,$0100,$0000,$0380,$0000,$0000,$0280
	DC.W $0380,$0100,$0100,$0300,$0700,$0400,$0000,$0300
	DC.W $0280,$0200,$0200,$0080,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0200,$0000,$0200,$0000,$0000,$0000,$0000,$0000
	DC.W $4220,$0880,$0220,$4000,$0540,$1550,$0000,$0000
	DC.W $0BA0,$0280,$0820,$0100,$2FF0,$0C20,$2010,$02C0
	DC.W $0BC0,$0100,$0900,$0340,$07F0,$0460,$0010,$0380
	DC.W $0FC0,$0B00,$04C0,$0000,$1100,$0220,$1100,$0000
	DC.W $0090,$0000,$0090,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0800,$0000,$0000
	DC.W $1248,$0000,$1208,$0040,$49F0,$0820,$01D0,$4000
	DC.W $1074,$0780,$1074,$0000,$97F8,$0FE0,$8008,$1010
	DC.W $5FEC,$0A30,$500C,$0180,$0FF6,$3C34,$0002,$0240
	DC.W $2FE4,$5998,$2184,$05A0,$1FF0,$0428,$1000,$0A50
	DC.W $37D8,$19B0,$2008,$0640,$38A8,$0758,$3800,$00A0
	DC.W $2E04,$05C0,$0A04,$2000,$0C42,$0000,$0C42,$0000
	DC.W $0800,$0000,$0800,$0000,$0000,$0000,$0000,$0000

	DC.W $00A5,$0042,$00A5,$0000,$5FEA,$2004,$5BEA,$0400
	DC.W $36B6,$1968,$2696,$0000,$6AFE,$1F5C,$6020,$0082
	DC.W $6FFE,$37F4,$400A,$0800,$CFFC,$7808,$8004,$07B0
	DC.W $7FFC,$3014,$0008,$4E60,$7FF6,$1208,$6206,$0B50
	DC.W $DFF3,$319E,$4181,$85A0,$4FFF,$3009,$4006,$0D70
	DC.W $FFF9,$5054,$A001,$0EA8,$FBE6,$273C,$C002,$18C0
	DC.W $74DC,$1BF8,$4404,$2000,$6F6E,$36D4,$492A,$0000
	DC.W $5672,$6000,$1672,$0000,$C820,$C020,$0800,$0000

