
	DC.W $03C0,$03C0,$03C0,$0000,$0F70,$0DB0,$0E70,$0000

	DC.W $1D78,$1388,$1E78,$0660,$1F78,$17C8,$1E38,$0E70

	DC.W $3F7C,$2FC4,$363C,$0E70,$397C,$2F84,$367C,$0E70

	DC.W $1BF8,$1788,$1C78,$0FF0,$1FF8,$1208,$1DF8,$07E0

	DC.W $0FF0,$0C30,$0FF0,$0000,$03C0,$03C0,$03C0,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0420,$0420,$0420,$0000,$0E70,$0E70,$0A50,$0000

	DC.W $1DB8,$17E8,$1998,$0000,$1FF8,$17C8,$19B8,$0C30

	DC.W $3E7C,$2FC4,$303C,$0C30,$3FFC,$2F84,$347C,$0E70

	DC.W $1BF8,$1788,$1C78,$0FF0,$1FF8,$1208,$1DF8,$07E0

	DC.W $0FF0,$0C30,$0FF0,$0000,$03C0,$03C0,$03C0,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0C30,$0C30,$0C30,$0000

	DC.W $1A58,$1E78,$1248,$0000,$1DB8,$17E8,$1998,$0810

	DC.W $3E7C,$2FC4,$303C,$0C30,$3DFC,$2F84,$367C,$0E70

	DC.W $1BF8,$1788,$1C78,$0FF0,$1FF8,$1208,$1DF8,$07E0

	DC.W $0FF0,$0C30,$0FF0,$0000,$03C0,$03C0,$03C0,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $1818,$1818,$1818,$0000,$366C,$3E7C,$2664,$0000

	DC.W $3DBC,$2FF4,$318C,$0000,$3FFC,$2FC4,$303C,$0C00

	DC.W $1BF8,$1788,$1C78,$0FF0,$1FF8,$1208,$1DF8,$07E0

	DC.W $0FF0,$0C30,$0FF0,$0000,$03C0,$03C0,$03C0,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

