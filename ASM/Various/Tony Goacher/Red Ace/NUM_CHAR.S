	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FBFB,$FFFF,$0000,$C3C3
	DC.W $C5C5,$FFFF,$0000,$8181,$DDDD,$FFFF,$0000,$9999
	DC.W $DDDD,$FFFF,$0000,$9999,$DDDD,$FFFF,$0000,$9999
	DC.W $DDDD,$FFFF,$0000,$9999,$DDDD,$FFFF,$0000,$9999
	DC.W $B9B9,$FFFF,$0000,$8181,$C3C3,$FFFF,$0000,$C3C3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$F7F7,$FFFF,$0000,$E7E7
	DC.W $F7F7,$FFFF,$0000,$C7C7,$D7D7,$FFFF,$0000,$C7C7
	DC.W $F7F7,$FFFF,$0000,$E7E7,$F7F7,$FFFF,$0000,$E7E7
	DC.W $F7F7,$FFFF,$0000,$E7E7,$F7F7,$FFFF,$0000,$E7E7
	DC.W $FBFB,$FFFF,$0000,$C3C3,$C3C3,$FFFF,$0000,$C3C3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FBFB,$FFFF,$0000,$C3C3
	DC.W $C5C5,$FFFF,$0000,$8181,$9D9D,$FFFF,$0000,$9999
	DC.W $F9F9,$FFFF,$0000,$F1F1,$F3F3,$FFFF,$0000,$E3E3
	DC.W $E7E7,$FFFF,$0000,$C7C7,$CFCF,$FFFF,$0000,$8F8F
	DC.W $FDFD,$FFFF,$0000,$8181,$8181,$FFFF,$0000,$8181
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FBFB,$FFFF,$0000,$8383
	DC.W $8585,$FFFF,$0000,$8181,$FDFD,$FFFF,$0000,$F9F9
	DC.W $FBFB,$FFFF,$0000,$C3C3,$C5C5,$FFFF,$0000,$C1C1
	DC.W $FDFD,$FFFF,$0000,$F9F9,$FDFD,$FFFF,$0000,$F9F9
	DC.W $F9F9,$FFFF,$0000,$8181,$8383,$FFFF,$0000,$8383
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$DFDF,$FFFF,$0000,$9F9F
	DC.W $DFDF,$FFFF,$0000,$9F9F,$DFDF,$FFFF,$0000,$9F9F
	DC.W $DBDB,$FFFF,$0000,$9393,$DBDB,$FFFF,$0000,$9393
	DC.W $FDFD,$FFFF,$0000,$8181,$8989,$FFFF,$0000,$8181
	DC.W $FBFB,$FFFF,$0000,$F3F3,$F3F3,$FFFF,$0000,$F3F3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FDFD,$FFFF,$0000,$8181
	DC.W $C1C1,$FFFF,$0000,$8181,$DFDF,$FFFF,$0000,$9F9F
	DC.W $FBFB,$FFFF,$0000,$8383,$8585,$FFFF,$0000,$8181
	DC.W $FDFD,$FFFF,$0000,$F9F9,$DDDD,$FFFF,$0000,$9999
	DC.W $B9B9,$FFFF,$0000,$8181,$C3C3,$FFFF,$0000,$C3C3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FBFB,$FFFF,$0000,$C3C3
	DC.W $C3C3,$FFFF,$0000,$8383,$DFDF,$FFFF,$0000,$9F9F
	DC.W $FBFB,$FFFF,$0000,$8383,$C5C5,$FFFF,$0000,$8181
	DC.W $DDDD,$FFFF,$0000,$9999,$DDDD,$FFFF,$0000,$9999
	DC.W $B9B9,$FFFF,$0000,$8181,$C3C3,$FFFF,$0000,$C3C3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FDFD,$FFFF,$0000,$8181
	DC.W $C5C5,$FFFF,$0000,$8181,$9D9D,$FFFF,$0000,$9999
	DC.W $F9FB,$FFFF,$0000,$F1F3,$FBFB,$FFFF,$0000,$F3F3
	DC.W $F3F7,$FFFF,$0000,$E3E7,$F7F7,$FFFF,$0000,$E7E7
	DC.W $F7F7,$FFFF,$0000,$E7E7,$E7E7,$FFFF,$0000,$E7E7
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FBFB,$FFFF,$0000,$C3C3
	DC.W $C5C5,$FFFF,$0000,$8181,$DDDD,$FFFF,$0000,$9999
	DC.W $FBFB,$FFFF,$0000,$C3C3,$C5C5,$FFFF,$0000,$8181
	DC.W $DDDD,$FFFF,$0000,$9999,$DDDD,$FFFF,$0000,$9999
	DC.W $B9B9,$FFFF,$0000,$8181,$C3C3,$FFFF,$0000,$C3C3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FBFB,$FFFF,$0000,$C3C3
	DC.W $C5C5,$FFFF,$0000,$8181,$DDDD,$FFFF,$0000,$9999
	DC.W $DDDD,$FFFF,$0000,$9999,$BDBD,$FFFF,$0000,$8181
	DC.W $C5C5,$FFFF,$0000,$C1C1,$FDFD,$FFFF,$0000,$B9B9
	DC.W $B9B9,$FFFF,$0000,$8181,$C3C3,$FFFF,$0000,$C3C3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
