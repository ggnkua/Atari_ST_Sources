        DC.W $FFDF,$FEFF,$FFFF,$FF3F,$8BE0,$FCBF,$F7FF,$FE7F
        DC.W $BFC0,$E97F,$F7FF,$FCFF,$BF80,$C2FF,$FFFF,$E9FF
        DC.W $9F00,$E5FF,$FFFF,$F3FF,$BD83,$C9FF,$FC7C,$E5FF
        DC.W $FFC3,$91FF,$FE3C,$CFFF,$F7F3,$20BF,$F74C,$97FF
        DC.W $F3FB,$D53F,$F6C4,$37FF,$E9FB,$BA0F,$F3F4,$7BFF
        DC.W $CFFB,$7C6F,$F394,$FEFF,$93FF,$FE88,$EDF7,$FE18
        DC.W $81FD,$FE82,$FFFF,$FE0F,$81FF,$FE70,$FFFF,$FF03
        DC.W $81EF,$FE38,$FFEF,$FF00,$8FEE,$FF3F,$F0E2,$FF80
       
        DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
        DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF,$FFFF
        DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
        DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FF3F,$FF5F,$0360,$FF7F,$C363,$FF5F,$3E3C,$FF7F
        DC.W $BD7D,$FE13,$436E,$FE7F,$BF76,$C003,$7F75,$FE77
        DC.W $FF66,$0001,$FF67,$E803,$EE07,$0001,$EE06,$0003
        DC.W $000F,$11E0,$000F,$0003,$E3DF,$FFE0,$E01F,$2001
       
        DC.W $FFFF,$FEFF,$FB7E,$FCFF,$07FF,$FD7E,$FFA1,$FC7E
        DC.W $03FF,$FEB8,$FFDF,$FE3A,$01FF,$FF54,$FFEF,$FF32
        DC.W $23FB,$DE2C,$FDF7,$DF9E,$E3FF,$DD14,$3EFB,$DFCE
        DC.W $EBFF,$D628,$3DDF,$DF66,$EBFF,$DC04,$37FF,$DEE2
        DC.W $EF7F,$D8EB,$379F,$DDE8,$FEE7,$D9DC,$273F,$DFDE
        DC.W $E7C3,$8BBC,$6C7F,$CFBE,$FF83,$077C,$F8FF,$3F7E
        DC.W $FF03,$9EFC,$61FF,$DEFE,$F603,$8DFC,$7BFF,$FDFE
        DC.W $F807,$C7F8,$3FFF,$EFFA,$FFFF,$07F8,$F807,$EFFA
       
        DC.W $FFF7,$DF9B,$E071,$DFC4,$3177,$DF9C,$EEF0,$DFC3
        DC.W $EEF3,$D106,$3FF0,$D9E1,$FBF9,$0603,$FDF8,$D780
        DC.W $F1FD,$0265,$FF9C,$0300,$D1DC,$E220,$3FDC,$E300
        DC.W $F3F8,$EF00,$1CF8,$FFC0,$E7E5,$FC02,$1BE4,$FFC1
        DC.W $EFFC,$F802,$17FC,$FC00,$FFF9,$D000,$2FF9,$FBE0
        DC.W $FFEF,$C187,$3E68,$F380,$FEF8,$C383,$3D78,$FFC0
        DC.W $F171,$DF83,$2EF0,$FFE0,$EFFC,$F001,$1FFC,$FFF0
        DC.W $FFF8,$F002,$0FF8,$F690,$FFFC,$0000,$FFFC,$0440
       
        DC.W $CFCF,$FCF8,$C00F,$0300,$DFF3,$F072,$0003,$0C80
        DC.W $EFE2,$026E,$0202,$E280,$F2E3,$128F,$0201,$A202
        DC.W $FFF0,$8B17,$0000,$5040,$5FF9,$F00B,$7001,$7650
        DC.W $7FFC,$8205,$0200,$4348,$9FFE,$7603,$0600,$8EEC
        DC.W $DFFC,$1007,$8000,$4BA8,$7DFB,$480F,$0003,$10B0
        DC.W $FBFB,$040E,$0403,$EF90,$FCFB,$078E,$8003,$7850
        DC.W $F87D,$5CC7,$0001,$A038,$E1BD,$F8BF,$0181,$0000
        DC.W $47D1,$F0FF,$07C1,$0000,$0FEF,$A82E,$0FEF,$0000
       
        DC.W $FFFF,$4FFF,$F007,$DFFF,$9F18,$01FF,$9EE7,$0FFF
        DC.W $3FDB,$002F,$3FF4,$19FF,$FEAF,$0154,$FFFB,$17FF
        DC.W $3F7F,$01E0,$3E9F,$0794,$3E5F,$83E7,$3D98,$0F97
        DC.W $FF9F,$81EF,$FE70,$0FEF,$7FFF,$C06F,$7F90,$01FF
        DC.W $A1FF,$8027,$A1D8,$006F,$D9FF,$000B,$D9F4,$00EF
        DC.W $FFFF,$011B,$FEE4,$619F,$7FFF,$007B,$7F84,$7FFF
        DC.W $FF1F,$1FFB,$E0E4,$7FFF,$CFFF,$3003,$FFFC,$7FFF
        DC.W $FFFF,$301F,$CFE0,$F01F,$FFFF,$0000,$FFFF,$2000
       
        DC.W $8FFE,$FC60,$F39E,$FFF8,$8FFD,$FFE0,$F01D,$FFE8
        DC.W $8FFF,$F000,$FFFF,$F00E,$8053,$FFEE,$FFFD,$FFEF
        DC.W $40BF,$FFF6,$FFC9,$FFF7,$E17F,$7FF4,$BF8B,$FFF6
        DC.W $E2F3,$BFEE,$DF1D,$7FEF,$FDE3,$D7DF,$EE3C,$37DF
        DC.W $FFC3,$ABBF,$F47C,$9BBF,$FF83,$957F,$FAFC,$CD7F
        DC.W $BF03,$CAFF,$FDFC,$E6FF,$9F03,$E5FF,$FEFD,$F3FF
        DC.W $BFC3,$E2FD,$FF3F,$E9FD,$BFFE,$D93F,$F7C1,$CCFF
        DC.W $BFFF,$C081,$FFFE,$FE7F,$FFFF,$80C0,$FFFF,$8001
       
        DC.W $0FF7,$0030,$0FF7,$0380,$F7F7,$0A01,$FFF6,$0803
        DC.W $FF1F,$0410,$FB0F,$0415,$FC3F,$120D,$EE32,$DE1F
        DC.W $FE7F,$0E07,$F078,$5E37,$DEFF,$3003,$EEFC,$B0E3
        DC.W $FF7F,$8003,$7F7C,$C903,$FEFF,$0037,$FEC8,$BEF7
        DC.W $FFFF,$BC7F,$4380,$FEFF,$0FE0,$F85F,$F7BF,$FEFF
        DC.W $FFFF,$FC7F,$0380,$FFFF,$FFFF,$FEFF,$FFFF,$FFFF
        DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$0000
       
        DC.W $F7FF,$4FF8,$B807,$6FFA,$F7FF,$0FF8,$F807,$3FFA
        DC.W $F3FF,$0C00,$FFFF,$6C02,$FE07,$01FC,$FFFB,$BDFE
        DC.W $EF07,$16FC,$F9FB,$DEFE,$FF87,$E77C,$18FB,$FF7E
        DC.W $E7CF,$D9B9,$3E77,$DFBC,$E3FF,$D5D3,$362F,$D7D8
        DC.W $E9FF,$D3E4,$3A1F,$DBF2,$E3FF,$DE48,$3FBF,$DDE6
        DC.W $E0FF,$DE94,$3E7B,$DECE,$E1FB,$DF2C,$BEF7,$DF9E
        DC.W $E3FF,$DE58,$BDEF,$DF3A,$7F6F,$BC34,$C35F,$FE72
        DC.W $FFFF,$8100,$7FFF,$BCFE,$FFFF,$0300,$FFFF,$8000
       
        DC.W $FFFF,$5BFE,$FE5F,$DFBE,$FBD0,$04AE,$FFFE,$863E
        DC.W $FFC0,$BB3E,$FFFE,$807E,$F7A1,$3E5E,$E7FF,$80FF
        DC.W $EDE8,$8F57,$E1FF,$C03F,$F4FF,$93E2,$F0FD,$C40D
        DC.W $F33F,$98F1,$F03F,$C200,$FBAF,$AF5A,$F80D,$80A2
        DC.W $FDEF,$4E7F,$FC07,$0100,$CDFD,$B726,$FC04,$3098
        DC.W $9EFC,$679F,$FE00,$7040,$8EFF,$FB83,$FE00,$F06C
        DC.W $877F,$F9D0,$FF10,$F837,$87BF,$B3C4,$B784,$B035
        DC.W $9BFF,$FDC2,$FFC2,$E43B,$8F3F,$9DE3,$9703,$981B
       
        DC.W $FFFF,$FC4F,$FFFF,$F96F,$1FC0,$E13F,$FFFF,$E03F
        DC.W $FFFF,$D39B,$2EE4,$F83F,$FFFF,$03C9,$FEFE,$E837
        DC.W $FFFF,$03A0,$FC5F,$3005,$FFFF,$02D7,$FCFD,$110A
        DC.W $FBF8,$EEC7,$BA7F,$0107,$F3FF,$EFC0,$707F,$0005
        DC.W $FBFF,$CD31,$284E,$9281,$F3EF,$0E78,$006F,$F080
        DC.W $6780,$BC7F,$4000,$0280,$473C,$FDFF,$0100,$0300
        DC.W $C7FF,$F847,$0001,$06B8,$FFFF,$3906,$0100,$C549
        DC.W $FFFD,$000A,$0000,$F864,$FFBF,$0343,$0303,$3B3F
       
        DC.W $FFFF,$FAFE,$FFFF,$F9FF,$038F,$FD70,$FFFF,$FC7E
        DC.W $09FF,$FE88,$F7FF,$FE3A,$00FF,$DF04,$DFFF,$DF22
        DC.W $73FF,$DF10,$ACFF,$DF86,$EBFF,$DCE4,$37FB,$DE0E
        DC.W $EF3F,$59E8,$B73F,$FC06,$EE7F,$D3C4,$3E7F,$D812
        DC.W $F87F,$CF8B,$7877,$A038,$E9F7,$3F1C,$E1EB,$005C
        DC.W $EBF7,$EE2C,$43DB,$80FE,$FBC7,$FE7C,$0BBB,$00FE
        DC.W $F7C7,$9CBC,$177B,$40FE,$F7C7,$18BC,$077B,$41FE
        DC.W $EF07,$B9FC,$8EFB,$C3FE,$CFFF,$38FC,$0F03,$C3FE
       
        DC.W $FEDF,$D5F5,$EEC1,$D009,$377F,$D9FA,$EF00,$D804
        DC.W $FE77,$DBEC,$3E00,$C012,$FFFF,$01C0,$FF00,$D033
        DC.W $FEFF,$13C8,$FE88,$002C,$FEFF,$87C1,$7E01,$C029
        DC.W $FBFF,$1F61,$F801,$8099,$CFFF,$781A,$801A,$06BA
        DC.W $F7FF,$3F02,$F002,$80E7,$FC7F,$7FE1,$FC01,$0011
        DC.W $FFFE,$0BE3,$FFC0,$0018,$FFBF,$93F0,$6F80,$F00F
        DC.W $BF9E,$C17F,$7F80,$E000,$CFC1,$F7FE,$3BC0,$F801
        DC.W $FFFB,$F3FD,$0FF8,$F002,$FFF3,$00FC,$FFE0,$0002
       
        DC.W $FFFF,$8102,$8102,$917E,$FFDF,$6B25,$6B05,$6B05
        DC.W $EFFF,$F9B9,$E9B8,$E9B8,$FFFF,$3020,$3020,$3024
        DC.W $FFFF,$5A50,$5A50,$5A52,$FFFF,$9138,$9138,$B13D
        DC.W $FFFF,$B4BE,$B4BE,$B4BE,$FFFD,$91B3,$91B0,$91B0
        DC.W $FFFF,$3A2A,$3A2A,$3A2D,$FFFF,$0088,$0080,$8080
        DC.W $FFFF,$6920,$6920,$69AE,$7FFF,$9380,$1200,$5231
        DC.W $FF7F,$6898,$6818,$FF53,$FFFF,$48A8,$48A0,$DF47
        DC.W $FF3F,$8743,$8000,$B034,$7F7F,$21F3,$0041,$580C
       
        DC.W $E3FF,$7DBF,$4247,$C1FF,$7518,$9BFF,$06E7,$63FF
        DC.W $C7DB,$3A2F,$07F4,$C07F,$F1EF,$CF10,$01FF,$3013
        DC.W $DFFF,$6FF0,$039F,$1000,$F87F,$07FA,$0005,$7800
        DC.W $FFE3,$807E,$8003,$9780,$FF5F,$03FF,$005F,$FC00
        DC.W $F97F,$1F70,$017F,$E00F,$EEFF,$7F12,$0EFD,$8007
        DC.W $87FF,$7B03,$07FC,$801F,$DFFF,$780B,$1FF4,$807F
        DC.W $DFDF,$F83B,$1FE4,$007F,$BFFF,$FC03,$3FFC,$03FF
        DC.W $47FF,$B81F,$07E0,$401F,$7FFF,$B800,$1FFF,$4000
       
        DC.W $8FFF,$FC38,$F3F8,$FC05,$8FFE,$FEB9,$F170,$FE86
        DC.W $8FED,$F07B,$FFE0,$F004,$87DD,$FCF7,$FB81,$FE08
        DC.W $A7B3,$FCFF,$DB83,$FC00,$CF67,$39DF,$F707,$7C20
        DC.W $FEDF,$93F8,$EE1F,$3800,$F86F,$43E0,$F86F,$1002
        DC.W $F0FF,$A782,$F0FD,$803B,$E3BF,$CF00,$A3BF,$C00F
        DC.W $E367,$8018,$E37F,$C03F,$FEDB,$B467,$FEBD,$C0FF
        DC.W $FFA3,$A2FD,$FF5F,$E8FD,$FFFE,$9D7F,$F381,$CC7F
        DC.W $FFFF,$8081,$FFFE,$FE3F,$7FFF,$80C0,$FFFF,$8001
       
        DC.W $AEDE,$71F9,$2040,$8E02,$7BCF,$FFDD,$3140,$0002
        DC.W $FC63,$F71E,$F800,$0061,$AFB5,$CFCF,$8D84,$2030
        DC.W $ED5F,$7977,$8D0F,$0000,$5FFF,$BC73,$57EF,$0800
        DC.W $FFFF,$723D,$BDE7,$0000,$FFFF,$0638,$FFEF,$7081
        DC.W $FFFF,$3024,$CFFB,$7C44,$C79C,$3873,$FFFF,$FCE3
        DC.W $FFFF,$F945,$06BA,$FFEF,$FFFF,$FEFF,$D7FF,$FEFF
        DC.W $4968,$BFFF,$F697,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$0000
       
        DC.W $FFFF,$E818,$FFE7,$007A,$FFFF,$C008,$7FF7,$037A
        DC.W $FFFF,$E000,$7FFF,$0002,$BFFF,$619C,$1E63,$89FE
        DC.W $FFFF,$E30C,$3CF3,$0FBE,$5FFF,$F208,$1DF7,$031E
        DC.W $AFFF,$E419,$8BE7,$073C,$FFFF,$3A73,$ED8F,$03F8
        DC.W $EFFF,$2DE4,$E61F,$01F2,$FEFF,$1D48,$FFBF,$41E6
        DC.W $FF7F,$C094,$3FFB,$D0CE,$E7FB,$DE2C,$BFF7,$D81E
        DC.W $E3FF,$9C48,$FFFF,$9F3A,$7FEF,$F894,$87FF,$FE72
        DC.W $FFFF,$8100,$7FFF,$FCFE,$FFFF,$0300,$FFFF,$8000
       
        DC.W $FFDF,$FEFF,$FFFF,$FF3F,$8BE0,$FCBF,$F7FF,$FE7F
        DC.W $BFC0,$E97F,$F7FF,$FCFF,$BF80,$C2FF,$FFFF,$E9FF
        DC.W $9F00,$E5FF,$FFFF,$F3FF,$BD83,$C9FF,$FC7C,$E5FF
        DC.W $FFC3,$91FF,$FE3C,$CFFF,$F7F3,$20BF,$F74C,$97FF
        DC.W $F3FB,$D53F,$F6C4,$37FF,$E9FB,$BA0F,$F3F4,$7BFF
        DC.W $CFFB,$7C6F,$F394,$FEFF,$93FF,$FE88,$EDF7,$FE18
        DC.W $81FD,$FE82,$FFFF,$FE0F,$81FF,$FE70,$FFFF,$FF03
        DC.W $81EF,$FE38,$FFEF,$FF00,$8FEE,$FF3F,$F0E2,$FF80
       
        DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
        DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF,$FFFF
        DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FF7F,$0080,$FFFF
        DC.W $C5D0,$7A2F,$BFFF,$FBFF,$FFFF,$1807,$E7F8,$FE5F
        DC.W $FFFF,$601F,$9FE0,$FC3F,$FFEB,$C217,$3FFC,$F017
        DC.W $FF7F,$8380,$7F7F,$E013,$FF77,$0F40,$FD77,$C010
        DC.W $DEBF,$3FFC,$FCBF,$2000,$F7EB,$5FFF,$B5EB,$0000
        DC.W $FBFF,$FFFF,$F997,$0000,$F8BF,$FFCF,$788D,$0030
       
        DC.W $FFFF,$FEFF,$FB7E,$FCFF,$07E3,$FD7E,$FFBD,$FC7E
        DC.W $03FF,$FEB8,$FFDF,$FE3A,$01FF,$FF54,$FFEF,$FF12
        DC.W $23FB,$DE2C,$FDF7,$DF9E,$E3FF,$DD14,$3EFB,$DFCE
        DC.W $EBFF,$D628,$3DDF,$DF66,$EBFF,$DC04,$37FF,$DEE2
        DC.W $EF7F,$D8EB,$379F,$DDE8,$FEE7,$D9DC,$273F,$DFDE
        DC.W $E7C3,$8BBC,$6C7F,$CFBE,$FF83,$017C,$FEFF,$3F7E
        DC.W $FF03,$84FC,$7FFF,$C0FE,$F703,$38FC,$F7FF,$01FE
        DC.W $CE07,$F9F8,$CFFF,$03FA,$2FFF,$FBF8,$0C07,$03FA
       
        DC.W $FFF7,$D11C,$EEF0,$DF83,$33F3,$DD1E,$EEF0,$DF41
        DC.W $EFFB,$D10E,$3EF8,$DB41,$FBF6,$061F,$FDF6,$D680
        DC.W $F1FC,$02BF,$FF7C,$0380,$D5E3,$E73E,$3AE0,$E700
        DC.W $F7FF,$E870,$1FE0,$FE0F,$FFD7,$E06D,$1FC0,$F892
        DC.W $FFAF,$A3FD,$5F80,$F00A,$FF6F,$07FE,$FC00,$E001
        DC.W $BFC7,$C5FE,$7FC0,$D001,$FFDB,$80FE,$7F90,$F001
        DC.W $BFDB,$D0FE,$6FD8,$FE01,$DFFB,$E03F,$3FE0,$FE00
        DC.W $FFFD,$FE3F,$01EC,$FF00,$FFF8,$011F,$FEF8,$1F00
       
        DC.W $FD7C,$A7B3,$2020,$484C,$FEF1,$412F,$0000,$9E10
        DC.W $FFD8,$0A67,$0240,$B258,$CFCC,$B3F7,$0300,$4308
        DC.W $FFF6,$B009,$2000,$2C74,$FFE7,$6F18,$4F00,$5F43
        DC.W $FFFF,$D040,$1040,$134D,$FFFF,$0C68,$0C68,$EE6D
        DC.W $FFFF,$0C10,$0C10,$8D3D,$BFFF,$6601,$2600,$B6EA
        DC.W $7FF9,$F2F7,$72F0,$7AF8,$FFFF,$6020,$6020,$7D3F
        DC.W $EDFF,$3200,$2000,$ACFE,$EFF7,$1068,$0000,$C394
        DC.W $FE7F,$8FA1,$0001,$7019,$F71F,$FFEC,$0000,$0012
       
        DC.W $FFFF,$E3FF,$3C07,$07FF,$FD18,$72FF,$7FE7,$86FF
        DC.W $BFDB,$702F,$3FF4,$88FF,$1EAF,$F954,$1FFB,$03FF
        DC.W $1F7F,$F8A0,$1F9F,$03D4,$CFDF,$7867,$0F98,$8117
        DC.W $DFFF,$7E07,$1BF8,$807F,$8FFF,$7F87,$0FF8,$804F
        DC.W $CFFF,$FDC0,$01FF,$0200,$8FFF,$7FC3,$0FFC,$8007
        DC.W $1FFF,$FC03,$1FFC,$001F,$DFFF,$B01B,$1FE4,$01FF
        DC.W $BF9F,$F1FB,$3E64,$01FF,$1FFF,$F003,$1FFC,$01FF
        DC.W $CFFF,$780F,$0FF0,$801F,$EFFF,$3800,$0FFF,$C000
       
        DC.W $9FF3,$F10F,$EEF0,$F3C0,$9FF7,$E39C,$FC70,$FFC1
        DC.W $9FF7,$FC1A,$E3F2,$FC46,$80FF,$FF19,$FFF0,$FFC2
        DC.W $80ED,$FF37,$FFE1,$FFC8,$C2F7,$3C1F,$FEE7,$7EC0
        DC.W $E3FF,$9C20,$FFFF,$3FC0,$F1FF,$4A03,$FBFC,$1B9F
        DC.W $FBFF,$A700,$FCFF,$8FF8,$BF9F,$D360,$FCFF,$C770
        DC.W $9F1F,$E8F0,$FFEF,$E2FA,$8F0F,$F4FF,$FFF1,$F1FF
        DC.W $B783,$EA7D,$FFFF,$E8FD,$B7FE,$D93F,$FFC1,$CC7F
        DC.W $FFFF,$C081,$BFFE,$FE3F,$FFFF,$80C0,$FFFF,$8001
       
        DC.W $7FF7,$FF9C,$0000,$0061,$80E7,$FFFF,$0020,$0000
        DC.W $FC70,$7F7F,$3C30,$8000,$3F7B,$FBFF,$3F7B,$0000
        DC.W $FF7F,$C9E4,$FF7F,$0000,$FFFF,$1000,$EFFF,$1093
        DC.W $FF7F,$0000,$FF7F,$AD3A,$FEFF,$8801,$76FE,$BEFF
        DC.W $FEFF,$FC39,$02C6,$FEFF,$8380,$FC7F,$7FFF,$FEFF
        DC.W $FFFF,$FC7F,$0380,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
        DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$0000
       
        DC.W $FFFF,$38F8,$0F07,$C3FA,$EFFF,$F9F8,$0E07,$03FA
        DC.W $3FFF,$F000,$3FFF,$0602,$FE07,$E1FC,$FFFB,$0DFE
        DC.W $FF07,$06FC,$F9FB,$1EFE,$FF87,$077C,$F8FB,$FF7E
        DC.W $E7CF,$D9B9,$3E77,$DFBC,$E3FF,$D5D3,$362F,$D7D8
        DC.W $E9FF,$D3E4,$3A1F,$DBF2,$E3FF,$DE48,$3FBF,$DDE6
        DC.W $E0FF,$DE94,$3E7B,$DECE,$E1FB,$DF2C,$BEF7,$DF9E
        DC.W $E3FF,$DE58,$BDEF,$DF3A,$7F6F,$BC34,$C35F,$FE72
        DC.W $FFFF,$8100,$7FFF,$BCFE,$FFFF,$0300,$FFFF,$8000
       
        DC.W $FFDF,$FEFF,$FFFF,$FF3F,$8BE0,$FCBF,$F7FF,$FE7F
        DC.W $BFC0,$E97F,$F7FF,$FCFF,$BF80,$C2FF,$FFFF,$E9FF
        DC.W $9F00,$E5FF,$FFFF,$F3FF,$BD83,$C9FF,$FC7C,$E5FF
        DC.W $FFC3,$91FF,$FE3C,$CFFF,$F7F3,$20BF,$F74C,$97FF
        DC.W $F3FB,$D53F,$F6C4,$37FF,$E9FB,$BA0F,$F3F4,$7BFF
        DC.W $CFFB,$7C6F,$F394,$FEFF,$93FF,$FE88,$EDF7,$FE18
        DC.W $81FD,$FE82,$FFFF,$FE0F,$81FF,$FE70,$FFFF,$FF03
        DC.W $81EF,$FE38,$FFEF,$FF00,$8FEE,$FF3F,$F0E2,$FF80
       
        DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
        DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF,$FFFF
        DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
        DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FF3F,$FF5F,$0360,$FF7F,$C363,$FF5F,$3E3C,$FF7F
        DC.W $BD7D,$FE13,$436E,$FE7F,$BF76,$C003,$7F75,$FE77
        DC.W $FF66,$0001,$FF67,$E803,$EE07,$0001,$EE06,$0003
        DC.W $000F,$11E0,$000F,$0003,$E3DF,$FFE0,$E01F,$2001
       
        DC.W $FFFF,$FEFF,$FB7E,$FCFF,$07FF,$FD7E,$FFA1,$FC7E
        DC.W $03FF,$FEB8,$FFDF,$FE3A,$01FF,$FF54,$FFEF,$FF32
        DC.W $23FB,$DE2C,$FDF7,$DF9E,$E3FF,$DD14,$3EFB,$DFCE
        DC.W $EBFF,$D628,$3DDF,$DF66,$EBFF,$DC04,$37FF,$DEE2
        DC.W $EF7F,$D8EB,$379F,$DDE8,$FEE7,$D9DC,$273F,$DFDE
        DC.W $E7C3,$8BBC,$6C7F,$CFBE,$FF83,$077C,$F8FF,$3F7E
        DC.W $FF03,$9EFC,$61FF,$DEFE,$F603,$8DFC,$7BFF,$FDFE
        DC.W $F807,$C7F8,$3FFF,$EFFA,$FFFF,$07F8,$F807,$EFFA
       
        DC.W $FFF7,$DF9B,$E071,$DFC4,$3177,$DF9C,$EEF0,$DFC3
        DC.W $EEF3,$D106,$3FF0,$D9E1,$FBF9,$0603,$FDF8,$D780
        DC.W $F1FD,$0265,$FF9C,$0300,$D1DC,$E220,$3FDC,$E300
        DC.W $F3F8,$EF00,$1CF8,$FFC0,$E7E5,$FC02,$1BE4,$FFC1
        DC.W $EFFC,$F802,$17FC,$FC00,$FFF9,$D000,$2FF9,$FBE0
        DC.W $FFEF,$C187,$3E68,$F380,$FEF8,$C383,$3D78,$FFC0
        DC.W $F171,$DF83,$2EF0,$FFE0,$EFFC,$F001,$1FFC,$FFF0
        DC.W $FFF8,$F002,$0FF8,$F690,$FFFC,$0000,$FFFC,$0440
       
        DC.W $CFCF,$FCF8,$C00F,$0300,$DFF3,$F072,$0003,$0C80
        DC.W $EFE2,$026E,$0202,$E280,$F2E3,$128F,$0201,$A202
        DC.W $FFF0,$8B17,$0000,$5040,$5FF9,$F00B,$7001,$7650
        DC.W $7FFC,$8205,$0200,$4348,$9FFE,$7603,$0600,$8EEC
        DC.W $DFFC,$1007,$8000,$4BA8,$7DFB,$480F,$0003,$10B0
        DC.W $FBFB,$040E,$0403,$EF90,$FCFB,$078E,$8003,$7850
        DC.W $F87D,$5CC7,$0001,$A038,$E1BD,$F8BF,$0181,$0000
        DC.W $47D1,$F0FF,$07C1,$0000,$0FEF,$A82E,$0FEF,$0000
       
        DC.W $FFFF,$4FFF,$F007,$DFFF,$9F18,$01FF,$9EE7,$0FFF
        DC.W $3FDB,$002F,$3FF4,$19FF,$FEAF,$0154,$FFFB,$17FF
        DC.W $3F7F,$01E0,$3E9F,$0794,$3E5F,$83E7,$3D98,$0F97
        DC.W $FF9F,$81EF,$FE70,$0FEF,$7FFF,$C06F,$7F90,$01FF
        DC.W $A1FF,$8027,$A1D8,$006F,$D9FF,$000B,$D9F4,$00EF
        DC.W $FFFF,$011B,$FEE4,$619F,$7FFF,$007B,$7F84,$7FFF
        DC.W $FF1F,$1FFB,$E0E4,$7FFF,$CFFF,$3003,$FFFC,$7FFF
        DC.W $FFFF,$301F,$CFE0,$F01F,$FFFF,$0000,$FFFF,$2000
       
        DC.W $8FFE,$FC60,$F39E,$FFF8,$8FFD,$FFE0,$F01D,$FFE8
        DC.W $8FFF,$F000,$FFFF,$F00E,$8053,$FFEE,$FFFD,$FFEF
        DC.W $40BF,$FFF6,$FFC9,$FFF7,$E17F,$7FF4,$BF8B,$FFF6
        DC.W $E2F3,$BFEE,$DF1D,$7FEF,$FDE3,$D7DF,$EE3C,$37DF
        DC.W $FFC3,$ABBF,$F47C,$9BBF,$FF83,$957F,$FAFC,$CD7F
        DC.W $BF03,$CAFF,$FDFC,$E6FF,$9F03,$E5FF,$FEFD,$F3FF
        DC.W $BFC3,$E2FD,$FF3F,$E9FD,$BFFE,$D93F,$F7C1,$CCFF
        DC.W $BFFF,$C081,$FFFE,$FE7F,$FFFF,$80C0,$FFFF,$8001
       
        DC.W $0FF7,$0030,$0FF7,$0380,$F7F7,$0A01,$FFF6,$0803
        DC.W $FF1F,$0410,$FB0F,$0415,$FC3F,$120D,$EE32,$DE1F
        DC.W $FE7F,$0E07,$F078,$5E37,$DEFF,$3003,$EEFC,$B0E3
        DC.W $FF7F,$8003,$7F7C,$C903,$FEFF,$0037,$FEC8,$BEF7
        DC.W $FFFF,$BC7F,$4380,$FEFF,$0FE0,$F85F,$F7BF,$FEFF
        DC.W $FFFF,$FC7F,$0380,$FFFF,$FFFF,$FEFF,$FFFF,$FFFF
        DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$0000
       
        DC.W $F7FF,$4FF8,$B807,$6FFA,$F7FF,$0FF8,$F807,$3FFA
        DC.W $F3FF,$0C00,$FFFF,$6C02,$FE07,$01FC,$FFFB,$BDFE
        DC.W $EF07,$16FC,$F9FB,$DEFE,$FF87,$E77C,$18FB,$FF7E
        DC.W $E7CF,$D9B9,$3E77,$DFBC,$E3FF,$D5D3,$362F,$D7D8
        DC.W $E9FF,$D3E4,$3A1F,$DBF2,$E3FF,$DE48,$3FBF,$DDE6
        DC.W $E0FF,$DE94,$3E7B,$DECE,$E1FB,$DF2C,$BEF7,$DF9E
        DC.W $E3FF,$DE58,$BDEF,$DF3A,$7F6F,$BC34,$C35F,$FE72
        DC.W $FFFF,$8100,$7FFF,$BCFE,$FFFF,$0300,$FFFF,$8000
       
        DC.W $FFDF,$FEFF,$FFFF,$FF3F,$8BE0,$FCBF,$F7FF,$FE7F
        DC.W $BFC0,$E97F,$F7FF,$FCFF,$BF80,$C2FF,$FFFF,$E9FF
        DC.W $9F00,$E5FF,$FFFF,$F3FF,$BD83,$C9FF,$FC7C,$E5FF
        DC.W $FFC3,$91FF,$FE3C,$CFFF,$F7F3,$20BF,$F74C,$97FF
        DC.W $F3FB,$D53F,$F6C4,$37FF,$E9FB,$BA0F,$F3F4,$7BFF
        DC.W $CFFB,$7C6F,$F394,$FEFF,$93FF,$FE88,$EDF7,$FE18
        DC.W $81FD,$FE02,$FFFF,$FE0F,$81FF,$FE30,$FFFF,$FF03
        DC.W $81FF,$FE18,$FFFF,$FF00,$8FFF,$FF0F,$F0FF,$FF80
       
        DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
        DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF,$FFFF
        DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
        DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FF3F,$FF5F,$0360,$FF7F,$C363,$FF5F,$3E3C,$FF7F
        DC.W $BD7D,$FF5F,$4222,$FF7F,$BF76,$C007,$7F71,$FF77
        DC.W $0F66,$FF63,$FF65,$FF63,$7B65,$8002,$FB67,$FB03
        DC.W $FB0C,$4007,$BB0B,$C007,$39D7,$F91E,$F8CF,$F91F
       
        DC.W $FFFF,$FEFF,$FB7E,$FCFF,$07FF,$FD7E,$FFA1,$FC7E
        DC.W $03FF,$FEB8,$FFDF,$FE3A,$01FF,$FF54,$FFEF,$FF32
        DC.W $23FB,$DE2C,$FDF7,$DF9E,$E3FF,$DD14,$3EFB,$DFCE
        DC.W $EBFF,$D628,$3DDF,$DF66,$EBFF,$DC04,$37FF,$DEE2
        DC.W $EF7F,$D8EB,$379F,$DDE8,$FEE7,$D9DC,$273F,$DFDE
        DC.W $E7C3,$8BBC,$6C7F,$CFBE,$FF83,$077C,$F8FF,$3F7E
        DC.W $FF03,$9EFC,$61FF,$DEFE,$F603,$8DFC,$7BFF,$FDFE
        DC.W $F807,$C7F8,$3FFF,$EFFA,$FFFF,$07F8,$F807,$EFFA
       
        DC.W $FFFD,$DFCC,$E035,$DFFC,$312A,$DFFE,$EED6,$DFFE
        DC.W $EECF,$D13F,$3FFF,$D9FF,$FABF,$0740,$FDFF,$D7C0
        DC.W $F07F,$03E7,$FF9F,$0390,$D05F,$E3E6,$3F99,$E396
        DC.W $F299,$EF68,$1DF1,$FFE8,$E6A1,$FF60,$19C1,$FFE0
        DC.W $CEB3,$FB6E,$35DF,$FFEE,$AEF9,$D308,$7DF1,$FBE8
        DC.W $BEE0,$D300,$6DE0,$F380,$BEFE,$DF7A,$6184,$FFFE
        DC.W $B010,$DFF0,$6FE0,$FFF0,$CFF4,$F00C,$3FFC,$FFFC
        DC.W $FFFC,$F01F,$0FE3,$F01F,$FFFF,$0000,$FFFF,$0002
       
        DC.W $FA9F,$0200,$F89F,$0200,$0681,$0602,$0083,$0602
        DC.W $0F08,$0208,$0D00,$0208,$020F,$0007,$0208,$000F
        DC.W $8207,$8000,$8207,$0001,$E000,$E003,$E003,$E003
        DC.W $0003,$C003,$C002,$C003,$E009,$C00E,$600F,$C00E
        DC.W $C007,$0002,$C005,$0007,$8007,$0004,$8007,$0000
        DC.W $040B,$040E,$040F,$040C,$8017,$021D,$821B,$021C
        DC.W $070F,$0418,$0717,$0619,$8F9F,$8890,$8F8F,$8C13
        DC.W $4FCF,$3184,$7FCB,$3C47,$2FEF,$0800,$2FEF,$00E4
       
        DC.W $FFFF,$DFFF,$E007,$DFFF,$1118,$9FFF,$8EE7,$9FFF
        DC.W $2EDB,$112F,$3FF4,$19FF,$FAAF,$0754,$FDFB,$D7FF
        DC.W $307F,$03E0,$3F9F,$0394,$105F,$A3E7,$BF98,$A397
        DC.W $F29F,$6F6F,$9DF0,$7FEF,$E6BF,$3F6F,$D9D0,$FFFF
        DC.W $E0BF,$0067,$E0D8,$C0EF,$D0FF,$010B,$D1F4,$81EF
        DC.W $BEFF,$531B,$EDE4,$F39F,$3EFF,$5F7B,$6184,$7FFF
        DC.W $B01F,$5FFB,$EFE4,$FFFF,$CFFF,$F003,$3FFC,$FFFF
        DC.W $FFFF,$301F,$CFE0,$F01F,$FFFF,$0000,$FFFF,$2000
       
        DC.W $8FFE,$FC60,$F39E,$FFF8,$8FFD,$FFE0,$F01D,$FFE8
        DC.W $8FFF,$F000,$FFFF,$F00E,$8053,$FFEE,$FFFD,$FFEF
        DC.W $40BF,$FFF6,$FFC9,$FFF7,$E17F,$7FF4,$BF8B,$FFF6
        DC.W $E2F3,$BFEE,$DF1D,$7FEF,$FDE3,$D7DF,$EE3C,$37DF
        DC.W $FFC3,$ABBF,$F47C,$9BBF,$FF83,$957F,$FAFC,$CD7F
        DC.W $BF03,$CAFF,$FDFC,$E6FF,$9F03,$E5FF,$FEFD,$F3FF
        DC.W $BFC3,$E2FD,$FF3F,$E9FD,$BFFE,$D93F,$F7C1,$CCFF
        DC.W $BFFF,$C081,$FFFE,$FE7F,$FFFF,$80C0,$FFFF,$8001
       
        DC.W $7FF7,$0030,$7FF7,$03C4,$DFF7,$0201,$DFF6,$5007
        DC.W $FF1F,$0418,$FB07,$8C1D,$FC3F,$D20D,$2E32,$DE1F
        DC.W $FE7F,$0E07,$F078,$5E37,$DEFF,$B003,$6EFC,$B0E3
        DC.W $FF7F,$8003,$7F7C,$C103,$FEFF,$B837,$46C8,$BEF7
        DC.W $FFFF,$FC7F,$0380,$FEFF,$07A0,$F85F,$FFFF,$FEFF
        DC.W $FFFF,$FC7F,$0380,$FFFF,$FFFF,$FEFF,$FFFF,$FFFF
        DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
        DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$0000
       
        DC.W $F7FF,$4FF8,$B807,$6FFA,$F7FF,$0FF8,$F807,$3FFA
        DC.W $F3FF,$0C00,$FFFF,$6C02,$FE07,$01FC,$FFFB,$BDFE
        DC.W $EF07,$16FC,$F9FB,$DEFE,$FF87,$E77C,$18FB,$FF7E
        DC.W $E7CF,$D9B9,$3E77,$DFBC,$E3FF,$D5D3,$362F,$D7D8
        DC.W $E9FF,$D3E4,$3A1F,$DBF2,$E3FF,$DE48,$3FBF,$DDE6
        DC.W $E0FF,$DE94,$3E7B,$DECE,$E1FB,$DF2C,$BEF7,$DF9E
        DC.W $E3FF,$DE58,$BDEF,$DF3A,$7F6F,$BC34,$C35F,$FE72
        DC.W $FFFF,$8100,$7FFF,$BCFE,$FFFF,$0300,$FFFF,$8000
       
        DC.W $97F8,$1E00,$99F8,$1F80,$0BF7,$0F00,$0CF7,$0FC0
        DC.W $8AC8,$0380,$8B48,$03C0,$72F0,$0380,$7370,$03C0
        DC.W $8AC8,$0382,$8B4A,$03C0,$03E7,$87C0,$8427,$07E0
        DC.W $80F8,$1FC0,$9F38,$1FF8,$047D,$7FE1,$7F9D,$3FFD
        DC.W $8E7C,$3FE0,$BF9C,$3FFC,$647F,$7FE0,$7F9F,$7FFE
        DC.W $A0FE,$7FE0,$FF1E,$3FFE,$71FE,$7FC8,$0E3E,$7FFE
        DC.W $BFF8,$3F85,$847D,$3FF8,$2FEF,$5F31,$71FF,$2FED
        DC.W $9DF9,$8201,$9FF9,$9DF9,$7FFC,$090E,$7FFE,$0FEC
       
        DC.W $8988,$0180,$8988,$0180,$0707,$0A00,$0F07,$0200
        DC.W $8C08,$0480,$8C88,$0400,$7C70,$0C00,$7C70,$0C00
        DC.W $AA88,$2200,$AA88,$2200,$0587,$0380,$0787,$0180
        DC.W $8088,$08C0,$88C8,$0080,$7070,$0140,$7170,$0040
        DC.W $88AC,$0024,$88AC,$0024,$0717,$0010,$0717,$0010
        DC.W $8A98,$0234,$8ABC,$0210,$7878,$0828,$7878,$0828
        DC.W $89C8,$11E0,$99E8,$01C0,$0707,$0284,$0787,$0204
        DC.W $8C88,$0C00,$8C88,$0C00,$7870,$0A00,$7A70,$0800
       
        DC.W $8988,$05E0,$8DE8,$0180,$0647,$0150,$0757,$0040
        DC.W $8828,$00A0,$88A8,$0020,$7070,$0028,$7078,$0020
        DC.W $88C8,$0050,$88D8,$0040,$0087,$07C0,$07C7,$0080
        DC.W $8988,$0120,$89A8,$0100,$7270,$0280,$72F0,$0200
        DC.W $8C88,$2600,$AE88,$0400,$0707,$0400,$0707,$0400
        DC.W $8C88,$0440,$8CC8,$0400,$7260,$1210,$7270,$1200
        DC.W $8988,$0180,$8988,$0180,$2743,$2044,$2747,$2040
        DC.W $88E8,$0070,$88F8,$0060,$71F0,$0180,$71F0,$0180
       
        DC.W $8988,$0180,$8988,$0180,$0707,$0A00,$0F07,$0200
        DC.W $8C08,$0480,$8C88,$0400,$7C70,$0C00,$7C70,$0C00
        DC.W $AA88,$2200,$AA88,$2200,$0587,$0380,$0787,$0180
        DC.W $8088,$08C0,$88C8,$0080,$7070,$0140,$7170,$0040
        DC.W $88AC,$0024,$88AC,$0024,$0717,$0010,$0717,$0010
        DC.W $8A98,$0234,$8ABC,$0210,$7878,$0828,$7878,$0828
        DC.W $89C8,$11E0,$99E8,$01C0,$0707,$0284,$0787,$0204
        DC.W $8C88,$0C00,$8C88,$0C00,$7870,$0A00,$7A70,$0800
       
        DC.W $97F8,$1E00,$99F8,$1F80,$0BF7,$0F00,$0CF7,$0FC0
        DC.W $8AC8,$0380,$8B48,$03C0,$72F0,$0380,$7370,$03C0
        DC.W $8AC8,$0380,$8B48,$03C0,$03E7,$07C0,$0427,$07E0
        DC.W $C0F8,$5FC0,$DF38,$5FF8,$447E,$3FE6,$7F9E,$3FFE
        DC.W $CE7C,$7FE0,$FFBC,$7FFC,$047F,$7FF0,$7F9F,$7FFE
        DC.W $80F6,$7FE8,$FF1E,$1FF6,$619E,$7FE0,$7F7E,$6B9E
        DC.W $B6FA,$BF86,$8B7E,$B6FA,$FEDF,$DF32,$F1FF,$FEDE
        DC.W $9BCA,$2C7F,$BFFF,$1BCA,$56E0,$2390,$77F0,$06E0
       
        DC.W $8988,$0180,$8988,$0180,$0747,$0050,$0757,$0040
        DC.W $88A8,$0120,$89A8,$0020,$7070,$0030,$7070,$0030
        DC.W $88CC,$0044,$88CC,$0044,$0787,$01C0,$07C7,$0180
        DC.W $8988,$0310,$8B98,$0100,$7270,$0280,$72F0,$0200
        DC.W $AC88,$2400,$AC88,$2400,$0F07,$0800,$0F07,$0800
        DC.W $88C8,$2C40,$ACC8,$0840,$7470,$1410,$7470,$1410
        DC.W $8B80,$0788,$8F88,$0380,$2647,$2140,$2747,$2040
        DC.W $88B8,$0030,$88B8,$0030,$7030,$0050,$7070,$0010
       
        DC.W $8988,$0180,$8988,$0180,$0707,$0A00,$0F07,$0200
        DC.W $8C08,$0480,$8C88,$0400,$7C70,$0C00,$7C70,$0C00
        DC.W $AA88,$2200,$AA88,$2200,$0587,$0380,$0787,$0180
        DC.W $8088,$08C0,$88C8,$0080,$7070,$0140,$7170,$0040
        DC.W $88AC,$0024,$88AC,$0024,$0717,$0010,$0717,$0010
        DC.W $8A98,$0234,$8ABC,$0210,$7878,$0828,$7878,$0828
        DC.W $89C8,$11E0,$99E8,$01C0,$0707,$0284,$0787,$0204
        DC.W $8C88,$0C00,$8C88,$0C00,$7870,$0A00,$7A70,$0800
       
        DC.W $8988,$0180,$8988,$0180,$0747,$0050,$0757,$0040
        DC.W $88A8,$0120,$89A8,$0020,$7070,$0030,$7070,$0030
        DC.W $88CC,$0044,$88CC,$0044,$0787,$01C0,$07C7,$0180
        DC.W $8988,$0310,$8B98,$0100,$7270,$0280,$72F0,$0200
        DC.W $AC88,$2400,$AC88,$2400,$0F07,$0800,$0F07,$0800
        DC.W $88C8,$2C40,$ACC8,$0840,$7470,$1410,$7470,$1410
        DC.W $8B80,$0788,$8F88,$0380,$2647,$2140,$2747,$2040
        DC.W $88B8,$0030,$88B8,$0030,$7030,$0050,$7070,$0010
       
        DC.W $BFFC,$7FFC,$C000,$0000,$1BFD,$0782,$1C7F,$0FF0
        DC.W $BFF8,$320C,$FDFD,$27E0,$7FF2,$0C3A,$7FFA,$0002
        DC.W $8BC8,$1340,$9BCC,$0000,$0107,$02A0,$27A7,$0000
        DC.W $8888,$0000,$88A8,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $8FF0,$3FFC,$8000,$0000,$981B,$87E4,$9FFF,$8FF0
        DC.W $9E78,$33C8,$BDB8,$07E0,$7FF0,$0C32,$7FF2,$0000
        DC.W $87C8,$2FC8,$AFC8,$0408,$0407,$0320,$0727,$0000
        DC.W $8888,$1040,$98C8,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $7FFE,$7FFE,$C002,$4002,$1BDF,$0FF0,$17EF,$0FF0
        DC.W $9C38,$57EA,$DBDA,$07E0,$7FF8,$2C3C,$7FFC,$2008
        DC.W $8BC8,$13D0,$BBF8,$0000,$0047,$0550,$2757,$0040
        DC.W $8808,$0100,$8988,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $87E0,$7FFC,$C000,$0000,$199D,$07E2,$1FFF,$0FF0
        DC.W $2E7C,$A3C4,$ADBC,$27E4,$7FF0,$0C34,$7FF4,$0000
        DC.W $83C8,$2BD0,$ABD8,$0000,$0607,$0180,$0787,$0000
        DC.W $8A88,$0660,$8EE8,$0200,$7070,$0200,$7270,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $7FFE,$7FFE,$C002,$4002,$1BDF,$0FF0,$17EF,$0FF0
        DC.W $CFFC,$F80E,$8006,$07B0,$FFFE,$B01E,$800A,$4E60
        DC.W $FFF6,$720E,$E206,$0B50,$DFF3,$719F,$4181,$85A0
        DC.W $CFFF,$700F,$C006,$0D70,$FFF9,$F055,$A001,$0EA8
        DC.W $FBE6,$E73E,$C002,$18C0,$74DF,$5FFC,$4407,$2000
        DC.W $EF6E,$7FFE,$C92A,$0000,$D672,$F672,$9672,$0000
        DC.W $E8A8,$E820,$2888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $7BFE,$77F6,$C006,$080A,$3FF7,$3D1E,$3807,$00C0
        DC.W $A7FB,$7E1B,$E001,$0120,$57F2,$7CCE,$50C2,$02D0
        DC.W $AFF8,$3A14,$B800,$0528,$1BEF,$1CDC,$3007,$0320
        DC.W $9C56,$1FAE,$9C02,$0050,$771E,$07FE,$651E,$1000
        DC.W $8EE9,$06E1,$8EE9,$0000,$0707,$0400,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $77F6,$7FFE,$F556,$4002,$1FFF,$0F78,$1E3F,$0080
        DC.W $9FF8,$5E1A,$D80A,$0160,$7FF8,$2E9C,$7E9C,$21A8
        DC.W $8FF8,$1638,$BC08,$01C0,$0FF7,$0FF0,$2A77,$0000
        DC.W $8EA8,$07B8,$8EA8,$0000,$7170,$0150,$7170,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $97F8,$1E00,$99F8,$1F80,$0BF7,$0F00,$0CF7,$0FC0
        DC.W $8AC8,$0380,$8B48,$03C0,$72F0,$0380,$7370,$03C0
        DC.W $8AC8,$0380,$8B48,$03C0,$03E7,$07C0,$0427,$07E0
        DC.W $80F8,$1FC0,$9F38,$1FF8,$447C,$3FE0,$7F9C,$3FFC
        DC.W $8E7C,$3FE0,$BF9C,$3FFC,$647F,$7FE0,$1F9F,$7FFE
        DC.W $E0FE,$7FE0,$9F1E,$7FFE,$71FE,$7FC0,$0E3E,$7FFE
        DC.W $BFFC,$3F80,$807C,$3FFC,$3FFF,$0F00,$30FF,$3FFC
        DC.W $9FF8,$0000,$9FF8,$1FF8,$77F0,$0000,$77F0,$07E0
       
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
        DC.W $8888,$0000,$8888,$0000,$0707,$0000,$0707,$0000
        DC.W $8888,$0000,$8888,$0000,$7070,$0000,$7070,$0000
       
        DC.W $0000,$0180,$0180,$0180,$0080,$0180,$0100,$0180
        DC.W $0180,$0180,$0100,$0180,$0180,$0180,$0100,$0180
        DC.W $0180,$0180,$0100,$0180,$03F8,$0180,$0378,$0190
        DC.W $1FFA,$01BC,$1FC6,$07FC,$7008,$7FFE,$7FF6,$7FFE
        DC.W $78FE,$1FC0,$7F3E,$1FFE,$BFFE,$0800,$BFFE,$0FFE
        DC.W $1FFE,$0800,$1FFE,$0FFE,$BFF8,$0800,$BFF8,$0F80
        DC.W $7F00,$0000,$7F00,$1800,$0000,$0000,$0000,$0000
        DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
       
        DC.W $0180,$0180,$0000,$0180,$0080,$0180,$0100,$0180
        DC.W $0180,$0180,$0100,$0180,$0180,$0180,$0100,$0180
        DC.W $0180,$0180,$0100,$0180,$0180,$0180,$0100,$0180
        DC.W $0580,$03FC,$077C,$03FC,$1FFC,$0E78,$1D84,$0FFC
        DC.W $783C,$7FE0,$3FDC,$7FFC,$7F7C,$4380,$3CFC,$7FFC
        DC.W $677C,$0080,$67FC,$43F8,$4370,$00C0,$43B0,$01E0
        DC.W $6740,$0080,$67C0,$0380,$3C00,$0000,$3C00,$0000
        DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
       
        DC.W $0180,$0180,$0000,$0180,$0080,$0180,$0100,$0180
        DC.W $0180,$0100,$0180,$0180,$0180,$0100,$0180,$0180
        DC.W $0180,$0100,$0180,$0180,$0180,$0100,$0180,$0180
        DC.W $05E0,$0760,$0780,$07E0,$0BF0,$0D00,$0FF0,$0FF0
        DC.W $1F88,$1E78,$1FF0,$1FF8,$03C0,$1FF8,$1C38,$1FF8
        DC.W $1DB8,$1C20,$0198,$1C30,$1A58,$1800,$0258,$1810
        DC.W $1DB8,$1C00,$01B8,$1C30,$1FF8,$1800,$07F8,$1FC0
        DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
       
        DC.W $0180,$0180,$0000,$0180,$0080,$0180,$0100,$0180
        DC.W $0180,$0180,$0100,$0180,$0180,$0180,$0100,$0180
        DC.W $0180,$0180,$0100,$0180,$0180,$0180,$0100,$0180
        DC.W $39E0,$3F80,$3F60,$3FC0,$2DF8,$3E00,$3FF8,$3FF0
        DC.W $2206,$3FFC,$3FFA,$3FFE,$0CFE,$3FC0,$333E,$3FFE
        DC.W $3EE6,$1B00,$25E6,$1FC2,$0EC2,$0300,$0DC2,$0780
        DC.W $02E6,$0100,$03E6,$01C0,$003C,$0000,$003C,$0000
        DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
       
        DC.W $0000,$0180,$0180,$0180,$0080,$0180,$0100,$0180
        DC.W $0080,$0180,$0100,$0180,$0080,$0100,$0180,$0180
        DC.W $0180,$0100,$0180,$0180,$1FC0,$0100,$1FC0,$0980
        DC.W $677C,$7D80,$7BFC,$7DA0,$1FDA,$7C3C,$7FE6,$7E7C
        DC.W $018A,$7FFC,$7FF6,$7FFC,$1FE7,$7FF8,$601F,$7FF8
        DC.W $7FEF,$0710,$78FF,$3FF0,$0FE7,$0018,$0FFF,$01F8
        DC.W $00F8,$0000,$00F8,$0010,$0000,$0000,$0000,$0000
        DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
       
        DC.W $0000,$FFFF,$FFFF,$FFFF,$7FFF,$8000,$FFFF,$8000
        DC.W $6001,$A000,$DFFF,$A001,$4B30,$8FFC,$FFFF,$8B30
        DC.W $5002,$9FB6,$FFFF,$9002,$4000,$8ADE,$FFFF,$8000
        DC.W $4CD4,$9FFE,$FFFF,$8CD4,$5020,$9DFC,$FFFF,$9020
        DC.W $4402,$8FD6,$FFFF,$8402,$4AD8,$9FFE,$FFFF,$8AD8
        DC.W $4020,$8EFC,$FFFF,$8020,$6001,$A000,$DFFF,$A001
        DC.W $7FFF,$8000,$FFFF,$BFFF,$7FFF,$FFFF,$FFFF,$FFFF
        DC.W $3F30,$FFF9,$FFCF,$C0C9,$0000,$FFFF,$FFFF,$FFFF
       
        DC.W $0000,$FFFF,$FFFF,$FFFF,$7FFF,$8000,$FFFF,$8000
        DC.W $6001,$A000,$DFFF,$A001,$4004,$8FBC,$FFFF,$8004
        DC.W $4DB0,$9FFE,$FFFF,$8DB0,$4202,$9FF6,$FFFF,$8202
        DC.W $5000,$957E,$FFFF,$9000,$4AD8,$9FFA,$FFFF,$8AD8
        DC.W $4022,$8AFE,$FFFF,$8022,$4400,$9F6A,$FFFF,$8400
        DC.W $4D64,$8FFC,$FFFF,$8D64,$6001,$A000,$DFFF,$A001
        DC.W $7FFF,$8000,$FFFF,$BFFF,$7FFF,$FFFF,$FFFF,$FFFF
        DC.W $3F30,$FFF9,$FFCF,$C0C9,$0000,$FFFF,$FFFF,$FFFF
       
        DC.W $0000,$FFFF,$FFFF,$FFFF,$7FFF,$8000,$FFFF,$8000
        DC.W $6001,$A000,$DFFF,$A001,$4AB0,$8FFC,$FFFF,$8AB0
        DC.W $4004,$976E,$FFFF,$8004,$4AD8,$9FFC,$FFFF,$8AD8
        DC.W $4100,$8BB6,$FFFF,$8100,$444C,$9DEC,$FFFF,$844C
        DC.W $4000,$97B6,$FFFF,$8000,$4D64,$9FFE,$FFFF,$8D64
        DC.W $4010,$8ED6,$FFFF,$8010,$6001,$A000,$DFFF,$A001
        DC.W $7FFF,$8000,$FFFF,$BFFF,$7FFF,$FFFF,$FFFF,$FFFF
        DC.W $3F30,$FFF9,$FFCF,$C0C9,$0000,$FFFF,$FFFF,$FFFF
       
        DC.W $0000,$FFFF,$FFFF,$FFFF,$7FFF,$8000,$FFFF,$8000
        DC.W $6001,$A000,$DFFF,$A001,$4088,$8FFC,$FFFF,$8088
        DC.W $5000,$9BFA,$FFFF,$9000,$4654,$8ED6,$FFFF,$8654
        DC.W $4800,$9FFC,$FFFF,$8800,$4280,$97DA,$FFFF,$8280
        DC.W $4C30,$8D74,$FFFF,$8C30,$4002,$9FFE,$FFFF,$8002
        DC.W $494C,$8DFC,$FFFF,$894C,$6001,$A000,$DFFF,$A001
        DC.W $7FFF,$8000,$FFFF,$BFFF,$7FFF,$FFFF,$FFFF,$FFFF
        DC.W $3F30,$FFF9,$FFCF,$C0C9,$0000,$FFFF,$FFFF,$FFFF
       
        DC.W $0000,$FFFF,$FFFF,$FFFF,$7FFF,$8000,$FFFF,$8000
        DC.W $6001,$A000,$DFFF,$A001,$4004,$8FBC,$FFFF,$8004
        DC.W $4DB0,$9FFE,$FFFF,$8DB0,$4202,$9FF6,$FFFF,$8202
        DC.W $5000,$957E,$FFFF,$9000,$4AD8,$9FFA,$FFFF,$8AD8
        DC.W $4022,$8AFE,$FFFF,$8022,$4400,$9F6A,$FFFF,$8400
        DC.W $4D64,$8FFC,$FFFF,$8D64,$6001,$A000,$DFFF,$A001
        DC.W $7FFF,$8000,$FFFF,$BFFF,$7FFF,$FFFF,$FFFF,$FFFF
        DC.W $3F30,$FFF9,$FFCF,$C0C9,$0000,$FFFF,$FFFF,$FFFF
