
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $00F8,$0078,$00E0,$00E0,$7F7E,$3C86,$5FC0,$7EB8

	DC.W $C7FF,$FFC1,$38C0,$FFC2,$6FFE,$3C06,$53C0,$7EB8

	DC.W $00D8,$0038,$00E0,$0060,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $00F0,$0070,$00E0,$00E0,$7F78,$3C88,$5FC0,$7E90

	DC.W $C7FC,$FFC4,$38C0,$FFC8,$6FF8,$3C08,$53C0,$7E90

	DC.W $00D0,$0030,$00E0,$0060,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $1F00,$1E00,$0700,$0700,$7EFE,$613C,$03FA,$1D7E

	DC.W $FFE3,$83FF,$031C,$43FF,$7FF6,$603C,$03CA,$1D7E

	DC.W $1B00,$1C00,$0700,$0600,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0F00,$0E00,$0700,$0700,$1EFE,$113C,$03FA,$097E

	DC.W $3FE3,$23FF,$031C,$13FF,$1FF6,$103C,$03CA,$097E

	DC.W $0B00,$0C00,$0700,$0600,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $00E0,$0060,$00E0,$00E0,$7F40,$3C80,$5FC0,$7E80

	DC.W $C7C0,$FFC0,$38C0,$FFC0,$6FC0,$3C00,$53C0,$7E80

	DC.W $00C0,$0020,$00E0,$0060,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0700,$0600,$0700,$0700,$02FE,$013C,$03FA,$017E

	DC.W $03E3,$03FF,$031C,$03FF,$03F6,$003C,$03CA,$017E

	DC.W $0300,$0400,$0700,$0600,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

