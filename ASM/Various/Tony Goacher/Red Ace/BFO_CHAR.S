
	DC.W $08A0,$08A0,$08A0,$0000,$1C62,$1C62,$1422,$0000

	DC.W $0F74,$0F74,$0D70,$0000,$2FF8,$2F78,$2808,$0080

	DC.W $7FFC,$780C,$5004,$05B0,$3FFE,$2A02,$2202,$1614

	DC.W $7FFE,$70AE,$40A2,$04B0,$BFFE,$B5C6,$85C2,$05D0

	DC.W $5FFE,$588E,$0082,$0490,$DFFA,$C988,$C180,$17A2

	DC.W $2FF5,$2805,$2001,$01F0,$17FA,$177A,$000A,$0080

	DC.W $2610,$2610,$2610,$0000,$0120,$0120,$0000,$0000

	DC.W $0150,$0150,$0150,$0000,$0000,$0000,$0000,$0000


	DC.W $1124,$1124,$1124,$0000,$33F8,$32F8,$22D0,$0100

	DC.W $17F8,$17F8,$15B8,$0000,$3FFC,$3F7C,$280C,$0080

	DC.W $1FFE,$180E,$100A,$03F0,$7FFF,$680D,$6005,$1632

	DC.W $FFFE,$F88E,$A082,$0490,$7FFE,$71C6,$61C2,$05D0

	DC.W $3FFE,$388E,$2082,$0490,$3FFE,$2802,$2002,$1634

	DC.W $7FFD,$780D,$5005,$05F0,$2FFB,$2F7B,$280A,$0080

	DC.W $07F5,$05F5,$05D1,$0200,$1A44,$1A44,$1204,$0000

	DC.W $0840,$0840,$0840,$0000,$0000,$0000,$0000,$0000

