                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0003,$0000,$0003,$0000
	DC.W $000F,$0003,$000F,$0000,$001C,$000F,$001C,$0003
	DC.W $0019,$000F,$0018,$0004,$0033,$001E,$0030,$0009
                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$8000,$0000,$8000,$0000
	DC.W $E000,$8000,$E000,$0000,$7000,$E000,$7000,$8000
	DC.W $3000,$E000,$3000,$4000,$9800,$F000,$1800,$2000
                
	DC.W $0037,$001C,$0030,$000A,$0033,$001E,$0030,$0009
	DC.W $0019,$000F,$0018,$0004,$001C,$000F,$001C,$0003
	DC.W $000F,$0003,$000F,$0000,$0003,$0000,$0003,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $D800,$7000,$1800,$A000,$9800,$F000,$1800,$2000
	DC.W $3000,$E000,$3000,$4000,$7000,$E000,$7000,$8000
	DC.W $E000,$8000,$E000,$0000,$8000,$0000,$8000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0001,$0000,$0001,$0000
	DC.W $0001,$0000,$0001,$0000,$0001,$0000,$0001,$0000
	DC.W $0003,$0001,$0003,$0000,$000F,$0003,$000F,$0000
	DC.W $005C,$004F,$005C,$0003,$0031,$001F,$0030,$000C
	DC.W $0063,$003E,$0060,$0011,$00CF,$0078,$00C0,$0026
	DC.W $00CF,$0072,$00C0,$002C,$019F,$00F6,$0180,$0048
                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $8000,$0000,$8000,$0000,$E000,$8000,$E000,$0000
	DC.W $7400,$E400,$7400,$8000,$1800,$F000,$1800,$6000
	DC.W $8C00,$F800,$0C00,$1000,$E600,$3C00,$0600,$C800
	DC.W $E600,$9C00,$0600,$6800,$F300,$DE00,$0300,$2400
                
	DC.W $0FBF,$01E1,$0F81,$0051,$019F,$00F6,$0180,$0048
	DC.W $00CF,$0072,$00C0,$002C,$004F,$0078,$0040,$0026
	DC.W $0063,$003E,$0060,$0011,$0031,$001F,$0030,$000C
	DC.W $005C,$004F,$005C,$0003,$000F,$0003,$000F,$0000
	DC.W $0003,$0001,$0003,$0000,$0001,$0000,$0001,$0000
	DC.W $0001,$0000,$0001,$0000,$0001,$0000,$0001,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $FBE0,$0F00,$03E0,$1400,$F300,$DE00,$0300,$2400
	DC.W $E600,$9C00,$0600,$6800,$E400,$3C00,$0400,$C800
	DC.W $8C00,$F800,$0C00,$1000,$1800,$F000,$1800,$6000
	DC.W $7400,$E400,$7400,$8000,$E000,$8000,$E000,$0000
	DC.W $8000,$0000,$8000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0001,$0000,$0001,$0000,$0000,$0001,$0000,$0001
	DC.W $001E,$0001,$001E,$0000,$007F,$001F,$007E,$0000
	DC.W $01E3,$007D,$01E2,$0000,$039F,$01F3,$038E,$0000
	DC.W $067D,$03AE,$065C,$0001,$0CF3,$07DE,$0C30,$0008
	DC.W $0DE7,$073E,$0C60,$0090,$19CF,$0F78,$18C0,$0024
	DC.W $1BDF,$0E73,$18C1,$0109,$1B3F,$0FF5,$1901,$0001
                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $F200,$0200,$F200,$0000,$FC00,$F000,$FC00,$0000
	DC.W $8F00,$7C00,$8F00,$0000,$F380,$9F00,$E380,$0000
	DC.W $7CC0,$EB80,$74C0,$0000,$9E60,$F7C0,$1860,$2000
	DC.W $CF60,$F9C0,$0C60,$1200,$E7B0,$3CE0,$0630,$4900
	DC.W $F7B0,$9CE0,$0630,$2100,$F9B0,$5FE0,$0130,$0000
                
	DC.W $73FF,$0F87,$7007,$0847,$1B3F,$0FF5,$1901,$0001
	DC.W $1BDF,$0E73,$18C1,$0109,$19CF,$0F78,$1840,$00A4
	DC.W $0DE7,$07BE,$0C60,$0010,$0CF3,$07DE,$0C30,$0008
	DC.W $067D,$03AE,$065C,$0001,$039F,$01F3,$038E,$0000
	DC.W $01E3,$007D,$01E2,$0000,$007F,$001F,$007E,$0000
	DC.W $001E,$0001,$001E,$0000,$0000,$0001,$0000,$0001
	DC.W $0001,$0000,$0001,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $FF9C,$C3E0,$C01C,$C420,$F9B0,$5FE0,$0130,$0000
	DC.W $F7B0,$9CE0,$0630,$2100,$E7B0,$3DE0,$0430,$4A00
	DC.W $CF60,$FBC0,$0C60,$1000,$9E60,$F7C0,$1860,$2000
	DC.W $7CC0,$EB80,$74C0,$0000,$F380,$9F00,$E380,$0000
	DC.W $8F40,$7C40,$8F40,$0000,$FD00,$F100,$FD00,$0000
	DC.W $F000,$0000,$F000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $001E,$0000,$001E,$0000,$07FF,$023F,$07FF,$0000
	DC.W $02F0,$007F,$02F0,$0000,$0DDD,$00FF,$0DC0,$0002
	DC.W $1FBD,$0DFB,$1F80,$0046,$1FF3,$0FEF,$1F82,$001C
	DC.W $1FED,$0EDE,$180C,$0131,$1BD3,$0FBE,$1810,$0468
	DC.W $09A7,$0FFE,$0820,$0650,$0C4F,$07F8,$0C40,$02A4
	DC.W $0C5F,$0FF3,$0C41,$0089,$193F,$0FF5,$1901,$0401
                
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $03E0,$00C0,$03E0,$0000,$FFE0,$87C0,$FFE0,$0000
	DC.W $7FE0,$DEC0,$7EE0,$8100,$7640,$FDC0,$7040,$8280
	DC.W $6460,$FFC0,$0060,$8080,$9CF0,$F7E0,$80F0,$6900
	DC.W $68E0,$FF80,$60E0,$1500,$94C0,$FF80,$10C0,$2900
	DC.W $C9D0,$FF80,$09D0,$1400,$E4E0,$3FC0,$04E0,$4B00
	DC.W $F470,$9FE0,$0470,$2280,$F918,$5FF0,$0118,$0060
                
	DC.W $1BFF,$0F87,$1807,$0047,$1F3F,$1FF5,$1901,$0001
	DC.W $1F5F,$1FF3,$1841,$0089,$1F4F,$0FF8,$1C40,$00A4
	DC.W $19A7,$0FFE,$1820,$0050,$19D3,$0FFE,$1810,$0428
	DC.W $1CED,$0FBE,$1C0C,$0051,$0CF3,$0F9F,$0C02,$026C
	DC.W $0EF9,$07FF,$0E00,$0106,$0ED1,$07FF,$0E00,$0006
	DC.W $0E0E,$07FF,$0E0E,$0070,$0E7E,$07FD,$0E7E,$0181
	DC.W $0FF8,$07E0,$0FF8,$0000,$07E0,$0000,$07E0,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $FF98,$C3F0,$C018,$C420,$F998,$5FF0,$0118,$0060
	DC.W $F5B8,$9FF0,$0438,$2240,$E770,$3FE0,$0470,$4800
	DC.W $CA60,$FFC0,$0860,$1580,$94C0,$FF80,$10C0,$2900
	DC.W $6E40,$FB80,$6040,$1400,$9F40,$F180,$8040,$6E80
	DC.W $0F40,$FDC0,$0040,$C200,$73C0,$FF80,$7140,$8800
	DC.W $FF30,$DFE0,$FF30,$0000,$DEF0,$87C0,$DEF0,$0100
	DC.W $87E0,$01C0,$87E0,$0000,$01C0,$0000,$01C0,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
                
	DC.W $007F,$0000,$007F,$0041,$087F,$003E,$087F,$0000
	DC.W $1DFD,$087F,$1DFD,$0002,$09D0,$00FF,$09C0,$0020
	DC.W $77BF,$03FF,$7780,$0000,$FF7F,$77F1,$FF00,$008E
	DC.W $DE7F,$FFC1,$DE00,$213C,$D7FF,$7FD7,$C500,$2828
	DC.W $DFFF,$7B98,$C000,$0463,$EFFF,$7C10,$E000,$13E8
	DC.W $67FF,$3E19,$6001,$19E5,$7BFF,$3F20,$7800,$00D8
	DC.W $73FF,$1F46,$7006,$08A6,$73FF,$3F4C,$700C,$008C
	DC.W $E7FF,$7F58,$E018,$1098,$CFFF,$7C83,$C003,$2343
                
	DC.W $00FC,$0038,$00FC,$0000,$83CC,$00F8,$83CC,$0030
	DC.W $FF9C,$83F8,$FF9C,$0000,$38DC,$EFB0,$381C,$C640
	DC.W $7998,$FF70,$7818,$00A0,$F314,$FFF0,$0014,$0020
	DC.W $3F3E,$DFE4,$003E,$6040,$FF3E,$63EC,$003E,$9840
	DC.W $FF3C,$B1E0,$003C,$4640,$FF38,$19F0,$0038,$0640
	DC.W $FF7A,$47F0,$427A,$7000,$FD78,$11F0,$0278,$2600
	DC.W $FF3C,$03F8,$003C,$3C40,$FF8E,$91FC,$900E,$9A30
	DC.W $FFC3,$12FE,$1003,$151C,$FFE3,$80FE,$8003,$890C
                
	DC.W $9EFF,$FD01,$8001,$4345,$9FFF,$F481,$8001,$4B45
	DC.W $9FFF,$FC80,$8000,$4341,$DFFF,$7C40,$D000,$03A0
	DC.W $C7FF,$7E2A,$C00A,$21DE,$C7FF,$7D02,$C000,$32BD
	DC.W $CFFF,$7F23,$C000,$20C4,$E3FF,$7F1F,$E000,$10A0
	DC.W $71FE,$3F7F,$7000,$0800,$79E8,$1FFF,$7800,$0607
	DC.W $39A1,$1FFF,$3801,$0006,$3307,$1FFF,$3007,$0830
	DC.W $301F,$1FFF,$301F,$08E0,$30FF,$1FF8,$30FF,$0F00
	DC.W $3FF8,$1FC0,$3FF8,$0000,$1FC0,$0000,$1FC0,$0000
                
	DC.W $FFE3,$207E,$2003,$398C,$FFE3,$007E,$0003,$2C8C
	DC.W $FFE7,$157E,$1007,$1298,$FFDE,$0CFC,$001E,$0200
	DC.W $FF9C,$89F8,$801C,$D660,$FF38,$63F0,$0038,$9840
	DC.W $FFF0,$E1E0,$0070,$1A00,$FF98,$F8F0,$0018,$0700
	DC.W $1FD8,$FA70,$0018,$05A0,$07D8,$FF70,$0018,$E080
	DC.W $38E8,$FFF0,$3808,$C400,$FC2C,$FFF0,$FC0C,$0380
	DC.W $FFC6,$EFFC,$FFC6,$0000,$EFBE,$C1F8,$EFBE,$0040
	DC.W $C1FC,$0078,$C1FC,$0000,$0078,$0000,$0078,$0000
