
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $1E78,$0000,$1E78,$0000,$13F8,$0C30,$13C8,$0000

	DC.W $13F8,$0DB0,$13C8,$0180,$33CC,$0DB0,$3FFC,$0DB0

	DC.W $3FEC,$1FF8,$3FFC,$1FF8,$3A1C,$1818,$381C,$1A18

	DC.W $2204,$1818,$381C,$1A18,$3A9C,$1818,$2004,$1A98

	DC.W $3BDC,$0000,$381C,$1BD8,$389C,$0000,$381C,$0080

	DC.W $300C,$0FF0,$3FFC,$1FF8,$3FFC,$0000,$3FFC,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $1E78,$0000,$1E78,$0000,$1FC8,$0C30,$13C8,$0000

	DC.W $1FC8,$0DB0,$13C8,$0180,$33CC,$0DB0,$3FFC,$0DB0

	DC.W $3FEC,$1FF8,$3FFC,$1FF8,$3BDC,$1818,$381C,$1BD8

	DC.W $2044,$1818,$381C,$1858,$38DC,$1818,$2004,$18D8

	DC.W $385C,$0000,$381C,$1858,$3BDC,$0000,$381C,$03C0

	DC.W $300C,$0FF0,$3FFC,$1FF8,$3FFC,$0000,$3FFC,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $1E78,$0000,$1E78,$0000,$13F8,$0C30,$13C8,$0000

	DC.W $13F8,$0DB0,$13C8,$0180,$33CC,$0DB0,$3FFC,$0DB0

	DC.W $3FEC,$1FF8,$3FFC,$1FF8,$3BDC,$1818,$381C,$1BD8

	DC.W $2044,$1818,$381C,$1858,$399C,$1818,$2004,$1998

	DC.W $3A1C,$0000,$381C,$1A18,$3BDC,$0000,$381C,$03C0

	DC.W $300C,$0FF0,$3FFC,$1FF8,$3FFC,$0000,$3FFC,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000


	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $1E78,$0000,$1E78,$0000,$1FC8,$0C30,$13C8,$0000

	DC.W $1FC8,$0DB0,$13C8,$0180,$33CC,$0DB0,$3FFC,$0DB0

	DC.W $3FEC,$1FF8,$3FFC,$1FF8,$389C,$1818,$381C,$1898

	DC.W $2184,$1818,$381C,$1998,$389C,$1818,$2004,$1898

	DC.W $389C,$0000,$381C,$1898,$39DC,$0000,$381C,$01C0

	DC.W $300C,$0FF0,$3FFC,$1FF8,$3FFC,$0000,$3FFC,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

