	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FD7F,$BFFF,$4F82,$FFFF,$FAFF,$BFFF,$4F82,$FFFF
	DC.W $F5FF,$BFFF,$4FC2,$FFFF,$FB9F,$BFFF,$4FF2,$FFFF
	DC.W $F737,$BFF7,$4FF2,$FFFF,$FE77,$BFF7,$4FF2,$FFFF
	DC.W $F4E7,$B7E7,$47E2,$FFFF,$F9EF,$BFEF,$47E2,$FFFF
	DC.W $FD9F,$BD9F,$4182,$FFFF,$FE7F,$BE7F,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FF7F,$BFFF,$4082,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $F7FF,$B7FF,$4042,$FFFF,$F99F,$A9FF,$5872,$FFFF
	DC.W $F637,$8EF7,$7EF2,$FFFF,$FE77,$AFF7,$5FF2,$FFFF
	DC.W $FCE7,$A7E7,$5FE2,$FFFF,$F9EF,$B7EF,$4FE2,$FFFF
	DC.W $FF9F,$B99F,$4782,$FFFF,$FE7F,$BE7F,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FBFF,$ABFF,$5802,$FFFF
	DC.W $F6F7,$8EF7,$7E32,$FFFF,$FE77,$AF77,$5F72,$FFFF
	DC.W $FCE7,$A7E7,$5FE2,$FFFF,$F9EF,$B7EF,$4FE2,$FFFF
	DC.W $FF9F,$B99F,$4782,$FFFF,$FE7F,$BE7F,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFF7,$BFF7,$4032,$FFFF,$FFF7,$BFF7,$4072,$FFFF
	DC.W $FFEF,$BFEF,$4062,$FFFF,$FFEF,$BFEF,$4062,$FFFF
	DC.W $FF9F,$BF9F,$4182,$FFFF,$FE7F,$BE7F,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $D823,$996B,$4002,$E697,$DA5F,$9F5F,$4002,$E0A3
	DC.W $EFF7,$B7F7,$4002,$C80B,$CFFB,$980B,$4002,$E2B7
	DC.W $FFF7,$B017,$4002,$CE2B,$DFF3,$930B,$4302,$EB57
	DC.W $DFFF,$B19F,$4182,$C5A3,$CFFB,$B00B,$4002,$CD37
	DC.W $D7FB,$9857,$4002,$E6AB,$FBE7,$A73F,$4002,$D8C3
	DC.W $F0DB,$9BFB,$4002,$E407,$E647,$B657,$4002,$C9AB
	DC.W $8003,$FFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FDBF,$BFFF,$4002,$FDBF,$EF77,$BFFF,$4002,$E657
	DC.W $EA2B,$BFFF,$4002,$E80B,$FFFF,$BDAF,$4002,$EA57
	DC.W $CFEF,$BA3F,$4002,$C18F,$FFFF,$BC3F,$4002,$E24B
	DC.W $EFEF,$B99F,$4182,$E5AF,$FFFB,$B02F,$4002,$EE53
	DC.W $D7FB,$B99F,$4002,$C66B,$F89B,$BF7F,$4002,$F893
	DC.W $E7F7,$BFFF,$4002,$E257,$FD5F,$BFFF,$4002,$FD5F
	DC.W $8003,$FFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$F7DF
	DC.W $FE7F,$BFFF,$4002,$FE7F,$FFFF,$BFEF,$4002,$F81F
	DC.W $FFEF,$BA3F,$4002,$F18F,$EFFF,$BC3F,$4002,$E24B
	DC.W $EFEF,$B99F,$4182,$E5AF,$FFFF,$B42F,$4002,$FA5F
	DC.W $F7DF,$B9BF,$4002,$E64F,$FC9F,$BF7F,$4002,$FC97
	DC.W $FFFF,$BFFF,$4002,$FBFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $8003,$FFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FABF
	DC.W $FFFF,$BEFF,$4002,$FD7F,$FFFF,$BC3F,$4002,$F2DF
	DC.W $FFFF,$BC3F,$4002,$FC7F,$FFFF,$BC7F,$4002,$FB9F
	DC.W $FFFF,$BFFF,$4002,$F4BF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $8003,$FFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$B83F,$4002,$F83F,$FFFF,$B29F,$4282,$F7DF
	DC.W $FD7F,$B01F,$4002,$F7DF,$FFFF,$BBBF,$439A,$FFFF
	DC.W $FFFF,$BC7F,$4062,$FBFF,$FFFF,$BF9F,$4182,$F1FF
	DC.W $FF7F,$BC9F,$4402,$F77F,$F31F,$BCFF,$4002,$F31F
	DC.W $FD7F,$BFFF,$4002,$FD7F,$FDFF,$BFFF,$4002,$FD7F
	DC.W $FFFF,$BFFF,$4002,$FD7F,$FFFF,$BFFF,$46C2,$FFFF
	DC.W $C003,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFBF,$BFBF,$4382,$FFFF
	DC.W $FEDF,$BF1F,$47C2,$FFFF,$FDEF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$F9EF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$FFFF,$BC3F,$4002,$F24F
	DC.W $FFFF,$BC3F,$4002,$FA5F,$FFFF,$BE7F,$4002,$F99F
	DC.W $FFFF,$BE7F,$4002,$FDBF,$FFFF,$BFFF,$4002,$FE7F
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFBF,$43C2,$FFBF
	DC.W $FEDF,$BF1F,$47C2,$FFFF,$FDEF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$F9EF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$FFFF,$BC3F,$4002,$FA5F
	DC.W $FFFF,$BC3F,$4002,$FA5F,$FFFF,$BE7F,$4002,$FDBF
	DC.W $FFFF,$BFFF,$4002,$FE7F,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFBF,$43C2,$FFBF
	DC.W $FEDF,$BF1F,$47C2,$FFFF,$FDEF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$F9EF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$FFFF,$BE7F,$4002,$F81F
	DC.W $FFFF,$BE7F,$4002,$FDBF,$FFFF,$BFFF,$4002,$FE7F
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFBF,$43C2,$FFBF
	DC.W $FEDF,$BF1F,$47C2,$FFFF,$FDEF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$F9EF,$BF0F,$4EE2,$FFDF
	DC.W $F9EF,$BF0F,$4EE2,$FFDF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $001C,$0018,$0014,$FFFF,$633F,$7FF9,$7FD7,$FFFB
	DC.W $C602,$FFFE,$FFFE,$FFFF,$EFFE,$7820,$97DE,$1C65
	DC.W $FFFE,$7E44,$81BA,$00ED,$FFFA,$7FEC,$E016,$601D
	DC.W $FFFE,$7FFC,$CA02,$4A01,$FFFE,$7FFC,$EAC2,$6AC1
	DC.W $FFFE,$7FFC,$CA92,$4A91,$FFFE,$7FFC,$CAD2,$4AD1
	DC.W $FFFE,$7FFC,$8E92,$0E91,$FFFE,$7FFC,$80D2,$00D1
	DC.W $FFFE,$0FFC,$F01A,$3019,$FFFE,$11FC,$EE02,$7B01
	DC.W $FE1E,$23FC,$DDE2,$77E1,$FFFE,$0000,$FFFE,$0001
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FDAF,$BCAF,$4002,$FF57,$FFFB,$BBE3,$4002,$DDDF
	DC.W $CEDF,$8E57,$4002,$FBE3,$FFFB,$BDD3,$4002,$F76F
	DC.W $FFDF,$BC4B,$4002,$FF23,$FEFF,$BE83,$4002,$FBE7
	DC.W $FFFF,$BFE3,$4002,$C017,$FFBF,$BF83,$4002,$FFFB
	DC.W $F77F,$B64B,$4002,$FDA3,$FFEB,$BAA3,$4002,$F79F
	DC.W $F7F7,$B6D7,$4002,$FDBB,$FFDF,$BE47,$4002,$DFBB
	DC.W $C401,$BFFF,$7BFE,$FBFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFEF,$BFEF,$4002,$FFDF
	DC.W $FFFB,$BF53,$4002,$FBE7,$FEBF,$BC97,$4002,$FF6B
	DC.W $FFFF,$BE6B,$4002,$FF03,$FFFF,$BF83,$4002,$FFF7
	DC.W $FFFF,$BFE3,$4002,$C017,$FF7F,$BF03,$4002,$FFFF
	DC.W $FFFF,$BECB,$4002,$FDA3,$FFE7,$BBA3,$4002,$FF9F
	DC.W $FFFF,$BEDF,$4002,$FFFB,$FFFF,$BFEF,$4002,$FFBB
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFB7,$FFFF,$BFF7,$4002,$FFEB
	DC.W $FFFF,$BFFB,$4002,$FFDB,$FFFF,$BFE3,$4002,$FFFF
	DC.W $FFFF,$BFE3,$4002,$C017,$FFFF,$BFF3,$4002,$FFDF
	DC.W $FFFF,$BFD7,$4002,$FFFF,$FFFF,$BFFB,$4002,$FFEF
	DC.W $FFFF,$BFFF,$4002,$FFDB,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFB,$FFFF,$BFFF,$4002,$FFEF
	DC.W $FFFF,$BFF3,$4002,$FFFB,$FFFF,$BFF3,$4002,$FFF7
	DC.W $FFFF,$BFF3,$4002,$C003,$FFFF,$BFF3,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFEF,$FFFF,$BFFF,$4002,$FFFB
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FF3F,$FFFF,$BF7F,$4002,$FF8F
	DC.W $FFFF,$BF3F,$4002,$FFCF,$FFFF,$BF1F,$4002,$FF67
	DC.W $FFFF,$BF1F,$4002,$FF27,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FF3F,$FFFF,$BF7F,$4002,$FF8F
	DC.W $FFFF,$BF3F,$4002,$FFCF,$FFFF,$BF1F,$4002,$FF67
	DC.W $FFFF,$BF1F,$4002,$FF27,$FFFF,$BF1F,$4002,$FF67
	DC.W $FFFF,$BF3F,$4002,$FFCF,$FFFF,$BF7F,$4002,$FF8F
	DC.W $FFFF,$BFFF,$4002,$FF3F,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FF3F,$FFFF,$BF7F,$4002,$FF8F
	DC.W $FFFF,$BF3F,$4002,$FFCF,$FFFF,$BF1F,$4002,$FF67
	DC.W $FFFF,$BF1F,$4002,$FF27,$FFFF,$B81F,$4002,$E667
	DC.W $FFFF,$BC3F,$4002,$F3CF,$FFFF,$BE7F,$4002,$F18F
	DC.W $FFFF,$BFFF,$4002,$FC3F,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FC3F,$FFFF,$BE7F,$4002,$F18F
	DC.W $FFFF,$BC3F,$4002,$F3CF,$FFFF,$B81F,$4002,$E667
	DC.W $FFFF,$B81F,$4002,$E427,$FFFF,$B81F,$4002,$E667
	DC.W $FFFF,$BC3F,$4002,$F3CF,$FFFF,$BE7F,$4002,$F18F
	DC.W $FFFF,$BFFF,$4002,$FC3F,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $FFFD,$BE0F,$41F2,$FFFF,$FFFD,$B1F7,$4FFA,$FC07
	DC.W $FFFD,$BF5B,$4FFE,$F157,$F555,$BEAF,$5BFE,$EAAB
	DC.W $FFFD,$BD57,$52AE,$E95B,$FFFD,$BE0B,$4FFE,$F0A7
	DC.W $FFFD,$B1F7,$4FFA,$FC07,$FFFD,$BE0F,$41F2,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $FFFD,$BE0F,$41F2,$FFFF,$FFFD,$B1FF,$4FF2,$FC0F
	DC.W $FFFD,$BF5F,$4FF2,$F15F,$F55D,$BEAF,$5BF2,$EAAF
	DC.W $FFFD,$BD5F,$52A2,$E95F,$FFFD,$BE0F,$4FF2,$F0AF
	DC.W $FFFD,$B1FF,$4FF2,$FC0F,$FFFD,$BE0F,$41F2,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $FFFD,$BE3F,$41C2,$FFFF,$FFFD,$B1FF,$4FC2,$FC3F
	DC.W $FFFD,$BF7F,$4FC2,$F17F,$F57D,$BEBF,$5BC2,$EABF
	DC.W $FFFD,$BD7F,$5282,$E97F,$FFFD,$BE3F,$4FC2,$F0BF
	DC.W $FFFD,$B1FF,$4FC2,$FC3F,$FFFD,$BE3F,$41C2,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $FFFD,$BEFF,$4102,$FFFF,$FFFD,$B1FF,$4F02,$FCFF
	DC.W $FFFD,$BFFF,$4F02,$F1FF,$F5FD,$BEFF,$5B02,$EAFF
	DC.W $FFFD,$BDFF,$5202,$E9FF,$FFFD,$BEFF,$4F02,$F0FF
	DC.W $FFFD,$B1FF,$4F02,$FCFF,$FFFD,$BEFF,$4102,$FFFF
	DC.W $FFFD,$BFFF,$4002,$FFFF,$FFFD,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $E187,$A187,$4002,$FFFF,$E037,$AC37,$4002,$F3CF
	DC.W $E1B7,$ADB7,$4182,$F3CF,$C183,$8DB3,$4DB2,$FFFF
	DC.W $DFEB,$9FFB,$5FFA,$FFFF,$DA1B,$981B,$581A,$FA1F
	DC.W $C203,$981B,$581A,$FA1F,$DA9B,$981B,$4002,$FA9F
	DC.W $DBDB,$8003,$581A,$FBDF,$D89B,$8003,$581A,$E087
	DC.W $D00B,$8FF3,$5FFA,$FFFF,$C003,$8003,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $E187,$A187,$4002,$FFFF,$E037,$AC37,$4002,$F3CF
	DC.W $E1B7,$ADB7,$4182,$F3CF,$C183,$8DB3,$4DB2,$FFFF
	DC.W $DFEB,$9FFB,$5FFA,$FFFF,$D9DB,$981B,$581A,$F9DF
	DC.W $C043,$981B,$581A,$F85F,$D9DB,$981B,$4002,$F9DF
	DC.W $D85B,$8003,$581A,$F85F,$D9DB,$8003,$581A,$E1C7
	DC.W $D00B,$8FF3,$5FFA,$FFFF,$C003,$8003,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $E187,$A187,$4002,$FFFF,$ED87,$ADB7,$4002,$F3CF
	DC.W $EC07,$AC37,$4002,$F3CF,$C183,$8DB3,$4DB2,$FFFF
	DC.W $DFEB,$9FFB,$5FFA,$FFFF,$DB9B,$981B,$581A,$FB9F
	DC.W $C043,$981B,$581A,$F85F,$D99B,$981B,$4002,$F99F
	DC.W $DA1B,$8003,$581A,$FA1F,$DBDB,$8003,$581A,$E3C7
	DC.W $D00B,$8FF3,$5FFA,$FFFF,$C003,$8003,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $E187,$A187,$4002,$FFFF,$E037,$AC37,$4002,$F3CF
	DC.W $E1B7,$ADB7,$4182,$F3CF,$C183,$8DB3,$4DB2,$FFFF
	DC.W $DFEB,$9FFB,$5FFA,$FFFF,$D99B,$981B,$581A,$F99F
	DC.W $C083,$981B,$581A,$F89F,$D89B,$981B,$4002,$F89F
	DC.W $D89B,$8003,$581A,$F89F,$D9DB,$8003,$581A,$E1C7
	DC.W $D00B,$8FF3,$5FFA,$FFFF,$C003,$8003,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$8000,$7FFF,$FFFF,$FFFF,$FFFF,$3FE0,$3FFF
	DC.W $FFFF,$FFFF,$3FF8,$3FFF,$C01F,$FFFF,$3FFC,$3FFF
	DC.W $FFFF,$FFFF,$0000,$3FFF,$FFFF,$C003,$3FFC,$3FFF
	DC.W $FFFF,$C007,$3FF8,$0007,$FFFF,$C01F,$3FE0,$001F
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$C30C,$FFFF,$FFFF,$0000,$DF7D
	DC.W $FFFF,$FFFF,$0000,$C37D,$FFFF,$FFFF,$0000,$FB7D
	DC.W $FFFF,$FFFF,$0000,$C30C,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$30C3,$FFFF,$FFFF,$0000,$B6DF
	DC.W $FFFF,$FFFF,$0000,$B0C7,$FFFF,$FFFF,$0000,$B5DF
	DC.W $FFFF,$FFFF,$0000,$36C3,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0001,$FFFE,$FFFF,$FFFF,$FFFF,$07FC,$FFFC
	DC.W $FFFF,$FFFF,$1FFC,$FFFC,$F803,$FFFF,$3FFC,$FFFC
	DC.W $FFFF,$FFFF,$0000,$FFFC,$FFFF,$C003,$3FFC,$FFFC
	DC.W $FFFF,$E003,$1FFC,$E000,$FFFF,$F803,$07FC,$F800
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$F8E1,$FFFF,$FFFF,$0000,$FB6F
	DC.W $FFFF,$FFFF,$0000,$FB63,$FFFF,$FFFF,$0000,$FB6F
	DC.W $FFFF,$FFFF,$0000,$F8E1,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$8619,$FFFF,$FFFF,$0000,$BEF9
	DC.W $FFFF,$FFFF,$0000,$863A,$FFFF,$FFFF,$0000,$BEFA
	DC.W $FFFF,$FFFF,$0000,$BE1B,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$6187,$FFFF,$FFFF,$0000,$6FBF
	DC.W $FFFF,$FFFF,$0000,$6F8F,$FFFF,$FFFF,$0000,$6FBF
	DC.W $FFFF,$FFFF,$0000,$6187,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$F761,$FFFF,$FFFF,$0000,$F26D
	DC.W $FFFF,$FFFF,$0000,$F56D,$FFFF,$FFFF,$0000,$F76D
	DC.W $FFFF,$FFFF,$0000,$F761,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$8EDB,$FFFF,$FFFF,$0000,$B6DB
	DC.W $FFFF,$FFFF,$0000,$B6DB,$FFFF,$FFFF,$0000,$B6DB
	DC.W $FFFF,$FFFF,$0000,$8E18,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$C30F,$FFFF,$FFFF,$0000,$DF7F
	DC.W $FFFF,$FFFF,$0000,$C70F,$FFFF,$FFFF,$0000,$DFEF
	DC.W $FFFF,$FFFF,$0000,$C30F,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$DF1B,$FFFF,$FFFF,$0000,$DFB9
	DC.W $FFFF,$FFFF,$0000,$DFBD,$FFFF,$FFFF,$0000,$DFBC
	DC.W $FFFF,$FFFF,$0000,$C31E,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$FFFF,$0000,$B0C3,$FFFF,$FFFF,$0000,$37DF
	DC.W $FFFF,$FFFF,$0000,$71C3,$FFFF,$FFFF,$0000,$77FB
	DC.W $FFFF,$FFFF,$0000,$F0C3,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8000,$7FFF,$FFFF
	DC.W $FFFF,$BFFF,$4000,$FFFF,$FFF7,$BFFF,$4000,$FF87
	DC.W $FF8B,$BFFF,$4000,$FF03,$FFBB,$BFFF,$4000,$FF33
	DC.W $FFBB,$BFFF,$4000,$FF33,$FFBB,$BFFF,$4000,$FF33
	DC.W $FFBB,$BFFF,$4000,$FF33,$FFBB,$BFFF,$4000,$FF33
	DC.W $FF73,$BFFF,$4000,$FF03,$FF87,$BFFF,$4000,$FF87
	DC.W $FFFF,$BFFF,$4000,$FFFF,$FFFF,$BFFF,$4000,$FFFF
	DC.W $C000,$BFFF,$7FFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FBFB,$FFFF,$0000,$C3C3
	DC.W $C5C5,$FFFF,$0000,$8181,$DDDD,$FFFF,$0000,$9999
	DC.W $DDDD,$FFFF,$0000,$9999,$DDDD,$FFFF,$0000,$9999
	DC.W $DDDD,$FFFF,$0000,$9999,$DDDD,$FFFF,$0000,$9999
	DC.W $B9B9,$FFFF,$0000,$8181,$C3C3,$FFFF,$0000,$C3C3
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	DC.W $0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$0003,$FFFE,$FFFF
	DC.W $FFFF,$FFFF,$0002,$FFFF,$FBFF,$FFFF,$0002,$C3FF
	DC.W $C5FF,$FFFF,$0002,$81FF,$DDFF,$FFFF,$0002,$99FF
	DC.W $DDFF,$FFFF,$0002,$99FF,$DDFF,$FFFF,$0002,$99FF
	DC.W $DDFF,$FFFF,$0002,$99FF,$DDFF,$FFFF,$0002,$99FF
	DC.W $B9FF,$FFFF,$0002,$81FF,$C3FF,$FFFF,$0002,$C3FF
	DC.W $FFFF,$FFFF,$0002,$FFFF,$FFFF,$FFFF,$0002,$FFFF
	DC.W $0003,$FFFF,$FFFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	DC.W $F7FF,$FFFF,$F800,$FFFF,$17FF,$FC00,$FBFF,$FFFF
	DC.W $F7FF,$FDFF,$1A00,$FFFF,$F7FF,$3DFF,$FA00,$FFFF
	DC.W $F7FF,$3DFF,$FA00,$3FFF,$F7FF,$3DFF,$FA00,$3FFF
	DC.W $37FF,$FDFF,$FA00,$FFFF,$F7FF,$FDFF,$3A00,$FFFF
         
	DC.W $FFFF,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFFF,$0000,$0000,$FFFF,$0000,$FFFF,$FFFF
	DC.W $FFFF,$0000,$FFFF,$0000,$FFFF,$FFFF,$0000,$FFFF
	DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF,$FFFF
	DC.W $FFFF,$FFEF,$001F,$FFFF,$FFF8,$0007,$FFFF,$FFFF
	DC.W $FFBF,$FFE3,$005C,$FFF3,$FFBF,$FFE0,$005F,$FFF3
	DC.W $FFBF,$FFE0,$005F,$FFF0,$FFBF,$FFE0,$005F,$FFF0
	DC.W $FFBF,$FFE0,$005F,$FFF3,$FFBF,$FFE2,$005D,$FFF3
         
	DC.W $F7FF,$FDFF,$3A00,$FFFF,$F7FF,$FDFF,$3A00,$FFFF
	DC.W $F7FF,$FDFF,$3A00,$FFFF,$F7FF,$FDFF,$3A00,$FFFF
	DC.W $F7FF,$FDFF,$3A00,$FFFF,$F7FF,$FDFF,$3A00,$FFFF
	DC.W $F7FF,$FDFF,$3A00,$FFFF,$F7FF,$FDFF,$3A00,$FFFF
	DC.W $F7FF,$FDFF,$3A00,$FFFF,$F7FF,$FDFF,$3A00,$FFFF
	DC.W $F780,$FEFF,$397F,$FFFF,$F7FF,$FDFF,$1A00,$FFFF
	DC.W $FBFF,$FE00,$1DFF,$FFFF,$FDFF,$FE00,$0FFF,$FF00
	DC.W $FCFF,$FF00,$03FF,$FF00,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFBF,$FFE3,$005C,$FFF3,$FFBF,$FFE3,$005C,$FFF3
	DC.W $FFBF,$FFE3,$005C,$FFF3,$FFBF,$FFE3,$005C,$FFF3
	DC.W $FFBF,$FFE3,$005C,$FFF3,$FFBF,$FFE3,$005C,$FFF3
	DC.W $FFBF,$FFE3,$005C,$FFF3,$FFBF,$FFE3,$005C,$FFF3
	DC.W $FFBF,$FFE3,$005C,$FFF3,$FFBF,$FFE3,$005C,$FFF3
	DC.W $007F,$FFE3,$FF9C,$FFF3,$FFFF,$FFC3,$003C,$FFE3
	DC.W $FFFF,$0007,$FFF8,$FFC7,$FFFF,$0007,$FFF8,$0007
	DC.W $FFFF,$001F,$FFE0,$001F,$FFFF,$FFFF,$0000,$FFFF
         
	DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$8001,$7FFE,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FDFF,$BE0F,$41F2,$FC0F,$FFFF,$BFF7,$41FA,$FDF7
	DC.W $DE07,$BFFB,$41FE,$D5FB,$FFFF,$BE07,$41FA,$FDF7
	DC.W $FDFF,$BE0F,$41F2,$FC0F,$FFFF,$BFFF,$4002,$FFFF
	DC.W $FFFF,$BFFF,$4002,$FFFF,$FFFF,$BFFF,$4002,$FFFF
	DC.W $C001,$BFFF,$7FFE,$FFFF,$FFFF,$FFFF,$0000,$FFFF

