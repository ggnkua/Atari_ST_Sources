
	DC.W $FFFF,$0000,$FFFF,$0000,$F7C9,$067E,$F1BF,$467E

	DC.W $EF91,$0C7E,$E3FF,$0E7E,$DFA3,$187E,$C7FD,$1E7E

	DC.W $BFC7,$327E,$8DF9,$3E7E,$FD8F,$667E,$9BF1,$7E7E

	DC.W $F99F,$4E7C,$B7E3,$7E7E,$FFFF,$0000,$FFFF,$0000

	DC.W $FFFF,$0000,$FFFF,$0000,$C9FF,$7E60,$BF9F,$7E7C

	DC.W $91FF,$7E40,$FFBF,$7E7A,$A3FF,$7E02,$FDFD,$7E76

	DC.W $C7FF,$7E06,$F9F9,$7E6E,$8FFF,$7E0E,$F1F1,$7E5E

	DC.W $9FFF,$7C1E,$E3E1,$7E3E,$FFFF,$0000,$FFFF,$0000


	DC.W $FFFF,$0000,$FFFF,$0000,$F429,$001E,$F43F,$401E

	DC.W $EC31,$081E,$E43F,$081E,$DC23,$181E,$C43D,$181E

	DC.W $BC27,$301E,$8C39,$381E,$FC3F,$0000,$FC3F,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $FC3F,$0000,$FC3F,$0000,$A43F,$7802,$FC3D,$7816

	DC.W $C43F,$7806,$FC39,$780E,$8C3F,$780E,$F431,$781E

	DC.W $9C3F,$781E,$E421,$781E,$FFFF,$0000,$FFFF,$0000


	DC.W $FFFF,$0000,$FFFF,$0000,$F009,$0006,$F00F,$4006

	DC.W $F009,$0006,$F00F,$0006,$F00F,$0000,$F00F,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $F00F,$0000,$F00F,$0000,$900F,$6006,$F009,$6006

	DC.W $900F,$6006,$F009,$6006,$FFFF,$0000,$FFFF,$0000


	DC.W $FFFF,$0000,$FFFF,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$8001,$0000,$8001,$0000

	DC.W $8001,$0000,$8001,$0000,$FFFF,$0000,$FFFF,$0000

