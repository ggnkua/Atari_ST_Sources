
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $01C0,$0040,$0000,$0180,$03E0,$0120,$0100,$0340

	DC.W $03C0,$0020,$0000,$0240,$03C0,$0260,$0000,$0180

	DC.W $0100,$01C0,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

