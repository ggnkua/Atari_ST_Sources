
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$3E3F

	DC.W $601F,$181F,$7C00,$7FFF,$C01F,$3000,$FF00,$FFFF

	DC.W $6000,$1800,$7C00,$7F9F,$0007,$0007,$0007,$3E00

	DC.W $0000,$0003,$0003,$0000,$0000,$0003,$0003,$0000

	DC.W $0007,$0003,$0000,$3E07,$6007,$1800,$7C00,$7F9F

	DC.W $C000,$3000,$FF00,$FFFF,$601F,$181F,$7C1F,$7FE0

	DC.W $0000,$0000,$0000,$3E3F,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000




	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$F000

	DC.W $6000,$E000,$0000,$FC00,$6C00,$FC00,$0000,$FF80

	DC.W $6D80,$FF80,$0000,$FFF0,$6DB0,$93F0,$0000,$FFFE

	DC.W $6DB6,$924E,$0000,$FFFF,$0180,$9248,$0000,$FFFF

	DC.W $0000,$9240,$0030,$FFCE,$6D80,$FF80,$6D80,$9270

	DC.W $6C00,$FC00,$6C00,$9380,$6000,$E000,$6000,$9C00

	DC.W $0000,$0000,$0000,$F000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000





	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$3E3F

	DC.W $001F,$001F,$0000,$03FF,$001F,$0000,$0000,$00FF

	DC.W $0000,$0000,$0000,$039F,$0007,$0007,$0007,$3E00

	DC.W $0000,$0003,$0003,$0000,$0000,$0003,$0003,$0000

	DC.W $0007,$0003,$0000,$3E07,$0007,$0000,$0000,$039F

	DC.W $0000,$0000,$0000,$00FF,$001F,$001F,$001F,$03E0

	DC.W $0000,$0000,$0000,$3E3F,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

