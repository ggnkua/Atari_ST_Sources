	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$4000,$4000,$0000,$0000
	DC.W $A000,$A000,$0000,$0000,$C000,$4000,$0000,$8000
	DC.W $E000,$2000,$0000,$4000,$C000,$8000,$8000,$C000
	DC.W $E000,$2000,$0000,$4000,$C000,$4000,$0000,$8000
	DC.W $9000,$9000,$0000,$0000,$4000,$4000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$2000,$2000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$8000,$8000,$0000,$0000
	DC.W $E800,$E800,$0000,$0000,$E000,$6000,$0000,$8000
	DC.W $F000,$3000,$0000,$C000,$F000,$1000,$0000,$2000
	DC.W $F000,$9000,$8000,$A000,$F400,$9400,$8000,$A000
	DC.W $F000,$3000,$0000,$0000,$E000,$2000,$0000,$C000
	DC.W $E000,$6000,$0000,$8000,$8000,$8000,$0000,$0000
	DC.W $1000,$1000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$2200,$2200,$0000,$0000
	DC.W $8C00,$8C00,$0000,$0000,$E000,$E000,$0000,$0000
	DC.W $F400,$3400,$0000,$C000,$FD00,$0D00,$0000,$7000
	DC.W $FC80,$0480,$0000,$1800,$FE00,$4600,$4000,$5800
	DC.W $FD00,$C100,$C000,$CC00,$FC00,$8400,$8000,$8800
	DC.W $F500,$8500,$8000,$9000,$F900,$0900,$0000,$3000
	DC.W $F000,$1000,$0000,$E000,$EC00,$EC00,$0000,$0000
	DC.W $A000,$A000,$0000,$0000,$2000,$2000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0002,$0002,$0000,$0000
	DC.W $0005,$0005,$0000,$0000,$0003,$0002,$0000,$0001
	DC.W $0007,$0004,$0000,$0002,$0003,$0001,$0001,$0003
	DC.W $0007,$0004,$0000,$0002,$0003,$0002,$0000,$0001
	DC.W $0009,$0009,$0000,$0000,$0002,$0002,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0004,$0004,$0000,$0000
	DC.W $0000,$0000,$0000,$0000,$0001,$0001,$0000,$0000
	DC.W $0017,$0017,$0000,$0000,$0007,$0006,$0000,$0001
	DC.W $000F,$000C,$0000,$0003,$000F,$0008,$0000,$0004
	DC.W $000F,$0009,$0001,$0005,$002F,$0029,$0001,$0005
	DC.W $000F,$000C,$0000,$0000,$0007,$0004,$0000,$0003
	DC.W $0007,$0006,$0000,$0001,$0001,$0001,$0000,$0000
	DC.W $0008,$0008,$0000,$0000,$0000,$0000,$0000,$0000

	DC.W $0000,$0000,$0000,$0000,$0044,$0044,$0000,$0000
	DC.W $0031,$0031,$0000,$0000,$0007,$0007,$0000,$0000
	DC.W $002F,$002C,$0000,$0003,$00BF,$00B0,$0000,$000E
	DC.W $013F,$0120,$0000,$0018,$007F,$0062,$0002,$001A
	DC.W $00BF,$0083,$0003,$0033,$003F,$0021,$0001,$0011
	DC.W $00AF,$00A1,$0001,$0009,$009F,$0090,$0000,$000C
	DC.W $000F,$0008,$0000,$0007,$0037,$0037,$0000,$0000
	DC.W $0005,$0005,$0000,$0000,$0004,$0004,$0000,$0000
