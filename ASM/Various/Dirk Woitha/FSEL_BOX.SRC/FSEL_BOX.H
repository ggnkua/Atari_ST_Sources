#define FSEL 0  	/* TREE */
#define PATHNAME 1  	/* OBJECT in TREE #0 */
#define DRIVE0 4  	/* OBJECT in TREE #0 */
#define DRIVE3 5  	/* OBJECT in TREE #0 */
#define DRIVE6 6  	/* OBJECT in TREE #0 */
#define DRIVE9 7  	/* OBJECT in TREE #0 */
#define DRIVE1 8  	/* OBJECT in TREE #0 */
#define DRIVE4 9  	/* OBJECT in TREE #0 */
#define DRIVE7 10  	/* OBJECT in TREE #0 */
#define DRIVE10 11  	/* OBJECT in TREE #0 */
#define DRIVE2 12  	/* OBJECT in TREE #0 */
#define DRIVE5 13  	/* OBJECT in TREE #0 */
#define DRIVE8 14  	/* OBJECT in TREE #0 */
#define DRIVE11 15  	/* OBJECT in TREE #0 */
#define NAMES 19  	/* OBJECT in TREE #0 */
#define FILE1 20  	/* OBJECT in TREE #0 */
#define FILE2 21  	/* OBJECT in TREE #0 */
#define FILE3 22  	/* OBJECT in TREE #0 */
#define FILE4 23  	/* OBJECT in TREE #0 */
#define FILE5 24  	/* OBJECT in TREE #0 */
#define FILE6 25  	/* OBJECT in TREE #0 */
#define FILE7 26  	/* OBJECT in TREE #0 */
#define FILE8 27  	/* OBJECT in TREE #0 */
#define FILE9 28  	/* OBJECT in TREE #0 */
#define CLOSER 29  	/* OBJECT in TREE #0 */
#define UP 30  	/* OBJECT in TREE #0 */
#define MOVER 31  	/* OBJECT in TREE #0 */
#define DOWN 32  	/* OBJECT in TREE #0 */
#define GROUND 33  	/* OBJECT in TREE #0 */
#define SLIDER 34  	/* OBJECT in TREE #0 */
#define LEFT 35  	/* OBJECT in TREE #0 */
#define ANZTYP 36  	/* OBJECT in TREE #0 */
#define RIGHT 37  	/* OBJECT in TREE #0 */
#define DEFEXT 38  	/* OBJECT in TREE #0 */
#define STERN2 39  	/* OBJECT in TREE #0 */
#define FILENAME 40  	/* OBJECT in TREE #0 */
#define ERASE 41  	/* OBJECT in TREE #0 */
#define ABBRUCH 42  	/* OBJECT in TREE #0 */
#define OPENORD 43  	/* OBJECT in TREE #0 */
#define OK 44  	/* OBJECT in TREE #0 */
