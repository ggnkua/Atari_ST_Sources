#define MAIN 0  	/* TREE */
#define NETFORM 0  	/* OBJECT in TREE #0 */
#define READONLY 3  	/* OBJECT in TREE #0 */
#define READWRIT 4  	/* OBJECT in TREE #0 */
#define INAKTIV 5  	/* OBJECT in TREE #0 */
#define DRIVEA 10  	/* OBJECT in TREE #0 */
#define DRIVEB 11  	/* OBJECT in TREE #0 */
#define DRIVEC 12  	/* OBJECT in TREE #0 */
#define DRIVED 13  	/* OBJECT in TREE #0 */
#define DRIVEE 14  	/* OBJECT in TREE #0 */
#define DRIVEF 15  	/* OBJECT in TREE #0 */
#define DRIVEG 16  	/* OBJECT in TREE #0 */
#define DRIVEH 17  	/* OBJECT in TREE #0 */
#define DRIVEI 18  	/* OBJECT in TREE #0 */
#define DRIVEJ 19  	/* OBJECT in TREE #0 */
#define ZEILE1 21  	/* OBJECT in TREE #0 */
#define ZEILE2 22  	/* OBJECT in TREE #0 */
#define SCHICKE 24  	/* OBJECT in TREE #0 */
#define OK 25  	/* OBJECT in TREE #0 */
