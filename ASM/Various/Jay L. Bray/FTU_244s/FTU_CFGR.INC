	User_Menu=    0;

	About_FTUEdit=    9;
	F_Load=   18;
	Make_Neu=   20;
	F_Save=   22;
	Prg_Quit=   24;
	Chg_All_Sec_Lvls=   26;
	Ext_Ulog=   28;
	Misc=   30;
	Arc_Utl=   32;
	Frm_Usr_Lstng=   34;
	New_URec=   36;
	Vis_Rec=   38;
	Usr_Masks=   40;
	FileSigs=   42;

	User_Info=    1;

	UName=    3;
	Usr_Num=    5;
	UHandle=    7;
	Xmodem=   11;
	XModem_Crc=   12;
	XModem_1k=   13;
	Y_Modem=   14;
	YModem_G=   15;
	ZModem=   16;
	RT_File=   23;
	Ratio_File=   24;
	DL_File=   25;
	UL_File=   26;
	RT_K=   28;
	Ratio_K=   29;
	DL_K=   30;
	UL_K=   31;
	RT_Pts=   33;
	Ratio_Pts=   34;
	DL_Pts=   36;
	UL_Pts=   37;
	RT_None=   38;
	Edit_Sigs=   39;
	UInf_Cnx=   40;
	UInf_Ok=   41;

	User_Listing=    2;

	Sldr_Parent=    2;
	Up_Lstng=    3;
	Dwn_Lstng=    4;
	Slid_Bar=    5;
	Slid_Btn=    6;
	Usr_Box=   10;
	Usr1=   11;
	Handle1=   12;
	Real_Name1=   13;
	User2=   14;
	Handle2=   15;
	Real_Name2=   16;
	User16=   56;
	handle16=   57;
	Real_Name16=   58;
	User20=   68;
	Handle20=   69;
	Real_Name20=   70;
	UListing_Ok=   71;

	Select_Bits=    3;

	Box1=    8;
	Box9=   16;
	Box10=   18;
	Box19=   27;
	Box20=   29;
	Box29=   38;
	Box30=   40;
	Box33=   43;
	Box39=   49;
	Box49=   60;
	Box59=   71;
	Box65=   78;
	Box69=   82;
	Box79=   93;
	Box89=  104;
	Box97=  113;
	Box99=  115;
	Box109=  126;
	Box119=  137;
	Box129=  148;
	Box139=  159;
	Box149=  170;
	Box159=  181;
	Box161=  184;
	Box169=  192;
	Box179=  203;
	Box189=  214;
	Box193=  219;
	Box199=  225;
	Box209=  236;
	Box219=  247;
	Box225=  254;
	Box229=  258;
	Box239=  269;
	Box249=  280;
	Box250=  282;
	Box256=  288;
	Add_All=  299;
	Clear_All=  300;
	Sel2_Ok=  301;
	Sel2_Cnx=  302;
	Fsig_Access=  305;
	Usr_Sig_Accs=  306;
	Turn_On=  309;
	Turn_Off=  310;
	Select_As_Shown=  311;
	Apply_Mask=  312;
	Select_Ok=  313;
	Select_Cnx=  314;

	About=    4;

	dumm=    1;

	File_SIGS=    5;

	FSigs_UName=    2;
	Fsig_Nm1=    3;
	Fsig_N1=    4;
	FSig_Nm2=    5;
	FSig_N2=    6;
	Fsig_Nm3=    7;
	Fsig_Nm4=    9;
	FSig_Nm29=   59;
	FSig_N29=   60;
	FSig_Nm30=   61;
	FSig_N30=   62;
	FSig_Nm31=   63;
	FSig_N31=   64;
	FSig_Nm32=   65;
	FSig_N32=   66;
	Prev_Fsig=   67;
	Done_Fsig=   68;
	Next_Fsig=   69;

	FSig_More=    6;

	FSig_Name=    2;
	FSig_Path=    6;
	FSig_Desc=    9;
	Desc_Y=   14;
	Desc_N=   15;
	Slvl_Kill=   17;
	Slvl_Edit=   19;
	Upld_Y=   22;
	Upld_N=   23;
	Slvl_Name=   25;
	Free_SP_Y=   28;
	Free_SP_N=   29;
	Slvl_Valid=   31;
	Free_DL_Y=   34;
	Free_DL_N=   35;
	FSIG_MCNX=   37;
	FSIG_MOK=   38;
	CD_ROM_Y=   41;
	CD_ROM_N=   42;

	Misc_Vars=    7;

	Upload_Path=    3;
	UserLog_File=    5;
	UserData_File=    7;
	XYZ_File=    9;
	Pnts_File=   13;
	Slvl_DOS=   15;
	Sig1_Y=   19;
	Sig1_N=   20;
	Misc_Cnx=   21;
	Misc_Ok=   22;

	Arc_Vars=    8;

	Arc_TTP=    3;
	Lzh_TTP=    5;
	Zip_TTP=    7;
	Arc_Temp=    9;
	Add_ArcC=   16;
	Del_ArcC=   17;
	Ext_ArcC=   18;
	Tst_ArcC=   19;
	Add_LzhC=   21;
	Del_LzhC=   22;
	Ext_LzhC=   23;
	Tst_LzhC=   24;
	Add_ZipC=   26;
	Del_ZipC=   27;
	Ext_ZipC=   28;
	Tst_ZipC=   29;
	Use_ArcY=   33;
	Use_ArcN=   34;
	Test_UpY=   37;
	Test_UpN=   38;
	Arc_Cnx=   39;
	Arc_Ok=   40;

	Masks=    9;

	Msk_B1=    2;
	Msk_Com1=    3;
	Msk_B2=    4;
	Msk_Com2=    5;
	Msk_B3=    6;
	Msk_Com3=    7;
	Msk_B4=    8;
	Msk_Com4=    9;
	Msk_B5=   10;
	Msk_Com5=   11;
	Msk_B6=   12;
	Msk_Com6=   13;
	Msk_B7=   14;
	Msk_Com7=   15;
	Msk_B8=   16;
	Msk_Com8=   17;
	Msk_B9=   18;
	Msk_Com9=   19;
	Msk_B10=   20;
	Msk_Com10=   21;
	Msks_Cnx=   22;

	Extend_UData=   10;

	Exp_Users=    3;
	FTU_Users=    5;
	Extnd_Cnx=    6;
	Extnd_Ok=    7;
	Extnd_Warn=    8;

	Init_Stuff=   11;

	Init_FSys=    2;
	Init_FUser=    3;
	Init_FMask=    4;
	Init_Cnx=    5;
	Init_Doit=    6;

	User_Masks=   12;

	Umb1=    2;
	Usr_Msk1=    3;
	Umb2=    4;
	Usr_Msk2=    5;
	Umb3=    6;
	Usr_Msk3=    7;
	Umb4=    8;
	Usr_Msk4=    9;
	Umb5=   10;
	Usr_Msk5=   11;
	Umb6=   12;
	Usr_Msk6=   13;
	Umb7=   14;
	Usr_Msk7=   15;
	Umb8=   16;
	Usr_Msk8=   17;
	Umb9=   18;
	Usr_Msk9=   19;
	Umb10=   20;
	Usr_Msk10=   21;
	Usr_Mok=   22;

	Update_Info=   13;

	Updt_Txt=    2;

	Info_Mesg=   14;


	Bits=   15;

	Bits_Txt=    2;
	Bit1=   37;
	Bit32=   68;
	Select_All=   70;
	Clear_ALL_2=   71;
	Bits_Cnx=   73;
	Bits_Ok=   74;

