
int fft(int *signal,int *spectre,int ability);
int ffti(int *spectre,int *signal,int ability);

