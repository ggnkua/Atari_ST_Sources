Scale_Factors
	dc	1.99999999999999/2.0
	dc	1.58740105196820/2.0
	dc	1.25992104989487/2.0
	dc	1.00000000000000/2.0
	dc	0.79370052598410/2.0
	dc	0.62996052494744/2.0
	dc	0.50000000000000/2.0
	dc	0.39685026299205/2.0
	dc	0.31498026247372/2.0
	dc	0.25000000000000/2.0
	dc	0.19842513149602/2.0
	dc	0.15749013123686/2.0
	dc	0.12500000000000/2.0
	dc	0.09921256574801/2.0
	dc	0.07874506561843/2.0
	dc	0.06250000000000/2.0
	dc	0.04960628287401/2.0
	dc	0.03937253280921/2.0
	dc	0.03125000000000/2.0
	dc	0.02480314143700/2.0
	dc	0.01968626640461/2.0
	dc	0.01562500000000/2.0
	dc	0.01240157071850/2.0
	dc	0.00984313320230/2.0
	dc	0.00781250000000/2.0
	dc	0.00620078535925/2.0
	dc	0.00492156660115/2.0
	dc	0.00390625000000/2.0
	dc	0.00310039267963/2.0
	dc	0.00246078330058/2.0
	dc	0.00195312500000/2.0
	dc	0.00155019633981/2.0
	dc	0.00123039165029/2.0
	dc	0.00097656250000/2.0
	dc	0.00077509816991/2.0
	dc	0.00061519582514/2.0
	dc	0.00048828125000/2.0
	dc	0.00038754908495/2.0
	dc	0.00030759791257/2.0
	dc	0.00024414062500/2.0
	dc	0.00019377454248/2.0
	dc	0.00015379895629/2.0
	dc	0.00012207031250/2.0
	dc	0.00009688727124/2.0
	dc	0.00007689947814/2.0
	dc	0.00006103515625/2.0
	dc	0.00004844363562/2.0
	dc	0.00003844973907/2.0
	dc	0.00003051757813/2.0
	dc	0.00002422181781/2.0
	dc	0.00001922486954/2.0
	dc	0.00001525878906/2.0
	dc	0.00001211090890/2.0
	dc	0.00000961243477/2.0
	dc	0.00000762939453/2.0
	dc	0.00000605545445/2.0
	dc	0.00000480621738/2.0
	dc	0.00000381469727/2.0
	dc	0.00000302772723/2.0
	dc	0.00000240310869/2.0
	dc	0.00000190734863/2.0
	dc	0.00000151386361/2.0
	dc	0.00000120155435/2.0
	dc	0.00000000000000/2.0
