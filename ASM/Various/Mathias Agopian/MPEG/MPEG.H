int debit_tbl[16]={1,32,64,96,128,160,192,224,256,288,320,352,384,416,448,0};
double frequence_tbl[4]={44.1,48.0,32.0};
uchar numBitsAlowed_tbl[16]={0,2,3,4,5,6,7,8,9,10,11,12,13,14,15,0};

