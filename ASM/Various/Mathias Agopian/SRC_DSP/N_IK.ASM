
vect_Nik
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.671558955
	dc	-0.803207531
	dc	-0.514102744
	dc	0.903989293
	dc	0.336889853
	dc	-0.970031253
	dc	-0.146730474
	dc	0.998795456
	dc	-0.049067674
	dc	-0.989176510
	dc	0.242980180
	dc	0.941544065
	dc	-0.427555093
	dc	-0.857728610
	dc	0.595699304
	dc	0.740951125
	dc	-0.740951125
	dc	-0.595699304
	dc	0.857728610
	dc	0.427555093
	dc	-0.941544065
	dc	-0.242980180
	dc	0.989176510
	dc	0.049067674
	dc	-0.998795456
	dc	0.146730474
	dc	0.970031253
	dc	-0.336889853
	dc	-0.903989293
	dc	0.514102744
	dc	0.803207531
	dc	-0.671558955
	dc	0.634393284
	dc	-0.881921264
	dc	-0.290284677
	dc	0.995184727
	dc	-0.098017140
	dc	-0.956940336
	dc	0.471396737
	dc	0.773010453
	dc	-0.773010453
	dc	-0.471396737
	dc	0.956940336
	dc	0.098017140
	dc	-0.995184727
	dc	0.290284677
	dc	0.881921264
	dc	-0.634393284
	dc	-0.634393284
	dc	0.881921264
	dc	0.290284677
	dc	-0.995184727
	dc	0.098017140
	dc	0.956940336
	dc	-0.471396737
	dc	-0.773010453
	dc	0.773010453
	dc	0.471396737
	dc	-0.956940336
	dc	-0.098017140
	dc	0.995184727
	dc	-0.290284677
	dc	-0.881921264
	dc	0.634393284
	dc	0.595699304
	dc	-0.941544065
	dc	-0.049067674
	dc	0.970031253
	dc	-0.514102744
	dc	-0.671558955
	dc	0.903989293
	dc	0.146730474
	dc	-0.989176510
	dc	0.427555093
	dc	0.740951125
	dc	-0.857728610
	dc	-0.242980180
	dc	0.998795456
	dc	-0.336889853
	dc	-0.803207531
	dc	0.803207531
	dc	0.336889853
	dc	-0.998795456
	dc	0.242980180
	dc	0.857728610
	dc	-0.740951125
	dc	-0.427555093
	dc	0.989176510
	dc	-0.146730474
	dc	-0.903989293
	dc	0.671558955
	dc	0.514102744
	dc	-0.970031253
	dc	0.049067674
	dc	0.941544065
	dc	-0.595699304
	dc	0.555570233
	dc	-0.980785280
	dc	0.195090322
	dc	0.831469612
	dc	-0.831469612
	dc	-0.195090322
	dc	0.980785280
	dc	-0.555570233
	dc	-0.555570233
	dc	0.980785280
	dc	-0.195090322
	dc	-0.831469612
	dc	0.831469612
	dc	0.195090322
	dc	-0.980785280
	dc	0.555570233
	dc	0.555570233
	dc	-0.980785280
	dc	0.195090322
	dc	0.831469612
	dc	-0.831469612
	dc	-0.195090322
	dc	0.980785280
	dc	-0.555570233
	dc	-0.555570233
	dc	0.980785280
	dc	-0.195090322
	dc	-0.831469612
	dc	0.831469612
	dc	0.195090322
	dc	-0.980785280
	dc	0.555570233
	dc	0.514102744
	dc	-0.998795456
	dc	0.427555093
	dc	0.595699304
	dc	-0.989176510
	dc	0.336889853
	dc	0.671558955
	dc	-0.970031253
	dc	0.242980180
	dc	0.740951125
	dc	-0.941544065
	dc	0.146730474
	dc	0.803207531
	dc	-0.903989293
	dc	0.049067674
	dc	0.857728610
	dc	-0.857728610
	dc	-0.049067674
	dc	0.903989293
	dc	-0.803207531
	dc	-0.146730474
	dc	0.941544065
	dc	-0.740951125
	dc	-0.242980180
	dc	0.970031253
	dc	-0.671558955
	dc	-0.336889853
	dc	0.989176510
	dc	-0.595699304
	dc	-0.427555093
	dc	0.998795456
	dc	-0.514102744
	dc	0.471396737
	dc	-0.995184727
	dc	0.634393284
	dc	0.290284677
	dc	-0.956940336
	dc	0.773010453
	dc	0.098017140
	dc	-0.881921264
	dc	0.881921264
	dc	-0.098017140
	dc	-0.773010453
	dc	0.956940336
	dc	-0.290284677
	dc	-0.634393284
	dc	0.995184727
	dc	-0.471396737
	dc	-0.471396737
	dc	0.995184727
	dc	-0.634393284
	dc	-0.290284677
	dc	0.956940336
	dc	-0.773010453
	dc	-0.098017140
	dc	0.881921264
	dc	-0.881921264
	dc	0.098017140
	dc	0.773010453
	dc	-0.956940336
	dc	0.290284677
	dc	0.634393284
	dc	-0.995184727
	dc	0.471396737
	dc	0.427555093
	dc	-0.970031253
	dc	0.803207531
	dc	-0.049067674
	dc	-0.740951125
	dc	0.989176510
	dc	-0.514102744
	dc	-0.336889853
	dc	0.941544065
	dc	-0.857728610
	dc	0.146730474
	dc	0.671558955
	dc	-0.998795456
	dc	0.595699304
	dc	0.242980180
	dc	-0.903989293
	dc	0.903989293
	dc	-0.242980180
	dc	-0.595699304
	dc	0.998795456
	dc	-0.671558955
	dc	-0.146730474
	dc	0.857728610
	dc	-0.941544065
	dc	0.336889853
	dc	0.514102744
	dc	-0.989176510
	dc	0.740951125
	dc	0.049067674
	dc	-0.803207531
	dc	0.970031253
	dc	-0.427555093
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.336889853
	dc	-0.857728610
	dc	0.989176510
	dc	-0.671558955
	dc	0.049067674
	dc	0.595699304
	dc	-0.970031253
	dc	0.903989293
	dc	-0.427555093
	dc	-0.242980180
	dc	0.803207531
	dc	-0.998795456
	dc	0.740951125
	dc	-0.146730474
	dc	-0.514102744
	dc	0.941544065
	dc	-0.941544065
	dc	0.514102744
	dc	0.146730474
	dc	-0.740951125
	dc	0.998795456
	dc	-0.803207531
	dc	0.242980180
	dc	0.427555093
	dc	-0.903989293
	dc	0.970031253
	dc	-0.595699304
	dc	-0.049067674
	dc	0.671558955
	dc	-0.989176510
	dc	0.857728610
	dc	-0.336889853
	dc	0.290284677
	dc	-0.773010453
	dc	0.995184727
	dc	-0.881921264
	dc	0.471396737
	dc	0.098017140
	dc	-0.634393284
	dc	0.956940336
	dc	-0.956940336
	dc	0.634393284
	dc	-0.098017140
	dc	-0.471396737
	dc	0.881921264
	dc	-0.995184727
	dc	0.773010453
	dc	-0.290284677
	dc	-0.290284677
	dc	0.773010453
	dc	-0.995184727
	dc	0.881921264
	dc	-0.471396737
	dc	-0.098017140
	dc	0.634393284
	dc	-0.956940336
	dc	0.956940336
	dc	-0.634393284
	dc	0.098017140
	dc	0.471396737
	dc	-0.881921264
	dc	0.995184727
	dc	-0.773010453
	dc	0.290284677
	dc	0.242980180
	dc	-0.671558955
	dc	0.941544065
	dc	-0.989176510
	dc	0.803207531
	dc	-0.427555093
	dc	-0.049067674
	dc	0.514102744
	dc	-0.857728610
	dc	0.998795456
	dc	-0.903989293
	dc	0.595699304
	dc	-0.146730474
	dc	-0.336889853
	dc	0.740951125
	dc	-0.970031253
	dc	0.970031253
	dc	-0.740951125
	dc	0.336889853
	dc	0.146730474
	dc	-0.595699304
	dc	0.903989293
	dc	-0.998795456
	dc	0.857728610
	dc	-0.514102744
	dc	0.049067674
	dc	0.427555093
	dc	-0.803207531
	dc	0.989176510
	dc	-0.941544065
	dc	0.671558955
	dc	-0.242980180
	dc	0.195090322
	dc	-0.555570233
	dc	0.831469612
	dc	-0.980785280
	dc	0.980785280
	dc	-0.831469612
	dc	0.555570233
	dc	-0.195090322
	dc	-0.195090322
	dc	0.555570233
	dc	-0.831469612
	dc	0.980785280
	dc	-0.980785280
	dc	0.831469612
	dc	-0.555570233
	dc	0.195090322
	dc	0.195090322
	dc	-0.555570233
	dc	0.831469612
	dc	-0.980785280
	dc	0.980785280
	dc	-0.831469612
	dc	0.555570233
	dc	-0.195090322
	dc	-0.195090322
	dc	0.555570233
	dc	-0.831469612
	dc	0.980785280
	dc	-0.980785280
	dc	0.831469612
	dc	-0.555570233
	dc	0.195090322
	dc	0.146730474
	dc	-0.427555093
	dc	0.671558955
	dc	-0.857728610
	dc	0.970031253
	dc	-0.998795456
	dc	0.941544065
	dc	-0.803207531
	dc	0.595699304
	dc	-0.336889853
	dc	0.049067674
	dc	0.242980180
	dc	-0.514102744
	dc	0.740951125
	dc	-0.903989293
	dc	0.989176510
	dc	-0.989176510
	dc	0.903989293
	dc	-0.740951125
	dc	0.514102744
	dc	-0.242980180
	dc	-0.049067674
	dc	0.336889853
	dc	-0.595699304
	dc	0.803207531
	dc	-0.941544065
	dc	0.998795456
	dc	-0.970031253
	dc	0.857728610
	dc	-0.671558955
	dc	0.427555093
	dc	-0.146730474
	dc	0.098017140
	dc	-0.290284677
	dc	0.471396737
	dc	-0.634393284
	dc	0.773010453
	dc	-0.881921264
	dc	0.956940336
	dc	-0.995184727
	dc	0.995184727
	dc	-0.956940336
	dc	0.881921264
	dc	-0.773010453
	dc	0.634393284
	dc	-0.471396737
	dc	0.290284677
	dc	-0.098017140
	dc	-0.098017140
	dc	0.290284677
	dc	-0.471396737
	dc	0.634393284
	dc	-0.773010453
	dc	0.881921264
	dc	-0.956940336
	dc	0.995184727
	dc	-0.995184727
	dc	0.956940336
	dc	-0.881921264
	dc	0.773010453
	dc	-0.634393284
	dc	0.471396737
	dc	-0.290284677
	dc	0.098017140
	dc	0.049067674
	dc	-0.146730474
	dc	0.242980180
	dc	-0.336889853
	dc	0.427555093
	dc	-0.514102744
	dc	0.595699304
	dc	-0.671558955
	dc	0.740951125
	dc	-0.803207531
	dc	0.857728610
	dc	-0.903989293
	dc	0.941544065
	dc	-0.970031253
	dc	0.989176510
	dc	-0.998795456
	dc	0.998795456
	dc	-0.989176510
	dc	0.970031253
	dc	-0.941544065
	dc	0.903989293
	dc	-0.857728610
	dc	0.803207531
	dc	-0.740951125
	dc	0.671558955
	dc	-0.595699304
	dc	0.514102744
	dc	-0.427555093
	dc	0.336889853
	dc	-0.242980180
	dc	0.146730474
	dc	-0.049067674
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	0.000000000
	dc	-0.000000000
	dc	-0.049067674
	dc	0.146730474
	dc	-0.242980180
	dc	0.336889853
	dc	-0.427555093
	dc	0.514102744
	dc	-0.595699304
	dc	0.671558955
	dc	-0.740951125
	dc	0.803207531
	dc	-0.857728610
	dc	0.903989293
	dc	-0.941544065
	dc	0.970031253
	dc	-0.989176510
	dc	0.998795456
	dc	-0.998795456
	dc	0.989176510
	dc	-0.970031253
	dc	0.941544065
	dc	-0.903989293
	dc	0.857728610
	dc	-0.803207531
	dc	0.740951125
	dc	-0.671558955
	dc	0.595699304
	dc	-0.514102744
	dc	0.427555093
	dc	-0.336889853
	dc	0.242980180
	dc	-0.146730474
	dc	0.049067674
	dc	-0.098017140
	dc	0.290284677
	dc	-0.471396737
	dc	0.634393284
	dc	-0.773010453
	dc	0.881921264
	dc	-0.956940336
	dc	0.995184727
	dc	-0.995184727
	dc	0.956940336
	dc	-0.881921264
	dc	0.773010453
	dc	-0.634393284
	dc	0.471396737
	dc	-0.290284677
	dc	0.098017140
	dc	0.098017140
	dc	-0.290284677
	dc	0.471396737
	dc	-0.634393284
	dc	0.773010453
	dc	-0.881921264
	dc	0.956940336
	dc	-0.995184727
	dc	0.995184727
	dc	-0.956940336
	dc	0.881921264
	dc	-0.773010453
	dc	0.634393284
	dc	-0.471396737
	dc	0.290284677
	dc	-0.098017140
	dc	-0.146730474
	dc	0.427555093
	dc	-0.671558955
	dc	0.857728610
	dc	-0.970031253
	dc	0.998795456
	dc	-0.941544065
	dc	0.803207531
	dc	-0.595699304
	dc	0.336889853
	dc	-0.049067674
	dc	-0.242980180
	dc	0.514102744
	dc	-0.740951125
	dc	0.903989293
	dc	-0.989176510
	dc	0.989176510
	dc	-0.903989293
	dc	0.740951125
	dc	-0.514102744
	dc	0.242980180
	dc	0.049067674
	dc	-0.336889853
	dc	0.595699304
	dc	-0.803207531
	dc	0.941544065
	dc	-0.998795456
	dc	0.970031253
	dc	-0.857728610
	dc	0.671558955
	dc	-0.427555093
	dc	0.146730474
	dc	-0.195090322
	dc	0.555570233
	dc	-0.831469612
	dc	0.980785280
	dc	-0.980785280
	dc	0.831469612
	dc	-0.555570233
	dc	0.195090322
	dc	0.195090322
	dc	-0.555570233
	dc	0.831469612
	dc	-0.980785280
	dc	0.980785280
	dc	-0.831469612
	dc	0.555570233
	dc	-0.195090322
	dc	-0.195090322
	dc	0.555570233
	dc	-0.831469612
	dc	0.980785280
	dc	-0.980785280
	dc	0.831469612
	dc	-0.555570233
	dc	0.195090322
	dc	0.195090322
	dc	-0.555570233
	dc	0.831469612
	dc	-0.980785280
	dc	0.980785280
	dc	-0.831469612
	dc	0.555570233
	dc	-0.195090322
	dc	-0.242980180
	dc	0.671558955
	dc	-0.941544065
	dc	0.989176510
	dc	-0.803207531
	dc	0.427555093
	dc	0.049067674
	dc	-0.514102744
	dc	0.857728610
	dc	-0.998795456
	dc	0.903989293
	dc	-0.595699304
	dc	0.146730474
	dc	0.336889853
	dc	-0.740951125
	dc	0.970031253
	dc	-0.970031253
	dc	0.740951125
	dc	-0.336889853
	dc	-0.146730474
	dc	0.595699304
	dc	-0.903989293
	dc	0.998795456
	dc	-0.857728610
	dc	0.514102744
	dc	-0.049067674
	dc	-0.427555093
	dc	0.803207531
	dc	-0.989176510
	dc	0.941544065
	dc	-0.671558955
	dc	0.242980180
	dc	-0.290284677
	dc	0.773010453
	dc	-0.995184727
	dc	0.881921264
	dc	-0.471396737
	dc	-0.098017140
	dc	0.634393284
	dc	-0.956940336
	dc	0.956940336
	dc	-0.634393284
	dc	0.098017140
	dc	0.471396737
	dc	-0.881921264
	dc	0.995184727
	dc	-0.773010453
	dc	0.290284677
	dc	0.290284677
	dc	-0.773010453
	dc	0.995184727
	dc	-0.881921264
	dc	0.471396737
	dc	0.098017140
	dc	-0.634393284
	dc	0.956940336
	dc	-0.956940336
	dc	0.634393284
	dc	-0.098017140
	dc	-0.471396737
	dc	0.881921264
	dc	-0.995184727
	dc	0.773010453
	dc	-0.290284677
	dc	-0.336889853
	dc	0.857728610
	dc	-0.989176510
	dc	0.671558955
	dc	-0.049067674
	dc	-0.595699304
	dc	0.970031253
	dc	-0.903989293
	dc	0.427555093
	dc	0.242980180
	dc	-0.803207531
	dc	0.998795456
	dc	-0.740951125
	dc	0.146730474
	dc	0.514102744
	dc	-0.941544065
	dc	0.941544065
	dc	-0.514102744
	dc	-0.146730474
	dc	0.740951125
	dc	-0.998795456
	dc	0.803207531
	dc	-0.242980180
	dc	-0.427555093
	dc	0.903989293
	dc	-0.970031253
	dc	0.595699304
	dc	0.049067674
	dc	-0.671558955
	dc	0.989176510
	dc	-0.857728610
	dc	0.336889853
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.382683432
	dc	0.923879533
	dc	-0.923879533
	dc	0.382683432
	dc	0.382683432
	dc	-0.923879533
	dc	0.923879533
	dc	-0.382683432
	dc	-0.427555093
	dc	0.970031253
	dc	-0.803207531
	dc	0.049067674
	dc	0.740951125
	dc	-0.989176510
	dc	0.514102744
	dc	0.336889853
	dc	-0.941544065
	dc	0.857728610
	dc	-0.146730474
	dc	-0.671558955
	dc	0.998795456
	dc	-0.595699304
	dc	-0.242980180
	dc	0.903989293
	dc	-0.903989293
	dc	0.242980180
	dc	0.595699304
	dc	-0.998795456
	dc	0.671558955
	dc	0.146730474
	dc	-0.857728610
	dc	0.941544065
	dc	-0.336889853
	dc	-0.514102744
	dc	0.989176510
	dc	-0.740951125
	dc	-0.049067674
	dc	0.803207531
	dc	-0.970031253
	dc	0.427555093
	dc	-0.471396737
	dc	0.995184727
	dc	-0.634393284
	dc	-0.290284677
	dc	0.956940336
	dc	-0.773010453
	dc	-0.098017140
	dc	0.881921264
	dc	-0.881921264
	dc	0.098017140
	dc	0.773010453
	dc	-0.956940336
	dc	0.290284677
	dc	0.634393284
	dc	-0.995184727
	dc	0.471396737
	dc	0.471396737
	dc	-0.995184727
	dc	0.634393284
	dc	0.290284677
	dc	-0.956940336
	dc	0.773010453
	dc	0.098017140
	dc	-0.881921264
	dc	0.881921264
	dc	-0.098017140
	dc	-0.773010453
	dc	0.956940336
	dc	-0.290284677
	dc	-0.634393284
	dc	0.995184727
	dc	-0.471396737
	dc	-0.514102744
	dc	0.998795456
	dc	-0.427555093
	dc	-0.595699304
	dc	0.989176510
	dc	-0.336889853
	dc	-0.671558955
	dc	0.970031253
	dc	-0.242980180
	dc	-0.740951125
	dc	0.941544065
	dc	-0.146730474
	dc	-0.803207531
	dc	0.903989293
	dc	-0.049067674
	dc	-0.857728610
	dc	0.857728610
	dc	0.049067674
	dc	-0.903989293
	dc	0.803207531
	dc	0.146730474
	dc	-0.941544065
	dc	0.740951125
	dc	0.242980180
	dc	-0.970031253
	dc	0.671558955
	dc	0.336889853
	dc	-0.989176510
	dc	0.595699304
	dc	0.427555093
	dc	-0.998795456
	dc	0.514102744
	dc	-0.555570233
	dc	0.980785280
	dc	-0.195090322
	dc	-0.831469612
	dc	0.831469612
	dc	0.195090322
	dc	-0.980785280
	dc	0.555570233
	dc	0.555570233
	dc	-0.980785280
	dc	0.195090322
	dc	0.831469612
	dc	-0.831469612
	dc	-0.195090322
	dc	0.980785280
	dc	-0.555570233
	dc	-0.555570233
	dc	0.980785280
	dc	-0.195090322
	dc	-0.831469612
	dc	0.831469612
	dc	0.195090322
	dc	-0.980785280
	dc	0.555570233
	dc	0.555570233
	dc	-0.980785280
	dc	0.195090322
	dc	0.831469612
	dc	-0.831469612
	dc	-0.195090322
	dc	0.980785280
	dc	-0.555570233
	dc	-0.595699304
	dc	0.941544065
	dc	0.049067674
	dc	-0.970031253
	dc	0.514102744
	dc	0.671558955
	dc	-0.903989293
	dc	-0.146730474
	dc	0.989176510
	dc	-0.427555093
	dc	-0.740951125
	dc	0.857728610
	dc	0.242980180
	dc	-0.998795456
	dc	0.336889853
	dc	0.803207531
	dc	-0.803207531
	dc	-0.336889853
	dc	0.998795456
	dc	-0.242980180
	dc	-0.857728610
	dc	0.740951125
	dc	0.427555093
	dc	-0.989176510
	dc	0.146730474
	dc	0.903989293
	dc	-0.671558955
	dc	-0.514102744
	dc	0.970031253
	dc	-0.049067674
	dc	-0.941544065
	dc	0.595699304
	dc	-0.634393284
	dc	0.881921264
	dc	0.290284677
	dc	-0.995184727
	dc	0.098017140
	dc	0.956940336
	dc	-0.471396737
	dc	-0.773010453
	dc	0.773010453
	dc	0.471396737
	dc	-0.956940336
	dc	-0.098017140
	dc	0.995184727
	dc	-0.290284677
	dc	-0.881921264
	dc	0.634393284
	dc	0.634393284
	dc	-0.881921264
	dc	-0.290284677
	dc	0.995184727
	dc	-0.098017140
	dc	-0.956940336
	dc	0.471396737
	dc	0.773010453
	dc	-0.773010453
	dc	-0.471396737
	dc	0.956940336
	dc	0.098017140
	dc	-0.995184727
	dc	0.290284677
	dc	0.881921264
	dc	-0.634393284
	dc	-0.671558955
	dc	0.803207531
	dc	0.514102744
	dc	-0.903989293
	dc	-0.336889853
	dc	0.970031253
	dc	0.146730474
	dc	-0.998795456
	dc	0.049067674
	dc	0.989176510
	dc	-0.242980180
	dc	-0.941544065
	dc	0.427555093
	dc	0.857728610
	dc	-0.595699304
	dc	-0.740951125
	dc	0.740951125
	dc	0.595699304
	dc	-0.857728610
	dc	-0.427555093
	dc	0.941544065
	dc	0.242980180
	dc	-0.989176510
	dc	-0.049067674
	dc	0.998795456
	dc	-0.146730474
	dc	-0.970031253
	dc	0.336889853
	dc	0.903989293
	dc	-0.514102744
	dc	-0.803207531
	dc	0.671558955
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.707106781
	dc	0.707106781
	dc	0.707106781
	dc	-0.707106781
	dc	-0.740951125
	dc	0.595699304
	dc	0.857728610
	dc	-0.427555093
	dc	-0.941544065
	dc	0.242980180
	dc	0.989176510
	dc	-0.049067674
	dc	-0.998795456
	dc	-0.146730474
	dc	0.970031253
	dc	0.336889853
	dc	-0.903989293
	dc	-0.514102744
	dc	0.803207531
	dc	0.671558955
	dc	-0.671558955
	dc	-0.803207531
	dc	0.514102744
	dc	0.903989293
	dc	-0.336889853
	dc	-0.970031253
	dc	0.146730474
	dc	0.998795456
	dc	0.049067674
	dc	-0.989176510
	dc	-0.242980180
	dc	0.941544065
	dc	0.427555093
	dc	-0.857728610
	dc	-0.595699304
	dc	0.740951125
	dc	-0.773010453
	dc	0.471396737
	dc	0.956940336
	dc	-0.098017140
	dc	-0.995184727
	dc	-0.290284677
	dc	0.881921264
	dc	0.634393284
	dc	-0.634393284
	dc	-0.881921264
	dc	0.290284677
	dc	0.995184727
	dc	0.098017140
	dc	-0.956940336
	dc	-0.471396737
	dc	0.773010453
	dc	0.773010453
	dc	-0.471396737
	dc	-0.956940336
	dc	0.098017140
	dc	0.995184727
	dc	0.290284677
	dc	-0.881921264
	dc	-0.634393284
	dc	0.634393284
	dc	0.881921264
	dc	-0.290284677
	dc	-0.995184727
	dc	-0.098017140
	dc	0.956940336
	dc	0.471396737
	dc	-0.773010453
	dc	-0.803207531
	dc	0.336889853
	dc	0.998795456
	dc	0.242980180
	dc	-0.857728610
	dc	-0.740951125
	dc	0.427555093
	dc	0.989176510
	dc	0.146730474
	dc	-0.903989293
	dc	-0.671558955
	dc	0.514102744
	dc	0.970031253
	dc	0.049067674
	dc	-0.941544065
	dc	-0.595699304
	dc	0.595699304
	dc	0.941544065
	dc	-0.049067674
	dc	-0.970031253
	dc	-0.514102744
	dc	0.671558955
	dc	0.903989293
	dc	-0.146730474
	dc	-0.989176510
	dc	-0.427555093
	dc	0.740951125
	dc	0.857728610
	dc	-0.242980180
	dc	-0.998795456
	dc	-0.336889853
	dc	0.803207531
	dc	-0.831469612
	dc	0.195090322
	dc	0.980785280
	dc	0.555570233
	dc	-0.555570233
	dc	-0.980785280
	dc	-0.195090322
	dc	0.831469612
	dc	0.831469612
	dc	-0.195090322
	dc	-0.980785280
	dc	-0.555570233
	dc	0.555570233
	dc	0.980785280
	dc	0.195090322
	dc	-0.831469612
	dc	-0.831469612
	dc	0.195090322
	dc	0.980785280
	dc	0.555570233
	dc	-0.555570233
	dc	-0.980785280
	dc	-0.195090322
	dc	0.831469612
	dc	0.831469612
	dc	-0.195090322
	dc	-0.980785280
	dc	-0.555570233
	dc	0.555570233
	dc	0.980785280
	dc	0.195090322
	dc	-0.831469612
	dc	-0.857728610
	dc	0.049067674
	dc	0.903989293
	dc	0.803207531
	dc	-0.146730474
	dc	-0.941544065
	dc	-0.740951125
	dc	0.242980180
	dc	0.970031253
	dc	0.671558955
	dc	-0.336889853
	dc	-0.989176510
	dc	-0.595699304
	dc	0.427555093
	dc	0.998795456
	dc	0.514102744
	dc	-0.514102744
	dc	-0.998795456
	dc	-0.427555093
	dc	0.595699304
	dc	0.989176510
	dc	0.336889853
	dc	-0.671558955
	dc	-0.970031253
	dc	-0.242980180
	dc	0.740951125
	dc	0.941544065
	dc	0.146730474
	dc	-0.803207531
	dc	-0.903989293
	dc	-0.049067674
	dc	0.857728610
	dc	-0.881921264
	dc	-0.098017140
	dc	0.773010453
	dc	0.956940336
	dc	0.290284677
	dc	-0.634393284
	dc	-0.995184727
	dc	-0.471396737
	dc	0.471396737
	dc	0.995184727
	dc	0.634393284
	dc	-0.290284677
	dc	-0.956940336
	dc	-0.773010453
	dc	0.098017140
	dc	0.881921264
	dc	0.881921264
	dc	0.098017140
	dc	-0.773010453
	dc	-0.956940336
	dc	-0.290284677
	dc	0.634393284
	dc	0.995184727
	dc	0.471396737
	dc	-0.471396737
	dc	-0.995184727
	dc	-0.634393284
	dc	0.290284677
	dc	0.956940336
	dc	0.773010453
	dc	-0.098017140
	dc	-0.881921264
	dc	-0.903989293
	dc	-0.242980180
	dc	0.595699304
	dc	0.998795456
	dc	0.671558955
	dc	-0.146730474
	dc	-0.857728610
	dc	-0.941544065
	dc	-0.336889853
	dc	0.514102744
	dc	0.989176510
	dc	0.740951125
	dc	-0.049067674
	dc	-0.803207531
	dc	-0.970031253
	dc	-0.427555093
	dc	0.427555093
	dc	0.970031253
	dc	0.803207531
	dc	0.049067674
	dc	-0.740951125
	dc	-0.989176510
	dc	-0.514102744
	dc	0.336889853
	dc	0.941544065
	dc	0.857728610
	dc	0.146730474
	dc	-0.671558955
	dc	-0.998795456
	dc	-0.595699304
	dc	0.242980180
	dc	0.903989293
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.941544065
	dc	-0.514102744
	dc	0.146730474
	dc	0.740951125
	dc	0.998795456
	dc	0.803207531
	dc	0.242980180
	dc	-0.427555093
	dc	-0.903989293
	dc	-0.970031253
	dc	-0.595699304
	dc	0.049067674
	dc	0.671558955
	dc	0.989176510
	dc	0.857728610
	dc	0.336889853
	dc	-0.336889853
	dc	-0.857728610
	dc	-0.989176510
	dc	-0.671558955
	dc	-0.049067674
	dc	0.595699304
	dc	0.970031253
	dc	0.903989293
	dc	0.427555093
	dc	-0.242980180
	dc	-0.803207531
	dc	-0.998795456
	dc	-0.740951125
	dc	-0.146730474
	dc	0.514102744
	dc	0.941544065
	dc	-0.956940336
	dc	-0.634393284
	dc	-0.098017140
	dc	0.471396737
	dc	0.881921264
	dc	0.995184727
	dc	0.773010453
	dc	0.290284677
	dc	-0.290284677
	dc	-0.773010453
	dc	-0.995184727
	dc	-0.881921264
	dc	-0.471396737
	dc	0.098017140
	dc	0.634393284
	dc	0.956940336
	dc	0.956940336
	dc	0.634393284
	dc	0.098017140
	dc	-0.471396737
	dc	-0.881921264
	dc	-0.995184727
	dc	-0.773010453
	dc	-0.290284677
	dc	0.290284677
	dc	0.773010453
	dc	0.995184727
	dc	0.881921264
	dc	0.471396737
	dc	-0.098017140
	dc	-0.634393284
	dc	-0.956940336
	dc	-0.970031253
	dc	-0.740951125
	dc	-0.336889853
	dc	0.146730474
	dc	0.595699304
	dc	0.903989293
	dc	0.998795456
	dc	0.857728610
	dc	0.514102744
	dc	0.049067674
	dc	-0.427555093
	dc	-0.803207531
	dc	-0.989176510
	dc	-0.941544065
	dc	-0.671558955
	dc	-0.242980180
	dc	0.242980180
	dc	0.671558955
	dc	0.941544065
	dc	0.989176510
	dc	0.803207531
	dc	0.427555093
	dc	-0.049067674
	dc	-0.514102744
	dc	-0.857728610
	dc	-0.998795456
	dc	-0.903989293
	dc	-0.595699304
	dc	-0.146730474
	dc	0.336889853
	dc	0.740951125
	dc	0.970031253
	dc	-0.980785280
	dc	-0.831469612
	dc	-0.555570233
	dc	-0.195090322
	dc	0.195090322
	dc	0.555570233
	dc	0.831469612
	dc	0.980785280
	dc	0.980785280
	dc	0.831469612
	dc	0.555570233
	dc	0.195090322
	dc	-0.195090322
	dc	-0.555570233
	dc	-0.831469612
	dc	-0.980785280
	dc	-0.980785280
	dc	-0.831469612
	dc	-0.555570233
	dc	-0.195090322
	dc	0.195090322
	dc	0.555570233
	dc	0.831469612
	dc	0.980785280
	dc	0.980785280
	dc	0.831469612
	dc	0.555570233
	dc	0.195090322
	dc	-0.195090322
	dc	-0.555570233
	dc	-0.831469612
	dc	-0.980785280
	dc	-0.989176510
	dc	-0.903989293
	dc	-0.740951125
	dc	-0.514102744
	dc	-0.242980180
	dc	0.049067674
	dc	0.336889853
	dc	0.595699304
	dc	0.803207531
	dc	0.941544065
	dc	0.998795456
	dc	0.970031253
	dc	0.857728610
	dc	0.671558955
	dc	0.427555093
	dc	0.146730474
	dc	-0.146730474
	dc	-0.427555093
	dc	-0.671558955
	dc	-0.857728610
	dc	-0.970031253
	dc	-0.998795456
	dc	-0.941544065
	dc	-0.803207531
	dc	-0.595699304
	dc	-0.336889853
	dc	-0.049067674
	dc	0.242980180
	dc	0.514102744
	dc	0.740951125
	dc	0.903989293
	dc	0.989176510
	dc	-0.995184727
	dc	-0.956940336
	dc	-0.881921264
	dc	-0.773010453
	dc	-0.634393284
	dc	-0.471396737
	dc	-0.290284677
	dc	-0.098017140
	dc	0.098017140
	dc	0.290284677
	dc	0.471396737
	dc	0.634393284
	dc	0.773010453
	dc	0.881921264
	dc	0.956940336
	dc	0.995184727
	dc	0.995184727
	dc	0.956940336
	dc	0.881921264
	dc	0.773010453
	dc	0.634393284
	dc	0.471396737
	dc	0.290284677
	dc	0.098017140
	dc	-0.098017140
	dc	-0.290284677
	dc	-0.471396737
	dc	-0.634393284
	dc	-0.773010453
	dc	-0.881921264
	dc	-0.956940336
	dc	-0.995184727
	dc	-0.998795456
	dc	-0.989176510
	dc	-0.970031253
	dc	-0.941544065
	dc	-0.903989293
	dc	-0.857728610
	dc	-0.803207531
	dc	-0.740951125
	dc	-0.671558955
	dc	-0.595699304
	dc	-0.514102744
	dc	-0.427555093
	dc	-0.336889853
	dc	-0.242980180
	dc	-0.146730474
	dc	-0.049067674
	dc	0.049067674
	dc	0.146730474
	dc	0.242980180
	dc	0.336889853
	dc	0.427555093
	dc	0.514102744
	dc	0.595699304
	dc	0.671558955
	dc	0.740951125
	dc	0.803207531
	dc	0.857728610
	dc	0.903989293
	dc	0.941544065
	dc	0.970031253
	dc	0.989176510
	dc	0.998795456
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-1.000000000
	dc	-0.998795456
	dc	-0.989176510
	dc	-0.970031253
	dc	-0.941544065
	dc	-0.903989293
	dc	-0.857728610
	dc	-0.803207531
	dc	-0.740951125
	dc	-0.671558955
	dc	-0.595699304
	dc	-0.514102744
	dc	-0.427555093
	dc	-0.336889853
	dc	-0.242980180
	dc	-0.146730474
	dc	-0.049067674
	dc	0.049067674
	dc	0.146730474
	dc	0.242980180
	dc	0.336889853
	dc	0.427555093
	dc	0.514102744
	dc	0.595699304
	dc	0.671558955
	dc	0.740951125
	dc	0.803207531
	dc	0.857728610
	dc	0.903989293
	dc	0.941544065
	dc	0.970031253
	dc	0.989176510
	dc	0.998795456
	dc	-0.995184727
	dc	-0.956940336
	dc	-0.881921264
	dc	-0.773010453
	dc	-0.634393284
	dc	-0.471396737
	dc	-0.290284677
	dc	-0.098017140
	dc	0.098017140
	dc	0.290284677
	dc	0.471396737
	dc	0.634393284
	dc	0.773010453
	dc	0.881921264
	dc	0.956940336
	dc	0.995184727
	dc	0.995184727
	dc	0.956940336
	dc	0.881921264
	dc	0.773010453
	dc	0.634393284
	dc	0.471396737
	dc	0.290284677
	dc	0.098017140
	dc	-0.098017140
	dc	-0.290284677
	dc	-0.471396737
	dc	-0.634393284
	dc	-0.773010453
	dc	-0.881921264
	dc	-0.956940336
	dc	-0.995184727
	dc	-0.989176510
	dc	-0.903989293
	dc	-0.740951125
	dc	-0.514102744
	dc	-0.242980180
	dc	0.049067674
	dc	0.336889853
	dc	0.595699304
	dc	0.803207531
	dc	0.941544065
	dc	0.998795456
	dc	0.970031253
	dc	0.857728610
	dc	0.671558955
	dc	0.427555093
	dc	0.146730474
	dc	-0.146730474
	dc	-0.427555093
	dc	-0.671558955
	dc	-0.857728610
	dc	-0.970031253
	dc	-0.998795456
	dc	-0.941544065
	dc	-0.803207531
	dc	-0.595699304
	dc	-0.336889853
	dc	-0.049067674
	dc	0.242980180
	dc	0.514102744
	dc	0.740951125
	dc	0.903989293
	dc	0.989176510
	dc	-0.980785280
	dc	-0.831469612
	dc	-0.555570233
	dc	-0.195090322
	dc	0.195090322
	dc	0.555570233
	dc	0.831469612
	dc	0.980785280
	dc	0.980785280
	dc	0.831469612
	dc	0.555570233
	dc	0.195090322
	dc	-0.195090322
	dc	-0.555570233
	dc	-0.831469612
	dc	-0.980785280
	dc	-0.980785280
	dc	-0.831469612
	dc	-0.555570233
	dc	-0.195090322
	dc	0.195090322
	dc	0.555570233
	dc	0.831469612
	dc	0.980785280
	dc	0.980785280
	dc	0.831469612
	dc	0.555570233
	dc	0.195090322
	dc	-0.195090322
	dc	-0.555570233
	dc	-0.831469612
	dc	-0.980785280
	dc	-0.970031253
	dc	-0.740951125
	dc	-0.336889853
	dc	0.146730474
	dc	0.595699304
	dc	0.903989293
	dc	0.998795456
	dc	0.857728610
	dc	0.514102744
	dc	0.049067674
	dc	-0.427555093
	dc	-0.803207531
	dc	-0.989176510
	dc	-0.941544065
	dc	-0.671558955
	dc	-0.242980180
	dc	0.242980180
	dc	0.671558955
	dc	0.941544065
	dc	0.989176510
	dc	0.803207531
	dc	0.427555093
	dc	-0.049067674
	dc	-0.514102744
	dc	-0.857728610
	dc	-0.998795456
	dc	-0.903989293
	dc	-0.595699304
	dc	-0.146730474
	dc	0.336889853
	dc	0.740951125
	dc	0.970031253
	dc	-0.956940336
	dc	-0.634393284
	dc	-0.098017140
	dc	0.471396737
	dc	0.881921264
	dc	0.995184727
	dc	0.773010453
	dc	0.290284677
	dc	-0.290284677
	dc	-0.773010453
	dc	-0.995184727
	dc	-0.881921264
	dc	-0.471396737
	dc	0.098017140
	dc	0.634393284
	dc	0.956940336
	dc	0.956940336
	dc	0.634393284
	dc	0.098017140
	dc	-0.471396737
	dc	-0.881921264
	dc	-0.995184727
	dc	-0.773010453
	dc	-0.290284677
	dc	0.290284677
	dc	0.773010453
	dc	0.995184727
	dc	0.881921264
	dc	0.471396737
	dc	-0.098017140
	dc	-0.634393284
	dc	-0.956940336
	dc	-0.941544065
	dc	-0.514102744
	dc	0.146730474
	dc	0.740951125
	dc	0.998795456
	dc	0.803207531
	dc	0.242980180
	dc	-0.427555093
	dc	-0.903989293
	dc	-0.970031253
	dc	-0.595699304
	dc	0.049067674
	dc	0.671558955
	dc	0.989176510
	dc	0.857728610
	dc	0.336889853
	dc	-0.336889853
	dc	-0.857728610
	dc	-0.989176510
	dc	-0.671558955
	dc	-0.049067674
	dc	0.595699304
	dc	0.970031253
	dc	0.903989293
	dc	0.427555093
	dc	-0.242980180
	dc	-0.803207531
	dc	-0.998795456
	dc	-0.740951125
	dc	-0.146730474
	dc	0.514102744
	dc	0.941544065
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.923879533
	dc	-0.382683432
	dc	0.382683432
	dc	0.923879533
	dc	0.923879533
	dc	0.382683432
	dc	-0.382683432
	dc	-0.923879533
	dc	-0.903989293
	dc	-0.242980180
	dc	0.595699304
	dc	0.998795456
	dc	0.671558955
	dc	-0.146730474
	dc	-0.857728610
	dc	-0.941544065
	dc	-0.336889853
	dc	0.514102744
	dc	0.989176510
	dc	0.740951125
	dc	-0.049067674
	dc	-0.803207531
	dc	-0.970031253
	dc	-0.427555093
	dc	0.427555093
	dc	0.970031253
	dc	0.803207531
	dc	0.049067674
	dc	-0.740951125
	dc	-0.989176510
	dc	-0.514102744
	dc	0.336889853
	dc	0.941544065
	dc	0.857728610
	dc	0.146730474
	dc	-0.671558955
	dc	-0.998795456
	dc	-0.595699304
	dc	0.242980180
	dc	0.903989293
	dc	-0.881921264
	dc	-0.098017140
	dc	0.773010453
	dc	0.956940336
	dc	0.290284677
	dc	-0.634393284
	dc	-0.995184727
	dc	-0.471396737
	dc	0.471396737
	dc	0.995184727
	dc	0.634393284
	dc	-0.290284677
	dc	-0.956940336
	dc	-0.773010453
	dc	0.098017140
	dc	0.881921264
	dc	0.881921264
	dc	0.098017140
	dc	-0.773010453
	dc	-0.956940336
	dc	-0.290284677
	dc	0.634393284
	dc	0.995184727
	dc	0.471396737
	dc	-0.471396737
	dc	-0.995184727
	dc	-0.634393284
	dc	0.290284677
	dc	0.956940336
	dc	0.773010453
	dc	-0.098017140
	dc	-0.881921264
	dc	-0.857728610
	dc	0.049067674
	dc	0.903989293
	dc	0.803207531
	dc	-0.146730474
	dc	-0.941544065
	dc	-0.740951125
	dc	0.242980180
	dc	0.970031253
	dc	0.671558955
	dc	-0.336889853
	dc	-0.989176510
	dc	-0.595699304
	dc	0.427555093
	dc	0.998795456
	dc	0.514102744
	dc	-0.514102744
	dc	-0.998795456
	dc	-0.427555093
	dc	0.595699304
	dc	0.989176510
	dc	0.336889853
	dc	-0.671558955
	dc	-0.970031253
	dc	-0.242980180
	dc	0.740951125
	dc	0.941544065
	dc	0.146730474
	dc	-0.803207531
	dc	-0.903989293
	dc	-0.049067674
	dc	0.857728610
	dc	-0.831469612
	dc	0.195090322
	dc	0.980785280
	dc	0.555570233
	dc	-0.555570233
	dc	-0.980785280
	dc	-0.195090322
	dc	0.831469612
	dc	0.831469612
	dc	-0.195090322
	dc	-0.980785280
	dc	-0.555570233
	dc	0.555570233
	dc	0.980785280
	dc	0.195090322
	dc	-0.831469612
	dc	-0.831469612
	dc	0.195090322
	dc	0.980785280
	dc	0.555570233
	dc	-0.555570233
	dc	-0.980785280
	dc	-0.195090322
	dc	0.831469612
	dc	0.831469612
	dc	-0.195090322
	dc	-0.980785280
	dc	-0.555570233
	dc	0.555570233
	dc	0.980785280
	dc	0.195090322
	dc	-0.831469612
	dc	-0.803207531
	dc	0.336889853
	dc	0.998795456
	dc	0.242980180
	dc	-0.857728610
	dc	-0.740951125
	dc	0.427555093
	dc	0.989176510
	dc	0.146730474
	dc	-0.903989293
	dc	-0.671558955
	dc	0.514102744
	dc	0.970031253
	dc	0.049067674
	dc	-0.941544065
	dc	-0.595699304
	dc	0.595699304
	dc	0.941544065
	dc	-0.049067674
	dc	-0.970031253
	dc	-0.514102744
	dc	0.671558955
	dc	0.903989293
	dc	-0.146730474
	dc	-0.989176510
	dc	-0.427555093
	dc	0.740951125
	dc	0.857728610
	dc	-0.242980180
	dc	-0.998795456
	dc	-0.336889853
	dc	0.803207531
	dc	-0.773010453
	dc	0.471396737
	dc	0.956940336
	dc	-0.098017140
	dc	-0.995184727
	dc	-0.290284677
	dc	0.881921264
	dc	0.634393284
	dc	-0.634393284
	dc	-0.881921264
	dc	0.290284677
	dc	0.995184727
	dc	0.098017140
	dc	-0.956940336
	dc	-0.471396737
	dc	0.773010453
	dc	0.773010453
	dc	-0.471396737
	dc	-0.956940336
	dc	0.098017140
	dc	0.995184727
	dc	0.290284677
	dc	-0.881921264
	dc	-0.634393284
	dc	0.634393284
	dc	0.881921264
	dc	-0.290284677
	dc	-0.995184727
	dc	-0.098017140
	dc	0.956940336
	dc	0.471396737
	dc	-0.773010453
	dc	-0.740951125
	dc	0.595699304
	dc	0.857728610
	dc	-0.427555093
	dc	-0.941544065
	dc	0.242980180
	dc	0.989176510
	dc	-0.049067674
	dc	-0.998795456
	dc	-0.146730474
	dc	0.970031253
	dc	0.336889853
	dc	-0.903989293
	dc	-0.514102744
	dc	0.803207531
	dc	0.671558955
	dc	-0.671558955
	dc	-0.803207531
	dc	0.514102744
	dc	0.903989293
	dc	-0.336889853
	dc	-0.970031253
	dc	0.146730474
	dc	0.998795456
	dc	0.049067674
	dc	-0.989176510
	dc	-0.242980180
	dc	0.941544065
	dc	0.427555093
	dc	-0.857728610
	dc	-0.595699304
	dc	0.740951125