void SendKey(int scan,int ascii);

