#include <aes.h>

void PatchAes(void);
void UnpatchAes(void);
volatile extern OBJECT *menutree;