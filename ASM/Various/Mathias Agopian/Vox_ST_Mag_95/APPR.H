#include <aes.h>

void apprentissage(int objet);
void redraw_f0(OBJECT *adr,int x,int y,int w,int h);
void apprend(LISTE_MOTS *liste);
void recognize(LISTE_MOTS *liste);
void init_liste_mots(LISTE_MOTS *liste);
