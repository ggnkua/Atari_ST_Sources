
void call_main(int event,int wh,int objet,int *buf);
void InitRessource(void);
void fulled(void);
void resize(void);
void redraw_window(int index,GRECT *rect);
void byebye(void);
