/* Indices du ressource pour VOX */

#define F_ICONE  0   /* Formulaire/Dialogue */

#define F_INFOS  1   /* Formulaire/Dialogue */
#define INFOS_B_OK 12  /* BUTTON dans l'arbre F_INFOS */

#define M_MAIN   2   /* Arbre menu */
#define M0_INFOS 8   /* STRING dans l'arbre M_MAIN */
#define M0_LOAD  17  /* STRING dans l'arbre M_MAIN */
#define M0_SAVE  18  /* STRING dans l'arbre M_MAIN */
#define M0_QUIT  20  /* STRING dans l'arbre M_MAIN */
#define M0_APPR  22  /* STRING dans l'arbre M_MAIN */
#define M0_PARAM 24  /* STRING dans l'arbre M_MAIN */
#define M0_SEUIL 26  /* STRING dans l'arbre M_MAIN */
#define M0_RECO  27  /* STRING dans l'arbre M_MAIN */

#define F0       3   /* Formulaire/Dialogue */
#define F0_AFF   1   /* BOX dans l'arbre F0 */
#define F0_UP    2   /* BOXCHAR dans l'arbre F0 */
#define F0_DOWN  3   /* BOXCHAR dans l'arbre F0 */
#define F0_GLISS 4   /* BOX dans l'arbre F0 */
#define F0_CURS  5   /* BOX dans l'arbre F0 */
#define F0_B_APPR 7   /* BUTTON dans l'arbre F0 */
#define F0_B_EXIT 8   /* BUTTON dans l'arbre F0 */

#define BUREAU   4   /* Formulaire/Dialogue */

#define F01      5   /* Formulaire/Dialogue */
#define F01_EXIT 1   /* BUTTON dans l'arbre F01 */
#define F01_TXT_MOT 2   /* TEXT dans l'arbre F01 */
#define F01_TXT_TEXT 3   /* TEXT dans l'arbre F01 */

#define F1       6   /* Formulaire/Dialogue */
#define F1_MOT   6   /* TEXT dans l'arbre F1 */
#define F1_MARQUE 7   /* BOX dans l'arbre F1 */
#define F1_SEUIL 8   /* USERDEF dans l'arbre F1 */

#define F2       7   /* Formulaire/Dialogue */
#define F2_T1    7   /* USERDEF dans l'arbre F2 */
#define F2_T2    8   /* USERDEF dans l'arbre F2 */
#define F2_T3    9   /* USERDEF dans l'arbre F2 */
#define F2_T4    10  /* USERDEF dans l'arbre F2 */
#define F2_T5    11  /* USERDEF dans l'arbre F2 */
#define F2_OK    12  /* BUTTON dans l'arbre F2 */

#define A_RSRC_NOT_FOUND 0   /* Chaine Alerte */

#define A_NOT_FALCON 1   /* Chaine Alerte */

#define A_NO_MORE_MEM 2   /* Chaine Alerte */

#define A_LOD_NOT_FOUND 3   /* Chaine Alerte */

#define A_DSP_LOCKED 4   /* Chaine Alerte */

#define A_QUIT   5   /* Chaine Alerte */
