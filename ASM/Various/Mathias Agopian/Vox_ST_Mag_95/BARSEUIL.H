int cdecl BarSeuil(PARMBLK *para);

