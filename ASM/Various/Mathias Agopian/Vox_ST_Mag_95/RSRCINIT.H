void rsrc_init(char *filename);

