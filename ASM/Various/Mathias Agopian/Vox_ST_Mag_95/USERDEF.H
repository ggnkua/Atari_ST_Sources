/* objets utilisateur */