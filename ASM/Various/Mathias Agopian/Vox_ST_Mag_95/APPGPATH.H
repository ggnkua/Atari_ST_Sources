int app_get_path(char *path);
