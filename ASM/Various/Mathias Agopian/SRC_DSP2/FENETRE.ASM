fenetre
	dc	0.000000000/2.0
	dc	-0.000015259/2.0
	dc	-0.000015259/2.0
	dc	-0.000015259/2.0
	dc	-0.000015259/2.0
	dc	-0.000015259/2.0
	dc	-0.000015259/2.0
	dc	-0.000030518/2.0
	dc	-0.000030518/2.0
	dc	-0.000030518/2.0
	dc	-0.000030518/2.0
	dc	-0.000045776/2.0
	dc	-0.000045776/2.0
	dc	-0.000061035/2.0
	dc	-0.000061035/2.0
	dc	-0.000076294/2.0
	dc	-0.000076294/2.0
	dc	-0.000091553/2.0
	dc	-0.000106812/2.0
	dc	-0.000106812/2.0
	dc	-0.000122070/2.0
	dc	-0.000137329/2.0
	dc	-0.000152588/2.0
	dc	-0.000167847/2.0
	dc	-0.000198364/2.0
	dc	-0.000213623/2.0
	dc	-0.000244141/2.0
	dc	-0.000259399/2.0
	dc	-0.000289917/2.0
	dc	-0.000320435/2.0
	dc	-0.000366211/2.0
	dc	-0.000396729/2.0
	dc	-0.000442505/2.0
	dc	-0.000473022/2.0
	dc	-0.000534058/2.0
	dc	-0.000579834/2.0
	dc	-0.000625610/2.0
	dc	-0.000686646/2.0
	dc	-0.000747681/2.0
	dc	-0.000808716/2.0
	dc	-0.000885010/2.0
	dc	-0.000961304/2.0
	dc	-0.001037598/2.0
	dc	-0.001113892/2.0
	dc	-0.001205444/2.0
	dc	-0.001296997/2.0
	dc	-0.001388550/2.0
	dc	-0.001480103/2.0
	dc	-0.001586914/2.0
	dc	-0.001693726/2.0
	dc	-0.001785278/2.0
	dc	-0.001907349/2.0
	dc	-0.002014160/2.0
	dc	-0.002120972/2.0
	dc	-0.002243042/2.0
	dc	-0.002349854/2.0
	dc	-0.002456665/2.0
	dc	-0.002578735/2.0
	dc	-0.002685547/2.0
	dc	-0.002792358/2.0
	dc	-0.002899170/2.0
	dc	-0.002990723/2.0
	dc	-0.003082275/2.0
	dc	-0.003173828/2.0
	dc	0.003250122/2.0
	dc	0.003326416/2.0
	dc	0.003387451/2.0
	dc	0.003433228/2.0
	dc	0.003463745/2.0
	dc	0.003479004/2.0
	dc	0.003479004/2.0
	dc	0.003463745/2.0
	dc	0.003417969/2.0
	dc	0.003372192/2.0
	dc	0.003280640/2.0
	dc	0.003173828/2.0
	dc	0.003051758/2.0
	dc	0.002883911/2.0
	dc	0.002700806/2.0
	dc	0.002487183/2.0
	dc	0.002227783/2.0
	dc	0.001937866/2.0
	dc	0.001617432/2.0
	dc	0.001266479/2.0
	dc	0.000869751/2.0
	dc	0.000442505/2.0
	dc	-0.000030518/2.0
	dc	-0.000549316/2.0
	dc	-0.001098633/2.0
	dc	-0.001693726/2.0
	dc	-0.002334595/2.0
	dc	-0.003005981/2.0
	dc	-0.003723145/2.0
	dc	-0.004486084/2.0
	dc	-0.005294800/2.0
	dc	-0.006118774/2.0
	dc	-0.007003784/2.0
	dc	-0.007919312/2.0
	dc	-0.008865356/2.0
	dc	-0.009841919/2.0
	dc	-0.010848999/2.0
	dc	-0.011886597/2.0
	dc	-0.012939453/2.0
	dc	-0.014022827/2.0
	dc	-0.015121460/2.0
	dc	-0.016235352/2.0
	dc	-0.017349243/2.0
	dc	-0.018463135/2.0
	dc	-0.019577026/2.0
	dc	-0.020690918/2.0
	dc	-0.021789551/2.0
	dc	-0.022857666/2.0
	dc	-0.023910522/2.0
	dc	-0.024932861/2.0
	dc	-0.025909424/2.0
	dc	-0.026840210/2.0
	dc	-0.027725220/2.0
	dc	-0.028533936/2.0
	dc	-0.029281616/2.0
	dc	-0.029937744/2.0
	dc	-0.030532837/2.0
	dc	-0.031005859/2.0
	dc	-0.031387329/2.0
	dc	-0.031661987/2.0
	dc	-0.031814575/2.0
	dc	-0.031845093/2.0
	dc	-0.031738281/2.0
	dc	-0.031478882/2.0
	dc	0.031082153/2.0
	dc	0.030517578/2.0
	dc	0.029785156/2.0
	dc	0.028884888/2.0
	dc	0.027801514/2.0
	dc	0.026535034/2.0
	dc	0.025085449/2.0
	dc	0.023422241/2.0
	dc	0.021575928/2.0
	dc	0.019531250/2.0
	dc	0.017257690/2.0
	dc	0.014801025/2.0
	dc	0.012115479/2.0
	dc	0.009231567/2.0
	dc	0.006134033/2.0
	dc	0.002822876/2.0
	dc	-0.000686646/2.0
	dc	-0.004394531/2.0
	dc	-0.008316040/2.0
	dc	-0.012420654/2.0
	dc	-0.016708374/2.0
	dc	-0.021179199/2.0
	dc	-0.025817871/2.0
	dc	-0.030609131/2.0
	dc	-0.035552979/2.0
	dc	-0.040634155/2.0
	dc	-0.045837402/2.0
	dc	-0.051132202/2.0
	dc	-0.056533813/2.0
	dc	-0.061996460/2.0
	dc	-0.067520142/2.0
	dc	-0.073059082/2.0
	dc	-0.078628540/2.0
	dc	-0.084182739/2.0
	dc	-0.089706421/2.0
	dc	-0.095169067/2.0
	dc	-0.100540161/2.0
	dc	-0.105819702/2.0
	dc	-0.110946655/2.0
	dc	-0.115921021/2.0
	dc	-0.120697021/2.0
	dc	-0.125259399/2.0
	dc	-0.129562378/2.0
	dc	-0.133590698/2.0
	dc	-0.137298584/2.0
	dc	-0.140670776/2.0
	dc	-0.143676758/2.0
	dc	-0.146255493/2.0
	dc	-0.148422241/2.0
	dc	-0.150115967/2.0
	dc	-0.151306152/2.0
	dc	-0.151962280/2.0
	dc	-0.152069092/2.0
	dc	-0.151596069/2.0
	dc	-0.150497437/2.0
	dc	-0.148773193/2.0
	dc	-0.146362305/2.0
	dc	-0.143264771/2.0
	dc	-0.139450073/2.0
	dc	-0.134887695/2.0
	dc	-0.129577637/2.0
	dc	-0.123474121/2.0
	dc	-0.116577148/2.0
	dc	-0.108856201/2.0
	dc	0.100311279/2.0
	dc	0.090927124/2.0
	dc	0.080688477/2.0
	dc	0.069595337/2.0
	dc	0.057617187/2.0
	dc	0.044784546/2.0
	dc	0.031082153/2.0
	dc	0.016510010/2.0
	dc	0.001068115/2.0
	dc	-0.015228271/2.0
	dc	-0.032379150/2.0
	dc	-0.050354004/2.0
	dc	-0.069168091/2.0
	dc	-0.088775635/2.0
	dc	-0.109161377/2.0
	dc	-0.130310059/2.0
	dc	-0.152206421/2.0
	dc	-0.174789429/2.0
	dc	-0.198059082/2.0
	dc	-0.221984863/2.0
	dc	-0.246505737/2.0
	dc	-0.271591187/2.0
	dc	-0.297210693/2.0
	dc	-0.323318481/2.0
	dc	-0.349868774/2.0
	dc	-0.376800537/2.0
	dc	-0.404083252/2.0
	dc	-0.431655884/2.0
	dc	-0.459472656/2.0
	dc	-0.487472534/2.0
	dc	-0.515609741/2.0
	dc	-0.543823242/2.0
	dc	-0.572036743/2.0
	dc	-0.600219727/2.0
	dc	-0.628295898/2.0
	dc	-0.656219482/2.0
	dc	-0.683914185/2.0
	dc	-0.711318970/2.0
	dc	-0.738372803/2.0
	dc	-0.765029907/2.0
	dc	-0.791213989/2.0
	dc	-0.816864014/2.0
	dc	-0.841949463/2.0
	dc	-0.866363525/2.0
	dc	-0.890090942/2.0
	dc	-0.913055420/2.0
	dc	-0.935195923/2.0
	dc	-0.956481934/2.0
	dc	-0.976852417/2.0
	dc	-0.996246338/2.0
	dc	-1.014617920/2.0
	dc	-1.031936646/2.0
	dc	-1.048156738/2.0
	dc	-1.063217163/2.0
	dc	-1.077117920/2.0
	dc	-1.089782715/2.0
	dc	-1.101211548/2.0
	dc	-1.111373901/2.0
	dc	-1.120223999/2.0
	dc	-1.127746582/2.0
	dc	-1.133926392/2.0
	dc	-1.138763428/2.0
	dc	-1.142211914/2.0
	dc	-1.144287109/2.0
	dc	1.144989014/2.0
	dc	1.144287109/2.0
	dc	1.142211914/2.0
	dc	1.138763428/2.0
	dc	1.133926392/2.0
	dc	1.127746582/2.0
	dc	1.120223999/2.0
	dc	1.111373901/2.0
	dc	1.101211548/2.0
	dc	1.089782715/2.0
	dc	1.077117920/2.0
	dc	1.063217163/2.0
	dc	1.048156738/2.0
	dc	1.031936646/2.0
	dc	1.014617920/2.0
	dc	0.996246338/2.0
	dc	0.976852417/2.0
	dc	0.956481934/2.0
	dc	0.935195923/2.0
	dc	0.913055420/2.0
	dc	0.890090942/2.0
	dc	0.866363525/2.0
	dc	0.841949463/2.0
	dc	0.816864014/2.0
	dc	0.791213989/2.0
	dc	0.765029907/2.0
	dc	0.738372803/2.0
	dc	0.711318970/2.0
	dc	0.683914185/2.0
	dc	0.656219482/2.0
	dc	0.628295898/2.0
	dc	0.600219727/2.0
	dc	0.572036743/2.0
	dc	0.543823242/2.0
	dc	0.515609741/2.0
	dc	0.487472534/2.0
	dc	0.459472656/2.0
	dc	0.431655884/2.0
	dc	0.404083252/2.0
	dc	0.376800537/2.0
	dc	0.349868774/2.0
	dc	0.323318481/2.0
	dc	0.297210693/2.0
	dc	0.271591187/2.0
	dc	0.246505737/2.0
	dc	0.221984863/2.0
	dc	0.198059082/2.0
	dc	0.174789429/2.0
	dc	0.152206421/2.0
	dc	0.130310059/2.0
	dc	0.109161377/2.0
	dc	0.088775635/2.0
	dc	0.069168091/2.0
	dc	0.050354004/2.0
	dc	0.032379150/2.0
	dc	0.015228271/2.0
	dc	-0.001068115/2.0
	dc	-0.016510010/2.0
	dc	-0.031082153/2.0
	dc	-0.044784546/2.0
	dc	-0.057617187/2.0
	dc	-0.069595337/2.0
	dc	-0.080688477/2.0
	dc	-0.090927124/2.0
	dc	0.100311279/2.0
	dc	0.108856201/2.0
	dc	0.116577148/2.0
	dc	0.123474121/2.0
	dc	0.129577637/2.0
	dc	0.134887695/2.0
	dc	0.139450073/2.0
	dc	0.143264771/2.0
	dc	0.146362305/2.0
	dc	0.148773193/2.0
	dc	0.150497437/2.0
	dc	0.151596069/2.0
	dc	0.152069092/2.0
	dc	0.151962280/2.0
	dc	0.151306152/2.0
	dc	0.150115967/2.0
	dc	0.148422241/2.0
	dc	0.146255493/2.0
	dc	0.143676758/2.0
	dc	0.140670776/2.0
	dc	0.137298584/2.0
	dc	0.133590698/2.0
	dc	0.129562378/2.0
	dc	0.125259399/2.0
	dc	0.120697021/2.0
	dc	0.115921021/2.0
	dc	0.110946655/2.0
	dc	0.105819702/2.0
	dc	0.100540161/2.0
	dc	0.095169067/2.0
	dc	0.089706421/2.0
	dc	0.084182739/2.0
	dc	0.078628540/2.0
	dc	0.073059082/2.0
	dc	0.067520142/2.0
	dc	0.061996460/2.0
	dc	0.056533813/2.0
	dc	0.051132202/2.0
	dc	0.045837402/2.0
	dc	0.040634155/2.0
	dc	0.035552979/2.0
	dc	0.030609131/2.0
	dc	0.025817871/2.0
	dc	0.021179199/2.0
	dc	0.016708374/2.0
	dc	0.012420654/2.0
	dc	0.008316040/2.0
	dc	0.004394531/2.0
	dc	0.000686646/2.0
	dc	-0.002822876/2.0
	dc	-0.006134033/2.0
	dc	-0.009231567/2.0
	dc	-0.012115479/2.0
	dc	-0.014801025/2.0
	dc	-0.017257690/2.0
	dc	-0.019531250/2.0
	dc	-0.021575928/2.0
	dc	-0.023422241/2.0
	dc	-0.025085449/2.0
	dc	-0.026535034/2.0
	dc	-0.027801514/2.0
	dc	-0.028884888/2.0
	dc	-0.029785156/2.0
	dc	-0.030517578/2.0
	dc	0.031082153/2.0
	dc	0.031478882/2.0
	dc	0.031738281/2.0
	dc	0.031845093/2.0
	dc	0.031814575/2.0
	dc	0.031661987/2.0
	dc	0.031387329/2.0
	dc	0.031005859/2.0
	dc	0.030532837/2.0
	dc	0.029937744/2.0
	dc	0.029281616/2.0
	dc	0.028533936/2.0
	dc	0.027725220/2.0
	dc	0.026840210/2.0
	dc	0.025909424/2.0
	dc	0.024932861/2.0
	dc	0.023910522/2.0
	dc	0.022857666/2.0
	dc	0.021789551/2.0
	dc	0.020690918/2.0
	dc	0.019577026/2.0
	dc	0.018463135/2.0
	dc	0.017349243/2.0
	dc	0.016235352/2.0
	dc	0.015121460/2.0
	dc	0.014022827/2.0
	dc	0.012939453/2.0
	dc	0.011886597/2.0
	dc	0.010848999/2.0
	dc	0.009841919/2.0
	dc	0.008865356/2.0
	dc	0.007919312/2.0
	dc	0.007003784/2.0
	dc	0.006118774/2.0
	dc	0.005294800/2.0
	dc	0.004486084/2.0
	dc	0.003723145/2.0
	dc	0.003005981/2.0
	dc	0.002334595/2.0
	dc	0.001693726/2.0
	dc	0.001098633/2.0
	dc	0.000549316/2.0
	dc	0.000030518/2.0
	dc	-0.000442505/2.0
	dc	-0.000869751/2.0
	dc	-0.001266479/2.0
	dc	-0.001617432/2.0
	dc	-0.001937866/2.0
	dc	-0.002227783/2.0
	dc	-0.002487183/2.0
	dc	-0.002700806/2.0
	dc	-0.002883911/2.0
	dc	-0.003051758/2.0
	dc	-0.003173828/2.0
	dc	-0.003280640/2.0
	dc	-0.003372192/2.0
	dc	-0.003417969/2.0
	dc	-0.003463745/2.0
	dc	-0.003479004/2.0
	dc	-0.003479004/2.0
	dc	-0.003463745/2.0
	dc	-0.003433228/2.0
	dc	-0.003387451/2.0
	dc	-0.003326416/2.0
	dc	0.003250122/2.0
	dc	0.003173828/2.0
	dc	0.003082275/2.0
	dc	0.002990723/2.0
	dc	0.002899170/2.0
	dc	0.002792358/2.0
	dc	0.002685547/2.0
	dc	0.002578735/2.0
	dc	0.002456665/2.0
	dc	0.002349854/2.0
	dc	0.002243042/2.0
	dc	0.002120972/2.0
	dc	0.002014160/2.0
	dc	0.001907349/2.0
	dc	0.001785278/2.0
	dc	0.001693726/2.0
	dc	0.001586914/2.0
	dc	0.001480103/2.0
	dc	0.001388550/2.0
	dc	0.001296997/2.0
	dc	0.001205444/2.0
	dc	0.001113892/2.0
	dc	0.001037598/2.0
	dc	0.000961304/2.0
	dc	0.000885010/2.0
	dc	0.000808716/2.0
	dc	0.000747681/2.0
	dc	0.000686646/2.0
	dc	0.000625610/2.0
	dc	0.000579834/2.0
	dc	0.000534058/2.0
	dc	0.000473022/2.0
	dc	0.000442505/2.0
	dc	0.000396729/2.0
	dc	0.000366211/2.0
	dc	0.000320435/2.0
	dc	0.000289917/2.0
	dc	0.000259399/2.0
	dc	0.000244141/2.0
	dc	0.000213623/2.0
	dc	0.000198364/2.0
	dc	0.000167847/2.0
	dc	0.000152588/2.0
	dc	0.000137329/2.0
	dc	0.000122070/2.0
	dc	0.000106812/2.0
	dc	0.000106812/2.0
	dc	0.000091553/2.0
	dc	0.000076294/2.0
	dc	0.000076294/2.0
	dc	0.000061035/2.0
	dc	0.000061035/2.0
	dc	0.000045776/2.0
	dc	0.000045776/2.0
	dc	0.000030518/2.0
	dc	0.000030518/2.0
	dc	0.000030518/2.0
	dc	0.000030518/2.0
	dc	0.000015259/2.0
	dc	0.000015259/2.0
	dc	0.000015259/2.0
	dc	0.000015259/2.0
	dc	0.000015259/2.0
	dc	0.000015259/2.0