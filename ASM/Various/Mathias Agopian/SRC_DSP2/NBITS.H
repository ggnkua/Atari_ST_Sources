
uchar index_tbl_A[32]={4,4,4,4,4,4,4,4,4,4,4,3,3,3,3,3,3,3,3,3,3,3,3,2,2,2,2,0,0,0,0,0};
uchar numBits_tbl_A[32][16]={
{25,3,4,5,6,7,8,9,10,11,12,13,14,15,16},
{25,3,4,5,6,7,8,9,10,11,12,13,14,15,16},
{25,3,4,5,6,7,8,9,10,11,12,13,14,15,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0}
};

uchar index_tbl_B[32]={4,4,4,4,4,4,4,4,4,4,4,3,3,3,3,3,3,3,3,3,3,3,3,2,2,2,2,2,2,2,0,0};
uchar numBits_tbl_B[32][16]={
{25,3,4,5,6,7,8,9,10,11,12,13,14,15,16},
{25,3,4,5,6,7,8,9,10,11,12,13,14,15,16},
{25,3,4,5,6,7,8,9,10,11,12,13,14,15,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,6,7,8,9,10,11,12,13,16},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,3,30,4,5,16,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0},
{25,27,16,0,0,0,0,0,0,0,0,0,0,0,0}
};



uchar index_tbl_C[32]={4,4,3,3,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
uchar numBits_tbl_C[32][16]={
{25,27,30,4,5,6,7,8,9,10,11,12,13,14,15},
{25,27,30,4,5,6,7,8,9,10,11,12,13,14,15},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0}
};



uchar index_tbl_D[32]={4,4,3,3,3,3,3,3,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
uchar numBits_tbl_D[32][16]={
{25,27,30,4,5,6,7,8,9,10,11,12,13,14,15},
{25,27,30,4,5,6,7,8,9,10,11,12,13,14,15},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0},
{25,27,30,4,5,6,7,0,0,0,0,0,0,0,0}
};


