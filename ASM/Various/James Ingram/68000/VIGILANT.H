/* resource set indicies for VIGILANT */

#define BOOTSEC  0	/* form/dialog */

#define MENU     1	/* form/dialog */

#define CONFIG   2	/* form/dialog */

#define WAIT     3	/* form/dialog */

#define MEMFOUND 4	/* form/dialog */

#define MEMFREE  5	/* form/dialog */

#define STARTOK  6	/* form/dialog */

#define STARTBAD 7	/* form/dialog */

#define VIEWBOOT 8	/* form/dialog */

