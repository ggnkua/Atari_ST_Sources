* Get music data out!
* Music by Mad Max

* Extraction routines by James Ingram


* Enable "int" to hear music as it is extracted
;int	equ	1

	opt	x+
	opt	o-,ow-

	include	\includes\macros.s


	super_on

	moveq	#1,d0
	bsr	start
loop:
	ifd	int
	move.w	#37,-(a7)
	trap	#14		; wait 1/50th second
	addq.l	#2,a7
	endc


	bsr	play

	tst.w	flag
	bne.s	end		; branch if at end of music

	move.w	#$ff,-(a7)
	move.w	#6,-(a7)
	trap	#1		; abort if key pressed
	addq.l	#4,a7
	
	tst.w	d0
	beq.s	loop

	super_off

	clr.w	-(a7)
	trap	#1

end:
* save the music data!
	super_off

	lea	mus(pc),a0
	move.l	#mymus,a1
	move.l	addr,d0
	sub.l	a1,d0
	bsr	save_file
	
	clr.w	-(a7)
	trap	#1

mus:
	dc.b	"mus.bin",0
	even

	include	\includes\save.s


start:
	BRA	L0000
	BRA	L0001
play:
	BRA	L0008
L0000:
	MOVEM.L	A0-A6/D0-D7,-(A7)
	BSR	L0003
	MOVEM.L	(A7)+,A0-A6/D0-D7
	RTS
L0001:
	MOVEM.L	A0-A6/D0-D7,-(A7)
	BSR	L0002
	MOVEM.L	(A7)+,A0-A6/D0-D7
	RTS
L0002:
	LEA	L0051(PC),A0
	BSR	L0006
	MOVEA.L	L004F(PC),A1
	ANDI.L	#$FF,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADDA.W	D0,A1
	LEA	L004B(PC),A6
	MOVE.W	(A1)+,(A6)
	MOVE.W	(A1)+,D0
	ANDI.L	#$FF,D0
	BSR	L003A
	RTS
L0003:
	LEA	L0051(PC),A0
	BSR	L0006
	TST.W	D0
	BEQ	L0005
L0004:
	MOVEA.L	L004E(PC),A1
	ANDI.L	#$FF,D0
	SUBQ.L	#1,D0
	MULU	#6,D0
	ADDA.W	D0,A1
	MOVE.W	(A1)+,D0
	MOVE.W	(A1)+,D1
	LEA	L0040(PC),A6
	MOVE.W	(A1),(A6)+
	MOVE.W	(A1)+,(A6)+
	BSR	L0037
	RTS
L0005:
	MOVE.L	#1,D0
	BRA	L0004
L0006:
	MOVE.W	L0050(PC),D7
	BNE	L0007
	MOVEQ	#0,D7
	LEA	L0045(PC),A6
	MOVE.W	12(A0),(A6)
	LEA	32(A0),A1
	LEA	L0047(PC),A6
	MOVE.L	A1,(A6)
	MOVE.W	4(A0),D7
	ADDQ.W	#1,D7
	ASL.W	#6,D7
	ADDA.L	D7,A1
	LEA	L0048(PC),A6
	MOVE.L	A1,(A6)
	MOVE.W	6(A0),D7
	ADDQ.W	#1,D7
	ASL.W	#6,D7
	ADDA.L	D7,A1
	LEA	L0046(PC),A6
	MOVE.L	A1,(A6)
	MOVE.W	8(A0),D7
	ADDQ.W	#1,D7
	MOVE.W	12(A0),D6
	MULU	D6,D7
	ADDA.L	D7,A1
	LEA	L0049(PC),A6
	MOVE.L	A1,(A6)
	MOVEQ	#0,D7
	MOVE.W	10(A0),D7
	ADDQ.W	#1,D7
	MULU	#$C,D7
	ADDA.L	D7,A1
	LEA	L004E(PC),A6
	MOVE.L	A1,(A6)+
	MOVE.W	16(A0),D7
	ADDQ.W	#1,D7
	MULU	#6,D7
	ADDA.W	D7,A1
	MOVE.L	A1,(A6)+
	LEA	L0050(PC),A6
	MOVE.W	#1,(A6)
	LEA	L004C(PC),A6
	MOVE.W	#2,(A6)
L0007:
	RTS
L0008:
	LEA	L003E(PC),A6
	LEA	L0040(PC),A0
	TST.W	4(A0)
	BEQ.B	L0009
	CLR.B	34(A6)
	CLR.B	38(A6)
	CLR.B	42(A6)
	MOVEM.L	(A6),A0-A2/D0-D7
	MOVEM.L	A0-A2/D0-D7,$FFFF8800.W
	RTS
L0009:
	SUBQ.W	#1,(A0)
	BNE.B	L000A
	MOVE.W	2(A0),(A0)
	LEA	L0041(PC),A0
	BSR	L000D
	LEA	L0042(PC),A0
	BSR	L000D
	LEA	L0043(PC),A0
	BSR	L000D
L000A:
	LEA	L004A(PC),A5
	LEA	L0041(PC),A0
	BSR	L0014
	MOVE.W	D0,2(A5)
	MOVE.B	3(A5),2(A6)
	MOVE.B	2(A5),6(A6)
	MOVE.B	D1,34(A6)
	LEA	L0042(PC),A0
	BSR	L0014
	MOVE.W	D0,2(A5)
	MOVE.B	3(A5),10(A6)
	MOVE.B	2(A5),14(A6)
	MOVE.B	D1,38(A6)
	LEA	L0043(PC),A0
	BSR	L0014
	MOVE.W	D0,2(A5)
	MOVE.B	3(A5),18(A6)
	MOVE.B	2(A5),22(A6)
	MOVE.B	D1,42(A6)
	MOVE.W	4(A5),D0
	BEQ.B	L000C
	MOVE.W	D0,-(A7)
	LEA	L0044(PC),A0
	BSR	L0014
	MOVEA.L	10(A0),A1
	ADDA.L	14(A0),A1
	CMPI.B	#$E1,1(A1)
	BNE.B	L000B
	CLR.W	4(A5)
L000B:
	MOVE.W	(A7)+,D7
	LEA	L003F(PC),A1
	ADD.W	D7,D7
	ADD.W	D7,D7
	ADDA.W	D7,A1
	MOVEQ	#0,D6
	MOVE.B	(A1)+,D6
	MOVE.W	D0,2(A5)
	MOVE.B	D0,0(A6,D6.W)
	MOVE.B	(A1)+,D6
	MOVE.B	2(A5),0(A6,D6.W)
	MOVE.B	(A1)+,D6
	MOVE.B	D1,0(A6,D6.W)
L000C:
	MOVE.B	(A5)+,D7
	ORI.B	#$C0,D7
	MOVE.B	D7,30(A6)
	MOVE.B	(A5)+,26(A6)
	MOVEM.L	(A6),A0-A2/D0-D7
	MOVEM.L	A0-A2/D0-D7,$FFFF8800.W
* This is the playing bit!
* so keep the music data!
	move.l	addr,a5

	move.b	2(a6),(a5)+
	move.b	6(a6),(a5)+
	move.b	$a(a6),(a5)+
	move.b	$e(a6),(a5)+
	move.b	$12(a6),(a5)+
	move.b	$16(a6),(a5)+
	move.b	$1a(a6),(a5)+
	move.b	$1e(a6),(a5)+
	move.b	$22(a6),(a5)+
	move.b	$26(a6),(a5)+
	move.b	$2a(a6),(a5)+

	move.l	a5,addr

* 1 more bit played!
	addq.w	#1,count

	RTS
L000D:
	MOVEQ	#0,D5
	MOVEQ	#6,D6
	MOVE.W	L0045(PC),D7
	MOVEA.L	34(A0),A1
	ADDA.L	38(A0),A1
	MOVE.B	(A1),D0
	ANDI.W	#$7F,D0
	CMPI.W	#1,D0
	BEQ.B	L000E
	CMP.W	40(A0),D7
	BNE.B	L0011
L000E:
	MOVEA.L	52(A0),A3
	MOVEA.L	(A0),A2
	ADDA.L	4(A0),A2
	CMPA.L	A3,A2
	BNE.B	L000F
	MOVE.L	D5,4(A0)
	MOVEA.L	(A0),A2

* music looping! Set the STOP flag!
	st	flag

L000F:
	MOVEQ	#0,D1
	MOVE.B	(A2),D1
	MOVE.B	1(A2),44(A0)
	MOVE.B	2(A2),22(A0)
	MOVE.B	3(A2),D2
	ANDI.W	#$F0,D2
	CMPI.W	#$F0,D2
	BNE	L0010
	MOVE.B	3(A2),D2
	ANDI.B	#$F,D2
	MOVE.B	D2,60(A0)
L0010:
	MOVE.L	D5,38(A0)
	MULU	D7,D1
	MOVEA.L	L0046(PC),A3
	ADDA.L	D1,A3
	MOVE.L	A3,34(A0)
	ADDI.L	#$C,4(A0)
	MOVEA.L	34(A0),A1
	ADDA.L	38(A0),A1
L0011:
	MOVE.B	(A1)+,D0
	MOVE.B	D0,D1
	ANDI.W	#$7F,D1
	TST.W	D1
	BEQ	L0013
	MOVE.L	D5,56(A0)
	MOVE.B	D1,8(A0)
	MOVEA.L	A1,A3
	TST.L	38(A0)
	BNE.B	L0012
	ADDA.W	D7,A3
L0012:
	MOVE.B	-2(A3),31(A0)
	MOVE.B	(A1),9(A0)
	TST.B	D0
	BMI.B	L0013
	MOVE.B	(A1),D1
	ANDI.W	#$1F,D1
	ADD.B	22(A0),D1
	MOVEA.L	L0048(PC),A2
	ASL.W	D6,D1
	ADDA.W	D1,A2
	MOVE.L	D5,14(A0)
	MOVE.B	(A2),23(A0)
	MOVE.B	(A2)+,24(A0)
	MOVE.B	(A2)+,D1
	ANDI.W	#$FF,D1
	MOVE.B	(A2)+,27(A0)
	MOVEQ	#0,D0
	MOVE.B	#$40,46(A0)
	MOVE.B	(A2)+,D0
	MOVE.B	D0,28(A0)
	MOVE.B	D0,29(A0)
	MOVE.B	(A2)+,30(A0)
	MOVE.L	A2,10(A0)
	MOVEA.L	L0047(PC),A2
	ASL.W	D6,D1
	ADDA.W	D1,A2
	MOVE.L	A2,18(A0)
	MOVE.L	D5,48(A0)
	MOVE.B	D5,26(A0)
	MOVE.B	D5,25(A0)
L0013:
	ADDQ.L	#2,38(A0)
	RTS
L0014:
	MOVEQ	#0,D7
	MOVE.B	D7,32(A0)
L0015:
	TST.B	26(A0)
	BEQ.B	L0016
	SUBQ.B	#1,26(A0)
	BRA	L0020
L0016:
	MOVEA.L	18(A0),A1
	ADDA.L	48(A0),A1
L0017:
	CMPI.B	#$E1,(A1)
	BEQ	L0020
	CMPI.B	#$E0,(A1)
	BNE.B	L0018
	MOVE.B	1(A1),D0
	ANDI.L	#$3F,D0
	MOVE.L	D0,48(A0)
	MOVEA.L	18(A0),A1
	ADDA.L	D0,A1
L0018:
	CMPI.B	#$E2,(A1)
	BNE.B	L0019
	CLR.L	14(A0)
	MOVE.B	#1,23(A0)
	ADDQ.L	#1,48(A0)
	BRA.B	L0016
L0019:
	CMPI.B	#$E7,(A1)
	BNE.B	L001A
	MOVE.B	1(A1),D0
	ANDI.W	#$FF,D0
	ASL.W	#6,D0
	MOVEA.L	L0047(PC),A1
	ADDA.W	D0,A1
	MOVE.L	A1,18(A0)
	MOVE.L	D7,48(A0)
	BRA.B	L0017
L001A:
	CMPI.B	#$E8,(A1)
	BNE.B	L001B
	MOVE.B	1(A1),26(A0)
	ADDQ.L	#2,48(A0)
	BRA	L0015
L001B:
	CMPI.B	#$E4,(A1)
	BNE.B	L001C
	MOVE.B	D7,42(A0)
	MOVE.B	1(A1),32(A0)
	ADDQ.L	#2,48(A0)
	BRA.B	L001F
L001C:
	CMPI.B	#$E5,(A1)
	BNE.B	L001D
	MOVE.B	#1,42(A0)
	ADDQ.L	#1,48(A0)
	BRA	L0015
L001D:
	CMPI.B	#$E6,(A1)
	BNE.B	L001E
	MOVE.B	#2,42(A0)
	ADDQ.L	#1,48(A0)
	BRA.B	L001F
L001E:
	CMPI.B	#$E3,(A1)
	BNE.B	L001F
	ADDQ.L	#3,48(A0)
	MOVE.B	1(A1),27(A0)
	MOVE.B	2(A1),28(A0)
	NOP
L001F:
	MOVEA.L	18(A0),A1
	ADDA.L	48(A0),A1
	MOVE.B	(A1),43(A0)
	ADDQ.L	#1,48(A0)
L0020:
	TST.B	25(A0)
	BEQ.B	L0021
	SUBQ.B	#1,25(A0)
	BRA.B	L0025
L0021:
	SUBQ.B	#1,23(A0)
	BNE.B	L0025
	MOVE.B	24(A0),23(A0)
L0022:
	MOVEA.L	10(A0),A1
	ADDA.L	14(A0),A1
	MOVE.B	(A1),D0
	CMPI.B	#$E8,D0
	BNE	L0023
	ADDQ.L	#2,14(A0)
	MOVE.B	1(A1),25(A0)
	BRA	L0020
L0023:
	CMPI.B	#$E1,D0
	BEQ.B	L0025
	CMPI.B	#$E0,D0
	BNE.B	L0024
	MOVE.B	1(A1),D0
	ANDI.L	#$3F,D0
	SUBQ.L	#5,D0
	MOVE.L	D0,14(A0)
	BRA.B	L0022
L0024:
	MOVE.B	(A1),45(A0)
	ADDQ.L	#1,14(A0)
L0025:
	MOVE.B	43(A0),D0
	BMI.B	L0026
	ADD.B	8(A0),D0
	ADD.B	44(A0),D0
L0026:
	ANDI.W	#$7F,D0
	LEA	L004D(PC),A1
	ADD.W	D0,D0
	MOVE.W	D0,D1
	ADDA.W	D0,A1
	MOVE.W	(A1),D0
	MOVE.B	33(A0),D3
	MOVE.B	42(A0),D2
	ANDI.L	#$F,D2
	BNE.B	L0027
	BCLR	D3,(A5)
	ADDQ.W	#3,D3
	BCLR	D3,(A5)
	BRA.B	L002A
L0027:
	CMPI.B	#1,D2
	BNE.B	L0029
	BSET	D3,(A5)
	ADDQ.W	#3,D3
	BCLR	D3,(A5)
	MOVE.B	8(A0),32(A0)
	MOVE.B	43(A0),D4
	BPL.B	L0028
	ANDI.B	#$7F,D4
	MOVE.B	D4,32(A0)
	BRA.B	L002A
L0028:
	ADD.B	D4,32(A0)
	BRA.B	L002A
L0029:
	BCLR	D3,(A5)
	ADDQ.W	#3,D3
	BSET	D3,(A5)
L002A:
	TST.B	32(A0)
	BEQ.B	L002B
	MOVE.B	32(A0),D3
	ANDI.B	#$1F,D3
	EORI.B	#$1F,D3
	MOVE.B	D3,1(A5)
L002B:
	MOVE.B	46(A0),D7
	TST.B	30(A0)
	BEQ.B	L002C
	SUBQ.B	#1,30(A0)
	BRA.B	L0034
L002C:
	MOVE.B	D1,D5
	MOVE.B	28(A0),D4
	ADD.B	D4,D4
	MOVE.B	29(A0),D1
	TST.B	D7
	BPL.B	L002D
	BTST	#0,D7
	BNE.B	L0030
L002D:
	BTST	#5,D7
	BNE.B	L002E
	SUB.B	27(A0),D1
	BCC.B	L002F
	BSET	#5,D7
	MOVEQ	#0,D1
	BRA.B	L002F
L002E:
	ADD.B	27(A0),D1
	CMP.B	D4,D1
	BCS.B	L002F
	BCLR	#5,D7
	MOVE.B	D4,D1
L002F:
	MOVE.B	D1,29(A0)
L0030:
	LSR.B	#1,D4
	SUB.B	D4,D1
	BCC.B	L0031
	SUBI.W	#$100,D1
L0031:
	ADDI.B	#$A0,D5
	BCS.B	L0033
L0032:
	ADD.W	D1,D1
	ADDI.B	#$18,D5
	BCC.B	L0032
L0033:
	ADD.W	D1,D0
L0034:
	EORI.B	#1,D7
	MOVE.B	D7,46(A0)
	BTST	#5,9(A0)
	BEQ	L0035
	MOVEQ	#0,D7
	MOVE.W	D7,D1
	MOVE.B	31(A0),D1
	EXT.W	D1
	MOVE.L	56(A0),D2
	MOVEQ	#$C,D3
	ASL.L	D3,D1
	ADD.L	D1,D2
	MOVE.L	D2,56(A0)
	SWAP	D2
	SUB.W	D2,D0
L0035:
	MOVE.B	45(A0),D1
	SUB.B	60(A0),D1
	BPL	L0036
	MOVEQ	#0,D1
L0036:
	RTS
L0037:
	MOVE.L	D0,D7
	MULU	#$C,D7
	MOVE.L	D1,D6
	ADDQ.L	#1,D6
	MULU	#$C,D6
	MOVEQ	#2,D0
	LEA	L0041(PC),A0
	LEA	L003C(PC),A1
	LEA	L003D(PC),A2
L0038:
	MOVE.L	A1,10(A0)
	CLR.L	14(A0)
	MOVE.B	#0,45(A0)
	CLR.B	8(A0)
	CLR.B	9(A0)
	MOVE.L	A1,18(A0)
	CLR.L	48(A0)
	MOVE.B	#1,23(A0)
	MOVE.B	#1,24(A0)
	CLR.B	25(A0)
	CLR.B	26(A0)
	CLR.B	27(A0)
	CLR.B	28(A0)
	CLR.B	29(A0)
	CLR.W	30(A0)
	CLR.B	32(A0)
	MOVE.B	(A2),D3
	ANDI.L	#$F,D3
	ADD.W	D3,D3
	ADD.W	D3,D3
	MOVE.B	(A2)+,33(A0)
	MOVE.L	L0049(PC),(A0)
	MOVE.L	L0049(PC),52(A0)
	ADD.L	D6,52(A0)
	ADD.L	D3,52(A0)
	ADD.L	D7,(A0)
	ADD.L	D3,(A0)
	MOVE.L	#$C,4(A0)
	MOVEA.L	(A0),A3
	MOVE.B	(A3),D1
	ANDI.L	#$FF,D1
	MOVE.W	L0045(PC),D2
	MULU	D1,D2
	MOVEA.L	L0046(PC),A4
	ADDA.L	D2,A4
	MOVE.L	A4,34(A0)
	CLR.L	38(A0)
	MOVE.B	#2,42(A0)
	MOVE.B	1(A3),44(A0)
	CLR.B	43(A0)
	MOVE.B	2(A3),22(A0)
	CLR.B	60(A0)
	MOVE.B	3(A3),D1
	ANDI.W	#$F0,D1
	CMPI.W	#$F0,D1
	BNE	L0039
	MOVE.B	3(A3),D1
	ANDI.B	#$F,D1
	MOVE.B	D1,60(A0)
L0039:
	CLR.B	45(A0)
	CLR.W	56(A0)
	ADDA.L	#$3E,A0
	DBF	D0,L0038
	LEA	L0040(PC),A0
	MOVE.W	2(A0),(A0)
	CLR.W	4(A0)
	RTS
L003A:
	MOVE.W	L004B(PC),D2
	MOVE.W	L004C(PC),D1
	TST.W	D2
	BEQ	L003B
	LEA	L0044(PC),A0
	LEA	L004A(PC),A5
	MOVE.B	D2,8(A0)
	MOVE.B	D1,33(A0)
	CLR.B	22(A0)
	MOVEQ	#6,D6
	MOVEQ	#0,D5
	ANDI.W	#$1F,D0
	MOVEA.L	L0048(PC),A2
	ASL.W	D6,D0
	ADDA.W	D0,A2
	MOVE.L	D5,14(A0)
	MOVE.B	(A2),23(A0)
	MOVE.B	(A2)+,24(A0)
	MOVE.B	(A2)+,D0
	ANDI.W	#$FF,D0
	MOVE.B	(A2)+,27(A0)
	MOVEQ	#0,D2
	MOVE.B	#$40,46(A0)
	MOVE.B	(A2)+,D2
	MOVE.B	D2,28(A0)
	MOVE.B	D2,29(A0)
	MOVE.B	(A2)+,30(A0)
	MOVE.L	A2,10(A0)
	MOVEA.L	L0047(PC),A2
	ASL.W	D6,D0
	ADDA.W	D0,A2
	MOVE.L	A2,18(A0)
	MOVE.L	D5,48(A0)
	CLR.B	25(A0)
	CLR.B	26(A0)
	ADDQ.W	#1,D1
	MOVE.W	D1,4(A5)
L003B:
	RTS
L003C:
	DC.B	$01,$00,$00,$00,$00,$00,$00,$E1
L003D:
	DC.B	$00,$01,$02,$00
L003E:
	DC.B	$00,$00,$3E,$00,$01,$01,$01,$00,$02,$02,$EE,$00,$03,$03,$00,$00,$04,$04,$59,$00,$05,$05,$02,$00,$06,$06,$07,$00,$07,$07,$F8,$FF,$08,$08,$0E,$00,$09,$09,$0E,$00,$0A,$0A,$0F,$00
L003F:
	DC.B	$00,$00,$00,$00,$02,$06,$22,$00,$0A,$0E,$26,$00,$12,$16,$2A,$00
L0040:
	DC.B	$00,$02,$00,$02,$00,$00
L0041:
	DC.B	$00,$05,$13,$EA,$00,$00,$01,$44,$2B,$00,$00,$05,$0E,$6F,$00,$00,$00,$02,$00,$05,$0A,$6A,$0C,$02,$02,$00,$00,$01,$02,$02,$03,$00,$00,$00,$00,$05,$13,$6A,$00,$00,$00,$24,$02,$00,$00,$0E,$41,$00,$00,$00,$00,$04
	DC.B	$00,$05,$16,$EA,$00,$00,$00,$00,$00,$00
L0042:
	DC.B	$00,$05,$13,$EE,$00,$00,$01,$44,$30,$00,$00,$05,$0D,$AF,$00,$00,$00,$03,$00,$05,$0B,$2A,$09,$01,$01,$00,$00,$01,$01,$01,$00,$00,$00,$01,$00,$05,$11,$6A,$00,$00,$00,$24,$02,$00,$00,$0E,$61,$00,$00,$00,$00,$05
	DC.B	$00,$05,$16,$EE,$00,$00,$00,$00,$00,$00
L0043:
	DC.B	$00,$05,$13,$F2,$00,$00,$01,$44,$0C,$04,$00,$05,$0C,$EF,$00,$00,$00,$03,$00,$05,$0A,$EA,$02,$01,$01,$00,$00,$00,$00,$00,$00,$00,$00,$02,$00,$05,$10,$2A,$00,$00,$00,$24,$02,$A0,$FC,$0F,$41,$00,$00,$00,$00,$06
	DC.B	$00,$05,$16,$F2,$00,$00,$00,$00,$00,$00
L0044:
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
L0045:
	DC.B	$00,$40,$00,$00
L0046:
	DC.B	$00,$05,$0E,$AA
L0047:
	DC.B	$00,$05,$09,$6A
L0048:
	DC.B	$00,$05,$0B,$6A
L0049:
	DC.B	$00,$05,$13,$EA
L004A:
	DC.B	$38,$07,$02,$59,$00,$00
L004B:
	DC.B	$00,$00
L004C:
	DC.B	$00,$02
L004D:
	DC.B	$0E,$EE,$0E,$17,$0D,$4D,$0C,$8E,$0B,$D9,$0B,$2F,$0A,$8E,$09,$F7,$09,$67,$08,$E0,$08,$61,$07,$E8,$07,$77,$07,$0B,$06,$A6,$06,$47,$05,$EC,$05,$97,$05,$47,$04,$FB,$04,$B3,$04,$70,$04,$30,$03,$F4,$03,$BB,$03,$85
	DC.B	$03,$53,$03,$23,$02,$F6,$02,$CB,$02,$A3,$02,$7D,$02,$59,$02,$38,$02,$18,$01,$FA,$01,$DD,$01,$C2,$01,$A9,$01,$91,$01,$7B,$01,$65,$01,$51,$01,$3E,$01,$2C,$01,$1C,$01,$0C,$00,$FD,$00,$EE,$00,$E1,$00,$D4,$00,$C8
	DC.B	$00,$BD,$00,$B2,$00,$A8,$00,$9F,$00,$96,$00,$8E,$00,$86,$00,$7E,$00,$77,$00,$70,$00,$6A,$00,$64,$00,$5E,$00,$59,$00,$54,$00,$4F,$00,$4B,$00,$47,$00,$43,$00,$3F,$00,$3B,$00,$38,$00,$35,$00,$32,$00,$2F,$00,$2C
	DC.B	$00,$2A,$00,$27,$00,$25,$00,$23,$00,$21,$00,$1F,$00,$1D,$00,$1C,$00,$1A,$00,$19,$00,$17,$00,$16,$00,$15,$00,$13,$00,$12,$00,$11,$00,$10,$00,$0F
L004E:
	DC.B	$00,$05,$16,$EA
L004F:
	DC.B	$00,$05,$17,$02,$00,$00,$00,$00,$00,$00,$00,$00
L0050:
	DC.B	$00,$00
L0051:
	DC.B	$54,$46,$4D,$58,$00,$07,$00,$0C,$00,$14,$00,$3F,$00,$40,$00,$02,$00,$03,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$E2,$E6,$00,$00,$00,$00,$E3,$02,$03,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$E2,$E6,$00,$E1,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$E2,$E6,$93,$8C,$8A,$E5,$96,$E6,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$E2,$E6,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$E2,$E6,$00,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$E2,$E5,$98,$E6,$9E,$A0,$E5,$93,$95,$E0,$07,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$E2,$E5,$98,$E6,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$04,$00,$01,$02,$00,$0F,$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$01,$01,$02,$0A,$0F,$0E,$0D,$E1,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$02,$01,$02
	DC.B	$00,$0E,$0F,$0F,$0B,$0E,$0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A,$0A,$09,$09,$08,$08,$07,$07,$06,$06,$05,$05,$04,$04,$03,$03,$02,$02,$01,$01,$00,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$03,$01,$01,$02,$00,$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$03,$01,$01,$02,$00,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$03,$01,$01,$02,$00,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$06,$00,$00,$00,$0F,$0F,$0F
	DC.B	$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$01,$06,$00,$00,$00,$0D,$0D,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$06,$00,$00,$00,$0B,$0B,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$07,$01,$01,$00,$0D,$0F,$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$07,$01,$01,$00,$0A,$0C,$0B,$0A,$09,$08,$07
	DC.B	$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$01,$03,$01,$02,$0A,$0F,$0E,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$02,$04,$01,$02,$06,$0F,$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$32,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$2B,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$2B,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$33,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$33,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$33,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$0C,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$04,$00,$00,$00,$00,$00,$00,$0C,$05,$00,$00,$0C,$02,$00,$00,$0C,$06,$00,$00,$0C,$02,$00,$00,$0C,$00,$00,$00
	DC.B	$0C,$02,$00,$00,$0C,$00,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$04,$00,$00,$00,$00,$00,$00,$0C,$05,$00,$00,$0C,$02,$00,$00
	DC.B	$0C,$06,$00,$00,$0C,$03,$00,$00,$0A,$01,$00,$00,$00,$00,$00,$00,$0C,$00,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$01,$00,$00,$00,$00,$00,$00,$0C,$04,$00,$00
	DC.B	$00,$00,$00,$00,$0C,$05,$00,$00,$00,$00,$00,$00,$0C,$04,$00,$00,$00,$00,$00,$00,$0C,$04,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00
	DC.B	$30,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$2E,$00,$00,$00,$00,$00,$00,$00,$2E,$01,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$01,$00,$00
	DC.B	$00,$00,$00,$00,$2E,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$01,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$2E,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00
	DC.B	$30,$01,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$2E,$00,$00,$00,$00,$00,$00,$00,$2E,$01,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$01,$00,$00,$00,$00,$00,$00,$2E,$00,$00,$00
	DC.B	$00,$00,$00,$00,$2E,$01,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$01,$00,$00,$00,$00,$00,$00,$2E,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$01,$00,$00,$00,$00,$00,$00
	DC.B	$30,$00,$00,$00,$00,$00,$00,$00,$2E,$00,$00,$00,$00,$00,$00,$00,$2E,$01,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$33,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$37,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$35,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$2E,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$33,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$35,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$37,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00
	DC.B	$33,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$2B,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$33,$00,$00,$00
	DC.B	$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$2B,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$33,$00,$00,$00,$00,$00,$00,$00
	DC.B	$32,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$01,$00,$00,$00,$03,$00,$00,$00,$05,$0C,$01,$00,$02,$00,$00,$00,$04,$00,$00,$00,$00,$0C,$01,$00,$01,$00,$00,$00,$03,$00,$00,$00,$05,$08,$01,$00
	DC.B	$02,$00,$00,$00,$04,$00,$00,$00,$00,$08,$01,$00,$01,$00,$00,$00,$03,$00,$00,$00,$05,$0C,$01,$00,$02,$00,$00,$00,$04,$00,$00,$00,$00,$0C,$01,$00,$01,$00,$00,$00,$03,$00,$00,$00,$05,$13,$01,$00,$02,$00,$00,$00
	DC.B	$04,$00,$00,$00,$00,$07,$01,$00,$00,$00,$00,$00,$09,$00,$09,$00,$06,$00,$02,$00,$00,$00,$00,$00,$0A,$00,$09,$00,$07,$00,$02,$00,$00,$00,$00,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$00,$00,$00,$00,$0C,$00,$09,$00
	DC.B	$08,$FE,$02,$00,$00,$00,$00,$00,$09,$00,$09,$00,$06,$00,$02,$00,$00,$00,$00,$00,$0A,$00,$09,$00,$07,$00,$02,$00,$00,$00,$00,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$00,$00,$00,$00,$0C,$00,$09,$00,$08,$FE,$02,$00
	DC.B	$0D,$00,$0B,$00,$09,$00,$09,$00,$06,$00,$02,$00,$0E,$00,$0B,$00,$0A,$00,$09,$00,$07,$00,$02,$00,$0F,$00,$0B,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$10,$00,$0B,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$0D,$00,$0B,$00
	DC.B	$09,$00,$09,$00,$06,$00,$02,$00,$11,$00,$0B,$00,$0A,$00,$09,$00,$07,$00,$02,$00,$12,$00,$0B,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$00,$00,$0B,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$13,$00,$0C,$00,$09,$00,$09,$00
	DC.B	$06,$00,$02,$00,$14,$00,$0C,$00,$0A,$00,$09,$00,$07,$00,$02,$00,$13,$00,$0C,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$14,$00,$0C,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$13,$00,$0C,$00,$09,$00,$09,$00,$06,$00,$02,$00
	DC.B	$14,$00,$0C,$00,$0A,$00,$09,$00,$07,$00,$02,$00,$13,$00,$0C,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$14,$00,$0C,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$0D,$00,$0B,$00,$09,$00,$09,$00,$06,$00,$02,$00,$0E,$00,$0B,$00
	DC.B	$0A,$00,$09,$00,$07,$00,$02,$00,$0F,$00,$0B,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$10,$00,$0B,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$0D,$00,$0B,$00,$09,$00,$09,$00,$06,$00,$02,$00,$11,$00,$0B,$00,$0A,$00,$09,$00
	DC.B	$07,$00,$02,$00,$12,$00,$0B,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$00,$00,$0B,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$0D,$00,$0B,$00,$09,$00,$09,$00,$06,$00,$02,$00,$0E,$00,$0B,$00,$0A,$00,$09,$00,$07,$00,$02,$00
	DC.B	$0F,$00,$0B,$00,$0B,$00,$09,$00,$06,$FC,$02,$00,$10,$00,$0B,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$0D,$00,$0B,$00,$09,$00,$09,$00,$06,$00,$02,$00,$11,$00,$0B,$00,$0A,$00,$09,$00,$07,$00,$02,$00,$12,$00,$0B,$00
	DC.B	$0B,$00,$09,$00,$06,$FC,$02,$00,$00,$00,$0B,$00,$0C,$00,$09,$00,$08,$FE,$02,$00,$01,$0C,$0C,$00,$03,$0C,$0C,$00,$06,$00,$02,$00,$02,$0C,$0C,$00,$04,$0C,$0C,$00,$07,$00,$02,$00,$01,$0C,$0C,$00,$03,$0C,$0C,$00
	DC.B	$06,$FC,$02,$00,$02,$0C,$0C,$00,$04,$0C,$0C,$00,$08,$FE,$02,$00,$01,$0C,$0C,$00,$03,$0C,$0C,$00,$06,$00,$02,$00,$02,$0C,$0C,$00,$04,$0C,$0C,$00,$07,$00,$02,$00,$01,$0C,$0C,$00,$03,$0C,$0C,$00,$06,$FC,$02,$00
	DC.B	$02,$0C,$0C,$00,$04,$0C,$0C,$00,$08,$FE,$02,$00,$01,$00,$00,$00,$03,$00,$00,$00,$00,$00,$00,$00,$02,$00,$00,$00,$04,$00,$00,$00,$00,$00,$00,$00,$01,$00,$00,$00,$03,$00,$00,$00,$00,$00,$00,$00,$02,$00,$00,$00
	DC.B	$04,$00,$00,$00,$00,$00,$00,$00,$01,$00,$00,$00,$03,$00,$00,$00,$00,$00,$00,$00,$02,$00,$00,$00,$04,$00,$00,$00,$00,$00,$00,$00,$01,$00,$00,$00,$03,$00,$00,$00,$00,$00,$00,$00,$02,$00,$00,$00,$04,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$3F,$00,$02,$00,$00,$00,$3F,$00,$02,$00,$08,$00,$0B,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$18,$01,$03,$00,$0F,$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$02,$19,$01,$01,$00,$0F,$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$01,$1B,$18,$20,$00,$0F,$0E,$E1,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$07,$11,$01,$02,$00,$0F,$0E,$0D,$0C,$0B,$0A,$09,$08,$07,$06,$05,$04,$03,$02,$01,$00,$E1,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$03,$1B,$01,$02,$00,$0A,$0A,$E0,$05,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$03,$0A,$00,$00,$00,$02,$04,$06,$08,$0A,$0B,$0C,$0D,$0E,$0F,$0E,$0D,$0C,$0B,$0A,$08,$06,$04,$02,$00,$E1,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$02,$1C,$01,$01,$00,$0D,$0E,$0E,$0E,$0E,$0D,$0C,$0A,$00,$E1,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$07,$0E,$02,$05
	DC.B	$08,$09,$0A,$0B,$0C,$0D,$0E,$0F,$0E,$0E,$0E,$0E,$0D,$0D,$0D,$0C,$0C,$0C,$0B,$0B,$0B,$0A,$0A,$0A,$09,$09,$09,$09,$08,$08,$08,$08,$07,$07,$07,$06,$06,$06,$05,$05,$05,$04,$04,$04,$03,$03,$03,$02,$02,$02,$02,$01
	DC.B	$01,$01,$00,$00,$00,$00,$E1,$00,$0C,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$09,$00,$00,$00,$09,$00,$00,$00,$00,$00,$00,$00,$09,$00,$00,$00,$09,$00,$00,$00,$00,$00,$00,$00,$07,$00,$00,$00,$09,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$07,$00,$00,$00,$09,$00,$00,$00,$07,$00,$00,$00,$05,$00,$00,$00,$05,$00,$00,$00,$00,$00,$00,$00,$05,$00,$00,$00,$05,$00,$00,$00
	DC.B	$00,$00,$00,$00,$05,$00,$00,$00,$07,$00,$00,$00,$00,$00,$00,$00,$07,$00,$00,$00,$00,$00,$00,$00,$07,$00,$00,$00,$07,$00,$00,$00,$05,$00,$00,$00,$0C,$00,$00,$00,$07,$00,$00,$00,$09,$06,$09,$07,$09,$0A,$00,$00
	DC.B	$00,$00,$00,$00,$09,$0A,$00,$00,$09,$08,$00,$00,$09,$0A,$00,$00,$07,$0A,$00,$00,$09,$0A,$00,$00,$00,$00,$00,$00,$09,$0A,$00,$00,$09,$06,$00,$00,$09,$0A,$00,$00,$09,$08,$00,$00,$00,$00,$00,$00,$09,$06,$09,$0A
	DC.B	$07,$0A,$00,$00,$39,$00,$00,$00,$39,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$39,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$39,$00,$00,$00
	DC.B	$39,$00,$00,$00,$00,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00
	DC.B	$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00
	DC.B	$30,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$2B,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$30,$00,$00,$00,$32,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$2B,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$2B,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$2D,$00,$00,$00
	DC.B	$30,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00
	DC.B	$30,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$15,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$21,$00,$00,$00,$00,$00,$00,$00,$21,$00,$00,$00,$21,$00,$00,$00
	DC.B	$25,$00,$00,$00,$00,$00,$00,$00,$28,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$25,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$21,$00,$00,$00,$00,$00,$00,$00,$2D,$00,$00,$00
	DC.B	$00,$00,$00,$00,$28,$00,$00,$00,$28,$00,$00,$00,$25,$00,$00,$00,$00,$00,$00,$00,$21,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$09,$00,$00,$00,$09,$01,$00,$00,$09,$01,$00,$00,$09,$00,$00,$00,$15,$02,$00,$00,$09,$00,$00,$00,$09,$01,$00,$00,$09,$10,$00,$00,$09,$00,$00,$00,$09,$01,$00,$00,$09,$01,$00,$00
	DC.B	$09,$01,$00,$00,$09,$02,$00,$00,$09,$01,$00,$00,$09,$01,$00,$00,$09,$00,$00,$00,$09,$00,$00,$00,$00,$00,$00,$00,$09,$00,$00,$00,$09,$00,$00,$00,$09,$00,$00,$00,$00,$00,$00,$00,$09,$04,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$15,$00,$00,$00,$09,$01,$00,$00,$0C,$02,$00,$00,$09,$00,$00,$00,$15,$00,$00,$00
	DC.B	$21,$01,$00,$00,$0C,$02,$00,$00,$10,$00,$00,$00,$15,$00,$00,$00,$13,$01,$00,$00,$0C,$02,$00,$00,$10,$00,$00,$00,$0C,$00,$00,$00,$10,$01,$00,$00,$0C,$02,$00,$00,$0C,$02,$00,$00,$39,$00,$00,$00,$2D,$00,$00,$00
	DC.B	$39,$00,$00,$00,$00,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$2B,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$24,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$0C,$00,$00,$00,$24,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$2B,$00,$00,$00,$00,$00,$00,$00,$28,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$2F,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$2D,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$34,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00
	DC.B	$34,$00,$00,$00,$35,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$34,$00,$00,$00,$00,$00,$00,$00,$32,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$00,$00,$00,$00,$30,$00,$00,$00,$30,$05,$00,$00,$30,$00,$00,$00
	DC.B	$30,$00,$00,$00,$30,$00,$00,$00,$32,$05,$00,$00,$33,$05,$00,$00,$30,$00,$00,$00,$30,$00,$00,$00,$35,$05,$00,$00,$37,$05,$00,$00,$30,$00,$00,$00,$3A,$05,$00,$00,$30,$00,$00,$00,$3C,$05,$00,$00,$30,$00,$00,$00
	DC.B	$3A,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3C,$00,$00,$00
	DC.B	$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00
	DC.B	$3A,$00,$00,$00,$37,$00,$00,$00,$37,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00
	DC.B	$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00,$3A,$00,$00,$00,$37,$00,$00,$00,$3C,$00,$00,$00,$37,$00,$00,$00,$3F,$00,$00,$00,$37,$00,$00,$00,$40,$00,$00,$00,$43,$00,$00,$00,$45,$00,$00,$00,$40,$00,$00,$00
	DC.B	$43,$00,$00,$00,$45,$00,$00,$00,$40,$00,$00,$00,$43,$00,$00,$00,$45,$00,$00,$00,$40,$00,$00,$00,$43,$00,$00,$00,$45,$00,$00,$00,$40,$00,$00,$00,$43,$00,$00,$00,$45,$00,$00,$00,$43,$00,$00,$00,$37,$00,$00,$00
	DC.B	$00,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$37,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$37,$00,$00,$00,$39,$00,$00,$00,$00,$00,$00,$00,$37,$00,$00,$00,$39,$00,$00,$00
	DC.B	$00,$00,$00,$00,$37,$00,$00,$00,$39,$20,$00,$00,$BB,$00,$00,$18,$39,$20,$00,$00,$BB,$00,$00,$18,$39,$20,$00,$00,$BB,$00,$00,$00,$37,$00,$00,$00,$34,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$18,$39,$2E,$00,$00,$BB,$0E,$00,$18,$39,$2E,$00,$00,$BB,$0E,$00,$18,$39,$2E,$00,$00,$BB,$0E,$00,$00,$4D,$55,$53,$49,$43,$00,$00,$00
	DC.B	$A2,$00,$00,$00,$00,$DC

addr	dc.l	mymus

flag	ds.w	1


	section	bss
mymus	ds.b	70000
count	ds.w	1