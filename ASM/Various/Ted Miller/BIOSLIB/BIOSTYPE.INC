nineints = array[1..9] of integer;
threeints = array[1..3] of integer;
secbuff  = array[1..512] of integer;

