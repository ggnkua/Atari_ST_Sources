/* resource set indices for FORM_MSG */

#define MAIN       0 /* menu */
#define MNFORM     7 /* STRING in tree MAIN */
#define MNQUIT    16 /* STRING in tree MAIN */

#define FORM       1 /* form/dialog */
#define OK         1 /* BUTTON in tree FORM */
#define IMGSTRNG   5 /* IBOX in tree FORM */
#define SPARENT    6 /* BOX in tree FORM */
#define SBUTTON1   7 /* BUTTON in tree FORM */
#define SBUTTON2   8 /* BUTTON in tree FORM */
#define RPARENT    9 /* BOX in tree FORM */
#define RBUTTON1  10 /* BUTTON in tree FORM */
#define RBUTTON2  11 /* BUTTON in tree FORM */

