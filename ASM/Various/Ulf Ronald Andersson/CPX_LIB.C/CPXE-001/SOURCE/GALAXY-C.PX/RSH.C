/***** GEM C Resource File ****
 * built from input resource file   'bild.rsc'   with
 * krsc2c  V 1.05  Copyright (c) 1995,1996 ToMST, Thomas Maier, 07.09.96
 *   (GEM Resource File to C Converter)
 */

#define __RSC_RELATIV 0
#define __RSC_ABSOLUT 1
#define __RSC_ABSOLUT_MIN 2

/* mode that was used to built this file */
#define __RSC_mode __RSC_ABSOLUT_MIN

#include <aes.h>


TEDINFO rs_tedinfo[] = {};

static UWORD rs_bitmap_0[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0008, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x8001, 0x0820, 0x0000, 0x0000, 0x0400, 0x0010, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0004, 0x0000, 0x0000, 0x2200,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0100, 0x4800, 0x0000,
 0x0000, 0x0000, 0x0022, 0x1220, 0x0000, 0x0000, 0x0400, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x8002, 0x0040, 0x0200, 0x0000, 0x0002, 0x0040, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0800, 0x0900, 0x0000, 0x0000, 0x0000, 0x0010,
 0x0000, 0x8000, 0x0000, 0x0000, 0x0000, 0x0100, 0x0000, 0x0000,
 0x0002, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x1000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0082, 0x0000, 0x0042,
 0x0000, 0x0800, 0x0000, 0x0000, 0x0000, 0x0100, 0x0080, 0x0008,
 0x0000, 0x0000, 0x0002, 0x0100, 0x0000, 0x0000, 0x0002, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0040, 0x2000, 0x0000,
 0x0001, 0x0000, 0x0040, 0x0000, 0x0000, 0x0000, 0x2000, 0x0280,
 0x0400, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x4008, 0x0200, 0x0002, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0400, 0x0060, 0x0000, 0x0000, 0x0002, 0x0000,
 0x0020, 0x0000, 0x0000, 0x0000, 0x0200, 0x0541, 0x0900, 0x0000,
 0x0000, 0x1000, 0x20e9, 0x0020, 0x0000, 0x0000, 0x0002, 0x0300,
 0x0800, 0x0000, 0x0000, 0x0000, 0x40b0, 0x0000, 0x0800, 0x0000,
 0x0100, 0x0140, 0x0184, 0x0000, 0x0000, 0x0008, 0x00c4, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0001, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0002, 0x0000, 0x0000, 0x2000, 0x0080, 0x0004, 0x2000,
 0x0008, 0x0000, 0x0004, 0x0000, 0x2000, 0x0000, 0x0040, 0x0200,
 0x0000, 0x0800, 0x0000, 0x0004, 0x0080, 0x8001, 0x0000, 0x0000,
 0x0010, 0x0000, 0x0000, 0x4800, 0x0000, 0x0000, 0x0200, 0x0000,
 0x0000, 0x0000, 0x8000, 0x0000, 0x0000, 0x2200, 0x0000, 0x2000,
 0x0800, 0x0000, 0x0000, 0x0000, 0x0800, 0x2000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x1020, 0x0800, 0x0000, 0x0040, 0x0000,
 0x0000, 0x1000, 0x0000, 0x0012, 0x0000, 0x5000, 0x0000, 0x0000,
 0x0000, 0x0010, 0x4002, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0001, 0x0000, 0x0000, 0x0000, 0x1000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x2000, 0x0000, 0x0002, 0x0000, 0x0800, 0x0000,
 0x0000, 0x0171, 0x0000, 0x0000, 0x0000, 0x0000, 0x0009, 0x0000,
 0xa000, 0x0000, 0x0000, 0x000a, 0x0000, 0x0000, 0x0000, 0x0000,
 0x003c, 0x1104, 0x0010, 0x0000, 0x0000, 0x02be, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0018, 0x8400, 0x0001, 0x0000, 0x0000, 0x0000,
 0x2040, 0x0000, 0x0000, 0x0000, 0x0410, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0008, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000};

ICONBLK rs_iconblk[] = {};

BITBLK rs_bitblk[] = {
{ rs_bitmap_0, 10, 80, 0, 0, 1 }};

char *rs_frstr[] = {};

BITBLK *rs_frimg[] = {
 &rs_bitblk[0]};

OBJECT rs_object[] = {};

OBJECT *rs_trindex[] = {};

