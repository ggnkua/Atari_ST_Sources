/* resource set indices for DOG-RSC */

#define OTDOGS     0 /* form/dialog */
#define OBACK      0 /* BOX in tree OTDOGS */
#define ODOG1      1 /* IMAGE in tree OTDOGS */
#define ODOG2      2 /* IMAGE in tree OTDOGS */
#define ODOG3      3 /* IMAGE in tree OTDOGS */
#define ODOG4      4 /* IMAGE in tree OTDOGS */
#define ODOG5      5 /* IMAGE in tree OTDOGS */
#define ODOG6      6 /* IMAGE in tree OTDOGS */
#define ODOG7      7 /* IMAGE in tree OTDOGS */

