
/* Sinus/Cosinus und Tangens Tabelle */

#include <compiler.h>
#include "eyes.h"

WORD sintab[SINTABMAX+1] = {
0,
4,
8,
13,
17,
22,
26,
31,
35,
40,
44,
48,
53,
57,
61,
66,
70,
74,
79,
83,
87,
91,
95,
100,
104,
108,
112,
116,
120,
124,
128,
131,
135,
139,
143,
146,
150,
154,
157,
161,
164,
167,
171,
174,
177,
181,
184,
187,
190,
193,
196,
198,
201,
204,
207,
209,
212,
214,
217,
219,
221,
223,
226,
228,
230,
232,
233,
235,
237,
238,
240,
242,
243,
244,
246,
247,
248,
249,
250,
251,
252,
252,
253,
254,
254,
255,
255,
255,
255,
255,
256
};

WORD tantab[TANTABMAX+1] = {
0,
4,
8,
13,
17,
22,
26,
31,
35,
40,
45,
49,
54,
59,
63,
68,
73,
78,
83,
88,
93,
98,
103,
108,
113,
119,
124,
130,
136,
141,
147,
153,
159,
166,
172,
179,
185,
192,
200,
207,
214,
222,
230,
238,
247,
256,
265,
274,
284,
294,
305,
316,
327,
339,
352,
365,
379,
394,
409,
426,
443,
461,
481,
502,
524,
548,
574,
603,
633,
666,
703,
743,
787,
837,
892,
955,
1026,
1108,
1204,
1317,
1451,
1616,
1821,
2084,
2435,
2926,
3660,
4884,
7330,
14666
};
