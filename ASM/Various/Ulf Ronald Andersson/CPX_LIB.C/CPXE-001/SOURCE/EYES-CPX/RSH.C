/***** GEM C Resource File ****
 * built from input resource file   'eyes.rsc'   with
 * krsc2c  V 1.05  Copyright (c) 1995,1996 ToMST, Thomas Maier, 07.09.96
 *   (GEM Resource File to C Converter)
 */

#define __RSC_RELATIV 0
#define __RSC_ABSOLUT 1
#define __RSC_ABSOLUT_MIN 2

/* mode that was used to built this file */
#define __RSC_mode __RSC_ABSOLUT_MIN

#include <aes.h>


TEDINFO rs_tedinfo[] = {};

static UWORD rs_bitmap_0[] = {
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0001, 0x4000, 0x0004, 0x4000, 0x0025, 0x2400, 0x004c, 0x8800,
 0x0027, 0xf580, 0x006f, 0xee00, 0x0118, 0x0d00, 0x0230, 0x1880,
 0x09e0, 0x0320, 0x02c0, 0x0680, 0x0480, 0x00e0, 0x0100, 0x0120,
 0x0500, 0x0040, 0x0200, 0x00a0, 0x0200, 0x0020, 0x0400, 0x0040,
 0x0200, 0x0020, 0x0400, 0x0050, 0x0400, 0x0010, 0x0800, 0x0020,
 0x0800, 0x0008, 0x1000, 0x0010, 0x0800, 0x0008, 0x1000, 0x0010,
 0x1000, 0x0004, 0x2000, 0x0008, 0x1000, 0x0004, 0x2000, 0x0008,
 0x1000, 0x0004, 0x2000, 0x0008, 0x1000, 0x0004, 0x2000, 0x0008,
 0x2000, 0x0002, 0x4000, 0x0004, 0x2000, 0x0002, 0x4000, 0x0004,
 0x2000, 0x0002, 0x4000, 0x0004, 0x2000, 0x0002, 0x4000, 0x0004,
 0x2000, 0x0002, 0x4000, 0x0004, 0x2000, 0x0002, 0x4000, 0x0004,
 0x2000, 0x0002, 0x4000, 0x0004, 0x2000, 0x0002, 0x4000, 0x0004,
 0x2000, 0x0002, 0x4000, 0x0004, 0x1000, 0x0004, 0x2000, 0x0008,
 0x1000, 0x0004, 0x2000, 0x0008, 0x1000, 0x0004, 0x2000, 0x0008,
 0x1000, 0x0004, 0x2000, 0x0008, 0x0800, 0x0008, 0x1000, 0x0010,
 0x0800, 0x0008, 0x1000, 0x0010, 0x0400, 0x0010, 0x0800, 0x0020,
 0x0200, 0x0020, 0x0400, 0x0040, 0x0200, 0x0020, 0x0400, 0x0040,
 0x0100, 0x0040, 0x0200, 0x0080, 0x0080, 0x0080, 0x0100, 0x0100,
 0x0060, 0x0300, 0x00c0, 0x0600, 0x0018, 0x0c00, 0x0030, 0x1800,
 0x0007, 0xf000, 0x000f, 0xe000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000};

static UWORD rs_bitmap_1[] = {
 0x0000, 0x0000, 0x0000, 0x03c0, 0x0ff0, 0x0cf0, 0x19f8, 0x13f8,
 0x1ff8, 0x1ff8, 0x0ff0, 0x0ff0, 0x03c0, 0x0000, 0x0000, 0x0000};

static UWORD rs_bitmap_2[] = {
 0x0000, 0x0000, 0x0000, 0x03c0, 0x0ff0, 0x0f30, 0x1f98, 0x1fd8,
 0x1ff8, 0x1ff8, 0x0ff0, 0x0ff0, 0x03c0, 0x0000, 0x0000, 0x0000};

ICONBLK rs_iconblk[] = {};

BITBLK rs_bitblk[] = {
{ rs_bitmap_0, 8, 48, 0, 0, 1 },
{ rs_bitmap_1, 2, 16, 0, 0, 1 },
{ rs_bitmap_2, 2, 16, 0, 0, 1 }};

char *rs_frstr[] = {};

BITBLK *rs_frimg[] = {};

OBJECT rs_object[] = {
{ -1, 1, 1, 0x14, 0x0000, 0x0000,{ (void *)0x1100 }, 0x0002, 0x0001, 0x0008, 0x0003 },
{ 0, 2, 2, 0x17, 0x0000, 0x0000,{ (void *)&rs_bitblk[0] }, 0x0000, 0x0000, 0x4000, 0x3000 },
{ 1, 3, 4, 0x19, 0x0000, 0x0000,{ (void *)0x1100 }, 0x0000, 0x0000, 0x0008, 0x0003 },
{ 4, -1, -1, 0x17, 0x0000, 0x0000,{ (void *)&rs_bitblk[1] }, 0x0005, 0x0001, 0x1000, 0x1000 },
{ 2, -1, -1, 0x17, 0x0020, 0x0000,{ (void *)&rs_bitblk[2] }, 0x0001, 0x0001, 0x1000, 0x1000 }};

OBJECT *rs_trindex[] = {
 &rs_object[0]};

