;----------------------------------------------------------------------------
; File name:	HUGE_EMU.S		Revision date:	1997.02.11
; Created by:	U.R. Andersson		Creation date:	1994.07.02
; Project:	Lace_Emu		Version:	3.5
;----------------------------------------------------------------------------
emu_unique	=	5		;emu_id:	5
emu_unique_defined	set	1
;----------------------------------------------------------------------------
	output	.PRX
;----------------------------------------------------------------------------
maxrez_size	=	4*(1280*960/8)	;Bytes used for emu screen
;
;NB: This allows TT-High dimensions with 16 colours
;----------------------------------------------------------------------------
	include	Lace_Emu.s
;----------------------------------------------------------------------------
;End of file:	HUGE_EMU.S
;----------------------------------------------------------------------------
