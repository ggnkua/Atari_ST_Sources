;----------------------------------------------------------------------------
; File name:	HUGE_EMU.S		Revision date:	2000.07.11
; Created by:	U.R. Andersson		Creation date:	1994.07.02
; Project:	Lace_Emu		Version:	4.1
;----------------------------------------------------------------------------
emu_unique	=	7		;emu_id:	7
emu_unique_defined	set	1
;----------------------------------------------------------------------------
	output	.PRX
;----------------------------------------------------------------------------
maxrez_size	=	4*(1280*960/8)	;Bytes used for emu screen
;
;NB: This allows TT-High dimensions with 16 colours
;----------------------------------------------------------------------------
	include	LaceEmu2.s
;----------------------------------------------------------------------------
;End of file:	HUGE_EMU.S
;----------------------------------------------------------------------------
