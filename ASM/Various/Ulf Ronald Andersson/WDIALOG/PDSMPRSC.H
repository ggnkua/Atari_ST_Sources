/* Resource Datei Indizes f�r PDSMPRSC */

#define MENU             0   /* Menuebaum */
#define MDATEI           4   /* TITLE in Baum MENU */
#define DCLOSE           18  /* STRING in Baum MENU */
#define DLAYOUT          20  /* STRING in Baum MENU */
#define DPAPIER          21  /* STRING in Baum MENU */
#define DDRUCKEN         22  /* STRING in Baum MENU */
#define DQUIT            24  /* STRING in Baum MENU */

#define MY_SPECIAL_DLG1  1   /* Formular/Dialog */
#define PO_BG_PRINTING   1   /* BUTTON in Baum MY_SPECIAL_DLG1 */
#define MYSP_FARBKEIL1   3   /* BUTTON in Baum MY_SPECIAL_DLG1 */
#define MYSP_PUSH_ME1    8   /* BUTTON in Baum MY_SPECIAL_DLG1 */
#define PUSH_ME_ICON1    9   /* ICON in Baum MY_SPECIAL_DLG1 */

#define MY_SPECIAL_DLG2  2   /* Formular/Dialog */

#define ICON_DIALOG      3   /* Formular/Dialog */
#define PI_MY_SPECIAL1   1   /* ICON in Baum ICON_DIALOG */
#define PI_MY_SPECIAL2   2   /* ICON in Baum ICON_DIALOG */

#define LAYOUT_ALERT     0   /* Alert String */

#define PRINT_ALERT      1   /* Alert String */
