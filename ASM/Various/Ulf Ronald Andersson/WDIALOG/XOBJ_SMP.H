/* Resource Datei Indizes f�r XOBJ_SMP */

#define OBJDEMO  0   /* Formular/Dialog */
#define GROUP    1   /* BUTTON in Baum OBJDEMO */
#define CANCEL   6   /* BUTTON in Baum OBJDEMO */
#define TOK      7   /* BUTTON in Baum OBJDEMO */

#define IMAGE_DIALOG 1   /* Formular/Dialog */
#define RADIO_SLCT 1   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_DESLCT 2   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_DESLCT 3   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_SLCT 4   /* IMAGE in Baum IMAGE_DIALOG */

#define WDLG_MISSING 0   /* Alert String */

#define TEST_TITEL 1   /* Freier String */
