/* Resource Datei Indizes f�r WDLG_SMP */

#define TESTME   0   /* Formular/Dialog */
#define FSTL_BACK 2   /* BOX in Baum TESTME */
#define FSTL_WHITE 3   /* BOX in Baum TESTME */
#define FSTL_DOWN 4   /* BOXCHAR in Baum TESTME */
#define FSTL_UP  5   /* BOXCHAR in Baum TESTME */
#define FSTL_BOX 6   /* IBOX in Baum TESTME */
#define FSTL_1   7   /* TEXT in Baum TESTME */
#define FSTL_2   8   /* TEXT in Baum TESTME */
#define FSTL_0   9   /* TEXT in Baum TESTME */
#define FSTL_3   10  /* TEXT in Baum TESTME */
#define PAT_RIGHT 11  /* BOXCHAR in Baum TESTME */
#define PAT_LEFT 12  /* BOXCHAR in Baum TESTME */
#define PAT_BOX  13  /* IBOX in Baum TESTME */
#define PAT_0    14  /* BOX in Baum TESTME */
#define PAT_1    15  /* BOX in Baum TESTME */
#define PAT_2    16  /* BOX in Baum TESTME */
#define PAT_3    17  /* BOX in Baum TESTME */
#define PAT_4    18  /* BOX in Baum TESTME */
#define PAT_5    19  /* BOX in Baum TESTME */
#define PAT_6    20  /* BOX in Baum TESTME */
#define PAT_7    21  /* BOX in Baum TESTME */
#define PAT_8    22  /* BOX in Baum TESTME */
#define PAT_9    23  /* BOX in Baum TESTME */
#define PAT_10   24  /* BOX in Baum TESTME */
#define PAT_11   25  /* BOX in Baum TESTME */
#define PAT_12   26  /* BOX in Baum TESTME */
#define PAT_SAMPLE 27  /* BOX in Baum TESTME */
#define FSTL_SAMPLE 28  /* BOXTEXT in Baum TESTME */
#define SPICE_BOX 29  /* IBOX in Baum TESTME */
#define SPICE_0  30  /* TEXT in Baum TESTME */
#define SPICE_1  31  /* TEXT in Baum TESTME */
#define SPICE_2  32  /* TEXT in Baum TESTME */
#define SPICE_3  33  /* TEXT in Baum TESTME */
#define SPICE_BACK 34  /* BOX in Baum TESTME */
#define SPICE_SL 35  /* BOX in Baum TESTME */
#define SPICE_DOWN 37  /* BOXCHAR in Baum TESTME */
#define SPICE_UP 38  /* BOXCHAR in Baum TESTME */
#define TUPDATE  40  /* BUTTON in Baum TESTME */
#define SLBK_H   41  /* BOX in Baum TESTME */
#define SL_H     42  /* BOX in Baum TESTME */
#define SL_LEFT  43  /* BOXCHAR in Baum TESTME */
#define SL_RIGHT 44  /* BOXCHAR in Baum TESTME */
#define TBUTTONS 45  /* IBOX in Baum TESTME */
#define TSIZE    46  /* BOXCHAR in Baum TESTME */
#define TEST_BT  47  /* BUTTON in Baum TESTME */
#define TOK      48  /* BUTTON in Baum TESTME */

#define IMAGE_DIALOG 1   /* Formular/Dialog */
#define RADIO_SLCT 1   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_DESLCT 2   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_DESLCT 3   /* IMAGE in Baum IMAGE_DIALOG */
#define RADIO_M_SLCT 4   /* IMAGE in Baum IMAGE_DIALOG */

#define WDLG_MISSING 0   /* Alert String */

#define TEST_TITEL 1   /* Freier String */
