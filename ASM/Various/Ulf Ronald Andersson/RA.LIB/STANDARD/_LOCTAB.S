;----------------------------------------------------------------------------
;File name:	_LocTab.s			Revision date:	2000.08.25
;Revised by:	Ronald Andersson		Revision start:	2000.08.25
;----------------------------------------------------------------------------
_LocTab:
	dc.w	$0001,$0203,$0405,$0607
	dc.w	$0809,$0A0B,$0C0D,$0E0F
	dc.w	$1011,$1213,$1415,$1617
	dc.w	$1819,$1A1B,$1C1D,$1E1F
	dc.w	$2021,$2223,$2425,$2627
	dc.w	$2829,$2A2B,$2C2D,$2E2F
	dc.w	$3031,$3233,$3435,$3637
	dc.w	$3839,$3A3B,$3C3D,$3E3F
	dc.w	$4061,$6263,$6465,$6667
	dc.w	$6869,$6A6B,$6C6D,$6E6F
	dc.w	$7071,$7273,$7475,$7677
	dc.w	$7879,$7A5B,$5C5D,$5E5F
	dc.w	$6061,$6263,$6465,$6667
	dc.w	$6869,$6A6B,$6C6D,$6E6F
	dc.w	$7071,$7273,$7475,$7677
	dc.w	$7879,$7A7B,$7C7D,$7E7F
	dc.w	$8081,$8283,$8485,$8687
	dc.w	$8889,$8A8B,$8C8D,$8E8F
	dc.w	$9091,$9293,$9495,$9697
	dc.w	$9899,$9A9B,$9C9D,$9E9F
	dc.w	$A0A1,$A2A3,$A4A5,$A6A7
	dc.w	$A8A9,$AAAB,$ACAD,$AEAF
	dc.w	$B0B1,$B2B3,$B4B5,$B6B7
	dc.w	$B8B9,$BABB,$BCBD,$BEBF
	dc.w	$C0C1,$C2C3,$C4C5,$C6C7
	dc.w	$C8C9,$CACB,$CCCD,$CECF
	dc.w	$D0D1,$D2D3,$D4D5,$D6D7
	dc.w	$D8D9,$DADB,$DCDD,$DEDF
	dc.w	$E0E1,$E2E3,$E4E5,$E6E7
	dc.w	$E8E9,$EAEB,$ECED,$EEEF
	dc.w	$F0F1,$F2F3,$F4F5,$F6F7
	dc.w	$F8F9,$FAFB,$FCFD,$FEFF
;----------------------------------------------------------------------------
;End of file:	_LocTab.s
;----------------------------------------------------------------------------
