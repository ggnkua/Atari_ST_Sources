	include	ra_struc.i
	include	dracopts.i
	TEXT
	dc.l	sizeof_DRAC_OPTS
	END
