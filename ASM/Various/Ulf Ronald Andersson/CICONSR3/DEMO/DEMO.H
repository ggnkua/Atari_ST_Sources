/* Resource Datei Indizes f�r DEMO */

#define DEMO_DIALOG 0   /* Formular/Dialog */
#define DEMO_ICON 1   /* USERDEF in Baum DEMO_DIALOG */
#define DEMO_BUTTON 2   /* BUTTON in Baum DEMO_DIALOG */
