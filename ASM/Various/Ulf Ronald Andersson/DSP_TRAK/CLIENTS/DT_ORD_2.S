;----------------------------------------------------------------------------
;File name:	DT_Ord_2.S			Revision date:	1999.09.19
;Creator:	Ulf Ronald Andersson		Creation date:	1996.02.19
;(c)1996 by:	Ulf Ronald Andersson		All rights reserved
;----------------------------------------------------------------------------
;
	include	RA_TOS.I
	include	RA_DSPT.I
	include	RA_JAR.I
;
;----------------------------------------------------------------------------
	TEXT
text_start:
;----------------------------------------------------------------------------
start:
	moveq	#-1,d0
	move.l	a0,d0
	bne.s	.exit
	move.l	4(sp),a5
	lea	loc_stack_top(pc),sp
	gemdos	Mshrink,!,(a5),#total_size
	bsr	main
.exit:
	gemdos	Pterm,d0
;----------------------------------------------------------------------------
main:
	DspT_u_init
	move.l	DspT_cookie_p,d0
	ble.s	exit_direct
	DspT	u,set_order,#2
exit_ok:
	clr.l	d0
exit_direct:
	rts
;----------------------------------------------------------------------------
	make	JAR_links
;----------------------------------------------------------------------------
text_end:
text_size	=	text_end-text_start
;----------------------------------------------------------------------------
	DATA
data_start:
;----------------------------------------------------------------------------
data_end:
data_size	=	data_end-data_start
;----------------------------------------------------------------------------
	BSS
bss_start:
;----------------------------------------------------------------------------
loc_stack_base:
	ds.l	1024
loc_stack_top:
	ds.l	4
;----------------------------------------------------------------------------
bss_end:
bss_size	=	bss_end-bss_start
total_size	=	$100+text_size+data_size+bss_size
;----------------------------------------------------------------------------
	END
;----------------------------------------------------------------------------
;End of file:	DT_Ord_2.S
;----------------------------------------------------------------------------
