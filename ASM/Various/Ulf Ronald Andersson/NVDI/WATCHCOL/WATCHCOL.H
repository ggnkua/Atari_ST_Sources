/* Resource Datei Indizes f�r WATCHCOL */

#define TESTME           0   /* Formular/Dialog */
#define COLSTR           1   /* STRING in Baum TESTME */
#define SET_SYSCOL       2   /* BUTTON in Baum TESTME */

#define TEST_TITEL       0   /* Freier String */

#define STR_SYSPAL       1   /* Freier String */

#define STR_BADCOL       2   /* Freier String */
