/*
	Tabulatorweite: 3
	Kommentare ab: Spalte 60											*Spalte 60*
*/

#include	<Types2B.h>

#ifndef	__IMG_IMAGE__
#define	__IMG_IMAGE__

typedef struct
{
	int16	version;
	int16	length;
	int16	planes;
	int16	pattern_length;
	int16	pix_width;
	int16	pix_height;
	int16	w;
	int16	h;
} IMGHDR;

#endif