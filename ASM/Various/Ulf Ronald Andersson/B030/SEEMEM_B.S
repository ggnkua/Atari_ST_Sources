;----------------------------------------------------------------------------
;File name:	SEEMEM_B.S			Revision date:	1999.01.22
;Created by:	Ulf Ronald Andersson		Creation date:	1997.03.14
;----------------------------------------------------------------------------
	output	.BS
;----------------------------------------------------------------------------
	include	RA_TOS.I
	include	bs_comp\TRACER.I
;----------------------------------------------------------------------------
	TEXT
;----------------------------------------------------------------------------
code_beg:
	bra.s	main_code	;boot sector code link
;----------------------------------------------------------------------------
	ds.b	28		;boot sector parts reserved for BIOS use
;----------------------------------------------------------------------------
main_code:
	dc.w	$a000		;a0 -> line_a variable base
	include	"bs_comp\seemem.s"
;----------------------------------------------------------------------------
code_end:
code_size	=	code_end-code_beg
;----------------------------------------------------------------------------
sz_pad	MACRO	id,limit,pos
	IFNE	((\2)>(\3))
sz_pad__tmp	set	\2-\3
	dcb.b	sz_pad__tmp,0
;--Note--;	\1 was padded by \<sz_pad__tmp> bytes. OK!
	ELSE
	IFNE	((\3)>(\2))
sz_pad__tmp	set	\3-\2
	FAIL	\1 was too large by \<sz_pad__tmp> bytes.
	ENDC
	ENDC
	ENDM	;sz_pad
;----------------------------------------------------------------------------
	sz_pad	boot_sector,510,code_size
;
checksum:
	dc.w	0
;----------------------------------------------------------------------------
booter_end:
;----------------------------------------------------------------------------
	END
;----------------------------------------------------------------------------
;End of file:	SEEMEM_B.S
;----------------------------------------------------------------------------
