/************************************************************************/
/* module:          export.h                                            */
/* author:          Jan Kriesten        date:        27.11.1992         */
/*                                                                      */
/* description:     header-file to export variables;                    */
/*                                                                      */
/* last change: 	27.11.1992                                          */
/************************************************************************/

/* -------------------------------------------------------------------- */
/*       environment.                                                   */
/* -------------------------------------------------------------------- */

#ifndef __EXPORT_H__
#define	__EXPORT_H__

/* -------------------------------------------------------------------- */
/*       includes.                                                      */
/* -------------------------------------------------------------------- */

/* -------------------------------------------------------------------- */
/*       constants.                                                     */
/* -------------------------------------------------------------------- */

#ifdef GLOBAL
#undef GLOBAL
#endif

#define GLOBAL

/* -------------------------------------------------------------------- */
/*       types.                                                         */
/* -------------------------------------------------------------------- */

/* -------------------------------------------------------------------- */
/*       end of header module.                                          */
/* -------------------------------------------------------------------- */

#endif /* __EXPORT_H__ */

