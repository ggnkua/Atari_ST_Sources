/* Indice du ressource pour UNITRANS */

#define MAIN_FORM 0   /* Formulaire/Dialogue */
#define RDIO_FATHER_SRC 2   /* IBOX dans l'arbre MAIN_FORM */
#define RDIO_SRC_UNIX 3   /* USERDEF dans l'arbre MAIN_FORM */
#define RDIO_SRC_ATARI 4   /* USERDEF dans l'arbre MAIN_FORM */
#define RDIO_SRC_HTML 5   /* USERDEF dans l'arbre MAIN_FORM */
#define RDIO_SRC_PC 6   /* USERDEF dans l'arbre MAIN_FORM */
#define TXT_SRC_UNIX 7   /* TEXT dans l'arbre MAIN_FORM */
#define TXT_SRC_ATARI 8   /* TEXT dans l'arbre MAIN_FORM */
#define TXT_SRC_HTML 9   /* TEXT dans l'arbre MAIN_FORM */
#define TXT_SRC_PC 10  /* TEXT dans l'arbre MAIN_FORM */
#define RDIO_FATHER_DEST 13  /* IBOX dans l'arbre MAIN_FORM */
#define RDIO_DEST_UNIX 14  /* USERDEF dans l'arbre MAIN_FORM */
#define RDIO_DEST_ATARI 15  /* USERDEF dans l'arbre MAIN_FORM */
#define RDIO_DEST_HTML 16  /* USERDEF dans l'arbre MAIN_FORM */
#define RDIO_DEST_PC 17  /* USERDEF dans l'arbre MAIN_FORM */
#define TXT_DEST_UNIX 18  /* TEXT dans l'arbre MAIN_FORM */
#define TXT_DEST_ATARI 19  /* TEXT dans l'arbre MAIN_FORM */
#define TXT_DEST_HTML 20  /* TEXT dans l'arbre MAIN_FORM */
#define TXT_DEST_PC 21  /* TEXT dans l'arbre MAIN_FORM */
#define TXT_WARNING_LIMI 25  /* TEXT dans l'arbre MAIN_FORM */
#define BTON_LOAD_CONV 27  /* BUTTON dans l'arbre MAIN_FORM */
#define BTON_CLOSE 29  /* BUTTON dans l'arbre MAIN_FORM */

#define ALERT1   0   /* Chaine d'alerte */
