/* Indices du fichier ressource pour CAREFUL */

#define MENU_PRINCIPAL   0   /* Menu */
#define MNU_INFO         7   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_F_QUIT       16  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_PRINCIPAL   1   /* Formulaire/Dialogue */
#define I_REDRAW         1   /* IBOX dans l'arbre FORM_PRINCIPAL */
#define T_ADRESSE        2   /* TEXT dans l'arbre FORM_PRINCIPAL */
#define T_DUMP           18  /* FTEXT dans l'arbre FORM_PRINCIPAL */
#define T_ASCII          34  /* TEXT dans l'arbre FORM_PRINCIPAL */
#define B_BACKW_PAGE     50  /* BUTTON dans l'arbre FORM_PRINCIPAL */
#define B_BACKW          51  /* BUTTON dans l'arbre FORM_PRINCIPAL */
#define B_ADRESSE        52  /* BUTTON dans l'arbre FORM_PRINCIPAL */
#define B_FORW           53  /* BUTTON dans l'arbre FORM_PRINCIPAL */
#define B_FORW_PAGE      54  /* BUTTON dans l'arbre FORM_PRINCIPAL */
#define B_QUITTER        55  /* BUTTON dans l'arbre FORM_PRINCIPAL */
#define B_INFO           56  /* BOXCHAR dans l'arbre FORM_PRINCIPAL */
#define B_REALTIME       57  /* BUTTON dans l'arbre FORM_PRINCIPAL */

#define F_INFO           2   /* Formulaire/Dialogue */

#define QUESTION         3   /* Formulaire/Dialogue */
#define B_ADR_OK         1   /* BUTTON dans l'arbre QUESTION */
#define B_ADR_ABANDON    2   /* BUTTON dans l'arbre QUESTION */
#define F_NOUV_ADRESSE   4   /* FTEXT dans l'arbre QUESTION */

#define ERREUR           0   /* Chaine d'alerte */
