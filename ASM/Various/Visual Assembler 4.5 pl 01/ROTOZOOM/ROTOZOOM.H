/* Indice du ressource pour ROTOZOOM */

#define MENU_PRINCIPAL 0   /* Arbre menu */
#define MNU_DESK_INFO 7   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_OPEN 16  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_QUIT 17  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_BACKGROUND 1   /* Formulaire/Dialogue */

#define FORM_SIZE_XY 2   /* Formulaire/Dialogue */
#define FSXY_TEXT_WIDTH 5   /* FBOXTEXT dans l'arbre FORM_SIZE_XY */
#define FSXY_TEXT_HEIGHT 7   /* FBOXTEXT dans l'arbre FORM_SIZE_XY */
#define FSXY_BTON_OK 8   /* BUTTON dans l'arbre FORM_SIZE_XY */
#define FSXY_BTON_CANCEL 10  /* BUTTON dans l'arbre FORM_SIZE_XY */

#define FORM_INFORMATION 3   /* Formulaire/Dialogue */
#define REGISTRED_USR_NM 6   /* TEXT dans l'arbre FORM_INFORMATION */

#define ALERT_NO_16_8BIT 0   /* Chaine d'alerte */

#define ALERT_FILENOTFND 1   /* Chaine d'alerte */
