/* Indice du ressource pour WAX_GIFV */

#define MENU_PRINCIPAL 0   /* Arbre menu */
#define MNU_DESK_INFO 7   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_OPEN 16  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_SAVE_PALETTE 17  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_QUIT 18  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_INFORMATION 1   /* Formulaire/Dialogue */
#define REGISTRED_USR_NM 6   /* TEXT dans l'arbre FORM_INFORMATION */

#define ALERT_FILE_NOTF 0   /* Chaine d'alerte */

#define ALERT_NOT_ENOUGH 1   /* Chaine d'alerte */

#define ALERT_NOT_GOOD_F 2   /* Chaine d'alerte */

#define ALERT_UNPACK_ERR 3   /* Chaine d'alerte */

#define ALERT_NO_MORE_WI 4   /* Chaine d'alerte */
