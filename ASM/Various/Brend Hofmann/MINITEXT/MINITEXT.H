/* resource set indicies for MINITEXT */

#define MENU1    0	/* menu tree */

#define FORM2    1	/* form/dialog */

#define FORM3    2	/* form/dialog */

#define FORM4    3	/* form/dialog */

#define FORM5    4	/* form/dialog */

#define FORM6    5	/* form/dialog */

#define FORM7    6	/* form/dialog */

#define FORM8    7	/* form/dialog */

#define FORM9    8	/* form/dialog */

#define FORM10   9	/* form/dialog */

#define FORM11   10	/* form/dialog */

#define FORM12   11	/* form/dialog */

#define FORM13   12	/* form/dialog */

#define FORM14   13	/* form/dialog */

#define FORM15   14	/* form/dialog */

#define FORM16   15	/* form/dialog */
