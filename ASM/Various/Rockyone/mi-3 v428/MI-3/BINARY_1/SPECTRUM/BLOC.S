;   +0       5120 octets : reserv‚s pour table de conversion
;   +5120     320 octets : reserv‚s pour conversion ligne image
;   +5440     octets inutilis‚s           : 
;   +32000  19104 octets : palettes Restauration, Sauvegarde, Conversion
;   +51104  19104 octets : palettes noir pour le diaporama
;   +70208   2016 octets : 63 palettes / 21 lignes, pour le diaporama
;   total   72224 octets
;
