
	* ON VA TRANSFORMER LE SCORE EN DECIMAL*
	LEA	DECIMAL,A0
	MOVE.L	SCORE,D0
	CMP.L	#10,D0
	BGE.S	SUP_10
	ADD.B	#'0',D0
	MOVE.B	D0,(A0)+
	BRA.S	FIN_DIGIT
SUP_10
	MOVE.L	#1000000000,D2
	MOVEQ	#4,D7	* SUR 5 CHIFFRES
LOOP
	DIVU.L	D2,D1:D0
	ADD.B	#'0',D0
	MOVE.B	D0,(A0)+
	MOVE.L	D1,D0
	MOVEQ	#0,D1
	DIVU.L	#10,D2
	DBRA	D7,LOOP
FIN_DIGIT
	
	PEA	DECIMAL
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	
	
	MOVE.W	#0,-(A7)
	TRAP	#1
	
	DATA
SCORE	DC.L	25
DECIMAL	DCB.B	16,0
