( LDFLOATS: load floating point package and vectors )
: program ;

decimal macros

load floats.s
load fpin.s
load fpout.s
load trig.s
load vectors.s
 
 
from program

keep pi  keep pi/2  keep pi/4

keep sin  keep cos  keep tan

keep int  keep fix  keep i>f  keep f>i

keep integers  keep reals  keep integer  keep real

public
