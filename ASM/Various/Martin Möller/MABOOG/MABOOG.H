/* resource set indicies for MABOOG */

#define SELECT   0	/* form/dialog */
#define PCPW     2	/* BUTTON in tree SELECT */
#define PIC      3	/* BUTTON in tree SELECT */
#define PSW      4	/* BUTTON in tree SELECT */
#define PICC     5	/* BUTTON in tree SELECT */
#define PCMC     6	/* BUTTON in tree SELECT */
#define ABBRUCH  7	/* BUTTON in tree SELECT */

#define PASSWORT 1	/* form/dialog */
#define PASS     3	/* FTEXT in tree PASSWORT */
#define POK      4	/* BUTTON in tree PASSWORT */

