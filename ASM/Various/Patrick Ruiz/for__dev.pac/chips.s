MMU_CR	   = $FFFF8000 ; ST / STE
GLU_CR	   = $FFFF8006 ;	    F30
MFP_GPIP   = $FFFFFA00 ; ST / STE / F30
MFP_AER    = $FFFFFA02 ; ST / STE / F30
MFP_DDR    = $FFFFFA04 ; ST / STE / F30
MFP_IERA   = $FFFFFA06 ; ST / STE / F30
MFP_IERB   = $FFFFFA08 ; ST / STE / F30
MFP_IPRA   = $FFFFFA0A ; ST / STE / F30
MFP_IPRB   = $FFFFFA0C ; ST / STE / F30
MFP_ISRA   = $FFFFFA0E ; ST / STE / F30
MFP_ISRB   = $FFFFFA00 ; ST / STE / F30
MFP_IMRA   = $FFFFFA12 ; ST / STE / F30
MFP_IMRB   = $FFFFFA14 ; ST / STE / F30
MFP_VR	   = $FFFFFA16 ; ST / STE / F30
MFP_TACR   = $FFFFFA18 ; ST / STE / F30
MFP_TBCR   = $FFFFFA1A ; ST / STE / F30
MFP_TCDCR  = $FFFFFA1C ; ST / STE / F30
MFP_TADR   = $FFFFFA1E ; ST / STE / F30
MFP_TBDR   = $FFFFFA20 ; ST / STE / F30
MFP_TCDR   = $FFFFFA22 ; ST / STE / F30
MFP_TDDR   = $FFFFFA24 ; ST / STE / F30
MFP_SCR    = $FFFFFA26 ; ST / STE / F30
MFP_UCR    = $FFFFFA28 ; ST / STE / F30
MFP_RSR    = $FFFFFA2A ; ST / STE / F30
MFP_TSR    = $FFFFFA2C ; ST / STE / F30
MFP_UDR    = $FFFFFA2E ; ST / STE / F30
DMA_SR	   = $FFFF8606 ; ST / STE / F30
DMA_CR	   = $FFFF8606 ; ST / STE / F30
DMA_CH	   = $FFFF8608 ; ST / STE / F30
DMA_CM	   = $FFFF860A ; ST / STE / F30
DMA_CL	   = $FFFF860C ; ST / STE / F30
DMA_SCFDHD = $FFFF8604 ; ST / STE / F30
VID_SYNC   = $FFFF820A ; ST / STE / F30
VID_RES1   = $FFFF8260 ; ST / STE / F30
VID_RES2   = $FFFF8266 ;	    F30
VID_MODE   = $FFFF82C2 ;	    F30
VID_CO	   = $FFFF82C0 ;	    F30
VID_BH	   = $FFFF8200 ; ST / STE / F30
VID_BM	   = $FFFF8202 ; ST / STE / F30
VID_BL	   = $FFFF820C ;      STE / F30
VID_CH	   = $FFFF8204 ; ST / STE / F30
VID_CM	   = $FFFF8206 ; ST / STE / F30
VID_CL	   = $FFFF8208 ; ST / STE / F30
VID_HJ	   = $FFFF8264 ;      STE / F30
VID_VJ	   = $FFFF820E ;      STE / F30
VID_LW	   = $FFFF8210 ;	    F30
VID_HHT    = $FFFF8282 ;	    F30
VID_HBB    = $FFFF8284 ;	    F30
VID_HBE    = $FFFF8286 ;	    F30
VID_HDB    = $FFFF8288 ;	    F30
VID_HDE    = $FFFF828A ;	    F30
VID_HSS    = $FFFF828C ;	    F30
VID_HHC    = $FFFF8280 ;	    F30
VID_HFS    = $FFFF828E ;	    F30
VID_HEE    = $FFFF8290 ;	    F30
VID_VFT    = $FFFF82A2 ;	    F30
VID_VBB    = $FFFF82A4 ;	    F30
VID_VBE    = $FFFF82A6 ;	    F30
VID_VDB    = $FFFF82A8 ;	    F30
VID_VDE    = $FFFF82AA ;	    F30
VID_VSS    = $FFFF82AC ;	    F30
VID_VFC    = $FFFF82A0 ;	    F30
VID_VC	   = $FFFF82A0 ;	    F30
VID_CR0    = $FFFF8240 ; ST / STE / F30
VID_CR00   = $FFFF9800 ;	    F30
PSG_SR	   = $FFFF8800 ; ST / STE / F30
PSG_REGR   = $FFFF8800 ; ST / STE / F30
PSG_REGW   = $FFFF8802 ; ST / STE / F30
KBD_SR	   = $FFFFFC00 ; ST / STE / F30
KBD_CR	   = $FFFFFC00 ; ST / STE / F30
KBD_RD	   = $FFFFFC02 ; ST / STE / F30
KBD_TD	   = $FFFFFC02 ; ST / STE / F30
MID_SR	   = $FFFFFC04 ; ST / STE / F30
MID_CR	   = $FFFFFC04 ; ST / STE / F30
MID_RD	   = $FFFFFC06 ; ST / STE / F30
MID_TD	   = $FFFFFC06 ; ST / STE / F30
BLT_CR	   = $FFFF8A3C ;      STE / F30
BLT_OR	   = $FFFF8A3A ;      STE / F30
BLT_SAH    = $FFFF8A24 ;      STE / F30
BLT_SAL    = $FFFF8A26 ;      STE / F30
BLT_DAH    = $FFFF8A32 ;      STE / F30
BLT_DAL    = $FFFF8A34 ;      STE / F30
BLT_HC	   = $FFFF8A36 ;      STE / F30
BLT_VC	   = $FFFF8A38 ;      STE / F30
BLT_SHI    = $FFFF8A20 ;      STE / F30
BLT_SVI    = $FFFF8A22 ;      STE / F30
BLT_DHI    = $FFFF8A2E ;      STE / F30
BLT_DVI    = $FFFF8A30 ;      STE / F30
BLT_BM	   = $FFFF8A28 ;      STE / F30
BLT_MM	   = $FFFF8A2A ;      STE / F30
BLT_EM	   = $FFFF8A2C ;      STE / F30
BLT_PL0    = $FFFF8A00 ;      STE / F30
GAM_FIRES  = $FFFF9200 ;      STE / F30
GAM_STICKS = $FFFF9202 ;      STE / F30
GAM_XPAD0  = $FFFF9210 ;      STE / F30
GAM_YPAD0  = $FFFF9212 ;      STE / F30
GAM_XPAD1  = $FFFF9214 ;      STE / F30
GAM_YPAD1  = $FFFF9216 ;      STE / F30
GAM_XPEN   = $FFFF9220 ;      STE / F30
GAM_YPEN   = $FFFF9222 ;      STE / F30
SND_CR	   = $FFFF8900 ;      STE / F30
SND_MODE1  = $FFFF8920 ;      STE / F30
SND_BH	   = $FFFF8902 ;      STE / F30
SND_BM	   = $FFFF8904 ;      STE / F30
SND_BL	   = $FFFF8906 ;      STE / F30
SND_CH	   = $FFFF8908 ;      STE / F30
SND_CM	   = $FFFF890A ;      STE / F30
SND_CL	   = $FFFF890C ;      STE / F30
SND_EH	   = $FFFF890E ;      STE / F30
SND_EM	   = $FFFF8910 ;      STE / F30
SND_EL	   = $FFFF8912 ;      STE / F30
SND_MODE2  = $FFFF8936 ;	    F30
SND_FREQ   = $FFFF8934 ;	    F30
SND_XBARIN = $FFFF8930 ;	    F30
SND_XBAROUT= $FFFF8932 ;	    F30
SND_INPUT  = $FFFF8938 ;	    F30
SND_OUTPUT = $FFFF893A ;	    F30
SND_INPUTST= $FFFF893C ;	    F30
SND_DSPDD  = $FFFF8940 ;	    F30
SND_DSPDATA= $FFFF8942 ;	    F30
TON_MASK   = $FFFF8924 ;      STE
TON_DATA   = $FFFF8922 ;      STE
DSP_ICR_CVR= $FFFFA200 ;	    F30
DSP_ISR_IVR= $FFFFA202 ;	    F30
DSP_RDH	   = $FFFFA204 ;	    F30
DSP_RDL	   = $FFFFA206 ;	    F30
DSP_TDH	   = $FFFFA204 ;	    F30
DSP_TDL	   = $FFFFA206 ;	    F30
