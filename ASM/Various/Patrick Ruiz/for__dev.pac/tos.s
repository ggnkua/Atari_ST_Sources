;*** TOS ***

TOS:MACRO f,n
 PW #\1
 TRAP #1
 IFLE \2-8
 ADDQ #\2,SP
 ELSE
 ADDA #\2,SP
 ENDC
 ENDM

PROG_START:MACRO m,n,c
 CLR -(SP)
 PEA (SP)
 PL \3
 PL \2
 PW \1
 TOS 75,18
 ENDM

PROG_STOP:MACRO s,p
 PW \2
 PL \1
 TOS 49,8
 ENDM

PROG_END:MACRO
 PW #0
 TRAP #1
 ENDM

PROG_ENDPARAM:MACRO p
 PL \1
 TOS 76,6
 ENDM

PROG_SUPERMODE:MACRO m
 PL \1
 TOS 32,6
 ENDM

MEMO_SHRINK:MACRO a,s
 PL \2
 PL \1
 PW #0
 TOS 74,12
 ENDM

MEMO_ALLOC:MACRO s
 PL \1
 TOS 72,6
 ENDM

MEMO_FREE:MACRO a
 PL \1
 TOS 73,6
 ENDM

DISK_GET:MACRO
 TOS 25,2
 ENDM

DISK_SET:MACRO d
 PW \1
 TOS 14,4
 ENDM

; DISK_GSPACE

DISK_GDIR:MACRO r,d
 PW \2
 PL \1
 TOS 71,8
 ENDM

DISK_SDIR:MACRO r
 PL \1
 TOS 59,6
 ENDM

; DISK_CREATEDIR

; DISK_DELETEDIR

FILE_GDTA:MACRO
 TOS 47,2
 ENDM

FILE_SDTA:MACRO d
 PL \1
 TOS 26,6
 ENDM

FILE_GFIRST:MACRO f,a
 PW \2
 PL \1
 TOS 78,8
 ENDM

FILE_GNEXT:MACRO
 TOS 79,2
 ENDM

FILE_CREATE:MACRO f,a
 PW \2
 PL \1
 TOS 60,8
 ENDM

FILE_DELETE:MACRO f
 PL \1
 TOS 65,6
 ENDM

FILE_OPEN:MACRO f,m
 PW \2
 PL \1
 TOS 61,8
 ENDM

FILE_CLOSE:MACRO h
 PW \1
 TOS 62,4
 ENDM

FILE_READ:MACRO h,n,b
 PL \3
 PL \2
 PW \1
 TOS 63,12
 ENDM

FILE_WRITE:MACRO h,n,b
 PL \3
 PL \2
 PW \1
 TOS 64,12
 ENDM

FILE_SEEK:MACRO s,h,m
 PW \3
 PW \2
 PL \1
 TOS 66,10
 ENDM

FILE_RENAME:MACRO o,n
 PL \2
 PL \1
 CLR -(SP)
 TOS 86,12
 ENDM

; FILE_ATTRIB

; FILE_TIME

; FILE_DUPLICATE

; FILE_FORCE
