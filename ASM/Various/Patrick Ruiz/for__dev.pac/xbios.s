;*** XBIOS ***

XBIOS:MACRO f,p
 PW #\1
 TRAP #14
 IFLE \2-8
 ADDQ #\2,SP
 ELSE
 ADDA #\2,SP
 ENDC
 ENDM

PROG_SUPER:MACRO r
 PL \1
 XBIOS 38,6
 ENDM

PROG_SINTVECTOR:MACRO n,v
 PL \2
 PW \1
 XBIOS 13,8
 ENDM

PROG_INTENABLE:MACRO n
 PW \1
 XBIOS 27,4
 ENDM

PROG_INTDISABLE:MACRO n
 PW \1
 XBIOS 26,4
 ENDM

PROG_TIMER:MACRO t,c,d,v
 PL \4
 PW \3
 PW \2
 PW \1
 XBIOS 31,12
 ENDM

CONS_GBUFFERS:MACRO d
 PW \1
 XBIOS 14,4
 ENDM

CONS_GVECTORS:MACRO
 XBIOS 34,2
 ENDM

IKBD_OUTS:MACRO c,s
 PL \2
 PW \1
 XBIOS 25,8
 ENDM

MOUS_INIT:MACRO m,p,v
 PL \3
 PL \2
 PW \1
 XBIOS 0,12
 ENDM

MIDI_OUTS:MACRO c,s
 PL \2
 PW \1
 XBIOS 12,8
 ENDM

KBRD_STABLES:MACRO n,s,c
 PL \3
 PL \2
 PL \1
 XBIOS 16,14
 ENDM

KBRD_RTABLES:MACRO
 XBIOS 24,2
 ENDM

KBRD_DELREP:MACRO d,r
 PW \2
 PW \1
 XBIOS 35,6
 ENDM

SCRN_GRES:MACRO
 XBIOS 4,2
 ENDM

SCRN_GPBASE:MACRO
 XBIOS 2,2
 ENDM

SCRN_COLOR:MACRO r,c
 PW \2
 PW \1
 XBIOS 7,6
 ENDM

SCRN_SPALETTE:MACRO p
 PL \1
 XBIOS 6,6
 ENDM

SCRN_GLBASE:MACRO
 XBIOS 3,2
 ENDM

SCRN_SET:MACRO l,p,r
 PW \3
 PL \2
 PL \1
 XBIOS 5,12
 ENDM

SCRN_WVBL:MACRO
 XBIOS 37,2
 ENDM

SCRN_CSRCONF:MACRO f,p
 PW \2
 PW \1
 XBIOS 21,6
 ENDM

SCRN_BLITMODE:MACRO m
 PW \1
 XBIOS 64,4
 ENDM

SOUN_RW:MACRO d,r
 PW \2
 PW \1
 XBIOS 28,6
 ENDM

SOUN_PLAY:MACRO s
 PL \1
 XBIOS 32,6
 ENDM

SOUN_PABON:MACRO m
 PW \1
 XBIOS 30,4
 ENDM

SOUN_PABOFF:MACRO m
 PW \1
 XBIOS 29,4
 ENDM

DISK_FORMAT:MACRO b,d,s,t,f
 PW #$E5E5
 PL #$87654321
 PW #1
 PW \5
 PW \4
 PW \3
 PW \2
 CLR.L -(SP)
 PL \1
 XBIOS 10,26
 ENDM

DISK_READ:MACRO b,d,s,t,f,n
 PW \6
 PW \5
 PW \4
 PW \3
 PW \2
 CLR.L -(SP)
 PL \1
 XBIOS 8,20
 ENDM

DISK_WRITE:MACRO b,d,s,t,f,n
 PW \6
 PW \5
 PW \4
 PW \3
 PW \2
 CLR.L -(SP)
 PL \1
 XBIOS 9,20
 ENDM

DISK_VERIFY:MACRO b,d,s,t,f,n
 PW \6
 PW \5
 PW \4
 PW \3
 PW \2
 CLR.L -(SP)
 PL \1
 XBIOS 19,20
 ENDM

DISK_SBOOT:MACRO b,i,d,e
 PW \4
 PW \3
 PL \2
 PL \1
 XBIOS 18,14
 ENDM

PRNT_CONF:MACRO c
 PW \1
 XBIOS 33,4
 ENDM

PRNT_BLKCOPY:MACRO p
 BRA.S .L1
.L2 MOVE #1,$4EE
 PL \1
 XBIOS 36,6
 MOVE #-1,$4EE
 RTS
.L1 PL #.L2
 XBIOS 38,6
 ENDM

PRNT_SCRNCOPY:MACRO
 XBIOS 20,2
 ENDM

AUXI_SCONF:MACRO b,c,u,r,t,s
 PW \6
 PW \5
 PW \4
 PW \3
 PW \2
 PW \1
 XBIOS 15,14
 ENDM

TIME_GET:MACRO
 XBIOS 23,2
 ENDM

TIME_SET:MACRO t
 PL \1
 XBIOS 22,6
 ENDM

TIME_GRANDOM:MACRO
 XBIOS 17,2
 ENDM
