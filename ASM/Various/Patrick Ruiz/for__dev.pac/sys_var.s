rst_val=$426
rst_vec=$42A
mem_siz=$42E
mem_bot=$432
mem_top=$436
scr_bas=$44E
vbl_num=$454
vbl_ptr=$456
tim_cnt=$4BA
kbd_opt=$484
mch_sys=$5A0
