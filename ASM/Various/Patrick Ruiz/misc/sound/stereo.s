	PW	#"ST"
	PL	#TailleProgDSP/3
	PEA	ProgDSP(PC)
	XBIOS	109,12 Dsp_ExecProg
	PROG_SUPER #Init
	PROG_END

Init:	LEA	SND_XBARIN,A0
	MOVE	(A0),D0
	ANDI	#%1111111100000000,D0
	ORI	#%0000000010010001,D0
	MOVE	D0,(A0)
	LEA	SND_XBAROUT,A0
	MOVE	(A0),D0
	ANDI	#%1100100000000000,D0
	ORI	#%0010001110010011,D0
	MOVE	D0,(A0)

	MOVE.B	#%10010011,$FFFFA201
	;Host Command Bit (Handshake)
	;Host Vector=19

	MOVEQ	#2,D0
	MOVE.L	D0,$FFFFA204   Port HOST, X:$FFEB, pour du 25KHz.
	RTS

	D_
ProgDSP INCBIN	STEREO.P56
TailleProgDSP=*-ProgDSP
	END
