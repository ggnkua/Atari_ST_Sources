
F_CPU_MOD	=  0
FExit		=  1
FTitle		=  2
FOscilloscope	=  3
FMessage	=  4
FPower		=  5
FLoad		=  6
FModuleTitle	=  7
FPlay		= 13
FIPlay		= 14
FStop		= 15
FIStop		= 16
FRS		= 17
FIRS		= 18
FFS		= 19
FIFS		= 20
FFF		= 21
FIFF		= 22
F8KHz		= 26
F9KHz		= 30
F12KHz		= 34
F16KHz		= 38
F19KHz		= 27
F24KHz		= 31
F32KHz		= 35
F49KHz		= 39
FRepeat 	= 42
F8_16bits	= 45
FMo_St	 	= 48

S_POWEROFF	=  0

S_STOP		=  1

S_LOAD		=  2

S_LOADING	=  3

S_PLAYING	=  4

S_PAUSE 	=  5

S_NOMOD 	=  6

S_INCMOD	=  7
