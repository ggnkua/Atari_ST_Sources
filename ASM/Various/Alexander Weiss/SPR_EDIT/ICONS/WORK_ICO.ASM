            dc.w     $0000,$0000,$0000,$0000,$FFFF,$FFFE,$8000,$0003
            dc.w     $80F0,$0003,$8108,$18C3,$8084,$18C3,$8042,$18C3
            dc.w     $8021,$1AC3,$9021,$1FC3,$A821,$1DC3,$A441,$18C3
            dc.w     $A381,$0003,$A001,$0003,$9000,$8003,$8800,$4003
            dc.w     $8400,$2003,$83F0,$1003,$8008,$0F83,$8004,$0043
            dc.w     $8002,$0023,$8001,$0013,$8000,$8713,$8000,$8893
            dc.w     $8000,$8853,$8000,$8823,$8000,$8403,$8000,$4203
            dc.w     $8000,$2103,$8000,$1E03,$8000,$0003,$FFFF,$FFFF
