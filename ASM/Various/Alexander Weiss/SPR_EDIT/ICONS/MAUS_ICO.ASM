            dc.w     $0000,$0000,$0000,$0000,$FFFF,$FFFE,$8000,$0003
            dc.w     $8300,$0003,$8360,$0003,$87F0,$0003,$8FF0,$0003
            dc.w     $9F60,$0003,$9F80,$0003,$83E0,$0383,$83F0,$0E43
            dc.w     $87F8,$1C23,$8FFC,$3803,$8BFE,$7003,$82FE,$E003
            dc.w     $80FF,$C003,$803F,$8003,$81EF,$0003,$801C,$0003
            dc.w     $8078,$0003,$8000,$0003,$8000,$0003,$BB80,$0003
            dc.w     $BF80,$0003,$BF9E,$667B,$B583,$66C3,$B19F,$6673
            dc.w     $B1B3,$661B,$B19F,$3EF3,$8000,$0003,$FFFF,$FFFF
