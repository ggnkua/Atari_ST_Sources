/*
//////////////////////////////
//
//
// Created by Binary2Header V0.5
// (c) HxC2001
// (c) PowerOfAsm
//
// File: font.bmp  Size: 8192  (8193) x:256 y:256
//
//
*/


#include "bmaptype.h"


unsigned char __attribute__ ((aligned (2))) data_bmpfont_bmp[]={
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x01,0xf0,0x03,0xc0,0x00,0x00,0x00,0x70,0x07,0xe0,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x70,0x06,0x60,0x00,0x00,0x03,0xf0,0x07,0xe0,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x03,0xc0,0x0e,0x70,0x00,0x00,0x00,0x00,0x00,0xf0,0x06,0x60,0x00,0x00,0x03,0x70,0x03,0xc0,
0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x07,0xe0,0x0c,0x30,0x00,0x00,0x00,0x00,0x00,0xf0,0x03,0xc0,0x00,0x00,0x03,0xf0,0x03,0xc0,
0x00,0x00,0x01,0xf0,0x0f,0x80,0x01,0xf0,0x0f,0x80,0x01,0x80,0x0f,0xf0,0x07,0xe0,0x0c,0x30,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x03,0x30,0x07,0xe0,
0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x07,0xe0,0x0c,0x30,0x00,0x00,0x00,0x00,0x01,0x80,0x07,0xe0,0x00,0x00,0x03,0x30,0x03,0xc0,
0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x03,0xc0,0x0e,0x70,0x00,0x00,0x00,0x00,0x03,0x80,0x01,0x80,0x00,0x00,0x03,0x30,0x03,0xc0,
0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x06,0xc0,0x01,0x80,0x00,0x00,0x03,0x70,0x07,0xe0,
0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x06,0xc0,0x01,0x80,0x00,0x00,0x07,0x70,0x07,0xe0,
0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x03,0x80,0x01,0x80,0x00,0x00,0x07,0x00,0x00,0x00,
0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x01,0x80,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x30,0x03,0xc0,0x03,0x60,0x03,0xe0,0x01,0x80,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x70,0x07,0xe0,0x03,0x60,0x07,0xe0,0x01,0x80,0x00,0x00,0x01,0x80,0x03,0xc0,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0xf0,0x01,0x80,0x03,0x60,0x07,0xe0,0x01,0x80,0x00,0x00,0x01,0x80,0x07,0xe0,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x01,0xf0,0x01,0x80,0x03,0x60,0x07,0xe0,0x01,0x80,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x03,0xf0,0x01,0x80,0x03,0x60,0x07,0xe0,0x01,0x80,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0xc0,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x0f,0xf0,0x07,0xf0,0x01,0x80,0x03,0x60,0x07,0xe0,0x0f,0xf0,0x0f,0xf0,0x0f,0x80,0x01,0x80,0x01,0xf0,0x00,0x60,0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x03,0xf0,0x01,0x80,0x03,0x60,0x03,0xe0,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x07,0xf0,0x07,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x01,0xf0,0x01,0x80,0x03,0x60,0x01,0xe0,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x60,0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0xf0,0x01,0x80,0x00,0x00,0x01,0xe0,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0xc0,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x70,0x07,0xe0,0x00,0x00,0x01,0xe0,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x30,0x03,0xc0,0x03,0x60,0x01,0xe0,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x00,0x01,0x80,0x03,0x60,0x01,0xe0,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x01,0x80,0x06,0xc0,0x01,0x20,0x03,0x80,0x04,0x40,0x03,0xc0,0x01,0x80,0x00,0x40,0x01,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,
0x00,0x00,0x01,0x80,0x06,0xc0,0x01,0x20,0x07,0xc0,0x0a,0x40,0x06,0x60,0x01,0x80,0x00,0xc0,0x01,0x80,0x03,0xe0,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,
0x00,0x00,0x01,0x80,0x06,0xc0,0x01,0x20,0x0d,0x60,0x0a,0x00,0x06,0x60,0x01,0x80,0x00,0x80,0x00,0x80,0x01,0xc0,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,
0x00,0x00,0x01,0x80,0x06,0xc0,0x07,0xe0,0x0d,0x00,0x0a,0x80,0x03,0xc0,0x01,0x80,0x01,0x80,0x00,0xc0,0x03,0x60,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,
0x00,0x00,0x01,0x80,0x00,0x00,0x02,0x40,0x07,0x80,0x04,0x80,0x03,0x80,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,
0x00,0x00,0x01,0x80,0x00,0x00,0x02,0x40,0x01,0xc0,0x01,0x20,0x07,0xc0,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x00,0x0f,0xf0,0x00,0x00,0x01,0xe0,0x00,0x00,0x01,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xe0,0x01,0x60,0x01,0x50,0x0c,0xf0,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x00,0x01,0x80,0x00,0x00,0x01,0xe0,0x00,0x00,0x01,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0d,0x60,0x00,0x50,0x0c,0x70,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,
0x00,0x00,0x01,0x80,0x00,0x00,0x04,0x80,0x07,0xc0,0x02,0x50,0x0c,0x70,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x01,0x80,0x02,0x00,
0x00,0x00,0x01,0x80,0x00,0x00,0x04,0x80,0x03,0x80,0x02,0x20,0x03,0xd8,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x01,0x80,0x02,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xc0,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0x80,0x01,0x80,0x03,0xc0,0x03,0xc0,0x00,0xc0,0x07,0xe0,0x03,0xc0,0x0f,0xe0,0x07,0xc0,0x03,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xc0,
0x07,0xc0,0x03,0x80,0x07,0xe0,0x07,0xe0,0x01,0xc0,0x07,0xe0,0x07,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xc0,0x00,0x00,0x00,0x00,0x00,0x20,0x00,0x00,0x08,0x00,0x07,0xe0,
0x0e,0xe0,0x07,0x80,0x0c,0x60,0x0c,0x60,0x01,0xc0,0x04,0x00,0x0e,0x60,0x00,0x40,0x0c,0x60,0x0c,0x60,0x01,0x80,0x01,0x80,0x00,0xe0,0x0f,0xe0,0x0e,0x00,0x0c,0x30,
0x0c,0x60,0x05,0x80,0x0c,0x60,0x00,0x60,0x02,0xc0,0x0f,0x80,0x0c,0x00,0x00,0x80,0x0c,0x60,0x0c,0x60,0x01,0x80,0x01,0x80,0x03,0xc0,0x0f,0xe0,0x07,0x80,0x00,0x30,
0x0c,0x60,0x01,0x80,0x00,0xc0,0x01,0xc0,0x06,0xc0,0x0f,0xc0,0x0f,0xc0,0x01,0x80,0x07,0xc0,0x0f,0xe0,0x00,0x00,0x00,0x00,0x0e,0x00,0x00,0x00,0x01,0xe0,0x00,0xe0,
0x0c,0x60,0x01,0x80,0x01,0x80,0x00,0x60,0x0c,0xc0,0x0c,0x60,0x0f,0xe0,0x01,0x80,0x07,0xc0,0x07,0xe0,0x00,0x00,0x00,0x00,0x0f,0x00,0x0f,0xe0,0x01,0xe0,0x01,0xc0,
0x0c,0x60,0x01,0x80,0x03,0x00,0x0c,0x60,0x0f,0xe0,0x00,0x60,0x0c,0x60,0x01,0x00,0x0c,0x60,0x00,0x60,0x00,0x00,0x00,0x00,0x03,0xc0,0x0f,0xe0,0x07,0x80,0x01,0x80,
0x0e,0xe0,0x01,0x80,0x06,0x00,0x0e,0x60,0x0f,0xe0,0x0c,0x60,0x0c,0x60,0x03,0x00,0x0c,0x60,0x0c,0xe0,0x00,0x00,0x00,0x00,0x00,0xe0,0x00,0x00,0x0e,0x00,0x00,0x00,
0x07,0xc0,0x01,0x80,0x0f,0xe0,0x07,0xc0,0x00,0xc0,0x07,0xc0,0x07,0xe0,0x03,0x00,0x0f,0xe0,0x0f,0xc0,0x01,0x80,0x01,0x80,0x00,0x20,0x00,0x00,0x08,0x00,0x01,0x80,
0x03,0x80,0x01,0x80,0x0f,0xe0,0x03,0x80,0x00,0xc0,0x03,0x80,0x03,0x80,0x03,0x00,0x03,0xc0,0x07,0x80,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0xf0,0x01,0xc0,0x0f,0xe0,0x03,0xc0,0x0f,0xc0,0x07,0xf0,0x07,0xf0,0x03,0xc0,0x0c,0x30,0x01,0x80,0x00,0x60,0x0c,0x30,0x06,0x00,0x1c,0x1c,0x0c,0x30,0x07,0xc0,
0x0c,0x18,0x01,0xc0,0x0f,0xf0,0x07,0xe0,0x0f,0xe0,0x07,0xf0,0x07,0xf0,0x0f,0xe0,0x0c,0x30,0x01,0x80,0x00,0x60,0x0c,0x60,0x06,0x00,0x1e,0x3c,0x0e,0x30,0x0f,0xe0,
0x13,0xb4,0x03,0xe0,0x0c,0x30,0x06,0x70,0x0c,0x70,0x06,0x00,0x06,0x00,0x1c,0x70,0x0c,0x30,0x01,0x80,0x00,0x60,0x0c,0xc0,0x06,0x00,0x1e,0x3c,0x0e,0x30,0x0c,0x60,
0x27,0xf2,0x03,0x60,0x0c,0x30,0x0c,0x20,0x0c,0x30,0x06,0x00,0x06,0x00,0x18,0x20,0x0c,0x30,0x01,0x80,0x00,0x60,0x0d,0x80,0x06,0x00,0x1a,0x2c,0x0f,0x30,0x18,0x30,
0x46,0x72,0x03,0x60,0x0f,0xe0,0x0c,0x00,0x0c,0x30,0x07,0xf0,0x07,0xe0,0x18,0x00,0x0f,0xf0,0x01,0x80,0x00,0x60,0x0f,0xc0,0x06,0x00,0x1b,0x6c,0x0d,0xb0,0x18,0x30,
0x4c,0x72,0x06,0x30,0x0f,0xf0,0x0c,0x00,0x0c,0x30,0x07,0xf0,0x07,0xe0,0x18,0xf0,0x0f,0xf0,0x01,0x80,0x00,0x60,0x0e,0xc0,0x06,0x00,0x1b,0x6c,0x0d,0xb0,0x18,0x30,
0x4c,0x62,0x07,0xf0,0x0c,0x30,0x0c,0x20,0x0c,0x30,0x06,0x00,0x06,0x00,0x18,0xf0,0x0c,0x30,0x01,0x80,0x0c,0x60,0x0c,0x60,0x06,0x00,0x19,0xcc,0x0c,0xf0,0x18,0x30,
0x4c,0xe4,0x07,0xf0,0x0c,0x30,0x0e,0x70,0x0c,0x70,0x06,0x00,0x06,0x00,0x1c,0x30,0x0c,0x30,0x01,0x80,0x0c,0x60,0x0c,0x60,0x06,0x00,0x19,0xcc,0x0c,0xf0,0x0c,0x60,
0x4f,0xec,0x0c,0x18,0x0f,0xf0,0x07,0xe0,0x0f,0xe0,0x07,0xf0,0x06,0x00,0x0f,0xe0,0x0c,0x30,0x01,0x80,0x0f,0xe0,0x0c,0x30,0x07,0xf0,0x19,0xcc,0x0c,0x70,0x0f,0xe0,
0x27,0x70,0x0c,0x18,0x0f,0xe0,0x03,0xc0,0x0f,0xc0,0x07,0xf0,0x06,0x00,0x03,0xc0,0x0c,0x30,0x01,0x80,0x07,0x80,0x0c,0x30,0x07,0xf0,0x18,0x8c,0x0c,0x30,0x07,0xc0,
0x30,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x18,0x0c,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x07,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x07,0xe0,0x07,0xc0,0x0f,0xe0,0x03,0xe0,0x0f,0xf0,0x0c,0x30,0x0c,0x18,0x31,0xc6,0x06,0x30,0x0c,0x30,0x0f,0xf0,0x01,0xe0,0x02,0x00,0x03,0xc0,0x01,0x80,0x00,0x00,
0x07,0xf0,0x0f,0xe0,0x0f,0xf0,0x07,0xf0,0x0f,0xf0,0x0c,0x30,0x06,0x30,0x31,0xc6,0x06,0x30,0x0c,0x30,0x0f,0xf0,0x01,0xe0,0x02,0x00,0x03,0xc0,0x01,0x80,0x00,0x00,
0x06,0x30,0x0c,0x60,0x0c,0x30,0x06,0x30,0x01,0x80,0x0c,0x30,0x06,0x30,0x19,0xcc,0x03,0x60,0x06,0x60,0x00,0x60,0x01,0x80,0x01,0x00,0x00,0xc0,0x03,0xc0,0x00,0x00,
0x06,0x30,0x18,0x30,0x0c,0x30,0x06,0x00,0x01,0x80,0x0c,0x30,0x06,0x30,0x1b,0x6c,0x01,0xc0,0x03,0xc0,0x00,0xc0,0x01,0x80,0x01,0x00,0x00,0xc0,0x02,0x40,0x00,0x00,
0x07,0xf0,0x18,0x30,0x0f,0xe0,0x07,0xe0,0x01,0x80,0x0c,0x30,0x03,0x60,0x1b,0x6c,0x01,0xc0,0x03,0xc0,0x01,0x80,0x01,0x80,0x01,0x00,0x00,0xc0,0x06,0x60,0x00,0x00,
0x07,0xe0,0x18,0x30,0x0f,0xc0,0x03,0xf0,0x01,0x80,0x0c,0x30,0x03,0x60,0x1b,0x6c,0x01,0xc0,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0x80,0x00,0xc0,0x00,0x00,0x00,0x00,
0x06,0x00,0x19,0x30,0x0c,0xe0,0x00,0x30,0x01,0x80,0x0c,0x30,0x03,0xe0,0x1f,0x7c,0x01,0xc0,0x01,0x80,0x03,0x00,0x01,0x80,0x00,0x80,0x00,0xc0,0x00,0x00,0x00,0x00,
0x06,0x00,0x1c,0xf0,0x0c,0x60,0x06,0x30,0x01,0x80,0x0e,0x70,0x01,0xc0,0x0e,0x38,0x03,0x60,0x01,0x80,0x06,0x00,0x01,0x80,0x00,0x80,0x00,0xc0,0x00,0x00,0x00,0x00,
0x06,0x00,0x0f,0xe0,0x0c,0x70,0x03,0xf0,0x01,0x80,0x07,0xe0,0x01,0xc0,0x0e,0x38,0x06,0x30,0x01,0x80,0x0f,0xf0,0x01,0x80,0x00,0x40,0x00,0xc0,0x00,0x00,0x00,0x00,
0x06,0x00,0x07,0xa0,0x0c,0x38,0x01,0xe0,0x01,0x80,0x03,0xc0,0x01,0xc0,0x0e,0x38,0x06,0x30,0x01,0x80,0x0f,0xf0,0x01,0x80,0x00,0x40,0x00,0xc0,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0xc0,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xe0,0x00,0x00,0x03,0xc0,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xe0,0x00,0x00,0x03,0xc0,0x00,0x00,0x0f,0xf0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0x00,0x00,0x00,0x06,0x00,0x00,0x00,0x00,0x30,0x00,0x00,0x00,0xe0,0x00,0x00,0x06,0x00,0x01,0x80,0x01,0x80,0x06,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x00,0x00,0x06,0x00,0x00,0x00,0x00,0x30,0x00,0x00,0x01,0x80,0x00,0x00,0x06,0x00,0x00,0x00,0x00,0x00,0x06,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x03,0xc0,0x06,0xc0,0x01,0xc0,0x01,0xb0,0x01,0xc0,0x03,0xe0,0x01,0xb0,0x06,0xe0,0x01,0x80,0x01,0x80,0x06,0x60,0x01,0x80,0x1b,0x70,0x06,0xe0,0x01,0xc0,
0x00,0x00,0x07,0xe0,0x07,0xe0,0x03,0xc0,0x03,0xf0,0x03,0xe0,0x03,0xe0,0x03,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x06,0xc0,0x01,0x80,0x1f,0xf8,0x07,0xf0,0x03,0xe0,
0x00,0x00,0x00,0x60,0x07,0x70,0x06,0x60,0x07,0x70,0x06,0x30,0x01,0x80,0x07,0x70,0x07,0x30,0x01,0x80,0x01,0x80,0x07,0x80,0x01,0x80,0x19,0x98,0x07,0x30,0x07,0x70,
0x00,0x00,0x01,0xe0,0x06,0x30,0x06,0x00,0x06,0x30,0x07,0xf0,0x01,0x80,0x06,0x30,0x06,0x30,0x01,0x80,0x01,0x80,0x07,0x80,0x01,0x80,0x19,0x98,0x06,0x30,0x06,0x30,
0x00,0x00,0x03,0x60,0x06,0x30,0x06,0x00,0x06,0x30,0x07,0xf0,0x01,0x80,0x06,0x30,0x06,0x30,0x01,0x80,0x01,0x80,0x07,0xc0,0x01,0x80,0x19,0x98,0x06,0x30,0x06,0x30,
0x00,0x00,0x06,0x60,0x06,0x70,0x06,0x60,0x07,0x70,0x06,0x00,0x01,0x80,0x07,0x70,0x06,0x30,0x01,0x80,0x01,0x80,0x06,0xc0,0x01,0x80,0x19,0x98,0x06,0x30,0x07,0x70,
0x00,0x00,0x07,0xe0,0x07,0xe0,0x03,0xe0,0x03,0xf0,0x03,0xf0,0x01,0x80,0x03,0xf0,0x06,0x30,0x01,0x80,0x01,0x80,0x06,0x60,0x01,0x80,0x19,0x98,0x06,0x30,0x03,0xe0,
0x00,0x00,0x03,0xb0,0x06,0xc0,0x01,0xc0,0x01,0xb0,0x01,0xe0,0x01,0x80,0x01,0xb0,0x06,0x30,0x01,0x80,0x01,0x80,0x06,0x60,0x01,0x80,0x19,0x98,0x06,0x30,0x01,0xc0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x30,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xf0,0x00,0x00,0x00,0x00,0x07,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xe0,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xf0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xe0,0x01,0x00,0x03,0x80,0x00,0x00,0x06,0x30,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xe0,0x01,0x00,0x03,0xc0,0x00,0x00,0x06,0x30,
0x06,0xc0,0x01,0xb0,0x03,0x60,0x03,0xc0,0x03,0xe0,0x06,0x30,0x06,0x30,0x31,0x18,0x06,0x60,0x0c,0x60,0x07,0xc0,0x01,0x80,0x01,0x00,0x00,0xc0,0x00,0x00,0x06,0x30,
0x07,0xe0,0x03,0xf0,0x03,0xe0,0x07,0xe0,0x03,0xe0,0x06,0x30,0x06,0x30,0x33,0x98,0x06,0x40,0x0c,0x60,0x07,0xc0,0x01,0x80,0x01,0x00,0x00,0xc0,0x07,0x20,0x06,0x30,
0x07,0x70,0x07,0x70,0x03,0x80,0x06,0x00,0x01,0x80,0x06,0x30,0x06,0x30,0x1b,0xb0,0x03,0xc0,0x06,0xc0,0x00,0xc0,0x01,0x80,0x01,0x00,0x00,0xc0,0x0f,0xe0,0x06,0x30,
0x06,0x30,0x06,0x30,0x03,0x00,0x07,0x80,0x01,0x80,0x06,0x30,0x03,0x60,0x1b,0xb0,0x01,0x80,0x06,0xc0,0x01,0x80,0x01,0x80,0x01,0x00,0x00,0xc0,0x00,0xc0,0x06,0x30,
0x06,0x30,0x06,0x30,0x03,0x00,0x01,0xe0,0x01,0x80,0x06,0x30,0x03,0x60,0x1e,0xf0,0x01,0x80,0x06,0xc0,0x03,0x00,0x03,0x00,0x01,0x00,0x00,0x60,0x00,0x00,0x06,0x30,
0x07,0x70,0x07,0x70,0x03,0x00,0x00,0x60,0x01,0x80,0x06,0x70,0x01,0xc0,0x0e,0xe0,0x03,0xc0,0x07,0xc0,0x02,0x00,0x01,0x80,0x01,0x00,0x00,0xc0,0x00,0x00,0x06,0x30,
0x07,0xe0,0x03,0xf0,0x03,0x00,0x07,0xe0,0x01,0xe0,0x07,0xf0,0x01,0xc0,0x0e,0xe0,0x06,0x60,0x03,0x80,0x07,0xc0,0x01,0x80,0x01,0x00,0x00,0xc0,0x00,0x00,0x06,0x30,
0x06,0xc0,0x01,0xb0,0x03,0x00,0x03,0xc0,0x00,0xe0,0x03,0xb0,0x01,0xc0,0x0c,0x60,0x06,0x60,0x03,0x80,0x07,0xc0,0x01,0x80,0x01,0x00,0x00,0xc0,0x00,0x00,0x07,0xf0,
0x06,0x00,0x00,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x80,0x00,0x00,0x01,0x80,0x01,0x00,0x00,0xc0,0x00,0x00,0x00,0x00,
0x06,0x00,0x00,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0x00,0x01,0xe0,0x01,0x00,0x03,0xc0,0x00,0x00,0x00,0x00,
0x06,0x00,0x00,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0x00,0x00,0xe0,0x01,0x00,0x03,0x80,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x40,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0xe0,0x03,0xc0,0x00,0x00,0x00,0x70,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x80,0x11,0x00,0x03,0xe0,0x00,0x00,0x1d,0xfc,0x03,0xc0,0x0f,0xf0,0x03,0xc0,
0x03,0xe0,0x03,0x00,0x00,0x00,0x00,0xe0,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x40,0x29,0x00,0x07,0xf0,0x00,0x00,0x3f,0xfc,0x03,0x00,0x0f,0xf0,0x03,0x00,
0x06,0x00,0x03,0x00,0x00,0x00,0x00,0xc0,0x00,0x00,0x00,0x00,0x01,0x80,0x0f,0xf0,0x00,0x00,0x28,0x00,0x06,0x30,0x00,0x00,0x73,0x80,0x03,0x00,0x00,0x60,0x03,0x00,
0x0f,0xc0,0x03,0x00,0x00,0x00,0x03,0xe0,0x00,0x00,0x00,0x00,0x07,0xe0,0x0f,0xf0,0x00,0x00,0x2a,0x00,0x06,0x00,0x00,0x00,0x61,0x80,0x03,0x00,0x00,0xc0,0x03,0x00,
0x06,0x00,0x03,0x00,0x00,0x00,0x03,0xe0,0x00,0x00,0x00,0x00,0x07,0xe0,0x01,0x80,0x00,0x00,0x12,0x00,0x07,0xe0,0x00,0x40,0x61,0xfc,0x03,0x00,0x01,0x80,0x03,0x00,
0x0f,0xc0,0x03,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x04,0x88,0x03,0xf0,0x00,0xc0,0x61,0xfc,0x03,0x00,0x01,0x80,0x03,0x00,
0x06,0x00,0x03,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x05,0x54,0x00,0x30,0x01,0x80,0x61,0x80,0x03,0x00,0x03,0x00,0x03,0x00,
0x03,0x00,0x03,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x01,0x54,0x06,0x30,0x01,0x80,0x73,0x80,0x03,0x00,0x06,0x00,0x03,0x00,
0x03,0xe0,0x03,0x00,0x01,0x80,0x03,0x00,0x06,0xc0,0x31,0x8c,0x01,0x80,0x0f,0xf0,0x00,0x00,0x09,0x54,0x03,0xf0,0x00,0xc0,0x3f,0xfc,0x03,0x00,0x0f,0xf0,0x03,0x00,
0x01,0xe0,0x03,0xc0,0x01,0x80,0x03,0x00,0x06,0xc0,0x31,0x8c,0x01,0x80,0x0f,0xf0,0x00,0x00,0x08,0x88,0x01,0xe0,0x00,0x40,0x1d,0xfc,0x03,0xc0,0x0f,0xf0,0x03,0xc0,
0x00,0x00,0x00,0x00,0x00,0x80,0x03,0x00,0x02,0x40,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x01,0x00,0x07,0x00,0x04,0x80,0x00,0x00,0x01,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x0e,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x20,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x80,0x00,0x00,
0x03,0xc0,0x00,0x80,0x01,0x80,0x02,0x40,0x06,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xa0,0x7d,0x8c,0x00,0x80,0x00,0x00,0x00,0x00,0x03,0xc0,0x01,0x00,0x06,0x18,
0x03,0x00,0x01,0x00,0x01,0x80,0x04,0x80,0x06,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xe0,0x11,0x8c,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0x00,0x06,0x18,
0x03,0x00,0x01,0x80,0x00,0x80,0x06,0xc0,0x02,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x11,0x54,0x03,0xc0,0x00,0x00,0x07,0x38,0x03,0x00,0x07,0xc0,0x03,0x30,
0x03,0x00,0x01,0x80,0x01,0x00,0x06,0xc0,0x04,0x80,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x11,0x74,0x07,0xe0,0x00,0x00,0x0f,0xf8,0x03,0x00,0x07,0xc0,0x01,0xe0,
0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x11,0x74,0x06,0x00,0x01,0x00,0x18,0xcc,0x03,0x00,0x00,0xc0,0x01,0xe0,
0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xc0,0x0f,0xf0,0x7f,0xfe,0x00,0x00,0x11,0x24,0x07,0x80,0x01,0x80,0x18,0xfc,0x03,0x00,0x01,0x80,0x00,0xc0,
0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x0f,0xf0,0x7f,0xfe,0x00,0x00,0x00,0x00,0x01,0xe0,0x00,0xc0,0x18,0xc0,0x03,0x00,0x03,0x00,0x00,0xc0,
0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x60,0x00,0xc0,0x18,0xcc,0x03,0x00,0x02,0x00,0x00,0xc0,
0x03,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xe0,0x01,0x80,0x0f,0xf8,0x03,0x00,0x07,0xc0,0x00,0xc0,
0x03,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xc0,0x01,0x00,0x07,0x38,0x03,0xc0,0x07,0xc0,0x00,0xc0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xf0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x40,0x03,0xc0,0x00,0x00,0x0c,0x30,0x01,0x00,0x03,0x80,0x01,0x20,0x03,0xc0,0x01,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xc0,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x80,0x07,0xe0,0x04,0x20,0x06,0x60,0x01,0x00,0x06,0xc0,0x00,0x00,0x0c,0x30,0x02,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x30,0x00,0x00,
0x00,0x00,0x01,0x80,0x03,0x80,0x06,0x60,0x0f,0xf0,0x06,0x60,0x01,0x00,0x06,0x00,0x00,0x00,0x09,0x90,0x01,0xc0,0x00,0x00,0x0f,0xe0,0x00,0x00,0x0b,0x90,0x00,0x00,
0x00,0x00,0x01,0x80,0x07,0xc0,0x06,0x00,0x06,0x60,0x03,0xc0,0x01,0x00,0x07,0x00,0x00,0x00,0x12,0x48,0x02,0x40,0x00,0x00,0x0f,0xe0,0x00,0x00,0x12,0x48,0x00,0x00,
0x00,0x00,0x00,0x00,0x0c,0xe0,0x0f,0xc0,0x04,0x20,0x0f,0xf0,0x01,0x00,0x07,0xc0,0x00,0x00,0x12,0x08,0x01,0xc0,0x02,0x20,0x00,0x60,0x00,0x00,0x12,0x48,0x00,0x00,
0x00,0x00,0x00,0x00,0x0d,0x00,0x0f,0xc0,0x04,0x20,0x01,0x80,0x01,0x00,0x0c,0xe0,0x00,0x00,0x12,0x08,0x00,0x00,0x06,0x60,0x00,0x60,0x01,0xe0,0x13,0x88,0x00,0x00,
0x00,0x00,0x01,0x80,0x0d,0x00,0x03,0x00,0x06,0x60,0x0f,0xf0,0x00,0x00,0x0c,0x60,0x00,0x00,0x12,0x48,0x00,0x00,0x0c,0xc0,0x00,0x60,0x01,0xe0,0x12,0xc8,0x00,0x00,
0x00,0x00,0x01,0x80,0x0f,0x60,0x07,0x00,0x0f,0xf0,0x01,0x80,0x00,0x00,0x0e,0x60,0x00,0x00,0x09,0x90,0x00,0x00,0x0c,0xc0,0x00,0x00,0x00,0x00,0x0a,0x50,0x00,0x00,
0x00,0x00,0x01,0x80,0x07,0xc0,0x0f,0xf0,0x04,0x20,0x01,0x80,0x01,0x00,0x07,0xc0,0x00,0x00,0x0c,0x30,0x00,0x00,0x06,0x60,0x00,0x00,0x00,0x00,0x0c,0x30,0x00,0x00,
0x00,0x00,0x01,0x80,0x03,0x80,0x04,0xe0,0x00,0x00,0x01,0x80,0x01,0x00,0x01,0xc0,0x00,0x00,0x03,0xc0,0x00,0x00,0x02,0x20,0x00,0x00,0x00,0x00,0x03,0xc0,0x00,0x00,
0x00,0x00,0x01,0x80,0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x01,0x80,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x0c,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x01,0x80,0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x07,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,0x00,0xc0,0x00,0x00,0x07,0xe0,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0xc0,0x00,0x00,0x10,0x40,0x10,0x20,0x18,0x20,0x00,0x00,
0x02,0x40,0x01,0x80,0x02,0x40,0x02,0x40,0x01,0x80,0x00,0x00,0x0f,0x40,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x20,0x00,0x00,0x30,0x40,0x30,0x40,0x24,0x40,0x00,0x00,
0x02,0x40,0x0f,0xf0,0x00,0x80,0x00,0xc0,0x00,0x00,0x0c,0x60,0x0f,0x40,0x00,0x00,0x00,0x00,0x00,0x80,0x01,0x20,0x00,0x00,0x10,0x80,0x10,0x80,0x0c,0x40,0x01,0x80,
0x01,0x80,0x0f,0xf0,0x01,0x00,0x02,0x40,0x00,0x00,0x0c,0x60,0x0f,0x40,0x00,0x00,0x00,0x00,0x00,0x80,0x01,0x20,0x00,0x00,0x11,0x00,0x10,0x80,0x24,0x80,0x01,0x80,
0x00,0x00,0x01,0x80,0x03,0xc0,0x01,0x80,0x00,0x00,0x0c,0x60,0x0f,0x40,0x01,0x80,0x00,0x00,0x00,0x80,0x00,0xc0,0x04,0x40,0x11,0x00,0x11,0x00,0x18,0x80,0x00,0x00,
0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x60,0x07,0x40,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x60,0x02,0x10,0x02,0x30,0x01,0x10,0x01,0x80,
0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x60,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x30,0x04,0x30,0x00,0x48,0x00,0x30,0x03,0x80,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x60,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x30,0x04,0x50,0x04,0x10,0x02,0x50,0x07,0x00,
0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xe0,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x60,0x08,0x78,0x08,0x20,0x04,0x78,0x06,0x00,
0x00,0x00,0x0f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x0d,0x60,0x01,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0x40,0x10,0x10,0x10,0x78,0x04,0x10,0x0c,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x00,0x01,0x40,0x00,0x00,0x01,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x30,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x00,0x01,0x40,0x00,0x00,0x00,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xe0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0c,0x00,0x01,0x40,0x00,0x00,0x03,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xc0,
0x03,0x00,0x00,0xc0,0x01,0x00,0x07,0x40,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x60,0x00,0x80,0x00,0x00,0x03,0x00,0x00,0xc0,0x00,0x80,0x00,0x00,
0x01,0x80,0x01,0x80,0x02,0x80,0x05,0xc0,0x02,0x40,0x02,0x40,0x00,0x00,0x00,0x00,0x00,0xc0,0x00,0xc0,0x01,0x40,0x01,0x20,0x01,0x80,0x01,0x80,0x01,0x40,0x02,0x40,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0x80,0x03,0x80,0x03,0x80,0x03,0x80,0x03,0x80,0x03,0x80,0x07,0xfc,0x03,0xc0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x03,0x80,0x03,0x80,0x03,0x80,0x03,0x80,0x03,0x80,0x03,0x80,0x0d,0xfc,0x07,0xe0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x07,0xc0,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x0d,0x80,0x06,0x70,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x06,0xc0,0x06,0xc0,0x06,0xc0,0x06,0xc0,0x06,0xc0,0x06,0xc0,0x19,0x80,0x0c,0x20,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x06,0xc0,0x06,0xc0,0x06,0xc0,0x06,0xc0,0x06,0xc0,0x06,0xc0,0x19,0xfc,0x0c,0x00,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x0c,0x60,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x31,0xfc,0x0c,0x00,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x3f,0x80,0x0c,0x20,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x7f,0x80,0x0e,0x70,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x61,0xfc,0x07,0xe0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0xc1,0xfc,0x03,0xc0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x03,0xa0,0x03,0x00,0x01,0x80,0x01,0x00,0x07,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x00,0x00,0xc0,0x00,0x80,0x00,0x00,0x00,0x60,0x00,0x00,0x00,0x00,
0x00,0x00,0x02,0xe0,0x01,0x80,0x03,0x00,0x02,0x80,0x05,0xc0,0x02,0x40,0x00,0x00,0x00,0x00,0x01,0x80,0x01,0x80,0x01,0x40,0x02,0x40,0x00,0xc0,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x0f,0xc0,0x0c,0x30,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x00,0x00,0x07,0xd0,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x06,0x18,0x06,0x00,0x03,0x80,
0x0f,0xe0,0x0e,0x30,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x00,0x00,0x0f,0xf0,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x06,0x18,0x06,0x00,0x07,0xc0,
0x0c,0x70,0x0e,0x30,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x04,0x40,0x0c,0x70,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x03,0x30,0x07,0xe0,0x06,0xc0,
0x0c,0x30,0x0f,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x06,0xc0,0x18,0xf0,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x01,0xe0,0x07,0xf0,0x06,0x80,
0x1f,0x30,0x0d,0xb0,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x03,0x80,0x19,0xb0,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x01,0xe0,0x06,0x30,0x07,0x80,
0x0c,0x30,0x0d,0xb0,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x03,0x80,0x1b,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x00,0xc0,0x06,0x30,0x07,0xc0,
0x0c,0x30,0x0c,0xf0,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x18,0x30,0x06,0xc0,0x1e,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x0c,0x30,0x00,0xc0,0x07,0xf0,0x06,0xe0,
0x0c,0x70,0x0c,0xf0,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x0c,0x60,0x04,0x40,0x1c,0x60,0x0e,0x70,0x0e,0x70,0x0e,0x70,0x0e,0x70,0x00,0xc0,0x07,0xe0,0x06,0x60,
0x0f,0xe0,0x0c,0x70,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x0f,0xe0,0x00,0x00,0x1f,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x00,0xc0,0x06,0x00,0x06,0xe0,
0x0f,0xc0,0x0c,0x30,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x07,0xc0,0x00,0x00,0x1f,0xc0,0x03,0xc0,0x03,0xc0,0x03,0xc0,0x03,0xc0,0x00,0xc0,0x06,0x00,0x06,0xc0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0x00,0x00,0xc0,0x00,0x80,0x03,0xa0,0x00,0x00,0x02,0x40,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x80,0x00,0x00,0x03,0x00,0x00,0xc0,0x00,0x80,0x00,0x00,
0x01,0x80,0x01,0x80,0x01,0x40,0x02,0xe0,0x02,0x40,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0xc0,0x01,0x80,0x01,0x40,0x01,0x20,0x01,0x80,0x01,0x80,0x01,0x40,0x02,0x40,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0xc0,0x03,0xc0,0x03,0xc0,0x03,0xc0,0x03,0xc0,0x03,0xc0,0x0f,0x70,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x07,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x1f,0xf8,0x03,0xc0,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x00,0x60,0x00,0x60,0x00,0x60,0x00,0x60,0x00,0x60,0x00,0x60,0x11,0x8c,0x06,0x60,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x01,0xe0,0x01,0xe0,0x01,0xe0,0x01,0xe0,0x01,0xe0,0x01,0xe0,0x07,0xfc,0x06,0x00,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x03,0x60,0x03,0x60,0x03,0x60,0x03,0x60,0x03,0x60,0x03,0x60,0x09,0x80,0x06,0x00,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x06,0x60,0x06,0x60,0x06,0x60,0x06,0x60,0x06,0x60,0x06,0x60,0x19,0xcc,0x06,0x60,0x06,0x00,0x06,0x00,0x06,0x00,0x06,0x00,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x07,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x07,0xe0,0x1f,0xf8,0x03,0xe0,0x03,0xf0,0x03,0xf0,0x03,0xf0,0x03,0xf0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x03,0xb0,0x03,0xb0,0x03,0xb0,0x03,0xb0,0x03,0xb0,0x03,0xb0,0x0e,0x70,0x01,0xc0,0x01,0xe0,0x01,0xe0,0x01,0xe0,0x01,0xe0,0x01,0x80,0x01,0x80,0x01,0x80,0x01,0x80,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x03,0xa0,0x01,0x80,0x00,0xc0,0x00,0x80,0x03,0xa0,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0xc0,0x00,0x80,0x00,0x00,0x00,0xc0,0x00,0x00,0x00,0x00,
0x01,0x80,0x02,0xe0,0x00,0xc0,0x01,0x80,0x01,0x40,0x02,0xe0,0x01,0x20,0x00,0x00,0x00,0x00,0x00,0xc0,0x01,0x80,0x01,0x40,0x01,0x20,0x01,0x80,0x06,0x00,0x02,0x40,
0x00,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x06,0x00,0x00,0x00,
0x00,0x60,0x06,0xe0,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0x80,0x01,0xe0,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x0c,0x60,0x06,0xc0,0x0c,0x60,
0x01,0xe0,0x07,0xf0,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x00,0x00,0x03,0xe0,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x0c,0x60,0x07,0xe0,0x0c,0x60,
0x03,0xf0,0x07,0x30,0x07,0x70,0x07,0x70,0x07,0x70,0x07,0x70,0x07,0x70,0x0f,0xf0,0x06,0x60,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0xc0,0x07,0x70,0x06,0xc0,
0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x0f,0xf0,0x06,0xf0,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0xc0,0x06,0x30,0x06,0xc0,
0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x00,0x00,0x07,0xb0,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0x30,0x06,0xc0,0x06,0x30,0x06,0xc0,
0x06,0x30,0x06,0x30,0x07,0x70,0x07,0x70,0x07,0x70,0x07,0x70,0x07,0x70,0x01,0x80,0x07,0x30,0x06,0x70,0x06,0x70,0x06,0x70,0x06,0x70,0x07,0xc0,0x06,0x70,0x07,0xc0,
0x03,0xe0,0x06,0x30,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x03,0xe0,0x01,0x80,0x03,0xe0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x07,0xf0,0x03,0x80,0x07,0xe0,0x03,0x80,
0x01,0xc0,0x06,0x30,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x01,0xc0,0x00,0x00,0x03,0xc0,0x03,0xb0,0x03,0xb0,0x03,0xb0,0x03,0xb0,0x03,0x80,0x06,0xc0,0x03,0x80,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x80,0x06,0x00,0x03,0x80,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0x00,0x06,0x00,0x03,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0x00,0x06,0x00,0x07,0x00,
0xcd};


static bmaptype bitmap_font_bmp[]=
{{
 1,
 256,
 256,
 8192,
 8193,
 data_bmpfont_bmp
}};
