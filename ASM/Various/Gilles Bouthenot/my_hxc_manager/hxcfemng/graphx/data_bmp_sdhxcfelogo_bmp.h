/*
//////////////////////////////
//
//
// Created by Binary2Header V0.5
// (c) HxC2001
// (c) PowerOfAsm
//
// File: sdhxcfelogo.bmp  Size: 1320  (1321) x:320 y:33
//
//
*/


#include "bmaptype.h"


unsigned char __attribute__ ((aligned (2))) data_bmpsdhxcfelogo_bmp[]={
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xf0,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x07,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xfc,
0x00,0xff,0x00,0x00,0x1f,0x80,0x00,0x00,0x00,0x00,0x1c,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0x1c,0x1f,0x31,0xf0,0x00,0xf0,0xf0,0x00,0x00,0x00,0x00,0x38,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1c,0x08,0x60,0xf0,0x3c,0x03,0x80,0x30,0x00,0x00,0x00,0x00,0x78,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x38,0x09,0x80,0xe0,0x1e,0x0e,0x00,0x20,0x1f,0x80,
0xef,0x03,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x3c,0x03,
0x01,0xe0,0x0e,0x1c,0x00,0x20,0xff,0x8f,0xde,0x1f,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x1f,0x02,0x01,0xc0,0x0e,0x38,0x00,0x03,0x87,0x11,0xf0,0x70,0xe0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xc3,0x03,0xc0,0x0e,0x78,0x00,0x06,0x0f,0x03,0xc0,0xc0,0xe0,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xe3,0xc3,0x80,0x1c,0x70,0x00,0x0c,0x0e,0x03,
0x81,0x81,0xc0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xe0,
0xc7,0x80,0x38,0x70,0x00,0x1c,0x3e,0x47,0x03,0x83,0xc8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x1c,0x00,0xe0,0x0f,0x01,0xe0,0x70,0x00,0x1f,0xff,0x87,0x03,0xff,0xf0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1c,0x01,0xc0,0x7f,0xff,0x00,0x38,0x01,0x9f,0x9e,0x0e,0x03,0xf3,0xc0,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0x0f,0x00,0x00,0x00,0x00,0x3c,0x07,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xf8,0x00,
0x00,0x00,0x00,0x0f,0xfc,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xfe,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,
0xf8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xfc,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xfe,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xf8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xf8,0x07,0x0c,0x00,0x00,0x3f,0xf0,0x00,0x3f,0xff,0xc7,0x80,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0f,0xff,0xf8,0x00,0x00,0x00,0x00,0x00,0x1e,0x00,0x00,0x01,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x30,0x38,0x0e,0x00,0x00,0x01,
0xe0,0x38,0x01,0xc3,0x80,0x87,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x70,0xf0,0x10,0x00,0x00,0x00,0x00,0x00,0x1c,0x00,0x00,0x07,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x60,0x70,0x1c,0x00,0x00,0x03,0x80,0x10,0x03,0x03,0x80,0x0f,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xc0,0xe0,0x00,0x00,0x00,0x00,0x00,0x00,0x3c,
0x00,0x00,0x0e,0x00,0x00,0x00,0x03,0x00,0x00,0x00,0x70,0xf0,0x18,0x0f,0x87,0xcf,0x00,0x10,0x06,0x07,0x04,0x0e,0x03,0xfc,0x3e,0x3f,0x3e,0x3f,0x3e,0x0e,0x01,0x81,
0xc0,0x80,0x3c,0x78,0xf0,0x78,0x38,0x38,0x03,0xfc,0x7f,0xc0,0xff,0x03,0xff,0x00,0x00,0x00,0x30,0xe0,0x38,0x1b,0x9f,0xde,0x00,0x00,0x06,0x07,0xfc,0x1e,0x0e,0x1e,
0xfe,0xff,0xbe,0xff,0xbf,0x0e,0x01,0x81,0xff,0x80,0xdf,0xfb,0xf3,0xb8,0x70,0x78,0x0e,0x3c,0x1c,0x03,0x87,0x9d,0xf8,0x00,0x00,0x00,0x01,0xff,0xf0,0x01,0xf0,0x1c,
0x00,0x00,0x07,0x0e,0x08,0x1c,0x1c,0x0e,0x8f,0x87,0x8f,0x87,0x07,0x0e,0x01,0xc3,0x81,0x01,0x3e,0x7c,0xe0,0x70,0xf0,0x70,0x38,0x38,0x3c,0x07,0x03,0x83,0xe0,0x00,
0x00,0x00,0x01,0xc0,0x70,0x00,0xc0,0x38,0x00,0x00,0x03,0x0e,0x00,0x3c,0x38,0x0e,0x1e,0x07,0x1e,0x07,0x03,0x8c,0x00,0xc3,0x80,0x00,0x38,0x70,0xe0,0x60,0xe0,0xf0,
0x70,0x70,0x38,0x0e,0x03,0x83,0x80,0x00,0x00,0x00,0x03,0xc0,0xe0,0x03,0xe0,0x38,0x00,0x00,0x00,0x1c,0x00,0x38,0x38,0x0c,0x1c,0x0e,0x1c,0x0e,0x01,0x98,0x00,0x07,
0x00,0x70,0x78,0xf1,0xc0,0xe1,0xe0,0xe0,0xe0,0xf0,0x78,0x0e,0x03,0x07,0x00,0x00,0x00,0x00,0x07,0x80,0xe0,0x06,0xe0,0x38,0x00,0x00,0x00,0x3c,0x00,0x79,0xf8,0x18,
0x3c,0x1c,0x3c,0x1c,0x01,0xf8,0x00,0x07,0x00,0x70,0x70,0xe3,0x99,0xcf,0xc5,0xe7,0xe3,0xf6,0x71,0xce,0x06,0x07,0x00,0x00,0x00,0x03,0x0f,0x01,0xc1,0x98,0x70,0x38,
0x00,0x40,0x00,0x78,0x00,0x7f,0x3c,0x70,0x3c,0x70,0x3c,0x70,0x01,0xf0,0x00,0x1e,0x00,0x70,0xf1,0xe3,0xe1,0xfd,0xf9,0xfc,0xfe,0xf8,0x7f,0x0f,0x1c,0x0f,0x00,0x00,
0x00,0x03,0xfc,0x01,0xfd,0xe0,0x70,0x1c,0x01,0xc0,0x01,0xff,0x00,0x78,0x0f,0x80,0x7f,0xc0,0x7f,0xc0,0x01,0xc0,0x00,0x7f,0xff,0xc0,0xe1,0xc3,0x81,0xc1,0xc1,0xe0,
0x70,0xe0,0x78,0x03,0xe0,0x0e,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x38,0x0f,0x07,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x70,0x00,0x70,0x00,0x03,0x80,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1e,0x31,0xf8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0xf0,0x00,0xf0,0x00,0x07,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xe0,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xe0,0x00,0xe0,0x0f,0xfc,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xfc,0x07,0xfc,0x0f,0xe0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xcd};


static bmaptype bitmap_sdhxcfelogo_bmp[]=
{{
 1,
 320,
 33,
 1320,
 1321,
 data_bmpsdhxcfelogo_bmp
}};
