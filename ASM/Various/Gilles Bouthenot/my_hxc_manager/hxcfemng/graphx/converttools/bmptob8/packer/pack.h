/*===========================================================================--
-------------------------------------------------------------------------------
-------------------------------------------------------------------------------
-----------H----H--X----X-----CCCCC----22222----0000-----0000------11----------
----------H----H----X-X-----C--------------2---0----0---0----0--1--1-----------
---------HHHHHH-----X------C----------22222---0----0---0----0-----1------------
--------H----H----X--X----C----------2-------0----0---0----0-----1-------------
-------H----H---X-----X---CCCCC-----222222----0000-----0000----1111------------
-------------------------------------------------------------------------------
----------------------------------------- http://jeanfrancoisdelnero.free.fr --
-------------------------------------------------------------------------------
-------------------------------------------------------------------------------
------------------- official Infoticaires 2006 invitation ---------------------
------------------ French Retro-Gaming party in Courcelles --------------------
--------------------------- www.obsolete-tears.com ----------------------------
----------------------------  Jeff -  14/06/2006  -----------------------------
--===========================================================================*/

unsigned char pack(unsigned char * bufferin, unsigned long sizein,unsigned char * bufferout, int * sizeout);
unsigned char * unpack(unsigned char * bufferin, unsigned long sizein,unsigned char * bufferout, unsigned long sizeout);

