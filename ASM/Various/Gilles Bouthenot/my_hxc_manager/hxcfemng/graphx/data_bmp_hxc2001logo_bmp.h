/*
//////////////////////////////
//
//
// Created by Binary2Header V0.5
// (c) HxC2001
// (c) PowerOfAsm
//
// File: hxc2001logo.bmp  Size: 468  (469) x:144 y:26
//
//
*/


#include "bmaptype.h"


unsigned char __attribute__ ((aligned (2))) data_bmphxc2001logo_bmp[]={
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xf0,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xfc,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7f,
0xf0,0x1f,0x3c,0x00,0x00,0x0f,0xfe,0x03,0xf8,0x00,0xfe,0x00,0x3f,0x80,0x00,0x70,0x01,0xc3,0xe0,0x3e,0x00,0x00,0x00,0x3c,0x0f,0x07,0x3c,0x03,0xc3,0x80,0xf0,0xe0,
0x03,0xf0,0x07,0x03,0xe0,0x7c,0x00,0x00,0x00,0xe0,0x07,0x0e,0x0e,0x07,0x01,0x81,0xc0,0x60,0x1f,0xe0,0x03,0x03,0xc0,0xf8,0x00,0x00,0x01,0xc0,0x06,0x0c,0x0e,0x0e,
0x01,0xc3,0x80,0x70,0x11,0xe0,0x03,0x87,0x80,0xf8,0x07,0xc3,0xc7,0x00,0x02,0x00,0x1e,0x1e,0x01,0xc7,0x80,0x70,0x03,0xc0,0x00,0x87,0xff,0xe0,0x1f,0xff,0xcf,0x00,
0x00,0x00,0x7c,0x3c,0x03,0xcf,0x00,0xf0,0x03,0xc0,0x00,0x0f,0x81,0xe0,0x01,0xf0,0x1e,0x00,0x00,0x00,0xe0,0x3c,0x03,0xcf,0x00,0xf0,0x07,0x80,0x00,0x1f,0x01,0xc0,
0x01,0xe0,0x1e,0x00,0x00,0x03,0x80,0x3c,0x03,0xcf,0x00,0xf0,0x07,0x80,0x00,0x1e,0x03,0x80,0x03,0xe0,0x3e,0x00,0x00,0x0e,0x00,0x3c,0x07,0x8f,0x01,0xe0,0x0f,0x00,
0x00,0x3c,0x03,0x80,0x0f,0xe0,0x3e,0x00,0x00,0x1c,0x04,0x3c,0x0f,0x0f,0x03,0xc0,0x1f,0x00,0x00,0x78,0x07,0x01,0xbc,0x70,0x3f,0x00,0x00,0x78,0x18,0x1e,0x1e,0x07,
0x87,0x80,0x3e,0x00,0x1d,0xf0,0x07,0xf9,0xf0,0x38,0x1f,0x80,0x10,0xff,0xf0,0x0f,0x7c,0x03,0xdf,0x00,0x3e,0x00,0x0f,0x80,0x00,0x00,0x00,0x38,0x0f,0xc0,0xe1,0xff,
0xf0,0x01,0xe0,0x00,0x78,0x03,0xff,0xc0,0x00,0x00,0x00,0x00,0x00,0x0c,0x3b,0xff,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,
0xf8,0x7e,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xcd};


static bmaptype bitmap_hxc2001logo_bmp[]=
{{
 1,
 144,
 26,
 468,
 469,
 data_bmphxc2001logo_bmp
}};
