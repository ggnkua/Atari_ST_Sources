	INCLUDE a2b_drop.S