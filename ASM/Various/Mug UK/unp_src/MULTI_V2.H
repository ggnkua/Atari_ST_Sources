/* Resource file indices for MULTI_V2 */

#define COPYRIGH 0   /* Form/Dialog box */
#define ALTERME  3   /* STRING in Tree COPYRIGH */
#define BYECRED  9   /* BUTTON in Tree COPYRIGH */

#define MENU     1   /* Form/Dialog box */
#define CLICKME  1   /* BOXTEXT in Tree MENU */
#define INFO     3   /* BUTTON in Tree MENU */
#define DPAKFILE 4   /* BUTTON in Tree MENU */
#define FREEMEM  5   /* BUTTON in Tree MENU */
#define GREETZ   6   /* BUTTON in Tree MENU */
#define DESKTOP  7   /* BUTTON in Tree MENU */

#define DEPACKER 2   /* Form/Dialog box */
#define PACKTYPE 5   /* TEXT in Tree DEPACKER */
#define FILETYPE 7   /* TEXT in Tree DEPACKER */
#define FILELEN  9   /* TEXT in Tree DEPACKER */
#define PACKED   11  /* TEXT in Tree DEPACKER */
#define UNPACKED 13  /* TEXT in Tree DEPACKER */
#define GODEPACK 14  /* BUTTON in Tree DEPACKER */
#define SAV_FILE 15  /* BUTTON in Tree DEPACKER */
#define EXITDPAK 16  /* BUTTON in Tree DEPACKER */
#define DISPLAY  17  /* BUTTON in Tree DEPACKER */

#define FREE     3   /* Form/Dialog box */
#define MEMLEFT  3   /* TEXT in Tree FREE */
#define TOSVERS  5   /* TEXT in Tree FREE */
#define EXITMEM  6   /* BUTTON in Tree FREE */
#define GEMDOS   9   /* TEXT in Tree FREE */
#define GDOSHERE 11  /* TEXT in Tree FREE */
#define BLITHERE 13  /* TEXT in Tree FREE */

#define DPAKINFO 4   /* Form/Dialog box */
#define GOBACK   17  /* BUTTON in Tree DPAKINFO */

#define GREETING 5   /* Form/Dialog box */
#define HIDDEN   1   /* BOXTEXT in Tree GREETING */
#define READALL  13  /* BOXTEXT in Tree GREETING */

#define COCKUP   6   /* Form/Dialog box */
#define TITLEBOX 1   /* BOXTEXT in Tree COCKUP */
#define LINE1    2   /* TEXT in Tree COCKUP */
#define LINE2    3   /* TEXT in Tree COCKUP */
#define LINE3    4   /* TEXT in Tree COCKUP */
#define LINE4    5   /* TEXT in Tree COCKUP */
#define OPTION1  6   /* BOXTEXT in Tree COCKUP */
#define OPTION2  7   /* BOXTEXT in Tree COCKUP */
#define OPTION3  8   /* BOXTEXT in Tree COCKUP */

#define TEXTWIND 7   /* Form/Dialog box */
#define TEXTTIT  0   /* TEXT in Tree TEXTWIND */

#define CONTACT  8   /* Form/Dialog box */
#define EXITCONT 7   /* BUTTON in Tree CONTACT */
