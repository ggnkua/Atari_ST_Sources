;
; Soundchip database, 75 chip effects
;
; ~C:chipfx%(sound)
;
; ------- Copyright Terry King Ninth Wave Software 1993-95 -------

	bra	chipfx
	bra	playing_chip
	
chipfx	movem.l	d1-3/a0-3,-(a7)
	bsr	super
	move	32(a7),d0
	cmp	#75,d0
	bgt.s	.skip
	move	d0,d1
	add	d0,d0			; make word offset
	lea	s1(pc),a0		; first sound effect
	add	soundlist(pc,d0.w),a0	; add offset
	move.l	a0,-(a7)
	lea	counter(pc),a1
	move.b	(a0)+,(a1)+		; sound fx length
	move.b	(a0)+,(a1)+		;
	move	d1,(a1)+		; sound number 
	move.l	a0,-(a7)
	move	#32,-(a7)
	trap	#14			; XBIOS dosound command
	addq.l	#6,a7
	lea	vbl(pc),a0
	move.l	a0,$4e6.w
	bsr	user
	move.l	(a7)+,d0		; returns address of sound effect
.skip	movem.l	(a7)+,d1-3/a0-3
	rts

soundlist
	dc.w	s0-s1
	dc.w	s1-s1,s2-s1,s3-s1,s4-s1,s5-s1,s6-s1,s7-s1,s8-s1,s9-s1
	dc.w	s10-s1,s11-s1,s12-s1,s13-s1,s14-s1,s15-s1,s16-s1,s17-s1
	dc.w	s18-s1,s19-s1,s20-s1,s21-s1,s22-s1,s23-s1,s24-s1,s25-s1
	dc.w	s26-s1,s27-s1,s28-s1,s29-s1,s30-s1,s31-s1,s32-s1,s33-s1
	dc.w	s34-s1,s35-s1,s36-s1,s37-s1,s38-s1,s39-s1,s40-s1
	dc.w	s41-s1,s42-s1,s43-s1,s44-s1,s45-s1,s46-s1,s47-s1,s48-s1
	dc.w	s49-s1,s50-s1,s51-s1,s52-s1,s53-s1,s54-s1,s55-s1,s56-s1
	dc.w	s57-s1,s58-s1,s59-s1,s60-s1,s61-s1,s62-s1,s63-s1,s64-s1
	dc.w	s65-s1,s66-s1,s67-s1,s68-s1,s69-s1,s70-s1,s71-s1
	dc.w	s72-s1,s73-s1,s74-s1,s75-s1

super	clr.l	-(a7)
	move	#$20,-(a7)
	trap	#1			; put in supervisor mode
	addq.l	#6,a7
	lea	save_sp(pc),a0
	move.l	d0,(a0)
	rts
user	lea	save_sp(pc),a0
	move.l	(a0),-(a7)
	move	#$20,-(a7)
	trap	#1			; back to user mode
	addq.l	#6,a7
	rts
	
playing_chip
	move.l	a0,-(a7)
	lea	counter(pc),a0
	tst	(a0)
	bmi.s	.fin
	move	snd_num(pc),d0
	ext.l	d0
	bra.s	.eoc
.fin	moveq	#0,d0
.eoc	move.l	(a7)+,a0
	rts
	
vbl	move.l	a0,-(a7)
	lea	counter(pc),a0
	subq	#1,(a0)
	bmi.s	.fin
	move.l	(a7)+,a0
	rts
.fin	clr.l	$4e6.w
	move.l	(a7)+,a0
	rts
counter	ds.w	1
snd_num	ds.w	1
save_sp	ds.l	1

		
;
; s0=sounds off, s1-s75 sound effects
;

s0	dc.w	1
	dc.b	8,0,9,0,10,0,7,0,255,0
s1	dc.w	10
	dc.b	0,0,1,0,6,0,7,%11110111,8,16,9,0,10,0,11,0,12,20
	dc.b	13,0,128,0,129,0,1,255,8,0,255,0
s2	dc.w	10
	dc.b	0,0,1,0,6,10,7,%11110111,8,16,9,0,10,0,11,0,12,20
	dc.b	13,0,128,0,129,0,1,255,8,0,255,0
s3	dc.w	20
	dc.b	0,0,1,0,6,20,7,%11110111,8,16,9,0,10,0,11,0,12,20
	dc.b	13,0,128,0,129,0,1,255,8,0,255,0
s4	dc.w	20
	dc.b	0,0,1,0,6,30,7,%11110111,8,16,9,0,10,0,11,0,12,20
	dc.b	13,0,128,0,129,0,1,255,8,0,255,0
s5	dc.w	30
	dc.b	0,0,1,0,6,31,7,%11110111,8,16,9,0,10,0,11,0,12,40
	dc.b	13,0,128,0,129,0,1,255,8,0,255,0
s6	dc.w	130
	dc.b	0,0,1,0,6,5,7,%11110110,8,16,9,0,10,0,11,0,12,130
	dc.b	13,0,128,1,129,1,3,1,8,0,255,0
s7	dc.w	130
	dc.b	0,200,1,0,6,20,7,%11110110,8,16,9,0,10,0,11,0,12,130
	dc.b	13,0,128,1,129,1,6,0,8,0,255,0
s8	dc.w	10
	dc.b	0,0,1,0,6,0,7,%11110111,8,16,9,0,10,0,11,0,12,15
	dc.b	13,0,128,0,129,6,1,31,8,0,255,0
s9	dc.w	10
	dc.b	0,0,1,0,6,31,7,%11110111,8,16,9,0,10,0,11,0,12,15
	dc.b	13,0,128,31,129,6,-1,0,8,0,255,0
s10	dc.w	10
	dc.b	0,0,1,0,6,31,7,%11110111,8,16,9,0,10,0,11,0,12,20
	dc.b	13,0,128,31,129,6,-5,0,8,0,255,0
s11	dc.w	20
	dc.b	0,0,1,0,6,31,7,%11110111,8,16,9,0,10,0,11,0,12,20
	dc.b	13,0,128,31,129,6,-15,0,8,0,255,0
s12	dc.w	20
	dc.b	0,0,1,0,6,31,7,%11110111,8,16,9,0,10,0,11,0,12,15
	dc.b	13,0,128,1,129,6,240,2,8,0,255,0
s13	dc.w	140
	dc.b	0,0,1,0,6,255,7,%11110111,8,16,9,0,10,0,11,0,12,140
	dc.b	13,0,128,255,129,6,-1,0,8,0,255,0
s14	dc.w	190
	dc.b	0,200,1,0,2,100,3,0,4,50,5,0,6,31,7,%11011100
	dc.b	8,16,9,16,10,16,11,0,12,140,13,0,128,0,129,0,137,200
	dc.b	255,0
s15	dc.w	70
	dc.b	0,128,1,0,2,0,3,0,6,31,7,%11101110,8,16,9,16,10,0
	dc.b	11,0,12,64,13,0,128,174,129,0,81,1,255,0
s16	dc.w	10
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,20,0,8,0,255,0
s17	dc.w	10
	dc.b	0,0,1,2,7,%11111110,8,16,9,0,10,0,11,0,12,6,13,0
	dc.b	128,0,129,0,20,0,8,0,255,0
s18	dc.w	10
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,46,0,8,0,255,0
s19	dc.w	10
	dc.b	0,0,1,2,7,%11111110,8,16,9,0,10,0,11,0,12,6,13,0
	dc.b	128,0,129,0,46,0,8,0,255,0
s20	dc.w	10
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,-45,0,8,0,255,0
s21	dc.w	10
	dc.b	0,0,1,1,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,-46,0,8,0,255,0
s22	dc.w	20
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,111,0,8,0,255,0
s23	dc.w	20
	dc.b	0,0,1,1,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,112,0,8,0,255,0
s24	dc.w	10
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,170,0,8,0,255,0
s25	dc.w	10
	dc.b	0,0,1,1,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,171,0,8,0,255,0
s26	dc.w	10
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,1,129,0,192,0,8,0,255,0
s27	dc.w	10
	dc.b	0,0,1,1,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,1,129,0,191,0,8,0,255,0
s28	dc.w	10
	dc.b	0,0,1,2,7,%11111110,8,16,9,0,10,0,11,0,12,12,13,0
	dc.b	128,0,129,0,20,0,8,0,255,0
s29	dc.w	20
	dc.b	0,55,1,1,2,50,3,1,7,%11111100,8,16,9,16,10,0
	dc.b	11,0,12,20,13,0,255,0
s30	dc.w	10
	dc.b	0,55,1,2,2,50,3,4,7,%11111100,8,16,9,16,10,0,11,0,12,20
	dc.b	13,0,128,200,129,0,1,0,255,0
s31	dc.w	10
	dc.b	0,0,1,1,7,%11111110,8,16,9,0,10,0,11,0,12,15
	dc.b	13,0,128,1,129,0,-30,0,255,0
s32	dc.w	90
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,100
	dc.b	13,0,128,0,129,1,1,0,8,0,255,0
s33	dc.w	90
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,100
	dc.b	13,0,128,0,129,1,2,0,8,0,255,0
s34	dc.w	90
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,100
	dc.b	13,0,128,0,129,1,3,0,8,0,255,0
s35	dc.w	60
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,100
	dc.b	13,0,128,0,129,1,4,0,8,0,255,0
s36	dc.w	90
	dc.b	0,100,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,100
	dc.b	13,0,128,0,129,1,-2,0,8,0,255,0
s37	dc.w	70
	dc.b	0,100,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,100
	dc.b	13,0,128,1,129,1,7,0,8,0,255,0
s38	dc.w	200
	dc.b	0,100,1,3,2,101,3,3,4,102,5,3,7,%11111000,8,16
	dc.b	9,16,10,16,11,0,12,160,13,0,255,0
s39	dc.w	200
	dc.b	0,200,1,3,2,201,3,3,4,102,5,3,7,%11111000,8,16
	dc.b	9,16,10,16,11,0,12,160,13,0,255,0
s40	dc.w	20
	dc.b	0,0,1,0,7,%1111110,8,15,9,0,10,0,128,60,129,0,254,40
	dc.b	255,4,8,16,12,10,13,0,255,0
s41	dc.w	40
	dc.b	0,80,1,4,2,82,3,4,7,%11111100,8,15,9,15,10,0,255,5
	dc.b	1,2,3,2,255,5,1,1,3,1,255,5,1,0,3,0,255,5
	dc.b	11,0,12,30,13,0,8,16,9,16,255,0
s42	dc.w	30
	dc.b	0,80,1,2,2,82,3,2,7,%11111100,8,15,9,16,10,0
	dc.b	11,100,12,0,13,10,128,15,129,8,-1,0,255,10,9,0,255,0
s43	dc.w	40
	dc.b	0,80,1,12,2,82,3,13,4,84,5,14,7,%11111000
	dc.b	8,16,9,16,10,16,11,0,12,44,13,0,255,0
s44	dc.w	200
	dc.b	0,116,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,200
	dc.b	13,0,128,0,129,1,-1,0,8,0,255,0
s45	dc.w	200
	dc.b	7,%11110111,8,16,9,0,10,0,11,0,12,200,13,0
	dc.b	128,0,129,6,8,1,8,0,255,0
s46	dc.w	400
	dc.b	0,200,1,6,2,202,3,6,7,%11111100,13,13,8,16,9,16,10,0
	dc.b	11,0,12,30,255,250,11,0,12,255,13,0,255,0
s47	dc.w	400
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,0,13,14
	dc.b	128,0,129,0,1,255,129,0,-1,0,8,0,255,0
s48	dc.w	150
	dc.b	0,210,1,3,2,230,3,3,4,250,5,7,7,%11111000
	dc.b	8,16,9,16,10,16,11,0,12,160,13,0,255,0
s49	dc.w	10
	dc.b	0,52,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,16
	dc.b	13,9,255,100,8,0,255,0
s50	dc.w	10
	dc.b	0,0,1,1,7,%11111110,8,16,9,0,10,0,11,0,12,15,13,0
	dc.b	255,5,0,50,1,1,255,5,0,100,1,1,255,5,8,0,255,0
s51	dc.w	10
	dc.b	0,0,1,15,2,10,3,15,4,20,5,15,7,%11111000
	dc.b	8,16,9,16,10,16,11,0,12,19,13,0,255,0
s52	dc.w	10
	dc.b	0,0,1,0,2,10,3,0,4,20,5,0,6,0,7,%11100100
	dc.b	8,16,9,16,10,16,11,0,12,3,13,0,255,0
s53	dc.w	10
	dc.b	0,50,1,0,6,31,7,%11110111,8,16,9,0,10,0
	dc.b	11,0,12,3,13,0,255,0
s54	dc.w	20
	dc.b	0,50,1,0,6,31,7,%11100100,8,16,9,0,10,0
	dc.b	11,0,12,50,13,0,255,0
s55	dc.w	20
	dc.b	0,61,1,0,7,%11111110,8,16,9,0,10,0
	dc.b	11,0,12,50,13,0,255,0
s56	dc.w	20
	dc.b	0,37,1,2,2,35,3,2,7,%11111100,8,16,9,16,10,0
	dc.b	11,0,12,15,13,0,255,0
s57	dc.w	10
	dc.b	0,0,1,15,6,0,7,%11110111,8,16,9,0,10,0
	dc.b	11,0,12,1,13,4,255,0
s58	dc.w	10
	dc.b	0,0,1,15,6,0,7,%11110111,8,16,9,0,10,0
	dc.b	11,0,12,1,13,0,255,0
s59	dc.w	10
	dc.b	0,200,1,0,7,%11111110,8,16,9,0,10,0
	dc.b	11,118,12,0,13,0,128,89,129,0,1,7,255,0
s60	dc.w	30
	dc.b	0,200,1,0,6,30,7,%11110111,8,0,9,0,10,0,13,0
	dc.b	128,1,129,8,2,15,255,5,128,15,129,8,-1,0,255,0
s61	dc.w	30
	dc.b	6,0,7,%11110111,8,0,9,0,10,0,13,0,128,0
	dc.b	129,8,1,14,255,5,128,14,128,14,129,8,-1,0,255,0
s62	dc.w	40
	dc.b	6,0,7,%11110111,8,0,9,0,10,0,128,0,129,8,1,14
	dc.b	255,5,128,0,129,6,2,30,128,14,129,8,-2,0,255,0
s63	dc.w	20
	dc.b	6,0,7,%11000111,8,16,9,16,10,16,11,10,12,0
	dc.b	13,14,128,50,129,11,-2,10,8,0,9,0,10,0,255,0
s64	dc.w	20
	dc.b	6,0,7,%11000111,8,16,9,16,10,16,11,10,12,0
	dc.b	13,14,128,10,129,11,2,50,8,0,9,0,10,0,255,0
s65	dc.w	100
	dc.b	7,%11111110,8,15,9,0,10,0,0,28,1,1,255,15,0,222
	dc.b	255,15,0,28,255,15,0,222,255,15,0,28,255,15,0,222
	dc.b	255,15,8,0,255,0
s66	dc.w	80
	dc.b	0,55,1,8,2,50,1,8,7,%11111100,8,16,9,16,10,0
	dc.b	11,0,12,5,13,13,255,10,11,0,12,40,13,0,255,0
s67	dc.w	160
	dc.b	0,100,1,3,2,101,3,3,4,102,5,3,7,%11111000
	dc.b	8,16,9,16,10,16,11,0,12,160,13,0,128,0,192,2,1,200,255,0
s68	dc.w	30
	dc.b	0,0,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,28
	dc.b	13,0,128,128,129,0,73,128,255,0
s69	dc.w	100
	dc.b	0,0,1,15,7,%11111110,8,15,9,0,10,0,255,40
	dc.b	8,16,11,0,12,100,13,0,255,0
s70	dc.w	50
	dc.b	0,20,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,63
	dc.b	13,0,128,169,129,1,128,0,255,0
s71	dc.w	10
	dc.b	0,162,1,0,6,9,7,%11110110,8,16,9,0,10,0
	dc.b	11,0,12,7,13,0,128,0,129,1,1,1,255,0
s72	dc.w	100
	dc.b	0,100,1,5,2,80,3,1,8,15,9,0,10,0,11,0,12,70
	dc.b	7,%11110110,128,0,129,6,1,31,255,3,13,40
	dc.b	13,0,8,16,255,0
s73	dc.w	80
	dc.b	0,100,1,5,2,80,3,1,8,15,9,0,10,0,11,0,12,70
	dc.b	7,%11110110,128,31,129,6,-1,0,255,3,13,40
	dc.b	13,0,8,16,255,0
s74	dc.w	10
	dc.b	0,122,1,0,7,%11111100,8,16,9,0,10,0,11,0,12,12
	dc.b	13,0,128,3,129,0,12,0,255,0
s75	dc.w	200
	dc.b	0,128,1,0,7,%11111110,8,16,9,0,10,0,11,0,12,253
	dc.b	13,0,128,0,129,0,64,1,255,0

