;Es muss Bit 5 im Soundregister gesetzt werden

MOVE.W #$20,-(a7)     ; also 32 auf den Stack
MOVE.W #$001e,-(a7)   ; 30 (f�r die Funktionsnummer) auf den Stack
TRAP #14              ; XBIOS aufrufen
ADDQ.L #4,a7          ; Stack aufr„umen
CLR.W -(a7)           ; Stackpointer l”schen
TRAP #1               ; und PRG beenden