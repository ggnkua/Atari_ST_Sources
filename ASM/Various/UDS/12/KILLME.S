section	text
	
	jmp	main
	
****************
* First init   *
****************
first_init
	clr.l	-(sp)
	move.w	#$20,-(sp)
	trap	#1
	addq.l	#6,sp
	move.l	d0,ustk

	move.w	#2,-(sp)
	trap	#14
	addq.l	#2,sp
	move.l	d0,oldphys
	
	move.w	#3,-(sp)
	trap	#14
	addq.l	#2,sp
	move.l	d0,oldlog
	
	move.w	#4,-(sp)
	trap	#14
	addq.l	#2,sp
	move.w	d0,oldrez
	
	movem.l	$ffff8240.w,d0-d7
	movem.l	d0-d7,savepal
	
	move.w	#0,-(sp)
	pea	-1
	pea	-1
	move.w	#5,-(sp)
	trap	#14
	lea	12(sp),sp
	
	rts

**************
* init y rot *
**************
init_y_rot
	lea	y_add,a0
	moveq	#0,d0
	move.w	#200-1,d1
.precy	move.w	d0,(a0)+
	add.w	#160,d0
	dbf	d1,.precy
	
	lea	x_add,a0
	moveq	#0,d0
	moveq	#0,d1
	move.w	#20-1,d6
.precx1	move.w	#16-1,d7
	moveq	#0,d1
.precx2	move.w	d0,(a0)+
	move.w	d1,(a0)+
	add.w	#2560,d1
	dbf	d7,.precx2
	add.w	#8,d0
	dbf	d6,.precx1

	lea	bredd_add1,a0
	lea	slutmasker3,a2
	moveq	#0,d4			; list add
	moveq	#0,d5
	move.w	#-1,d5			; first slutm

	move.w	#16-1,d7
.precb1	move.w	#320-1,d6
	moveq	#1,d0			; xc
	move.w	#160-(8*1)+8,d1		; yadd
	lea	slutmasker,a1
	add.l	d4,a1
	move.w	(a2)+,d5		; h„mta ettan
.precb2
	cmp.w	#1,d0
	bne	.hopp
	move.w	d5,d3
	and.w	(a1)+,d3
	move.w	d3,(a0)+
	move.w	#0,(a0)+	; helt on”dig nu n„r den inte ritas
	bra	.hopp2
.hopp:
	move.w	d5,(a0)+		; slutmask 1
	move.w	(a1)+,(a0)+	; slutmask 2
.hopp2:
	move.w	d0,(a0)+		; xcount
	move.w	d1,(a0)+		; yadd

	tst.w	(a1)
	bne.s	.go_on
	add.w	#1,d0		; ett mera p† xc
	sub.w	#8,d1		; ett mindre p† ya
	lea	slutmasker,a1
.go_on	dbf	d6,.precb2
	add.l	#2,d4
	dbf	d7,.precb1

	lea	bredd_add2,a0
	lea	slutmasker,a2
	moveq	#0,d4			; list add
	moveq	#0,d5
	move.w	#-1,d5			; first slutm

	move.w	#16-1,d7
.precb3	move.w	#320-1,d6
	moveq	#1,d0			; xc
	move.w	#160-(8*1)+8,d1		; yadd
	lea	slutmasker4+30,a1
	add.l	d4,a1
	move.w	(a2)+,d5		; h„mta ettan
.precb4
	cmp.w	#1,d0
	bne	.hopp3
	move.w	d5,d3
	and.w	(a1)+,d3
	move.w	d3,(a0)+
	move.w	#0,(a0)+	; slutmask 3 „r helt on”dig nu n„r den inte ritas
	bra	.hopp4
.hopp3:
	move.w	d5,(a0)+		; slutmask 1
	move.w	(a1)+,(a0)+	; slutmask 2
.hopp4:
	move.w	d0,(a0)+		; xcount
	move.w	d1,(a0)+		; yadd

	tst.w	(a1)
	bne.s	.go_on2
	add.w	#1,d0		; ett mera p† xc
	add.w	#8,d1		; ett mera p† ya
	lea	slutmasker4,a1
.go_on2	dbf	d6,.precb4
	sub.l	#2,d4
	dbf	d7,.precb3
	
	rts

**************
* init y bli *
**************
init_y_bli1
	move.w	#0,$ffff8a20.w
	move.w	#0,$ffff8a22.w
	move.l	#fyllt_word,$ffff8a24.w
	move.w	#-1,$ffff8a2a.w
	move.w	#8,$ffff8a2e.w
	
	move.w	#$0003,$ffff8a3a.w
	move.b	#0,$ffff8a3d.w

	rts

init_y_bli2
	move.w	#0,$ffff8a20.w
	move.w	#0,$ffff8a22.w
	move.l	#fyllt_word,$ffff8a24.w
	move.w	#-1,$ffff8a2a.w
	move.w	#-8,$ffff8a2e.w
	
	move.w	#$0003,$ffff8a3a.w
	move.b	#0,$ffff8a3d.w

	rts
	
*********************
* Main och mainloop *
*********************
main	jsr	first_init
	jsr	init_y_rot

	move.w	#$3,$ff8242
	move.w	#$7,$ff8244
	move.w	#$30,$ff8246
	move.w	#$70,$ff8248
	move.w	#$300,$ff824a
	move.w	#$700,$ff824c
	move.w	#$770,$ff824e
	
	move.l	$70.w,svbi
	move.l	#vbi,$70.w
	
main_loop
	jsr	change_screen

	move.w	#1500,d0
.wait:	nop
	dbf.w	d0,.wait

	move.w	#$353,$ffff8240.w
	lea	koords,a0		; x1,y1,x2,y2,col
	move.w	#130,(a0)
	move.w	#-2,2(a0)
	move.w	#14,4(a0)
	move.w	#23,6(a0)
	move.w	#1,8(a0)
	jsr	do_yrot_poly
	move.w	#$0,$ffff8240.w
	jsr	vsync

	cmp.b	#59,$fffffc02.w
	bne.s	h
	add.w	#1,koords
	move.l	screen,a0
	move.w	#7999,d0
suddgg	move.l	#0,(a0)+
	dbf	d0,suddgg
h
	cmp.b	#57,$fffffc02.w
	bne	main_loop
	bra	end

****************
* Do yrot poly *
****************
do_yrot_poly

	move.w	6(a0),d0
	cmp.w	2(a0),d0
	bge	.hopp
	move.w	2(a0),6(a0)
	move.w	d0,2(a0)
	move.w	4(a0),d0
	move.w	(a0),4(a0)
	move.w	d0,(a0)
.hopp:

	tst.w	2(a0)
	bgt	.no_pure_box
	tst.w	6(a0)
	ble	pure_box
.no_pure_box:

	cmp.w	#0,(a0)
	blt	clipp
	cmp.w	#255,(a0)
	bgt	clipp
	cmp.w	#0,4(a0)
	blt	clipp
	cmp.w	#255,4(a0)
	bgt	clipp

back_to_poly:

	tst.w	2(a0)
	bgt	.no_pure_box
	tst.w	6(a0)
	ble	pure_box
.no_pure_box:

	moveq	#0,d2
	move.w	(a0),d0		; x1
	move.w	2(a0),d1		; y1
	move.w	4(a0),d2		; x2
	move.w	6(a0),d3		; y2

	cmp.w	d0,d2
	blt	rita_bak	; H„r hoppar vi till en mycket lik rutin fast den har inverterade x1,x2

	jsr	init_y_bli1
	lea	x_add,a1
	lea	y_add,a2
	lea	$ffff8a00,a3
	lea	bredd_add1,a4

	tst.w	2(a0)
	blt	draw_y_clip_poly

	add.w	d0,d0
	add.w	d0,d0
	add.w	d1,d1
	move.l	#tillf_scr,d4		; screen adr
	move.l	screen,a6		; screen adr
	add.w	(a1,d0.w),d4	; dest in
	add.w	(a2,d1.w),d4	; dest ner
	move.l	d4,save_source
	add.w	(a1,d0.w),a6	; dest in
	add.w	(a2,d1.w),a6	; dest ner
	move.l	d4,$32(a3)	; s„tt dest
	moveq	#0,d4
	move.w	2(a1,d0.w),d4	; r„tt skew och allt
	add.l	d4,a4

	sub.w	(a0),d2
	moveq	#0,d0		; x1
	move.w	2(a0),d1		; y1
	move.w	d3,d4		; save y2
	sub.w	d1,d4		; y2-y1=ant scan
	subq.w	#1,d4		; -1 for the dbf

	moveq	#0,d6	
	sub.w	d1,d3		; y2-y1
	bne	.do_a_little_jump
	move.w	#1,d4
	asl.w	#6,d2
	move.w	d2,d6
	move.w	#0,d2
	move.l	a4,a5		; save
	move.w	d4,d5
	bra	.tri_lp1
.do_a_little_jump:
	asl.w	#6,d2
	divs	d3,d2		; d3=k*64
	move.l	a4,a5		; save
	move.w	d4,d5
.tri_lp1
	add.w	d2,d6		; x1+k
	move.w	d6,d0
	asr.w	#3,d0		; /64*8

	and.w	#%1111111111111000,d0
	move.l	a5,a4
	add.w	d0,a4
	move.w	(a4)+,$28(a3)	; slutmask1
	move.w	(a4)+,$2c(a3)	; slutmask3
	move.w	(a4)+,$36(a3)	; xcount
	move.w	#1,$38(a3)	; ycount
	move.w	(a4)+,$30(a3)	; yadd
	move.b	#$c0,$3c(a3)	; blitta
	dbf	d4,.tri_lp1	

*	Nu har vi ritat triangeln p† en egen sk„rm och den skall nu ritas
*	p† den riktiga sk„rmen.

	move.w	8(a0),d0	; col
	move.b	#3,$3b(a3)	; det normala
	btst.l	#0,d0
	bne	.no_bitplane1
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane1:

	move.w	#$7,$ff8240

	move.l	save_source,$24(a3)
	move.w	#8,$20(a3)
	move.w	-2(a4),$22(a3)
	move.l	a6,$32(a3)
	move.w	#$ffff,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#1,d0
	bne	.no_bitplane2
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane2:

	move.w	#$5,$ff8240

	move.l	save_source,$24(a3)
	move.w	#8,$20(a3)
	move.w	-2(a4),$22(a3)
	move.l	a6,$32(a3)
	move.w	#$ffff,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#2,d0
	bne	.no_bitplane3
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane3:

	move.w	#$3,$ff8240

	move.l	save_source,$24(a3)
	move.w	#8,$20(a3)
	move.w	-2(a4),$22(a3)
	move.l	a6,$32(a3)
	move.w	#$ffff,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta


*	Rita den raka delen av v„ggen


	move.w	6(a0),d4
	neg.w	d4
	add.w	#99,d4

	tst.w	d4
	ble	.no_rak_draw	

	sub.w	#4,a6		; Fixxa till sk„rmadressen
	mulu.w	#160,d5
	add.w	d5,a6

	
	move.l	#-1,d3		;det normala
	btst.l	#0,d0
	bne	.no_bitplane1_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane1_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$700,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#1,d0
	bne	.no_bitplane2_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane2_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$500,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#2,d0
	bne	.no_bitplane3_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane3_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$300,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

.no_rak_draw:

	rts

*	Y clip polyn

draw_y_clip_poly:

	add.w	d0,d0
	add.w	d0,d0
	move.l	#tillf_scr,d4		; screen adr
	move.l	screen,a6		; screen adr
	add.w	(a1,d0.w),d4	; dest in
	move.l	d4,save_source
	add.w	(a1,d0.w),a6	; dest in
	move.l	d4,$32(a3)	; s„tt dest
	moveq	#0,d4
	move.w	2(a1,d0.w),d4	; r„tt skew och allt
	add.l	d4,a4

	sub.w	(a0),d2
	moveq	#0,d0		; x1
	move.w	2(a0),d1		; y1
	move.w	d3,d4		; save y2
	subq.w	#1,d4		; -1 for the dbf


	moveq	#0,d6	
	sub.w	d1,d3		; y2-y1
	bne	.do_a_little_jump
	move.w	#1,d4
	asl.w	#6,d2
	move.w	d2,d6
	move.w	#0,d2
	move.l	a4,a5		; save
	move.w	d4,d5
	move.w	4(a0),d6
	muls.w	d2,d6
	bra	.tri_lp1

.do_a_little_jump:
	asl.w	#6,d2
	ext.l	d2
	divs	d3,d2		; d3=k*64
	move.l	a4,a5		; save
	move.w	2(a0),d6
	neg.w	d6
	muls.w	d2,d6
	move.w	d4,d5
.tri_lp1
	add.w	d2,d6		; x1+k
	move.w	d6,d0
	asr.w	#3,d0		; /64*8

	and.w	#%1111111111111000,d0
	move.l	a5,a4
	add.w	d0,a4
	move.w	(a4)+,$28(a3)	; slutmask1
	move.w	(a4)+,$2c(a3)	; slutmask3
	move.w	(a4)+,$36(a3)	; xcount
	move.w	#1,$38(a3)	; ycount
	move.w	(a4)+,$30(a3)	; yadd
	move.b	#$c0,$3c(a3)	; blitta
	dbf	d4,.tri_lp1	

*	Nu har vi ritat triangeln p† en egen sk„rm och den skall nu ritas
*	p† den riktiga sk„rmen.

	move.w	8(a0),d0	; col
	move.b	#3,$3b(a3)	; det normala
	btst.l	#0,d0
	bne	.no_bitplane1
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane1:

	move.w	#$7,$ff8240

	move.l	save_source,$24(a3)
	move.w	#8,$20(a3)
	move.w	-2(a4),$22(a3)
	move.l	a6,$32(a3)
	move.w	#$ffff,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#1,d0
	bne	.no_bitplane2
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane2:

	move.w	#$5,$ff8240

	move.l	save_source,$24(a3)
	move.w	#8,$20(a3)
	move.w	-2(a4),$22(a3)
	move.l	a6,$32(a3)
	move.w	#$ffff,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#2,d0
	bne	.no_bitplane3
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane3:

	move.w	#$3,$ff8240

	move.l	save_source,$24(a3)
	move.w	#8,$20(a3)
	move.w	-2(a4),$22(a3)
	move.l	a6,$32(a3)
	move.w	#$ffff,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

*	Rita den raka delen av v„ggen

	move.w	6(a0),d4
	neg.w	d4
	add.w	#99,d4

	tst.w	d4
	ble	.no_rak_draw	

	sub.w	#4,a6		; Fixxa till sk„rmadressen
	mulu.w	#160,d5
	add.w	d5,a6

	
	move.l	#-1,d3		;det normala
	btst.l	#0,d0
	bne	.no_bitplane1_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane1_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$700,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#1,d0
	bne	.no_bitplane2_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane2_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$500,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#2,d0
	bne	.no_bitplane3_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane3_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$300,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

.no_rak_draw:

	rts

************************************************ DRA MIG BAKLŽNGES
rita_bak:
	jsr	init_y_bli2
	lea	x_add,a1
	lea	y_add,a2
	lea	$ffff8a00,a3
	lea	bredd_add2,a4

	tst.w	2(a0)
	blt	draw_y_clip_poly2

	add.w	d0,d0
	add.w	d0,d0
	add.w	d1,d1
	move.l	#tillf_scr,d4		; tillf. screen adr
	move.l	screen,a6		; screen adr
	add.w	(a1,d0.w),d4	; dest in
	add.w	(a2,d1.w),d4	; dest ner
	add.w	(a1,d0.w),a6	; dest in
	add.w	(a2,d1.w),a6	; dest ner
	move.l	d4,save_source
	move.l	d4,$32(a3)	; s„tt dest
	moveq	#0,d4
	move.w	2(a1,d0.w),d4	; r„tt skew och allt
	add.l	d4,a4

	sub.w	(a0),d2
	neg.w	d2
	moveq	#0,d0		; x1
	move.w	2(a0),d1		; y1
	move.w	d3,d4		; save y2
	sub.w	d1,d4		; y2-y1=ant scan
	subq.w	#1,d4		; -1 for the dbf

	moveq	#0,d6	
	sub.w	d1,d3		; y2-y1
	bne	.do_a_little_jump
	move.w	#1,d4
	asl.w	#6,d2
	move.w	d2,d6
	move.w	#0,d2
	move.l	a4,a5		; save
	move.w	d4,d5
	bra	.tri_lp1
.do_a_little_jump:

	asl.w	#6,d2
	divs	d3,d2		; d3=k*64
	move.l	a4,a5		; save
	move.w	d4,d5
.tri_lp1
	add.w	d2,d6		; x1+k
	move.w	d6,d0
	asr.w	#3,d0		; /64*8

	and.w	#%1111111111111000,d0
	move.l	a5,a4
	add.w	d0,a4
	move.w	(a4)+,$28(a3)	; slutmask1
	move.w	(a4)+,$2c(a3)	; slutmask3
	move.w	(a4)+,$36(a3)	; xcount
	move.w	#1,$38(a3)	; ycount
	move.w	(a4)+,$30(a3)	; yadd
	move.b	#$c0,$3c(a3)	; blitta
	dbf	d4,.tri_lp1	

*	Nu har vi ritat triangeln p† en egen sk„rm och den skall nu ritas
*	p† den riktiga sk„rmen.

	move.w	8(a0),d0	; col
	move.b	#3,$3b(a3)	; det normala
	btst.l	#0,d0
	bne	.no_bitplane1
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane1:

	move.w	#$7,$ff8240

	move.l	save_source,$24(a3)
	move.w	#-8,$20(a3)
	move.w	-2(a4),$22(a3)
	add.w	#8,$22(a3)
	move.l	a6,$32(a3)
	add.l	#8,$32(a3)
	move.w	#$0,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	add.w	#1,$36(a3)
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	add.w	#8,$30(a3)
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#1,d0
	bne	.no_bitplane2
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane2:

	move.w	#$5,$ff8240

	move.l	save_source,$24(a3)
	move.w	#-8,$20(a3)
	move.w	-2(a4),$22(a3)
	add.w	#8,$22(a3)
	move.l	a6,$32(a3)
	add.l	#8,$32(a3)
	move.w	#$0,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	add.w	#1,$36(a3)
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	add.w	#8,$30(a3)
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#2,d0
	bne	.no_bitplane3
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane3:

	move.w	#$3,$ff8240

	move.l	save_source,$24(a3)
	move.w	#-8,$20(a3)
	move.w	-2(a4),$22(a3)
	add.w	#8,$22(a3)
	move.l	a6,$32(a3)
	add.l	#8,$32(a3)
	move.w	#$0,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	add.w	#1,$36(a3)
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	add.w	#8,$30(a3)
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

*	Rita den raka delen av v„ggen

	move.w	6(a0),d4
	neg.w	d4
	add.w	#99,d4

	tst.w	d4
	ble	.no_rak_draw	

	sub.w	#4,a6		; Fixxa till sk„rmadressen
	mulu.w	#160,d5
	add.w	d5,a6
	
	move.l	#-1,d3		;det normala
	btst.l	#0,d0
	bne	.no_bitplane1_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane1_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$700,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#1,d0
	bne	.no_bitplane2_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane2_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$500,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#2,d0
	bne	.no_bitplane3_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane3_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$300,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

.no_rak_draw:

	rts

draw_no_poly:

	rts

draw_y_clip_poly2:

	add.w	d0,d0
	add.w	d0,d0
	move.l	#tillf_scr,d4		; screen adr
	move.l	screen,a6		; screen adr
	add.w	(a1,d0.w),d4	; dest in
	move.l	d4,save_source
	add.w	(a1,d0.w),a6	; dest in
	move.l	d4,$32(a3)	; s„tt dest
	moveq	#0,d4
	move.w	2(a1,d0.w),d4	; r„tt skew och allt
	add.l	d4,a4

	sub.w	(a0),d2
	neg.w	d2
	moveq	#0,d0		; x1
	move.w	2(a0),d1		; y1
	move.w	d3,d4		; save y2
	subq.w	#1,d4		; -1 for the dbf

	moveq	#0,d6	
	sub.w	d1,d3		; y2-y1
	bne	.do_a_little_jump
	move.w	#1,d4
	asl.w	#6,d2
	move.w	d2,d6
	move.w	#0,d2
	move.l	a4,a5		; save
	move.w	d4,d5
	move.w	4(a0),d6
	muls.w	d2,d6
	bra	.tri_lp1

.do_a_little_jump:
	asl.w	#6,d2
	ext.l	d2
	divs	d3,d2		; d3=k*64
	move.l	a4,a5		; save
	move.w	2(a0),d6
	neg.w	d6
	muls.w	d2,d6
	move.w	d4,d5
.tri_lp1
	add.w	d2,d6		; x1+k
	move.w	d6,d0
	asr.w	#3,d0		; /64*8

	and.w	#%1111111111111000,d0
	move.l	a5,a4
	add.w	d0,a4
	move.w	(a4)+,$28(a3)	; slutmask1
	move.w	(a4)+,$2c(a3)	; slutmask3
	move.w	(a4)+,$36(a3)	; xcount
	move.w	#1,$38(a3)	; ycount
	move.w	(a4)+,$30(a3)	; yadd
	move.b	#$c0,$3c(a3)	; blitta
	dbf	d4,.tri_lp1	

*	Nu har vi ritat triangeln p† en egen sk„rm och den skall nu ritas
*	p† den riktiga sk„rmen.

	move.w	8(a0),d0	; col
	move.b	#3,$3b(a3)	; det normala
	btst.l	#0,d0
	bne	.no_bitplane1
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane1:

	move.w	#$7,$ff8240

	move.l	save_source,$24(a3)
	move.w	#-8,$20(a3)
	move.w	-2(a4),$22(a3)
	add.w	#8,$22(a3)
	move.l	a6,$32(a3)
	add.l	#8,$32(a3)
	move.w	#$0,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	add.w	#1,$36(a3)
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	add.w	#8,$30(a3)
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#1,d0
	bne	.no_bitplane2
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane2:

	move.w	#$5,$ff8240

	move.l	save_source,$24(a3)
	move.w	#-8,$20(a3)
	move.w	-2(a4),$22(a3)
	add.w	#8,$22(a3)
	move.l	a6,$32(a3)
	add.l	#8,$32(a3)
	move.w	#$0,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	add.w	#1,$36(a3)
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	add.w	#8,$30(a3)
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.b	#3,$3b(a3)	; det normala
	btst.l	#2,d0
	bne	.no_bitplane3
	move.b	#4,$3b(a3)	; men skall ej planet ritas s† maska det
.no_bitplane3:

	move.w	#$3,$ff8240

	move.l	save_source,$24(a3)
	move.w	#-8,$20(a3)
	move.w	-2(a4),$22(a3)
	add.w	#8,$22(a3)
	move.l	a6,$32(a3)
	add.l	#8,$32(a3)
	move.w	#$0,$28(a3)	; slutmask1
	move.w	#$ffff,$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	add.w	#1,$36(a3)
	move.w	d5,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	add.w	#8,$30(a3)
	move.b	#2,$3a(a3)
	move.b	#$c0,$3c(a3)	; blitta

*	Rita den raka delen av v„ggen

	move.w	6(a0),d4
	neg.w	d4
	add.w	#99,d4

	tst.w	d4
	ble	.no_rak_draw	

	sub.w	#4,a6		; Fixxa till sk„rmadressen
	mulu.w	#160,d5
	add.w	d5,a6

	
	move.l	#-1,d3		;det normala
	btst.l	#0,d0
	bne	.no_bitplane1_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane1_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$700,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#1,d0
	bne	.no_bitplane2_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane2_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$500,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#2,d0
	bne	.no_bitplane3_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane3_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$300,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

.no_rak_draw:



*****************************************************************
*	Om Triangeln inte syns skall det bara ritas en fyrkant

pure_box:

	move.w	#$300,$ff8240

	tst.w	(a0)
	bge	.hoppy
	move.w	#0,(a0)
.hoppy:
	cmp.w	#255,(a0)
	ble	.hoppy2
	move.w	#255,(a0)
.hoppy2:
	tst.w	4(a0)
	bge	.hoppy3
	move.w	#0,4(a0)
.hoppy3:
	cmp.w	#255,4(a0)
	ble	.hoppy4
	move.w	#255,4(a0)
.hoppy4:

	jsr	init_y_bli2

	move.w	4(a0),d0
	cmp.w	(a0),d0
	ble	.hopp
	move.w	(a0),4(a0)
	move.w	d0,(a0)
	move.w	6(a0),d0
	move.w	2(a0),6(a0)
	move.w	d0,2(a0)
.hopp:

	move.w	(a0),d0
	move.w	2(a0),d1
	move.w	4(a0),d2
	move.w	6(a0),d3

	lea	x_add,a1
	lea	y_add,a2
	lea	$ffff8a00,a3
	lea	bredd_add2,a4

	add.w	d0,d0
	add.w	d0,d0
	move.l	#tillf_scr,d4		; screen adr
	move.l	screen,a6		; screen adr
	add.w	(a1,d0.w),d4	; dest in
	move.l	d4,save_source
	add.w	(a1,d0.w),a6	; dest in
	move.l	d4,$32(a3)	; s„tt dest
	moveq	#0,d4
	move.w	2(a1,d0.w),d4	; r„tt skew och allt
	add.l	d4,a4

	move.w	(a0),d3
	sub.w	d3,d2
	tst.w	d2
	bge	.haha
	neg.w	d2
.haha:
	asl.w	#3,d2
	add.w	d2,a4

*	move.w	6(a0),d4
*	neg.w	d4
*	add.w	#99,d4

*	tst.w	d4
*	ble	.no_rak_draw	

*	move.w	(a4),$28(a3)	; slutmask1
*	move.w	2(a4),$2c(a3)	; slutmask3
*	move.w	4(a4),$36(a3)	; xcount
*	move.w	#99,$38(a3)	; ycount
*	move.w	6(a4),$30(a3)	; yadd
*	move.b	#$c0,$3c(a3)	; blitta

*	move.w	6(a0),d4
*	neg.w	d4
*	add.w	#99,d4

*	tst.w	d4
*	ble	.no_rak_draw	

	sub.w	#4,a6		; Fixxa till sk„rmadressen
	mulu.w	#160,d5
	add.w	d5,a6

	move.l	#-1,d3		;det normala
	btst.l	#0,d0
	bne	.no_bitplane1_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane1_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$700,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#1,d0
	bne	.no_bitplane2_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane2_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$500,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

	add.w	#2,a6
	move.l	#-1,d3		; det normala
	btst.l	#2,d0
	bne	.no_bitplane3_2
	move.l	#0,d3		; men skall ej planet ritas s† maska det
.no_bitplane3_2:

	move.l	d3,(a3)
	move.l	d3,4(a3)
	move.l	d3,8(a3)
	move.l	d3,12(a3)
	move.l	d3,16(a3)	; men skall ej planet ritas s† maska det
	move.l	d3,20(a3)
	move.l	d3,24(a3)
	move.l	d3,28(a3)

	move.w	#$300,$ff8240

	move.w	#0,$20(a3)
	move.w	#0,$22(a3)
	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.l	a6,$32(a3)
	move.b	#1,$3a(a3)
	move.b	#3,$3b(a3)
	move.b	#$c0,$3c(a3)	; blitta

*.no_rak_draw:

*.no_rak_draw:

	rts

***************************************************************************
*	Clipping rutinen ; step p† 1/32=0,03125 vilket „r lite f”r d†lig
*	precision...

clipp:

*	Sortera f”rst bort boxen om den inte syns ((x1 och x2)<0 eller >255)

	tst.w	(a0)
	bge	.no_bort
	tst.w	4(a0)
	bge	.no_bort
	bra	draw_no_poly
.no_bort:
	cmp.w	#255,(a0)
	ble	.no_bort2
	cmp.w	#255,4(a0)
	ble	.no_bort2
	bra	draw_no_poly
.no_bort2:

*	Clipp linjen

	move.w	(a0),d1
	sub.w	4(a0),d1
	move.w	2(a0),d0
	sub.w	6(a0),d0
	asl.w	#5,d0
	ext.l	d0
	divs.w	d1,d0	; d0 inneh†ller K v„rdet p† linjen


*	X1<0 klipp

	tst.w	(a0)
	bge	.no_clipp_x1

	move.w	4(a0),d3
	muls.w	d0,d3
	move.w	6(a0),d4
	asl.w	#5,d4
	sub.w	d3,d4
	asr.w	#5,d4
	move.w	#0,(a0)
	move.w	d4,2(a0)

.no_clipp_x1:

*	X1>255 klipp

	cmp.w	#255,(a0)
	ble	.no_clipp_x1_2

	move.w	4(a0),d3
	muls.w	d0,d3
	move.w	#255,d5
	muls.w	d0,d5
	move.w	6(a0),d4
	asl.w	#5,d4
	add.w	d5,d4
	sub.w	d3,d4
	asr.w	#5,d4
	move.w	#255,(a0)
	move.w	d4,2(a0)

.no_clipp_x1_2:

*	X2<0 klipp

	tst.w	4(a0)
	bge	.no_clipp_x2

	move.w	(a0),d3
	muls.w	d0,d3
	move.w	2(a0),d4
	asl.w	#5,d4
	sub.w	d3,d4
	asr.w	#5,d4
	move.w	#0,4(a0)
	move.w	d4,6(a0)

.no_clipp_x2:

*	X2>255 klipp

	cmp.w	#255,4(a0)
	ble	.no_clipp_x2_2

	move.w	#255,d3
	muls.w	d0,d3
	move.w	(a0),d5
	muls.w	d0,d5
	move.w	2(a0),d4
	asl.w	#5,d4
	sub.w	d5,d4
	add.w	d3,d4
	asr.w	#5,d4
	move.w	#255,4(a0)
	move.w	d4,6(a0)

.no_clipp_x2_2:

	bra	back_to_poly

****************
* Endif        *
****************
end
	movem.l	savepal,d0-d7
	movem.l	d0-d7,$ffff8240.w
	
	move.l	svbi,$70.w
	
	move.w	oldrez,-(sp)
	move.l	oldphys,-(sp)
	move.l	oldlog,-(sp)
	move.w	#5,-(sp)
	trap	#14
	lea	12(sp),sp
	
	move.l	ustk,-(sp)
	move.w	#$20,-(sp)
	trap	#1
	addq.l	#6,sp
	
	clr.w	-(sp)
	trap	#1
	
*****************
* VBI och VSYNC *
*****************
vbi	add.w	#1,vflag
	rte
	
vsync	tst.w	vflag
	beq.s	vsync
	clr.w	vflag
	rts

vsync2	cmp.w	vflag,d0		; d0 = parameter f”r antal vbi
	bgt.s	vsync2
	clr.w	vflag
	rts
	
**********************
* olika screenseters * 
**********************
change_screen
	move.l	a0,-(sp)
	move.l	screen,a0
	move.l	screen,screen+4
	move.l	a0,screen
	move.l	(sp)+,a0
	
set_screen
	move.b	screen+1,$ffff8201.w
	move.b	screen+2,$ffff8203.w
	move.b	screen+3,$ffff820d.w
	rts

set_screen2
	move.b	screen+4+1,$ffff8201.w
	move.b	screen+4+2,$ffff8203.w
	move.b	screen+4+3,$ffff820d.w
	rts
	
***************************************************************************
	section	data
	
screen		dc.l	scrblk,scrblk+32000
y_normal		dc.w	99
koords		ds.w	5

slutmasker	dc.w	%1000000000000000
		dc.w	%1100000000000000
		dc.w	%1110000000000000
		dc.w	%1111000000000000
		dc.w	%1111100000000000
		dc.w	%1111110000000000
		dc.w	%1111111000000000
		dc.w	%1111111100000000
		dc.w	%1111111110000000
		dc.w	%1111111111000000
		dc.w	%1111111111100000
		dc.w	%1111111111110000
		dc.w	%1111111111111000
		dc.w	%1111111111111100
		dc.w	%1111111111111110
		dc.w	%1111111111111111
		dc.w	0			; endcode


slutmasker3	dc.w	%1111111111111111
		dc.w	%0111111111111111
		dc.w	%0011111111111111
		dc.w	%0001111111111111
		dc.w	%0000111111111111
		dc.w	%0000011111111111
		dc.w	%0000001111111111
		dc.w	%0000000111111111
		dc.w	%0000000011111111
		dc.w	%0000000001111111
		dc.w	%0000000000111111
		dc.w	%0000000000011111
		dc.w	%0000000000001111
		dc.w	%0000000000000111
		dc.w	%0000000000000011
		dc.w	%0000000000000001

slutmasker4
		dc.w	%0000000000000001
		dc.w	%0000000000000011
		dc.w	%0000000000000111
		dc.w	%0000000000001111
		dc.w	%0000000000011111
		dc.w	%0000000000111111
		dc.w	%0000000001111111
		dc.w	%0000000011111111
		dc.w	%0000000111111111
		dc.w	%0000001111111111
		dc.w	%0000011111111111
		dc.w	%0000111111111111
		dc.w	%0001111111111111
		dc.w	%0011111111111111
		dc.w	%0111111111111111
		dc.w	%1111111111111111
		dc.w	0			; endcode

fyllt_word	dc.w	$ffff
tomt_word:	dc.w	$0

	section	bss
scrblk		ds.l	2*8000
ustk		ds.l	1
oldphys		ds.l	1
oldlog		ds.l	1
oldrez		ds.l	1
svbi		ds.l	1
y_add		ds.w	200
x_add		ds.w	640
bredd_add1	ds.w	20480
bredd_add2	ds.w	20480
tillf_scr:	ds.l	4000
savepal		ds.w	16
vflag		ds.w	1
save_source:	ds.l	1
	end


draw_y_clip_poly2:

	add.w	d0,d0
	add.w	d0,d0
	move.l	#tillf_scr,d4		; screen adr
	add.w	(a1,d0.w),d4	; dest in
	move.l	d4,$32(a3)	; s„tt dest
	moveq	#0,d4
	move.w	2(a1,d0.w),d4	; r„tt skew och allt
	add.l	d4,a4

	sub.w	(a0),d2
	neg.w	d2
	moveq	#0,d0		; x1
	move.w	2(a0),d1		; y1
	move.w	d3,d4		; save y2
	subq.w	#1,d4		; -1 for the dbf

	moveq	#0,d6	
	sub.w	d1,d3		; y2-y1
	bne	.do_a_little_jump
	move.w	#1,d4
	asl.w	#6,d2
	move.w	d2,d6
	move.w	#0,d2
	move.l	a4,a5		; save
	move.w	4(a0),d6
	muls.w	d2,d6

	bra	.tri_lp1
.do_a_little_jump:
	asl.w	#6,d2
	ext.l	d2
	divs	d3,d2		; d3=k*64
	move.l	a4,a5		; save
	move.w	2(a0),d6
	neg.w	d6
	muls.w	d2,d6

.tri_lp1
	add.w	d2,d6		; x1+k
	move.w	d6,d0
	asr.w	#3,d0		; /64*8

	and.w	#%1111111111111000,d0
	move.l	a5,a4
	add.w	d0,a4
	move.w	(a4)+,$28(a3)	; slutmask1
	move.w	(a4)+,$2c(a3)	; slutmask3
	move.w	(a4)+,$36(a3)	; xcount
	move.w	#1,$38(a3)	; ycount
	move.w	(a4)+,$30(a3)	; yadd
	move.b	#$c0,$3c(a3)	; blitta
	dbf	d4,.tri_lp1	

*	Rita den raka delen av v„ggen

	move.w	#$300,$ff8240

	move.w	6(a0),d4
	neg.w	d4
	add.w	#99,d4

	tst.w	d4
	ble	.no_rak_draw	

	move.w	-8(a4),$28(a3)	; slutmask1
	move.w	-6(a4),$2c(a3)	; slutmask3
	move.w	-4(a4),$36(a3)	; xcount
	move.w	d4,$38(a3)	; ycount
	move.w	-2(a4),$30(a3)	; yadd
	move.b	#$c0,$3c(a3)	; blitta

.no_rak_draw:

	rts

*****************************************************************
*	Om Triangeln inte syns skall det bara ritas en fyrkant

pure_box:

	move.w	#$300,$ff8240

	tst.w	(a0)
	bge	.hoppy
	move.w	#0,(a0)
.hoppy:
	cmp.w	#255,(a0)
	ble	.hoppy2
	move.w	#255,(a0)
.hoppy2:
	tst.w	4(a0)
	bge	.hoppy3
	move.w	#0,4(a0)
.hoppy3:
	cmp.w	#255,4(a0)
	ble	.hoppy4
	move.w	#255,4(a0)
.hoppy4:

	jsr	init_y_bli2

	move.w	4(a0),d0
	cmp.w	(a0),d0
	ble	.hopp
	move.w	(a0),4(a0)
	move.w	d0,(a0)
	move.w	6(a0),d0
	move.w	2(a0),6(a0)
	move.w	d0,2(a0)
.hopp:

	move.w	(a0),d0
	move.w	2(a0),d1
	move.w	4(a0),d2
	move.w	6(a0),d3

	lea	x_add,a1
	lea	y_add,a2
	lea	$ffff8a00,a3
	lea	bredd_add2,a4

	add.w	d0,d0
	add.w	d0,d0
	move.l	screen,d4		; screen adr
	add.w	(a1,d0.w),d4	; dest in
	move.l	d4,$32(a3)	; s„tt dest
	moveq	#0,d4
	move.w	2(a1,d0.w),d4	; r„tt skew och allt
	add.l	d4,a4

	move.w	(a0),d3
	sub.w	d3,d2
	tst.w	d2
	bge	.haha
	neg.w	d2
.haha:
	asl.w	#3,d2
	add.w	d2,a4

*	move.w	6(a0),d4
*	neg.w	d4
*	add.w	#99,d4

*	tst.w	d4
*	ble	.no_rak_draw	

	move.w	(a4),$28(a3)	; slutmask1
	move.w	2(a4),$2c(a3)	; slutmask3
	move.w	4(a4),$36(a3)	; xcount
	move.w	#99,$38(a3)	; ycount
	move.w	6(a4),$30(a3)	; yadd
	move.b	#$c0,$3c(a3)	; blitta

*.no_rak_draw:

	rts