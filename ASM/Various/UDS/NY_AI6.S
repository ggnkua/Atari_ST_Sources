*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri*	Senast uppdaterad 950425

START_SPRITE		EQU	48
SPRITE_ANIMATIONER	EQU	14
MAX_LJUD_I_SOUND_BOARD	EQU	20
SIKT_STRACKA		EQU	64*6*64*6 ; Den str„ckan som fi kan se.
HAR_STRACKA		EQU	64*4*64*4 ; Den str„ckan som fi kan h”ra.
EVENT_STRACKA		EQU	64*4*64*4 ; Den str„ckan som eventet n†r.
BIT_AVST		EQU	70*70	  ; Den str„ckan som 'bitet' n†r.
VAKEN_TID		EQU	25*12	  ; Den tid som fi „r vaken(larm)
FLY_TID			EQU	25*12	  ; Den tid som fi flyr
FI_MAX_SHOOT_WAIT	EQU	20	  ; Vad skall nedr„kningen b”rja p†
TJOCKLEK		EQU	16*25	  ; Gubbens tjocklek

;--------------------------------------------------------------------------
;				Initiering av Fi
;--------------------------------------------------------------------------
init_av_fi:

*	Fixxa till IX,IY +m.m om det „r en vakt och
*	l„gg in Fi's adress(Adressen till adressmappen) i 56+2(a0) och
*	i adrmap.

	jsr	.init_sublevel

	jsr	.plot_fi

	move.b	$fff820d,slump	; Lite slump in i slump

	rts

*****************************************
*	Initieri