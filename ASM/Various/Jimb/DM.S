	TEXT
Begin:
	MOVE.L	4(A7),$66000
	CLR.L	-(A7)
	MOVE.W	#$20,-(A7)	;SUPER
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.L	D0,oldstack
	MOVE.W	#2,-(A7)	;PHYSBASE
	TRAP	#$E
	MOVEA.L	D0,A0
	MOVE.L	#$1F40,D0
L0000:	CLR.L	(A0)+
	DBF	D0,L0000
	MOVE.W	#$777,$FF8240.L
	PEA	L0008
	MOVE.W	#9,-(A7)	;CCONWS
	TRAP	#1
	MOVE.W	#7,-(A7)
	NOP
	CLR.W	-(A7)
	PEA	L0006
	MOVE.W	#$3D,-(A7)	;FOPEN
	TRAP	#1
	MOVE.W	D0,D5
	MOVE.L	#$40000,-(A7)
	MOVE.L	#$C00,-(A7)
	MOVE.W	D5,-(A7)
	MOVE.W	#$3F,-(A7)	;FREAD
	TRAP	#1
	MOVE.W	D5,-(A7)
	MOVE.W	#$3E,-(A7)	;FCLOSE
	TRAP	#1
	MOVE.L	#$F,D0
	LEA	$FF8240.L,A0
L0001:CLR.W	(A0)+
	DBF	D0,L0001
	JSR	$40000
	MOVEA.L	#L0003,A1
	MOVEA.L	#$2000,A0
	MOVE.L	#$200,D0
L0002:MOVE.L	(A1)+,(A0)+
	DBF	D0,L0002
	JMP	$2000

L0003:	LEA	$7FFFE,A7

	move.w	#$19,-(sp)		;getdrv
	trap	#1
	addq.l	#2,sp
	lea	space(pc),a0
	move.w	d0,(a0)

	CLR.W	-(A7)
	PEA	L0007(pc)
	MOVE.W	#$3D,-(A7)	;FOPEN
	TRAP	#1
	MOVE.W	D0,D5
	MOVE.L	#$1151A,-(A7)
	MOVE.L	#$29000,-(A7)
	MOVE.W	D5,-(A7)
	MOVE.W	#$3F,-(A7)	;FREAD
	TRAP	#1
	MOVE.W	D5,-(A7)
	MOVE.W	#$3E,-(A7)	;FCLOSE
	TRAP	#1
	ADDA.L	#$18,A7
	lea	oldstack(pc),a6
	MOVE.L	(a6),-(A7)
	MOVE.W	#$20,-(A7)	;SUPER
	TRAP	#1
	ADDQ.L	#6,A7
	LEA	$7FFF8,A7
	MOVE.B	#$60,D0
	MOVE.B	D0,$21570
	MOVE.B	D0,$2B336
	MOVE.B	D0,$17CEE
	MOVE.B	D0,$2978C
	MOVE.B	D0,$2B5A6
	MOVE.B	D0,$2F004
	MOVE.B	D0,$2F02E
	MOVE.B	D0,$2F050
	MOVE.B	D0,$2AB66
	MOVE.B	D0,$23AAA
	MOVE.B	D0,$2BECE
	MOVE.W	#$4EF9,D0
	MOVE.W	D0,$30BEE
	MOVE.W	D0,$30D56
	MOVE.L	#$FC0020,D0
	MOVE.L	D0,$30BF0
	MOVE.L	D0,$30D58
	MOVE.W	#$6002,$2F046
	MOVE.L	#$303CFFF8,D0
	MOVE.L	D0,$2EFFA
	MOVE.L	D0,$2F024
	MOVE.W	#$4E71,D0
	MOVE.W	D0,$1A5CA
	MOVE.W	D0,$3113E
	MOVE.W	D0,$2F240
	MOVE.W	D0,$2EF24
	MOVE.L	#$4E714E71,D0
	MOVE.L	D0,$18832
	MOVE.L	D0,$11E24
	MOVE.L	D0,$2FA88
	MOVE.L	#$3E3C0002,$2F248
	MOVE.W	#$603C,$2F24C
	MOVE.B	#$88,$11EC3
	MOVE.W	#$3F00,$2F6C6
	MOVE.W	#$31E9,$11EBC
	MOVE.W	#$C91,D0
	MOVE.W	D0,$146C6
	MOVE.W	D0,$17D00
	MOVE.W	D0,$2AA3A
	MOVE.W	D0,$2B5BA
	MOVE.W	D0,$2B348
	MOVE.L	#$303C0088,$166D6
	MOVE.L	#$42806010,$2F07A
	MOVE.L	#$397C0088,$31D4A
	MOVE.L	#$FC6A397C,$31D4E
	MOVE.L	#$88F8D4,$31D52
	MOVE.L	#$397C0000,$31D56
	MOVE.L	#$D41C4E75,$31D5A
	MOVE.L	$66000,D0
	MOVE.L	#$1151A,D1
	SUB.L	D0,D1
	SUB.L	D1,$1151A
	SUB.L	D1,$11546
	SUB.L	D1,$11532
	SUB.L	D1,$11522
	SUB.L	D1,$1153A
	SUB.L	D1,$1152A
	MOVEA.L	#$1161C,A1
L0004:SUB.L	D1,(A1)
	ADDA.L	#6,A1
	MOVE.L	A1,D2
	CMP.L	#$11C28,D2
	BNE.S	L0004

	MOVEA.L	$66000,A0
	MOVEA.L	#$1151A,A1
	MOVE.L	#$14000,D0
L0005:MOVE.L	(A1)+,(A0)+
	SUBI.L	#1,D0
	CMP.L	#0,D0
	BNE.S	L0005

	lea	space(pc),a0
	move.w	(a0),-(sp)
	move.w	#$e,-(sp)		;setdrv
	trap	#1
	addq.l	#4,sp

	pea	path(pc)
	move.w	#$3b,-(sp)		;setpath
	trap	#1
	addq.l	#6,sp

	MOVE.L	$66000,D0
	MOVE.L	D0,4(A7)
	MOVEA.L	D0,A0
	ADDA.L	#$100,A0
	JMP	(A0)
oldstack	DS.W	2
space		ds.w	1
path		dc.b	'\dm',0
L0006:	DC.B	'40000',0
L0007:	DC.B	'wazzzzzz.was',0
L0008:	DC.B	'Cracked by Was (Not Was).',13,10
	dc.b	'Hard Drive fix by Jim',13,10,0
ZUEND:	END
