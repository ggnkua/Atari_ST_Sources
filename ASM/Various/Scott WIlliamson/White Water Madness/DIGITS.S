DIGITLEN = 7            ; HEIGHT OF DIGIT

  TEXT
DISPDGTS:    ; DISPLAYS THE 10 DIGIT (5-BYTE) # AT (A1) AT (A0)
  LEA DIGITDAT,A2       ; A2 POINTS TO DIGIT CHARS

  MOVE #5-1,D6          ; LOOP THRU 10 DIGITS AS 5 DIGIT PAIRS
DRAWNUMBER:
  MOVE.B (A1)+,D0       ; GET DATA IN D0                LSB
  MOVE.B D0,D1          ; GET LOWER 2 DIGITS
  AND #$F,D1            ; ISOLATE LOWEST DIGIT
  MULU #DIGITLEN*4,D1   ; MAKE INDEX INTO DIGIT DATA

  CLR D2                ; CLEAR VIDEO INDEX D2
  MOVE #DIGITLEN-1,D7   ; LOOP DIGITLEN TIMES
DRAWDIGIT2:
  MOVE.B 0(A2,D1.W),1(A0,D2.W) ; COPY DIGIT BYTE
  MOVE.B 1(A2,D1.W),3(A0,D2.W)
  MOVE.B 2(A2,D1.W),5(A0,D2.W)
  MOVE.B 3(A2,D1.W),7(A0,D2.W)
  ADD #160,D2           ; UPDATE VIDEO INDEX
  ADD #4,D1             ; UPDATE DIGIT LOOKUP INDEX
  DBRA D7,DRAWDIGIT2

  ROR.B #4,D0           ; PUT MSB IN LSB OF D0          MSB
  AND #$F,D0            ; ISOLATE LOWEST DIGIT
  MULU #DIGITLEN*4,D0   ; MAKE INDEX INTO DIGIT DATA

  CLR D2                ; CLEAR VIDEO INDEX D2
  MOVE #DIGITLEN-1,D7   ; LOOP DIGITLEN TIMES
DRAWDIGIT1:
  MOVE.B 0(A2,D0.W),0(A0,D2.W) ; COPY DIGIT BYTE
  MOVE.B 1(A2,D0.W),2(A0,D2.W)
  MOVE.B 2(A2,D0.W),4(A0,D2.W)
  MOVE.B 3(A2,D0.W),6(A0,D2.W)
  ADD #160,D2           ; UPDATE VIDEO INDEX
  ADD #4,D0             ; UPDATE DIGIT LOOKUP INDEX
  DBRA D7,DRAWDIGIT1
  ADD #8,A0
  DBRA D6,DRAWNUMBER
  RTS

; ***** reserved data area *****

DIGITDAT:
  IBYTES '\ASSEMPRO\WWM\DIGITS.DAT'
PALETTE:
  IBYTES '\ASSEMPRO\WWM\PALETTE.DAT',32

  END
