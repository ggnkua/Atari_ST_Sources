; ANIMATE.PRG           ANIMATE SCREENS
; THIS PROGRAM WILL LOOK IN THE CURRENT DIRECTORY AND LOAD
; UP TO 20 PICTURES (DEGAS UNCOMPRESED) NAMED "FRAME##.PI1" WHERE
; ## IS ANY NUMBER FROM 01 TO 20 THEN WILL ANIMATE THROUGH THE
; EXISTING FRAMES.

; +      SPEED UP (UP TO 60 FRAMES A SECOND)
; -      SLOW DOWN
; ->     FORWARDS
; <-     BACKWARDS
; SPACE  PAUSE
; ESC    EXIT

  BSS
  ALIGN
SCREENA  DS.L 1
SSSAVE   DS.L 1
HANDLE   DS.W 1
REZPAL   DS.W 18        ; SPACE FOR REZ FLAG & PALETTE
         DS.B $100      ; PAGE ALIGNMENT SPACE
SCREEN1  DS.B 32000*50  ; BUFFERS FOR 100 SCREENS
AFTERLASTSCREEN:
buffer   DS.B 129

  DATA
  ALIGN
DEL      DC.W 20
DIR      DC.L 32000
FILE     DC.B 'FRAME'
FRNO     DC.B '01?*.P?1',0

  TEXT
  CLR.L -(SP)           ; SUPER
  MOVE #$20,-(SP)
  TRAP #1
  ADDQ.L #6,SP
  MOVE.L D0,SSSAVE     ; AND GET READY TO GO BACK TO USER

  CLR.L D7              ; INIT FRAME COUNTER TO 0
  MOVE.L #SCREEN1,D0    ; FETCH SCREEN ADRESS
  AND.L #$FFFFFF00,D0   ; AND MAKE IT FALL ON A PAGE BOUNDRY
  MOVE.L D0,A6

GET_PICTURE:
  MOVE #2,-(SP)         ; OPEN FILE
  MOVE.L #FILE,-(SP)
  MOVE #$3D,-(SP)
  TRAP #1
  ADDQ.L #8,SP
  TST D0
  BMI INCFRAMECTR       ; NO FILE? GO CHECK FOR ANOTHER
  MOVE D0,HANDLE

  MOVE.L #REZPAL,-(SP)  ; READ IN PALETTRE AND REZ
  MOVE.L #34,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$3F,-(SP)
  TRAP #1
  ADD.L #12,SP
  cmp.b #$80,rezpal        ; compressed?
  beq compressed

  MOVE.L A6,-(SP)       ; READ IN IMAGE DATA
  MOVE.L #32000,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$3F,-(SP)
  TRAP #1
  ADD.L #12,SP
  jmp close

compressed:
  CLR.L d6              ; screen length in bytes
  move.l #40,d5         ; line length 1 bpl
  move.l #4,d4          ; bpl counter
  MOVE.L #2,D3          ; WORD
READCOMMAND:
  MOVE.L #BUFFER,-(SP)  ; READ A COMMAND
  MOVE.L #1,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$3F,-(SP)
  TRAP #1
  ADD.L #12,SP

  MOVE.B BUFFER,D0
  CMP.B #-128,D0
  BEQ READCOMMAND       ; IGNORE -128
  CMP.B #0,D0
  BGE COPYNEXTBYTES     ; D0 >=0 COPY NEXT D0+1 BYTES LITERALLY

COPYNEXTBYTE:           ;    OTHERWISE
  NEG.B D0              ; D0 <0 COPY NEXT BYTE -D0+1 TIMES
  EXT.W D0
  EXT.L D0              ; NEGATE D0 & MAKE IT A LONG WORD
  MOVE.L D0,-(SP)       ; SAVE D0

  move.l #BUFFER,-(SP)  ; READ ONLY 1 BYTE
  MOVE.L #1,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$3F,-(SP)
  TRAP #1
  ADD.L #12,SP

  MOVE.L (SP)+,D0         ; RECOVER D0 (N-1 FOR DBRA)

PUTBYTE:
  MOVE.B BUFFER,(A6,D6.L) ; PUT BYTE IN SCREEN BUFFER
  ADDQ.L #1,D6          ; INC SCREEN ADR
  SUBQ.L #1,D5          ; LINE LENGTH
  SUBQ.L #1,D3          ; BYTES PER WORD
  BNE WORDOK
  ADDQ.L #6,D6          ; SKIP OTHER BPL'S
  MOVE.L #2,D3
WORDOK:
  DBRA D0,PUTBYTE
  BRA PROCEND

COPYNEXTBYTES:
  EXT.W D0
  EXT.L D0              ; MAKE D0 A LONG WORD
  MOVE.L D0,-(SP)       ; SAVE D0

  ADDQ.L #1,D0          ; ADD 1 TO D0 ONLY FOR THE LOAD
  MOVE.L #BUFFER,-(SP)  ; READ N+1 BYTES
  MOVE.L D0,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$3F,-(SP)
  TRAP #1
  ADD.L #12,SP

  MOVE.L (SP)+,D0         ; RECOVER D0 ((N+1)-1 FOR DBRA)
  LEA BUFFER,A5
PUTBYTE2:
  MOVE.B (A5)+,(A6,D6.L) ; PUT BYTE IN SCREEN BUFFER
  ADDQ.L #1,D6          ; INC SCREEN ADR
  SUBQ.L #1,D5          ; LINE LENGTH
  SUBQ.L #1,D3          ; BYTES PER WORD
  BNE WORDOK2
  ADDQ.L #6,D6          ; SKIP OTHER BPL'S
  MOVE.L #2,D3
WORDOK2:
  DBRA D0,PUTBYTE2

PROCEND:
  CMP.L #0,D5           ; END OF LINE?
  BNE READCOMMAND       ; NO KEEP READING
  MOVE.L #40,D5         ; EOL - RESET LINE BYTE COUNER
  SUBQ.L #1,D4          ; LAST BPL ?
  BEQ NEXTLINE          ; YES
  SUB.L #158,D6         ; NO - NEXT BPL CURRENT LINE
  BRA READCOMMAND
NEXTLINE:               ; NEW LINE
  SUBQ.L #6,D6          ; RESET TO BPL 0 NEXT LINE
  MOVE.L #4,D4          ; RESET BPL COUNTER
  CMP.L #32000,D6       ; END OF SCREEN ?
  BEQ DONECOMPRESSED
  BRA READCOMMAND

DONECOMPRESSED:
close:
  MOVE HANDLE,-(SP)     ; CLOSE FILE
  MOVE #$3E,-(SP)
  TRAP #1
  ADDQ.L #4,SP

  ADD.L #32000,A6       ; INREMENT FRAME BASE ADR COUNTER
  CMP.L #AFTERLASTSCREEN,A6
  BEQ ANIMATE           ; IF ALL BUFFERS ARE FULL THEN ANIMATE
  ADDQ #1,D7            ; INMCREMENT FRAME COUNTER

INCFRAMECTR:
  ADD.B #1,FRNO+1       ; INCREMENT FRAME NUMBER IN FILENAME
  CMP.B #'9'+1,FRNO+1
  BNE LT10
  ADD.B #1,FRNO
  SUB.B #10,FRNO+1
LT10:
  CMP.B #'0',FRNO+1       ; CHECK TO SEE IF FRNO=100
  BNE GET_PICTURE
  CMP.B #'9'+1,FRNO
  BNE GET_PICTURE

; IF FRNO = 100 OR A6 (FRADR) EXCEEDS THE END OF THE SCREEN BUFFERS
; THEN THE LOOP FALLS THROUGH TO HERE.

ANIMATE:
  MOVE $FF8260,-(SP)    ; REZ
  MOVE.L $FF8240,-(SP)  ; SAVE PALETTE
  MOVE.L $FF8244,-(SP)
  MOVE.L $FF8248,-(SP)
  MOVE.L $FF824C,-(SP)
  MOVE.L $FF8250,-(SP)
  MOVE.L $FF8254,-(SP)
  MOVE.L $FF8258,-(SP)
  MOVE.L $FF825C,-(SP)

  MOVE #2,-(SP)         ; GET PHYSBASE
  TRAP #14
  ADDQ.L #2,SP
  MOVE.L D0,SCREENA

  MOVE.L #REZPAL+2,$45A   ; SET PALETTE
  MOVE.B #0,$FF8260     ; LOW REZ

  MOVE.L #SCREEN1,D0    ; INIT SCREEN1 BASE ADRESS
  AND.L #$FFFFFF00,D0
  MOVE.L D0,A6
  MOVE D7,D6            ; COPY # OF FRAMES
  SUBQ #1,D6                            
  MULU #32000,D6        ; * FRLEN
  MOVE.L A6,A5
  ADD.L D6,A5           ; A5 HAS ADRESS OF LAST FRAME IN IT

DISPSCREEN:
  MOVE.L A6,$45E        ; VIDEO ADR

  MOVE #2,-(SP)         ; KEY WAITING?
  MOVE #1,-(SP)
  TRAP #13
  ADDQ.L #4,SP
  TST D0
  BEQ NOKEY             ; NO GO WAIT FOR VBLS

  MOVE #7,-(SP)         ; IF THERE IS A CHAR GET IT
  TRAP #1
  ADDQ.L #2,SP

  CMP.B #'+',D0         ; +
  BNE NOTPLUS
  SUBQ #1,DEL
  BNE NOTPLUS
  MOVE #1,DEL

NOTPLUS:
  CMP.B #'-',D0         ; -
  BNE NOTMINUS
  ADDQ #1,DEL

NOTMINUS:
  CMP.B #27,D0          ; ESC
  BNE NOTESC
EXIT:
  MOVE.L SCREENA,$45E   ; RELOAD SCREEN ADRESS
  MOVE.L #0,$45A        ; CLR COLOR POINTER TOO
  MOVE.L $462,D7        ; WAIT FOR
  ADDQ.L #2,D7          ; 1 VBL
WVBL:
  CMP.L $462,D7
  BNE WVBL
  MOVE.L #0,$45E
  MOVE.L (SP)+,$FF825C  ; RESTORE PALETTE
  MOVE.L (SP)+,$FF8258
  MOVE.L (SP)+,$FF8254
  MOVE.L (SP)+,$FF8250
  MOVE.L (SP)+,$FF824C
  MOVE.L (SP)+,$FF8248
  MOVE.L (SP)+,$FF8244
  MOVE.L (SP)+,$FF8240
  MOVE   (SP)+,$FF8260  ; RESTORE REZ
  MOVE.L SSSAVE,-(SP)
  MOVE #$20,-(SP)
  TRAP #1               ; USER
  ADDQ.L #6,SP
  CLR -(SP)             ; TERM
  TRAP #1

NOTESC:
  CMP.B #' ',D0         ; SPACE
  BNE NOTSPACE
  MOVE #7,-(SP)         ; CONIN
  TRAP #1
  ADDQ.L #2,SP

NOTSPACE:
  SWAP D0               ; USE KEY CODE FOR SPECIAL KEYS
  CMP.B #$4B,D0         ; LEFT ARROW
  BNE NOTLEFT
  MOVE.L #-32000,DIR

NOTLEFT:
  CMP.B #$4D,D0         ; RIGHT ARROW
  BNE NOTRIGHT
  MOVE.L #32000,DIR

NOTRIGHT:
NOKEY:                  ; THERE IS NO KEY WAITING
  ADD.L DIR,A6          ; INDEX POINTER TO NEXT SCREEN
  CMP.L #SCREEN1-$100,A6 ; AND CHECK TO SEE IF TO FAR
  BGT NOTLESS
  MOVE.L A5,A6

NOTLESS:
  CMP.L A5,A6
  BLE NOTHI
  MOVE.L #SCREEN1,D0
  AND.L #$FFFFFF00,D0
  MOVE.L D0,A6

NOTHI:
  MOVE DEL,D7           ; WAIT DELAY
  AND.L #$FF,D7
  ADD.L $462,D7
DELAY:
  CMP.L $462,D7
  BNE DELAY
  JMP DISPSCREEN
  END
