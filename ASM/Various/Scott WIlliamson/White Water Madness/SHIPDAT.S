 DATA
        ALIGN
;
; DEFINED DATA GOES HERE
;

SPDATA:
SHIP:
;0000
 DC.W $1830,$1830,$1830,$1830,$1830,$1830,$1830,$1830
 DC.W $1830,$1830,$1830,$1FF0,$1838,$1830,$1838,$1FF0
 DC.W $3EFC,$1830,$183C,$1930,$383A,$583C,$5836,$1FF8
 DC.W $F82E,$083C,$C836,$0FF8,$77EE,$801C,$87D2,$07DC
 DC.W $F7EC,$001E,$C6D2,$06DC,$37CA,$4038,$46F2,$06F8
 DC.W $FFC8,$403B,$C6F3,$06F8,$1FD2,$4032,$46E2,$06F0
 DC.W $07EC,$2826,$2FCE,$0FE0,$1008,$2004,$300C,$0000
 DC.W $1F78,$1E98,$1FF8,$0000,$0000,$0000,$0000,$0000
;0001
 DC.W $0060,$0060,$0060,$0060,$02C0,$02C0,$02C0,$00C0
 DC.W $00C6,$0086,$0086,$0386,$022E,$000E,$000E,$05CE
 DC.W $001E,$001A,$001E,$07F8,$20B0,$303E,$303E,$1F7C
 DC.W $1C72,$207C,$2C6E,$0FFC,$9EB7,$20BF,$BA8B,$3BBC
 DC.W $1FE5,$A0ED,$B709,$37EC,$5FC5,$21DD,$7619,$37DC
 DC.W $5FCB,$41BA,$4E33,$0FB8,$0F92,$6070,$6662,$0670
 DC.W $77E8,$40EC,$700C,$00E0,$7C13,$2007,$7817,$0000
 DC.W $0594,$07BC,$07BC,$0000,$0040,$0260,$0260,$0000
;0002
 DC.W $0030,$0030,$0030,$0030,$0060,$0060,$0060,$00E0
 DC.W $0022,$0022,$0022,$01C2,$0D0E,$0416,$0C1E,$02E6
 DC.W $085C,$101C,$100C,$07BC,$3C3C,$203C,$241C,$07F8
 DC.W $3E7C,$2076,$2C32,$0DF4,$5FF0,$60F6,$6F46,$0FF4
 DC.W $DFE1,$00EC,$CB0D,$0BEC,$BFD1,$C0CC,$DF0D,$1FCC
 DC.W $4FE5,$019C,$4619,$079C,$678B,$617B,$6673,$0778
 DC.W $23F6,$10F4,$3006,$00F0,$08C0,$14CC,$1C0C,$00C0
 DC.W $0228,$0010,$0238,$0000,$01C0,$01C0,$01C0,$0000
;0003
 DC.W $0000,$0000,$0000,$0000,$03FC,$03FC,$03FC,$03FC
 DC.W $089C,$001C,$081C,$0F7C,$1800,$0000,$1800,$1FE0
 DC.W $1808,$0018,$1018,$17F0,$3890,$000E,$380E,$3F68
 DC.W $7FFE,$47FC,$6FFE,$2FFC,$FFFC,$0FFF,$D0FF,$1FFC
 DC.W $BFF2,$9FEF,$A00F,$3FEC,$0037,$A00C,$A00B,$200C
 DC.W $9FE4,$101A,$801E,$1018,$0F8A,$49FA,$4072,$09F8
 DC.W $6E34,$0DF0,$61C4,$0DF0,$03C8,$13C8,$1008,$03C0
 DC.W $0410,$0C30,$0C30,$0000,$0180,$0340,$03C0,$0000
;0004
 DC.W $0000,$0000,$0000,$0000,$009C,$001C,$001C,$037C
 DC.W $041C,$001C,$041C,$07FC,$0C84,$081C,$0C1C,$0770
 DC.W $1C86,$1018,$181E,$0B78,$2FFF,$13FE,$37FF,$17FE
 DC.W $2FFF,$77FF,$79FF,$1FFE,$4FF6,$5FEF,$500B,$1FEC
 DC.W $4015,$100E,$500B,$100C,$0FE6,$500D,$500B,$100C
 DC.W $DB86,$947F,$C47B,$147C,$0D8A,$2E78,$2272,$0E78
 DC.W $23E6,$33E2,$3006,$03E0,$1408,$0C04,$1C0C,$0000
 DC.W $02B0,$0370,$03F0,$0000,$0000,$0040,$0040,$0000
;0005
 DC.W $0000,$0000,$0000,$0000,$0200,$0000,$0200,$0380
 DC.W $0650,$0010,$0610,$07A0,$281E,$301C,$381E,$0FFC
 DC.W $790E,$601E,$783E,$1EFE,$3E10,$1E08,$2268,$3FE8
 DC.W $FF80,$9F8F,$C3FF,$1FF8,$07F4,$A7EE,$A1EE,$27E8
 DC.W $B376,$037C,$80FE,$03F8,$3920,$815E,$80DE,$01D8
 DC.W $9E84,$8078,$807C,$0078,$4B0C,$04F7,$44FF,$04F0
 DC.W $0008,$23CC,$23CC,$03C0,$1008,$1014,$101C,$0000
 DC.W $0620,$0750,$0770,$0000,$0100,$01C0,$01C0,$0000
;0006
 DC.W $0000,$0000,$0000,$0000,$0080,$0000,$0080,$00C0
 DC.W $0320,$0000,$0300,$03C0,$0448,$0008,$0408,$07B8
 DC.W $990E,$A00E,$A81E,$0EFC,$BC06,$240E,$A03E,$07FE
 DC.W $1617,$260F,$22EB,$27EF,$1B07,$631D,$63DB,$23DD
 DC.W $7DA4,$419E,$419A,$019C,$1EE8,$40DA,$40D2,$00D8
 DC.W $5C7A,$53FA,$43E2,$13F8,$0C30,$6BF2,$63C2,$0BF0
 DC.W $07E4,$17E0,$1004,$07E0,$200C,$0804,$280C,$0000
 DC.W $05D8,$0330,$07F8,$0000,$0000,$0000,$0000,$0000
;0007
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0180,$0000,$0180,$0180,$0F00,$0830,$0F30,$07F0
 DC.W $1C50,$0018,$1C18,$0FB8,$2918,$381C,$381C,$1EFC
 DC.W $1C1E,$6C0C,$646E,$0FEC,$9616,$460E,$C7EE,$07EE
 DC.W $5B1A,$0306,$43C6,$03C6,$59B2,$4188,$418A,$0188
 DC.W $4FC2,$00FA,$40FA,$00F8,$3364,$14F0,$34F4,$04F0
 DC.W $0808,$0BE4,$0BEC,$03E0,$0400,$0010,$0410,$0000
 DC.W $02C0,$0100,$03C0,$0000,$0000,$0000,$0000,$0000
;0008
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $07F0,$0000,$07F0,$07F0,$0410,$0C18,$0C18,$0FF8
 DC.W $0F7C,$1C1C,$1C18,$1C9C,$2C1E,$3C1C,$3C1A,$1FFC
 DC.W $5C1E,$0C1C,$4FFA,$0FFC,$0C1D,$5C1C,$5FF9,$1FFC
 DC.W $DC1C,$0C1C,$CFF8,$0FFC,$4FFA,$0C18,$4C1A,$0C18
 DC.W $6F0A,$20FA,$60F2,$00F8,$3432,$07F2,$33C2,$07F0
 DC.W $10C0,$01C4,$1104,$01C0,$0418,$1818,$1C18,$0000
 DC.W $02D0,$03A0,$03F0,$0000,$0000,$0020,$0020,$0000
;0009
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $00C0,$1200,$12C0,$01C0,$0070,$0C00,$0C70,$03E0
 DC.W $1638,$4000,$5038,$09F8,$1038,$3024,$303C,$1FF8
 DC.W $71B2,$F03E,$F83E,$7E7C,$5076,$E074,$EC62,$6FF4
 DC.W $90E6,$20EF,$A7CB,$27EC,$21C5,$99DC,$9B99,$1BDC
 DC.W $530A,$1F38,$4F32,$1F38,$2A14,$6CF6,$64E6,$0CF0
 DC.W $5766,$37EA,$708E,$07E0,$2808,$2008,$2808,$0000
 DC.W $0AA8,$0D68,$0FE8,$0000,$0040,$0440,$0440,$0000
;000A
 DC.W $0000,$0000,$0000,$0000,$0040,$0000,$0040,$01C0
 DC.W $0070,$1800,$1870,$03F0,$9B18,$0800,$9818,$0CF8
 DC.W $38B8,$383E,$3816,$1F7C,$78F8,$7076,$7436,$3774
 DC.W $38FB,$60F5,$6667,$27F4,$C4E0,$50EF,$D3CF,$13EC
 DC.W $15C4,$89DE,$899A,$09DC,$4386,$5F3C,$5F3A,$1F3C
 DC.W $4148,$4EBA,$4EB2,$0EB8,$7016,$77F6,$77E6,$07F0
 DC.W $01C8,$19C8,$1808,$01C0,$0A38,$0418,$0E38,$0000
 DC.W $0480,$0580,$0580,$0000,$0000,$0000,$0000,$0000
;000B
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0500,$0400,$0400,$06C0,$7810,$7800,$7810,$7FF0
 DC.W $747C,$7000,$7A1C,$739C,$383A,$C03E,$E706,$07FC
 DC.W $58F0,$20F6,$6726,$07F4,$BCE3,$80E6,$83E7,$03E4
 DC.W $3BC3,$43CF,$438F,$03CC,$5F89,$4F06,$4F07,$0F04
 DC.W $1FE3,$441F,$441F,$041C,$4E02,$20F8,$60FA,$00F8
 DC.W $3000,$46F2,$76F2,$06F0,$1008,$180C,$180C,$0000
 DC.W $0E90,$0570,$0FF0,$0000,$0100,$0010,$0110,$0000
;000C
 DC.W $0000,$0000,$0000,$0000,$1F80,$1F80,$1F80,$1F80
 DC.W $1C90,$1C00,$1C10,$1F70,$0C98,$0400,$0818,$0370
 DC.W $0C1C,$1002,$101E,$03FC,$7C9E,$2002,$600E,$036C
 DC.W $389D,$2002,$2017,$0376,$FFFC,$3FE3,$FFFB,$3FFA
 DC.W $3FFC,$7FF3,$7FCF,$3FFE,$0BFD,$53FB,$5007,$13FE
 DC.W $4810,$1009,$5009,$1008,$478A,$C878,$C872,$0878
 DC.W $70F2,$5370,$7302,$0370,$0806,$1806,$1806,$0000
 DC.W $0EDC,$097C,$0FFC,$0000,$0120,$01A0,$01A0,$0000
;000D
 DC.W $1F80,$1F80,$1F80,$1F80,$1F20,$1E00,$1E20,$1EE0
 DC.W $3530,$1800,$3C30,$02F0,$A434,$780C,$F81C,$0BD0
 DC.W $6D3E,$D004,$F02E,$12E8,$BFFA,$BFC4,$BFF6,$3FF4
 DC.W $3FFA,$BFC7,$BFBF,$3FFC,$9BFA,$A3F5,$A00F,$23FC
 DC.W $9BF9,$A3FE,$A007,$23FC,$0800,$F006,$F006,$3004
 DC.W $47C2,$1838,$583A,$1838,$03C0,$2C34,$2C34,$0C30
 DC.W $100C,$03CC,$13CC,$03C0,$0820,$0A38,$0A38,$0000
 DC.W $0740,$0780,$07C0,$0000,$0100,$0100,$0100,$0000
;000E
 DC.W $0100,$0100,$0100,$0100,$0380,$0380,$0380,$0380
 DC.W $0040,$0040,$0040,$01C0,$0040,$0000,$0000,$03A0
 DC.W $6090,$6800,$6810,$6F70,$723A,$7000,$703A,$7DF8
 DC.W $3C7E,$3803,$383F,$3BBC,$1EFE,$FE00,$EEDE,$7FDC
 DC.W $0FFC,$EE03,$E7EF,$6FEC,$B7FE,$0703,$83F7,$07F4
 DC.W $59F9,$C180,$C079,$01FC,$4CF9,$C2C2,$C23B,$02F8
 DC.W $2C22,$2304,$2306,$0300,$21C8,$03C0,$2208,$03C0
 DC.W $3800,$1838,$3838,$0000,$0EE0,$0390,$0FF0,$0000
;000F
 DC.W $0040,$0040,$0040,$0040,$00E0,$00E0,$00E0,$00E0
 DC.W $0010,$0010,$0010,$0070,$1010,$1018,$1018,$11F8
 DC.W $3828,$3808,$3808,$3FD8,$1904,$1806,$1806,$1EFC
 DC.W $2C0D,$1C02,$3C0F,$1FFE,$4C1D,$5C03,$5C1F,$1FFE
 DC.W $0E7E,$5603,$565D,$17DE,$CFFE,$9201,$D3EF,$13EE
 DC.W $27FE,$6901,$68E7,$09E6,$237E,$2481,$24F7,$04F6
 DC.W $C9FC,$D38F,$DA73,$03FC,$15FC,$1DF8,$1C04,$01F8
 DC.W $0000,$0210,$0210,$0000,$0060,$0590,$05F0,$0000

SHOTDAT:
 DC.W $0000,$0000,$0000,$6000,$0000,$6000,$6000,$9000
 DC.W $0000,$0000,$0000,$6000

MINEDATA:
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0700,$0000,$0000,$0700
 DC.W $0FE0,$0260,$02E0,$0F70,$00A8,$00A0,$00F8,$00A8
 DC.W $1FF8,$01F8,$05F8,$1FD8,$18A0,$0020,$07E0,$18A0
 DC.W $1FFC,$0008,$0B7C,$17F4,$0188,$0020,$0158,$0188
 DC.W $1FC4,$0020,$00EC,$1FC4,$0728,$0000,$00F8,$0728
 DC.W $0BF0,$0000,$0080,$0BF0,$03C0,$0000,$0000,$03C0
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0001
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0740,$0000,$0040,$0740
 DC.W $0760,$0060,$0560,$0770,$0F30,$0320,$0330,$0F30
 DC.W $1DF8,$03F8,$07F8,$1DD8,$0360,$0020,$03E0,$0360
 DC.W $1F68,$0088,$0BE8,$1760,$1FD8,$0020,$01D8,$1FD8
 DC.W $0604,$0000,$0004,$0604,$0F68,$0000,$0068,$0F68
 DC.W $06A0,$0080,$01E0,$0620,$03C0,$0000,$0000,$03C0
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0002
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0600,$0000,$0000,$0600
 DC.W $0FC0,$0140,$01C0,$0F50,$0938,$0120,$07F8,$0938
 DC.W $1DA0,$03A0,$07E0,$1D80,$13FC,$0030,$0FFC,$13FC
 DC.W $1E08,$0008,$0BF8,$1600,$1FC8,$0020,$01D8,$1FCC
 DC.W $19C4,$0020,$06EC,$19C4,$0F08,$0000,$0008,$0F08
 DC.W $0000,$0000,$0000,$0000,$03C0,$0000,$0000,$03C0
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

;SMASHDAT.ASM
;             SHIP SMASHER  1X1 5 SEQ.
;
   DATA
SMASHDATA:
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $300C,$1000,$200C,$200C,$1004,$1000,$0004,$0004
 DC.W $301C,$301C,$3004,$3004,$19A0,$1820,$0180,$0180
 DC.W $0BB0,$0AB0,$0190,$0190,$1F90,$1300,$1C90,$1C90
 DC.W $11F0,$11E0,$1050,$1050,$1FE0,$1460,$1B80,$1B80
 DC.W $043C,$0420,$001C,$001C,$300C,$1000,$200C,$200C
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0001
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $100C,$1000,$000C,$000C,$1004,$1000,$0004,$0004
 DC.W $201C,$201C,$2004,$2004,$19B0,$1830,$0180,$0180
 DC.W $0BA0,$0AA0,$0180,$0180,$1FF0,$1360,$1CD0,$1CD0
 DC.W $1E10,$1200,$1E10,$1E10,$07C0,$0440,$0380,$0380
 DC.W $3C3C,$1420,$281C,$281C,$2814,$0810,$2004,$2004
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0002
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $300C,$1000,$200C,$200C,$3008,$1000,$2008,$2008
 DC.W $181C,$181C,$1004,$1004,$11B0,$1030,$0180,$0180
 DC.W $1BB0,$1AB0,$0190,$0190,$0710,$0300,$0410,$0410
 DC.W $1DF0,$11E0,$1C50,$1C50,$0780,$0400,$0380,$0380
 DC.W $3C3C,$1420,$281C,$281C,$1810,$1810,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0003
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$7007,$0000,$6003,$7007
 DC.W $7007,$0000,$6003,$7007,$780F,$5005,$5005,$780F
 DC.W $380C,$0000,$0000,$380C,$1CDC,$1C14,$10C4,$10CC
 DC.W $0DD8,$0D58,$08C8,$08C8,$1DDC,$1D54,$108C,$108C
 DC.W $1FFC,$13B4,$1E6C,$1E6C,$1FFC,$1434,$1BCC,$1BCC
 DC.W $7FFF,$0030,$6FCB,$7FCF,$7C1F,$0410,$680B,$780F
 DC.W $780F,$0808,$6003,$7007,$7007,$0000,$6003,$7007
;0004
 DC.W $0000,$0000,$0000,$0000,$6003,$6003,$6003,$6003
 DC.W $6003,$6003,$6003,$6003,$6003,$6003,$6003,$6003
 DC.W $3242,$1220,$1262,$1002,$03B0,$02C0,$03F0,$0000
 DC.W $13E2,$1172,$13F2,$10C2,$00F0,$1250,$12F0,$00E0
 DC.W $0AE6,$3220,$3AA6,$08A4,$3A76,$0210,$3A56,$0A54
 DC.W $3B34,$1332,$3B36,$0B34,$2807,$2002,$2807,$0804
 DC.W $6807,$6003,$6807,$6807,$6AB7,$61A3,$6BB7,$6807
 DC.W $6287,$6223,$62A3,$6003,$6363,$63C3,$63E3,$6003
   END
