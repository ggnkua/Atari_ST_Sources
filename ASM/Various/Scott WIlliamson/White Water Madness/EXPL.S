;EXPL.ASM
;                   GENERIC EXPLOSION 1X1 5 SEQ.
;
  DATA
;0000
EXPL1:
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0100,$0100,$0100,$0100
 DC.W $0100,$0100,$0100,$0108,$0100,$0100,$05C0,$17D0
 DC.W $0240,$0000,$07C0,$0FE0,$03C0,$0180,$03E0,$07E0
 DC.W $1FF0,$1CF0,$07F0,$1FF0,$07F0,$0180,$07F0,$07F8
 DC.W $07E0,$06E0,$07C0,$07E0,$03E0,$0260,$05A0,$0FE0
 DC.W $1990,$1990,$1410,$1D90,$0000,$0000,$0000,$0100
 DC.W $0000,$0000,$0000,$0100,$0000,$0000,$0000,$0000
;0001
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0100,$0180,$0100,$0100,$0320,$0BB0
 DC.W $0180,$01A0,$09A0,$0FF0,$0198,$07F8,$07F8,$3FFC
 DC.W $1BF8,$1AF8,$1FF8,$3FF8,$0FE0,$0EF0,$0FF0,$1FFC
 DC.W $07E0,$18F0,$1FF0,$3FFC,$1FF8,$1C78,$1FF8,$3FFC
 DC.W $1BE0,$1CF0,$1FF0,$3FFC,$03C0,$0760,$3FEC,$3FFE
 DC.W $0660,$07E0,$07E0,$0FF8,$0020,$0120,$0720,$0FF0
 DC.W $0000,$0000,$0100,$0180,$0000,$0000,$0000,$0000
;0002
 DC.W $0000,$0000,$0000,$0000,$0100,$0100,$0F00,$0F80
 DC.W $0000,$02C0,$4FC0,$6FC0,$0200,$0C00,$9DC0,$FDC0
 DC.W $8E80,$EACA,$604E,$FBCE,$58C2,$60F7,$2737,$67FF
 DC.W $0880,$0090,$06F1,$07FF,$1071,$4049,$4C49,$4FCF
 DC.W $2012,$1005,$1665,$5FED,$1037,$0808,$0A48,$6FC8
 DC.W $006A,$1D00,$5F90,$7F94,$3588,$3820,$0A30,$3A70
 DC.W $3938,$2158,$0140,$27D8,$21C0,$2A20,$0A20,$3E38
 DC.W $1EE0,$1E10,$0010,$1E10,$0000,$0000,$0000,$0000
;0003
 DC.W $0E00,$0400,$0E00,$0E00,$6FD8,$0408,$2FD8,$2FD8
 DC.W $7FFC,$0200,$27FC,$27FC,$6E7C,$0004,$021C,$021C
 DC.W $27BC,$0318,$2798,$2798,$7FFC,$138C,$779C,$779C
 DC.W $7FFC,$108C,$339C,$339C,$6FBF,$200C,$208F,$208F
 DC.W $1FFF,$0065,$0A67,$0A67,$7FFF,$2233,$66F3,$66F3
 DC.W $FFF3,$2071,$E6F1,$E6F1,$FFF0,$1120,$3730,$3730
 DC.W $FFFE,$000E,$221E,$221E,$0F8E,$0080,$0086,$0086
 DC.W $070C,$0000,$0300,$0300,$0000,$0000,$0000,$0000
;0004
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $04E0,$0000,$00E0,$00E0,$0808,$0800,$0808,$0808
 DC.W $0000,$0000,$0000,$0000,$0008,$0000,$0008,$0008
 DC.W $2000,$0000,$2000,$2000,$0004,$0000,$0004,$0004
 DC.W $0000,$0000,$0000,$0000,$2004,$0000,$2004,$2004
 DC.W $2004,$0000,$0004,$0004,$3008,$0008,$0008,$0008
 DC.W $1400,$0000,$1400,$1400,$0BC0,$0080,$00C0,$00C0
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

;0000
 DC.W $C000,$C000,$C000,$C000,$C000,$C000,$C000,$C000
 END
