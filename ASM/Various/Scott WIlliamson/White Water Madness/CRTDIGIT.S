CHARH    = 7

  DATA
  ALIGN
FILESPEC DC.B '\ARTPROGS\DEGAS\PICTURES\WWMDIGIT.PI1',0
OUTFILE  DC.B '\ASSEMPRO\WWM\DIGITS.DAT',0
STRING   DC.B 27,'Y',20+32,32,'0 1 2 3 4 5 6 7 8 9',10,13
         DC.B                 '    SELECT 0-9:',0
  BSS
  ALIGN
SCREENA  DS.L 1         ; SCREEN BASE ADRESS
RES      DS.W 1         ; RESOLUTION
PALETTE  DS.W 16        ; PALETTE
HANDLE   DS.W 1         ; FILE HANDLE
OUTBUF   DS.B CHARH*4*16     ; OUTPUT BUFFER

  TEXT
  MOVE #2,-(SP)         ; FETCH SCREEN ADRESS
  TRAP #14
  ADDQ.L #2,SP
  MOVE.L D0,SCREENA

  MOVE #2,-(SP)         ; OPEN PIC FILE
  MOVE.L #FILESPEC,-(SP)
  MOVE #$3D,-(SP)
  TRAP #1
  ADD.L #8,SP
  MOVE D0,HANDLE

  MOVE.L #RES,-(SP)     ; READ RESOLUTION & PALETTE
  MOVE.L #17*2,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$3F,-(SP)
  TRAP #1
  ADD.L #12,SP

  MOVE.L #PALETTE,-(SP) ; CHANGE PALETTE
  MOVE #6,-(SP)
  TRAP #14
  ADDQ.L #6,SP

  MOVE #0,-(SP)       ; MAKE LOW RES
  MOVE.L #-1,-(SP)
  MOVE.L #-1,-(SP)
  MOVE #5,-(SP)
;  TRAP #14
  ADD.L #12,SP

  MOVE.L SCREENA,-(SP)  ; READ SCREEN DATA
  MOVE.L #32000,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$3F,-(SP)
  TRAP #1
  ADD.L #12,SP

  MOVE HANDLE,-(SP)     ; CLOSE FILE
  MOVE #$3E,-(SP)
  TRAP #1
  ADDQ.L #4,SP

  MOVE.L #STRING,-(SP)  ; PROMPT FOR SELECTION
  MOVE #9,-(SP)
  TRAP #1
  ADDQ.L #6,SP

  MOVE #1,-(SP)         ; CONIN
  TRAP #1
  ADDQ.L #2,SP
  SUB #'0',D0

  MOVE.L SCREENA,A0     ; FETCH SCREEN BASE ADRESS
  LSL #3,D0             ; ALIGN SELECTION ON VIDEO WORD
  ADD D0,A0             ; AND ADJUST POINTER
  LEA OUTBUF,A1         ; FETCH OUTPUT BUFFER ADRESS

  MOVE #CHARH*16-1,D0   ; LOOP FOR 16 CHARACTERS
COPYLOOP:
  MOVE.B 0(A0),(A1)+    ; ONLY TAKING THE DATA WE NEED (.B)
  MOVE.B 2(A0),(A1)+
  MOVE.B 4(A0),(A1)+
  MOVE.B 6(A0),(A1)+
  EOR.B #$FF,0(A0)      ; SHOW USER WHAT WAS SELECTED
  EOR.B #$FF,2(A0)
  EOR.B #$FF,4(A0)
  EOR.B #$FF,6(A0)
  ADD.L #160,A0
  DBRA D0,COPYLOOP

  MOVE #0,-(SP)         ; CREATE OUTPUT FILE
  MOVE.L #OUTFILE,-(SP)
  MOVE #$3C,-(SP)
  TRAP #1
  ADDQ.L #8,SP
  MOVE D0,HANDLE

  MOVE.L #OUTBUF,-(SP)  ; WRITE FILE
  MOVE.L #CHARH*16*4,-(SP)
  MOVE HANDLE,-(SP)
  MOVE #$40,-(SP)
  TRAP #1
  ADD.L #12,SP

  MOVE HANDLE,-(SP)     ; CLOSE FILE
  MOVE #$3E,-(SP)
  TRAP #1
  ADDQ.L #4,SP

  MOVE #1,-(SP)         ; MAKE MED RES
  MOVE.L #-1,-(SP)
  MOVE.L #-1,-(SP)
  MOVE #5,-(SP)
  TRAP #14
  ADD.L #12,SP

  CLR -(SP)             ; TERM
  TRAP #1

  END
