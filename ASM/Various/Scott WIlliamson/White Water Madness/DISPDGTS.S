DIGITLEN = 7            ; HEIGHT OF DIGIT

  DATA
DIGITDAT:
  IBYTES '\ASSEMPRO\WWM\DIGITS.DAT',280
PALETTE:
  IBYTES '\ASSEMPRO\WWM\PALETTE.DAT',32
DIG:
  IBYTES '\ASSEMPRO\WWM\DIGITS.B',446
ONE:
  DC.L 1

  BSS
  ALIGN
SCREENA  DS.L 1         ; SCREEN ADRESS POINTER
COUNTER  DS.L 1

  TEXT
  MOVE #2,-(SP)         ; FETCH SCREEN BASE ADRESS
  TRAP #14
  ADDQ.L #2,SP
  MOVE.L D0,SCREENA

  MOVE #0,-(SP)         ; LOW RES
  MOVE.L #-1,-(SP)
  MOVE.L #-1,-(SP)
  MOVE #5,-(SP)
  TRAP #14
  ADD.L #12,SP

  MOVE.L #PALETTE,-(SP)
  MOVE #6,-(SP)
  TRAP #14
  ADDQ.L #2,SP

  MOVE.L #0,COUNTER     ; CLEAR COUNTER

TESTLOOP:
  MOVE.L COUNTER,D0
  MOVE.L SCREENA,A0     ; GET SCREEN ADRESS
  JSR DIG         ; DISP #

  LEA COUNTER+4,A0      ; INCREMENT COUNTER
  LEA ONE+4,A1
  MOVE #0,CCR
  ABCD.B -(A1),-(A0)
  ABCD.B -(A1),-(A0)
  ABCD.B -(A1),-(A0)
  ABCD.B -(A1),-(A0)

;  MOVE #37,-(SP)        ; WVBL
;  TRAP #14
;  ADDQ.L #2,SP
  JMP TESTLOOP          ; AND KEEP LOOPING

DISPDGTS:               ; DISPLAYS THE 8 DIGIT BCD # IN D0 AT (A0)
  LEA DIGITDAT,A1       ; A1 POINTS TO DIGIT CHARS

  MOVE #4-1,D6          ; LOOP THRU 8 DIGITS AS 4 DIGIT PAIRS
DRAWNUMBER:
  ROL.L #4,D0           ; PUT MSB IN LSB OF D0
  MOVE.B D0,D1          ; GET LOWER 2 DIGITS
  AND #$F,D1            ; ISOLATE LOWEST DIGIT
  MULU #DIGITLEN*4,D1   ; MAKE INDEX INTO DIGIT DATA

  CLR D2                ; CLEAR VIDEO INDEX D2
  MOVE #DIGITLEN-1,D7   ; LOOP DIGITLEN TIMES
DRAWDIGIT1:
  MOVE.B 0(A1,D1.W),0(A0,D2.W) ; COPY DIGIT BYTE
  MOVE.B 1(A1,D1.W),2(A0,D2.W)
  MOVE.B 2(A1,D1.W),4(A0,D2.W)
  MOVE.B 3(A1,D1.W),6(A0,D2.W)
  ADD #160,D2           ; UPDATE VIDEO INDEX
  ADD #4,D1             ; UPDATE DIGIT LOOKUP INDEX
  DBRA D7,DRAWDIGIT1

  ROL.L #4,D0           ; PUT MSB IN LSB OF D0
  MOVE.B D0,D1          ; GET LOWER 2 DIGITS
  AND #$F,D1            ; ISOLATE LOWEST DIGIT
  MULU #DIGITLEN*4,D1   ; MAKE INDEX INTO DIGIT DATA

  CLR D2                ; CLEAR VIDEO INDEX D2
  MOVE #DIGITLEN-1,D7   ; LOOP DIGITLEN TIMES
DRAWDIGIT2:
  MOVE.B 0(A1,D1.W),1(A0,D2.W) ; COPY DIGIT BYTE
  MOVE.B 1(A1,D1.W),3(A0,D2.W)
  MOVE.B 2(A1,D1.W),5(A0,D2.W)
  MOVE.B 3(A1,D1.W),7(A0,D2.W)
  ADD #160,D2           ; UPDATE VIDEO INDEX
  ADD #4,D1             ; UPDATE DIGIT LOOKUP INDEX
  DBRA D7,DRAWDIGIT2
  ADD #8,A0
  DBRA D6,DRAWNUMBER
  RTS

  END
