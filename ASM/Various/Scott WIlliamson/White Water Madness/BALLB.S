;BALLB.ASM
;BALL BLASTER 1X1 16 SEQ.
;
 DATA
BALLB:
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $00A0,$0000,$0000,$0000,$0968,$0000,$0000,$0000
 DC.W $0444,$0000,$0000,$0000,$0A90,$0000,$0000,$0000
 DC.W $056C,$0000,$0000,$0000,$1A90,$0000,$0000,$0000
 DC.W $0548,$0000,$0000,$0000,$0AA0,$0000,$0000,$0000
 DC.W $0150,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0001
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0100,$0000,$0000,$0000
 DC.W $03E0,$0000,$0000,$0000,$0D58,$0000,$0000,$0000
 DC.W $17F8,$0000,$0000,$0000,$1F6C,$0000,$0000,$0000
 DC.W $0D98,$0000,$0000,$0000,$17FC,$0000,$0000,$0000
 DC.W $1AA8,$0000,$0000,$0000,$07F8,$0000,$0000,$0000
 DC.W $0260,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0002
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $03E0,$0000,$0000,$0000,$0FF8,$0000,$0000,$0000
 DC.W $1FFC,$0000,$0000,$0000,$1FFC,$0000,$0000,$0000
 DC.W $1FFC,$0000,$0000,$0000,$1FFC,$0000,$0000,$0000
 DC.W $1FFC,$0000,$0000,$0000,$07F8,$0000,$0000,$0000
 DC.W $03E0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0003
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $03E0,$0000,$0000,$0000,$0FF8,$0000,$0000,$0000
 DC.W $1FFC,$0000,$0000,$0000,$1FFC,$0000,$0000,$0000
 DC.W $1FFC,$0000,$0000,$0000,$1BCC,$0430,$0000,$0430
 DC.W $0D60,$121C,$0160,$1F7C,$0F78,$0020,$0778,$0F78
 DC.W $03E0,$0020,$0360,$0360,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0004
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $03E0,$0000,$0000,$0000,$0FF8,$0000,$0000,$0000
 DC.W $0FFC,$0000,$0000,$0000,$1D84,$0278,$0000,$03F8
 DC.W $17B4,$0808,$01B4,$0FBC,$0FBC,$1010,$03BC,$1FBC
 DC.W $1FFC,$0018,$05BC,$07BC,$07F8,$0000,$05B8,$07B8
 DC.W $03E0,$0000,$02A0,$03A0,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0005
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $03E0,$0000,$0000,$0000,$0FF8,$0000,$0000,$0000
 DC.W $1BCC,$0430,$0000,$0430,$0D60,$121C,$0160,$1F7C
 DC.W $1F78,$0024,$0778,$1F7C,$1FF8,$0034,$0B78,$1F7C
 DC.W $1FF8,$0004,$0B78,$1F7C,$0BF0,$0408,$0370,$0F78
 DC.W $0360,$0000,$0340,$0340,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0006
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $03E0,$0000,$0000,$0000,$0B08,$04F0,$0000,$07F0
 DC.W $0F68,$1014,$0368,$1F7C,$1F78,$2026,$0778,$3F7E
 DC.W $1FFC,$0030,$0B78,$0F78,$0FF8,$0000,$0B78,$0F78
 DC.W $0FF8,$0000,$0570,$0770,$0370,$0000,$0370,$0370
 DC.W $0000,$03E0,$0000,$03E0,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0007
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0430,$0000,$0430
 DC.W $0D60,$121C,$0160,$1F7C,$1F78,$2026,$0778,$3F7E
 DC.W $1FF8,$2036,$0B78,$3F7E,$1FF8,$6007,$0B78,$7F7F
 DC.W $1BF0,$240E,$1370,$3F7E,$0F60,$301E,$0B40,$3B5E
 DC.W $37E6,$0818,$0000,$0818,$180C,$0410,$0000,$0410
 DC.W $0C18,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0008
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0010,$07E0,$0000,$07E0,$0DF0,$1200,$0060,$1F60
 DC.W $1FF0,$2020,$0670,$3F70,$1FF8,$2036,$0A78,$3F7E
 DC.W $1EFD,$6103,$0A7D,$7F7F,$00F4,$070A,$0074,$077E
 DC.W $04C8,$0336,$0048,$037E,$073E,$00C0,$0738,$07F8
 DC.W $006E,$0790,$0060,$07F0,$07F8,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;0009
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0300,$04F0,$0000,$07F0,$0F68,$1014,$0368,$1F7C
 DC.W $1F78,$2026,$0778,$3F7E,$3FFE,$0030,$0B78,$0F78
 DC.W $0FF8,$0000,$0B78,$0F78,$0FF8,$0000,$0570,$0770
 DC.W $0770,$380E,$0370,$3F7E,$2002,$1FFC,$0000,$1FFC
 DC.W $1004,$0FF8,$0000,$0FF8,$0FF8,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;000A
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0400,$03F0,$0000,$03F0,$0468,$0314,$0068,$037C
 DC.W $067A,$2126,$067A,$277E,$1E78,$2136,$0A78,$3F7E
 DC.W $1E7D,$6103,$0A7D,$7F7F,$187D,$2702,$1060,$3F63
 DC.W $1826,$2700,$1800,$3F00,$3700,$08C0,$0700,$0FC0
 DC.W $3800,$07C0,$0000,$07C0,$0FE0,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;000B
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0430,$0000,$0430,$0D60,$121C,$0060,$1F7C
 DC.W $1F7A,$2026,$067A,$3F7E,$1FF8,$2036,$0A78,$3F7E
 DC.W $1EF9,$6107,$0A79,$7F7F,$18F0,$270E,$1070,$3F7E
 DC.W $0860,$371E,$0840,$3F5E,$37E6,$0818,$0400,$0C18
 DC.W $180C,$0410,$0000,$0410,$0C18,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;000C
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0300,$04F0,$0000,$07F0,$0F68,$1014,$0368,$1F7C
 DC.W $1F78,$2026,$0778,$3F7E,$3FFE,$0030,$0B78,$0F78
 DC.W $0FF8,$0000,$0B78,$0F78,$0FF8,$0000,$0570,$0770
 DC.W $0770,$380E,$0370,$3F7E,$2002,$1FFC,$0000,$1FFC
 DC.W $1004,$0FF8,$0000,$0FF8,$0FF8,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;000D
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0300,$04F0,$0000,$07F0,$0F68,$1014,$0228,$1E3C
 DC.W $1F78,$2026,$0638,$3E3E,$3FFE,$0030,$0A38,$0E38
 DC.W $0FF8,$0000,$0A38,$0E38,$0FF8,$0000,$0430,$0630
 DC.W $0770,$380E,$0370,$3F7E,$2002,$1FFC,$0000,$1FFC
 DC.W $1004,$0FF8,$0000,$0FF8,$0FF8,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;000E
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0430,$0000,$0430,$0D60,$121C,$0020,$1E3C
 DC.W $1F78,$2006,$0418,$3C1E,$1FF8,$2016,$0818,$3C1E
 DC.W $1FF8,$6007,$0818,$7C1F,$1BF0,$240E,$1230,$3E3E
 DC.W $0FE0,$301E,$0B40,$3B5E,$37E6,$0818,$0000,$0818
 DC.W $180C,$0410,$0000,$0410,$0C18,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
;000F
 DC.W $0000,$0000,$0000,$0000,$6000,$6000,$6000,$6000
 DC.W $0003,$0003,$0003,$0003,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$1800,$1800,$1800,$1800
 DC.W $0018,$0018,$0018,$0018,$0000,$0000,$0000,$0000
 DC.W $0300,$0300,$0300,$0300,$0000,$0000,$0000,$0000
 DC.W $0060,$0060,$0060,$0060,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0060,$0060,$0060,$0060
 DC.W $0300,$0300,$0300,$0300,$0000,$0000,$0000,$0000
;EXPL.ASM
;                   GENERIC EXPLOSION 1X1 5 SEQ.
;
;0000
EXPL1:
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0100,$0100,$0100,$0100
 DC.W $0100,$0100,$0100,$0108,$0100,$0100,$05C0,$17D0
 DC.W $0240,$0000,$07C0,$0FE0,$03C0,$0180,$03E0,$07E0
 DC.W $1FF0,$1CF0,$07F0,$1FF0,$07F0,$0180,$07F0,$07F8
 DC.W $07E0,$06E0,$07C0,$07E0,$03E0,$0260,$05A0,$0FE0
 DC.W $1990,$1990,$1410,$1D90,$0000,$0000,$0000,$0100
 DC.W $0000,$0000,$0000,$0100,$0000,$0000,$0000,$0000
;0001
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0100,$0180,$0100,$0100,$0320,$0BB0
 DC.W $0180,$01A0,$09A0,$0FF0,$0198,$07F8,$07F8,$3FFC
 DC.W $1BF8,$1AF8,$1FF8,$3FF8,$0FE0,$0EF0,$0FF0,$1FFC
 DC.W $07E0,$18F0,$1FF0,$3FFC,$1FF8,$1C78,$1FF8,$3FFC
 DC.W $1BE0,$1CF0,$1FF0,$3FFC,$03C0,$0760,$3FEC,$3FFE
 DC.W $0660,$07E0,$07E0,$0FF8,$0020,$0120,$0720,$0FF0
 DC.W $0000,$0000,$0100,$0180,$0000,$0000,$0000,$0000
;0002
 DC.W $0000,$0000,$0000,$0000,$0100,$0100,$0F00,$0F80
 DC.W $0000,$02C0,$4FC0,$6FC0,$0200,$0C00,$9DC0,$FDC0
 DC.W $8E80,$EACA,$604E,$FBCE,$58C2,$60F7,$2737,$67FF
 DC.W $0880,$0090,$06F1,$07FF,$1071,$4049,$4C49,$4FCF
 DC.W $2012,$1005,$1665,$5FED,$1037,$0808,$0A48,$6FC8
 DC.W $006A,$1D00,$5F90,$7F94,$3588,$3820,$0A30,$3A70
 DC.W $3938,$2158,$0140,$27D8,$21C0,$2A20,$0A20,$3E38
 DC.W $1EE0,$1E10,$0010,$1E10,$0000,$0000,$0000,$0000
;0003
 DC.W $0E00,$0400,$0E00,$0E00,$6FD8,$0408,$2FD8,$2FD8
 DC.W $7FFC,$0200,$27FC,$27FC,$6E7C,$0004,$021C,$021C
 DC.W $27BC,$0318,$2798,$2798,$7FFC,$138C,$779C,$779C
 DC.W $7FFC,$108C,$339C,$339C,$6FBF,$200C,$208F,$208F
 DC.W $1FFF,$0065,$0A67,$0A67,$7FFF,$2233,$66F3,$66F3
 DC.W $FFF3,$2071,$E6F1,$E6F1,$FFF0,$1120,$3730,$3730
 DC.W $FFFE,$000E,$221E,$221E,$0F8E,$0080,$0086,$0086
 DC.W $070C,$0000,$0300,$0300,$0000,$0000,$0000,$0000
;0004
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $04E0,$0000,$00E0,$00E0,$0808,$0800,$0808,$0808
 DC.W $0000,$0000,$0000,$0000,$0008,$0000,$0008,$0008
 DC.W $2000,$0000,$2000,$2000,$0004,$0000,$0004,$0004
 DC.W $0000,$0000,$0000,$0000,$2004,$0000,$2004,$2004
 DC.W $2004,$0000,$0004,$0004,$3008,$0008,$0008,$0008
 DC.W $1400,$0000,$1400,$1400,$0BC0,$0080,$00C0,$00C0
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

;
;FOUNT.ASM
;FOUNTAIN SPARKLE 1X0 1 SEQ.
;
FOUNT1:
;0000
 DC.W $C000,$C000,$C000,$C000,$C000,$C000,$C000,$C000

 END
