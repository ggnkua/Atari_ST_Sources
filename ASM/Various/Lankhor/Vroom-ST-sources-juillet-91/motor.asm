       TTL      MOTOR TABLES 20 Cycles - V15 - 22 Jun 91

       XDEF     GVVTBL,GVNTBL,GNNTBL,GDNTBL,GAUTBL,MOMTBL

GVVTBL
       DC.W    14280
       DC.W    18870
       DC.W    25041
       DC.W    31451
       DC.W    36440
       DC.W    45550
GVNTBL
       DC.W    18944
       DC.W    14336
       DC.W    10803
       DC.W    8601
       DC.W    7424
       DC.W    5939
GNNTBL
       DC.W    339
       DC.W    194
       DC.W    110
       DC.W    70
       DC.W    52
       DC.W    33
GDNTBL
       DC.W    650
       DC.W    372
       DC.W    211
       DC.W    134
       DC.W    99
       DC.W    63
GAUTBL
       DC.W    0
       DC.W    120
       DC.W    105
       DC.W    195
       DC.W    180
       DC.W    270
       DC.W    255
       DC.W    345
       DC.W    315
       DC.W    405
       DC.W    360
       DC.W    500
 
MOMTBL
       DC.W     0     0 Rpm
       DC.W     1     16 Rpm
       DC.W     3     32 Rpm
       DC.W     4     48 Rpm
       DC.W     6     64 Rpm
       DC.W     7     80 Rpm
       DC.W     9     96 Rpm
       DC.W     10     112 Rpm
       DC.W     12     128 Rpm
       DC.W     13     144 Rpm
       DC.W     15     160 Rpm
       DC.W     16     176 Rpm
       DC.W     18     192 Rpm
       DC.W     20     208 Rpm
       DC.W     21     224 Rpm
       DC.W     23     240 Rpm
       DC.W     24     256 Rpm
       DC.W     26     272 Rpm
       DC.W     27     288 Rpm
       DC.W     29     304 Rpm
       DC.W     30     320 Rpm
       DC.W     32     336 Rpm
       DC.W     33     352 Rpm
       DC.W     35     368 Rpm
       DC.W     36     384 Rpm
       DC.W     38     400 Rpm
       DC.W     39     416 Rpm
       DC.W     41     432 Rpm
       DC.W     42     448 Rpm
       DC.W     44     464 Rpm
       DC.W     45     480 Rpm
       DC.W     47     496 Rpm
       DC.W     48     512 Rpm
       DC.W     50     528 Rpm
       DC.W     51     544 Rpm
       DC.W     53     560 Rpm
       DC.W     54     576 Rpm
       DC.W     56     592 Rpm
       DC.W     57     608 Rpm
       DC.W     58     624 Rpm
       DC.W     60     640 Rpm
       DC.W     61     656 Rpm
       DC.W     63     672 Rpm
       DC.W     64     688 Rpm
       DC.W     66     704 Rpm
       DC.W     67     720 Rpm
       DC.W     69     736 Rpm
       DC.W     70     752 Rpm
       DC.W     72     768 Rpm
       DC.W     73     784 Rpm
       DC.W     74     800 Rpm
       DC.W     76     816 Rpm
       DC.W     77     832 Rpm
       DC.W     79     848 Rpm
       DC.W     80     864 Rpm
       DC.W     82     880 Rpm
       DC.W     83     896 Rpm
       DC.W     85     912 Rpm
       DC.W     86     928 Rpm
       DC.W     87     944 Rpm
       DC.W     89     960 Rpm
       DC.W     90     976 Rpm
       DC.W     92     992 Rpm
       DC.W     93     1008 Rpm
       DC.W     94     1024 Rpm
       DC.W     96     1040 Rpm
       DC.W     97     1056 Rpm
       DC.W     99     1072 Rpm
       DC.W     100     1088 Rpm
       DC.W     102     1104 Rpm
       DC.W     103     1120 Rpm
       DC.W     104     1136 Rpm
       DC.W     106     1152 Rpm
       DC.W     107     1168 Rpm
       DC.W     108     1184 Rpm
       DC.W     110     1200 Rpm
       DC.W     111     1216 Rpm
       DC.W     113     1232 Rpm
       DC.W     114     1248 Rpm
       DC.W     115     1264 Rpm
       DC.W     117     1280 Rpm
       DC.W     118     1296 Rpm
       DC.W     120     1312 Rpm
       DC.W     121     1328 Rpm
       DC.W     122     1344 Rpm
       DC.W     124     1360 Rpm
       DC.W     125     1376 Rpm
       DC.W     126     1392 Rpm
       DC.W     128     1408 Rpm
       DC.W     129     1424 Rpm
       DC.W     130     1440 Rpm
       DC.W     132     1456 Rpm
       DC.W     133     1472 Rpm
       DC.W     134     1488 Rpm
       DC.W     136     1504 Rpm
       DC.W     137     1520 Rpm
       DC.W     138     1536 Rpm
       DC.W     140     1552 Rpm
       DC.W     141     1568 Rpm
       DC.W     142     1584 Rpm
       DC.W     144     1600 Rpm
       DC.W     145     1616 Rpm
       DC.W     146     1632 Rpm
       DC.W     148     1648 Rpm
       DC.W     149     1664 Rpm
       DC.W     150     1680 Rpm
       DC.W     152     1696 Rpm
       DC.W     153     1712 Rpm
       DC.W     154     1728 Rpm
       DC.W     156     1744 Rpm
       DC.W     157     1760 Rpm
       DC.W     158     1776 Rpm
       DC.W     160     1792 Rpm
       DC.W     161     1808 Rpm
       DC.W     162     1824 Rpm
       DC.W     164     1840 Rpm
       DC.W     165     1856 Rpm
       DC.W     166     1872 Rpm
       DC.W     167     1888 Rpm
       DC.W     169     1904 Rpm
       DC.W     170     1920 Rpm
       DC.W     171     1936 Rpm
       DC.W     173     1952 Rpm
       DC.W     174     1968 Rpm
       DC.W     175     1984 Rpm
       DC.W     176     2000 Rpm
       DC.W     178     2016 Rpm
       DC.W     179     2032 Rpm
       DC.W     180     2048 Rpm
       DC.W     181     2064 Rpm
       DC.W     183     2080 Rpm
       DC.W     184     2096 Rpm
       DC.W     185     2112 Rpm
       DC.W     186     2128 Rpm
       DC.W     188     2144 Rpm
       DC.W     189     2160 Rpm
       DC.W     190     2176 Rpm
       DC.W     191     2192 Rpm
       DC.W     193     2208 Rpm
       DC.W     194     2224 Rpm
       DC.W     195     2240 Rpm
       DC.W     196     2256 Rpm
       DC.W     198     2272 Rpm
       DC.W     199     2288 Rpm
       DC.W     200     2304 Rpm
       DC.W     201     2320 Rpm
       DC.W     203     2336 Rpm
       DC.W     204     2352 Rpm
       DC.W     205     2368 Rpm
       DC.W     206     2384 Rpm
       DC.W     207     2400 Rpm
       DC.W     209     2416 Rpm
       DC.W     210     2432 Rpm
       DC.W     211     2448 Rpm
       DC.W     212     2464 Rpm
       DC.W     214     2480 Rpm
       DC.W     215     2496 Rpm
       DC.W     216     2512 Rpm
       DC.W     217     2528 Rpm
       DC.W     218     2544 Rpm
       DC.W     220     2560 Rpm
       DC.W     221     2576 Rpm
       DC.W     222     2592 Rpm
       DC.W     223     2608 Rpm
       DC.W     224     2624 Rpm
       DC.W     225     2640 Rpm
       DC.W     227     2656 Rpm
       DC.W     228     2672 Rpm
       DC.W     229     2688 Rpm
       DC.W     230     2704 Rpm
       DC.W     231     2720 Rpm
       DC.W     233     2736 Rpm
       DC.W     234     2752 Rpm
       DC.W     235     2768 Rpm
       DC.W     236     2784 Rpm
       DC.W     237     2800 Rpm
       DC.W     238     2816 Rpm
       DC.W     240     2832 Rpm
       DC.W     241     2848 Rpm
       DC.W     242     2864 Rpm
       DC.W     243     2880 Rpm
       DC.W     244     2896 Rpm
       DC.W     245     2912 Rpm
       DC.W     246     2928 Rpm
       DC.W     248     2944 Rpm
       DC.W     249     2960 Rpm
       DC.W     250     2976 Rpm
       DC.W     251     2992 Rpm
       DC.W     252     3008 Rpm
       DC.W     253     3024 Rpm
       DC.W     254     3040 Rpm
       DC.W     255     3056 Rpm
       DC.W     257     3072 Rpm
       DC.W     258     3088 Rpm
       DC.W     259     3104 Rpm
       DC.W     260     3120 Rpm
       DC.W     261     3136 Rpm
       DC.W     262     3152 Rpm
       DC.W     263     3168 Rpm
       DC.W     264     3184 Rpm
       DC.W     265     3200 Rpm
       DC.W     267     3216 Rpm
       DC.W     268     3232 Rpm
       DC.W     269     3248 Rpm
       DC.W     270     3264 Rpm
       DC.W     271     3280 Rpm
       DC.W     272     3296 Rpm
       DC.W     273     3312 Rpm
       DC.W     274     3328 Rpm
       DC.W     275     3344 Rpm
       DC.W     276     3360 Rpm
       DC.W     277     3376 Rpm
       DC.W     279     3392 Rpm
       DC.W     280     3408 Rpm
       DC.W     281     3424 Rpm
       DC.W     282     3440 Rpm
       DC.W     283     3456 Rpm
       DC.W     284     3472 Rpm
       DC.W     285     3488 Rpm
       DC.W     286     3504 Rpm
       DC.W     287     3520 Rpm
       DC.W     288     3536 Rpm
       DC.W     289     3552 Rpm
       DC.W     290     3568 Rpm
       DC.W     291     3584 Rpm
       DC.W     292     3600 Rpm
       DC.W     293     3616 Rpm
       DC.W     294     3632 Rpm
       DC.W     296     3648 Rpm
       DC.W     297     3664 Rpm
       DC.W     298     3680 Rpm
       DC.W     299     3696 Rpm
       DC.W     300     3712 Rpm
       DC.W     301     3728 Rpm
       DC.W     302     3744 Rpm
       DC.W     303     3760 Rpm
       DC.W     304     3776 Rpm
       DC.W     305     3792 Rpm
       DC.W     306     3808 Rpm
       DC.W     307     3824 Rpm
       DC.W     308     3840 Rpm
       DC.W     309     3856 Rpm
       DC.W     310     3872 Rpm
       DC.W     311     3888 Rpm
       DC.W     312     3904 Rpm
       DC.W     313     3920 Rpm
       DC.W     314     3936 Rpm
       DC.W     315     3952 Rpm
       DC.W     316     3968 Rpm
       DC.W     317     3984 Rpm
       DC.W     318     4000 Rpm
       DC.W     319     4016 Rpm
       DC.W     320     4032 Rpm
       DC.W     321     4048 Rpm
       DC.W     322     4064 Rpm
       DC.W     323     4080 Rpm
       DC.W     324     4096 Rpm
       DC.W     325     4112 Rpm
       DC.W     326     4128 Rpm
       DC.W     327     4144 Rpm
       DC.W     328     4160 Rpm
       DC.W     329     4176 Rpm
       DC.W     330     4192 Rpm
       DC.W     331     4208 Rpm
       DC.W     331     4224 Rpm
       DC.W     332     4240 Rpm
       DC.W     333     4256 Rpm
       DC.W     334     4272 Rpm
       DC.W     335     4288 Rpm
       DC.W     336     4304 Rpm
       DC.W     337     4320 Rpm
       DC.W     338     4336 Rpm
       DC.W     339     4352 Rpm
       DC.W     340     4368 Rpm
       DC.W     341     4384 Rpm
       DC.W     342     4400 Rpm
       DC.W     343     4416 Rpm
       DC.W     344     4432 Rpm
       DC.W     345     4448 Rpm
       DC.W     346     4464 Rpm
       DC.W     347     4480 Rpm
       DC.W     347     4496 Rpm
       DC.W     348     4512 Rpm
       DC.W     349     4528 Rpm
       DC.W     350     4544 Rpm
       DC.W     351     4560 Rpm
       DC.W     352     4576 Rpm
       DC.W     353     4592 Rpm
       DC.W     354     4608 Rpm
       DC.W     355     4624 Rpm
       DC.W     356     4640 Rpm
       DC.W     357     4656 Rpm
       DC.W     357     4672 Rpm
       DC.W     358     4688 Rpm
       DC.W     359     4704 Rpm
       DC.W     360     4720 Rpm
       DC.W     361     4736 Rpm
       DC.W     362     4752 Rpm
       DC.W     363     4768 Rpm
       DC.W     364     4784 Rpm
       DC.W     365     4800 Rpm
       DC.W     365     4816 Rpm
       DC.W     366     4832 Rpm
       DC.W     367     4848 Rpm
       DC.W     368     4864 Rpm
       DC.W     369     4880 Rpm
       DC.W     370     4896 Rpm
       DC.W     371     4912 Rpm
       DC.W     371     4928 Rpm
       DC.W     372     4944 Rpm
       DC.W     373     4960 Rpm
       DC.W     374     4976 Rpm
       DC.W     375     4992 Rpm
       DC.W     376     5008 Rpm
       DC.W     377     5024 Rpm
       DC.W     377     5040 Rpm
       DC.W     378     5056 Rpm
       DC.W     379     5072 Rpm
       DC.W     380     5088 Rpm
       DC.W     381     5104 Rpm
       DC.W     382     5120 Rpm
       DC.W     382     5136 Rpm
       DC.W     383     5152 Rpm
       DC.W     384     5168 Rpm
       DC.W     385     5184 Rpm
       DC.W     386     5200 Rpm
       DC.W     387     5216 Rpm
       DC.W     387     5232 Rpm
       DC.W     388     5248 Rpm
       DC.W     389     5264 Rpm
       DC.W     390     5280 Rpm
       DC.W     391     5296 Rpm
       DC.W     391     5312 Rpm
       DC.W     392     5328 Rpm
       DC.W     393     5344 Rpm
       DC.W     394     5360 Rpm
       DC.W     395     5376 Rpm
       DC.W     395     5392 Rpm
       DC.W     396     5408 Rpm
       DC.W     397     5424 Rpm
       DC.W     398     5440 Rpm
       DC.W     399     5456 Rpm
       DC.W     399     5472 Rpm
       DC.W     400     5488 Rpm
       DC.W     401     5504 Rpm
       DC.W     402     5520 Rpm
       DC.W     402     5536 Rpm
       DC.W     403     5552 Rpm
       DC.W     404     5568 Rpm
       DC.W     405     5584 Rpm
       DC.W     406     5600 Rpm
       DC.W     406     5616 Rpm
       DC.W     407     5632 Rpm
       DC.W     408     5648 Rpm
       DC.W     409     5664 Rpm
       DC.W     409     5680 Rpm
       DC.W     410     5696 Rpm
       DC.W     411     5712 Rpm
       DC.W     412     5728 Rpm
       DC.W     412     5744 Rpm
       DC.W     413     5760 Rpm
       DC.W     414     5776 Rpm
       DC.W     415     5792 Rpm
       DC.W     415     5808 Rpm
       DC.W     416     5824 Rpm
       DC.W     417     5840 Rpm
       DC.W     418     5856 Rpm
       DC.W     418     5872 Rpm
       DC.W     419     5888 Rpm
       DC.W     420     5904 Rpm
       DC.W     420     5920 Rpm
       DC.W     421     5936 Rpm
       DC.W     422     5952 Rpm
       DC.W     423     5968 Rpm
       DC.W     423     5984 Rpm
       DC.W     424     6000 Rpm
       DC.W     425     6016 Rpm
       DC.W     425     6032 Rpm
       DC.W     426     6048 Rpm
       DC.W     427     6064 Rpm
       DC.W     427     6080 Rpm
       DC.W     428     6096 Rpm
       DC.W     429     6112 Rpm
       DC.W     430     6128 Rpm
       DC.W     430     6144 Rpm
       DC.W     431     6160 Rpm
       DC.W     432     6176 Rpm
       DC.W     432     6192 Rpm
       DC.W     433     6208 Rpm
       DC.W     434     6224 Rpm
       DC.W     434     6240 Rpm
       DC.W     435     6256 Rpm
       DC.W     436     6272 Rpm
       DC.W     436     6288 Rpm
       DC.W     437     6304 Rpm
       DC.W     438     6320 Rpm
       DC.W     438     6336 Rpm
       DC.W     439     6352 Rpm
       DC.W     440     6368 Rpm
       DC.W     440     6384 Rpm
       DC.W     441     6400 Rpm
       DC.W     442     6416 Rpm
       DC.W     442     6432 Rpm
       DC.W     443     6448 Rpm
       DC.W     444     6464 Rpm
       DC.W     444     6480 Rpm
       DC.W     445     6496 Rpm
       DC.W     445     6512 Rpm
       DC.W     446     6528 Rpm
       DC.W     447     6544 Rpm
       DC.W     447     6560 Rpm
       DC.W     448     6576 Rpm
       DC.W     449     6592 Rpm
       DC.W     449     6608 Rpm
       DC.W     450     6624 Rpm
       DC.W     450     6640 Rpm
       DC.W     451     6656 Rpm
       DC.W     452     6672 Rpm
       DC.W     452     6688 Rpm
       DC.W     453     6704 Rpm
       DC.W     454     6720 Rpm
       DC.W     454     6736 Rpm
       DC.W     455     6752 Rpm
       DC.W     455     6768 Rpm
       DC.W     456     6784 Rpm
       DC.W     457     6800 Rpm
       DC.W     457     6816 Rpm
       DC.W     458     6832 Rpm
       DC.W     458     6848 Rpm
       DC.W     459     6864 Rpm
       DC.W     459     6880 Rpm
       DC.W     460     6896 Rpm
       DC.W     461     6912 Rpm
       DC.W     461     6928 Rpm
       DC.W     462     6944 Rpm
       DC.W     462     6960 Rpm
       DC.W     463     6976 Rpm
       DC.W     463     6992 Rpm
       DC.W     464     7008 Rpm
       DC.W     465     7024 Rpm
       DC.W     465     7040 Rpm
       DC.W     466     7056 Rpm
       DC.W     466     7072 Rpm
       DC.W     467     7088 Rpm
       DC.W     467     7104 Rpm
       DC.W     468     7120 Rpm
       DC.W     468     7136 Rpm
       DC.W     469     7152 Rpm
       DC.W     470     7168 Rpm
       DC.W     470     7184 Rpm
       DC.W     471     7200 Rpm
       DC.W     471     7216 Rpm
       DC.W     472     7232 Rpm
       DC.W     472     7248 Rpm
       DC.W     473     7264 Rpm
       DC.W     473     7280 Rpm
       DC.W     474     7296 Rpm
       DC.W     474     7312 Rpm
       DC.W     475     7328 Rpm
       DC.W     475     7344 Rpm
       DC.W     476     7360 Rpm
       DC.W     476     7376 Rpm
       DC.W     477     7392 Rpm
       DC.W     477     7408 Rpm
       DC.W     478     7424 Rpm
       DC.W     478     7440 Rpm
       DC.W     479     7456 Rpm
       DC.W     479     7472 Rpm
       DC.W     480     7488 Rpm
       DC.W     480     7504 Rpm
       DC.W     481     7520 Rpm
       DC.W     481     7536 Rpm
       DC.W     482     7552 Rpm
       DC.W     482     7568 Rpm
       DC.W     483     7584 Rpm
       DC.W     483     7600 Rpm
       DC.W     484     7616 Rpm
       DC.W     484     7632 Rpm
       DC.W     485     7648 Rpm
       DC.W     485     7664 Rpm
       DC.W     486     7680 Rpm
       DC.W     486     7696 Rpm
       DC.W     487     7712 Rpm
       DC.W     487     7728 Rpm
       DC.W     488     7744 Rpm
       DC.W     488     7760 Rpm
       DC.W     489     7776 Rpm
       DC.W     489     7792 Rpm
       DC.W     489     7808 Rpm
       DC.W     490     7824 Rpm
       DC.W     490     7840 Rpm
       DC.W     491     7856 Rpm
       DC.W     491     7872 Rpm
       DC.W     492     7888 Rpm
       DC.W     492     7904 Rpm
       DC.W     493     7920 Rpm
       DC.W     493     7936 Rpm
       DC.W     493     7952 Rpm
       DC.W     494     7968 Rpm
       DC.W     494     7984 Rpm
       DC.W     495     8000 Rpm
       DC.W     495     8016 Rpm
       DC.W     496     8032 Rpm
       DC.W     496     8048 Rpm
       DC.W     496     8064 Rpm
       DC.W     497     8080 Rpm
       DC.W     497     8096 Rpm
       DC.W     498     8112 Rpm
       DC.W     498     8128 Rpm
       DC.W     498     8144 Rpm
       DC.W     499     8160 Rpm
       DC.W     499     8176 Rpm
       DC.W     500     8192 Rpm
       DC.W     500     8208 Rpm
       DC.W     500     8224 Rpm
       DC.W     501     8240 Rpm
       DC.W     501     8256 Rpm
       DC.W     502     8272 Rpm
       DC.W     502     8288 Rpm
       DC.W     502     8304 Rpm
       DC.W     503     8320 Rpm
       DC.W     503     8336 Rpm
       DC.W     503     8352 Rpm
       DC.W     504     8368 Rpm
       DC.W     504     8384 Rpm
       DC.W     505     8400 Rpm
       DC.W     505     8416 Rpm
       DC.W     505     8432 Rpm
       DC.W     506     8448 Rpm
       DC.W     506     8464 Rpm
       DC.W     506     8480 Rpm
       DC.W     507     8496 Rpm
       DC.W     507     8512 Rpm
       DC.W     507     8528 Rpm
       DC.W     508     8544 Rpm
       DC.W     508     8560 Rpm
       DC.W     509     8576 Rpm
       DC.W     509     8592 Rpm
       DC.W     509     8608 Rpm
       DC.W     510     8624 Rpm
       DC.W     510     8640 Rpm
       DC.W     510     8656 Rpm
       DC.W     511     8672 Rpm
       DC.W     511     8688 Rpm
       DC.W     511     8704 Rpm
       DC.W     512     8720 Rpm
       DC.W     512     8736 Rpm
       DC.W     512     8752 Rpm
       DC.W     512     8768 Rpm
       DC.W     513     8784 Rpm
       DC.W     513     8800 Rpm
       DC.W     513     8816 Rpm
       DC.W     514     8832 Rpm
       DC.W     514     8848 Rpm
       DC.W     514     8864 Rpm
       DC.W     515     8880 Rpm
       DC.W     515     8896 Rpm
       DC.W     515     8912 Rpm
       DC.W     516     8928 Rpm
       DC.W     516     8944 Rpm
       DC.W     516     8960 Rpm
       DC.W     516     8976 Rpm
       DC.W     517     8992 Rpm
       DC.W     517     9008 Rpm
       DC.W     517     9024 Rpm
       DC.W     518     9040 Rpm
       DC.W     518     9056 Rpm
       DC.W     518     9072 Rpm
       DC.W     518     9088 Rpm
       DC.W     519     9104 Rpm
       DC.W     519     9120 Rpm
       DC.W     519     9136 Rpm
       DC.W     519     9152 Rpm
       DC.W     520     9168 Rpm
       DC.W     520     9184 Rpm
       DC.W     520     9200 Rpm
       DC.W     520     9216 Rpm
       DC.W     521     9232 Rpm
       DC.W     521     9248 Rpm
       DC.W     521     9264 Rpm
       DC.W     521     9280 Rpm
       DC.W     522     9296 Rpm
       DC.W     522     9312 Rpm
       DC.W     522     9328 Rpm
       DC.W     522     9344 Rpm
       DC.W     523     9360 Rpm
       DC.W     523     9376 Rpm
       DC.W     523     9392 Rpm
       DC.W     523     9408 Rpm
       DC.W     524     9424 Rpm
       DC.W     524     9440 Rpm
       DC.W     524     9456 Rpm
       DC.W     524     9472 Rpm
       DC.W     524     9488 Rpm
       DC.W     525     9504 Rpm
       DC.W     525     9520 Rpm
       DC.W     525     9536 Rpm
       DC.W     525     9552 Rpm
       DC.W     525     9568 Rpm
       DC.W     526     9584 Rpm
       DC.W     526     9600 Rpm
       DC.W     526     9616 Rpm
       DC.W     526     9632 Rpm
       DC.W     526     9648 Rpm
       DC.W     527     9664 Rpm
       DC.W     527     9680 Rpm
       DC.W     527     9696 Rpm
       DC.W     527     9712 Rpm
       DC.W     527     9728 Rpm
       DC.W     528     9744 Rpm
       DC.W     528     9760 Rpm
       DC.W     528     9776 Rpm
       DC.W     528     9792 Rpm
       DC.W     528     9808 Rpm
       DC.W     528     9824 Rpm
       DC.W     529     9840 Rpm
       DC.W     529     9856 Rpm
       DC.W     529     9872 Rpm
       DC.W     529     9888 Rpm
       DC.W     529     9904 Rpm
       DC.W     529     9920 Rpm
       DC.W     529     9936 Rpm
       DC.W     530     9952 Rpm
       DC.W     530     9968 Rpm
       DC.W     530     9984 Rpm
       DC.W     530     10000 Rpm
       DC.W     530     10016 Rpm
       DC.W     530     10032 Rpm
       DC.W     530     10048 Rpm
       DC.W     531     10064 Rpm
       DC.W     531     10080 Rpm
       DC.W     531     10096 Rpm
       DC.W     531     10112 Rpm
       DC.W     531     10128 Rpm
       DC.W     531     10144 Rpm
       DC.W     531     10160 Rpm
       DC.W     531     10176 Rpm
       DC.W     532     10192 Rpm
       DC.W     532     10208 Rpm
       DC.W     532     10224 Rpm
       DC.W     532     10240 Rpm
       DC.W     532     10256 Rpm
       DC.W     532     10272 Rpm
       DC.W     532     10288 Rpm
       DC.W     532     10304 Rpm
       DC.W     532     10320 Rpm
       DC.W     533     10336 Rpm
       DC.W     533     10352 Rpm
       DC.W     533     10368 Rpm
       DC.W     533     10384 Rpm
       DC.W     533     10400 Rpm
       DC.W     533     10416 Rpm
       DC.W     533     10432 Rpm
       DC.W     533     10448 Rpm
       DC.W     533     10464 Rpm
       DC.W     533     10480 Rpm
       DC.W     533     10496 Rpm
       DC.W     533     10512 Rpm
       DC.W     534     10528 Rpm
       DC.W     534     10544 Rpm
       DC.W     534     10560 Rpm
       DC.W     534     10576 Rpm
       DC.W     534     10592 Rpm
       DC.W     534     10608 Rpm
       DC.W     534     10624 Rpm
       DC.W     534     10640 Rpm
       DC.W     534     10656 Rpm
       DC.W     534     10672 Rpm
       DC.W     534     10688 Rpm
       DC.W     534     10704 Rpm
       DC.W     534     10720 Rpm
       DC.W     534     10736 Rpm
       DC.W     534     10752 Rpm
       DC.W     534     10768 Rpm
       DC.W     534     10784 Rpm
       DC.W     534     10800 Rpm
       DC.W     534     10816 Rpm
       DC.W     534     10832 Rpm
       DC.W     534     10848 Rpm
       DC.W     534     10864 Rpm
       DC.W     534     10880 Rpm
       DC.W     534     10896 Rpm
       DC.W     534     10912 Rpm
       DC.W     534     10928 Rpm
       DC.W     534     10944 Rpm
       DC.W     534     10960 Rpm
       DC.W     534     10976 Rpm
       DC.W     534     10992 Rpm
       DC.W     534     11008 Rpm
       DC.W     534     11024 Rpm
       DC.W     534     11040 Rpm
       DC.W     534     11056 Rpm
       DC.W     533     11072 Rpm
       DC.W     533     11088 Rpm
       DC.W     533     11104 Rpm
       DC.W     533     11120 Rpm
       DC.W     532     11136 Rpm
       DC.W     532     11152 Rpm
       DC.W     532     11168 Rpm
       DC.W     531     11184 Rpm
       DC.W     531     11200 Rpm
       DC.W     531     11216 Rpm
       DC.W     531     11232 Rpm
       DC.W     530     11248 Rpm
       DC.W     530     11264 Rpm
       DC.W     530     11280 Rpm
       DC.W     529     11296 Rpm
       DC.W     529     11312 Rpm
       DC.W     529     11328 Rpm
       DC.W     529     11344 Rpm
       DC.W     528     11360 Rpm
       DC.W     528     11376 Rpm
       DC.W     528     11392 Rpm
       DC.W     527     11408 Rpm
       DC.W     527     11424 Rpm
       DC.W     527     11440 Rpm
       DC.W     526     11456 Rpm
       DC.W     526     11472 Rpm
       DC.W     526     11488 Rpm
       DC.W     526     11504 Rpm
       DC.W     525     11520 Rpm
       DC.W     525     11536 Rpm
       DC.W     525     11552 Rpm
       DC.W     524     11568 Rpm
       DC.W     524     11584 Rpm
       DC.W     524     11600 Rpm
       DC.W     523     11616 Rpm
       DC.W     523     11632 Rpm
       DC.W     523     11648 Rpm
       DC.W     522     11664 Rpm
       DC.W     522     11680 Rpm
       DC.W     521     11696 Rpm
       DC.W     521     11712 Rpm
       DC.W     521     11728 Rpm
       DC.W     520     11744 Rpm
       DC.W     520     11760 Rpm
       DC.W     520     11776 Rpm
       DC.W     519     11792 Rpm
       DC.W     519     11808 Rpm
       DC.W     519     11824 Rpm
       DC.W     518     11840 Rpm
       DC.W     518     11856 Rpm
       DC.W     518     11872 Rpm
       DC.W     517     11888 Rpm
       DC.W     517     11904 Rpm
       DC.W     516     11920 Rpm
       DC.W     516     11936 Rpm
       DC.W     516     11952 Rpm
       DC.W     515     11968 Rpm
       DC.W     515     11984 Rpm
       DC.W     514     12000 Rpm
       DC.W     514     12016 Rpm
       DC.W     514     12032 Rpm
       DC.W     513     12048 Rpm
       DC.W     513     12064 Rpm
       DC.W     512     12080 Rpm
       DC.W     512     12096 Rpm
       DC.W     512     12112 Rpm
       DC.W     511     12128 Rpm
       DC.W     511     12144 Rpm
       DC.W     510     12160 Rpm
       DC.W     510     12176 Rpm
       DC.W     510     12192 Rpm
       DC.W     509     12208 Rpm
       DC.W     509     12224 Rpm
       DC.W     508     12240 Rpm
       DC.W     508     12256 Rpm
       DC.W     507     12272 Rpm
       DC.W     507     12288 Rpm
       DC.W     507     12304 Rpm
       DC.W     506     12320 Rpm
       DC.W     506     12336 Rpm
       DC.W     505     12352 Rpm
       DC.W     505     12368 Rpm
       DC.W     504     12384 Rpm
       DC.W     504     12400 Rpm
       DC.W     504     12416 Rpm
       DC.W     503     12432 Rpm
       DC.W     503     12448 Rpm
       DC.W     502     12464 Rpm
       DC.W     502     12480 Rpm
       DC.W     501     12496 Rpm
       DC.W     501     12512 Rpm
       DC.W     500     12528 Rpm
       DC.W     500     12544 Rpm
       DC.W     499     12560 Rpm
       DC.W     499     12576 Rpm
       DC.W     498     12592 Rpm
       DC.W     498     12608 Rpm
       DC.W     497     12624 Rpm
       DC.W     497     12640 Rpm
       DC.W     496     12656 Rpm
       DC.W     496     12672 Rpm
       DC.W     496     12688 Rpm
       DC.W     495     12704 Rpm
       DC.W     495     12720 Rpm
       DC.W     494     12736 Rpm
       DC.W     494     12752 Rpm
       DC.W     493     12768 Rpm
       DC.W     493     12784 Rpm
       DC.W     492     12800 Rpm
       DC.W     492     12816 Rpm
       DC.W     491     12832 Rpm
       DC.W     491     12848 Rpm
       DC.W     490     12864 Rpm
       DC.W     489     12880 Rpm
       DC.W     489     12896 Rpm
       DC.W     488     12912 Rpm
       DC.W     488     12928 Rpm
       DC.W     487     12944 Rpm
       DC.W     487     12960 Rpm
       DC.W     486     12976 Rpm
       DC.W     486     12992 Rpm
       DC.W     485     13008 Rpm
       DC.W     485     13024 Rpm
       DC.W     484     13040 Rpm
       DC.W     484     13056 Rpm
       DC.W     483     13072 Rpm
       DC.W     483     13088 Rpm
       DC.W     482     13104 Rpm
       DC.W     482     13120 Rpm
       DC.W     481     13136 Rpm
       DC.W     480     13152 Rpm
       DC.W     480     13168 Rpm
       DC.W     479     13184 Rpm
       DC.W     479     13200 Rpm
       DC.W     478     13216 Rpm
       DC.W     478     13232 Rpm
       DC.W     477     13248 Rpm
       DC.W     476     13264 Rpm
       DC.W     476     13280 Rpm
       DC.W     475     13296 Rpm
       DC.W     475     13312 Rpm
 
       END
