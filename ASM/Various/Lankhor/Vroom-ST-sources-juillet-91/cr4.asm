         TTL   Circuit 4 - Sweden - V15 - 13 APR 91

         INCLUDE   "EQU.ASM"

* Macros MTOP,TOP,EVT,YX
* Last MTOP/TOP Word filled by Program for Topology Events

MTOP     MACRO
         NOLIST
         DC.B  \1       Curve
         DC.B  (32*\5)!\2 Action + Bits
DIS      SET   DIS+\3
         DC.L  DIS      Y in cm
         DC.W  0        Filled by Program
CUR      SET   CUR+8
         LIST
         ENDM

YX       MACRO
         NOLIST
         DC.W  \1       Y
         DC.W  \2       X
CUR      SET   CUR+4
         LIST
         ENDM

* Events (Position on Circuit, Type,Speed, Initial Position)

SEVT
         DC.W  13,800,0         Cloud5
         DC.W  14,1000,0        Cloud6
         DC.W   2,320,-1        Plan1
         DS.W   SKYEQU-3

CUR      SET   0
DIS      SET   0

CEVT
         MTOP   3,4,37032,0,7              Curve R (7)         2

         MTOP   0,0,21294,0,0              Straight (0)        3

         MTOP   3,8,23145,0,7              Curve L (-7)        4

         MTOP   0,0,21294,0,0              Straight (0)        5

         MTOP   3,8,38884,0,3              Curve L (-10)       6

         MTOP   0,0,13887,0,0              Straight (0)        7

         MTOP   3,4,11110,0,7              Curve R (8)         8

         MTOP   0,0,24071,0,0              Straight (0)        9

         MTOP   2,8,10184,0,7              Curve L (-6)        10

         MTOP   0,0,9258,0,0               Straight (0)        11

         MTOP   4,4,15739,0,7              Curve R (8)         12

         MTOP   7,4,20368,0,1              Curve R (50)        13

         MTOP   6,4,9258,0,1               Curve R (20)        14

         MTOP   0,0,2777,0,0               Straight (0)        15

         MTOP   7,4,60177,0,1              Curve R (60)        16

         MTOP   0,0,7406,0,0               Straight (0)        17

         MTOP   4,4,27774,0,7              Curve R (9)         18

         MTOP   0,0,11110,0,0              Straight (0)        19

         MTOP   4,4,13887,0,7              Curve R (10)        20

         MTOP   0,0,15739,0,0              Straight (0)        21

         MTOP   -1,-1,7406,0,0             End of Circuit
                   
         DS.B  800*8-CUR

* XY Coordinates on Top Circuit

CUR      SET   0
CLAP     DC.L  401800           Lap Length in cm
CSCA     DC.W  401800/434       Scale for CDRW

CDRW  

         YX    3520,27
         YX    3520,27
         YX    3520,28
         YX    3520,29
         YX    3520,29
         YX    3520,30
         YX    3520,31
         YX    3520,31
         YX    3520,32
         YX    3520,33
         YX    3520,33
         YX    3520,34
         YX    3520,35
         YX    3520,35
         YX    3520,36
         YX    3520,37
         YX    3520,37
         YX    3520,38
         YX    3520,39
         YX    3520,39
         YX    3520,40
         YX    3520,41
         YX    3520,41
         YX    3520,42
         YX    3520,43
         YX    3520,43
         YX    3520,44
         YX    3520,45
         YX    3520,45
         YX    3520,46
         YX    3520,47
         YX    3520,47
         YX    3520,48
         YX    3520,49
         YX    3520,49
         YX    3520,50
         YX    3520,51
         YX    3520,51
         YX    3520,52
         YX    3520,53
*         YX    3520,53

         YX    3520,53
         YX    3680,54
         YX    3680,54
         YX    3680,55
         YX    3680,56
         YX    3840,56
         YX    3840,57
         YX    4000,57
         YX    4000,57
         YX    4160,58
         YX    4320,58
         YX    4320,58
         YX    4480,58
         YX    4480,58
         YX    4640,57
         YX    4800,57
         YX    4800,57
         YX    4960,56
         YX    4960,56
         YX    4960,55
         YX    5120,54
         YX    5120,54
         YX    5120,53
*         YX    5120,52

         YX    5120,52
         YX    5120,52
         YX    5120,51
         YX    4960,51
         YX    4960,50
         YX    4960,49
         YX    4960,49
         YX    4960,48
         YX    4960,47
         YX    4960,47
         YX    4960,46
         YX    4960,45
         YX    4960,45
         YX    4960,44
         YX    4800,43
         YX    4800,43
         YX    4800,42
         YX    4800,41
         YX    4800,41
         YX    4800,40
         YX    4800,39
         YX    4800,39
         YX    4800,38
         YX    4800,37
         YX    4640,37
*         YX    4640,36

         YX    4640,36
         YX    4640,35
         YX    4640,35
         YX    4800,34
         YX    4800,33
         YX    4800,33
         YX    4800,32
         YX    4960,32
         YX    4960,31
         YX    5120,31
         YX    5280,31
         YX    5280,31
         YX    5440,31
         YX    5600,31
         YX    5600,31
         YX    5760,31
         YX    5920,31
         YX    5920,32
         YX    6080,32
         YX    6080,33
         YX    6080,33
         YX    6080,34
         YX    6240,35
*         YX    6240,35

         YX    6240,35
         YX    6240,36
         YX    6240,37
         YX    6240,37
         YX    6240,38
         YX    6240,39
         YX    6240,39
         YX    6240,40
         YX    6240,41
         YX    6240,41
         YX    6240,42
         YX    6240,43
         YX    6240,43
         YX    6240,44
         YX    6240,45
         YX    6240,45
         YX    6240,46
         YX    6240,47
         YX    6240,47
         YX    6240,48
         YX    6240,49
         YX    6240,49
         YX    6240,50
         YX    6240,51
         YX    6240,51
         YX    6240,52
         YX    6240,53
         YX    6240,53
         YX    6240,54
         YX    6240,55
         YX    6240,55
         YX    6240,56
         YX    6240,57
         YX    6240,57
         YX    6240,58
         YX    6240,59
         YX    6240,59
         YX    6240,60
         YX    6240,61
         YX    6240,61
         YX    6240,62
         YX    6240,63
*         YX    6240,63

         YX    6240,63
         YX    6240,64
         YX    6240,65
         YX    6080,65
         YX    6080,66
         YX    6080,67
         YX    6080,67
         YX    5920,68
         YX    5920,68
         YX    5760,69
         YX    5760,69
         YX    5600,69
         YX    5440,70
         YX    5440,70
         YX    5280,70
*         YX    5120,70

         YX    5120,70
         YX    5120,70
         YX    4960,70
         YX    4800,70
         YX    4800,70
         YX    4640,70
         YX    4480,70
         YX    4480,70
         YX    4320,70
         YX    4160,70
         YX    4160,70
         YX    4000,70
*         YX    4000,71

         YX    4000,70
         YX    3840,70
         YX    3680,70
         YX    3680,70
         YX    3520,70
         YX    3360,71
         YX    3360,71
         YX    3360,72
         YX    3200,72
         YX    3200,73
         YX    3200,74
         YX    3200,74
         YX    3200,75
         YX    3200,76
         YX    3200,76
         YX    3200,77
         YX    3200,77
         YX    3360,78
         YX    3360,79
         YX    3360,79
         YX    3520,79
         YX    3680,80
         YX    3680,80
         YX    3840,80
         YX    4000,80
         YX    4000,80
*         YX    4160,80

         YX    4160,80
         YX    4160,80
         YX    4320,80
         YX    4480,80
         YX    4480,80
         YX    4640,80
         YX    4800,80
         YX    4800,80
         YX    4960,80
         YX    5120,80
         YX    5120,80
*         YX    5280,80

         YX    5280,80
         YX    5440,80
         YX    5440,80
         YX    5600,80
         YX    5760,80
         YX    5760,81
         YX    5920,81
         YX    5920,82
         YX    5920,82
         YX    6080,83
*         YX    6080,83

         YX    6080,83
         YX    6080,84
         YX    6080,85
         YX    6080,85
         YX    6080,86
         YX    6080,87
         YX    6080,87
         YX    6080,88
         YX    6080,89
         YX    6080,89
         YX    6080,90
         YX    6080,91
         YX    6080,91
         YX    6080,92
         YX    6240,93
         YX    6240,93
         YX    6240,94
*         YX    6240,95

         YX    6240,95
         YX    6240,95
         YX    6240,96
         YX    6240,97
         YX    6400,97
         YX    6400,98
         YX    6400,98
         YX    6560,99
         YX    6720,99
         YX    6720,99
         YX    6880,99
         YX    6880,100
         YX    7040,100
         YX    7200,100
         YX    7200,99
         YX    7360,99
         YX    7520,99
         YX    7520,99
         YX    7680,98
         YX    7680,98
         YX    7840,97
         YX    7840,97
*         YX    7840,96

         YX    7840,96
         YX    7840,95
         YX    7840,95
         YX    8000,94
         YX    8000,93
         YX    8000,93
         YX    8000,92
         YX    8000,91
         YX    8000,91
         YX    8000,90
*         YX    8000,89

         YX    8000,89
         YX    8000,89
         YX    8000,88
*         YX    8000,87

         YX    8000,87
         YX    8000,87
         YX    8000,86
         YX    8000,85
         YX    8000,85
         YX    8000,84
         YX    8000,83
         YX    8000,83
         YX    8000,82
         YX    8000,81
         YX    8000,81
         YX    8000,80
         YX    8000,79
         YX    8000,79
         YX    8000,78
         YX    8000,77
         YX    8000,77
         YX    8000,76
         YX    8000,75
         YX    8000,75
         YX    8000,74
         YX    8000,73
         YX    8000,73
         YX    8000,72
         YX    8000,71
         YX    8000,71
         YX    8000,70
         YX    8000,69
         YX    8000,69
         YX    8000,68
         YX    8000,67
         YX    8000,67
         YX    8000,66
         YX    8000,65
         YX    8000,65
         YX    8000,64
         YX    8000,63
         YX    7840,63
         YX    7840,62
         YX    7840,61
         YX    7840,61
         YX    7840,60
         YX    7840,59
         YX    7840,59
         YX    7840,58
         YX    7840,57
         YX    7840,57
         YX    7840,56
         YX    7840,55
         YX    7840,55
         YX    7840,54
         YX    7840,53
         YX    7840,53
         YX    7840,52
         YX    7840,51
         YX    7840,51
         YX    7840,50
         YX    7840,49
         YX    7840,49
         YX    7840,48
         YX    7840,47
         YX    7840,47
         YX    7840,46
         YX    7840,45
         YX    7840,45
*         YX    7840,44

         YX    7840,44
         YX    7840,43
         YX    7840,43
         YX    7840,42
         YX    7840,41
         YX    7680,41
         YX    7680,40
         YX    7680,39
*         YX    7680,39

         YX    7680,39
         YX    7680,38
         YX    7680,37
         YX    7680,37
         YX    7680,36
         YX    7680,35
         YX    7520,35
         YX    7520,34
         YX    7520,34
         YX    7520,33
         YX    7520,32
         YX    7520,32
         YX    7520,31
         YX    7520,30
         YX    7520,30
         YX    7360,29
         YX    7360,28
         YX    7360,28
         YX    7360,27
         YX    7360,26
         YX    7360,26
         YX    7360,25
         YX    7360,24
         YX    7200,24
         YX    7200,23
         YX    7200,22
         YX    7200,22
         YX    7200,21
         YX    7200,20
         YX    7200,20
*         YX    7200,19

         YX    7200,19
         YX    7200,18
         YX    7040,18
         YX    7040,17
         YX    7040,17
         YX    6880,16
         YX    6880,16
         YX    6720,15
         YX    6720,15
         YX    6560,15
         YX    6400,14
         YX    6400,14
*         YX    6240,14

         YX    6240,14
         YX    6080,14
         YX    6080,14
         YX    5920,14
         YX    5760,14
         YX    5760,14
         YX    5600,14
         YX    5440,14
         YX    5440,14
         YX    5280,14
         YX    5120,14
         YX    5120,14
         YX    4960,14
         YX    4800,14
         YX    4800,14
*         YX    4640,14

         YX    4640,14
         YX    4480,14
         YX    4480,14
         YX    4320,14
         YX    4320,14
         YX    4160,14
         YX    4000,14
         YX    4000,15
         YX    3840,15
         YX    3840,16
         YX    3680,16
         YX    3680,17
         YX    3680,17
         YX    3520,18
         YX    3520,19
         YX    3520,19
         YX    3520,20
*         YX    3520,21

         YX    3520,21
         YX    3520,21
         YX    3520,22
         YX    3520,23
         YX    3520,23
         YX    3520,24
         YX    3520,25
         YX    3520,25
*         YX    3520,26

         YX    -1,-1
         YX    -1,1
         DS.B  500*4-CUR

CEND
         END

