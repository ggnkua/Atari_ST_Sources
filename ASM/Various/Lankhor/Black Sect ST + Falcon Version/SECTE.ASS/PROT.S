debdeb:
	dc.w    0,12	
	dc.w    fin-debut,fin-debut
	dc.w    -1,-1
debut:
*	nbre de prot -1
        dc.w    049
*	nbre total de mots differents de la protection -1
        dc.w    049
*	num page, num ligne, num mot
        dc.w    001,003,008
        dc.w    001,008,002
        dc.w    001,009,005
        dc.w    001,013,008
        dc.w    001,015,007
        dc.w    001,017,004
        dc.w    001,019,001
        dc.w    001,023,001
        dc.w    001,024,006
        dc.w    001,029,005
        dc.w    002,001,007
        dc.w    002,003,006
        dc.w    002,009,002
        dc.w    002,010,004
        dc.w    002,015,003
        dc.w    002,016,004
        dc.w    002,018,009
        dc.w    003,005,004
        dc.w    003,009,005
        dc.w    003,011,005
        dc.w    003,019,003
        dc.w    003,021,003
        dc.w    004,003,004
        dc.w    004,004,003
        dc.w    004,009,002
        dc.w    004,014,001
        dc.w    004,023,002
        dc.w    005,002,005
        dc.w    005,004,007
        dc.w    005,006,003
        dc.w    005,008,002
        dc.w    005,011,001
        dc.w    005,021,003
        dc.w    005,026,001
        dc.w    005,030,003
        dc.w    006,005,002
        dc.w    006,006,002
        dc.w    006,009,002
        dc.w    006,021,008
        dc.w    007,003,006
        dc.w    007,007,011
        dc.w    007,009,005
        dc.w    007,015,007
        dc.w    007,018,005
        dc.w    008,002,010
        dc.w    008,004,007
        dc.w    008,006,002
        dc.W    008,008,003
        dc.w    008,012,004
        dc.w    008,013,009
fin:
