	dc.w $4E46,$4E75
	dc.w $202F,$0004
	dc.w $41FA,$0014
	dc.w $2080,$4E75
	dc.w $202F,$0006
	dc.w $41FA,$0008
	dc.w $2050,$2080
	dc.w $4E75,$0000
	dc.w $0000,$0000
