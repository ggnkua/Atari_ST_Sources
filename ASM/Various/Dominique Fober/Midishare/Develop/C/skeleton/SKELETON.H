/* resource file indicies for SKELETON */

#define MENU     0	/* menu tree */
#define ABOUTID  7	/* STRING in tree MENU */

#define RSC      1	/* form/dialog */
#define SKELETON 2	/* TEXT in tree RSC */

#define ABOUT    2	/* form/dialog */
#define OK       3	/* BUTTON in tree ABOUT */

