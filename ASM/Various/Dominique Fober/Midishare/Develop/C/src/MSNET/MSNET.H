/* resource file indicies for MSNET */

#define RSC      0	/* form/dialog */
#define FOND     0	/* BOX in tree RSC */
#define FAPP     1	/* BOX in tree RSC */
#define UPAPP    2	/* BOXCHAR in tree RSC */
#define DOWNAPP  3	/* BOXCHAR in tree RSC */
#define FSAPP    4	/* BOX in tree RSC */
#define SLIDEAPP 5	/* BOX in tree RSC */
#define APP      6	/* BOX in tree RSC */
#define FIN      7	/* BOX in tree RSC */
#define UPIN     8	/* BOXCHAR in tree RSC */
#define DOWNIN   9	/* BOXCHAR in tree RSC */
#define FSIN     10	/* BOX in tree RSC */
#define SLIDEIN  11	/* BOX in tree RSC */
#define IN       12	/* BOX in tree RSC */
#define FOUT     13	/* BOX in tree RSC */
#define OUT      14	/* BOX in tree RSC */
#define UPOUT    15	/* BOXCHAR in tree RSC */
#define DOWNOUT  16	/* BOXCHAR in tree RSC */
#define FSOUT    17	/* BOX in tree RSC */
#define SLIDEOUT 18	/* BOX in tree RSC */

#define MENU     1	/* menu tree */
#define ABOUTID  7	/* STRING in tree MENU */

#define ABOUT    2	/* form/dialog */
#define VAPPL    4	/* TEXT in tree ABOUT */
#define OK       6	/* BUTTON in tree ABOUT */
#define VERSION  11	/* TEXT in tree ABOUT */

