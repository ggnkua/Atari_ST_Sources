/* resource file indicies for MSSPACE */

#define MENU     0	/* menu tree */
#define ABOUTID  7	/* STRING in tree MENU */

#define RSC      1	/* form/dialog */
#define TOTAL    1	/* BOX in tree RSC */
#define USED     2	/* BOX in tree RSC */
#define TOTALNBR 5	/* TEXT in tree RSC */
#define USEDNBR  8	/* TEXT in tree RSC */
#define PRCENT   9	/* TEXT in tree RSC */
#define FREEINFO 10	/* TEXT in tree RSC */
#define IDMORE   11	/* TEXT in tree RSC */
#define SUITEA   12	/* BOXTEXT in tree RSC */

#define MORE     2	/* form/dialog */
#define RCVERR   3	/* TEXT in tree MORE */
#define ALLOCERR 6	/* TEXT in tree MORE */
#define RCVTOT   9	/* TEXT in tree MORE */
#define XMTTOT   12	/* TEXT in tree MORE */
#define CLEAR    13	/* BUTTON in tree MORE */
#define MOREOK   14	/* BUTTON in tree MORE */

#define RSC2     3	/* form/dialog */
#define GROWINFO 1	/* BOXTEXT in tree RSC2 */
#define NUMBER   4	/* BOXTEXT in tree RSC2 */
#define PLUS     5	/* TEXT in tree RSC2 */
#define MOINS    6	/* TEXT in tree RSC2 */
#define SUITEB   7	/* BOXTEXT in tree RSC2 */
#define GROW     8	/* BOXTEXT in tree RSC2 */
#define MEMFREE  10	/* BOXTEXT in tree RSC2 */

#define ABOUT    4	/* form/dialog */
#define VAPPL    2	/* TEXT in tree ABOUT */
#define OK       5	/* BUTTON in tree ABOUT */
#define VERSION  11	/* TEXT in tree ABOUT */

