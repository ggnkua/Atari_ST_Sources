*************************************
*    Colors are: R-1 G-2 B-3 W-4    *
*************************************
	opt	x+
	bsr	Rez
	and.b	#$fe,$fffffa07.w
	clr.b	$fffffa09.w
	and.b	#$fe,$fffffa13.w
	clr.b	$fffffa15.w
	move.l	#SyncCycle,$70.w
	bra	Kijek

SyncCycle:
	MOVE.W	#$2700,SR
	CLR.L	$FFFF8240.W
	LEA	$FFFF8209.W,A0
	LEA	JmpCycle(PC),A1
	MOVEQ	#0,D0
SYNC	MOVE.B	(A0),D0
	BEQ.S	SYNC
	jmp	(a1,d0.w)
JmpCycle
	dcb.w	$4e71,214
	move.w	#$40,$ffff8240.w
	lea	$ffff820a.w,a0
	lea	$ffff8260.w,a1
	lea	$200.w,a2
.SUCKER
 moveq	#0,d0
 moveq	#1,d1
 moveq	#2,d2

TuWstaw
	jsr	Ripp_0
	jsr	Ripp_0
	jsr	Ripp_0
	jsr	Ripp_0
	jsr	Ripp_0
	jsr	Ripp_0
	jsr	Ripp_0
	move.w	#$2300,sr
	clr.w	$ffff8240.w
	BSR	CalcNext

	rte
CalcNext:
	moveq	#0,d0
	lea	Kount(pc),a0
	move.w	(a0),d0
	cmp.w	#64,d0	; 8*8
	bne.s	Rebeka
	moveq	#0,d0
	move.w	d0,(a0)
Rebeka	addq.w	#8,(a0)
	lea	Joust(pc),a0
	add.w	d0,a0
	lea	ADR(pc),a1
	lea	TuWstaw(pc),a2
	moveq	#6,d7
fujem_up
	moveq	#0,d1
	move.b	(a0)+,d1
	add.w	d1,d1
	add.w	d1,d1
	move.l	(a1,d1.w),2(a2)
	addq.w	#6,a2
	dbf	d7,fujem_up
	moveq	#0,d0
	move.b	(a0),d0
	lea	SkrinA(pc),a0
	move.w	(a0),d1
	sub.w	d0,d1
	cmp.l	#$400,d1
	bgt.s	Normal
	move.w	#$4c8,d1
Normal	move.w	d1,(a0)
	lsl.l	#8,d1
	lsr.w	#8,d1
	move.l	d1,$ffff8200.w
Bak	rts
SkrinA	dc.w	$480
Kount	dc.w	0



*************************************
*      - R I P   F R A M E S -      *
*************************************
Ripp_0:	nop
	nop
	moveq	#36,d0
.cwks	dbf	d0,.cwks
	moveq	#0,d0
	rts
Ripp_1:	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	nop
	nop
	moveq	#27,d0
.cwks	dbf	d0,.cwks
	moveq	#0,d0
	MOVE.B	D0,(A0)
	MOVE.B	D2,(A0)
	dcb.w	$4e71,13
	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	dcb.w	$4e71,3
	rts
Ripp_2:	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	nop
	nop
	moveq	#27,d0
.cwks	dbf	d0,.cwks
	moveq	#0,d0
	MOVE.B	D2,(A0)
	MOVE.B	D2,(A0)
	dcb.w	$4e71,13
	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	dcb.w	$4e71,3
	rts
Ripp_3:	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	nop
	moveq	#27,d0
.cwks	dbf	d0,.cwks
	moveq	#0,d0
	MOVE.B	D0,(A0)
	MOVE.B	D2,(A0)
	dcb.w	$4e71,14
	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	dcb.w	$4e71,3
	rts
Ripp_4:	MOVE.B	D0,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	nop
	moveq	#27,d0
.cwks	dbf	d0,.cwks
	moveq	#0,d0
	MOVE.B	D0,(A0)
	MOVE.B	D2,(A0)
	dcb.w	$4e71,14
	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	dcb.w	$4e71,3
	rts
Ripp_5:	MOVE.B	D0,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	nop
	nop
	moveq	#27,d0
.cwks	dbf	d0,.cwks
	moveq	#0,d0
	MOVE.B	D0,(A0)
	MOVE.B	D2,(A0)
	dcb.w	$4e71,13
	MOVE.B	D2,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	dcb.w	$4e71,3
	rts


*************************************
* -S E T   A L L   P A R A M E T R- *
*************************************
Rez:
	DC.W	$A00A
	CLR.L	-(A7)
	MOVE.W	#32,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	clr.l	$140.w
	MOVE.B	#$12,$FFFFFC02.W
	MOVE.B	#2,$FFFF820A.W
	MOVE.B	#0,$FFFF8260.W
	CLR.W	-(A7)
	PEA	$48000
	PEA	$48000
	MOVE.W	#5,-(A7)
	TRAP	#14
	LEA	12(A7),A7
	MOVEQ	#15,D7
	LEA	$485a0,A0
	LEA	$49400,A2
	LEA	$4A260,A3
	LEA	GodsFnt(PC),A1
.LOOP1	MOVEQ	#19,D6
.LOOP2	MOVE.L	(A1),(A3)+
	MOVE.L	(A1),(A2)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1),(A3)+
	MOVE.L	(A1),(A2)+
	MOVE.L	(A1)+,(A0)+
	DBF	D6,.LOOP2
	DBF	D7,.LOOP1
StartC	LEA	$FFFF8240.W,A0
	lea	GodsPal(pc),a0
	lea	$ffff8240.w,a1
	rept	8
	move.l	(a0)+,(a1)+
	endr
	rts


*************************************
*       - E N D   R O U T S-        *
*************************************
Kijek	STOP	#$2300
	CMP.B	#$39,$FFFFFC02.W
	BNE.S	Kijek
KONIEC:
	MOVE.W	#$2700,SR
	MOVE.B	#$64,$FFFFFA09.W
	MOVE.B	#$64,$FFFFFA15.W
	MOVE.L	#$E00802,$70.W
	MOVE.B	#0,$FFFF8260.W
	MOVE.B	#0,$FFFF820A.W
	MOVE.W	#9999,D7
MAXSYNC	DBF	D7,MAXSYNC
	MOVE.B	#2,$FFFF820A.W
	MOVE.W	#$2300,SR
	MOVE.W	#$000,$FFFF8240.W
	MOVE.W	#$555,$FFFF825e.W
	MOVE.B	#8,$FFFFFC02.W
	CLR.L	-(A7)
	TRAP	#1
	ILLEGAL
ADR	dc.l	Ripp_0,Ripp_1
	dc.l	Ripp_2,Ripp_3
	dc.l	Ripp_4,Ripp_5
Joust
	dc.b	0,0,0,0,0,0,0,0 (+0)
	dc.b	3,3,3,3,0,0,0,1 (+1)
	dc.b	1,1,2,2,0,0,0,1 (+1)
	dc.b	4,4,4,4,4,4,5,0 (+0)
	dc.b	2,2,2,2,3,0,0,1 (+1)
	dc.b	1,1,4,4,5,5,0,1 (+1)
	dc.b	3,4,4,5,0,0,0,0 (+0)
	dc.b	1,1,3,4,4,0,0,1 (+1)
	even
GodsPal	dc.w  $000,$310,$420,$530,$640,$750,$760,$770
	dc.w  $014,$025,$036,$047,$057,$067,$467,$060
GodsFnt	dc.l  $00000000,$00000180,$00000000,$0000FFE0
	dc.l  $00000000,$000001FF,$00000000,$0000FFC0
	dc.l  $00000000,$000001FF,$00000000,$000001FF
	dc.l  $00000000,$00000100,$00000000,$0000FE7F
	dc.l  $00000000,$00003FF8,$00000000,$000000FE
	dc.l  $00000000,$0000FE20,$00000000,$0000FE00
	dc.l  $00000000,$0000F007,$00000000,$0000F07F
	dc.l  $00000000,$000001C0,$00000000,$0000FFE0
	dc.l  $00000000,$000001C0,$00000000,$0000FFE0
	dc.l  $00000000,$000001FF,$00000000,$0000FFFF
	dc.l  $00800180,$010003C0,$08207020,$7FC0FFF0
	dc.l  $00020102,$01FC03FF,$18406040,$7F80FFE0
	dc.l  $00020102,$01FC03FF,$00020102,$01FC03FF
	dc.l  $00000000,$01000380,$0C06743A,$783CFE7F
	dc.l  $04101810,$1FE03FF8,$000C0074,$007800FE
	dc.l  $08007400,$7820FE70,$0C007400,$7800FE00
	dc.l  $00037005,$7006F80F,$0006603A,$703CF87F
	dc.l  $01400140,$008003E0,$0C207020,$7FC0FFF0
	dc.l  $01400140,$008003E0,$0C207020,$7FC0FFF0
	dc.l  $00020102,$01FC03FF,$0E007001,$7FFEFFFF
	dc.l  $004001C0,$020007E0,$00107FF0,$4000FFF8
	dc.l  $000201FC,$020007FF,$00207FE0,$4000FFF0
	dc.l  $000201FC,$020007FF,$000201FC,$020007FF
	dc.l  $00800180,$020007C0,$0402783C,$4020FE7F
	dc.l  $0C600F90,$10003FF8,$00040078,$004000FE
	dc.l  $00107830,$4040FEF8,$04007800,$4000FE00
	dc.l  $00017806,$4008FC1F,$0802783C,$4020FC7F
	dc.l  $002001E0,$020007F0,$00107FF0,$4000FFF8
	dc.l  $002001E0,$020007F0,$00107FF0,$4000FFF8
	dc.l  $000201FC,$020007FF,$00017FFE,$4000FFFF
	dc.l  $03E003E0,$04000FF0,$7FF83FF8,$4000FFFC
	dc.l  $03FC03FC,$04000FFF,$7FF03FF0,$4000FFF8
	dc.l  $03FC03FC,$04000FFF,$03FC03FC,$04000FFF
	dc.l  $03C003C0,$04000FE0,$783C381C,$4020FE7F
	dc.l  $07800780,$00003FF8,$00780038,$004000FE
	dc.l  $78783878,$4080FFFC,$78003800,$4000FE00
	dc.l  $7C0E3C0E,$4010FE3F,$7C3C3C1C,$4020FE7F
	dc.l  $03F003F0,$04000FF8,$7FF83FF8,$4000FFFC
	dc.l  $03F003F0,$04000FF8,$7FF83FF8,$4000FFFC
	dc.l  $03FC03FC,$04000FFF,$7FFE3FFE,$4000FFFF
	dc.l  $00100010,$0FE01FF8,$00840004,$7878FFFE
	dc.l  $00000040,$0F801FFF,$01080008,$78F0FFFC
	dc.l  $00000040,$0F801FFF,$00000040,$0F801FFF
	dc.l  $00000000,$0F801FE0,$00000000,$783CFE7F
	dc.l  $00000000,$07800FE0,$00000000,$007800FE
	dc.l  $00000000,$79F0FFFC,$00000000,$7800FE00
	dc.l  $02000200,$7C3EFF7F,$02000200,$7C3CFF7F
	dc.l  $00080008,$0FF01FFC,$00840044,$7838FFFE
	dc.l  $00080008,$0FF01FFC,$00840044,$7838FFFE
	dc.l  $00000040,$0F801FFF,$24000200,$41C0FFFF
	dc.l  $0FF80008,$1FF03FFC,$387E0002,$783CFFFF
	dc.l  $0F000000,$1F003FFF,$38FC0004,$7878FFFE
	dc.l  $0F000000,$1F003FFF,$0F000000,$1F003FFF
	dc.l  $0F000000,$1F003FC0,$381C0000,$783CFE7F
	dc.l  $03800000,$07800FE0,$00380000,$007800FE
	dc.l  $3DE00000,$7BE0FFF8,$38000000,$7800FE00
	dc.l  $3D3E0100,$7E7EFFFF,$3F1C0100,$7E3CFFFF
	dc.l  $0FFC0004,$1F783FFE,$381E0000,$783CFFFF
	dc.l  $0FFC0004,$1F783FFE,$381E0000,$783CFFFF
	dc.l  $1F001000,$0F003FFF,$01C00000,$03C0FFFF
	dc.l  $00841E7C,$3E787FFE,$0022381C,$781CFFFF
	dc.l  $00001E00,$3E007F80,$0042383E,$783CFEFF
	dc.l  $00001E00,$3E007FFC,$00001E00,$3E007FFC
	dc.l  $00001E00,$3E007FBF,$0000381C,$783CFFFF
	dc.l  $00000380,$07800FE0,$00000038,$007808FE
	dc.l  $04203FC0,$7BC0FFF0,$00003800,$7800FE00
	dc.l  $00003B6E,$7FFEFFFF,$00803F9C,$7F3CFFFF
	dc.l  $00021E3E,$3E3C7FFF,$00003838,$7878FEFE
	dc.l  $00021E3E,$3E3C7FFF,$00003838,$7878FEFE
	dc.l  $00801F80,$0F003FC0,$000001C0,$03C007F0
	dc.l  $3C7C0042,$7C3CFFFF,$3E3C01C0,$7FF8FFFF
	dc.l  $3C000000,$7C00FF00,$383E0021,$781EFE7F
	dc.l  $3F900060,$7FF8FFFC,$3F3000C0,$7FF8FFFC
	dc.l  $3C0A0012,$7C1CFF3F,$3E7C0180,$7FFCFFFF
	dc.l  $03800000,$07800FE0,$00380000,$08781CFE
	dc.l  $3F800040,$7F80FFE0,$38000000,$7800FE00
	dc.l  $3E2E0000,$79DEFFFF,$3FDC0040,$7BBCFFFF
	dc.l  $3C3E0021,$7C1EFF7F,$3C700000,$78F0FFFC
	dc.l  $3C3E0021,$7C1EFF7F,$3C700000,$78F0FFFC
	dc.l  $07C00840,$07801FE0,$01C00000,$03C007F0
	dc.l  $00220020,$781CFE7F,$01C00024,$7818FFFE
	dc.l  $42000000,$3C00FF00,$00000000,$783EFE7F
	dc.l  $41780180,$3E00FFFC,$03F80400,$7800FFFC
	dc.l  $42000012,$3C1CFF3F,$03C007C0,$783CFFFF
	dc.l  $00000000,$07800FE0,$0C000400,$18783EFE
	dc.l  $00400040,$7F80FFE0,$00000000,$7800FE00
	dc.l  $01400000,$789EFFFF,$02000000,$79FCFFFF
	dc.l  $42000200,$3C3EFF7F,$00000380,$7FE0FFF8
	dc.l  $42000200,$3C3EFF7F,$00000380,$7FE0FFF8
	dc.l  $00200420,$03C00FF0,$00000000,$03C007F0
	dc.l  $381C381C,$4020FE7F,$383C381E,$4020FFFF
	dc.l  $3F001E00,$00007F80,$387C383C,$4040FEFF
	dc.l  $3F001E00,$00007FFC,$3C003800,$4000FFFC
	dc.l  $3F1E1E0C,$00107FBF,$381C381C,$4020FFFF
	dc.l  $03800380,$04000FE0,$1E381E38,$20407FFE
	dc.l  $3FE03BE0,$4000FFF0,$38003800,$4000FE00
	dc.l  $388E380E,$4010FFFF,$39FC38FC,$4000FFFF
	dc.l  $3F7C1F3C,$00407FFF,$3FC03FC0,$4000FFF0
	dc.l  $3F7C1F3C,$00407FFF,$3FC03FE0,$4000FFF0
	dc.l  $01F003F0,$000007F8,$01C001C0,$020007F0
	dc.l  $0020381C,$4020FFFF,$0440383C,$4040FFFF
	dc.l  $10800F00,$00003FFF,$04803878,$4080FFFE
	dc.l  $10800F00,$00003FFF,$00003800,$4000FE00
	dc.l  $10000F8C,$00103FFF,$0000381C,$4020FE7F
	dc.l  $00000380,$0400FFFE,$41007F38,$0040FFFE
	dc.l  $021039F0,$4000FFF8,$00003800,$4000FFFE
	dc.l  $0000380E,$4010FEBF,$0080387C,$4000FFFF
	dc.l  $10000F78,$00803FFE,$00003F80,$4000FFE0
	dc.l  $10000F78,$00803FFF,$061039F0,$4000FFF8
	dc.l  $010800F8,$0000FFFC,$000001C0,$020007F0
	dc.l  $3ABC0640,$41E0FFFF,$38780400,$4380FFFE
	dc.l  $0FA2006A,$001C1FFF,$38F00400,$4300FFFC
	dc.l  $0FA2006A,$001C1FFF,$38000000,$4000FE00
	dc.l  $0FCC0050,$00301FFF,$381C0000,$4020FE7F
	dc.l  $17A46064,$7C18FFFE,$3FB80080,$00407FFE
	dc.l  $39F80008,$4000FFFC,$3D540324,$40F8FFFE
	dc.l  $380E0000,$4010FE3F,$387C0000,$4000FEFF
	dc.l  $0FF00000,$00001FFC,$38000000,$4000FFC0
	dc.l  $0FFA0007,$00001FFF,$39F80008,$4000FFFC
	dc.l  $15F06600,$7800FFFC,$01C00000,$020007F0
	dc.l  $07C0383C,$4000FFFF,$00003FF0,$4000FFFC
	dc.l  $040203FC,$00000FFF,$00003FE0,$4000FFF8
	dc.l  $040203FC,$00000FFF,$00003800,$4000FE00
	dc.l  $040003FC,$00000FFF,$0000381C,$4020FE7F
	dc.l  $00043FF8,$4000FFFE,$10000FF8,$00003FFE
	dc.l  $0084387C,$4000FFFE,$00043FF8,$4000FFFE
	dc.l  $0000380E,$4010FE3F,$0020381C,$4000FE7F
	dc.l  $040003E0,$00000FF8,$00003800,$4000FF80
	dc.l  $040103FE,$00000FFF,$0084387C,$4000FFFE
	dc.l  $00003FE0,$4000FFF8,$000001C0,$020007F0
	dc.l  $68344824,$3018FFFF,$4B407860,$0780FFF8
	dc.l  $02A8018C,$007007FF,$5A8078C0,$0700FFF0
	dc.l  $02A8018C,$007007FF,$68004800,$3000FE00
	dc.l  $02A8018C,$007007FF,$68344824,$3018FE7F
	dc.l  $76B87138,$0FC0FFFE,$0EA80648,$01F01FFE
	dc.l  $686A4822,$301CFEFF,$4C984318,$3FE0FFFE
	dc.l  $681A4812,$300CFE3F,$68144804,$3008FE3F
	dc.l  $028000C0,$010007F0,$68004800,$3000FE00
	dc.l  $03560126,$00F807FF,$686A4822,$301CFEFF
	dc.l  $76C07140,$0F80FFF0,$03400240,$018007F0
	dc.l  $00004020,$0000FE7F,$00004000,$0000FFF0
	dc.l  $00000000,$000003FF,$00004000,$0000FFE0
	dc.l  $00000000,$000003FF,$40000000,$0000FE00
	dc.l  $00000000,$000003FF,$00004020,$0000FE7F
	dc.l  $00004000,$0000FFFE,$00000000,$00000FFE
	dc.l  $00214000,$0000FE7F,$00004000,$0000FFFE
	dc.l  $00004010,$0000FE3F,$00004000,$0000FE1F
	dc.l  $00000000,$000003E0,$00004000,$0000FE00
	dc.l  $00000000,$000003FF,$00214000,$0000FE7F
	dc.l  $00004000,$0000FFE0,$00000200,$000007F0
	dc.l  $00000000,$0000FE7F,$00000000,$0000FFE0
	dc.l  $00000000,$000001FF,$00000000,$0000FFC0
	dc.l  $00000000,$000001FF,$00000000,$0000FE00
	dc.l  $00000000,$000001FF,$00000000,$0000FE7F
	dc.l  $00000000,$0000FFFE,$00000000,$000007FE
	dc.l  $00000000,$0000FE3F,$00000000,$0000FFFE
	dc.l  $00000000,$0000FE3F,$00000000,$0000FE0F
	dc.l  $00000000,$000001C0,$00000000,$0000FE00
	dc.l  $00000000,$000001FF,$00000000,$0000FE3F
	dc.l  $00000000,$0000FFC0,$00000000,$000007F0
