 dc.w 115,99
 dc.w 119,99
 dc.w 123,99
 dc.w 127,99
 dc.w 131,99
 dc.w 134,98
 dc.w 138,98
 dc.w 142,98
 dc.w 145,97
 dc.w 149,96
 dc.w 153,96
 dc.w 156,95
 dc.w 160,94
 dc.w 163,94
 dc.w 167,93
 dc.w 170,92
 dc.w 173,91
 dc.w 176,90
 dc.w 179,89
 dc.w 182,88
 dc.w 185,87
 dc.w 188,85
 dc.w 191,84
 dc.w 193,83
 dc.w 196,82
 dc.w 198,80
 dc.w 200,79
 dc.w 203,77
 dc.w 205,76
 dc.w 207,75
 dc.w 209,73
 dc.w 210,71
 dc.w 212,70
 dc.w 213,68
 dc.w 215,67
 dc.w 216,65
 dc.w 217,63
 dc.w 218,62
 dc.w 219,60
 dc.w 220,58
 dc.w 220,56
 dc.w 221,55
 dc.w 221,53
 dc.w 221,51
 dc.w 222,50
 dc.w 221,48
 dc.w 221,46
 dc.w 221,44
 dc.w 220,43
 dc.w 220,41
 dc.w 219,39
 dc.w 218,37
 dc.w 217,36
 dc.w 216,34
 dc.w 215,32
 dc.w 213,31
 dc.w 212,29
 dc.w 210,28
 dc.w 209,26
 dc.w 207,24
 dc.w 205,23
 dc.w 203,22
 dc.w 200,20
 dc.w 198,19
 dc.w 196,17
 dc.w 193,16
 dc.w 191,15
 dc.w 188,14
 dc.w 185,12
 dc.w 182,11
 dc.w 179,10
 dc.w 176,9
 dc.w 173,8
 dc.w 170,7
 dc.w 167,6
 dc.w 163,5
 dc.w 160,5
 dc.w 156,4
 dc.w 153,3
 dc.w 149,3
 dc.w 145,2
 dc.w 142,1
 dc.w 138,1
 dc.w 134,1
 dc.w 131,0
 dc.w 127,0
 dc.w 123,0
 dc.w 119,0
 dc.w 115,0
 dc.w 112,0
 dc.w 108,0
 dc.w 104,0
 dc.w 100,0
 dc.w 96,0
 dc.w 92,0
 dc.w 89,1
 dc.w 85,1
 dc.w 81,1
 dc.w 78,2
 dc.w 74,3
 dc.w 70,3
 dc.w 67,4
 dc.w 63,5
 dc.w 60,5
 dc.w 57,6
 dc.w 53,7
 dc.w 50,8
 dc.w 47,9
 dc.w 44,10
 dc.w 41,11
 dc.w 38,12
 dc.w 35,14
 dc.w 32,15
 dc.w 30,16
 dc.w 27,17
 dc.w 25,19
 dc.w 23,20
 dc.w 20,22
 dc.w 18,23
 dc.w 16,24
 dc.w 14,26
 dc.w 13,28
 dc.w 11,29
 dc.w 10,31
 dc.w 8,32
 dc.w 7,34
 dc.w 6,36
 dc.w 5,37
 dc.w 4,39
 dc.w 3,41
 dc.w 3,43
 dc.w 2,44
 dc.w 2,46
 dc.w 2,48
 dc.w 2,49
 dc.w 2,51
 dc.w 2,53
 dc.w 2,55
 dc.w 3,56
 dc.w 3,58
 dc.w 4,60
 dc.w 5,62
 dc.w 6,63
 dc.w 7,65
 dc.w 8,67
 dc.w 10,68
 dc.w 11,70
 dc.w 13,71
 dc.w 14,73
 dc.w 16,74
 dc.w 18,76
 dc.w 20,77
 dc.w 23,79
 dc.w 25,80
 dc.w 27,82
 dc.w 30,83
 dc.w 32,84
 dc.w 35,85
 dc.w 38,87
 dc.w 41,88
 dc.w 44,89
 dc.w 47,90
 dc.w 50,91
 dc.w 53,92
 dc.w 56,93
 dc.w 60,94
 dc.w 63,94
 dc.w 67,95
 dc.w 70,96
 dc.w 74,96
 dc.w 78,97
 dc.w 81,98
 dc.w 85,98
 dc.w 89,98
 dc.w 92,99
 dc.w 96,99
 dc.w 100,99
 dc.w 104,99
 dc.w 108,99
 dc.w 111,100
