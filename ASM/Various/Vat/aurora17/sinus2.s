 dc.l 40-32
 dc.l 40-32
 dc.l 40-32
 dc.l 41-32
 dc.l 41-32
 dc.l 42-32
 dc.l 42-32
 dc.l 42-32
 dc.l 43-32
 dc.l 43-32
 dc.l 44-32
 dc.l 44-32
 dc.l 44-32
 dc.l 45-32
 dc.l 45-32
 dc.l 45-32
 dc.l 45-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 47-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 46-32
 dc.l 45-32
 dc.l 45-32
 dc.l 45-32
 dc.l 45-32
 dc.l 44-32
 dc.l 44-32
 dc.l 44-32
 dc.l 43-32
 dc.l 43-32
 dc.l 42-32
 dc.l 42-32
 dc.l 42-32
 dc.l 41-32
 dc.l 41-32
 dc.l 40-32
 dc.l 40-32
 dc.l 40-32
 dc.l 39-32
 dc.l 39-32
 dc.l 38-32
 dc.l 38-32
 dc.l 37-32
 dc.l 37-32
 dc.l 37-32
 dc.l 36-32
 dc.l 36-32
 dc.l 35-32
 dc.l 35-32
 dc.l 35-32
 dc.l 34-32
 dc.l 34-32
 dc.l 34-32
 dc.l 34-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 33-32
 dc.l 34-32
 dc.l 34-32
 dc.l 34-32
 dc.l 34-32
 dc.l 35-32
 dc.l 35-32
 dc.l 35-32
 dc.l 36-32
 dc.l 36-32
 dc.l 37-32
 dc.l 37-32
 dc.l 37-32
 dc.l 38-32
 dc.l 38-32
 dc.l 39-32
 dc.l 39-32
