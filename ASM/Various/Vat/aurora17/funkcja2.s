 dc.w 112,99
 dc.w 114,99
 dc.w 115,99
 dc.w 117,98
 dc.w 119,97
 dc.w 121,95
 dc.w 123,93
 dc.w 125,91
 dc.w 126,88
 dc.w 128,86
 dc.w 130,83
 dc.w 132,79
 dc.w 134,76
 dc.w 135,72
 dc.w 137,69
 dc.w 139,65
 dc.w 141,61
 dc.w 143,56
 dc.w 144,52
 dc.w 146,48
 dc.w 148,44
 dc.w 150,40
 dc.w 151,36
 dc.w 153,32
 dc.w 155,28
 dc.w 156,24
 dc.w 158,21
 dc.w 160,18
 dc.w 161,14
 dc.w 163,12
 dc.w 165,9
 dc.w 166,7
 dc.w 168,5
 dc.w 169,3
 dc.w 171,2
 dc.w 172,1
 dc.w 174,0
 dc.w 175,0
 dc.w 177,0
 dc.w 178,0
 dc.w 180,1
 dc.w 181,2
 dc.w 183,3
 dc.w 184,5
 dc.w 185,7
 dc.w 187,9
 dc.w 188,11
 dc.w 189,14
 dc.w 191,17
 dc.w 192,21
 dc.w 193,24
 dc.w 194,28
 dc.w 196,32
 dc.w 197,36
 dc.w 198,40
 dc.w 199,44
 dc.w 200,48
 dc.w 201,52
 dc.w 202,56
 dc.w 203,60
 dc.w 204,64
 dc.w 205,68
 dc.w 206,72
 dc.w 207,76
 dc.w 208,79
 dc.w 209,82
 dc.w 210,85
 dc.w 210,88
 dc.w 211,91
 dc.w 212,93
 dc.w 213,95
 dc.w 213,96
 dc.w 214,98
 dc.w 215,99
 dc.w 215,99
 dc.w 216,99
 dc.w 217,99
 dc.w 217,99
 dc.w 218,98
 dc.w 218,97
 dc.w 218,96
 dc.w 219,94
 dc.w 219,92
 dc.w 220,89
 dc.w 220,87
 dc.w 220,84
 dc.w 221,81
 dc.w 221,77
 dc.w 221,74
 dc.w 221,70
 dc.w 221,66
 dc.w 221,62
 dc.w 221,58
 dc.w 221,54
 dc.w 221,50
 dc.w 221,46
 dc.w 221,42
 dc.w 221,37
 dc.w 221,33
 dc.w 221,30
 dc.w 221,26
 dc.w 221,22
 dc.w 221,19
 dc.w 220,16
 dc.w 220,13
 dc.w 220,10
 dc.w 219,8
 dc.w 219,5
 dc.w 219,4
 dc.w 218,2
 dc.w 218,1
 dc.w 217,0
 dc.w 217,0
 dc.w 216,0
 dc.w 215,0
 dc.w 215,0
 dc.w 214,1
 dc.w 214,2
 dc.w 213,4
 dc.w 212,6
 dc.w 211,8
 dc.w 211,10
 dc.w 210,13
 dc.w 209,16
 dc.w 208,19
 dc.w 207,23
 dc.w 206,26
 dc.w 205,30
 dc.w 204,34
 dc.w 203,38
 dc.w 202,42
 dc.w 201,46
 dc.w 200,50
 dc.w 199,55
 dc.w 198,59
 dc.w 197,63
 dc.w 196,67
 dc.w 195,71
 dc.w 193,74
 dc.w 192,78
 dc.w 191,81
 dc.w 190,84
 dc.w 188,87
 dc.w 187,90
 dc.w 186,92
 dc.w 184,94
 dc.w 183,96
 dc.w 181,97
 dc.w 180,98
 dc.w 179,99
 dc.w 177,99
 dc.w 176,99
 dc.w 174,99
 dc.w 173,99
 dc.w 171,98
 dc.w 170,96
 dc.w 168,95
 dc.w 166,93
 dc.w 165,90
 dc.w 163,88
 dc.w 162,85
 dc.w 160,82
 dc.w 158,79
 dc.w 157,75
 dc.w 155,72
 dc.w 153,68
 dc.w 151,64
 dc.w 150,60
 dc.w 148,56
 dc.w 146,51
 dc.w 145,47
 dc.w 143,43
 dc.w 141,39
 dc.w 139,35
 dc.w 138,31
 dc.w 136,27
 dc.w 134,24
 dc.w 132,20
 dc.w 130,17
 dc.w 129,14
 dc.w 127,11
 dc.w 125,9
 dc.w 123,6
 dc.w 121,4
 dc.w 119,3
 dc.w 118,1
 dc.w 116,0
 dc.w 114,0
 dc.w 112,0
 dc.w 110,0
 dc.w 108,0
 dc.w 107,1
 dc.w 105,2
 dc.w 103,3
 dc.w 101,5
 dc.w 99,7
 dc.w 97,9
 dc.w 96,12
 dc.w 94,15
 dc.w 92,18
 dc.w 90,21
 dc.w 88,25
 dc.w 87,29
 dc.w 85,32
 dc.w 83,36
 dc.w 81,40
 dc.w 80,45
 dc.w 78,49
 dc.w 76,53
 dc.w 74,57
 dc.w 73,61
 dc.w 71,65
 dc.w 69,69
 dc.w 68,73
 dc.w 66,76
 dc.w 64,80
 dc.w 63,83
 dc.w 61,86
 dc.w 59,89
 dc.w 58,91
 dc.w 56,93
 dc.w 55,95
 dc.w 53,97
 dc.w 51,98
 dc.w 50,99
 dc.w 48,99
 dc.w 47,99
 dc.w 45,99
 dc.w 44,99
 dc.w 43,98
 dc.w 41,97
 dc.w 40,95
 dc.w 38,93
 dc.w 37,91
 dc.w 36,89
 dc.w 34,86
 dc.w 33,83
 dc.w 32,80
 dc.w 30,77
 dc.w 29,73
 dc.w 28,69
 dc.w 27,65
 dc.w 26,61
 dc.w 25,57
 dc.w 23,53
 dc.w 22,49
 dc.w 21,45
 dc.w 20,41
 dc.w 19,37
 dc.w 18,33
 dc.w 17,29
 dc.w 16,25
 dc.w 15,22
 dc.w 15,18
 dc.w 14,15
 dc.w 13,12
 dc.w 12,10
 dc.w 11,7
 dc.w 11,5
 dc.w 10,3
 dc.w 9,2
 dc.w 9,1
 dc.w 8,0
 dc.w 7,0
 dc.w 7,0
 dc.w 6,0
 dc.w 6,0
 dc.w 5,1
 dc.w 5,3
 dc.w 4,4
 dc.w 4,6
 dc.w 4,8
 dc.w 3,11
 dc.w 3,14
 dc.w 3,17
 dc.w 2,20
 dc.w 2,23
 dc.w 2,27
 dc.w 2,31
 dc.w 2,35
 dc.w 2,39
 dc.w 2,43
 dc.w 2,47
 dc.w 2,51
 dc.w 2,55
 dc.w 2,60
 dc.w 2,64
 dc.w 2,68
 dc.w 2,71
 dc.w 2,75
 dc.w 2,78
 dc.w 3,82
 dc.w 3,85
 dc.w 3,88
 dc.w 3,90
 dc.w 4,93
 dc.w 4,94
 dc.w 5,96
 dc.w 5,97
 dc.w 6,98
 dc.w 6,99
 dc.w 7,99
 dc.w 7,99
 dc.w 8,99
 dc.w 8,98
 dc.w 9,97
 dc.w 10,96
 dc.w 10,94
 dc.w 11,92
 dc.w 12,90
 dc.w 13,87
 dc.w 14,84
 dc.w 14,81
 dc.w 15,78
 dc.w 16,74
 dc.w 17,71
 dc.w 18,67
 dc.w 19,63
 dc.w 20,59
 dc.w 21,55
 dc.w 22,51
 dc.w 23,46
 dc.w 24,42
 dc.w 26,38
 dc.w 27,34
 dc.w 28,30
 dc.w 29,27
 dc.w 30,23
 dc.w 32,19
 dc.w 33,16
 dc.w 34,13
 dc.w 35,11
 dc.w 37,8
 dc.w 38,6
 dc.w 39,4
 dc.w 41,2
 dc.w 42,1
 dc.w 44,0
 dc.w 45,0
 dc.w 47,0
 dc.w 48,0
 dc.w 50,0
 dc.w 51,1
 dc.w 53,2
 dc.w 54,4
 dc.w 56,5
 dc.w 57,7
 dc.w 59,10
 dc.w 61,13
 dc.w 62,15
 dc.w 64,19
 dc.w 66,22
 dc.w 67,26
 dc.w 69,29
 dc.w 71,33
 dc.w 72,37
 dc.w 74,41
 dc.w 76,45
 dc.w 78,50
 dc.w 79,54
 dc.w 81,58
 dc.w 83,62
 dc.w 85,66
 dc.w 86,70
 dc.w 88,74
 dc.w 90,77
 dc.w 92,81
 dc.w 94,84
 dc.w 95,87
 dc.w 97,89
 dc.w 99,92
 dc.w 101,94
 dc.w 103,96
 dc.w 104,97
 dc.w 106,98
 dc.w 108,99
 dc.w 110,99
