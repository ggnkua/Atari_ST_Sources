 dc.l 40-25
 dc.l 40-25
 dc.l 41-25
 dc.l 42-25
 dc.l 43-25
 dc.l 44-25
 dc.l 45-25
 dc.l 46-25
 dc.l 47-25
 dc.l 48-25
 dc.l 48-25
 dc.l 49-25
 dc.l 50-25
 dc.l 50-25
 dc.l 51-25
 dc.l 52-25
 dc.l 52-25
 dc.l 53-25
 dc.l 53-25
 dc.l 53-25
 dc.l 54-25
 dc.l 54-25
 dc.l 54-25
 dc.l 54-25
 dc.l 54-25
 dc.l 55-25
 dc.l 54-25
 dc.l 54-25
 dc.l 54-25
 dc.l 54-25
 dc.l 54-25
 dc.l 53-25
 dc.l 53-25
 dc.l 53-25
 dc.l 52-25
 dc.l 52-25
 dc.l 51-25
 dc.l 50-25
 dc.l 50-25
 dc.l 49-25
 dc.l 48-25
 dc.l 48-25
 dc.l 47-25
 dc.l 46-25
 dc.l 45-25
 dc.l 44-25
 dc.l 43-25
 dc.l 42-25
 dc.l 41-25
 dc.l 40-25
 dc.l 40-25
 dc.l 39-25
 dc.l 38-25
 dc.l 37-25
 dc.l 36-25
 dc.l 35-25
 dc.l 34-25
 dc.l 33-25
 dc.l 32-25
 dc.l 31-25
 dc.l 31-25
 dc.l 30-25
 dc.l 29-25
 dc.l 29-25
 dc.l 28-25
 dc.l 27-25
 dc.l 27-25
 dc.l 26-25
 dc.l 26-25
 dc.l 26-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 25-25
 dc.l 26-25
 dc.l 26-25
 dc.l 26-25
 dc.l 27-25
 dc.l 27-25
 dc.l 28-25
 dc.l 29-25
 dc.l 29-25
 dc.l 30-25
 dc.l 31-25
 dc.l 31-25
 dc.l 32-25
 dc.l 33-25
 dc.l 34-25
 dc.l 35-25
 dc.l 36-25
 dc.l 37-25
 dc.l 38-25
 dc.l 39-25
