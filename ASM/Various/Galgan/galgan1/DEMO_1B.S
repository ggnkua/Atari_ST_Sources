* No name
	*opt	x+,o+
	bra.s	GONE
	dc.b	'Pierdol sie kutasie '
	dc.b	'od tego kodu, jebany '
	dc.b	'spermopiju i tryplojadzie  '
	even
GONE	dc.l	$a000a00a
	move.w	#4,-(a7)
	trap	#14
	addq.l	#2,a7
	move.w	d0,(save_res)
	move.w	#2,-(a7)
	trap	#14
	addq.l	#2,a7
	move.l	d0,(save_phys)
	move.w	#3,-(a7)
	trap	#14
	addq.l	#2,a7
	move.l	d0,(save_log)
	clr.l	-(a7)
	move.w	#$20,-(a7)
	trap	#1
	addq.l	#6,a7
	move.l	d0,save_a7
	movem.l	$ffff8240.w,d0-d7
	movem.l	d0-d7,(save_colors)
	movem.l	akcja,d0-d7/a0-a6
	clr.w	-(a7)
	pea	$78000
	move.l	(a7),-(a7)
 	move.w	#5,-(a7)
	trap	#14
	lea	12(a7),a7 
	pea	palette(pc)
	move.w	#6,-(a7)
	trap	#14
	addq.l	#6,a7
	move.b	#2,$484.w	
	movem.l	d0-d7,-(a7)
	move.l	$120.w,(save_120)
	movem.l	$fffffa00.w,d0-d7
	movem.l	d0-d7,(save_mfp)
	move.b	#$12,$fffffc02.w
	movem.l	(a7)+,d0-d7
	and.b	#$df,$fffffa09.w
	moveq	#1,d0
	bsr	(music)
	move.l	#vbl,$4d2.w
	move.b	#64,$fffffa17.w
	stop	#$2300
	lea	$78000+48,a1
	lea	picture1(pc),a2
	lea	tabble1(pc),a4 
	moveq	#0,d6
	move.l	a1,a3
	movem.l	d0-d7/a0-a6,save_jmp
	lea	pictureq(pc),a2
	lea	$7d008-30*160,a3
	lea	$7d000+$a0-24-40*160,a6
	lea	tabq(pc),a4
	move.l	a6,d6
	move.l	a3,d3
	moveq	#0,d4
	movem.l	d0-d7/a0-a6,save_quast
	moveq	#0,d4
	lea	picture0(pc),a2
	lea	$7d028-$10*$a0,a3
	lea	sin(pc),a4
	movem.l	d4/a2-a4,save_g
	lea	picture_2(pc),a2
	lea	$7d038-$10*$a0,a3
	lea	sin1(pc),a4
	movem.l	d4/a2-a4,save_a
	lea	picture_3(pc),a2
	lea	$7d048-$10*$a0,a3
	lea	sin2(pc),a4
	movem.l	d4/a2-a4,save_l
	lea	picture_4(pc),a2
	lea	$7d058-$10*$a0,a3
	lea	sin3(pc),a4
	movem.l	d4/a2-a4,save_g1
	lea	picture_5(pc),a2
	lea	$7d068-$10*$a0,a3
	lea	sin4(pc),a4
	movem.l	d4/a2-a4,save_a1
	lea	picture_6(pc),a2
	lea	$7d078-$10*$a0,a3
	lea	sin5(pc),a4
	movem.l	d4/a2-a4,save_n
key:
	bsr	vbl_sync
	bsr.s	jmp
	bsr.s	fuck
	bsr	g
	bsr	a
	bsr	l
	bsr	g1
	bsr	a1
	bsr	n
	bsr	scroll
	bsr	dawaj
	cmp.b	#$39,$fffffc02.w
	beq	end
	bra.s	key
jmp:
	movem.l	save_jmp(pc),d0-d7/a0-a6
	move.l	a3,a1
   	move.w	#$57,d7
copy1:
	movem.l	(a2)+,d0-d5/a0/a5-a6
	movem.l	d0-d5/a0/a5-a6,(a1)
	movem.l	(a2)+,d0-d5/a0/a5-a6
	movem.l	d0-d5/a0/a5-a6,36(a1)
	lea	$a0(a1),a1
	dbf	d7,copy1
	add.w	0(a4,d6.w),a3
	addq.w	#2,d6 
	lea	picture1(pc),a2         
	tst.w	(a4,d6.w)
	bne.s	nie_tera
	moveq	#0,d6
	lea	$78000+48,a3 
nie_tera:
	movem.l	d0-d7/a0-a6,save_jmp
	rts
fuck:
	movem.l	save_quast(pc),d0-d7/a0-a6
	move.l	d3,a3
	move.l	d6,a6
	moveq	#$23,d7
shit:
	movem.l	(a2)+,d0-d2
	movem.l	d0-d2,(a3)
	movem.l	d0-d2,(a6)
	movem.l	(a2)+,d0-d2
	movem.l	d0-d2,12(a3)
	movem.l	d0-d2,12(a6)
	lea	$a0(a3),a3
	lea	$a0(a6),a6
	dbf	d7,shit
	sub.w	(a4,d4.w),d6
	add.w	(a4,d4.w),d3
	move.l	d3,a3
	move.l	d6,a6
	addq.w	#2,d4
	tst.w	(a4,d4.w)
	bne.s	jeszcze_nie
	moveq	#0,d4
jeszcze_nie:
	lea	pictureq(pc),a2
	movem.l	d0-d7/a0-a6,save_quast
	rts
g:
	movem.l	save_g(pc),d4/a2-a4
	move.l	a3,-(a7)
	moveq	#$10,d7	
copy_9:
	movem.l	(a2)+,d0-d3
	movem.l	d0-d3,(a3)
	lea	$a0(a3),a3
	dbf	d7,copy_9
	addq.w	#2,d4  
	move.l	(a7)+,a3
	cmp.w   #-1,(a4,d4.w)
	bne.s	daley
	moveq	#0,d4
daley:
	add.w	(a4,d4.w),a3
	lea	picture0(pc),a2
	movem.l	d4/a2-a4,save_g
	rts
a:
	movem.l	save_a(pc),d4/a2-a4
	move.l	a3,-(a7)
	moveq	#$10,d7	
copy_90:
	movem.l	(a2)+,d0-d3
	movem.l	d0-d3,(a3)
	lea	$a0(a3),a3
	dbf	d7,copy_90
	addq.w	#2,d4
	move.l	(a7)+,a3
	cmp.w   #-1,(a4,d4.w)
	bne.s	daley1
	moveq	#0,d4
daley1:
	add.w	(a4,d4.w),a3
 	lea	picture_2(pc),a2
	movem.l	d4/a2-a4,save_a
	rts
l:
	movem.l	save_l(pc),d4/a2-a4
	move.l	a3,-(a7)
	moveq	#$10,d7	
copy_91:
	movem.l	(a2)+,d0-d3
	movem.l	d0-d3,(a3)
	lea	$a0(a3),a3
	dbf	d7,copy_91
	addq.w	#2,d4  
	move.l	(a7)+,a3
	cmp.w   #-1,(a4,d4.w)
	bne.s	daley2
	moveq	#0,d4
daley2:
	add.w	(a4,d4.w),a3
	lea	picture_3(pc),a2
	movem.l	d4/a2-a4,save_l
	rts
g1:
	movem.l	save_g1(pc),d4/a2-a4
	move.l	a3,-(a7)
	moveq	#$10,d7	
copy_93:
	movem.l	(a2)+,d0-d3
	movem.l	d0-d3,(a3)
	lea	$a0(a3),a3
	dbf	d7,copy_93
	addq.w	#2,d4  
	move.l	(a7)+,a3
	cmp.w   #-1,(a4,d4.w)
	bne.s	daley3
	moveq	#0,d4
daley3:
	add.w	(a4,d4.w),a3
	lea	picture_4(pc),a2
	movem.l	d4/a2-a4,save_g1
	rts
a1:
	movem.l	save_a1(pc),d4/a2-a4
	move.l	a3,-(a7)
	moveq	#$10,d7	
copy_94:
	movem.l	(a2)+,d0-d3
	movem.l	d0-d3,(a3)
	lea	$a0(a3),a3
	dbf	d7,copy_94
	addq.w	#2,d4  
	move.l	(a7)+,a3
	cmp.w   #-1,(a4,d4.w)
	bne.s	daley4
	moveq	#0,d4
daley4:
	add.w	(a4,d4.w),a3
	lea	picture_5(pc),a2
	movem.l	d4/a2-a4,save_a1
	rts
n:
	movem.l	save_n(pc),d4/a2-a4
	move.l	a3,-(a7)
	moveq	#$10,d7	
copy_95:
	movem.l	(a2)+,d0-d3
	movem.l	d0-d3,(a3)
	lea	$a0(a3),a3
	dbf	d7,copy_95
	addq.w	#2,d4  
	move.l	(a7)+,a3
	cmp.w   #-1,(a4,d4.w)
	bne.s	daley5
	moveq	#0,d4
daley5:
	add.w	(a4,d4.w),a3
	lea	picture_6(pc),a2
	movem.l	d4/a2-a4,save_n
	rts
palette: dc.w    $0000,$0714,$089F,$0726,$089C,$09F6,$0760,$0144
      	dc.w	$0117,$001F,$0370,$0117,$0167,$0165,$0705,$0726
tabble1: dc.w	160,160,160,160,160,160,160,160,160,160,160,160,160,160,160,160,160,160,160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,0
tabq:	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-160
	dc.w	160,160,160,160,160,160,160,160,160,160,160,160,160,160,0
sin:	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-1
sin1:	dc.w	0
 	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-1
sin2:	dc.w	0,0
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-1
sin3:	dc.w	0,0,0
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-1
sin4:	dc.w	0,0,0,0
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-1
sin5:	dc.w	0,0,0,0,0
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	160,160,160,160,160,160,160,160,160,160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160
	dc.w	-160,-160,-160,-160,-160,-160,-160,-160,-160,-160,-1	
	dc.w	0
picture1:
	ds.l	18
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
	dc.w	$7FE0,$001F,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0001,$FFFE,$0000,$0000
	dc.w	$FF00,$0000,$0000,$0000,$7FC0,$003F,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$FF00,$0000,$0000,$0000
	dc.w	$7F80,$007F,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$7F00,$8000,$0000,$0000,$7F00,$00FF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$3F00,$C000,$0000,$0000
	dc.w	$7E00,$01FF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$1F00,$E000,$0000,$0000,$7C00,$03FF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0F00,$F000,$0000,$0000
	dc.w	$7800,$07FF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0700,$F800,$0000,$0000,$7000,$0FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0300,$FC00,$0000,$0000
	dc.w	$6000,$1FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$07FC,$0000,$0000,$FFFF,$7C7C,$0000
	dc.w	$0000,$FFFF,$7FC1,$0000,$0000,$FFFF,$FFDF,$0000
	dc.w	$0000,$FFFF,$FF00,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$03F8,$FC07,$0404,$0000
	dc.w	$3838,$C7C7,$4444,$0000,$3F80,$C07F,$4041,$0000
	dc.w	$FF8F,$0070,$0050,$0000,$FE00,$01FF,$0100,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$03F8,$FC07,$1C07,$0000,$3838,$C7C7,$4445,$0000
	dc.w	$3F80,$C07F,$C077,$0000,$FF8F,$0070,$0050,$0000
	dc.w	$FE00,$01FF,$0100,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0E0E,$F1F1,$11F1,$0000
	dc.w	$3838,$C7C7,$4445,$0000,$E0E3,$1F1C,$1F14,$0000
	dc.w	$8000,$7FFF,$7FDF,$0000,$E000,$1FFF,$1F00,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0E0E,$F1F1,$1111,$0000,$3838,$C7C7,$4445,$0000
	dc.w	$E0E3,$1F1C,$1F14,$0000,$8000,$7FFF,$7F01,$0000
	dc.w	$E000,$1FFF,$1000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0E0E,$F1F1,$1111,$0000
	dc.w	$3838,$C7C7,$4445,$0000,$FFE0,$001F,$0017,$0000
	dc.w	$FE00,$01FF,$0101,$0000,$E000,$1FFF,$1000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0E0E,$F1F1,$1111,$0000,$3838,$C7C7,$4445,$0000
	dc.w	$FFE0,$001F,$0011,$0000,$FE00,$01FF,$01C1,$0000
	dc.w	$E000,$1FFF,$1000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0E0E,$F1F1,$1111,$0000
	dc.w	$3838,$C7C7,$4445,$0000,$E0E0,$1F1F,$1F11,$0000
	dc.w	$0380,$FC7F,$FC41,$0000,$E000,$1FFF,$1000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0E0E,$F1F1,$11F1,$0000,$3838,$C7C7,$47C5,$0000
	dc.w	$E0E0,$1F1F,$1117,$0000,$0380,$FC7F,$FC41,$0000
	dc.w	$E000,$1FFF,$1000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$03F8,$FC07,$1C07,$0000
	dc.w	$0FF8,$F007,$7005,$0000,$E0E3,$1F1C,$1114,$0000
	dc.w	$FE00,$01FF,$01C1,$0000,$E000,$1FFF,$1000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$03F8,$FC07,$0407,$0000,$0FF8,$F007,$1005,$0000
	dc.w	$E0E3,$1F1C,$1114,$0000,$FE00,$01FF,$0101,$0000
	dc.w	$E000,$1FFF,$1000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$003E,$FFC1,$07C1,$0000
	dc.w	$0000,$FFFF,$1FFD,$0000,$0000,$FFFF,$F1F7,$0000
	dc.w	$0000,$FFFF,$FF01,$0000,$0000,$FFFF,$F000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$003E,$FFC1,$0041,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$007F,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4001,$3FFE,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFF0,$000F,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4001,$3FFE,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFF0,$000F,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$03E3,$0000
	dc.w	$0000,$FFFF,$E3FE,$0000,$0000,$FFFF,$0FFE,$0000
	dc.w	$0000,$FFFF,$3FE0,$0000,$0000,$FFFF,$FFE3,$0000
	dc.w	$0000,$FFFF,$FE3E,$0000,$0000,$FFFF,$3E00,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$01C1,$FE3E,$0222,$0000,$C1FC,$3E03,$2202,$0000
	dc.w	$07FC,$F803,$0802,$0000,$1FC0,$E03F,$2020,$0000
	dc.w	$7FC1,$803E,$8022,$0000,$FC1C,$03E3,$0222,$0000
	dc.w	$1C00,$E3FF,$2200,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$01C1,$FE3E,$023E,$0000
	dc.w	$C1FC,$3E03,$2E03,$0000,$07FC,$F803,$B802,$0000
	dc.w	$1FC0,$E03F,$E03B,$0000,$7FC1,$803E,$8022,$0000
	dc.w	$FC1C,$03E3,$0223,$0000,$1C00,$E3FF,$A200,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$01F7,$FE08,$0208,$0000,$C707,$38F8,$28F8,$0000
	dc.w	$1C00,$E3FF,$A3FE,$0000,$7071,$8F8E,$8F8A,$0000
	dc.w	$C000,$3FFF,$3FE3,$0000,$701F,$8FE0,$8E20,$0000
	dc.w	$1C00,$E3FF,$A200,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$01F7,$FE08,$0208,$0000
	dc.w	$C707,$38F8,$28F8,$0000,$1C00,$E3FF,$A2FE,$0000
	dc.w	$7071,$8F8E,$8F8A,$0000,$C000,$3FFF,$3F80,$0000
	dc.w	$701F,$8FE0,$8820,$0000,$1C00,$E3FF,$E200,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$01DD,$FE22,$0222,$0000,$C7FF,$3800,$2800,$0000
	dc.w	$1C7C,$E383,$A282,$0000,$7FF0,$800F,$800B,$0000
	dc.w	$7F00,$80FF,$8080,$0000,$701D,$8FE2,$8822,$0000
	dc.w	$DC00,$23FF,$2200,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$01DD,$FE22,$0222,$0000
	dc.w	$C7FF,$3800,$2800,$0000,$1C7C,$E383,$A282,$0000
	dc.w	$7FF0,$800F,$8008,$0000,$7F00,$80FF,$80E0,$0000
	dc.w	$701D,$8FE2,$8822,$0000,$DC00,$23FF,$2200,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$01C1,$FE3E,$023E,$0000,$C707,$38F8,$28F8,$0000
	dc.w	$1C1C,$E3E3,$A2E2,$0000,$7070,$8F8F,$8F88,$0000
	dc.w	$01C0,$FE3F,$FE20,$0000,$701C,$8FE3,$8823,$0000
	dc.w	$7C00,$83FF,$8200,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$01C1,$FE3E,$0222,$0000
	dc.w	$C707,$38F8,$2888,$0000,$1C1C,$E3E3,$A3E2,$0000
	dc.w	$7070,$8F8F,$888B,$0000,$01C0,$FE3F,$FE23,$0000
	dc.w	$701C,$8FE3,$8E22,$0000,$7C00,$83FF,$8200,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$01C1,$FE3E,$0222,$0000,$C707,$38F8,$2888,$0000
	dc.w	$07FC,$F803,$B802,$0000,$7071,$8F8E,$888A,$0000
	dc.w	$FF01,$00FE,$00E2,$0000,$FC1C,$03E3,$0222,$0000
	dc.w	$1C00,$E3FF,$E200,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$01C1,$FE3E,$0222,$0000
	dc.w	$C707,$38F8,$2888,$0000,$07FC,$F803,$8802,$0000
	dc.w	$7071,$8F8E,$888A,$0000,$FF01,$00FE,$0082,$0000
	dc.w	$FC1C,$03E3,$0222,$0000,$1C00,$E3FF,$2200,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$03E3,$0000,$0000,$FFFF,$EF8F,$0000
	dc.w	$0000,$FFFF,$8FFE,$0000,$0000,$FFFF,$F8FB,$0000
	dc.w	$0000,$FFFF,$FF83,$0000,$0000,$FFFF,$FE3E,$0000
	dc.w	$0000,$FFFF,$3E00,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$4000,$3FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$4000,$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0100,$FE00,$0000,$0000,$6000,$1FFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0100,$FE00,$0000,$0000
	dc.w	$7000,$0FFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0300,$FC00,$0000,$0000,$7800,$07FF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0700,$F800,$0000,$0000
	dc.w	$7C00,$03FF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0F00,$F000,$0000,$0000,$7E00,$01FF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$1F00,$E000,$0000,$0000
	dc.w	$7F00,$00FF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$3F00,$C000,$0000,$0000,$7F80,$007F,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$7F00,$8000,$0000,$0000
	dc.w	$7FC0,$003F,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$FF00,$0000,$0000,$0000,$7FE0,$001F,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000
	dc.w	$0001,$FFFE,$0000,$0000,$FF00,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FF00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	ds.l	20
pictureq:
	ds.b	$18
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$7FFF
	dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$F000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFE,$3FFE,$4000
	dc.w	$FFFF,$49FF,$49FF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFE,$3FFE,$4000,$FFFF,$49FF,$49FF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFE,$3FFE,$4000
	dc.w	$FFFF,$49FF,$49FF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFE,$3FFE,$4000,$FFFF,$49FF,$49FF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFC,$3FFC,$4000
	dc.w	$FFFF,$48FF,$48FF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFC,$3FFC,$4000,$FFFF,$48FF,$48FF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FF8,$3FF8,$4000
	dc.w	$FFFF,$487F,$487F,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FF0,$3FF0,$4000,$FFFF,$CC3F,$CC3F,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FE0,$3FE0,$4000
	dc.w	$FFFF,$CC1F,$CC1F,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FE1,$3FE1,$4000,$FFFF,$CE1F,$CE1F,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FE1,$3FE1,$4000
	dc.w	$FFFF,$CE1F,$CE1F,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FE3,$3FE3,$4000,$FFFF,$CF1F,$CF1F,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FE7,$3FE7,$4000
	dc.w	$FFFF,$CF9F,$CF9F,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$3FFF,$3FFF,$3FFF,$4000
	dc.w	$FFFF,$FFFF,$FFFF,$0000,$E000,$E000,$E000,$1000
	dc.w	$3FFF,$3FFF,$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000
	dc.w	$E000,$E000,$E000,$1000,$0000,$0000,$0000,$7FFF
	dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$F000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.l	18
picture0:
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63FF,$3FFE,$5C01,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63FF,$3FFE,$5C01,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6383,$3FFE,$5C7D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6383,$3FFE,$5C7D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
picture_2:
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$780F,$3FFE,$47F1,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$780F,$3FFE,$47F1,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6003,$3FFE,$5FFD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6003,$3FFE,$5FFD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
picture_3:
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$78FF,$3FFE,$4701,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$78FF,$3FFE,$4701,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$78DF,$3FFE,$4721,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$789F,$3FFE,$4761,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$783F,$3FFE,$47C1,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$787F,$3FFE,$4781,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$78FF,$3FFE,$4701,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$78FF,$3FFE,$4701,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
picture_4:
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63FF,$3FFE,$5C01,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63FF,$3FFE,$5C01,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6383,$3FFE,$5C7D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6383,$3FFE,$5C7D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7803,$3FFE,$47FD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
picture_5:
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$780F,$3FFE,$47F1,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$780F,$3FFE,$47F1,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6003,$3FFE,$5FFD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6003,$3FFE,$5FFD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
picture_6:
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$60E3,$3FFE,$5F1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$60E3,$3FFE,$5F1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6223,$3FFE,$5DDD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6223,$3FFE,$5DDD,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6383,$3FFE,$5C7D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$6383,$3FFE,$5C7D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$63E3,$3FFE,$5C1D,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$3FFE,$4001,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$7FFF,$0000,$7FFF,$7FFF,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	ds.l	20
dawaj:	movem.l	(akcja)(pc),d0-d7/a0-a4
	lea	$ffff8800.w,a1
	moveq	#0,d1
	move.w	#$fffe,d2
	move.w	#$1e0,d3
	move.w	#$10,d5
	moveq	#8,d4
	lea	$7d000-70*$a0,a0
	bsr	equal
	moveq	#0,d1
	moveq	#10,d4
	lea	$7d0a0-$18-70*$a0,a0
	bsr	equal
	moveq	#9,d4
	moveq	#0,d1
	lea	$7d008-70*$a0,a0
	bsr	equal
	moveq	#9,d4
	moveq	#0,d1
	lea	$7d0a0-$10-70*$a0,a0
	bsr	equal
	moveq	#10,d4
	moveq	#0,d1
	lea	$7d010-70*$a0,a0
	bsr	equal
	moveq	#8,d4
	moveq	#0,d1
	lea	$7d0a0-$08-70*$a0,a0
	bsr	equal
	rts
c:	clr.w	kolej
	clr.w	tabble
scroll:
*	movem.l	(akcja),d0-d7/a0-a6
	tst.w	control
	bpl.s	rol
	move.w	lit(pc),d0
	lea	txt(pc),a1
	move.b	(a1,d0.w),d0
	tst.b	d0
	bne.s	jeszcze
	move.b	(a1),d0
	clr.w	lit
jeszcze	and.l	#$ff,d0
	addq.w	#1,lit
	sub.w	#32,d0
	add.w	d0,d0
	add.w	d0,d0
	lea	przesun(pc),a1
	add.l	d0,a1
	move.l	(a1),a1
	add.l	#picture,a1
	move.l	a1,adr
	move.w	#24,control
rol	move.w	control(pc),d0
	move.l 	adr(pc),a0
	lea 	$78000+160*161,a1
	move.w 	#24,d3
move	move.w 	(a0),d2
	swap 	d2
	move.w 	2(a0),d2
	lsr.l 	d0,d2
    	move.b 	1(a1),(a1)
    	move.b 	8(a1),1(a1)
    	move.b 	9(a1),8(a1)
    	move.b 	16(a1),9(a1)
    	move.b 	17(a1),16(a1)
    	move.b 	24(a1),17(a1)
    	move.b 	25(a1),24(a1)
    	move.b 	32(a1),25(a1)
    	move.b 	33(a1),32(a1)
    	move.b 	40(a1),33(a1)
    	move.b 	41(a1),40(a1)
    	move.b 	48(a1),41(a1)
    	move.b 	49(a1),48(a1)
    	move.b 	56(a1),49(a1)
    	move.b 	57(a1),56(a1)
    	move.b 	64(a1),57(a1)
    	move.b 	65(a1),64(a1)
    	move.b 	72(a1),65(a1)
    	move.b 	73(a1),72(a1)
    	move.b 	80(a1),73(a1)
    	move.b 	81(a1),80(a1)
    	move.b 	88(a1),81(a1)
    	move.b 	89(a1),88(a1)
    	move.b 	96(a1),89(a1)
    	move.b 	97(a1),96(a1)
    	move.b 	104(a1),97(a1)
    	move.b 	105(a1),104(a1)
    	move.b 	112(a1),105(a1)
    	move.b 	113(a1),112(a1)
    	move.b 	120(a1),113(a1)
    	move.b 	121(a1),120(a1)
    	move.b 	128(a1),121(a1)
    	move.b 	129(a1),128(a1)
    	move.b 	136(a1),129(a1)
    	move.b 	137(a1),136(a1)
    	move.b 	144(a1),137(a1)
    	move.b 	145(a1),144(a1)
    	move.b 	152(a1),145(a1)
    	move.b 	153(a1),152(a1)
    	move.b 	d2,153(a1)
  	addq.l 	#4,a0
  	lea 	160(a1),a1
	dbf 	d3,move
	subq.w	#8,control
	rts
lit	ds.w	1
adr	ds.l	1
kupa	ds.w	1
control	dc.w	-8
vbl_sync:
;	move.w	#-1,$ffff8240.w
	move.w	#37,-(a7)
	trap	#14
	addq.l	#2,a7
;	clr.w	$ffff8240.w
	rts
equal:	move.b	d4,(a1)
	move.b	(a1),d1
;	cmp.b	d5,d1
;	bge	key
plot:	move.w	d2,(a0)
	move.w	d2,$a0(a0)
	sub.w	d3,a0
	dbf	d1,plot
	moveq	#$0f,d0
clr:	clr.w	(a0)
	clr.w	$a0(a0)
	sub.w	d3,a0
	dbf	d0,clr
	rts
end:	move.b	#$11,$fffffc02.w
	move.b	#8,$fffffc02.w
	move.l	(save_120),$120.w
	movem.l	(save_mfp),d0-d7
	movem.l	d0-d7,$fffffa00.w
	lea 	$ffff8800.w,a0	
	move.l 	#$0707ffff,(a0)
	move.l 	#$08080000,(a0)
	move.l 	#$09090000,(a0)
	move.l 	#$0a0a0000,(a0)
	move.b	#$c0,$fffffa23.w
	clr.l	$4d2.w
	move.b	#7,$484.w
	movem.l	(save_colors),d0-d7
	movem.l	d0-d7,$ffff8240.w
	move.w	(save_res),-(a7)
	move.l	(save_phys),-(a7)
	move.l	(save_log),-(a7)
	move.w	#5,-(a7)
	trap	#14
	add.l	#12,a7
	move.l	save_a7,-(a7)
	move.w	#$20,-(a7)
	trap	#1
	addq.l	#6,a7
	clr.l	-(a7)
	trap	#1   
	illegal
vbl:	bsr	(music+8) 
	clr.b	$fffffa1b.w
	or.b	#1,$fffffa07.w
	or.b	#1,$fffffa13.w
	move.b	#7,$fffffa21.w
	move.l	#hbl,$120.w
	move.b	#8,$fffffa1b.w
	rts
hbl:	move.w	#$e72,$ffff8242.w
	clr.b	$fffffa1b.w
	move.b	#8,$fffffa21.w
	move.b	#8,$fffffa1b.w
	move.l	#hbl_1,$120.w
	rte
hbl_1:	move.w	#$e62,$ffff8242.w
	move.l	#hbl_2,$120.w
	rte
hbl_2:	move.w	#$e52,$ffff8242.w
	move.l	#hbl_3,$120.w
	rte
hbl_3:	move.w	#$e42,$ffff8242.w
	move.l	#hbl_4,$120.w
	rte
hbl_4:	move.w	#$e32,$ffff8242.w
	move.l	#hbl_5,$120.w
	rte
hbl_5:	move.w	#$e22,$ffff8242.w
	move.l	#hbl_6,$120.w
	rte
hbl_6:	move.w	#$e12,$ffff8242.w
	move.l	#hbl_7,$120.w
	rte
hbl_7:	move.w	#$0d8,$ffff8242.w
	move.l	#hbl_8,$120.w
	rte
hbl_8:	move.w	#$e12,$ffff8242.w
	move.l	#hbl_9,$120.w
	rte
hbl_9:	move.w	#$e22,$ffff8242.w
 	move.l	#hbl_10,$120.w
	rte
hbl_10:	move.w	#$e32,$ffff8242.w
	move.l	#hbl_11,$120.w
	rte
hbl_11:	move.w	#$e42,$ffff8242.w
	move.l	#hbl_12,$120.w
	rte
hbl_12:	move.w	#$e52,$ffff8242.w
	move.l	#hbl_13,$120.w
	rte
hbl_13:	move.w	#$e62,$ffff8242.w
	move.l	#hbl_14,$120.w
	rte
hbl_14:	move.w	#$e72,$ffff8242.w
	move.l	#hbl_15,$120.w
	rte
hbl_15:	move.w	#$000,$ffff8240.w
	move.l	#hbl_16,$120.w
	rte
hbl_16:	move.w	#$000,$ffff8240.w
	move.l	#hbl_18,$120.w
	rte
hbl_18:	move.b	#1,$fffffa21.w
	move.b	#8,$fffffa1b.w
	move.l	#hbl_19,$120.w
	rte
hbl_19:	move.w	#$0c8,$ffff8240.w
	move.l	#hbl_20,$120.w
	rte
hbl_20:	move.w	#$0d8,$ffff8240.w
	move.l	#hbl_21,$120.w
	rte
hbl_21:	move.w	#$0e8,$ffff8240.w
	move.l	#hbl_22,$120.w
	rte
hbl_22:	move.w	#$0f8,$ffff8240.w
	move.l	#hbl_23,$120.w
	rte
hbl_23:	move.w	#$0e8,$ffff8240.w
	move.l	#hbl_24,$120.w
	rte
hbl_24:	move.w	#$0d8,$ffff8240.w
	move.l	#hbl_25,$120.w
	rte
hbl_25:	move.w	#$0c8,$ffff8240.w
	move.l	#hbl_26,$120.w
	rte
hbl_26:	clr.b	$fffffa1b.w
	move.b	#32,$fffffa21.w
	move.b	#8,$fffffa1b.w
	move.w	#$000,$ffff8240.w
	move.l	#hbl_27,$120.w
	rte
hbl_27:	clr.b	$fffffa1b.w
	move.b	#1,$fffffa21.w
	move.b	#8,$fffffa1b.w
	move.b	#$0c8,$ffff8240.w
	move.l	#hbl_20a,$120.w
	rte
hbl_20a: move.w	#$0d8,$ffff8240.w
	move.l	#hbl_21,$120.w
	rte
hbl_21a: move.w	#$0e8,$ffff8240.w
	move.l	#hbl_22,$120.w
	rte
hbl_22a: move.w	#$0f8,$ffff8240.w
	move.l	#hbl_23,$120.w
	rte
hbl_23a: move.w	#$0e8,$ffff8240.w
	move.l	#hbl_24,$120.w
	rte
hbl_24a: move.w	#$0d8,$ffff8240.w
	move.l	#hbl_25,$120.w
	rte
hbl_25a: move.w	#$0c8,$ffff8240.w
	move.l	#hbl_33,$120.w
	rte
hbl_33:	clr.b	$fffffa1b.w
	rte
save_120: ds.l	1
save_mfp: ds.l	30
scan_line: ds.l	1
tabble:	ds.w	1
kolej:	ds.w	1
save_colors: ds.l 15
akcja:	ds.l	30
save_sp: ds.l	1
hit:	ds.w	1
ile:	ds.w	1
save_reg: ds.l	15
save_sys: ds.l	1
save_jmp: ds.l	16
save_quast: ds.l 16
save_g:	ds.l	4
save_a:	ds.l	4
save_l:	ds.l	4
save_g1: ds.l	4
save_a1: ds.l	4
save_n:	ds.l	4
save_res: ds.w	1
save_phys: ds.l	1
save_log: ds.l	1
save_a7: ds.l	1
	even
txt:	dc.b	'  B*EEEEEEEE...  SIE MA.  TU GA*GAN.  NA POCZ#TEK KILKA S*<W O TYM DEMIE. POWSTA*O ONO W DEVPAC-U 2.23.   TOTALN# MUZYCZK% '
	dc.b	'STWORZY* JOCHEN HIPPEL (DLA LAMER<W MAD MAX). RADZ% POS*UCHA$ JEJ CA*EJ CZYTAJ#C G*UPOTY W TYM SKROLU...'
	dc.b	'   DOBRA, Z TYM JU[ KONIEC. TERA PORA NA POZDROWIENIA (W KOLEJNO>CI PRZYPADKOWEJ I NIC NIE ZNACZ#CEJ) A WI%C:        '
	dc.b	'SUPER CODER........ CZYLI '
	dc.b	'=VAT=, ORAZ JEGO KUMPLE,         MESSIAH - M<J ODJAZDOWY BRACIAK (METAL TAK JAK JA),'
	dc.b	' ANDREAS, (KT<RY OSTRO KODUJE JOY',$27,'EM W KICK-OFF',$27,'A 2), DYMIN - JEDYNY AMIGOWIEC, Z KT<RYM MO[NA O CZYM> POROZMAWIA$ I KTORY UZNAJE ZALETY ATARI ST(E),'
	dc.b	' WRONEK, GRAJ#CY ZAWODOWO NA KLASYCZNYCH ORGANACH I'
	dc.b	' KT<RY NIGDY NIE MA CZASU NA STWORZENIE ZE MN# MUZYKI PRZEZ MIDI ZA POMOC# MOJEJ 1040-STKI STE I JEGO CASIO, CO PRZEBIEGA*O BY O TYLE SPRAWNIE [E MAJ# POKREWNE SOUND-CHIPY TYPU ',$27,'PCM',$27,'.'
	dc.b	' JE>LI JEDNAK KIEDY> ZDO*AMY CO> ZROBI$ WTEDY WYSI#DZIE PARSZYWA "AMIGA", I WSZYSCY (Z JEDNYM WYMIENIONYM JU[ WYJ#TKIEM)'
	dc.b	' "AMIGOWCY". '
	dc.b	' DALEJ POZDROWIENIA:'
	dc.b	' HENIU, WOJCIECH IBM-OWIEC, KT<RY CHCE MIE$ ATARI 1040 STE (G*<WNIE ZA NAMOW# MOJ# I ',$3d,'VAT',$3d,$27,'A).'
	dc.b	' NORMALNE JEDNAK JEST, [E JAKO JEGO KOLEDZY CHCEMY, [EBY MIA* DOBRY KOMPUTER, A NIE Z*OM). '
	dc.b	' MARCHEW - S*UCHAJ, WE@ SI% TROCH% PRZY*<[ DO SWOICH DEMEK, BO TO CO WIDA$ NA EKRANIE NIE ROBI DOBREGO WRA[ENIA.'
	dc.b	' WE WSZYSTKICH DEMACH WIDZIANYCH PRZEZE MNIE CO> SI% CHUJA, NIE M<WI#C JU[ O WYJ>CIU DO SYSTEMU (TO NAPRAWD% NIE TAKIE TRUDNE DO ZROBIENIA, WIESZ?)         '
	dc.b	' GREETINGS TO ALL SATANAS, GRINDCORE & DEATH METAL MANIACS (FUCK OFF GUNS & ROSES)...      ' 
	dc.b	' POZDRAWIAM TE[ WSZYSTKICH CHULIGAN<W KIBICUJ#CYCH LEGII-WARSZAWA.              '          
	dc.b	'    NO, DOBRA.  DO>$ JU[ TYCH SMUT<W. TERA CO> TRE>CIWEGO. '
	dc.b	' OSTATNIO BY*A U MNIE W CHACIE OSTRA PODJARKA, BO KUPI*EM SOBIE MONITOR KOLOROWY ATARI SC 1224 ZA 2 BA+KI 800000 TYS. ZROBI*EM INTERES NIE Z TEJ ZIEMI, A TO '
	dc.b	'WSZYSTKO DZI%KI =VAT=',$27,'OWI, KT<RY DA* MI CYNK, [E NA MARYNARSKIEJ S# MONITORY KOLOROWE ZA P<* DARMO. NIECH MU BOZIA WYNAGRODZI ...........           NA TYM KONIEC.  '
	dc.b	" SORRY ZA WSZYSTKIE B*%DY, ORAZ NADMIAR WYRAZU: 'KT<RY', ALE NIE CHCIA*O MI SI% KORYGOWA$ TYCH KWAS<W.       "
	dc.b	' JADZIEM OD NOWA!       '        
	dc.b	'                                                    ',0
	even
	ds.l	20
przesun: incbin	data\tab25-32.cod
music:	incbin	\data\r_o_m_ii.dat
	even
picture:incbin	\data\fonty_1.cod
	end of file
