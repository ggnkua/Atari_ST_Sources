	data
	even

banner:
	dc.l	.v1, .v2, .v3

.v1:	dc.b	$82,$00,$37,$08,$00,$02,$26,$00,$02
	dc.b	$37,$18,$34,$08,$30,$20,$34,$20,$37,$20,$3c,$40,$40,$18,$3e,$08
	dc.b	$3c,$20,$34,$20,$36,$20,$37,$40,$37,$10,$37,$10,$40,$30,$3e,$10
	dc.b	$3c,$20,$3b,$40,$39,$18,$3b,$08,$3c,$20,$3c,$20,$37,$20,$34,$20
	dc.b	$30,$20,$37,$18,$34,$08,$30,$20,$34,$20,$37,$20,$3c,$40,$40,$18
	dc.b	$3e,$08,$3c,$20,$34,$20,$36,$20,$37,$40,$37,$10,$37,$10,$40,$30
	dc.b	$3e,$10,$3c,$20,$3b,$40,$39,$18,$3b,$08,$3c,$20,$3c,$20,$37,$20
	dc.b	$34,$20,$30,$20,$40,$18,$40,$08,$40,$20,$41,$20,$43,$20,$43,$40
	dc.b	$41,$10,$40,$10,$3e,$20,$40,$20,$41,$20,$41,$40,$41,$20,$40,$30
	dc.b	$3e,$10,$3c,$20,$3b,$40,$39,$18,$3b,$08,$3c,$20,$34,$20,$36,$20
	dc.b	$37,$40,$37,$20,$3c,$20,$3c,$20,$3c,$10,$3b,$10,$39,$20,$39,$20
	dc.b	$39,$20,$3e,$10,$40,$10,$41,$10,$40,$10,$3e,$10,$3c,$10,$3c,$20
	dc.b	$3b,$20,$37,$10,$37,$10,$3c,$30,$3e,$10,$40,$10,$41,$10,$43,$40
	dc.b	$3c,$10,$3e,$10,$40,$20,$41,$20,$3e,$20,$3c,$40
	dc.b	$81,$00,$00

.v2:	dc.b	$82,$00,$37,$08,$00,$02,$26,$00,$02
	dc.b	$80,$80,$39,$40,$2c,$18,$2c,$08,$2d,$20,$30,$20,$30,$20,$2f,$40
	dc.b	$2b,$10,$2b,$10,$30,$30,$2f,$10,$2d,$20,$2b,$40,$2b,$10,$2b,$10
	dc.b	$30,$20,$30,$20,$2f,$20,$30,$20,$80,$20,$80,$80,$39,$40,$2c,$18
	dc.b	$2c,$08,$2d,$20,$30,$20,$30,$20,$2f,$40,$2b,$10,$2b,$10,$30,$30
	dc.b	$2f,$10,$2d,$20,$2b,$40,$2b,$10,$2b,$10,$30,$20,$30,$20,$2f,$20
	dc.b	$30,$20,$80,$20,$80,$80,$24,$20,$28,$20,$2a,$20,$2b,$40,$80,$20
	dc.b	$2b,$20,$2d,$20,$2f,$20,$30,$30,$2f,$10,$2d,$10,$2a,$10,$2b,$40
	dc.b	$29,$18,$2b,$08,$28,$20,$2d,$20,$26,$20,$2b,$10,$2d,$10,$2b,$10
	dc.b	$29,$10,$28,$10,$26,$10,$24,$20,$24,$20,$28,$10,$24,$10,$29,$20
	dc.b	$29,$20,$25,$20,$26,$10,$21,$10,$26,$10,$28,$10,$29,$10,$26,$10
	dc.b	$2b,$20,$2b,$20,$2b,$10,$2b,$10,$24,$30,$23,$10,$24,$10,$26,$10
	dc.b	$28,$40,$29,$10,$26,$10,$24,$20,$26,$20,$23,$20,$24,$40
	dc.b	$81,$00,$00

.v3:	dc.b	$82,$00,$37,$08,$00,$02,$26,$00,$02
	dc.b	$80,$40,$30,$20,$2f,$20,$2d,$40,$23,$18,$23,$08,$30,$20,$2d,$20
	dc.b	$32,$20,$32,$40,$80,$20,$3c,$30,$37,$10,$34,$10,$36,$10,$37,$40
	dc.b	$35,$18,$37,$08,$34,$20,$34,$20,$35,$20,$80,$40,$80,$40,$30,$20
	dc.b	$2f,$20,$2d,$40,$23,$18,$23,$08,$30,$20,$2d,$20,$32,$20,$32,$40
	dc.b	$80,$20,$3c,$30,$37,$10,$34,$10,$36,$10,$37,$40,$35,$18,$37,$08
	dc.b	$34,$20,$34,$20,$35,$20,$80,$40,$30,$18,$30,$08,$30,$20,$32,$20
	dc.b	$34,$20,$34,$40,$32,$10,$30,$10,$2f,$20,$30,$20,$32,$20,$32,$40
	dc.b	$32,$20,$30,$30,$37,$10,$34,$10,$36,$10,$37,$40,$35,$18,$32,$08
	dc.b	$34,$20,$32,$20,$32,$20,$37,$40,$37,$20,$34,$20,$34,$20,$37,$10
	dc.b	$34,$10,$35,$20,$35,$20,$34,$20,$39,$10,$37,$10,$39,$10,$37,$10
	dc.b	$39,$10,$39,$10,$37,$20,$37,$20,$37,$10,$35,$10,$34,$30,$32,$10
	dc.b	$30,$10,$32,$10,$34,$40,$39,$10,$38,$10,$37,$20,$39,$20,$37,$20
	dc.b	$34,$40
	dc.b	$81,$00,$00

