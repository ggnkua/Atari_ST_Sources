*******************************************
****** STARFIELD (F.O.F.) DAZ & JFB *******
*******************************************
	bsr	super
	bsr	setscrn
	bsr	setpal

start	move.w	#$64,d7
loop1	bsr	vsync		vsync
	cmp.b	#$39,$fffffc02
	beq	exit
	bsr	star
	dbf	d7,loop1
	bra	start


star	movem.l	d0-d7/a0-a6,-(a7)
	bsr	rout1
	bsr	rout2
	bsr	rout3
	movem.l	(a7)+,d0-d7/a0-a6
	rts


rout1	movea.l	t40c2e,a0		$34f94
	move.w	(a0)+,d0
	beq.s	t34faa
	subq.w	#1,d0
t34fa0	movea.l	(a0)+,a1
	clr.l	(a1)+
	clr.l	(a1)+
	dbf	d0,t34fa0
t34faa	move.l	a0,t40c2e
	rts


rout2	moveq	#0,d6		$34e92
	moveq	#$7f,d7
	movea.l	#t415c2,a0
	movea.l	t40c2e,a2
	movea.l	#t40c32,a3
	movea.l	#t410c2,a4
t34eae	move.l	(a0),d0
	move.l	4(a0),d1
	move.w	8(a0),d4
	move.l	d0,d2
	move.l	d1,d3
	asr.l	d4,d2
	asr.l	d4,d3
	add.l	d2,d0
	add.l	d3,d1
	move.l	d0,(a0)
	move.l	d1,4(a0)
	swap	d0
	swap	d1
	addi.w	#$a0,d0
	cmp.w	#$140,d0
	bcc.s	t34f42
	addi.w	#$64,d1
	cmp.w	#$c8,d1
	bcc.s	t34f42
	add.w	d0,d0
	add.w	d0,d0
	add.w	d1,d1
	movea.l	t40c26,a1
	adda.w	0(a3,d1.w),a1
	adda.w	0(a4,d0.w),a1
	move.w	2(a4,d0.w),d0
	move.l	(a1),d1
	or.l	4(a1),d1
	move.l	d1,d2
	swap	d1
	or.l	d2,d1
	and.w	d0,d1
	bne.s	t34f82
	move.l	a1,-(a2)
	addq.w	#1,d6
	move.w	8(a0),d1
	subq.w	#5,d1
	add.w	d1,d1
	
	jmp	t34f1a(pc,d1.w)
t34f1a	bra.s	t34f38
	bra.s	t34f2e
	bra.s	t34f26
	addq.l	#6,a1
	or.w	d0,(a1)
	bra.s	t34f82
t34f26	or.w	d0,(a1)
	addq.l	#6,a1
	or.w	d0,(a1)
	bra.s	t34f82
t34f2e	addq.l	#2,a1
	or.w	d0,(a1)
	addq.l	#4,a1
	or.w	d0,(a1)
	bra.s	t34f82
t34f38	or.w	d0,(a1)+
	or.w	d0,(a1)
	addq.l	#4,a1
	or.w	d0,(a1)
	bra.s	t34f82
t34f42	bsr	t34e62
	andi.w	#$7f,d0
	move.w	d0,d1
	bsr	t34e62
	andi.w	#$1ff,d0
	cmp.w	#$140,d0
	bcs.s	t34f5e
	subi.w	#$140,d0
t34f5e	subi.w	#$a0,d0
	subi.w	#$64,d1
	swap	d0
	swap	d1
	clr.w	d0
	clr.w	d1
	move.l	d0,(a0)
	move.l	d1,4(a0)
	bsr	t34e62
	andi.w	#3,d0
	addq.w	#5,d0
	move.w	d0,8(a0)
t34f82	lea	$a(a0),a0
	dbf	d7,t34eae
	move.w	d6,-(a2)
	move.l	a2,t40c2e
	rts

rout3	movea.l	t40c2e(pc),a0		$3b248
	move.l	t40c2a(pc),t40c2e
	move.l	a0,t40c2a
	movea.l	t40c26(pc),a0
	move.l	t40c22(pc),t40c26
	move.l	a0,t40c22
	move.l	a0,d0
	asr.l	#8,d0
	move.b	d0,$ffff8203.w
	asr.w	#8,d0
	move.b	d0,$ffff8201.w
	rts


t34e62	movem.l	d1-d3,-(a7)
	movem.l	t386ba(pc),d1-d2
	add.w	d1,d1
	move.w	d1,d3
	addX.w	d2,d1
	move.w	d3,d2
	swap	d1
	swap	d2
	move.w	d1,d3
	addX.w	d2,d1
	move.w	d3,d2
	swap	d1
	swap	d2
	movem.l	d1-d2,t386ba
	move.w	d1,d0
	movem.l	(a7)+,d1-d3
	rts
t386ba	dc.l	$63d3
	dc.l	$e1e1
********************************** rouTines *******************************
super	clr.l	-(sp)
	move.w	#$20,-(sp)
	trap	#1
	addq.l	#6,sp
	rts

setscrn	move.w	#0,-(sp)
	move.l	#$f8000,-(sp)	
	move.l	#$f8000,-(sp)
	move.w	#5,-(sp)
	trap	#14
	add.l	#12,sp
	rts

setpal	movem.l	$ff8240,d0-d7
	movem.l	d0-d7,oldcols
	move.l	#cols+2,-(sp)
	move.w	#6,-(sp)
	trap	#14
	addq.l	#6,sp
	rts
oldcols	ds.l	8			
vsync	move.w	#37,-(sp)
	trap	#14
	addq.l	#2,sp
	rts

exit	
	movem.l	oldcols,d0-d7
	movem.l	d0-d7,$ff8240
	clr.w	-(sp)
	trap	#1
	
********************************** data ************************************

t40c22	dc.b	0,7,$70,0
t40c26	dc.b	0,6,$e0,0
t40c2a	dc.l	t42af8
t40c2e	dc.l	t426d8
t40c32	dc.b	0,0,0,$a0,1,$40,1,$e0
	dc.b	2,$80,3,$20,3,$c0,4,$60
	dc.b	5,0,5,$a0,6,$40,6,$e0
	dc.b	7,$80,8,$20,8,$c0,9,$60
	dc.b	$a,0,$a,$a0,$b,$40,$b,$e0
	dc.b	$c,$80,$d,$20,$d,$c0,$e,$60
	dc.b	$f,0,$f,$a0,$10,$40,$10,$e0
	dc.b	$11,$80,$12,$20,$12,$c0,$13,$60
	dc.b	$14,0,$14,$a0,$15,$40,$15,$e0
	dc.b	$16,$80,$17,$20,$17,$c0,$18,$60
	dc.b	$19,0,$19,$a0,$1a,$40,$1a,$e0
	dc.b	$1b,$80,$1c,$20,$1c,$c0,$1d,$60
	dc.b	$1e,0,$1e,$a0,$1f,$40,$1f,$e0
	dc.b	$20,$80,$21,$20,$21,$c0,$22,$60
	dc.b	$23,0,$23,$a0,$24,$40,$24,$e0
	dc.b	$25,$80,$26,$20,$26,$c0,$27,$60
	dc.b	$28,0,$28,$a0,$29,$40,$29,$e0
	dc.b	$2a,$80,$2b,$20,$2b,$c0,$2c,$60
	dc.b	$2d,0,$2d,$a0,$2e,$40,$2e,$e0
	dc.b	$2f,$80,$30,$20,$30,$c0,$31,$60
	dc.b	$32,0,$32,$a0,$33,$40,$33,$e0
	dc.b	$34,$80,$35,$20,$35,$c0,$36,$60
	dc.b	$37,0,$37,$a0,$38,$40,$38,$e0
	dc.b	$39,$80,$3a,$20,$3a,$c0,$3b,$60
	dc.b	$3c,0,$3c,$a0,$3d,$40,$3d,$e0
	dc.b	$3e,$80,$3f,$20,$3f,$c0,$40,$60
	dc.b	$41,0,$41,$a0,$42,$40,$42,$e0
	dc.b	$43,$80,$44,$20,$44,$c0,$45,$60
	dc.b	$46,0,$46,$a0,$47,$40,$47,$e0
	dc.b	$48,$80,$49,$20,$49,$c0,$4a,$60
	dc.b	$4b,0,$4b,$a0,$4c,$40,$4c,$e0
	dc.b	$4d,$80,$4e,$20,$4e,$c0,$4f,$60
	dc.b	$50,0,$50,$a0,$51,$40,$51,$e0
	dc.b	$52,$80,$53,$20,$53,$c0,$54,$60
	dc.b	$55,0,$55,$a0,$56,$40,$56,$e0
	dc.b	$57,$80,$58,$20,$58,$c0,$59,$60
	dc.b	$5a,0,$5a,$a0,$5b,$40,$5b,$e0
	dc.b	$5c,$80,$5d,$20,$5d,$c0,$5e,$60
	dc.b	$5f,0,$5f,$a0,$60,$40,$60,$e0
	dc.b	$61,$80,$62,$20,$62,$c0,$63,$60
	dc.b	$64,0,$64,$a0,$65,$40,$65,$e0
	dc.b	$66,$80,$67,$20,$67,$c0,$68,$60
	dc.b	$69,0,$69,$a0,$6a,$40,$6a,$e0
	dc.b	$6b,$80,$6c,$20,$6c,$c0,$6d,$60
	dc.b	$6e,0,$6e,$a0,$6f,$40,$6f,$e0
	dc.b	$70,$80,$71,$20,$71,$c0,$72,$60
	dc.b	$73,0,$73,$a0,$74,$40,$74,$e0
	dc.b	$75,$80,$76,$20,$76,$c0,$77,$60
	dc.b	$78,0,$78,$a0,$79,$40,$79,$e0
	dc.b	$7a,$80,$7b,$20,$7b,$c0,$7c,$60
	dc.b	0,0,$21,$2e

t415c2	dc.b	$ff,$94,$e7,$af,$ff,$a2,$6b,$ff
	dc.b	0,8,$ff,$7d,$23,$57,0,1
	dc.b	$2b,$14,0,7,$ff,$b9,$b8,$f0
	dc.b	$ff,$db,$c3,$58,0,8,$ff,$f0
	dc.b	$df,$1b,$ff,$ec,$8c,$91,0,6
	dc.b	$ff,$b3,$22,$49,$ff,$d2,$fa,$75
	dc.b	0,8,$ff,$c8,$6f,$cb,$ff,$f2
	dc.b	$1b,$ec,0,8,$ff,$f3,$8c,$20
	dc.b	$ff,$ba,$f1,$d7,0,6,$ff,$c4
	dc.b	$f0,6,$ff,$e5,$7b,$6b,0,7
	dc.b	$ff,$f5,$89,$1b,$ff,$dc,$6b,$ed
	dc.b	0,5,$ff,$ad,$a4,$ba,$ff,$bb
	dc.b	$eb,$27,0,8,$ff,$d9,$6d,$b7
	dc.b	$ff,$cc,$2b,$6f,0,7,0,$f
	dc.b	$ab,$5d,$ff,$a9,$36,$e9,0,7
	dc.b	$ff,$79,$13,$cf,0,$55,$98,$81
	dc.b	0,6,$ff,$95,$43,$e3,0,$5e
	dc.b	$2d,$69,0,5,$ff,$71,$af,$db
	dc.b	$ff,$da,$54,$29,0,5,$ff,$ab
	dc.b	$a0,$a,$ff,$b8,$e2,$52,0,7
	dc.b	0,$6e,$42,$4b,$ff,$fa,$32,$59
	dc.b	0,6,0,$42,$73,$a6,$ff,$a0
	dc.b	$22,$8f,0,7,0,$80,$79,$c7
	dc.b	$ff,$ae,$bd,$d6,0,8,$ff,$be
	dc.b	$3d,$4a,$ff,$f9,$bc,$ac,0,8
	dc.b	0,$1b,$6a,$f2,$ff,$9c,$33,$a
	dc.b	0,5,0,$1c,$ed,$a4,0,$42
	dc.b	$4b,$4e,0,7,0,$28,$a1,7
	dc.b	$ff,$d4,$13,$91,0,8,0,$21
	dc.b	$ff,$7e,0,$19,$39,$6e,0,5
	dc.b	0,$22,0,0,$ff,$e0,0,0
	dc.b	0,5,$ff,$f7,$c7,$53,0,$13
	dc.b	$86,$90,0,8,$ff,$b5,$54,$7f
	dc.b	$ff,$a0,$77,$68,0,8,$ff,$be
	dc.b	$1d,$61,$ff,$fa,$82,$66,0,8
	dc.b	$ff,$cf,$be,$a8,0,2,$31,$84
	dc.b	0,5,$ff,$ea,$8b,$c2,$ff,$ba
	dc.b	$46,$4b,0,8,$ff,$dd,$f5,$8f
	dc.b	$ff,$a1,$90,$84,0,8,0,$26
	dc.b	$92,$34,$ff,$d5,$d0,0,0,7
	dc.b	0,$84,$96,$a7,0,$27,$c6,$c4
	dc.b	0,7,0,$53,$e4,$7a,$ff,$f5
	dc.b	$a4,$90,0,8,0,$50,$c2,$27
	dc.b	$ff,$fb,$2d,$ad,0,7,0,$8f
	dc.b	$67,$50,$ff,$b5,$b8,$e,0,8
	dc.b	0,$94,$42,$10,0,$21,$bf,$eb
	dc.b	0,7,$ff,$ba,$5c,$cc,0,$59
	dc.b	$f2,$b4,0,6,$ff,$fe,$e6,$d5
	dc.b	0,$4c,$dd,$a1,0,8,0,$12
	dc.b	$14,$81,0,0,0,0,0,7
	dc.b	$ff,$a3,$26,$63,$ff,$ab,$da,$cc
	dc.b	0,6,0,$25,$5d,$9c,0,7
	dc.b	$3b,$60,0,7,0,$59,$32,$23
	dc.b	0,$4b,$ef,$db,0,7,$ff,$9d
	dc.b	$2c,$17,$ff,$9c,$12,$f9,0,8
	dc.b	$ff,$db,$3e,$20,$ff,$cd,$30,$40
	dc.b	0,8,0,$38,$94,$8a,$ff,$a4
	dc.b	$99,$c9,0,6,$ff,$60,$6a,8
	dc.b	$ff,$cb,$c5,$91,0,6,$ff,$7b
	dc.b	$21,$b2,$ff,$c4,$b4,9,0,8
	dc.b	$ff,$fe,$e6,$d5,0,$46,$46,$f9
	dc.b	0,8,$ff,$b0,$34,$fd,$ff,$de
	dc.b	$a1,$c3,0,6,$ff,$64,$c4,$3b
	dc.b	$ff,$b0,$34,$fd,0,6,$ff,$89
	dc.b	$68,$1c,$ff,$c3,$9a,$ee,0,8
	dc.b	0,$35,$ad,$bb,0,$3e,$62,$20
	dc.b	0,6,0,$75,$7e,$b1,$ff,$a8
	dc.b	$27,$30,0,8,$ff,$7c,$9e,$57
	dc.b	$ff,$9f,$ba,$a3,0,7,0,$45
	dc.b	$a3,$1f,$ff,$ae,$c1,$96,0,6
	dc.b	$ff,$fc,$a0,$e1,$ff,$d9,$ca,$42
	dc.b	0,7,$ff,$b2,$90,$9a,0,$55
	dc.b	$ce,$5b,0,5,$ff,$8a,$7c,$99
	dc.b	0,$49,$fd,$51,0,6,0,$4d
	dc.b	$18,$56,$ff,$cf,$6b,$5c,0,8
	dc.b	$ff,$b8,$ba,$17,$ff,$e1,$9f,7
	dc.b	0,7,$ff,$f8,$be,$f3,0,7
	dc.b	$40,$f4,0,6,0,3,$4b,$4c
	dc.b	$ff,$e1,$40,$e1,0,8,$ff,$af
	dc.b	$c2,$24,0,4,$10,$18,0,8
	dc.b	$ff,$73,0,0,$ff,$b9,0,0
	dc.b	0,6,0,$66,$ec,$8a,0,5
	dc.b	$f,$cb,0,5,$ff,$9a,$f9,$dc
	dc.b	$ff,$a9,$40,$4b,0,8,0,$8f
	dc.b	$85,$52,0,$19,$1d,$af,0,7
	dc.b	$ff,$73,$fe,$7a,$ff,$e3,$c8,$19
	dc.b	0,8,$ff,$71,$c4,$b0,$ff,$b4
	dc.b	$10,$d,0,7,$ff,$d5,$d0,0
	dc.b	0,$5b,$9b,$45,0,7,$ff,$bf
	dc.b	$bc,$c2,0,$19,$b4,$71,0,7
	dc.b	0,$82,$f1,$36,0,$b,$9d,$a7
	dc.b	0,7,$ff,$fd,$cd,$ba,0,3
	dc.b	$4b,$4c,0,8,$ff,$a3,6,$9b
	dc.b	$ff,$fa,$98,$28,0,8,$ff,$6d
	dc.b	$78,$9e,0,$5e,$4c,$eb,0,6
	dc.b	$ff,$7c,$9d,$d3,0,$18,$1b,$5a
	dc.b	0,7,0,$45,$a3,$1f,0,$42
	dc.b	$bc,$50,0,6,$ff,$fe,$e6,$d5
	dc.b	$ff,$c0,$4f,$99,0,8,0,$11
	dc.b	$91,$b5,$ff,$b2,9,$2e,0,8
	dc.b	$ff,$dd,$b,$6c,$ff,$c8,$8d,$ba
	dc.b	0,7,0,$1e,$22,$32,0,7
	dc.b	$3b,$60,0,7,$ff,$d4,$c,$de
	dc.b	$ff,$a1,$d2,$7e,0,5,0,7
	dc.b	$3b,$60,$ff,$d3,$66,$de,0,7
	dc.b	$ff,$67,$5d,$b7,$ff,$ac,$8b,$a1
	dc.b	0,8,$ff,$f6,$5b,$65,0,$22
	dc.b	$f4,$7b,0,7,$ff,$79,$70,4
	dc.b	$ff,$d8,$45,$a1,0,6,0,$63
	dc.b	$cf,$1e,$ff,$d1,$36,$e8,0,7
	dc.b	0,$99,$bb,$4e,$ff,$f3,$eb,$c0
	dc.b	0,8,0,$7b,$50,$e6,0,$f
	dc.b	$f5,$57,0,6,$ff,$e6,$b0,0
	dc.b	0,$1c,$ed,$a4,0,7,$ff,$d5
	dc.b	$ed,$5f,$ff,$b8,$e9,$62,0,6
	dc.b	0,$65,8,$6f,0,0,0,0
	dc.b	0,5,$ff,$6e,$26,$fc,$ff,$ab
	dc.b	$a0,$a,0,7,$ff,$f4,$64,$c0
	dc.b	$ff,$fd,$19,$28,0,6,$ff,$6a
	dc.b	$db,$8e,$ff,$aa,9,$36,0,8
	dc.b	0,5,$34,$c8,$ff,$de,$28,$b6
	dc.b	0,6,$ff,$7e,$e1,$66,$ff,$d0
	dc.b	$1f,$c9,0,6,$ff,$9a,$71,$fe
	dc.b	$ff,$c0,$2a,$62,0,6,$ff,$7d
	dc.b	$6e,2,0,$25,$b8,$56,0,6
	dc.b	0,$12,$6d,$e,$ff,$e4,$5c,$66
	dc.b	0,8,$ff,$cb,$ad,$cb,$ff,$fd
	dc.b	$e8,$2c,0,5,0,$81,$92,$e2
	dc.b	0,$5b,$24,$c,0,8,0,$1d
	dc.b	$a5,$ea,$ff,$fd,$cd,$ba,0,8
	dc.b	$ff,$8d,$63,$6a,0,$d,$e,$88
	dc.b	0,6,$ff,$7d,$d2,$63,0,$44
	dc.b	$b4,$70,0,7,0,$9d,$ce,$55
	dc.b	$ff,$e8,$c1,$d6,0,6,$ff,$f0
	dc.b	$a0,$6a,$ff,$f3,$eb,$c0,0,8
	dc.b	$ff,$65,$2b,$7e,$ff,$ec,$3b,$fb
	dc.b	0,8,0,$7a,$fc,$3d,$ff,$d5
	dc.b	$2c,$ad,0,8,0,4,$d2,$3b
	dc.b	$ff,$f0,$54,$8d,0,7,0,$22
	dc.b	$5b,$ec,$ff,$fb,$17,$69,0,5
	dc.b	0,$9a,$3a,$31,0,$11,$80,$35
	dc.b	0,8,$ff,$b5,$44,$9b,$ff,$d5
	dc.b	$d0,0,0,7,$ff,$f2,1,$b
	dc.b	$ff,$f6,$ab,$5c,0,5,0,$11
	dc.b	$68,$bd,$ff,$ee,$97,$28,0,6
	dc.b	0,$69,$e8,$1f,0,$a,$27,$bd
	dc.b	0,6,$ff,$ac,$d4,$9c,$ff,$b2
	dc.b	$db,$79,0,7,$ff,$75,$a4,$26
	dc.b	$ff,$ca,$31,$96,0,8,$ff,$63
	dc.b	$e7,$ea,$ff,$ec,$18,$6b,0,6
	dc.b	0,$98,$ea,$f3,$ff,$ba,0,$91
	dc.b	0,8,$ff,$be,$b6,$fa,0,$3b
	dc.b	$7b,$51,0,6,$ff,$de,$99,7
	dc.b	$ff,$db,$77,$60,0,8,$ff,$83
	dc.b	$b9,$50,$ff,$fb,$b6,$e4,0,6
	dc.b	$ff,$ef,$1f,$f8,$ff,$c2,$86,$e1
	dc.b	0,7,0,4,$64,$37,$ff,$a0
	dc.b	$7b,$e2,0,7,$ff,$e3,$b6,$e9
	dc.b	$ff,$a0,$aa,$d9,0,6,$ff,$7d
	dc.b	$53,$e9,$ff,$ac,$8b,$a1,0,8


t410c2	dc.b	0,0,$80,0,0,0,$40,0
	dc.b	0,0,$20,0,0,0,$10,0
	dc.b	0,0,8,0,0,0,4,0
	dc.b	0,0,2,0,0,0,1,0
	dc.b	0,0,0,$80,0,0,0,$40
	dc.b	0,0,0,$20,0,0,0,$10
	dc.b	0,0,0,8,0,0,0,4
	dc.b	0,0,0,2,0,0,0,1
	dc.b	0,8,$80,0,0,8,$40,0
	dc.b	0,8,$20,0,0,8,$10,0
	dc.b	0,8,8,0,0,8,4,0
	dc.b	0,8,2,0,0,8,1,0
	dc.b	0,8,0,$80,0,8,0,$40
	dc.b	0,8,0,$20,0,8,0,$10
	dc.b	0,8,0,8,0,8,0,4
	dc.b	0,8,0,2,0,8,0,1
	dc.b	0,$10,$80,0,0,$10,$40,0
	dc.b	0,$10,$20,0,0,$10,$10,0
	dc.b	0,$10,8,0,0,$10,4,0
	dc.b	0,$10,2,0,0,$10,1,0
	dc.b	0,$10,0,$80,0,$10,0,$40
	dc.b	0,$10,0,$20,0,$10,0,$10
	dc.b	0,$10,0,8,0,$10,0,4
	dc.b	0,$10,0,2,0,$10,0,1
	dc.b	0,$18,$80,0,0,$18,$40,0
	dc.b	0,$18,$20,0,0,$18,$10,0
	dc.b	0,$18,8,0,0,$18,4,0
	dc.b	0,$18,2,0,0,$18,1,0
	dc.b	0,$18,0,$80,0,$18,0,$40
	dc.b	0,$18,0,$20,0,$18,0,$10
	dc.b	0,$18,0,8,0,$18,0,4
	dc.b	0,$18,0,2,0,$18,0,1
	dc.b	0,$20,$80,0,0,$20,$40,0
	dc.b	0,$20,$20,0,0,$20,$10,0
	dc.b	0,$20,8,0,0,$20,4,0
	dc.b	0,$20,2,0,0,$20,1,0
	dc.b	0,$20,0,$80,0,$20,0,$40
	dc.b	0,$20,0,$20,0,$20,0,$10
	dc.b	0,$20,0,8,0,$20,0,4
	dc.b	0,$20,0,2,0,$20,0,1
	dc.b	0,$28,$80,0,0,$28,$40,0
	dc.b	0,$28,$20,0,0,$28,$10,0
	dc.b	0,$28,8,0,0,$28,4,0
	dc.b	0,$28,2,0,0,$28,1,0
	dc.b	0,$28,0,$80,0,$28,0,$40
	dc.b	0,$28,0,$20,0,$28,0,$10
	dc.b	0,$28,0,8,0,$28,0,4
	dc.b	0,$28,0,2,0,$28,0,1
	dc.b	0,$30,$80,0,0,$30,$40,0
	dc.b	0,$30,$20,0,0,$30,$10,0
	dc.b	0,$30,8,0,0,$30,4,0
	dc.b	0,$30,2,0,0,$30,1,0
	dc.b	0,$30,0,$80,0,$30,0,$40
	dc.b	0,$30,0,$20,0,$30,0,$10
	dc.b	0,$30,0,8,0,$30,0,4
	dc.b	0,$30,0,2,0,$30,0,1
	dc.b	0,$38,$80,0,0,$38,$40,0
	dc.b	0,$38,$20,0,0,$38,$10,0
	dc.b	0,$38,8,0,0,$38,4,0
	dc.b	0,$38,2,0,0,$38,1,0
	dc.b	0,$38,0,$80,0,$38,0,$40
	dc.b	0,$38,0,$20,0,$38,0,$10
	dc.b	0,$38,0,8,0,$38,0,4
	dc.b	0,$38,0,2,0,$38,0,1
	dc.b	0,$40,$80,0,0,$40,$40,0
	dc.b	0,$40,$20,0,0,$40,$10,0
	dc.b	0,$40,8,0,0,$40,4,0
	dc.b	0,$40,2,0,0,$40,1,0
	dc.b	0,$40,0,$80,0,$40,0,$40
	dc.b	0,$40,0,$20,0,$40,0,$10
	dc.b	0,$40,0,8,0,$40,0,4
	dc.b	0,$40,0,2,0,$40,0,1
	dc.b	0,$48,$80,0,0,$48,$40,0
	dc.b	0,$48,$20,0,0,$48,$10,0
	dc.b	0,$48,8,0,0,$48,4,0
	dc.b	0,$48,2,0,0,$48,1,0
	dc.b	0,$48,0,$80,0,$48,0,$40
	dc.b	0,$48,0,$20,0,$48,0,$10
	dc.b	0,$48,0,8,0,$48,0,4
	dc.b	0,$48,0,2,0,$48,0,1
	dc.b	0,$50,$80,0,0,$50,$40,0
	dc.b	0,$50,$20,0,0,$50,$10,0
	dc.b	0,$50,8,0,0,$50,4,0
	dc.b	0,$50,2,0,0,$50,1,0
	dc.b	0,$50,0,$80,0,$50,0,$40
	dc.b	0,$50,0,$20,0,$50,0,$10
	dc.b	0,$50,0,8,0,$50,0,4
	dc.b	0,$50,0,2,0,$50,0,1
	dc.b	0,$58,$80,0,0,$58,$40,0
	dc.b	0,$58,$20,0,0,$58,$10,0
	dc.b	0,$58,8,0,0,$58,4,0
	dc.b	0,$58,2,0,0,$58,1,0
	dc.b	0,$58,0,$80,0,$58,0,$40
	dc.b	0,$58,0,$20,0,$58,0,$10
	dc.b	0,$58,0,8,0,$58,0,4
	dc.b	0,$58,0,2,0,$58,0,1
	dc.b	0,$60,$80,0,0,$60,$40,0
	dc.b	0,$60,$20,0,0,$60,$10,0
	dc.b	0,$60,8,0,0,$60,4,0
	dc.b	0,$60,2,0,0,$60,1,0
	dc.b	0,$60,0,$80,0,$60,0,$40
	dc.b	0,$60,0,$20,0,$60,0,$10
	dc.b	0,$60,0,8,0,$60,0,4
	dc.b	0,$60,0,2,0,$60,0,1
	dc.b	0,$68,$80,0,0,$68,$40,0
	dc.b	0,$68,$20,0,0,$68,$10,0
	dc.b	0,$68,8,0,0,$68,4,0
	dc.b	0,$68,2,0,0,$68,1,0
	dc.b	0,$68,0,$80,0,$68,0,$40
	dc.b	0,$68,0,$20,0,$68,0,$10
	dc.b	0,$68,0,8,0,$68,0,4
	dc.b	0,$68,0,2,0,$68,0,1
	dc.b	0,$70,$80,0,0,$70,$40,0
	dc.b	0,$70,$20,0,0,$70,$10,0
	dc.b	0,$70,8,0,0,$70,4,0
	dc.b	0,$70,2,0,0,$70,1,0
	dc.b	0,$70,0,$80,0,$70,0,$40
	dc.b	0,$70,0,$20,0,$70,0,$10
	dc.b	0,$70,0,8,0,$70,0,4
	dc.b	0,$70,0,2,0,$70,0,1
	dc.b	0,$78,$80,0,0,$78,$40,0
	dc.b	0,$78,$20,0,0,$78,$10,0
	dc.b	0,$78,8,0,0,$78,4,0
	dc.b	0,$78,2,0,0,$78,1,0
	dc.b	0,$78,0,$80,0,$78,0,$40
	dc.b	0,$78,0,$20,0,$78,0,$10
	dc.b	0,$78,0,8,0,$78,0,4
	dc.b	0,$78,0,2,0,$78,0,1
	dc.b	0,$80,$80,0,0,$80,$40,0
	dc.b	0,$80,$20,0,0,$80,$10,0
	dc.b	0,$80,8,0,0,$80,4,0
	dc.b	0,$80,2,0,0,$80,1,0
	dc.b	0,$80,0,$80,0,$80,0,$40
	dc.b	0,$80,0,$20,0,$80,0,$10
	dc.b	0,$80,0,8,0,$80,0,4
	dc.b	0,$80,0,2,0,$80,0,1
	dc.b	0,$88,$80,0,0,$88,$40,0
	dc.b	0,$88,$20,0,0,$88,$10,0
	dc.b	0,$88,8,0,0,$88,4,0
	dc.b	0,$88,2,0,0,$88,1,0
	dc.b	0,$88,0,$80,0,$88,0,$40
	dc.b	0,$88,0,$20,0,$88,0,$10
	dc.b	0,$88,0,8,0,$88,0,4
	dc.b	0,$88,0,2,0,$88,0,1
	dc.b	0,$90,$80,0,0,$90,$40,0
	dc.b	0,$90,$20,0,0,$90,$10,0
	dc.b	0,$90,8,0,0,$90,4,0
	dc.b	0,$90,2,0,0,$90,1,0
	dc.b	0,$90,0,$80,0,$90,0,$40
	dc.b	0,$90,0,$20,0,$90,0,$10
	dc.b	0,$90,0,8,0,$90,0,4
	dc.b	0,$90,0,2,0,$90,0,1
	dc.b	0,$98,$80,0,0,$98,$40,0
	dc.b	0,$98,$20,0,0,$98,$10,0
	dc.b	0,$98,8,0,0,$98,4,0
	dc.b	0,$98,2,0,0,$98,1,0
	dc.b	0,$98,0,$80,0,$98,0,$40
	dc.b	0,$98,0,$20,0,$98,0,$10
	dc.b	0,$98,0,8,0,$98,0,4
	dc.b	0,$98,0,2,0,$98,0,1
	dc.w	$ff94
	even
t426d8	dc.w	$80,6,$ea08,6
	dc.w	$e400,6,$e370,6
	dc.w	$f8a0,7,$1b70,7
	dc.w	$798,7,$42e8,6
	dc.w	$f358,7,$1200,6
	dc.w	$fcc8,6,$ee80,7
	dc.w	$24a0,7,$1398,7
	dc.w	$1888,7,$468,7
	dc.w	$29b8,7,$1bc0,7
	dc.w	$14d0,7,$428,7
	dc.w	$1200,7,$16a8,7
	dc.w	$10b8,7,$4908,7
	dc.w	$2610,7,$1cf8,7
	dc.w	$5750,7,$1cd0,7
	dc.w	$d58,7,$35a8,6
	dc.w	$f738,7,$90,7
	dc.w	$990,6,$e8c0,7
	dc.w	$1ce8,6,$ea00,7
	dc.w	$1f00,6,$f2f8,7
	dc.w	$3040,7,$2868,7
	dc.w	$16f8,7,$1a0,7
	dc.w	$588,7,$3408,6
	dc.w	$ea00,7,$2b0,6
	dc.w	$e538,7,$2338,6
	dc.w	$fbb8,6,$ee18,6
	dc.w	$f6c8,7,$4790,7
	dc.w	$2ce8,7,$5800,7
	dc.w	$1ae0,7,$20a8,7
	dc.w	$25f0,7,$2e50,7
	dc.w	$56f8,6,$ef08,7
	dc.w	$c68,7,$2e10,6
	dc.w	$e838,7,$2180,7
	dc.w	$24b8,7,$2128,7
	dc.w	$b70,7,$2328,7
	dc.w	$b48,7,$50,7
	dc.w	$4b90,7,$5288,7
	dc.w	$708,6,$ecf0,6
	dc.w	$e288,6,$e808,7
	dc.w	$4508,6,$f870,6
	dc.w	$ed20,7,$a08,7
	dc.w	$4a88,6,$f908,6
	dc.w	$fe00,6,$e6a8,6
	dc.w	$fed8,6,$e018,7
	dc.w	$4dd8,7,$2340,6
	dc.w	$eac0,7,$1ed8,7
	dc.w	$4e48,7,$55a8,7
	dc.w	$33b8,6,$f0d0,7
	dc.w	$1bd8,7,$1818,7
	dc.w	$3770,7,$4a0,6
	dc.w	$e358,6,$f300,7
	dc.w	$1ff8,7,$1ae8,6
	dc.w	$e2a8,7,$2aa8,6
	dc.w	$fe00,7,$2de0,7
	dc.w	$360,7,$4778,6
	dc.w	$e238,7,$1a48,6
	dc.w	$ec68,6,$e2f0,7
	dc.w	$1b40,6,$f240,7
	dc.w	$768,7,$5778,7
	dc.w	$5308,6,$e870,6
	dc.w	$fe38,6,$f420,7
	dc.w	$8e8,7,$dd0,6
	dc.w	$f448,7,$15f0,7
	dc.w	$288,7,$1248,7
	dc.w	$788,7,$1f28,6
	dc.w	$e3d8
	ori.b	#0,d0

t42af0	dc.b	0,$80,0,7,$7a,$a8,0,7
t42af8	dc.b	0,$7e,0,7,$7a,8,0,7
	dc.b	$72,$c0,0,7,$72,$d0,0,7
	dc.b	$88,0,0,7,$ab,$70,0,7
	dc.b	$97,$98,0,7,$d3,$88,0,7
	dc.b	$83,$58,0,7,$a2,0,0,7
	dc.b	$8c,$c8,0,7,$7d,$e0,0,7
	dc.b	$b5,$40,0,7,$a3,$98,0,7
	dc.b	$a8,$88,0,7,$93,$c8,0,7
	dc.b	$b9,$b8,0,7,$ab,$c0,0,7
	dc.b	$a4,$d0,0,7,$94,$28,0,7
	dc.b	$a2,0,0,7,$a6,$a8,0,7
	dc.b	$a0,$18,0,7,$d9,8,0,7
	dc.b	$b6,$b0,0,7,$ac,$f8,0,7
	dc.b	$e7,$f0,0,7,$ac,$d0,0,7
	dc.b	$9d,$58,0,7,$c5,$a8,0,7
	dc.b	$86,$98,0,7,$90,$88,0,7
	dc.b	$99,$90,0,7,$78,$c0,0,7
	dc.b	$ac,$e8,0,7,$79,$60,0,7
	dc.b	$af,0,0,7,$81,$b8,0,7
	dc.b	$c0,$40,0,7,$b8,$68,0,7
	dc.b	$a6,$f8,0,7,$91,$a0,0,7
	dc.b	$95,$88,0,7,$c4,8,0,7
	dc.b	$7a,0,0,7,$92,$b0,0,7
	dc.b	$73,$58,0,7,$b3,$38,0,7
	dc.b	$8b,$b8,0,7,$7e,$18,0,7
	dc.b	$86,$c8,0,7,$d8,$30,0,7
	dc.b	$bd,$88,0,7,$e9,$40,0,7
	dc.b	$aa,$e0,0,7,$b0,$a8,0,7
	dc.b	$b5,$f0,0,7,$be,$48,0,7
	dc.b	$e7,$98,0,7,$7f,8,0,7
	dc.b	$9c,$68,0,7,$be,$b0,0,7
	dc.b	$78,$38,0,7,$b2,$20,0,7
	dc.b	$b1,$20,0,7,$9b,$70,0,7
	dc.b	$b3,$28,0,7,$9b,$48,0,7
	dc.b	$90,$50,0,7,$dc,$30,0,7
	dc.b	$e3,$c8,0,7,$96,$68,0,7
	dc.b	$7b,$b0,0,7,$71,$e8,0,7
	dc.b	$78,8,0,7,$d5,$a8,0,7
	dc.b	$88,$70,0,7,$7c,$80,0,7
	dc.b	$99,$68,0,7,$da,$88,0,7
	dc.b	$89,8,0,7,$8d,$60,0,7
	dc.b	$75,$68,0,7,$8e,$d8,0,7
	dc.b	$70,$18,0,7,$dd,$d8,0,7
	dc.b	$b3,$40,0,7,$79,$80,0,7
	dc.b	$ae,$d8,0,7,$de,$48,0,7
	dc.b	$e6,$48,0,7,$c3,$b8,0,7
	dc.b	$80,$30,0,7,$ab,$d8,0,7
	dc.b	$a8,$18,0,7,$c7,$70,0,7
	dc.b	$94,0,0,7,$73,$58,0,7
	dc.b	$83,0,0,7,$af,$f0,0,7
	dc.b	$aa,$e8,0,7,$72,$a8,0,7
	dc.b	$ba,$a8,0,7,$be,$80,0,7
	dc.b	$93,$60,0,7,$d8,$18,0,7
	dc.b	$70,$58,0,7,$aa,$48,0,7
	dc.b	$7b,$d0,0,7,$72,$f0,0,7
	dc.b	$ab,$40,0,7,$81,$a0,0,7
	dc.b	$96,$c8,0,7,$e9,$58,0,7
	dc.b	$e3,$a8,0,7,$78,$70,0,7
	dc.b	$8e,$38,0,7,$83,$80,0,7
	dc.b	$98,$48,0,7,$9d,$d0,0,7
	dc.b	$83,8,0,7,$a5,$f0,0,7
	dc.b	$91,$e8,0,7,$a2,$48,0,7
	dc.b	$97,$88,0,7,$af,$28,0,7
	dc.b	$73,$d8,0,0

cols	dc.w	0,1,$700,$70
	dc.w	$770,7,$707,$77
	dc.w	$555,3,6,$47
	dc.w	$67,$337,$737,$377
	dc.w	$777,0
