* Exemple de chargement de fichier
* Par Golio junior

	section Text

	pea 	
	section Data
Nom	dc.b 'fichier.txt',00

	section bss
reserve	ds.b 100