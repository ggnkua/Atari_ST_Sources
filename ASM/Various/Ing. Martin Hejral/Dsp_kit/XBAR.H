#define ROOT 0  	/* TREE */
#define CODCOD 2  	/* OBJECT in TREE #0 */
#define CODDSP 3  	/* OBJECT in TREE #0 */
#define CODDMA 4  	/* OBJECT in TREE #0 */
#define CODEXT 5  	/* OBJECT in TREE #0 */
#define DSPCOD 7  	/* OBJECT in TREE #0 */
#define DSPDSP 8  	/* OBJECT in TREE #0 */
#define DSPDMA 9  	/* OBJECT in TREE #0 */
#define DSPEXT 10  	/* OBJECT in TREE #0 */
#define DMACOD 12  	/* OBJECT in TREE #0 */
#define DMADSP 13  	/* OBJECT in TREE #0 */
#define DMADMA 14  	/* OBJECT in TREE #0 */
#define DMAEXT 15  	/* OBJECT in TREE #0 */
#define EXTCOD 17  	/* OBJECT in TREE #0 */
#define EXTDSP 18  	/* OBJECT in TREE #0 */
#define EXTDMA 19  	/* OBJECT in TREE #0 */
#define EXTEXT 20  	/* OBJECT in TREE #0 */
#define DONE 29  	/* OBJECT in TREE #0 */
#define ADDER 32  	/* OBJECT in TREE #0 */
