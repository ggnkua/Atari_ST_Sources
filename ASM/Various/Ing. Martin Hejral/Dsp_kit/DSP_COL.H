/* Resource Datei Indizes f�r DSP_COL */

#define SOUND    0   /* Formular/Dialog */
#define SCROLL   5   /* BOX in Baum SOUND */
#define SLIDER   6   /* BOXTEXT in Baum SOUND */
#define RATE_8K  22  /* BOXTEXT in Baum SOUND */
#define RATE_10K 23  /* BOXTEXT in Baum SOUND */
#define RATE_12K 24  /* BOXTEXT in Baum SOUND */
#define RATE_16K 25  /* BOXTEXT in Baum SOUND */
#define RATE_20K 26  /* BOXTEXT in Baum SOUND */
#define RATE_25K 27  /* BOXTEXT in Baum SOUND */
#define RATE_33K 28  /* BOXTEXT in Baum SOUND */
#define RATE_50K 29  /* BOXTEXT in Baum SOUND */
#define S_EXIT   31  /* BUTTON in Baum SOUND */

#define FADER    1   /* Formular/Dialog */
#define F_EXIT   0   /* BOX in Baum FADER */
#define R_SCROLL 2   /* BOX in Baum FADER */
#define R_SLIDER 3   /* BOXTEXT in Baum FADER */
#define R_DOWN   4   /* BOXTEXT in Baum FADER */
#define L_SCROLL 5   /* BOX in Baum FADER */
#define L_SLIDER 6   /* BOXTEXT in Baum FADER */
#define L_UP     7   /* BOXTEXT in Baum FADER */
#define F_TITLE  9   /* TEXT in Baum FADER */
#define L_DOWN   11  /* BOXTEXT in Baum FADER */
#define R_UP     12  /* BOXTEXT in Baum FADER */

#define REGUL    2   /* Formular/Dialog */
