/* 6x6 font in standard format */

#include "portab.h"
#include "fontdef.h"

EXTERN	UWORD	off_first[], dat_first[];

struct font_head first ={
    1,			/*   WORD font_id	*/
    8,			/*   WORD point		*/
"system font",		/*   BYTE name[32]	*/
    0,			/*   UWORD first_ade	*/
    255,		/*   UWORD last_ade	*/
    4,	    		/*   UWORD top		*/
    4,	    		/*   UWORD ascent	*/
    3,	    		/*   UWORD half		*/
    1,	    		/*   UWORD descent	*/		
    1,			/*   UWORD bottom	*/
    5,			/*   UWORD max_char_width*/
    6,			/*   UWORD max_cell_width*/
    0,			/*   UWORD left_offset	*/
    2,			/*   UWORD right_offset	*/
    1,			/*   UWORD thicken	*/
    1,			/*   UWORD ul_size	*/
    0x5555,		/*   UWORD lighten	*/
    0x5555,		/*   UWORD skew		*/
    STDFORM | MONOSPACE,/*   UWORD flags        */

    0,			/*   UBYTE *hor_table	*/
    off_first,		/*   UWORD *off_table	*/
    dat_first,		/*   UWORD *dat_table	*/
    192,		/*   UWORD form_width	*/
    6,			/*   UWORD form_height	*/

    0,			/*   UWORD next_font	*/
    0			/*   UWORD next_seg	*/
};

UWORD off_first[257] =
{
	0x0, 0x6, 0xC, 0x12, 0x18, 0x1E, 0x24, 0x2A, 
	0x30, 0x36, 0x3C, 0x42, 0x48, 0x4E, 0x54, 0x5A, 
	0x60, 0x66, 0x6C, 0x72, 0x78, 0x7E, 0x84, 0x8A, 
	0x90, 0x96, 0x9C, 0xA2, 0xA8, 0xAE, 0xB4, 0xBA, 
	0xC0, 0xC6, 0xCC, 0xD2, 0xD8, 0xDE, 0xE4, 0xEA, 
	0xF0, 0xF6, 0xFC, 0x102, 0x108, 0x10E, 0x114, 0x11A, 
	0x120, 0x126, 0x12C, 0x132, 0x138, 0x13E, 0x144, 0x14A, 
	0x150, 0x156, 0x15C, 0x162, 0x168, 0x16E, 0x174, 0x17A, 
	0x180, 0x186, 0x18C, 0x192, 0x198, 0x19E, 0x1A4, 0x1AA, 
	0x1B0, 0x1B6, 0x1BC, 0x1C2, 0x1C8, 0x1CE, 0x1D4, 0x1DA, 
	0x1E0, 0x1E6, 0x1EC, 0x1F2, 0x1F8, 0x1FE, 0x204, 0x20A, 
	0x210, 0x216, 0x21C, 0x222, 0x228, 0x22E, 0x234, 0x23A, 
	0x240, 0x246, 0x24C, 0x252, 0x258, 0x25E, 0x264, 0x26A, 
	0x270, 0x276, 0x27C, 0x282, 0x288, 0x28E, 0x294, 0x29A, 
	0x2A0, 0x2A6, 0x2AC, 0x2B2, 0x2B8, 0x2BE, 0x2C4, 0x2CA, 
	0x2D0, 0x2D6, 0x2DC, 0x2E2, 0x2E8, 0x2EE, 0x2F4, 0x2FA, 
	0x300, 0x306, 0x30C, 0x312, 0x318, 0x31E, 0x324, 0x32A, 
	0x330, 0x336, 0x33C, 0x342, 0x348, 0x34E, 0x354, 0x35A, 
	0x360, 0x366, 0x36C, 0x372, 0x378, 0x37E, 0x384, 0x38A, 
	0x390, 0x396, 0x39C, 0x3A2, 0x3A8, 0x3AE, 0x3B4, 0x3BA, 
	0x3C0, 0x3C6, 0x3CC, 0x3D2, 0x3D8, 0x3DE, 0x3E4, 0x3EA, 
	0x3F0, 0x3F6, 0x3FC, 0x402, 0x408, 0x40E, 0x414, 0x41A, 
	0x420, 0x426, 0x42C, 0x432, 0x438, 0x43E, 0x444, 0x44A, 
	0x450, 0x456, 0x45C, 0x462, 0x468, 0x46E, 0x474, 0x47A, 
	0x480, 0x486, 0x48C, 0x492, 0x498, 0x49E, 0x4A4, 0x4AA, 
	0x4B0, 0x4B6, 0x4BC, 0x4C2, 0x4C8, 0x4CE, 0x4D4, 0x4DA, 
	0x4E0, 0x4E6, 0x4EC, 0x4F2, 0x4F8, 0x4FE, 0x504, 0x50A, 
	0x510, 0x516, 0x51C, 0x522, 0x528, 0x52E, 0x534, 0x53A, 
	0x540, 0x546, 0x54C, 0x552, 0x558, 0x55E, 0x564, 0x56A, 
	0x570, 0x576, 0x57C, 0x582, 0x588, 0x58E, 0x594, 0x59A, 
	0x5A0, 0x5A6, 0x5AC, 0x5B2, 0x5B8, 0x5BE, 0x5C4, 0x5CA, 
	0x5D0, 0x5D6, 0x5DC, 0x5E2, 0x5E8, 0x5EE, 0x5F4, 0x5FA, 
	0x600
};

UWORD dat_first[576] =
{
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x44, 0x8A11, 0x920C, 0x1084, 
	0x8000, 0x1, 0x3847, 0x1C09, 0xE19E, 0x30C0, 0x10, 0x21C, 
	0x38C7, 0xE71, 0xE78E, 0x48E0, 0x9241, 0x144C, 0x70C7, 0xE7D, 
	0x2491, 0x4517, 0x8E41, 0xC100, 0x3004, 0x8, 0x1C0, 0x4041, 
	0x1030, 0x0, 0x0, 0x20, 0x0, 0x0, 0x611, 0x8244, 
	0x3920, 0x8449, 0x380, 0x1124, 0x1231, 0x48C, 0x1803, 0xC449, 
	0x110, 0x4924, 0x8419, 0x1703, 0x820, 0x8279, 0xE38C, 0x0, 
	0x2080, 0x0, 0x79E3, 0x4200, 0xF61E, 0x7920, 0x847D, 0xE7BD, 
	0x4920, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0xC7, 0x8078, 0x0, 0x10C3, 
	0x870C, 0x438C, 0x7846, 0x60C, 0x410D, 0x30C0, 0x371, 0xC000, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x44, 0x9F39, 0xA504, 0x2043, 
	0x400, 0x2, 0x48C0, 0x8219, 0x202, 0x4923, 0xC21, 0xE102, 
	0x4524, 0x9049, 0x410, 0x4840, 0x9441, 0xB652, 0x4924, 0x9011, 
	0x2491, 0x2911, 0x820, 0x4280, 0x20E7, 0xE38, 0xC20E, 0x71C7, 
	0x1211, 0xA70C, 0x70E5, 0x8E79, 0x2491, 0x4927, 0x8410, 0x854A, 
	0x4001, 0xA00, 0x828E, 0x2802, 0x48, 0x830C, 0x79B5, 0xA00, 
	0x8288, 0xC0, 0xE20, 0xA484, 0x1041, 0x400, 0x492, 0x1000, 
	0x2080, 0x8000, 0x4, 0x8C39, 0x430C, 0x3001, 0xEFA, 0xDE57, 
	0x120, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x3524, 0x9F20, 0xF49E, 0x3924, 
	0x4410, 0xE412, 0x1F1, 0x9810, 0x4016, 0x49E0, 0x248, 0x6380, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x44, 0x8A60, 0x4348, 0x2047, 
	0x9F01, 0xE004, 0x4843, 0xC29, 0xC704, 0x30E0, 0x40, 0x8C, 
	0x4D27, 0x1049, 0xC712, 0x7844, 0x9841, 0x5552, 0x7127, 0xC11, 
	0x2495, 0x10A2, 0x810, 0x4440, 0x1124, 0x9049, 0x6792, 0x4841, 
	0x1411, 0x5492, 0x4926, 0x1821, 0x2495, 0x3121, 0x1810, 0x6491, 
	0x4127, 0x8E38, 0xE390, 0x79E7, 0x8C30, 0xC492, 0x4077, 0xCC30, 
	0xC492, 0x4924, 0x9071, 0xF78E, 0x38C3, 0x1271, 0xA38C, 0x1E7, 
	0xAE8C, 0x252, 0x38C7, 0x965D, 0x7492, 0x4800, 0x4FA, 0x9D55, 
	0x4920, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x4944, 0xA11, 0x2488, 0x55E4, 
	0x4E39, 0x5792, 0x7846, 0x610, 0x47C0, 0x30C1, 0x248, 0x8380, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x1F18, 0xB480, 0x2043, 
	0x430, 0x8, 0x4844, 0x27C, 0x2488, 0x4840, 0xC21, 0xE100, 
	0x4DE4, 0x9049, 0x412, 0x4844, 0x9441, 0x14D2, 0x4124, 0x8211, 
	0x251B, 0x2844, 0x808, 0x4000, 0x124, 0x9049, 0x20E, 0x4841, 
	0x1C11, 0x5492, 0x4924, 0x621, 0x2515, 0x3142, 0x400, 0x8011, 
	0x4124, 0x1249, 0x2490, 0x4104, 0x410, 0x479E, 0x71C5, 0x1249, 
	0x2492, 0x5124, 0x8E20, 0x45C4, 0x4844, 0x9249, 0x6000, 0x3100, 
	0xA394, 0x8489, 0x4924, 0x9A51, 0x479E, 0x4800, 0x47A, 0x9E40, 
	0x4820, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x4924, 0xA21, 0x2488, 0x3922, 
	0x9255, 0x5412, 0x0, 0x10, 0x400D, 0x0, 0x1249, 0xE380, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x40, 0xA71, 0x3340, 0x1084, 
	0x8010, 0x310, 0x7047, 0x9C09, 0xC308, 0x3183, 0x410, 0x208, 
	0x4127, 0xE71, 0xE40E, 0x48E3, 0x1279, 0x144C, 0x40C4, 0x5C11, 
	0xE211, 0x4447, 0x8E05, 0xC000, 0xE7, 0xE38, 0xE202, 0x49E1, 
	0x1279, 0x148C, 0x70E4, 0x1C18, 0xE20A, 0x4887, 0x8611, 0x801F, 
	0x38E3, 0x8E38, 0xE38E, 0x38E3, 0x9E79, 0xE492, 0x78F5, 0xCC30, 
	0xC38E, 0x20C7, 0x8478, 0x4498, 0x39E3, 0xE49, 0x279E, 0x4000, 
	0x43C, 0x8252, 0x38CB, 0xC3C, 0xF492, 0x3000, 0x40A, 0xDD40, 
	0x49C0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x35C4, 0x978, 0xC706, 0x10C6, 
	0xCC38, 0xE392, 0x79F7, 0x9E10, 0x4116, 0x0, 0x2A00, 0x380, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x20, 0x0, 0x0, 
	0x20, 0x0, 0x0, 0x0, 0x0, 0x0, 0x800, 0x0, 
	0x3800, 0x0, 0x0, 0x0, 0x0, 0x0, 0x60, 0x0, 
	0x0, 0x0, 0x0, 0x3F, 0x0, 0x0, 0x1C, 0x6, 
	0x0, 0x0, 0x4020, 0x0, 0x0, 0x100, 0x10, 0x0, 
	0x6000, 0x0, 0x18, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x4000, 0x0, 0x4C0, 0x0, 0x0, 0x0, 0x3800, 
	0xF04, 0x8000, 0x0, 0x1000, 0x0, 0x0, 0x9, 0xE780, 
	0x1000, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x100, 0x0, 0x800, 0x0, 
	0x60, 0x4000, 0x0, 0x11, 0x8000, 0x0, 0x600, 0x0, 
};

