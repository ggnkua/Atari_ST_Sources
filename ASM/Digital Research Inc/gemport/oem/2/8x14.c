/* 8x14 font */

#include "portab.h"

#include "fontdef.h"

EXTERN	UWORD	off_second[],dat_second[];

struct font_head second ={
    1,			/*   WORD font_id	*/
    10,			/*   WORD point		*/
"System",		/*   BYTE name[32]	*/
    0,			/*   UWORD first_ade	*/
    255,		/*   UWORD last_ade	*/
    10,	    		/*   UWORD top		*/
    8,	    		/*   UWORD ascent	*/
    5,	    		/*   UWORD half		*/
    2,	    		/*   UWORD descent	*/		
    3,			/*   UWORD bottom	*/
    7,			/*   UWORD max_char_width*/
    8,			/*   UWORD max_cell_width*/
    1,			/*   UWORD left_offset	*/
    5,			/*   UWORD right_offset	*/
    1,			/*   UWORD thicken	*/
    1,			/*   UWORD ul_size	*/
    0x5555,		/*   UWORD lighten	*/
    0x5555,		/*   UWORD skew		*/
  STDFORM |  MONOSPACE | DEFAULT,/*   UWORD flags        */

    0,			/*   UBYTE *hor_table	*/
    off_second,	/*   UWORD *off_table	*/
    dat_second,	/*   UWORD *dat_table	*/
    256,		/*   UWORD form_width	*/
    14,			/*   UWORD form_height	*/

    0,    		/*   UWORD next_font	*/
    0			/*   UWORD next_seg	*/
};

UWORD off_second[257] =
{
	0x0, 0x8, 0x10, 0x18, 0x20, 0x28, 0x30, 0x38, 
	0x40, 0x48, 0x50, 0x58, 0x60, 0x68, 0x70, 0x78, 
	0x80, 0x88, 0x90, 0x98, 0xA0, 0xA8, 0xB0, 0xB8, 
	0xC0, 0xC8, 0xD0, 0xD8, 0xE0, 0xE8, 0xF0, 0xF8, 
	0x100, 0x108, 0x110, 0x118, 0x120, 0x128, 0x130, 0x138, 
	0x140, 0x148, 0x150, 0x158, 0x160, 0x168, 0x170, 0x178, 
	0x180, 0x188, 0x190, 0x198, 0x1A0, 0x1A8, 0x1B0, 0x1B8, 
	0x1C0, 0x1C8, 0x1D0, 0x1D8, 0x1E0, 0x1E8, 0x1F0, 0x1F8, 
	0x200, 0x208, 0x210, 0x218, 0x220, 0x228, 0x230, 0x238, 
	0x240, 0x248, 0x250, 0x258, 0x260, 0x268, 0x270, 0x278, 
	0x280, 0x288, 0x290, 0x298, 0x2A0, 0x2A8, 0x2B0, 0x2B8, 
	0x2C0, 0x2C8, 0x2D0, 0x2D8, 0x2E0, 0x2E8, 0x2F0, 0x2F8, 
	0x300, 0x308, 0x310, 0x318, 0x320, 0x328, 0x330, 0x338, 
	0x340, 0x348, 0x350, 0x358, 0x360, 0x368, 0x370, 0x378, 
	0x380, 0x388, 0x390, 0x398, 0x3A0, 0x3A8, 0x3B0, 0x3B8, 
	0x3C0, 0x3C8, 0x3D0, 0x3D8, 0x3E0, 0x3E8, 0x3F0, 0x3F8, 
	0x400, 0x408, 0x410, 0x418, 0x420, 0x428, 0x430, 0x438, 
	0x440, 0x448, 0x450, 0x458, 0x460, 0x468, 0x470, 0x478, 
	0x480, 0x488, 0x490, 0x498, 0x4A0, 0x4A8, 0x4B0, 0x4B8, 
	0x4C0, 0x4C8, 0x4D0, 0x4D8, 0x4E0, 0x4E8, 0x4F0, 0x4F8, 
	0x500, 0x508, 0x510, 0x518, 0x520, 0x528, 0x530, 0x538, 
	0x540, 0x548, 0x550, 0x558, 0x560, 0x568, 0x570, 0x578, 
	0x580, 0x588, 0x590, 0x598, 0x5A0, 0x5A8, 0x5B0, 0x5B8, 
	0x5C0, 0x5C8, 0x5D0, 0x5D8, 0x5E0, 0x5E8, 0x5F0, 0x5F8, 
	0x600, 0x608, 0x610, 0x618, 0x620, 0x628, 0x630, 0x638, 
	0x640, 0x648, 0x650, 0x658, 0x660, 0x668, 0x670, 0x678, 
	0x680, 0x688, 0x690, 0x698, 0x6A0, 0x6A8, 0x6B0, 0x6B8, 
	0x6C0, 0x6C8, 0x6D0, 0x6D8, 0x6E0, 0x6E8, 0x6F0, 0x6F8, 
	0x700, 0x708, 0x710, 0x718, 0x720, 0x728, 0x730, 0x738, 
	0x740, 0x748, 0x750, 0x758, 0x760, 0x768, 0x770, 0x778, 
	0x780, 0x788, 0x790, 0x798, 0x7A0, 0x7A8, 0x7B0, 0x7B8, 
	0x7C0, 0x7C8, 0x7D0, 0x7D8, 0x7E0, 0x7E8, 0x7F0, 0x7F8, 
	0x800
};

UWORD dat_second[1792] =
{
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x3800, 0x0, 0x0, 0x0, 0xC638, 
	0xE00, 0x0, 0x0, 0x0, 0xC6, 0xC600, 0x0, 0x0, 
	0x0, 0x0, 0x76, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0xE076, 0x7600, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0xE18, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x3E, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x1000, 0x0, 0x0, 0x0, 0x0, 0x6, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0xC000, 0x1000, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1800, 0x0, 
	0x0, 0x610, 0x60, 0x4400, 0x1000, 0x6000, 0x1060, 0xC644, 
	0x1800, 0x10, 0x60, 0x1060, 0xC6, 0xC600, 0x0, 0x0, 
	0x60C, 0x606, 0x76DC, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x600, 0x0, 0x30DC, 0xDC00, 0x600, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0xC00, 0x0, 
	0x0, 0x0, 0x1B18, 0x0, 0x0, 0x7, 0x0, 0x0, 
	0x8, 0x1C10, 0x8FF, 0xF800, 0x31C, 0x181F, 0x3C3F, 0x7F18, 
	0x4001, 0x1833, 0x7F63, 0x18, 0x1818, 0x0, 0x0, 0x0, 
	0x18, 0x6644, 0x1060, 0x7838, 0xC60, 0x0, 0x0, 0x4, 
	0x7C18, 0x7C7C, 0xCFE, 0xCFE, 0x7C7C, 0x0, 0xC00, 0x603C, 
	0x7C38, 0xFC7C, 0xF87E, 0x7E7C, 0xC63C, 0x6C6, 0x6082, 0xC67C, 
	0xFC7C, 0xFC7C, 0x7EC6, 0xC6C6, 0xC6C6, 0xFE3C, 0x4078, 0x3800, 
	0x3800, 0xC000, 0x600, 0x1E00, 0xC018, 0xCC0, 0x7800, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x1C, 0x1870, 0x7610, 
	0x7C6C, 0xC38, 0x6C30, 0x4400, 0x386C, 0x306C, 0x3830, 0x44, 
	0x0, 0x3E38, 0x6C30, 0x3830, 0x6C00, 0x10, 0x3CC6, 0xF01E, 
	0xC18, 0xC0C, 0xDC00, 0x3C3C, 0x0, 0x40, 0x4000, 0x0, 
	0x7676, 0x7C00, 0x7E, 0x0, 0x6C, 0xC18, 0x7E7E, 0x7EF1, 
	0x66F6, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x78, 0xFE00, 0xFE00, 0x0, 0x3C38, 0x7C3E, 0x1000, 0x3E7C, 
	0x0, 0x600C, 0x1B18, 0x0, 0x3C38, 0x4, 0x7C3C, 0x0, 
	0x1C, 0x1C18, 0x18FF, 0xF810, 0x32A, 0x241E, 0x6633, 0x6318, 
	0x6003, 0x3C33, 0xDB30, 0x3C, 0x3C18, 0x0, 0x0, 0x7E, 
	0x3C, 0x6644, 0x7C92, 0xCC18, 0x1830, 0x0, 0x0, 0xC, 
	0xC638, 0xC6C6, 0x1CC0, 0x1806, 0xC6C6, 0x0, 0x1800, 0x3066, 
	0x866C, 0x66C6, 0x6C60, 0x60C6, 0xC618, 0x6C6, 0x60C6, 0xE6C6, 
	0xC6C6, 0xC6C6, 0x18C6, 0xC6C6, 0xC6C6, 0x630, 0x6018, 0x6C00, 
	0x3000, 0xC000, 0x600, 0x3300, 0xC018, 0xCC0, 0x1800, 0x0, 
	0x0, 0x0, 0x6000, 0x0, 0x0, 0x30, 0x1818, 0xDC38, 
	0xC66C, 0x186C, 0x6C18, 0x3800, 0x6C6C, 0x186C, 0x6C18, 0x3838, 
	0x7E00, 0x686C, 0x6C18, 0x6C18, 0x6C7C, 0xC610, 0x66C6, 0x8830, 
	0x1830, 0x1818, 0xC6, 0x666, 0x0, 0xC0, 0xC000, 0x0, 
	0xDCDC, 0xC600, 0xC8, 0x3838, 0x7C6C, 0x1818, 0xFC81, 0x815B, 
	0x6666, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xCC, 0x6200, 0x6200, 0x0, 0x186C, 0xC630, 0x1010, 0x60C6, 
	0x18, 0x3018, 0x1818, 0x1800, 0x667C, 0x4, 0x6666, 0x3C00, 
	0x3E, 0x1C1C, 0x38FF, 0xF838, 0x649, 0x2418, 0x663F, 0x7FDB, 
	0x7007, 0x7E33, 0xDB1C, 0x7E, 0x7E18, 0xC18, 0x24, 0x7E, 
	0x3C, 0x66FE, 0xD694, 0xCC18, 0x3018, 0x6C18, 0x0, 0x8, 
	0xC678, 0xC606, 0x3CC0, 0x3006, 0xC6C6, 0x1818, 0x3000, 0x1866, 
	0x9EC6, 0x66C6, 0x6660, 0x60C0, 0xC618, 0x6CC, 0x60EE, 0xF6C6, 
	0xC6C6, 0xC6C6, 0x18C6, 0xC6D6, 0xC6C6, 0xC30, 0x2018, 0xC600, 
	0x3000, 0xC000, 0x600, 0x3000, 0xC000, 0xC0, 0x1800, 0x0, 
	0x0, 0x0, 0x6000, 0x0, 0x0, 0x30, 0x1818, 0x6C, 
	0xC600, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x6C6C, 
	0x6000, 0xC800, 0x0, 0x0, 0xC6, 0xC67C, 0x60C6, 0x8830, 
	0x0, 0x0, 0xE6, 0x3E66, 0x3000, 0xC0, 0xC030, 0x0, 
	0x0, 0xCE06, 0xC8, 0x6C6C, 0xC600, 0x7E, 0xFC9D, 0xBD55, 
	0x66, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xCC, 0x6000, 0x3000, 0x0, 0x7EC6, 0xC618, 0x7C10, 0xC0C6, 
	0xFE18, 0x1830, 0x1818, 0x1876, 0x667C, 0x4, 0x6606, 0x3C00, 
	0x7F, 0x1CFE, 0x7FFF, 0xF87C, 0x649, 0x2410, 0x6630, 0x633C, 
	0x7C1F, 0x1833, 0xDB36, 0x18, 0x1818, 0x630, 0x6066, 0x183C, 
	0x18, 0x2444, 0xD068, 0xD830, 0x3018, 0x3818, 0x0, 0x18, 
	0xCE18, 0x606, 0x6CFC, 0x600C, 0xC6C6, 0x1818, 0x60FE, 0xC0C, 
	0xB6C6, 0x66C0, 0x6660, 0x60C0, 0xC618, 0x6D8, 0x60D6, 0xDEC6, 
	0xC6C6, 0xC660, 0x18C6, 0xC6D6, 0x6CC6, 0x1830, 0x3018, 0x0, 
	0x187C, 0xDC7C, 0x7E7C, 0x307E, 0xDC78, 0x3CC6, 0x18EC, 0xDC7C, 
	0xDC7E, 0xDC7C, 0xFCC6, 0xC6C6, 0xC6C6, 0xFE30, 0x1818, 0xC6, 
	0xC0C6, 0x7C7C, 0x7C7C, 0x7C7C, 0x7C7C, 0x7C78, 0x7878, 0xC6C6, 
	0x607C, 0xC87C, 0x7C7C, 0xC6C6, 0xC6C6, 0xC6D6, 0x606C, 0xF830, 
	0x7C78, 0x7CC6, 0xDCF6, 0x6666, 0x3000, 0xDC, 0xC630, 0x66CC, 
	0x7C7C, 0xDE7C, 0x7CC8, 0xC6C6, 0xC600, 0x18, 0xFCB1, 0xA551, 
	0xEE66, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x76C8, 0x60FE, 0x187F, 0x66FE, 0xDBC6, 0xC60C, 0xD67C, 0xC0C6, 
	0x7E, 0xC60, 0x1818, 0xDC, 0x3C38, 0x4, 0x663C, 0x3C00, 
	0x1C, 0x1CFF, 0xFFFF, 0xF8FE, 0xCC49, 0x2410, 0x3C30, 0x63E7, 
	0x7F7F, 0x1833, 0x5B63, 0x18, 0x1818, 0x7F7F, 0x60FF, 0x3C3C, 
	0x18, 0x44, 0x7C10, 0x7000, 0x3018, 0xFE7E, 0xFE, 0x10, 
	0xD618, 0x1C3C, 0xCC06, 0xFC18, 0x7C7E, 0x0, 0xC000, 0x618, 
	0xB6C6, 0x7CC0, 0x667C, 0x7CDE, 0xFE18, 0x6F0, 0x60D6, 0xCEC6, 
	0xC6C6, 0xFC38, 0x18C6, 0xC6D6, 0x386C, 0x3030, 0x1018, 0x0, 
	0x6, 0xE6C6, 0xC6C6, 0x7EC6, 0xE618, 0xCCC, 0x18D6, 0xE6C6, 
	0xE6C6, 0xE6C6, 0x60C6, 0xC6C6, 0x6CC6, 0xCE0, 0xE, 0xC6, 
	0xC0C6, 0xC606, 0x606, 0x6C6, 0xC6C6, 0xC618, 0x1818, 0xC6C6, 
	0x7C16, 0xFEC6, 0xC6C6, 0xC6C6, 0xC6C6, 0xC6D0, 0xF8FE, 0x927C, 
	0x618, 0xC6C6, 0xE6DE, 0x6666, 0xFE, 0xFEC6, 0xCE00, 0xCC66, 
	0x6C6, 0xF6CE, 0xD6CE, 0xC6C6, 0xC600, 0x18, 0x7CB1, 0xBD00, 
	0x6666, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xCCDC, 0x606C, 0xCCC, 0x6630, 0xDBFE, 0xC67C, 0xD6D6, 0xFEC6, 
	0xFE18, 0x1830, 0x1818, 0x7E00, 0x0, 0x1804, 0x6660, 0x3C00, 
	0x1C, 0x1CFE, 0x7FFF, 0xF87C, 0xCC45, 0x2410, 0x1830, 0x633C, 
	0x7C1F, 0x1833, 0x1B63, 0x18, 0x1818, 0x630, 0x6066, 0x3C18, 
	0x18, 0xFE, 0x162C, 0xDA00, 0x3018, 0x3818, 0x0, 0x30, 
	0xE618, 0x7006, 0xCC06, 0xC630, 0xC60C, 0x0, 0x60FE, 0xC18, 
	0xB6FE, 0x66C0, 0x6660, 0x60C6, 0xC618, 0xC6D8, 0x60D6, 0xC6C6, 
	0xFCC6, 0xD80C, 0x18C6, 0xC6D6, 0x6C38, 0x6030, 0x1818, 0x0, 
	0x7E, 0xC6C0, 0xC6FE, 0x30C6, 0xC618, 0xCD8, 0x18D6, 0xC6C6, 
	0xC6C6, 0xC670, 0x60C6, 0xC6D6, 0x38C6, 0x1820, 0x1808, 0xC6, 
	0xC0C6, 0xFE7E, 0x7E7E, 0x7EC0, 0xFEFE, 0xFE18, 0x1818, 0xFEFE, 
	0x607E, 0xC8C6, 0xC6C6, 0xC6C6, 0xC6C6, 0xC6D0, 0x6030, 0xBC30, 
	0x7E18, 0xC6C6, 0xC6CE, 0x3B3C, 0x30C0, 0x6C6, 0xD630, 0xCC66, 
	0x7EC6, 0xE6DE, 0xDEC8, 0xFEFE, 0xC600, 0x18, 0xCB1, 0xA900, 
	0x66F6, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xCCC6, 0x606C, 0x18C6, 0x6630, 0xDBC6, 0xC6C6, 0xD6D6, 0xC0C6, 
	0x18, 0x3018, 0x1818, 0x76, 0x0, 0x1844, 0x667E, 0x3C00, 
	0x1C, 0x7F1C, 0x38FF, 0xF938, 0x6C22, 0x2470, 0x7E70, 0x67DB, 
	0x7007, 0x7E00, 0x1B36, 0x7F7E, 0x187E, 0xC18, 0x7F24, 0x7E00, 
	0x0, 0x44, 0xD652, 0xCC00, 0x3018, 0x6C18, 0x0, 0x20, 
	0xC618, 0xC006, 0xFEC6, 0xC660, 0xC618, 0x0, 0x3000, 0x1800, 
	0x9EC6, 0x66C6, 0x6660, 0x60C6, 0xC618, 0xC6CC, 0x60C6, 0xC6C6, 
	0xC0F6, 0xCCC6, 0x18C6, 0x6C6C, 0xC630, 0xC030, 0x818, 0x0, 
	0xC6, 0xC6C0, 0xC6C0, 0x30CE, 0xC618, 0xCF8, 0x18D6, 0xC6C6, 
	0xC6C6, 0xC01C, 0x60C6, 0x6CD6, 0x386C, 0x3030, 0x1818, 0xC6, 
	0xC6C6, 0xC0C6, 0xC6C6, 0xC6C0, 0xC0C0, 0xC018, 0x1818, 0xC6C6, 
	0x60D0, 0xC8C6, 0xC6C6, 0xC6C6, 0x6CC6, 0xC6D6, 0x60FE, 0x9630, 
	0xC618, 0xC6C6, 0xC6C6, 0x0, 0x30C0, 0x60C, 0x2630, 0xCC66, 
	0xC6C6, 0xC6F6, 0xD0C8, 0xC6C6, 0xC600, 0x18, 0xC9D, 0xA500, 
	0x6606, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xCCC6, 0x606C, 0x30C6, 0x6630, 0x7EC6, 0x6CC6, 0xD6D6, 0xC0C6, 
	0xFE00, 0x600C, 0x1818, 0x18DC, 0x0, 0xE4, 0x0, 0x3C00, 
	0x1C, 0x3E18, 0x18FF, 0x510, 0x3822, 0x24F0, 0x18F0, 0xE718, 
	0x6003, 0x3C33, 0x1B1C, 0x7F3C, 0x183C, 0x0, 0x0, 0x7E00, 
	0x18, 0x44, 0x7C92, 0xCC00, 0x3018, 0x0, 0x3800, 0x1860, 
	0xC618, 0xC0C6, 0xCC6, 0xC660, 0xC630, 0x1838, 0x1800, 0x3018, 
	0x80C6, 0x66C6, 0x6C60, 0x60C6, 0xC618, 0xC6C6, 0x60C6, 0xC6C6, 
	0xC0DC, 0xCCC6, 0x18C6, 0x386C, 0xC630, 0xC030, 0xC18, 0x0, 
	0xC6, 0xC6C6, 0xCEC6, 0x3076, 0xC618, 0xCCC, 0x18D6, 0xC6C6, 
	0xC6CE, 0xC0C6, 0x66CE, 0x386C, 0x6C38, 0x6030, 0x1818, 0xC6, 
	0xC6CE, 0xC6C6, 0xC6C6, 0xC6C6, 0xC6C6, 0xC618, 0x1818, 0xC6C6, 
	0x60D0, 0xC8C6, 0xC6C6, 0xCECE, 0x38C6, 0xC67C, 0x4030, 0x9230, 
	0xC618, 0xC6CE, 0xC6C6, 0x0, 0x6000, 0x18, 0x3E30, 0x66CC, 
	0xC6C6, 0xC6E6, 0xD0C8, 0xC6C6, 0xC600, 0x18, 0xC81, 0x8100, 
	0x6666, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xCCE6, 0x606C, 0x62C6, 0x6630, 0x186C, 0x6CC6, 0x7CD6, 0x60C6, 
	0x7E, 0x0, 0x1818, 0x1800, 0x0, 0x34, 0x0, 0x3C00, 
	0x1C, 0x1C10, 0x8FF, 0x300, 0x181C, 0x7EF0, 0x18E0, 0xE618, 
	0x4001, 0x1833, 0x1B06, 0x7F18, 0x1818, 0x0, 0x0, 0x0, 
	0x18, 0x0, 0x100C, 0x7600, 0x1830, 0x0, 0x1800, 0x1840, 
	0x7C18, 0xFE7C, 0xC7C, 0x7C60, 0x7C60, 0x1818, 0xC00, 0x6018, 
	0x7CC6, 0xFC7C, 0xF87E, 0x607A, 0xC63C, 0x7CC6, 0x7EC6, 0xC67C, 
	0xC07C, 0xC67C, 0x187C, 0x1044, 0xC630, 0xFE30, 0x418, 0x0, 
	0x7E, 0xFC7C, 0x767C, 0x3006, 0xC67E, 0xCC6, 0x7EC6, 0xC67C, 
	0xFC76, 0xC07C, 0x3C76, 0x1044, 0xC630, 0xFE30, 0x1818, 0xFE, 
	0x7C76, 0x7C7E, 0x7E7E, 0x7E7C, 0x7C7C, 0x7C7E, 0x7E7E, 0xC6C6, 
	0x7E7E, 0xCE7C, 0x7C7C, 0x7676, 0x307C, 0x7C10, 0xFE30, 0x9430, 
	0x7E7E, 0x7C76, 0xC6C6, 0x7E7E, 0xCC00, 0x1E, 0x678, 0x0, 
	0x7E7C, 0x7C7C, 0x7E7E, 0xC6C6, 0x7C00, 0x18, 0xC7E, 0x7E00, 
	0xF63C, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x76DC, 0xF066, 0xFE7C, 0x7C1C, 0x3C38, 0xEE7C, 0x107C, 0x3EC6, 
	0x0, 0xFEFE, 0x1818, 0x0, 0x0, 0x1C, 0x0, 0x3C00, 
	0x1C, 0x800, 0xFF, 0xF00, 0x0, 0x1860, 0x0, 0xC000, 
	0x0, 0x0, 0x63, 0x7E, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x1000, 0x0, 0xC60, 0x0, 0x1800, 0xC0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x18, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x6, 0x0, 0x0, 0x0, 0x0, 0x3C, 0x678, 0x0, 
	0x0, 0x0, 0x0, 0xC6, 0x0, 0xCC00, 0x0, 0x0, 
	0xC006, 0x0, 0x0, 0x0, 0x60, 0x1C, 0x1870, 0x0, 
	0x1000, 0x0, 0x0, 0x10, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x6000, 0x10, 0x0, 0xE0, 
	0x0, 0x0, 0x0, 0x0, 0xCC00, 0x0, 0x78, 0x0, 
	0x0, 0xC0C0, 0x0, 0x0, 0x0, 0x0, 0xC00, 0x0, 
	0x600, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xC0, 0x0, 0x0, 0x6000, 0x0, 0x0, 0x1010, 0x0, 
	0x0, 0x0, 0x18D8, 0x0, 0x0, 0xC, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x3E, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x3000, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x30, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0xFF, 
	0x0, 0x0, 0x0, 0x7C, 0x0, 0x7800, 0x0, 0x0, 
	0xC006, 0x0, 0x0, 0x0, 0xC0, 0x0, 0x0, 0x0, 
	0x7000, 0x0, 0x0, 0x70, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0xC000, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x7800, 0x0, 0x30, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0xC00, 0x0, 
	0x3C00, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0xC0, 0x0, 0x0, 0xC000, 0x0, 0x0, 0x6010, 0x0, 
	0x0, 0x0, 0x18D8, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 
	0x0, 0x0, 0x1870, 0x0, 0x0, 0x0, 0x0, 0x0, 
};
