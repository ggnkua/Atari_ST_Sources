/********************************************************/
/*							*/
/*	Include file for SID-68K -- MC68010 Version	*/
/*							*/
/********************************************************/

#define MC68010 1

