   /* external function declarations for rcsiinit.c */
/*************************************************************
 * Copyright 1999 by Caldera Thin Clients, Inc.              *
 * This software is licensed under the GNU Public License.   *
 * Please see LICENSE.TXT for further information.           *
 *************************************************************/
#ifndef RCSIINIT_H

#define RCSIINIT_H

EXTERN	VOID	set_icnmenus(VOID);
EXTERN	VOID	init_img(VOID);
EXTERN	VOID	outl_img(VOID);
EXTERN	VOID	icn_init(BOOLEAN size_changed);
EXTERN  VOID    icon_edit(VOID);

#endif
