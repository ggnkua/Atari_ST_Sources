; Vertices
	dc.w 50
	dc.w 25
	dc.w 491,-2355,0
	dc.w 0,-2355,-456
	dc.w -491,-2355,0
	dc.w 0,-2355,456
	dc.w 288,-1857,0
	dc.w 0,-1857,-288
	dc.w -288,-1857,0
	dc.w 0,-1857,288
	dc.w 336,-1362,0
	dc.w 0,-1362,-336
	dc.w -336,-1362,0
	dc.w 0,-1362,336
	dc.w 576,-1133,0
	dc.w 0,-1133,-576
	dc.w -576,-1133,0
	dc.w 0,-1133,576
	dc.w 144,-637,0
	dc.w 0,-637,-144
	dc.w -144,-637,0
	dc.w 0,-637,144
	dc.w 144,-141,0
	dc.w 0,-141,-144
	dc.w -144,-141,0
	dc.w 0,-141,144
	dc.w 0,-2938,0

; Normal List
	dc.w 124,-8,-26
	dc.w -25,-9,-125
	dc.w -124,-8,26
	dc.w 25,-9,125
	dc.w 126,17,0
	dc.w -1,16,-126
	dc.w -126,17,0
	dc.w 1,16,126
	dc.w 113,-59,4
	dc.w 4,-59,-113
	dc.w -113,-59,-4
	dc.w -4,-59,113
	dc.w 127,-7,-1
	dc.w -1,-7,-127
	dc.w -127,-7,1
	dc.w 1,-7,127
	dc.w 118,47,-3
	dc.w -3,47,-118
	dc.w -118,47,3
	dc.w 3,47,118
	dc.w 90,85,30
	dc.w 36,52,-110
	dc.w -90,85,-30
	dc.w -36,52,110
	dc.w 0,-128,0

	dc.w 0	;0 texture vertices

; Face List
	dc.w 46
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,0,1,5,25,26,30
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,0,5,4,25,30,29
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,1,2,6,26,27,31
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,1,6,5,26,31,30
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,2,3,7,27,28,32
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,2,7,6,27,32,31
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,3,0,4,28,25,29
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,3,4,7,28,29,32
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,4,5,9,29,30,34
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,4,9,8,29,34,33
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,5,6,10,30,31,35
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,5,10,9,30,35,34
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,6,7,11,31,32,36
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,6,11,10,31,36,35
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,7,4,8,32,29,33
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,7,8,11,32,33,36
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,8,9,13,33,34,38
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,8,13,12,33,38,37
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,9,10,14,34,35,39
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,9,14,13,34,39,38
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,10,11,15,35,36,40
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,10,15,14,35,40,39
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,11,8,12,36,33,37
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,11,12,15,36,37,40
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,12,13,17,37,38,42
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,12,17,16,37,42,41
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,13,14,18,38,39,43
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,13,18,17,38,43,42
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,14,15,19,39,40,44
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,14,19,18,39,44,43
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,15,12,16,40,37,41
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,15,16,19,40,41,44
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,16,17,21,41,42,46
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,16,21,20,41,46,45
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,17,18,22,42,43,47
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,17,22,21,42,47,46
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,18,19,23,43,44,48
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,18,23,22,43,48,47
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,19,16,20,44,41,45
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,19,20,23,44,45,48
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,24,1,0,49,26,25
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,20,21,22,45,46,47
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,3,2,24,28,27,49
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,20,22,23,45,47,48
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,2,1,24,27,26,49
	dc.w Polygon.TRI|Polygon.ENVMAPPED|0,3,24,0,28,49,25
