	dc.w	$FFE3,$FFE2 ;-0.126471,-0.150000

	dc.w	$FFE7,$FFE2 ;-0.111677,-0.150000

	dc.w	$FFEA,$FFE2 ;-0.096884,-0.150000

	dc.w	$FFEE,$FFE2 ;-0.082090,-0.150000

	dc.w	$FFF0,$FFE3 ;-0.070588,-0.146709

	dc.w	$FFF0,$FFE6 ;-0.070588,-0.131915

	dc.w	$FFF0,$FFEA ;-0.070588,-0.117122

	dc.w	$FFF0,$FFED ;-0.070588,-0.102328

	dc.w	$FFF0,$FFF0 ;-0.070588,-0.087535

	dc.w	$FFF0,$FFF4 ;-0.071365,-0.072773

	dc.w	$FFF0,$FFF7 ;-0.072561,-0.058028

	dc.w	$FFF0,$FFFB ;-0.073756,-0.043283

	dc.w	$FFEF,$FFFE ;-0.074952,-0.028537

	dc.w	$FFEF,$0000 ;-0.076147,-0.013792

	dc.w	$FFEF,$0004 ;-0.077343,0.000953

	dc.w	$FFEE,$0007 ;-0.078538,0.015698

	dc.w	$FFEE,$000A ;-0.082153,0.029364

	dc.w	$FFEB,$000D ;-0.092327,0.040103

	dc.w	$FFE9,$000F ;-0.102501,0.050842

	dc.w	$FFE7,$0012 ;-0.112675,0.061582

	dc.w	$FFE4,$0014 ;-0.122849,0.072321

	dc.w	$FFE2,$0017 ;-0.133268,0.082688

	dc.w	$FFDF,$0018 ;-0.147157,0.087781

	dc.w	$FFDB,$0019 ;-0.161047,0.092874

	dc.w	$FFD8,$001A ;-0.174936,0.097967

	dc.w	$FFD5,$001B ;-0.188825,0.103059

	dc.w	$FFD2,$001C ;-0.202714,0.108152

	dc.w	$FFCF,$001E ;-0.216604,0.113245

	dc.w	$FFCB,$001E ;-0.231138,0.114706

	dc.w	$FFC8,$001E ;-0.245931,0.114706

	dc.w	$FFC5,$001E ;-0.260725,0.114706

	dc.w	$FFC1,$001E ;-0.275518,0.114706

	dc.w	$FFBE,$001E ;-0.290312,0.114706

	dc.w	$FFBB,$001D ;-0.302941,0.112542

	dc.w	$FFBB,$001A ;-0.302941,0.097749

	dc.w	$FFBB,$0017 ;-0.302941,0.082955

	dc.w	$FFBB,$0014 ;-0.300514,0.070588

	dc.w	$FFBF,$0014 ;-0.285721,0.070588

	dc.w	$FFC2,$0014 ;-0.270927,0.070588

	dc.w	$FFC6,$0014 ;-0.256134,0.070588

	dc.w	$FFC9,$0013 ;-0.241742,0.067195

	dc.w	$FFCC,$0012 ;-0.227357,0.063742

	dc.w	$FFD0,$0011 ;-0.212972,0.060290

	dc.w	$FFD3,$0011 ;-0.198587,0.056837

	dc.w	$FFD6,$0010 ;-0.184202,0.053385

	dc.w	$FFD9,$000E ;-0.172965,0.044106

	dc.w	$FFDB,$000B ;-0.162193,0.033967

	dc.w	$FFDE,$0009 ;-0.151420,0.023828

	dc.w	$FFE0,$0007 ;-0.140647,0.013689

	dc.w	$FFE2,$0004 ;-0.132119,0.002487

	dc.w	$FFE2,$0001 ;-0.131101,-0.012271

	dc.w	$FFE3,$FFFE ;-0.130083,-0.027030

	dc.w	$FFE3,$FFFB ;-0.129065,-0.041788

	dc.w	$FFE3,$FFF8 ;-0.128048,-0.056547

	dc.w	$FFE3,$FFF4 ;-0.127030,-0.071305

	dc.w	$FFE3,$FFF1 ;-0.126471,-0.086079

	dc.w	$FFE3,$FFED ;-0.126471,-0.100873

	dc.w	$FFE3,$FFEA ;-0.126471,-0.115666

	dc.w	$FFE3,$FFE7 ;-0.126471,-0.130460

	dc.w	$FFE3,$FFE3 ;-0.126471,-0.145253

	dc.w	$FFFA,$FFE4 ;-0.026471,-0.139953

	dc.w	$FFFA,$FFE8 ;-0.026471,-0.125160

	dc.w	$FFFA,$FFEB ;-0.026471,-0.110366

	dc.w	$FFFA,$FFEF ;-0.026471,-0.095573

	dc.w	$FFFA,$FFF2 ;-0.026471,-0.080780

	dc.w	$FFFA,$FFF5 ;-0.026471,-0.065986

	dc.w	$FFFA,$FFF9 ;-0.026471,-0.051193

	dc.w	$FFFA,$FFFC ;-0.026471,-0.036399

	dc.w	$FFFA,$0000 ;-0.026471,-0.021606

	dc.w	$FFFA,$0002 ;-0.026471,-0.006812

	dc.w	$FFFA,$0005 ;-0.026471,0.007981

	dc.w	$FFFA,$0009 ;-0.026471,0.022775

	dc.w	$FFFA,$000C ;-0.026471,0.037568

	dc.w	$FFFA,$0010 ;-0.026471,0.052362

	dc.w	$FFFA,$0013 ;-0.026471,0.067155

	dc.w	$FFFA,$0016 ;-0.026471,0.081949

	dc.w	$FFFA,$001A ;-0.026471,0.096742

	dc.w	$FFFB,$001D ;-0.023759,0.108824

	dc.w	$FFFE,$001D ;-0.008965,0.108824

	dc.w	$0001,$001D ;0.005828,0.108824

	dc.w	$0004,$001D ;0.020622,0.108824

	dc.w	$0005,$001A ;0.023529,0.096938

	dc.w	$0005,$0016 ;0.023529,0.082144

	dc.w	$0005,$0013 ;0.023529,0.067351

	dc.w	$0005,$0010 ;0.023529,0.052557

	dc.w	$0005,$000C ;0.023529,0.037764

	dc.w	$0005,$0009 ;0.023529,0.022970

	dc.w	$0005,$0005 ;0.023529,0.008177

	dc.w	$0005,$0002 ;0.023529,-0.006617

	dc.w	$0005,$0000 ;0.023529,-0.021410

	dc.w	$0005,$FFFC ;0.023529,-0.036204

	dc.w	$0005,$FFF9 ;0.023529,-0.050997

	dc.w	$0005,$FFF5 ;0.023529,-0.065791

	dc.w	$0005,$FFF2 ;0.023529,-0.080584

	dc.w	$0005,$FFEF ;0.023529,-0.095377

	dc.w	$0005,$FFEB ;0.023529,-0.110171

	dc.w	$0005,$FFE8 ;0.023529,-0.124964

	dc.w	$0005,$FFE4 ;0.023529,-0.139758

	dc.w	$0004,$FFE2 ;0.018978,-0.150000

	dc.w	$0000,$FFE2 ;0.004185,-0.150000

	dc.w	$FFFE,$FFE2 ;-0.010609,-0.150000

	dc.w	$FFFB,$FFE2 ;-0.025402,-0.150000

	dc.w	$0010,$FFE5 ;0.070588,-0.136275

	dc.w	$0010,$FFE9 ;0.070588,-0.121481

	dc.w	$0010,$FFEC ;0.070588,-0.106688

	dc.w	$0010,$FFEF ;0.070588,-0.091894

	dc.w	$0010,$FFF3 ;0.071013,-0.077118

	dc.w	$0010,$FFF6 ;0.072208,-0.062373

	dc.w	$0010,$FFFA ;0.073404,-0.047628

	dc.w	$0011,$FFFD ;0.074599,-0.032883

	dc.w	$0011,$0000 ;0.075795,-0.018138

	dc.w	$0011,$0003 ;0.076990,-0.003393

	dc.w	$0011,$0006 ;0.078186,0.011352

	dc.w	$0012,$000A ;0.079382,0.026097

	dc.w	$0014,$000C ;0.089866,0.036402

	dc.w	$0017,$000E ;0.100591,0.046591

	dc.w	$0019,$0011 ;0.111316,0.056780

	dc.w	$001C,$0013 ;0.122041,0.066969

	dc.w	$001E,$0015 ;0.132767,0.077158

	dc.w	$0021,$0017 ;0.145063,0.084792

	dc.w	$0024,$0018 ;0.158995,0.089767

	dc.w	$0027,$0019 ;0.172927,0.094743

	dc.w	$002A,$001A ;0.186858,0.099718

	dc.w	$002E,$001C ;0.200790,0.104694

	dc.w	$0031,$001D ;0.214721,0.109669

	dc.w	$0034,$001D ;0.229152,0.111765

	dc.w	$0038,$001D ;0.243946,0.111765

	dc.w	$003B,$001D ;0.258739,0.111765

	dc.w	$003E,$001D ;0.273533,0.111765

	dc.w	$0042,$001D ;0.288326,0.111765

	dc.w	$0045,$001D ;0.302941,0.111587

	dc.w	$0045,$001A ;0.302941,0.096793

	dc.w	$0045,$0016 ;0.302941,0.082000

	dc.w	$0045,$0013 ;0.302501,0.067647

	dc.w	$0042,$0013 ;0.287707,0.067647

	dc.w	$003E,$0013 ;0.272914,0.067647

	dc.w	$003B,$0013 ;0.258132,0.067519

	dc.w	$0038,$0012 ;0.243586,0.064825

	dc.w	$0034,$0012 ;0.229040,0.062132

	dc.w	$0031,$0011 ;0.214494,0.059438

	dc.w	$002D,$0011 ;0.199947,0.056744

	dc.w	$002A,$0010 ;0.185401,0.054050

	dc.w	$0027,$000E ;0.173075,0.046977

	dc.w	$0025,$000C ;0.162302,0.036838

	dc.w	$0022,$000A ;0.151530,0.026699

	dc.w	$0020,$0007 ;0.140757,0.016560

	dc.w	$001D,$0005 ;0.129984,0.006421

	dc.w	$001D,$0002 ;0.128018,-0.008055

	dc.w	$001D,$FFFF ;0.126546,-0.022775

	dc.w	$001C,$FFFC ;0.125074,-0.037495

	dc.w	$001C,$FFF9 ;0.123602,-0.052215

	dc.w	$001C,$FFF5 ;0.122130,-0.066935

	dc.w	$001B,$FFF2 ;0.120658,-0.081655

	dc.w	$001B,$FFEE ;0.120588,-0.096446

	dc.w	$001B,$FFEB ;0.120588,-0.111239

	dc.w	$001B,$FFE8 ;0.120588,-0.126032

	dc.w	$001B,$FFE4 ;0.120588,-0.140826

	dc.w	$001A,$FFE2 ;0.114969,-0.150000

	dc.w	$0017,$FFE2 ;0.100175,-0.150000

	dc.w	$0013,$FFE2 ;0.085382,-0.150000

