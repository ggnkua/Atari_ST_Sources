	dc.w	$FFE9/2,$FFE9/2 ;-0.250908/2,-0.400350

	dc.w	$FFE9/2,$FFEB/2 ;-0.250908/2,-0.395284

	dc.w	$FFE9/2,$FFEC/2 ;-0.250908/2,-0.390217

	dc.w	$FFE9/2,$FFED/2 ;-0.250908/2,-0.385151

	dc.w	$FFE9/2,$FFEE/2 ;-0.250908/2,-0.380084

	dc.w	$FFE9/2,$FFEF/2 ;-0.250908/2,-0.375018

	dc.w	$FFE9/2,$FFF0/2 ;-0.250908/2,-0.369951

	dc.w	$FFE9/2,$FFF2/2 ;-0.250908/2,-0.364885

	dc.w	$FFE9/2,$FFF3/2 ;-0.250908/2,-0.359818

	dc.w	$FFE9/2,$FFF4/2 ;-0.250908/2,-0.354752

	dc.w	$FFE9/2,$FFF5/2 ;-0.250908/2,-0.349685

	dc.w	$FFE9/2,$FFF6/2 ;-0.250908/2,-0.344619

	dc.w	$FFE9/2,$FFF7/2 ;-0.250908/2,-0.339552

	dc.w	$FFE9/2,$FFF9/2 ;-0.250908/2,-0.334486

	dc.w	$FFE9/2,$FFFA/2 ;-0.250908/2,-0.329419

	dc.w	$FFE9/2,$FFFB/2 ;-0.250908/2,-0.324353

	dc.w	$FFE9/2,$FFFC/2 ;-0.250908/2,-0.319286

	dc.w	$FFE9/2,$FFFD/2 ;-0.250908/2,-0.314220

	dc.w	$FFE9/2,$FFFE/2 ;-0.250908/2,-0.309153

	dc.w	$FFE9/2,$0000/2 ;-0.250908/2,-0.304087

	dc.w	$FFE9/2,$0000/2 ;-0.250908/2,-0.299020

	dc.w	$FFE9/2,$0001/2 ;-0.250908/2,-0.293954

	dc.w	$FFE9/2,$0002/2 ;-0.250908/2,-0.288887

	dc.w	$FFE9/2,$0003/2 ;-0.250908/2,-0.283821

	dc.w	$FFE9/2,$0004/2 ;-0.250908/2,-0.278754

	dc.w	$FFE9/2,$0006/2 ;-0.250908/2,-0.273688

	dc.w	$FFE9/2,$0007/2 ;-0.250908/2,-0.268621

	dc.w	$FFE9/2,$0008/2 ;-0.250908/2,-0.263555

	dc.w	$FFE9/2,$0009/2 ;-0.250908/2,-0.258489

	dc.w	$FFE9/2,$000A/2 ;-0.250908/2,-0.253422

	dc.w	$FFE9/2,$000B/2 ;-0.250907/2,-0.248356

	dc.w	$FFE9/2,$000D/2 ;-0.250907/2,-0.243289

	dc.w	$FFE9/2,$000E/2 ;-0.250907/2,-0.238223

	dc.w	$FFE9/2,$000F/2 ;-0.250907/2,-0.233156

	dc.w	$FFE9/2,$0010/2 ;-0.250907/2,-0.228090

	dc.w	$FFE9/2,$0011/2 ;-0.250907/2,-0.223023

	dc.w	$FFE9/2,$0012/2 ;-0.250907/2,-0.217957

	dc.w	$FFE9/2,$0014/2 ;-0.250907/2,-0.212890

	dc.w	$FFE9/2,$0015/2 ;-0.250907/2,-0.207824

	dc.w	$FFE9/2,$0016/2 ;-0.250907/2,-0.202757

	dc.w	$FFE9/2,$0017/2 ;-0.249228/2,-0.199370

	dc.w	$FFEB/2,$0017/2 ;-0.244162/2,-0.199370

	dc.w	$FFEC/2,$0017/2 ;-0.239095/2,-0.199370

	dc.w	$FFED/2,$0017/2 ;-0.234029/2,-0.199370

	dc.w	$FFEE/2,$0017/2 ;-0.228962/2,-0.199370

	dc.w	$FFEF/2,$0017/2 ;-0.223896/2,-0.199370

	dc.w	$FFF0/2,$0017/2 ;-0.218829/2,-0.199370

	dc.w	$FFF2/2,$0017/2 ;-0.213763/2,-0.199370

	dc.w	$FFF3/2,$0017/2 ;-0.208696/2,-0.199370

	dc.w	$FFF4/2,$0017/2 ;-0.203630/2,-0.199370

	dc.w	$FFF5/2,$0017/2 ;-0.198563/2,-0.199370

	dc.w	$FFF6/2,$0017/2 ;-0.193497/2,-0.199370

	dc.w	$FFF7/2,$0017/2 ;-0.188430/2,-0.199370

	dc.w	$FFF9/2,$0017/2 ;-0.183364/2,-0.199370

	dc.w	$FFFA/2,$0017/2 ;-0.178297/2,-0.199370

	dc.w	$FFFB/2,$0017/2 ;-0.173231/2,-0.199370

	dc.w	$FFFC/2,$0017/2 ;-0.168164/2,-0.199370

	dc.w	$FFFD/2,$0017/2 ;-0.163098/2,-0.199370

	dc.w	$FFFE/2,$0017/2 ;-0.158031/2,-0.199370

	dc.w	$0000/2,$0017/2 ;-0.152965/2,-0.199370

	dc.w	$0000/2,$0017/2 ;-0.147898/2,-0.199370

	dc.w	$0001/2,$0017/2 ;-0.142832/2,-0.199370

	dc.w	$0002/2,$0017/2 ;-0.137765/2,-0.199370

	dc.w	$0003/2,$0017/2 ;-0.132699/2,-0.199370

	dc.w	$0004/2,$0017/2 ;-0.127632/2,-0.199370

	dc.w	$0006/2,$0017/2 ;-0.122566/2,-0.199370

	dc.w	$0007/2,$0017/2 ;-0.117499/2,-0.199370

	dc.w	$0008/2,$0017/2 ;-0.112433/2,-0.199370

	dc.w	$0009/2,$0017/2 ;-0.107367/2,-0.199370

	dc.w	$000A/2,$0017/2 ;-0.102300/2,-0.199370

	dc.w	$000B/2,$0017/2 ;-0.097234/2,-0.199370

	dc.w	$000D/2,$0017/2 ;-0.092167/2,-0.199370

	dc.w	$000E/2,$0017/2 ;-0.087101/2,-0.199370

	dc.w	$000F/2,$0017/2 ;-0.082034/2,-0.199370

	dc.w	$0010/2,$0017/2 ;-0.076968/2,-0.199370

	dc.w	$0011/2,$0017/2 ;-0.071901/2,-0.199370

	dc.w	$0012/2,$0017/2 ;-0.066835/2,-0.199370

	dc.w	$0014/2,$0017/2 ;-0.061768/2,-0.199370

	dc.w	$0015/2,$0017/2 ;-0.056702/2,-0.199370

	dc.w	$0016/2,$0017/2 ;-0.051635/2,-0.199370

	dc.w	$0017/2,$0017/2 ;-0.046569/2,-0.199370

	dc.w	$0017/2,$0015/2 ;-0.046569/2,-0.204436

	dc.w	$0017/2,$0014/2 ;-0.046569/2,-0.209503

	dc.w	$0017/2,$0013/2 ;-0.046569/2,-0.214569

	dc.w	$0017/2,$0012/2 ;-0.046569/2,-0.219636

	dc.w	$0017/2,$0011/2 ;-0.046569/2,-0.224702

	dc.w	$0017/2,$0010/2 ;-0.046569/2,-0.229769

	dc.w	$0017/2,$000E/2 ;-0.046569/2,-0.234835

	dc.w	$0017/2,$000D/2 ;-0.046569/2,-0.239902

	dc.w	$0017/2,$000C/2 ;-0.046569/2,-0.244968

	dc.w	$0017/2,$000B/2 ;-0.046569/2,-0.250035

	dc.w	$0017/2,$000A/2 ;-0.046569/2,-0.255101

	dc.w	$0017/2,$0009/2 ;-0.046569/2,-0.260168

	dc.w	$0017/2,$0007/2 ;-0.046569/2,-0.265234

	dc.w	$0017/2,$0006/2 ;-0.046569/2,-0.270301

	dc.w	$0017/2,$0005/2 ;-0.046569/2,-0.275367

	dc.w	$0017/2,$0004/2 ;-0.046569/2,-0.280434

	dc.w	$0017/2,$0003/2 ;-0.046569/2,-0.285500

	dc.w	$0017/2,$0002/2 ;-0.046569/2,-0.290567

	dc.w	$0017/2,$0000/2 ;-0.046569/2,-0.295633

	dc.w	$0017/2,$0000/2 ;-0.046569/2,-0.300700

	dc.w	$0017/2,$FFFF/2 ;-0.046569/2,-0.305766

	dc.w	$0017/2,$FFFE/2 ;-0.046569/2,-0.310833

	dc.w	$0017/2,$FFFD/2 ;-0.046569/2,-0.315899

	dc.w	$0017/2,$FFFC/2 ;-0.046569/2,-0.320966

	dc.w	$0017/2,$FFFA/2 ;-0.046569/2,-0.326032

	dc.w	$0017/2,$FFF9/2 ;-0.046569/2,-0.331099

	dc.w	$0017/2,$FFF8/2 ;-0.046569/2,-0.336165

	dc.w	$0017/2,$FFF7/2 ;-0.046569/2,-0.341232

	dc.w	$0017/2,$FFF6/2 ;-0.046569,-0.346298

	dc.w	$0017/2,$FFF5/2 ;-0.046569/2,-0.351365

	dc.w	$0017/2,$FFF3/2 ;-0.046569/2,-0.356431

	dc.w	$0017/2,$FFF2/2 ;-0.046569/2,-0.361498

	dc.w	$0017/2,$FFF1/2 ;-0.046569/2,-0.366564

	dc.w	$0017/2,$FFF0/2 ;-0.046569/2,-0.371631

	dc.w	$0017/2,$FFEF/2 ;-0.046569/2,-0.376697

	dc.w	$0017/2,$FFEE/2 ;-0.046569/2,-0.381764

	dc.w	$0017/2,$FFEC/2 ;-0.046569/2,-0.386830

	dc.w	$0017/2,$FFEB/2 ;-0.046569/2,-0.391897

	dc.w	$0017/2,$FFEA/2 ;-0.046569/2,-0.396963

	dc.w	$0017/2,$FFE9/2 ;-0.048248/2,-0.400350

	dc.w	$0015/2,$FFE9/2 ;-0.053314/2,-0.400350

	dc.w	$0014/2,$FFE9/2 ;-0.058381/2,-0.400350

	dc.w	$0013/2,$FFE9/2 ;-0.063447/2,-0.400350

	dc.w	$0012/2,$FFE9/2 ;-0.068514/2,-0.400350

	dc.w	$0011/2,$FFE9/2 ;-0.073580/2,-0.400350

	dc.w	$0010/2,$FFE9/2 ;-0.078647/2,-0.400350

	dc.w	$000E/2,$FFE9/2 ;-0.083713/2,-0.400350

	dc.w	$000D/2,$FFE9/2 ;-0.088780/2,-0.400350

	dc.w	$000C/2,$FFE9/2 ;-0.093846/2,-0.400350

	dc.w	$000B/2,$FFE9/2 ;-0.098913/2,-0.400350

	dc.w	$000A/2,$FFE9/2 ;-0.103979/2,-0.400350

	dc.w	$0009/2,$FFE9/2 ;-0.109046/2,-0.400350

	dc.w	$0007/2,$FFE9/2 ;-0.114112/2,-0.400350

	dc.w	$0006/2,$FFE9/2 ;-0.119179/2,-0.400350

	dc.w	$0005/2,$FFE9/2 ;-0.124245/2,-0.400350

	dc.w	$0004/2,$FFE9/2 ;-0.129312/2,-0.400350

	dc.w	$0003/2,$FFE9/2 ;-0.134378/2,-0.400350

	dc.w	$0002/2,$FFE9/2 ;-0.139445/2,-0.400350

	dc.w	$0000/2,$FFE9/2 ;-0.144511/2,-0.400350

	dc.w	$0000/2,$FFE9/2 ;-0.149578/2,-0.400350

	dc.w	$FFFF/2,$FFE9/2 ;-0.154644/2,-0.400350

	dc.w	$FFFE/2,$FFE9/2 ;-0.159711/2,-0.400350

	dc.w	$FFFD/2,$FFE9/2 ;-0.164777/2,-0.400350

	dc.w	$FFFC/2,$FFE9/2 ;-0.169844/2,-0.400350

	dc.w	$FFFA/2,$FFE9/2 ;-0.174910/2,-0.400350

	dc.w	$FFF9/2,$FFE9/2 ;-0.179977/2,-0.400350

	dc.w	$FFF8/2,$FFE9/2 ;-0.185043/2,-0.400350

	dc.w	$FFF7/2,$FFE9/2 ;-0.190110/2,-0.400350

	dc.w	$FFF6/2,$FFE9/2 ;-0.195176/2,-0.400350

	dc.w	$FFF5/2,$FFE9/2 ;-0.200243/2,-0.400350

	dc.w	$FFF3/2,$FFE9/2 ;-0.205309/2,-0.400350

	dc.w	$FFF2/2,$FFE9/2 ;-0.210376/2,-0.400350

	dc.w	$FFF1/2,$FFE9/2 ;-0.215442/2,-0.400350

	dc.w	$FFF0/2,$FFE9/2 ;-0.220509/2,-0.400350

	dc.w	$FFEF/2,$FFE9/2 ;-0.225575/2,-0.400350

	dc.w	$FFEE/2,$FFE9/2 ;-0.230642/2,-0.400350

	dc.w	$FFEC/2,$FFE9/2 ;-0.235708/2,-0.400350

	dc.w	$FFEB/2,$FFE9/2 ;-0.240775/2,-0.400350

	dc.w	$FFEA/2,$FFE9/2 ;-0.245841/2,-0.400350

