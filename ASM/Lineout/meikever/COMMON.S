	bss

	even

Common.block:
	ds.b	1024*608
