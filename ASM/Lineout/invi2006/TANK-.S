; Vertices
object:	dc.w 12
	dc.w -56,2-11,-36		;  0
	dc.w +56,10-11,-36		;  1
	dc.w +56,10-11,36		;  2
	dc.w -56,2-11,36		;  3
	dc.w -56,32-11,36		;  4
	dc.w +56,32-11,36		;  5
	dc.w +56,32-11,-36		;  6
	dc.w -56,32-11,-36		;  7
	dc.w -12,-10-11,36		;  8
	dc.w -12,-10-11,-36	;  9
	dc.w -12,-10-11,0		; 10
	dc.w -56,2-11,0		; 11

; Face List
polys:	dc.w 7
	dc.w 1+1,5,8,2,5,4,3
	dc.w 2+1,4,6,5,2,1
	dc.w 2+1,4,3,0,9,8	; <- poly with mouse buttons..
	dc.w 2+1,4,9,1,2,8
	dc.w 0+1,4,4,5,6,7
	dc.w 2+1,4,0,3,4,7
	dc.w 1+1,5,1,9,0,7,6

lines:	dc.w	2
	dc.w	0+1,8,9
	dc.w	0+1,10,11
