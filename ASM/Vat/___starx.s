*************************************
* 306 STARS ON THR PLANES USING NEW *
* TECHNIQUE. All as always by ~Vat~ *
* Today date is 1993.07-13/14 21-03 *
*************************************
	opt	x+
Scr	equ	$78000
ScrX	equ	$78002
ScrY	equ	$78004
Lin	equ	$a0
IleGwzd	equ	102-1

	bsr	Rezol
Loop
	bsr	MyStars
	bsr	Vbl
	bra.s	Loop

MyStars:
	moveq	#0,d5
	moveq	#1,d6	;Szift
	moveq	#IleGwzd,d7
	lea	Pkt(pc),a0
	lea	(a0),a2
GetNxt1	move.l	(a0)+,a1 ;Adr
	move.w	(a0)+,d0 ;Where
	move.w	(a0)+,d1 ;Star
	ror.w	d6,d1
	bcc.s	.NotYet
	move.w	d5,(a1,d0.w)
	addq.w	#8,d0
	cmp.w	#160,d0
	blt.s	.Clus
	move.w	d5,d0
.Clus	move.w	d0,4(a2)
.NotYet	move.w	d1,6(a2)
	move.w	d1,(a1,d0.w)
	addq.w	#8,a2
	dbf	d7,GetNxt1

	moveq	#2,d6	;Szift
	moveq	#IleGwzd,d7
	lea	Pkt2(pc),a0
	lea	(a0),a2
GetNxt2	move.l	(a0)+,a1 ;Adr
	move.w	(a0)+,d0 ;Where
	move.w	(a0)+,d1 ;Star
	ror.w	d6,d1
	bcc.s	.NotYet
	move.w	d5,(a1,d0.w)
	addq.w	#8,d0
	cmp.w	#160,d0
	blt.s	.Clus
	move.w	d5,d0
.Clus	move.w	d0,4(a2)
.NotYet	move.w	d1,6(a2)
	move.w	d1,(a1,d0.w)
	addq.w	#8,a2
	dbf	d7,GetNxt2

	moveq	#4,d6	;Szift
	moveq	#IleGwzd,d7
	lea	Pkt3(pc),a0
	lea	(a0),a2
GetNxt3	move.l	(a0)+,a1 ;Adr
	move.w	(a0)+,d0 ;Where
	move.w	(a0)+,d1 ;Star
	ror.w	d6,d1
	bcc.s	.NotYet
	move.w	d5,(a1,d0.w)
	addq.w	#8,d0
	cmp.w	#160,d0
	blt.s	.Clus
	move.w	d5,d0
.Clus	move.w	d0,4(a2)
.NotYet	move.w	d1,6(a2)
	move.w	d1,(a1,d0.w)
	addq.w	#8,a2
	dbf	d7,GetNxt3
rw	rts


Vbl	move.l	#$333,$ffff8240.w
	move.w	#$555,$ffff8244.w
	move.w	#$777,$ffff8248.w
	move.l	$466.w,d0
VSync	cmp.l	$466.w,d0
	beq.s	VSync
*	move.w	#1999,d7
*Plk	dbf	d7,Plk
	move.w	#$01,$ffff8240.w
	cmp.b	#$39,$fffffc02.w
	beq.s	Koniec
	rts
Koniec	move.w	#$555,$ffff8240.w
	clr.l	-(a7)
	trap	#1
Rezol
	dc.w	$a00a
	clr.w	-(a7)
	pea	$78000
	pea	$78000
	move.w	#5,-(a7)
	trap	#14
	lea	12(a7),a7
	clr.l	-(a7)
	move.w	#32,-(a7)
	trap	#1
	addq.w	#6,a7
	bsr	SetNewStars
	rts
SetNewStars
	lea	Pkt(pc),a4
Calc	moveq	#15,d6
	moveq	#IleGwzd,d7
Random	moveq	#0,d4
	moveq	#0,d5
	move.w	#17,-(a7)
	trap	#14
	addq.w	#2,a7
	eor.w	d0,d1
	bset	d0,d4
	tst.w	d4
	bne.s	Upper
	swap	d4
Upper	and.w	d6,d1
	move.w	d4,6(a4)
	addq.w	#8,a4
	dbf	d7,Random
	rts
Pkt
	dc.l	Scr+1*Lin
	dc.w	8
	dc.w	$0002
	dc.l	Scr+1*Lin
	dc.w	72
	dc.w	$4000
	dc.l	Scr+1*Lin
	dc.w	144
	dc.w	$8000
	dc.l	Scr+4*Lin
	dc.w	40
	dc.w	$0010
	dc.l	Scr+4*Lin
	dc.w	64
	dc.w	$0008
	dc.l	Scr+4*Lin
	dc.w	96
	dc.w	$4000
	dc.l	Scr+7*Lin
	dc.w	0
	dc.w	$0800
	dc.l	Scr+7*Lin
	dc.w	24
	dc.w	$0040
	dc.l	Scr+7*Lin
	dc.w	48
	dc.w	$0200
	dc.l	Scr+10*Lin
	dc.w	32
	dc.w	$0400
	dc.l	Scr+10*Lin
	dc.w	48
	dc.w	$0008
	dc.l	Scr+10*Lin
	dc.w	128
	dc.w	$0100
	dc.l	Scr+13*Lin
	dc.w	48
	dc.w	$0080
	dc.l	Scr+13*Lin
	dc.w	96
	dc.w	$0400
	dc.l	Scr+13*Lin
	dc.w	144
	dc.w	$8000
	dc.l	Scr+16*Lin
	dc.w	16
	dc.w	$0400
	dc.l	Scr+16*Lin
	dc.w	80
	dc.w	$0002
	dc.l	Scr+16*Lin
	dc.w	120
	dc.w	$4000
	dc.l	Scr+19*Lin
	dc.w	8
	dc.w	$8000
	dc.l	Scr+19*Lin
	dc.w	72
	dc.w	$0010
	dc.l	Scr+19*Lin
	dc.w	144
	dc.w	$0008
	dc.l	Scr+22*Lin
	dc.w	48
	dc.w	$4000
	dc.l	Scr+22*Lin
	dc.w	96
	dc.w	$0800
	dc.l	Scr+22*Lin
	dc.w	152
	dc.w	$0040
	dc.l	Scr+25*Lin
	dc.w	16
	dc.w	$0200
	dc.l	Scr+25*Lin
	dc.w	32
	dc.w	$0400
	dc.l	Scr+25*Lin
	dc.w	136
	dc.w	$0800
	dc.l	Scr+28*Lin
	dc.w	32
	dc.w	$0100
	dc.l	Scr+28*Lin
	dc.w	72
	dc.w	$0080
	dc.l	Scr+28*Lin
	dc.w	152
	dc.w	$0400
	dc.l	Scr+31*Lin
	dc.w	88
	dc.w	$8000
	dc.l	Scr+31*Lin
	dc.w	112
	dc.w	$0400
	dc.l	Scr+31*Lin
	dc.w	152
	dc.w	$0002
	dc.l	Scr+34*Lin
	dc.w	16
	dc.w	$4000
	dc.l	Scr+34*Lin
	dc.w	88
	dc.w	$8000
	dc.l	Scr+34*Lin
	dc.w	120
	dc.w	$0010
	dc.l	Scr+37*Lin
	dc.w	64
	dc.w	$0008
	dc.l	Scr+37*Lin
	dc.w	96
	dc.w	$4000
	dc.l	Scr+37*Lin
	dc.w	112
	dc.w	$0800
	dc.l	Scr+40*Lin
	dc.w	32
	dc.w	$0040
	dc.l	Scr+40*Lin
	dc.w	48
	dc.w	$0200
	dc.l	Scr+40*Lin
	dc.w	136
	dc.w	$0400
	dc.l	Scr+43*Lin
	dc.w	128
	dc.w	$0800
	dc.l	Scr+43*Lin
	dc.w	112
	dc.w	$0100
	dc.l	Scr+43*Lin
	dc.w	16
	dc.w	$0080
	dc.l	Scr+46*Lin
	dc.w	40
	dc.w	$0400
	dc.l	Scr+46*Lin
	dc.w	64
	dc.w	$8000
	dc.l	Scr+46*Lin
	dc.w	112
	dc.w	$0400
	dc.l	Scr+49*Lin
	dc.w	16
	dc.w	$0002
	dc.l	Scr+49*Lin
	dc.w	80
	dc.w	$4000
	dc.l	Scr+49*Lin
	dc.w	144
	dc.w	$8000
	dc.l	Scr+52*Lin
	dc.w	64
	dc.w	$0010
	dc.l	Scr+52*Lin
	dc.w	88
	dc.w	$0008
	dc.l	Scr+52*Lin
	dc.w	152
	dc.w	$4000
	dc.l	Scr+55*Lin
	dc.w	8
	dc.w	$0800
	dc.l	Scr+55*Lin
	dc.w	112
	dc.w	$0040
	dc.l	Scr+55*Lin
	dc.w	136
	dc.w	$0200
	dc.l	Scr+58*Lin
	dc.w	24
	dc.w	$0400
	dc.l	Scr+58*Lin
	dc.w	88
	dc.w	$0800
	dc.l	Scr+58*Lin
	dc.w	128
	dc.w	$0100
	dc.l	Scr+61*Lin
	dc.w	8
	dc.w	$0080
	dc.l	Scr+61*Lin
	dc.w	72
	dc.w	$0400
	dc.l	Scr+61*Lin
	dc.w	128
	dc.w	$8000
	dc.l	Scr+64*Lin
	dc.w	8
	dc.w	$4000
	dc.l	Scr+64*Lin
	dc.w	48
	dc.w	$0004
	dc.l	Scr+64*Lin
	dc.w	120
	dc.w	$0400
	dc.l	Scr+67*Lin
	dc.w	88
	dc.w	$0040
	dc.l	Scr+67*Lin
	dc.w	104
	dc.w	$4000
	dc.l	Scr+67*Lin
	dc.w	152
	dc.w	$0004
	dc.l	Scr+70*Lin
	dc.w	8
	dc.w	$0040
	dc.l	Scr+70*Lin
	dc.w	56
	dc.w	$4000
	dc.l	Scr+70*Lin
	dc.w	136
	dc.w	$0004
	dc.l	Scr+73*Lin
	dc.w	64
	dc.w	$0040
	dc.l	Scr+73*Lin
	dc.w	88
	dc.w	$0400
	dc.l	Scr+73*Lin
	dc.w	152
	dc.w	$4000
	dc.l	Scr+76*Lin
	dc.w	16
	dc.w	$0004
	dc.l	Scr+76*Lin
	dc.w	48
	dc.w	$0004
	dc.l	Scr+76*Lin
	dc.w	144
	dc.w	$0400
	dc.l	Scr+79*Lin
	dc.w	0
	dc.w	$0400
	dc.l	Scr+79*Lin
	dc.w	80
	dc.w	$0004
	dc.l	Scr+79*Lin
	dc.w	112
	dc.w	$4000
	dc.l	Scr+82*Lin
	dc.w	32
	dc.w	$4000
	dc.l	Scr+82*Lin
	dc.w	56
	dc.w	$0040
	dc.l	Scr+82*Lin
	dc.w	104
	dc.w	$0004
	dc.l	Scr+85*Lin
	dc.w	0
	dc.w	$0040
	dc.l	Scr+85*Lin
	dc.w	64
	dc.w	$4000
	dc.l	Scr+85*Lin
	dc.w	128
	dc.w	$0400
	dc.l	Scr+88*Lin
	dc.w	48
	dc.w	$4000
	dc.l	Scr+88*Lin
	dc.w	88
	dc.w	$0400
	dc.l	Scr+88*Lin
	dc.w	144
	dc.w	$0040
	dc.l	Scr+91*Lin
	dc.w	8
	dc.w	$0004
	dc.l	Scr+91*Lin
	dc.w	80
	dc.w	$4000
	dc.l	Scr+91*Lin
	dc.w	120
	dc.w	$0400
	dc.l	Scr+94*Lin
	dc.w	32
	dc.w	$4000
	dc.l	Scr+94*Lin
	dc.w	40
	dc.w	$0004
	dc.l	Scr+94*Lin
	dc.w	104
	dc.w	$0040
	dc.l	Scr+97*Lin
	dc.w	0
	dc.w	$0004
	dc.l	Scr+97*Lin
	dc.w	40
	dc.w	$0040
	dc.l	Scr+97*Lin
	dc.w	128
	dc.w	$0400
	dc.l	Scr+100*Lin
	dc.w	32
	dc.w	$0004
	dc.l	Scr+100*Lin
	dc.w	136
	dc.w	$4000
	dc.l	Scr+100*Lin
	dc.w	144
	dc.w	$0004
	ds.l	10
Pkt2
	dc.l	ScrX+2*Lin
	dc.w	8
	dc.w	$0002
	dc.l	ScrX+2*Lin
	dc.w	72
	dc.w	$8000
	dc.l	ScrX+2*Lin
	dc.w	144
	dc.w	$2000
	dc.l	ScrX+5*Lin
	dc.w	40
	dc.w	$0080
	dc.l	ScrX+5*Lin
	dc.w	64
	dc.w	$0008
	dc.l	ScrX+5*Lin
	dc.w	96
	dc.w	$2000
	dc.l	ScrX+8*Lin
	dc.w	0
	dc.w	$0800
	dc.l	ScrX+8*Lin
	dc.w	24
	dc.w	$0020
	dc.l	ScrX+8*Lin
	dc.w	48
	dc.w	$0200
	dc.l	ScrX+11*Lin
	dc.w	32
	dc.w	$0800
	dc.l	ScrX+11*Lin
	dc.w	56
	dc.w	$0080
	dc.l	ScrX+11*Lin
	dc.w	128
	dc.w	$0200
	dc.l	ScrX+14*Lin
	dc.w	48
	dc.w	$8000
	dc.l	ScrX+14*Lin
	dc.w	88
	dc.w	$0200
	dc.l	ScrX+14*Lin
	dc.w	144
	dc.w	$0080
	dc.l	ScrX+17*Lin
	dc.w	32
	dc.w	$0020
	dc.l	ScrX+17*Lin
	dc.w	80
	dc.w	$0002
	dc.l	ScrX+17*Lin
	dc.w	128
	dc.w	$2000
	dc.l	ScrX+20*Lin
	dc.w	0
	dc.w	$0800
	dc.l	ScrX+20*Lin
	dc.w	72
	dc.w	$0020
	dc.l	ScrX+20*Lin
	dc.w	144
	dc.w	$0008
	dc.l	ScrX+23*Lin
	dc.w	48
	dc.w	$0020
	dc.l	ScrX+23*Lin
	dc.w	96
	dc.w	$0800
	dc.l	ScrX+23*Lin
	dc.w	152
	dc.w	$2000
	dc.l	ScrX+26*Lin
	dc.w	24
	dc.w	$0020
	dc.l	ScrX+26*Lin
	dc.w	40
	dc.w	$0008
	dc.l	ScrX+26*Lin
	dc.w	136
	dc.w	$0080
	dc.l	ScrX+29*Lin
	dc.w	32
	dc.w	$0200
	dc.l	ScrX+29*Lin
	dc.w	80
	dc.w	$0080
	dc.l	ScrX+29*Lin
	dc.w	152
	dc.w	$0200
	dc.l	ScrX+32*Lin
	dc.w	88
	dc.w	$0008
	dc.l	ScrX+32*Lin
	dc.w	112
	dc.w	$0020
	dc.l	ScrX+32*Lin
	dc.w	152
	dc.w	$0020
	dc.l	ScrX+35*Lin
	dc.w	8
	dc.w	$8000
	dc.l	ScrX+35*Lin
	dc.w	88
	dc.w	$8000
	dc.l	ScrX+35*Lin
	dc.w	120
	dc.w	$2000
	dc.l	ScrX+38*Lin
	dc.w	64
	dc.w	$0008
	dc.l	ScrX+38*Lin
	dc.w	96
	dc.w	$2000
	dc.l	ScrX+38*Lin
	dc.w	112
	dc.w	$0800
	dc.l	ScrX+41*Lin
	dc.w	32
	dc.w	$0020
	dc.l	ScrX+41*Lin
	dc.w	48
	dc.w	$0200
	dc.l	ScrX+41*Lin
	dc.w	136
	dc.w	$0800
	dc.l	ScrX+44*Lin
	dc.w	16
	dc.w	$0800
	dc.l	ScrX+44*Lin
	dc.w	112
	dc.w	$0200
	dc.l	ScrX+44*Lin
	dc.w	128
	dc.w	$0080
	dc.l	ScrX+47*Lin
	dc.w	40
	dc.w	$0200
	dc.l	ScrX+47*Lin
	dc.w	64
	dc.w	$8000
	dc.l	ScrX+47*Lin
	dc.w	112
	dc.w	$0200
	dc.l	ScrX+50*Lin
	dc.w	16
	dc.w	$0002
	dc.l	ScrX+50*Lin
	dc.w	80
	dc.w	$8000
	dc.l	ScrX+50*Lin
	dc.w	144
	dc.w	$2000
	dc.l	ScrX+53*Lin
	dc.w	88
	dc.w	$0020
	dc.l	ScrX+53*Lin
	dc.w	152
	dc.w	$0008
	dc.l	ScrX+53*Lin
	dc.w	64
	dc.w	$2000
	dc.l	ScrX+56*Lin
	dc.w	8
	dc.w	$0800
	dc.l	ScrX+56*Lin
	dc.w	112
	dc.w	$0020
	dc.l	ScrX+56*Lin
	dc.w	136
	dc.w	$2000
	dc.l	ScrX+59*Lin
	dc.w	24
	dc.w	$0008
	dc.l	ScrX+59*Lin
	dc.w	88
	dc.w	$0020
	dc.l	ScrX+59*Lin
	dc.w	128
	dc.w	$8000
	dc.l	ScrX+62*Lin
	dc.w	8
	dc.w	$0008
	dc.l	ScrX+62*Lin
	dc.w	72
	dc.w	$0020
	dc.l	ScrX+62*Lin
	dc.w	128
	dc.w	$0008
	dc.l	ScrX+65*Lin
	dc.w	24
	dc.w	$0200
	dc.l	ScrX+65*Lin
	dc.w	80
	dc.w	$0200
	dc.l	ScrX+65*Lin
	dc.w	144
	dc.w	$0200
	dc.l	ScrX+68*Lin
	dc.w	0
	dc.w	$2000
	dc.l	ScrX+68*Lin
	dc.w	48
	dc.w	$0020
	dc.l	ScrX+68*Lin
	dc.w	64
	dc.w	$0002
	dc.l	ScrX+71*Lin
	dc.w	16
	dc.w	$2000
	dc.l	ScrX+71*Lin
	dc.w	112
	dc.w	$0020
	dc.l	ScrX+71*Lin
	dc.w	128
	dc.w	$0002
	dc.l	ScrX+74*Lin
	dc.w	32
	dc.w	$0002
	dc.l	ScrX+74*Lin
	dc.w	48
	dc.w	$0020
	dc.l	ScrX+74*Lin
	dc.w	96
	dc.w	$0020
	dc.l	ScrX+77*Lin
	dc.w	0
	dc.w	$2000
	dc.l	ScrX+77*Lin
	dc.w	88
	dc.w	$0020
	dc.l	ScrX+77*Lin
	dc.w	112
	dc.w	$0002
	dc.l	ScrX+80*Lin
	dc.w	120
	dc.w	$0002
	dc.l	ScrX+80*Lin
	dc.w	136
	dc.w	$0200
	dc.l	ScrX+80*Lin
	dc.w	152
	dc.w	$0002
	dc.l	ScrX+83*Lin
	dc.w	8
	dc.w	$0020
	dc.l	ScrX+83*Lin
	dc.w	64
	dc.w	$0002
	dc.l	ScrX+83*Lin
	dc.w	144
	dc.w	$0020
	dc.l	ScrX+86*Lin
	dc.w	88
	dc.w	$2000
	dc.l	ScrX+86*Lin
	dc.w	104
	dc.w	$0020
	dc.l	ScrX+86*Lin
	dc.w	128
	dc.w	$0002
	dc.l	ScrX+89*Lin
	dc.w	56
	dc.w	$2000
	dc.l	ScrX+89*Lin
	dc.w	72
	dc.w	$2000
	dc.l	ScrX+89*Lin
	dc.w	128
	dc.w	$0020
	dc.l	ScrX+92*Lin
	dc.w	16
	dc.w	$0002
	dc.l	ScrX+92*Lin
	dc.w	80
	dc.w	$2000
	dc.l	ScrX+92*Lin
	dc.w	112
	dc.w	$0020
	dc.l	ScrX+95*Lin
	dc.w	0
	dc.w	$2000
	dc.l	ScrX+95*Lin
	dc.w	40
	dc.w	$2000
	dc.l	ScrX+95*Lin
	dc.w	80
	dc.w	$0002
	dc.l	ScrX+98*Lin
	dc.w	64
	dc.w	$2000
	dc.l	ScrX+98*Lin
	dc.w	80
	dc.w	$0002
	dc.l	ScrX+98*Lin
	dc.w	128
	dc.w	$0200
	dc.l	ScrX+101*Lin
	dc.w	8
	dc.w	$0002
	dc.l	ScrX+101*Lin
	dc.w	32
	dc.w	$0200
	dc.l	ScrX+101*Lin
	dc.w	128
	dc.w	$0020
	ds.l	10
Pkt3
	dc.l	ScrY+3*Lin
	dc.w	8
	dc.w	$0008
	dc.l	ScrY+3*Lin
	dc.w	72
	dc.w	$8000
	dc.l	ScrY+3*Lin
	dc.w	144
	dc.w	$8000
	dc.l	ScrY+6*Lin
	dc.w	40
	dc.w	$0080
	dc.l	ScrY+6*Lin
	dc.w	64
	dc.w	$0008
	dc.l	ScrY+6*Lin
	dc.w	104
	dc.w	$8000
	dc.l	ScrY+9*Lin
	dc.w	48
	dc.w	$0800
	dc.l	ScrY+9*Lin
	dc.w	0
	dc.w	$0080
	dc.l	ScrY+9*Lin
	dc.w	24
	dc.w	$0800
	dc.l	ScrY+12*Lin
	dc.w	128
	dc.w	$0800
	dc.l	ScrY+12*Lin
	dc.w	32
	dc.w	$0800
	dc.l	ScrY+12*Lin
	dc.w	48
	dc.w	$0800
	dc.l	ScrY+15*Lin
	dc.w	144
	dc.w	$0080
	dc.l	ScrY+15*Lin
	dc.w	96
	dc.w	$0800
	dc.l	ScrY+15*Lin
	dc.w	48
	dc.w	$8000
	dc.l	ScrY+18*Lin
	dc.w	120
	dc.w	$0800
	dc.l	ScrY+18*Lin
	dc.w	80
	dc.w	$0008
	dc.l	ScrY+18*Lin
	dc.w	16
	dc.w	$8000
	dc.l	ScrY+21*Lin
	dc.w	144
	dc.w	$8000
	dc.l	ScrY+21*Lin
	dc.w	72
	dc.w	$0080
	dc.l	ScrY+21*Lin
	dc.w	8
	dc.w	$0008
	dc.l	ScrY+24*Lin
	dc.w	96
	dc.w	$8000
	dc.l	ScrY+24*Lin
	dc.w	48
	dc.w	$0800
	dc.l	ScrY+24*Lin
	dc.w	152
	dc.w	$0080
	dc.l	ScrY+27*Lin
	dc.w	24
	dc.w	$0800
	dc.l	ScrY+27*Lin
	dc.w	136
	dc.w	$0800
	dc.l	ScrY+27*Lin
	dc.w	40
	dc.w	$0800
	dc.l	ScrY+30*Lin
	dc.w	72
	dc.w	$0800
	dc.l	ScrY+30*Lin
	dc.w	152
	dc.w	$0080
	dc.l	ScrY+30*Lin
	dc.w	32
	dc.w	$0800
	dc.l	ScrY+33*Lin
	dc.w	88
	dc.w	$8000
	dc.l	ScrY+33*Lin
	dc.w	120
	dc.w	$0008
	dc.l	ScrY+33*Lin
	dc.w	152
	dc.w	$0008
	dc.l	ScrY+36*Lin
	dc.w	88
	dc.w	$8000
	dc.l	ScrY+36*Lin
	dc.w	16
	dc.w	$8000
	dc.l	ScrY+36*Lin
	dc.w	120
	dc.w	$0080
	dc.l	ScrY+39*Lin
	dc.w	96
	dc.w	$0008
	dc.l	ScrY+39*Lin
	dc.w	64
	dc.w	$8000
	dc.l	ScrY+39*Lin
	dc.w	112
	dc.w	$0800
	dc.l	ScrY+42*Lin
	dc.w	40
	dc.w	$0080
	dc.l	ScrY+42*Lin
	dc.w	136
	dc.w	$0800
	dc.l	ScrY+42*Lin
	dc.w	32
	dc.w	$0800
	dc.l	ScrY+45*Lin
	dc.w	128
	dc.w	$0800
	dc.l	ScrY+45*Lin
	dc.w	112
	dc.w	$0800
	dc.l	ScrY+45*Lin
	dc.w	16
	dc.w	$0080
	dc.l	ScrY+48*Lin
	dc.w	64
	dc.w	$0800
	dc.l	ScrY+48*Lin
	dc.w	120
	dc.w	$8000
	dc.l	ScrY+48*Lin
	dc.w	40
	dc.w	$0800
	dc.l	ScrY+51*Lin
	dc.w	80
	dc.w	$0008
	dc.l	ScrY+51*Lin
	dc.w	144
	dc.w	$8000
	dc.l	ScrY+51*Lin
	dc.w	16
	dc.w	$8000
	dc.l	ScrY+54*Lin
	dc.w	88
	dc.w	$0080
	dc.l	ScrY+54*Lin
	dc.w	152
	dc.w	$0008
	dc.l	ScrY+54*Lin
	dc.w	64
	dc.w	$8000
	dc.l	ScrY+57*Lin
	dc.w	112
	dc.w	$0800
	dc.l	ScrY+57*Lin
	dc.w	8
	dc.w	$0080
	dc.l	ScrY+57*Lin
	dc.w	136
	dc.w	$0080
	dc.l	ScrY+60*Lin
	dc.w	24
	dc.w	$0800
	dc.l	ScrY+60*Lin
	dc.w	128
	dc.w	$0800
	dc.l	ScrY+60*Lin
	dc.w	88
	dc.w	$0800
	dc.l	ScrY+63*Lin
	dc.w	8
	dc.w	$0080
	dc.l	ScrY+63*Lin
	dc.w	128
	dc.w	$0800
	dc.l	ScrY+63*Lin
	dc.w	72
	dc.w	$8000
	dc.l	ScrY+66*Lin
	dc.w	8
	dc.w	$0800
	dc.l	ScrY+66*Lin
	dc.w	48
	dc.w	$0800
	dc.l	ScrY+66*Lin
	dc.w	144
	dc.w	$0800
	dc.l	ScrY+69*Lin
	dc.w	16
	dc.w	$0008
	dc.l	ScrY+69*Lin
	dc.w	40
	dc.w	$8000
	dc.l	ScrY+69*Lin
	dc.w	128
	dc.w	$0080
	dc.l	ScrY+72*Lin
	dc.w	0
	dc.w	$0800
	dc.l	ScrY+72*Lin
	dc.w	32
	dc.w	$0008
	dc.l	ScrY+72*Lin
	dc.w	56
	dc.w	$0080
	dc.l	ScrY+75*Lin
	dc.w	72
	dc.w	$0080
	dc.l	ScrY+75*Lin
	dc.w	88
	dc.w	$8000
	dc.l	ScrY+75*Lin
	dc.w	120
	dc.w	$8000
	dc.l	ScrY+78*Lin
	dc.w	8
	dc.w	$0800
	dc.l	ScrY+78*Lin
	dc.w	40
	dc.w	$0008
	dc.l	ScrY+78*Lin
	dc.w	72
	dc.w	$0080
	dc.l	ScrY+81*Lin
	dc.w	16
	dc.w	$0008
	dc.l	ScrY+81*Lin
	dc.w	56
	dc.w	$8000
	dc.l	ScrY+81*Lin
	dc.w	112
	dc.w	$0008
	dc.l	ScrY+84*Lin
	dc.w	24
	dc.w	$0080
	dc.l	ScrY+84*Lin
	dc.w	72
	dc.w	$8000
	dc.l	ScrY+84*Lin
	dc.w	144
	dc.w	$0800
	dc.l	ScrY+87*Lin
	dc.w	0
	dc.w	$8000
	dc.l	ScrY+87*Lin
	dc.w	32
	dc.w	$8000
	dc.l	ScrY+87*Lin
	dc.w	80
	dc.w	$0008
	dc.l	ScrY+90*Lin
	dc.w	48
	dc.w	$8000
	dc.l	ScrY+90*Lin
	dc.w	64
	dc.w	$0008
	dc.l	ScrY+90*Lin
	dc.w	144
	dc.w	$0080
	dc.l	ScrY+93*Lin
	dc.w	8
	dc.w	$0800
	dc.l	ScrY+93*Lin
	dc.w	56
	dc.w	$0008
	dc.l	ScrY+93*Lin
	dc.w	96
	dc.w	$0800
	dc.l	ScrY+96*Lin
	dc.w	32
	dc.w	$8000
	dc.l	ScrY+96*Lin
	dc.w	64
	dc.w	$0008
	dc.l	ScrY+96*Lin
	dc.w	96
	dc.w	$0080
	dc.l	ScrY+99*Lin
	dc.w	56
	dc.w	$0800
	dc.l	ScrY+99*Lin
	dc.w	64
	dc.w	$0008
	dc.l	ScrY+99*Lin
	dc.w	136
	dc.w	$8000
	dc.l	ScrY+102*Lin
	dc.w	0
	dc.w	$8000
	dc.l	ScrY+102*Lin
	dc.w	16
	dc.w	$0080
	dc.l	ScrY+102*Lin
	dc.w	80
	dc.w	$0800
	ds.l	10
