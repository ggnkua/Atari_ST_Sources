* Generate frequency table
* 614400 / VAL
VAL	EQU	12		
VAL1    EQU	1200
***************************************************************************
* VAL*96  VAL  FRQ_030    FRQ   ITERATION
*                                BY VBL
***************************************************************************
* 1152    12    49170    51200    1004
* 1728    18    33880    34133     670
* 2400    25    24585    24576     502                * BEST
* 2880    30    20770    20480     405
* 3552    37    16940    16605     335
* 4800    50    12292    12288     251

		
* 1200          49170             1004
* 1741          33880              692
* 2400    25    24585    24576     502                * BEST A 0.03660769 % PRES (ENVIRON)
* 2728          20770              424
* 3483          16940              346
* 4800    50    12292    12288     251

* 1200          49170             1004
* 1800          32780              669
* 2400    25    24585    24576     502                * BEST A 0.03660769 % PRES (ENVIRON)
* 3000          19668              402
* 3600          16390              335
* 4800    50    12292    12288     251
					


	*moveq	#VAL,d5
	*mulu	#96,d5
	
	MOVE.L	#VAL1,D5
	LEA	LA,a0
	addq	#4,a0
	moveq	#1,d0
ml1	moveq	#0,d2
	move	d0,d2
	lsl.l	#4,d2
	move.l	d5,d3
	divu	d2,d3
	move	d3,(a0)+
	clr	d3
	divu	d2,d3
	move	d3,(a0)+
	addq	#1,d0
	cmp	#1024,d0
	blt	ml1
	rts

LA	DS.L	1024
FIN	DC.B	'FIN',0
