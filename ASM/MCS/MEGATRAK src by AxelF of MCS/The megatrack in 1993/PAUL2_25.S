	LEA	DATA,A4
	
DEBUT	MOVE.L	(A4)+,A0
	MOVE.L	(A4)+,A1
	MOVE.L	(A4)+,A2
	CMP.L	#-1,A0
	BEQ.S	FIN
	BSR	SAVE
	BRA.S	DEBUT
		
FIN	MOVE.L	#0,-(A7)
	TRAP	#1

DATA	DC.L	FRQ1W,FRQ2W,FILE7
	DC.L	FRQ2W,FRQ3W,FILE8
	DC.L	FRQ3W,VFRQ1W,FILE9
	DC.L	VFRQ1W,VFRQ2W,FILE10
	DC.L	VFRQ2W,VFRQ3W,FILE11
	DC.L	VFRQ3W,D625R625,FILE12
	DC.L	D625R25,D625R625_ADD,FILE13
	DC.L	D625R125,D625R25,FILE14
	DC.L	D625R625,D125R625,FILE15
	DC.L	D125R625,D625R125,FILE16
	DC.L	D625R25_ADD,D625R625_VOL,FILE17
	DC.L	D625R125_ADD,D625R25_ADD,FILE18
	DC.L	D625R625_ADD,D125R625_ADD,FILE19
	DC.L	D125R625_ADD,D625R125_ADD,FILE20
	DC.L	D625R25_VOL,D625R625_VOL_ADD,FILE21
	DC.L	D625R125_VOL,D625R25_VOL,FILE22
	DC.L	D625R625_VOL,D125R625_VOL,FILE23
	DC.L	D125R625_VOL,D625R125_VOL,FILE24
	DC.L	D625R25_VOL_ADD,FINVOL,FILE25
	DC.L	D625R125_VOL_ADD,D625R25_VOL_ADD,FILE26
	DC.L	D625R625_VOL_ADD,D125R625_VOL_ADD,FILE27
	DC.L	D125R625_VOL_ADD,D625R125_VOL_ADD,FILE28
	DC.L	-1,-1,-1
 
FILE7	DC.B	'C:\BOSS\DATA\25.KHZ\FRQ1W',0
	EVEN
FILE8	DC.B	'C:\BOSS\DATA\25.KHZ\FRQ2W',0
	EVEN
FILE9	DC.B	'C:\BOSS\DATA\25.KHZ\FRQ3W',0
	EVEN
FILE10	DC.B	'C:\BOSS\DATA\25.KHZ\VFRQ1W',0
	EVEN
FILE11	DC.B	'C:\BOSS\DATA\25.KHZ\VFRQ2W',0
	EVEN
FILE12	DC.B	'C:\BOSS\DATA\25.KHZ\VFRQ3W',0
	EVEN
FILE13	DC.B	'C:\BOSS\DATA\25.KHZ\D625R25',0
	EVEN
FILE14	DC.B	'C:\BOSS\DATA\25.KHZ\D625R125',0
	EVEN
FILE15	DC.B	'C:\BOSS\DATA\25.KHZ\D625R625',0
	EVEN
FILE16	DC.B	'C:\BOSS\DATA\25.KHZ\D125R625',0
	EVEN
FILE17	DC.B	'C:\BOSS\DATA\25.KHZ\D625R25.A',0
	EVEN
FILE18	DC.B	'C:\BOSS\DATA\25.KHZ\D625R125.A',0
	EVEN
FILE19	DC.B	'C:\BOSS\DATA\25.KHZ\D625R625.A',0
	EVEN
FILE20	DC.B	'C:\BOSS\DATA\25.KHZ\D125R625.A',0
	EVEN
FILE21	DC.B	'C:\BOSS\DATA\25.KHZ\D625R25.V',0
	EVEN
FILE22	DC.B	'C:\BOSS\DATA\25.KHZ\D625R125.V',0
	EVEN
FILE23	DC.B	'C:\BOSS\DATA\25.KHZ\D625R625.V',0
	EVEN
FILE24	DC.B	'C:\BOSS\DATA\25.KHZ\D125R625.V',0
	EVEN
FILE25	DC.B	'C:\BOSS\DATA\25.KHZ\D625R25.VA',0
	EVEN
FILE26	DC.B	'C:\BOSS\DATA\25.KHZ\D625R125.VA',0
	EVEN
FILE27	DC.B	'C:\BOSS\DATA\25.KHZ\D625R625.VA',0
	EVEN
FILE28	DC.B	'C:\BOSS\DATA\25.KHZ\D125R625.VA',0
	EVEN

SAVE 	MOVE.L	A0,A5
	MOVE.L	A1,D0
	SUB.L	A0,D0
	MOVE.L	D0,D5
	MOVE.W	#0,-(A7)
	MOVE.L	A2,-(A7)
	MOVE.W	#$3C,-(A7)
	TRAP	#1
	ADDQ.W	#8,A7
	MOVE.W	D0,D3
	MOVE.L	A5,-(A7)
	MOVE.L	D5,-(A7)
	MOVE.W	D3,-(A7)
	MOVE.W	#$40,-(A7)
	TRAP	#1
	ADD.W	#12,A7
	MOVE.W	D3,-(A7)
	MOVE.W	#$3E,-(A7)
	TRAP	#1	
	ADDQ.W	#4,A7
	RTS



FRQ1W	REPT	$1FC			* MULU	#8
	SUB.W	D0,D1			*    4
	ADDX.W	D2,D3			*    4
	MOVE.B	0(A0,D3.W),(A5)+	*   20
	ENDR				* = 28 CYCLES
	RTS

FRQ2W	
M	SET	0
	REPT	$1FC			* MULU	#10
	SUB.W	D0,D1			*    4
	ADDX.W	D2,D3			*    4
	MOVE.B	0(A0,D3.W),M(A5)	*   24
M	SET	M+2			* = 32 CYCLES
	ENDR
	RTS

FRQ3W	
M	SET	0
	REPT	$1FC			* MULU	#12
	SUB.W	D0,D1			*    4
	ADDX.W	D2,D3			*    4
	MOVE.B	0(A0,D3.W),D4		*   16
	ADD.B	D4,M(A5)		*   16 
M	SET	M+2			* = 40 CYCLES
	ENDR
	RTS

VFRQ1W	REPT	$1FC			* MULU	#
	SUB.W	D0,D1			*    4
	ADDX.W	D2,D3			*    4
	MOVE.B	0(A0,D3.W),D4		*   16
	MOVE.L	D4,A4
	MOVE.B	(A4),(A5)+
	ENDR				* = 44  CYCLES
	RTS

VFRQ2W
M	SET	0
	REPT	$1FC			* MULU	#
	SUB.W	D0,D1			*   4
	ADDX.W	D2,D3			*   4
	MOVE.B	0(A0,D3.W),D4		*  16
	MOVE.L	D4,A4
	MOVE.B	(A4),M(A5)	
M	SET	M+2			*  48  CYCLES
	ENDR
	RTS

VFRQ3W
M	SET	0
	REPT	$1FC			* MULU	#
	SUB.W	D0,D1			*   4
	ADDX.W	D2,D3			*   4
	MOVE.B	0(A0,D3.W),D4		*   16
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,M(A5)		*   16
M	SET	M+2			* =    CYCLES
	ENDR
	RTS

********************* DRUM  ***********************************************
D625R625	
M	SET	0
N	SET	0
	REPT	$1FC
	MOVE.B	M(A0),N(A5)		* 20 CYCLES
M	SET	M+1
N	SET	N+2
	ENDR
	RTS

D125R625	
M	SET	0
N	SET	0
	REPT	$1FC		
	MOVE.B	M(A0),N(A5)		* 12 CYCLES
M	SET	M+2
N	SET	N+2
	ENDR
	RTS

D625R125	
M	SET	0
N	SET	0
	REPT	$1FC/2			
	MOVE.B	M(A0),N(A5)		* 12 CYCLES
	MOVE.B	M(A0),N+2(A5)
M	SET	M+1
N	SET	N+4
	ENDR
	RTS

D625R25	
M	SET	0
N	SET	0
	REPT	$1FC/4			
	MOVE.B	M(A0),N(A5)		* 12 CYCLES
	MOVE.B	M(A0),N+2(A5)
	MOVE.B	M(A0),N+4(A5)
	MOVE.B	M(A0),N+6(A5)
M	SET	M+1
N	SET	N+8
	ENDR
	RTS

******************** DRUM + ADD  ***********************************************
D625R625_ADD
M	SET	0
N	SET	0
	REPT	$1FC
	MOVE.B	M(A0),D4		*    8
	ADD.B	D4,N(A5)		* +  8
M	SET	M+1			* = 16 CYCLES
N	SET	N+2
	ENDR
	RTS

D125R625_ADD
M	SET	0
N	SET	0
	REPT	$1FC
	MOVE.B	M(A0),D4		*    8
	ADD.B	D4,N(A5)		*    8
M	SET	M+2			* = 16 CYCLES
N	SET	N+2
	ENDR
	RTS

D625R125_ADD
M	SET	0
N	SET	0
	REPT	$1FC/2			
	MOVE.B	M(A0),D4		*    8
	ADD.B	D4,N(A5)		*    8
	MOVE.B	M(A0),D4		*    8
	ADD.B	D4,N+2(A5)		* = 16 CYCLES
M	SET	M+1
N	SET	N+4
	ENDR
	RTS

D625R25_ADD
M	SET	0
N	SET	0
	REPT	$1FC/4			
	MOVE.B	M(A0),D4
	ADD.B	D4,N(A5)
	MOVE.B	M(A0),D4
	ADD.B	D4,N+2(A5)
	MOVE.B	M(A0),D4
	ADD.B	D4,N+4(A5)
	MOVE.B	M(A0),D4
	ADD.B	D4,N+6(A5)
M	SET	M+1
N	SET	N+8
	ENDR
	RTS

******************** DRUM + VOL  ***********************************************
D625R625_VOL
M	SET	0
N	SET	0
	REPT	$1FC
	MOVE.B	M(A0),D4		*    8
	MOVE.L	D4,A4
	MOVE.B  (A4),N(A5)	
M	SET	M+1			* = 20 CYCLES
N	SET	N+2
	ENDR
	RTS

D125R625_VOL
M	SET	0
N	SET	0
	REPT	$1FC		
	MOVE.B	M(A0),D4		*    8
	MOVE.L	D4,A4
	MOVE.B  (A4),N(A5)	
M	SET	M+2			* = 20 CYCLES
N	SET	N+2
	ENDR
	RTS

D625R125_VOL
M	SET	0
N	SET	0
	REPT	$1FC/2	
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),N(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),N+2(A5)
M	SET	M+1
N	SET	N+4
	ENDR
	RTS

D625R25_VOL
M	SET	0
N	SET	0
	REPT	$1FC/4	
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),N(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),N+2(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),N+4(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),N+6(A5)
M	SET	M+1
N	SET	N+8
	ENDR
	RTS
******************** DRUM + VOL + ADD  ***********************************************
D625R625_VOL_ADD
M	SET	0
N	SET	0
	REPT	$1FC
	MOVE.B	M(A0),D4		*   8
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N(A5)
M	SET	M+1	
N	SET	N+2
	ENDR
	RTS

D125R625_VOL_ADD
M	SET	0
N	SET	0
	REPT	$1FC		
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N(A5)
M	SET	M+2
N	SET	N+2
	ENDR
	RTS

D625R125_VOL_ADD
M	SET	0
N	SET	0
	REPT	$1FC/2			
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N+2(A5)
M	SET	M+1
N	SET	N+4
	ENDR
	RTS

D625R25_VOL_ADD
M	SET	0
N	SET	0
	REPT	$1FC/4	
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N+2(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N+4(A5)
	MOVE.B	M(A0),D4
	MOVE.L	D4,A4
	MOVE.B	(A4),D4
	ADD.B	D4,N+6(A5)
M	SET	M+1
N	SET	N+8
	ENDR
	RTS
FINVOL
****************************************************************************

*	FREQUENCE A 6.25	DRUM
*ROUTINE REELE		DC.L	D625R625,D125R625,D25R625,D50R625
*ROUTINE UTIL		DC.L	D625R625,D125R625,D25R625,D50R625
*LONGUEUR ROUT		DC.L	  127  ,  127  , 127  ,  127
*MULU			DC.L	   6   ,   6   ,  6   ,   6
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 12.5	DRUM
*ROUTINE REELE		DC.L	D625R125,D125R125,D25R125,D50R125
*ROUTINE UTIL		DC.L	D625R125,D625R625,D125R625,D25R625
*LONGUEUR ROUT		DC.L	  253  ,  253  , 253  ,  253
*MULU			DC.L	   6   ,   6   ,  6   ,   6
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 25		DRUM
*ROUTINE REELE		DC.L	D625R25,D125R25,D25R25,D50R25
*ROUTINE UTIL		DC.L	D625R25,D625R125,D625R625,D125R625
*LONGUEUR ROUT		DC.L	  506  ,  506  , 506  ,  506
*MULU			DC.L	   6   ,   6   ,  6   ,   6
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 50		DRUM
*ROUTINE REELE		DC.L	D625R50,D125R50,D25R50,D50R50
*ROUTINE UTIL		DC.L	D625R50,D125R50,D25R50,D625R625
*LONGUEUR ROUT		DC.L	  1012 ,  1012 , 1012 , 1012
*MULU			DC.L	   6   ,   6   ,  6   ,   6
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012




***********************************************************************




*	FREQUENCE A 6.25	DRUM+ADD
*ROUTINE REELE		DC.L	D625R625,D125R625,D25R625,D50R625
*ROUTINE UTIL		DC.L	D625R625_ADD,D125R625_ADD,D25R625_ADD,D50R625_ADD
*LONGUEUR ROUT		DC.L	      127   ,     127    ,     127   ,    127
*MULU			DC.L	       8    ,      8     ,      8     ,    8
*OCTETS PAR VBL		DC.L	      126   ,     253    ,     506   ,   1012

*	FREQUENCE A 12.5	DRUM+ADD
*ROUTINE REELE		DC.L	D625R125,D125R125,D25R125,D50R125
*ROUTINE UTIL		DC.L	D625R125_ADD,D625R625_ADD,D125R625_ADD,D25R625_ADD
*LONGUEUR ROUT		DC.L	  253  ,  253  , 253  ,  253
*MULU			DC.L	       8    ,      8     ,      8     ,    8
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 25		DRUM+ADD
*ROUTINE REELE		DC.L	D625R25,D125R25,D25R25,D50R25
*ROUTINE UTIL		DC.L	D625R25_ADD,D625R125_ADD,D625R625_ADD,D125R625_ADD
*LONGUEUR ROUT		DC.L	  506  ,  506  , 506  ,  506
*MULU			DC.L	       8    ,      8     ,      8     ,    8
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 50		DRUM+ADD
*ROUTINE REELE		DC.L	D625R50,D125R50,D25R50,D50R50
*ROUTINE UTIL		DC.L	D625R50_ADD,D125R50_ADD,D25R50_ADD,D625R625_ADD
*LONGUEUR ROUT		DC.L	  1012 ,  1012 , 1012 , 1012
*MULU			DC.L	   8   ,   8   ,  8   ,   8
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012



***********************************************************************



*	FREQUENCE A 6.25	DRUM+VOL
*ROUTINE REELE		DC.L	D625R625,D125R625,D25R625,D50R625
*ROUTINE UTIL		DC.L	D625R625_VOL,D125R625_VOL,D25R625_VOL,D50R625_VOL
*LONGUEUR ROUT		DC.L	     127    ,     127    ,    127    ,     127
*MULU			DC.L	      10     ,     10     ,    10     ,     10
*OCTETS PAR VBL		DC.L	     126    ,     253    ,    506    ,    1012

*	FREQUENCE A 12.5	DRUM+VOL
*ROUTINE REELE		DC.L	D625R125,D125R125,D25R125,D50R125
*ROUTINE UTIL		DC.L	D625R125_VOL,D625R625_VOL,D125R625_VOL,D25R625_VOL
*LONGUEUR ROUT		DC.L	  253  ,  253  , 253  ,  253
*MULU			DC.L	      10     ,     10     ,    10     ,     10
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 25		DRUM+VOL
*ROUTINE REELE		DC.L	D625R25,D125R25,D25R25,D50R25
*ROUTINE UTIL		DC.L	D625R25_VOL,D625R125_VOL,D625R625_VOL,D125R625_VOL
*LONGUEUR ROUT		DC.L	  506  ,  506  , 506  ,  506
*MULU			DC.L	      10     ,     10     ,    10     ,     10
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 50		DRUM+VOL
*ROUTINE REELE		DC.L	D625R50,D125R50,D25R50,D50R50
*ROUTINE UTIL		DC.L	D625R50_VOL,D125R50_VOL,D25R50_VOL,D625R625_VOL
*LONGUEUR ROUT		DC.L	  1012 ,  1012 , 1012 , 1012
*MULU			DC.L	      10     ,     10     ,    10     ,     10
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012



***********************************************************************




*	FREQUENCE A 6.25	DRUM+VOL+ADD
*ROUTINE REELE		DC.L	D625R625,D125R625,D25R625,D50R625
*ROUTINE UTIL		DC.L	D625R625_VOL_ADD,D125R625_VOL_ADD,D25R625_VOL_ADD,D50R625_VOL_ADD
*LONGUEUR ROUT		DC.L	  127  ,  127  , 127  ,  127
*MULU			DC.L	       12       ,      12        ,     12        ,        12
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 12.5	DRUM+VOL+ADD
*ROUTINE REELE		DC.L	D625R125,D125R125,D25R125,D50R125
*ROUTINE UTIL		DC.L	D625R125_VOL_ADD,D625R625_VOL_ADD,D125R625_VOL_ADD,D25R625_VOL_ADD
*LONGUEUR ROUT		DC.L	  253  ,  253  , 253  ,  253
*MULU			DC.L	       12       ,      12        ,     12        ,        12
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 25		DRUM+VOL+ADD
*ROUTINE REELE		DC.L	D625R25,D125R25,D25R25,D50R25
*ROUTINE UTIL		DC.L	D625R25_VOL_ADD,D625R125_VOL_ADD,D625R625_VOL_ADD,D125R625_VOL_ADD
*LONGUEUR ROUT		DC.L	  506  ,  506  , 506  ,  506
*MULU			DC.L	       12       ,      12        ,     12        ,        12
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

*	FREQUENCE A 50		DRUM+VOL+ADD
*ROUTINE REELE		DC.L	D625R50,D125R50,D25R50,D50R50
*ROUTINE UTIL		DC.L	D625R50_VOL_ADD,D125R50_VOL_ADD,D25R50_VOL_ADD,D625R625_VOL_ADD
*LONGUEUR ROUT		DC.L	  1012 ,  1012 , 1012 , 1012
*MULU			DC.L	       12       ,      12        ,     12        ,        12
*OCTETS PAR VBL		DC.L	  126  ,  253  , 506  , 1012

***********************************************************************
