
	PEA	0.W
	MOVE.W	#$20,-(A7)
	TRAP	#1
	
	MOVEQ	#0,D0
	JSR	ZIK			* INIT
	MOVE.L	#VBL,$110
WAIT	CMP.B	#$39,$FFFFFC02.W
	BNE.S	WAIT
	MOVE.L	#0,$110
	JSR	 ZIK+12			* END
	CLR.L	-(A7)
	TRAP	#1
	
VBL	MOVE.W	#$700,$FF8240
	JSR	ZIK+8			* SYNC_DAC
	JSR	ZIK+4			* PLAYER
	MOVE.W	#$777,$FF8240
	RTE
	
ZIK	INCBIN	WORM.MCS