		RSRESET
S_ENTETE	RS.L	2
S_NBVOICE	RS.W	1
S_NBMUS		RS.W	1
S_NBSEQ		RS.W	1
S_NBPATT	RS.W	1
S_NBTRK		RS.W	1
S_NBSPL		RS.W	1
S_VIDE		RS.W	1
S_RESERVED	RS.L	1
S_DEBMUS	RS.L	1
S_DEBSEQ	RS.L	1
S_DEBSPLDATA	RS.L	1
S_DEBPATT	RS.L	1
S_DEBTABTRACK	RS.L	1
S_DEBSPL	RS.L	1
S_LENSPL	RS.L	1
S_LEN_DEPACKED_TRACKS	RS.L	1

	LEA	GOOD,A2
	LEA 	BAD,A3
	MOVE.L	S_DEBTABTRACK(A2),A0
	MOVE.L	S_DEBTABTRACK(A3),A1
	ADD.L	A2,A0
	ADD.L	A3,A1
	
	MOVE.L	#8000,D0
AA	MOVE.B	(A0)+,D1
	MOVE.B	(A1)+,D2
	CMP.B	D1,D2
	BNE.S	ERROR
	DBF	D0,AA
	RTS
	
ERROR	NOP
	NOP
	NOP


GOOD	INCBIN	D:\SAT2.MGT
BAD	INCBIN	D:\SAT1.MGT
