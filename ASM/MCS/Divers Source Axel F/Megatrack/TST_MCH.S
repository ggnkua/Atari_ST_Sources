TST_MCH
	MOVE.L	$5A0,A0
	CMP.L	#0,A0
	BEQ	NOT_MSTE
LOOP_COOKIE
	CMP.L	#'_MCH',(A0)
	BEQ	OK_MCH
	CMP.L	#0,(A0)
	BEQ	NOT_MSTE
	ADDQ.L	#8,A0
	BRA	LOOP_COOKIE
OK_MCH	
	CMP.L	#$00010010,4(A0)
	BNE	NOT_MSTE

	MOVE.B	#3,$FFFF8E21.W
NOT_MSTE
	RTS