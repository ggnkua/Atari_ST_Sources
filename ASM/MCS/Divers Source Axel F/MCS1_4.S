	OPT	D-
SETBLOCK
	MOVE.L	A7,A5
	MOVE.L	#PILE,A7
	MOVE.L	4(A5),A5
	MOVE.L	$C(A5),D0
	ADD.L	$14(A5),D0
	ADD.L	$1C(A5),D0
	ADD.L	#$100,D0
	MOVE.L	D0,PRG_SIZE
	MOVE.L	D0,-(A7)
	MOVE.L	A5,-(A7)
	MOVE.W	#0,-(A7)
	MOVE.W	#$4A,-(A7)
	TRAP	#1
	ADD.L	#12,A7
	
	MOVE.W	#1,-(A7)
	PEA	-1
	PEA	-1
	MOVE.W	#5,-(A7)
	TRAP	#14
	ADD.W	#12,A7

DEBUT	MOVE.W	#0,ROUGH
	MOVE.W	#89,-(A7)
	TRAP	#14
	ADDQ.W	#2,A7
	CMP.W	#0,D0
	BEQ	MONOCHROM
	CMP.W	#1,D0
	BEQ	PAL_640
	CMP.W	#2,D0
	BEQ	VGA_640
	CMP.W	#3,D0
	BEQ	NTSC_640

PAL_640	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_PAL_640
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	PAL_320
	CMP.L	#$004B0000,D0
	BEQ	PAL_1280
	CMP.B	#'2',D0
	BEQ	NTSC_640
	CMP.B	#'3',D0
	BEQ	VGA_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_PAL_640,A1
ENCOR	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR
	BRA	GO
***************************************************************************
PAL_320	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_PAL_320
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	PAL_1280
	CMP.L	#$004B0000,D0
	BEQ	PAL_640
	CMP.B	#'2',D0
	BEQ	NTSC_640
	CMP.B	#'3',D0
	BEQ	VGA_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_PAL_320,A1
ENCOR1	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR1
	BRA	GO
***************************************************************************
PAL_1280	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_PAL_1280
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	PAL_640
	CMP.L	#$004B0000,D0
	BEQ	PAL_320
	CMP.B	#'2',D0
	BEQ	NTSC_640
	CMP.B	#'3',D0
	BEQ	VGA_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_PAL_1280,A1
ENCOR2	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR2
	BRA	GO
***************************************************************************
NTSC_640
	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_NTSC_640
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	NTSC_320
	CMP.L	#$004B0000,D0
	BEQ	NTSC_1280
	CMP.B	#'1',D0
	BEQ	PAL_640
	CMP.B	#'3',D0
	BEQ	VGA_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_NTSC_640,A1
ENCOR3	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR3
	BRA	GO
***************************************************************************
NTSC_320
	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_NTSC_320
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	NTSC_1280
	CMP.L	#$004B0000,D0
	BEQ	NTSC_640
	CMP.B	#'1',D0
	BEQ	PAL_640
	CMP.B	#'3',D0
	BEQ	VGA_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_NTSC_320,A1
ENCOR4	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR4
	BRA	GO
***************************************************************************
NTSC_1280
	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_NTSC_1280
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	NTSC_640
	CMP.L	#$004B0000,D0
	BEQ	NTSC_320
	CMP.B	#'1',D0
	BEQ	PAL_640
	CMP.B	#'3',D0
	BEQ	VGA_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_NTSC_1280,A1
ENCOR5	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR5
	BRA	GO
***************************************************************************
VGA_640	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_VGA_640
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	VGA_320
	CMP.L	#$004B0000,D0
	BEQ	VGA_320
	CMP.B	#'1',D0
	BEQ	PAL_640
	CMP.B	#'2',D0
	BEQ	NTSC_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_VGA_640,A1
ENCOR6	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR6
	BRA	GO
***************************************************************************
VGA_320
	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_VGA_320
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	CMP.L	#$004D0000,D0
	BEQ	VGA_640
	CMP.L	#$004B0000,D0
	BEQ	VGA_640
	CMP.B	#'1',D0
	BEQ	PAL_640
	CMP.B	#'2',D0
	BEQ	NTSC_640
	CMP.B	#'4',D0
	BEQ	MONOCHROM
	
	LEA	TAB_ASC,A0
	LEA	TAB_VGA_320,A1
ENCOR7	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCOR7
	BRA	GO
***************************************************************************
MONOCHROM
	PEA	TXT_INTRO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	TXT_MONO
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	PEA	INDIC
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

	*CMP.L	#$004D0000,D0
	*BEQ	VGA_640
	*CMP.L	#$004B0000,D0
	*BEQ	VGA_640
	CMP.B	#'1',D0
	BEQ	PAL_640
	CMP.B	#'2',D0
	BEQ	NTSC_640
	CMP.B	#'3',D0
	BEQ	VGA_640
	
	LEA	TAB_ASC,A0
	LEA	TAB_MONO,A1
ENCORM	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A5
	CMP.B	#-1,D1
	BEQ	EXIT
	CMP.L	#-1,A5
	BEQ	EXIT
	CMP.B	D1,D0
	BNE.S	ENCORM
	BRA	GO
***************************************************************************
EXIT	MOVE.W	#0,-(A7)
	MOVE.L	PRG_SIZE,-(A7)
	MOVE.W	#$31,-(A7)
	TRAP	#1		

***************************************************************************
CONVERT1
	LEA	RX+14,A2
	BSR	CONVERT2
	LEA	RX+53,A2
	MOVE.W	D1,D0
	BSR	CONVERT2
	
	LEA	RX+14,A2
	LEA	IY+14,A3
	MOVE.L	(A2),(A3)
	
	LEA	REWRIT+23,A3
	MOVE.L	(A2),(A3)
	
	LEA	RX+53,A2
	LEA	IY+53,A3
	MOVE.L	(A2),(A3)
	
	LEA	REWRIT+30,A3
	MOVE.L	(A2),(A3)
	
	LEA	REWRIT+23,A2
	LEA	RE2+23,A3
	BSR	RECOP1
	LEA	REWRIT+40,A2
	MOVE.L	D2,D0
	BSR	CONVERT3
	LEA	REWRIT+40,A2
	LEA	RE2+40,A3
	BSR	RECOP1
	RTS
	
RECOP1	MOVE.L	(A2)+,(A3)+
	MOVE.L	(A2)+,(A3)+
	MOVE.L	(A2)+,(A3)+
	RTS
	
CONVERT2	
	DIVU	#1000,D0
	ADD.B	#'0',D0
	CMP.B	#'0',D0
	BNE.S	BON
	MOVE.B	#' ',D0
BON	MOVE.B	D0,(A2)+
	MOVE.W	#0,D0
	SWAP	D0
	DIVU	#100,D0
	ADD.B	#'0',D0
	MOVE.B	D0,(A2)+
	MOVE.W	#0,D0
	SWAP	D0
	DIVU	#10,D0
	ADD.B	#'0',D0
	MOVE.B	D0,(A2)+
	MOVE.W	#0,D0
	SWAP	D0
	ADD.B	#'0',D0
	MOVE.B	D0,(A2)+
	RTS
CONVERT3
	DIVU	#10000,D2
	MOVE.L	D2,D0
	AND.L	#$FFFF,D2
	DIVU	#100,D2
	ADD.B	#'0',D2
	MOVE.B	D2,(A2)
	MOVE.W	#0,D2
	SWAP	D2
	DIVU	#10,D2
	ADD.B	#'0',D2
	MOVE.B	D2,2(A2)
	SWAP	D2
	ADD.B	#'0',D2
	MOVE.B	D2,3(A2)

	MOVE.W	#0,D0
	SWAP	D0	
	DIVU	#1000,D0
	ADD.B	#'0',D0
	MOVE.B	D0,4(A2)
	MOVE.W	#0,D0
	SWAP	D0
	DIVU	#100,D0
	ADD.B	#'0',D0
	MOVE.B	D0,6(A2)
	MOVE.W	#0,D0
	SWAP	D0
	DIVU	#10,D0
	ADD.B	#'0',D0
	MOVE.B	D0,7(A2)
	MOVE.W	#0,D0
	SWAP	D0
	ADD.B	#'0',D0
	MOVE.B	D0,8(A2)
	
	MOVEQ	#4,D0
BCL1	CMP.B	#'0',(A2)
	BNE.S	C1
	MOVE.B	#' ',(A2)+
C2	DBF	D0,BCL1
	BRA	OUT
C1	CMP.B	#' ',(A2)+
	BEQ.S	C2
OUT	RTS
***************************************************************************
TAB_ASC	DC.B	'a','z','e','r','t','y','u','i','o','p'
	DC.B	'q','s','d','f','g','h'
	DC.B	'j','k','w','x',' ',-1
	EVEN
TAB_GOTO
	DC.L	ADDX8,ADDX16,ADDX32,ADDX0,ADDY8,ADDY16,ADDY32,ADDY0,ORIGINAL,ORIGINAL
	DC.L	SUBX8,SUBX16,SUBX32,SUBX0,SUBY8,SUBY16,SUBY32,SUBY0
	DC.L	DEBUT,NEW_ROUGH,NEW
	DC.L	-1
***************************************************************************
GO:	MOVE.L	A5,SAFE
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVEQ	#0,D2
	MOVE.W	12(A5),NEWX
	MOVE.W	14(A5),NEWY
	MOVE.L	(A5),NEWLEN
	MOVE.W	4(A5),D0
	AND.W	#7,D0
	MOVE.W	D0,PLAN
	MOVE.W	12(A5),D0
	MOVE.W	14(A5),D1
	MOVE.L	(A5),D2
	BSR	CONVERT1

	PEA	RULE
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
ICI	PEA	RE2
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	
	LEA	TAB_ASC,A0
	LEA	TAB_GOTO,A1
ENCOR8	MOVE.B	(A0)+,D1
	MOVE.L	(A1)+,A4
	CMP.B	#-1,D1
	BEQ	ORIGINAL
	CMP.L	#-1,A4
	BEQ	ORIGINAL
	CMP.B	D1,D0
	BNE.S	ENCOR8
	JSR	(A4)
	BRA	ICI
	
ADDX8	ADD.W	#8,NEWX
	BRA	MAJ
ADDX16	ADD.W	#16,NEWX
	BRA	MAJ
ADDX32	ADD.W	#32,NEWX
	BRA	MAJ
ADDX0	MOVE.W	12(A5),D0
	ADD.W	D0,NEWX
	BRA	MAJ
SUBX8	SUB.W	#8,NEWX
	BRA	MAJ
SUBX16	SUB.W	#16,NEWX
	BRA	MAJ
SUBX32	SUB.W	#32,NEWX
	BRA	MAJ
SUBX0	MOVE.W	12(A5),D0
	SUB.W	D0,NEWX
	BRA	MAJ
ADDY8	ADD.W	#8,NEWY
	BRA	MAJ
ADDY16	ADD.W	#16,NEWY
	BRA	MAJ
ADDY32	ADD.W	#32,NEWY
	BRA	MAJ
ADDY0	MOVE.W	14(A5),D0
	ADD.W	D0,NEWY
	BRA	MAJ
SUBY8	SUB.W	#8,NEWY
	BRA	MAJ
SUBY16	SUB.W	#16,NEWY
	BRA	MAJ
SUBY32	SUB.W	#32,NEWY
	BRA	MAJ
SUBY0	MOVE.W	14(A5),D0
	SUB.W	D0,NEWY

MAJ	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVE.W	NEWY,D0
	CMP.W	14(A5),D0
	BGT.S	OKY
	MOVE.W	14(A5),NEWY
OKY	MOVE.W	NEWX,D0
	CMP.W	12(A5),D0
	BGT.S	OKX
	MOVE.W	12(A5),NEWX
OKX	MOVE.W	NEWY,D0
	MULU.W	NEWX,D0
	MOVE.W	PLAN,D1
	CMP.W	#0,D1
	BNE.S	COL4
	LSR.L	#3,D0
	BRA	MAJ2
COL4	CMP.B	#1,D1
	BNE.S	COL16
	LSR.L	#2,D0
	BRA	MAJ2
COL16	CMP.B	#2,D1
	BNE.S	COL256
	LSR.L	#1,D0
	BRA	MAJ2
COL256	CMP.W	#3,D1
	BNE.S	TRUECOL
	BRA	MAJ2
TRUECOL MULU.L	#2,D0
MAJ2	MOVE.L	D0,NEWLEN
	
	MOVE.L	D0,D2
	LEA	RE2+40,A2
	BSR	CONVERT3
	MOVEQ	#0,D0
	MOVE.W	NEWX,D0
	LEA	RE2+23,A2
	BSR	CONVERT2
	MOVE.W	NEWY,D0
	LEA	RE2+30,A2
	BSR	CONVERT2
	RTS
***************************************************************************
NEW_ROUGH
	MOVE.W	#1,ROUGH
***************************************************************************
NEW:	MOVE.L	SAFE,A5
	LEA	NEWSCREEN,A4
	
	MOVE.W	NEWY,D0
	CMP.W	14(A5),D0
	BNE.S	ZY
	MOVE.W	NEWX,D0
	CMP.W	12(A5),D0
	BNE.S	ZY
	BRA	ORIGINAL
	
ZY	MOVE.L	NEWLEN,(A4)
	MOVE.W	4(A5),4(A4)
	MOVEQ	#0,D0
	MOVE.W	NEWX,D0
	MOVE.W	D0,6(A4)
	SUBQ.W	#1,6(A4)
	MOVE.W	D0,12(A4)
	CMP.W	#0,PLAN
	BNE.S	COL_4
	LSR.W	#3,D0
COL_4	CMP.W	#1,PLAN
	BNE.S	COL_16
	LSR.W	#2,D0
COL_16	CMP.W	#2,PLAN
	BNE.S	COL_256
	LSR.W	#1,D0
COL_256	CMP.W	#3,PLAN
	BNE.S	TRU_COL
	NOP
TRU_COL	CMP.W	#4,PLAN
	BNE.S	AZ
	ADD.W	D0,D0
AZ	MOVE.W	D0,10(A4)
	MOVE.W	D0,OFFSET
	MOVEQ	#0,D1
	MOVE.W	NEWY,D1
	BTST	#0,33(A5)
	BNE.S	M8
	LSL.W	#4,D0
	LSR.W	#4,D1
	SUBQ.W	#1,D1
	BRA.S	ZE
M8	LSL.W	#3,D0
	LSR.W	#3,D1
	SUBQ.W	#1,D1
ZE	MOVE.W	D0,16(A4)
	MOVE.W	D1,20(A4)
	MOVE.W	NEWY,8(A4)
	SUBQ.W	#1,8(A4)
	MOVE.W	NEWY,14(A4)
	MOVEQ	#0,D0
	MOVE.W	NEWX,D0
	LSR.W	#3,D0
	SUBQ.W	#1,D0
	MOVE.W	D0,18(A4)
	MOVE.L	22(A5),22(A4)
	MOVE.L	26(A5),26(A4)
	MOVE.L	30(A5),30(A4)
	MOVE.L	34(A5),34(A4)
	MOVE.L	38(A5),38(A4)
	MOVE.L	42(A5),42(A4)
	MOVE.L	46(A5),46(A4)
	MOVEQ	#0,D0
	MOVE.W	OFFSET,D0
	LSR.W	#1,D0
	SUB.W	46(A4),D0
	MOVE.W	D0,OFFSET
	MOVE.W	12(A5),OFFSETX
	MOVE.W	14(A5),OFFSETY
	*SUB.W	#7,OFFSETX
	*SUB.W	#15,OFFSETY
	DC.W	$A000
	LEA	-$158(A0),A0
	MOVE.L	A0,X
	LEA	2(A0),A0
	MOVE.L	A0,Y
	LEA	NEWSCREEN,A5
	MOVE.W	#1,VIRTUAL
	BRA	ALLEZ
	
ORIGINAL
	MOVE.L	SAFE,A5
	
ALLEZ	MOVE.L	#-1,(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	SUB.L	(A5),D0
	MOVE.L	D0,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	MOVE.L	D0,D7
	MOVE.L	(A5)+,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	MOVE.L	D0,ECRAN
	MOVE.L	D7,-(A7)
	MOVE.W	#$49,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	PEA	CLS
	MOVE.W	#$9,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	MOVE.W	(A5)+,-(A7)
	MOVE.W	#3,-(A7)
	MOVE.L	ECRAN,-(A7)
	MOVE.L	ECRAN,-(A7)
	MOVE.W	#$5,-(A7)
	TRAP	#14
	ADD.W	#14,A7
	
	PEA	0
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.L	D0,OLD_SP
	
	MOVE.L	ECRAN,$44E.W
	MOVE.L	ECRAN,$436.w
	
	DC.W 	$A000
      	MOVE.L  	A0,LINE_A
      	MOVE.L	A5,PARAM
      	
      	*LEA   	4(A5),A5
      	MOVE.W	(A5)+,-692(A0)
      	MOVE.W	(A5)+,-690(A0)
      	MOVE.W 	(A5),-2(A0) 
      	MOVE.W 	(A5)+,2(A0) 
      	MOVE.W 	(A5)+,-12(A0) 
      	MOVE.W 	(A5)+,-4(A0)
      	MOVE.W 	(A5)+,-40(A0) 
      	MOVE.W 	(A5)+,-44(A0) 
      	MOVE.W 	(A5)+,-42(A0) 

	
	MOVE.W	(A5)+,$FFFF82A6.W
	MOVE.W	(A5)+,$FFFF82A8.W
	MOVE.W	(A5)+,$FFFF82A4.W
	MOVE.W	(A5)+,$FFFF82AA.W
	MOVE.W	(A5)+,$FFFF82AC.W
	MOVE.W	(A5)+,$FFFF82A2.W
	MOVE.W	(A5)+,$FFFF8282.W		*,d0
	MOVE.W	(A5)+,$FFFF828C.W
	MOVE.W	(A5)+,$FFFF8284.W
	MOVE.W	(A5)+,$FFFF8286.W
	MOVE.W	(A5)+,$FFFF8288.W
	MOVE.W	(A5)+,$FFFF828A.W
					*MOVE.W	(A5)+,$FFFF82C0.W
					*MOVE.W	(A5)+,$FFFF8266.W
					*MOVE.W	(A5)+,$FFFF8260.W
	MOVE.W	(A5)+,$FFFF8210.W
	MOVE.W	(A5)+,$FFFF82C2.W
	MOVE.W	OFFSET,D0
	BEQ.S	NO
	MOVE.W	D0,$FFFF820E.W
	
NO	MOVE.L	$88.W,NOT_YET+2
	MOVE.L	#NEW_88,$88.W

	MOVE.L	$70,JUMP+2
	CMP.W	#1,VIRTUAL
	BNE.S	NIET
	MOVE.L	#MY_VBL,$70.W
	BRA.S	ER
NIET	MOVE.L	JUMP+2,$70	
ER	MOVE.L	OLD_SP,-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	
	MOVE.W	#0,-(A7)
	MOVE.L	PRG_SIZE,-(A7)
	MOVE.W	#$31,-(A7)
	TRAP	#1
***************************************************************************
NEW_88	CMPI.W  	#$73,D0 
      	BNE.S   	NOT_YET 
      	MOVEA.L 	D1,A0 
      	MOVEA.L 	12(A0),A1 
      	MOVEA.L 	(A0)+,A0
      	CMPI.W  	#1,(A0) 
      	BNE.S   	NOT_YET
      	MOVE.L  	A1,SAVE_A1
      	MOVE.L  	2(A7),NOT_YET_2+2
      	MOVE.L  	#NEW_88_2,2(A7)
NOT_YET	JMP     	$12345678 
NEW_88_2
	MOVE.W 	NOT_YET,NEW_88 
      	MOVE.L 	NOT_YET+2,NEW_88+2
      	MOVE.L	PARAM,A0 
      	MOVE.L 	A0,SAVE_PARAM
      	MOVE.L	LINE_A,A0
      	MOVE.L 	SAVE_PARAM(PC),A1
      	MOVE.W 	(A1)+,-692(A0)
      	MOVE.W 	(A1)+,-690(A0)
      	MOVE.W 	(A1),-2(A0) 
      	MOVE.W 	(A1)+,2(A0) 
      	MOVE.W 	(A1)+,-12(A0) 
      	MOVE.W 	(A1)+,-4(A0)
      	MOVE.W 	(A1)+,-40(A0) 
      	MOVE.W 	(A1)+,-44(A0) 
      	MOVE.W 	(A1)+,-42(A0) 
      	MOVE.W 	(A1)+,SAVE_AES+0 
      	MOVE.W 	(A1)+,SAVE_AES+2 
      	MOVE.W 	(A1)+,SAVE_AES+4 
      	MOVE.W 	(A1)+,SAVE_AES+6 
      	MOVE.W 	(A1)+,SAVE_AES+8 
      	MOVE.W 	(A1)+,SAVE_AES+10 
      	MOVEA.L SAVE_A1,A0
      	MOVEA.L SAVE_PARAM(PC),A1
      	MOVE.W  (A1)+,(A0)+ 
      	MOVE.W  (A1)+,(A0)
	MOVE.L	NOT_YET+2,$88.W
	
NOT_YET_2	JMP	$87654320
***************************************************************************
MY_VBL	MOVEM.L	D0-A6,-(A7)
	BSR	TESTBORDS
	BSR	HARD
	MOVEM.L	(A7)+,D0-A6
JUMP	JMP	12345678

TESTBORDS
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVE.L	Y,A0
	MOVE.W	(A0),D0
	MOVE.W	SCREENY,D1
	CMP.W	D1,D0
	BGT.S	.SCRIN1
	MOVE.W	D0,SCREENY
	BRA.S	.SCRIN2
.SCRIN1	ADD.W	OFFSETY,D1
	CMP.W	D1,D0
	BLT.S	.SCRIN2
	SUB.W	OFFSETY,D0
	MOVE.W	D0,SCREENY
.SCRIN2	MOVE.L	X,A0
	MOVE.W	(A0),D0
	MOVE.W	SCREENX,D1
	CMP.W	D1,D0
	BGT.S	.SCRIN3
	MOVE.W	D0,SCREENX
	BRA.S	.SCRIN4
.SCRIN3	ADD.W	OFFSETX,D1
	CMP.W	D1,D0
	BLT.S	.SCRIN4
	SUB.W	OFFSETX,D0
	MOVE.W	D0,SCREENX
.SCRIN4 RTS	

HARD	LEA	NEWSCREEN,A5
	BSR	TESTPLAN
	MOVEQ	#0,D0
	MOVE.W	SCREENY,D0
	MULU	10(A5),D0
	ADD.L	$44E.W,D0
	ADD.L	D1,D0
	BTST	#0,33(A5)
	BNE.S	NOFL
	*BCHG	#0,FLICK
	BTST	#0,$469.W
	BEQ.S	NOFL
	MOVEQ	#0,D1
	MOVE.W	10(A5),D1
	ADD.L	D1,D0
NOFL	MOVE.L	D0,-(A7)
	MOVE.B	2(A7),$FFFF8203.W
	MOVE.B	2(A7),$FFFF8207.W
	MOVE.B	1(A7),$FFFF8201.W
	MOVE.B	1(A7),$FFFF8205.W
	MOVE.B	3(A7),$FFFF820D.W
	MOVE.B	3(A7),$FFFF8209.W
	ADDQ.W	#4,A7
	RTS
	
TESTPLAN
	MOVE.L	SAFE,A4
	MOVEQ	#0,D0
	MOVEQ	#0,D2
	MOVE.W	SCREENX,D0
	MOVE.L	D0,D1
	
	CMP.W	#1,ROUGH
	BNE.S	PAS_AU_BORD
	MOVE.W	OFFSETX,D2
	SUB.W	#3,D2
	CMP.W	D2,D1
	BLE.S	PAS_AU_BORD
	ADD.L	#16,D1
	
PAS_AU_BORD	
	CMP.W	#0,PLAN
	BNE.S	CC4
	DIVU	#32,D1
	SWAP	D1
	MOVE.W	D1,D2
	SWAP	D1
	MULU	#4,D1
	MOVE.W	#2,D3
	
CC4	CMP.W	#1,PLAN
	BNE.S	CC16
	DIVU	#16,D1
	SWAP	D1
	MOVE.W	D1,D2
	SWAP	D1
	MULU	#4,D1
	MOVE.W	#2,D3
	
CC16	CMP.W	#2,PLAN
	BNE.S	CC256
	DIVU	#16,D1
	SWAP	D1
	MOVE.W	D1,D2
	SWAP	D1	
	MULU	#8,D1
	MOVE.W	#4,D3
	
CC256	CMP.W	#3,PLAN
	BNE.S	CTC
	DIVU	#16,D1
	SWAP	D1
	MOVE.W	D1,D2
	SWAP	D1	
	MULU	#16,D1
	MOVE.W	#8,D3
	
CTC	CMP.W	#4,PLAN
	BNE.S	COTH
	MULU	#2,D1
	RTS
	
COTH	CMP.W	#1,ROUGH
	BEQ	OUT
	MOVE.W	10(A4),D4
	LSR.W	#1,D4
	TST.W	D2
	BEQ.S	CC3
	SUB.W	D3,D4
CC3	MOVE.W	D2,$FFFF8264.W
	MOVE.W	D4,$FFFF8210.W
	RTS
***************************************************************************
	DATA
CLS	DC.B	$1B,'E',0,0
TXT_INTRO
	DC.B	$1B,'E'
	DC.B	"                             MAXIMUM COLUMNS ON SCREEN                   V 1.4",$D,$A
	DC.B	'                     BY  GUILLAUME AUDUC  AND  RODOLPHE PINEAU',$D,$A
	DC.B	'                              (c) EUROSOFT JUILLET 93',$D,$A,0
TXT_PAL_640
	DC.B	$D,$A
	DC.B	'THIS IS THE 640*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A TV/MONITOR AT 50 HZ (PAL/SECAM).',$D,$A
	DC.B	"DON'T TRY THE VGA MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A
	DC.B	' A -   768   *  304        2    8 * 8     96     38    TV 50 HZ        29184',$D,$A
	DC.B	' Z -   832   *  304        4    8 * 8    104     38    TV 50 HZ        63232',$D,$A
	DC.B	' E -   832   *  304       16    8 * 8    104     38    TV 50 HZ       126464',$D,$A
	DC.B	' R -   832   *  304      256    8 * 8    104     38    TV 50 HZ       252928',$D,$A
	DC.B	' T -   832   *  304       TC    8 * 8    104     38    TV 50 HZ       505856',$D,$A,$D,$A
	
	DC.B	' Y -   768   *  608        2    8 *16     96     38    TV 50 HZ        58368',$D,$A
	DC.B	' U -   832   *  608        4    8 *16    104     38    TV 50 HZ       126464',$D,$A
	DC.B	' I -   832   *  608       16    8 *16    104     38    TV 50 HZ       252928',$D,$A
	DC.B	' O -   832   *  608      256    8 *16    104     38    TV 50 HZ       505856',$D,$A
	DC.B	' P -   832   *  608       TC    8 *16    104     38    TV 50 HZ      1011712',$D,$A,$D,$A,$D,$A,0
	EVEN
TAB_PAL_640
	DC.L	V768_304_2_TV_50
	DC.L	V832_304_4_TV_50
	DC.L	V832_304_16_TV_50
	DC.L	V832_304_256_TV_50
	DC.L	V832_304_TC_TV_50
	DC.L	V768_608_2_TV_50
	DC.L	V832_608_4_TV_50
	DC.L	V832_608_16_TV_50
	DC.L	V832_608_256_TV_50
	DC.L	V832_608_TC_TV_50
	DC.L	-1
V768_304_2_TV_50
	DC.L	768*304/8
	DC.W	$28
	DC.W	768-1,304-1,768/8,768,304,768*8/8,96-1,38-1
	DC.W	$F,$F,$26B,$270,$26B,$271,$1FE,$18E,$148,$48,$395,$C8+6,48,4	
V832_304_4_TV_50
	DC.L	832*304/4
	DC.W	$A9
	DC.W	832-1,304-1,832/4,832,304,832*8/4,104-1,38-1
	DC.W	$11,$11,$271,$271,$26E,$271,$3E,$34,$31,$9,$234,$29,104,4
V832_304_16_TV_50
	DC.L	832*304/2
	DC.W	$2A
	DC.W	832-1,304-1,832/2,832,304,832*8/2,104-1,38-1
	DC.W	$11,$11,$271,$271,$26E,$271,$1FE,$1AB,$18B,$4B,$3F8,$16C,208,4
V832_304_256_TV_50
	DC.L	832*304
	DC.W	$2B
	DC.W	832-1,304-1,832,832,304,832*8,104-1,38-1
	DC.W	$11,$11,$271,$271,$26B,$271,$1FE,$1A8,$183,$43,0,$177,416,4
V832_304_TC_TV_50
	DC.L	832*304*2
	DC.W	$2C
	DC.W	832-1,304-1,832*2,832,304,832*2*8,104-1,38-1
	DC.W	$F,$F,$271,$271,$26B,$271,$1FE,$1AB,$188,$48,$17,$188,832,4
V768_608_2_TV_50
	DC.L	768*608/8
	DC.W	$128
	DC.W	768-1,608-1,768/8,768,608,768*16/8,96-1,38-1
	DC.W	$11,$F,$26B,$270,$26B,$270,$1FE,$18E,$148,$48,$395,$C8+6,48,6
V832_608_4_TV_50
	DC.L	832*608/4
	DC.W	$128+1
	DC.W	832-1,608-1,832/4,832,608,832*16/4,104-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$3E,$3B,$39,$11,$0,$31,104,6
V832_608_16_TV_50
	DC.L	832*608/2
	DC.W	$128+2
	DC.W	832-1,608-1,832/2,832,608,832*16/2,104-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$1FE,$1AB,$18B,$4B,$3F8,$16C,208,6
V832_608_256_TV_50
	DC.L	832*608
	DC.W	$128+3
	DC.W	832-1,608-1,832,832,608,832*16,104-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$1FE,$19B,$17B,$3B,$3F8,$169,416,6
V832_608_TC_TV_50
	DC.L	832*608*2
	DC.W	$128+4
	DC.W	832-1,608-1,832*2,832,608,832*16*2,104-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$1FE,$195,$174,$34,$3,$174,832,6

	
TXT_PAL_320
	DC.B	$D,$A
	DC.B	'THIS IS THE 320*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A TV/MONITOR AT 50 HZ (PAL/SECAM).',$D,$A
	DC.B	"DON'T TRY THE VGA MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A	
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A
	DC.B	' A -   384   *  304        2    8 * 8     48     38    TV 50 HZ        14592',$D,$A
	DC.B	' Z -   416   *  304        4    8 * 8     52     38    TV 50 HZ        31616',$D,$A
	DC.B	' E -   416   *  304       16    8 * 8     52     38    TV 50 HZ        63232',$D,$A
	DC.B	' R -   416   *  304      256    8 * 8     52     38    TV 50 HZ       126464',$D,$A
	DC.B	' T -   416   *  304       TC    8 * 8     52     38    TV 50 HZ       252928',$D,$A,$D,$A
	
	DC.B	' Y -   384   *  608        2    8 * 8     48     38    TV 50 HZ        14592',$D,$A
	DC.B	' U -   416   *  608        4    8 * 8     52     38    TV 50 HZ        63232',$D,$A
	DC.B	' I -   416   *  608       16    8 * 8     52     38    TV 50 HZ       126484',$D,$A
	DC.B	' O -   416   *  608      256    8 * 8     52     38    TV 50 HZ       252928',$D,$A
	DC.B	' P -   416   *  608       TC    8 * 8     52     38    TV 50 HZ       505856',$D,$A,$D,$A,$D,$A,0
	EVEN
TAB_PAL_320
	DC.L	V384_304_2_TV_50
	DC.L	V416_304_4_TV_50
	DC.L	V416_304_16_TV_50
	DC.L	V416_304_256_TV_50
	DC.L	V416_304_TC_TV_50
	DC.L	V384_608_2_TV_50
	DC.L	V416_608_4_TV_50
	DC.L	V416_608_16_TV_50
	DC.L	V416_608_256_TV_50
	DC.L	V416_608_TC_TV_50	
	DC.L	-1
V384_304_2_TV_50
	DC.L	384*304/8
	DC.W	$20
	DC.W	384-1,304-1,384/8,384,304,384*8/8,48-1,38-1
	DC.W	$F,$F,$271,$271,$26B,$271,$FE,$D7,$B1,$31,$28E,$2F,24,0
V416_304_4_TV_50
	DC.L	416*304/4
	DC.W	$21
	DC.W	416-1,304-1,416/4,416,304,416*8/4,52-1,38-1
	DC.W	$F,$F,$271,$271,$26B,$271,$3E,$31,$2F,$6,$22D,$27,52,0
V416_304_16_TV_50
	DC.L	416*304/2
	DC.W	$A2
	DC.W	416-1,304-1,416/2,416,304,416*8/2,52-1,38-1
	DC.W	$F,$F,$271,$271,$26B,$271,$3E,$34,$31,$8,$233,$28,104,0
V416_304_256_TV_50
	DC.L	416*304
	DC.W	$23
	DC.W	416-1,304-1,416,416,304,416*8,52-1,38-1
	DC.W	$F,$F,$271,$271,$26B,$271,$FE,$E3,$D3,$33,$0,$C1,208,0
V416_304_TC_TV_50
	DC.L	416*304*2
	DC.W	$24
	DC.W	416-1,304-1,416*2,416,304,416*8*2,52-1,38-1
	DC.W	$F,$F,$271,$271,$26B,$271,$FE,$D8,$C8,$25,$5,$C8,416,0
V384_608_2_TV_50
	DC.L	384*608/8
	DC.W	$120
	DC.W	384-1,608-1,384/8,384,608,384*16/8,48-1,38-1
	DC.W	$11,$F,$26B,$270,$26B,$270,$FE,$D7,$B1,$31,$28E,$2F,24,2
V416_608_4_TV_50
	DC.L	416*608/4
	DC.W	$121
	DC.W	416-1,608-1,416/4,416,608,416*16/4,52-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$3E,$31,$2F,$6,$22D,$27,52,2
V416_608_16_TV_50
	DC.L	416*608/2
	DC.W	$122
	DC.W	416-1,608-1,416/2,416,608,416*16/2,52-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$3E,$34,$31,$8,$233,$28,104,2
V416_608_256_TV_50
	DC.L	416*608
	DC.W	$123
	DC.W	416-1,608-1,416,416,608,416*16,52-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$FE,$E3,$D3,$33,$0,$C1,208,2
V416_608_TC_TV_50
	DC.L	416*608*2
	DC.W	$124
	DC.W	416-1,608-1,416*2,416,608,416*16*2,52-1,38-1
	DC.W	$14,$11,$271,$271,$26E,$270,$FE,$D8,$C8,$25,$5,$C8,416,2

	
TXT_PAL_1280
	DC.B	$D,$A
	DC.B	'THIS IS THE BONUS 1280*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A TV/MONITOR AT 50 HZ (PAL/SECAM).',$D,$A
	DC.B	"DON'T TRY THE VGA MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A	
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A	
	DC.B	' A -  1664   *  304        4    8 * 8    208     38    TV 50 HZ       128484',$D,$A
	DC.B	' Z -  1664   *  304       16    8 * 8    208     38    TV 50 HZ       252928',$D,$A,$D,$A
	
	DC.B	' E -  1664   *  608        4    8 * 8    208     76    TV 50 HZ       252928',$D,$A
	DC.B	' R -  1664   *  608       16    8 * 8    208     76    TV 50 HZ       505856',$D,$A,$D,$A,$D,$A,0
	EVEN
TAB_PAL_1280
	DC.L	V1664_304_4_TV_50
	DC.L	V1664_304_16_TV_50
	DC.L	V1664_608_4_TV_50
	DC.L	V1664_608_16_TV_50
	DC.L	-1
V1664_304_4_TV_50
	DC.L	1664*304/4
	DC.W	$A9
	DC.W	1664-1,304-1,1664/4,1664,304,1664*8/4,208-1,38-1
	DC.W	$11,$11,$271,$271,$26B,$271,$3E,$36,$32,$B,$23A,$2F,208,8
V1664_304_16_TV_50
	DC.L	1664*304/2
	DC.W	$AA
	DC.W	1664-1,304-1,1664/2,1664,304,1664*8/2,208-1,38-1
	DC.W	$11,$11,$271,$271,$26B,$271,$3E,$35,$32,$A,$23B,$30,416,8
V1664_608_4_TV_50
	DC.L	1664*608/4
	DC.W	$A9
	DC.W	1664-1,608-1,1664/4,1664,608,1664*8/4,208-1,76-1
	DC.W	$13,$10,$271,$270,$26B,$270,$3E,$36,$33,$B,$23A,$2F,208,$A
V1664_608_16_TV_50
	DC.L	1664*608/2
	DC.W	$AA
	DC.W	1664-1,608-1,1664/2,1664,608,1664*8/2,208-1,76-1
	DC.W	$13,$10,$271,$270,$26B,$270,$3E,$35,$32,$A,$23B,$30,416,$A
************************************************************************************************************************	
TXT_NTSC_640
	DC.B	$D,$A
	DC.B	'THIS IS THE 640*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A TV/MONITOR AT 60 HZ (NTSC/SECAM).',$D,$A
	DC.B	"DON'T TRY THE VGA MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A
	DC.B	' A -   768   *  248        2    8 * 8     96     38    TV 60 HZ        23808',$D,$A
	DC.B	' Z -   832   *  248        4    8 * 8    104     38    TV 60 HZ        51584',$D,$A
	DC.B	' E -   832   *  248       16    8 * 8    104     38    TV 60 HZ       103168',$D,$A
	DC.B	' R -   832   *  248      256    8 * 8    104     38    TV 60 HZ       206336',$D,$A
	DC.B	' T -   832   *  248       TC    8 * 8    104     38    TV 60 HZ       412672',$D,$A,$D,$A
	
	DC.B	' Y -   768   *  496        2    8 *16     96     38    TV 60 HZ        47616',$D,$A
	DC.B	' U -   832   *  496        4    8 *16    104     38    TV 60 HZ       103168',$D,$A
	DC.B	' I -   832   *  496       16    8 *16    104     38    TV 60 HZ       206336',$D,$A
	DC.B	' O -   832   *  496      256    8 *16    104     38    TV 60 HZ       412672',$D,$A
	DC.B	' P -   832   *  496       TC    8 *16    104     38    TV 60 HZ       825344',$D,$A,$D,$A,$D,$A,0
	EVEN
TAB_NTSC_640
	DC.L	V768_248_2_TV_60
	DC.L	V832_248_4_TV_60
	DC.L	V832_248_16_TV_60
	DC.L	V832_248_256_TV_60
	DC.L	V832_248_TC_TV_60
	DC.L	V768_496_2_TV_60
	DC.L	V832_496_4_TV_60
	DC.L	V832_496_16_TV_60
	DC.L	V832_496_256_TV_60
	DC.L	V832_496_TC_TV_60
	DC.L	-1
V768_248_2_TV_60
	DC.L	768*248/8
	DC.W	$8
	DC.W	768-1,248-1,768/8,768,248,768*8/8,96-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$1FE,$18E-8,$148,$48,$395,$C8+6,48,4
V832_248_4_TV_60
	DC.L	832*248/4
	DC.W	$A9
	DC.W	832-1,248-1,832/4,832,248,832*8/4,104-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$3E,$34,$31,$9,$234,$29,104,4
V832_248_16_TV_60
	DC.L	832*248/2
	DC.W	$A
	DC.W	832-1,248-1,832/2,832,248,832*8/2,104-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$1FE,$1B1-8,$18C,$4B,$3F8,$16C,208,4
V832_248_256_TV_60
	DC.L	832*248
	DC.W	$B
	DC.W	832-1,248-1,832,832,248,832*8,104-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$1FE,$1BB,$19D,$5D,$1A,$18B,416,4
V832_248_TC_TV_60
	DC.L	832*248*2
	DC.W	$C
	DC.W	832-1,248-1,832*2,832,248,832*2*8,104-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$1FE,$1AA,$18B,$4B,$1A,$18B,832,4
V768_496_2_TV_60
	DC.L	768*496/8
	DC.W	$108
	DC.W	768-1,496-1,768/8,768,496,768*16/8,96-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$1FE,$18E-8,$148,$48,$395,$C8+6,48,6
V832_496_4_TV_60
	DC.L	832*496/4
	DC.W	$109
	DC.W	832-1,496-1,832/4,832,496,832*8/4,104-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$3E,$3B,$39,$11,$0,$31,104,6
V832_496_16_TV_60
	DC.L	832*496/2
	DC.W	$10A
	DC.W	832-1,496-1,832/2,832,496,832*16/2,104-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$1FE,$1B1-8,$18C,$4B,$3F8,$16C,208,6
V832_496_256_TV_60
	DC.L	832*496
	DC.W	$10B
	DC.W	832-1,496-1,832,832,496,832*16,104-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$1FE,$1BB,$19D,$5D,$1A,$18B,416,6
V832_496_TC_TV_60
	DC.L	832*496*2
	DC.W	$10C
	DC.W	832-1,496-1,832*2,832,496,832*16*2,104-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$1FE,$1AA,$18B,$4B,$1A,$18B,832,6
	
TXT_NTSC_320
	DC.B	$D,$A
	DC.B	'THIS IS THE 320*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A TV/MONITOR AT 60 HZ (NTSC).',$D,$A
	DC.B	"DON'T TRY THE VGA MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A	
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A
	DC.B	' A -   384   *  248        2    8 * 8     48     38    TV 60 HZ        11904',$D,$A
	DC.B	' Z -   416   *  248        4    8 * 8     52     38    TV 60 HZ        25792',$D,$A
	DC.B	' E -   416   *  248       16    8 * 8     52     38    TV 60 HZ        51584',$D,$A
	DC.B	' R -   416   *  248      256    8 * 8     52     38    TV 60 HZ       103168',$D,$A
	DC.B	' T -   416   *  248       TC    8 * 8     52     38    TV 60 HZ       206336',$D,$A,$D,$A
	
	DC.B	' Y -   384   *  496        2    8 * 8     48     38    TV 60 HZ        23808',$D,$A
	DC.B	' U -   416   *  496        4    8 * 8     52     38    TV 60 HZ        51584',$D,$A
	DC.B	' I -   416   *  496       16    8 * 8     52     38    TV 60 HZ       103168',$D,$A
	DC.B	' O -   416   *  496      256    8 * 8     52     38    TV 60 HZ       206336',$D,$A
	DC.B	' P -   416   *  496       TC    8 * 8     52     38    TV 60 HZ       412672',$D,$A,$D,$A,$D,$A,0
	EVEN
TAB_NTSC_320
	DC.L	V384_248_2_TV_60
	DC.L	V416_248_4_TV_60
	DC.L	V416_248_16_TV_60
	DC.L	V416_248_256_TV_60
	DC.L	V416_248_TC_TV_60
	DC.L	V384_496_2_TV_60
	DC.L	V416_496_4_TV_60
	DC.L	V416_496_16_TV_60
	DC.L	V416_496_256_TV_60
	DC.L	V416_496_TC_TV_60
	DC.L	-1
V384_248_2_TV_60
	DC.L	384*248/8
	DC.W	$0
	DC.W	384-1,248-1,384/8,384,248,384*8/8,48-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$1FE,$D7,$B1,$31,$28E,$2F,24,0
V416_248_4_TV_60
	DC.L	416*248/4
	DC.W	$1
	DC.W	416-1,248-1,416/4,416,248,416*8/4,52-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$3E,$31,$2F,$6,$22D,$27,52,0
V416_248_16_TV_60
	DC.L	416*248/2
	DC.W	$82
	DC.W	416-1,248-1,416/2,416,248,416*8/2,52-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$3E,$34,$31,$8,$233,$28,104,0
V416_248_256_TV_60
	DC.L	416*248
	DC.W	$3
	DC.W	416-1,248-1,416,416,248,416*8,52-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$FE,$E3,$D3,$33,$0,$C1,208,0
V416_248_TC_TV_60
	DC.L	416*248*2
	DC.W	$4
	DC.W	416-1,248-1,416*2,416,248,416*8*2,52-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$FE,$D8,$C8,$25,$5,$C8,416,0
V384_496_2_TV_60
	DC.L	384*496/8
	DC.W	$100
	DC.W	384-1,496-1,384/8,384,496,384*16/8,48-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$FE,$D7,$B1,$31,$28E,$2F,24,2
V416_496_4_TV_60
	DC.L	416*496/4
	DC.W	$101
	DC.W	416-1,496-1,416/4,416,496,416*16/4,52-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$3E,$31,$2F,$6,$22D,$27,52,2
V416_496_16_TV_60
	DC.L	416*496/2
	DC.W	$102
	DC.W	416-1,496-1,416/2,416,496,416*16/2,52-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$3E,$34,$31,$8,$233,$28,104,2
V416_496_256_TV_60
	DC.L	416*496
	DC.W	$103
	DC.W	416-1,496-1,416,416,496,416*16,52-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$FE,$E3,$D3,$33,$0,$C1,208,2
V416_496_TC_TV_60
	DC.L	416*496*2
	DC.W	$104
	DC.W	416-1,496-1,416*2,416,496,416*16*2,52-1,31-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$FE,$D8,$C8,$25,$5,$C8,416,2

	
TXT_NTSC_1280
	DC.B	$D,$A
	DC.B	'THIS IS THE BONUS 1280*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A TV/MONITOR AT 60 HZ (NTSC).',$D,$A
	DC.B	"DON'T TRY THE VGA MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A	
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A	
	DC.B	' A -  1664   *  248        4    8 * 8    208     38    TV 60 HZ       103168',$D,$A
	DC.B	' Z -  1664   *  248       16    8 * 8    208     38    TV 60 HZ       206336',$D,$A,$D,$A
	
	DC.B	' E -  1664   *  496        4    8 * 8    208     76    TV 60 HZ       206336',$D,$A
	DC.B	' R -  1664   *  496       16    8 * 8    208     76    TV 60 HZ       412672',$D,$A,$D,$A,$D,$A,0
	EVEN
TAB_NTSC_1280
	DC.L	V1664_248_4_TV_60
	DC.L	V1664_248_16_TV_60
	DC.L	V1664_496_4_TV_60
	DC.L	V1664_496_16_TV_60
	DC.L	-1
V1664_248_4_TV_60
	DC.L	1664*248/4
	DC.W	$89
	DC.W	1664-1,248-1,1664/4,1664,248,1664*8/4,208-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$3E,$36,$33,$B,$23A,$2F,208,8
V1664_248_16_TV_60
	DC.L	1664*248/2
	DC.W	$8A
	DC.W	1664-1,248-1,1664/2,1664,248,1664*8/2,208-1,31-1
	DC.W	$3,$1,$1F1,$1FE,$1F2,$20D,$3E,$35,$32,$A,$23B,$30,416,8
V1664_496_4_TV_60
	DC.L	1664*496/4
	DC.W	$89
	DC.W	1664-1,496-1,1664/4,1664,496,1664*8/4,208-1,62-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$3E,$36,$33,$B,$23A,$2F,208,$A
V1664_496_16_TV_60
	DC.L	1664*496/2
	DC.W	$8A
	DC.W	1664-1,496-1,1664/2,1664,496,1664*8/2,208-1,62-1
	DC.W	$4,$1,$1F1,$1FE,$1F2,$20A,$3E,$35,$32,$A,$23B,$30,416,$A
************************************************************************************************************************	
TXT_VGA_640
	DC.B	'THIS IS THE 640*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A VGA MONITOR.',$D,$A
	DC.B	"DON'T TRY THE OTHER MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A
	DC.B	' A -   640   *  248        2    8 * 8     80     31       VGA          19840',$D,$A
	DC.B	' Z -   640   *  248        4    8 * 8     80     31       VGA          39680',$D,$A
	DC.B	' E -   672   *  248       16    8 * 8     84     31       VGA          83328',$D,$A
	DC.B	' R -   672   *  248      256    8 * 8     84     31       VGA         166656',$D,$A,$D,$A

	DC.B	' T -   640   *  496        2    8 *16     80     31       VGA          39680',$D,$A
	DC.B	' Y -   640   *  496        4    8 *16     80     31       VGA          79360',$D,$A
	DC.B	' U -   672   *  496       16    8 *16     84     31       VGA         166656',$D,$A
	DC.B	' I -   672   *  496      256    8 *16     84     31       VGA         333312',$D,$A,$D,$A
	
	DC.B	' O -   640   * 1008        2    8 *16     80     63       VGA          80640',$D,$A
	DC.B	' P -   640   * 1008        4    8 *16     80     63       VGA         161280',$D,$A
	DC.B	' Q -   672   * 1008       16    8 *16     84     63       VGA         338688',$D,$A
	DC.B	' S -   672   * 1008      256    8 *16     84     63       VGA         677376',$D,$A,0
	EVEN
TAB_VGA_640
	DC.L	V640_248_2_VGA
	DC.L	V640_248_4_VGA
	DC.L	V672_248_16_VGA
	DC.L	V672_248_256_VGA
	DC.L	V640_496_2_VGA
	DC.L	V640_496_4_VGA
	DC.L	V672_496_16_VGA
	DC.L	V672_496_256_VGA
	DC.L	V640_1008_2_VGA
	DC.L	V640_1008_4_VGA
	DC.L	V672_1008_16_VGA
	DC.L	V672_1008_256_VGA
	DC.L	-1
V640_248_2_VGA
	DC.L	640*248/8
	DC.W	$118
	DC.W	640-1,248-1,640/8,640,248,640/8*8,80-1,31-1
	DC.W	$23,$21,$3FF,$3FF,$415,$419,$C6,$96,$8D,$15,$273,$50,40,9
V640_248_4_VGA
	DC.L	640*248/4
	DC.W	$119
	DC.W	640-1,248-1,640/4,640,248,640/4*8,80-1,31-1
	DC.W	$23,$1F,$3FF,$401,$415,$419,$17,$12,$11,$2,$20E,$D,80,9
V672_248_16_VGA
	DC.L	672*248/2
	DC.W	$11A
	DC.W	672-1,248-1,672/2,672,248,672/2*8,84-1,31-1
	DC.W	$23,$1F,$3FF,$401,$415,$419,$C6,$95,$94,$C,$29A,$83,168,9
V672_248_256_VGA
	DC.L	672*248
	DC.W	$11B
	DC.W	672-1,248-1,672,672,248,672*8,84-1,31-1
	DC.W	$23,$20,$3FF,$3FF,$415,$419,$C6,$96,$95,$E,$2A3,$8C,168*2,9
V640_496_2_VGA
	DC.L	640*496/8
	DC.W	$B8
	DC.W	640-1,496-1,640/8,640,496,640/8*16,80-1,31-1
	DC.W	$23,$21,$3FF,$3FF,$415,$419,$C6,$96,$8D,$15,$273,$50,40,8
V640_496_4_VGA
	DC.L	640*496/4
	DC.W	$19
	DC.W	640-1,496-1,640/4,640,496,640/4*16,80-1,31-1
	DC.W	$23,$1F,$3FF,$401,$415,$419,$17,$12,$11,$2,$20E,$D,80,8
V672_496_16_VGA
	DC.L	672*496/2
	DC.W	$1A
	DC.W	672-1,496-1,672/2,672,496,672*16/2,84-1,31-1
	DC.W	$23,$1F,$3FF,$401,$415,$419,$C6,$95,$94,$C,$29A,$83,168,8
V672_496_256_VGA
	DC.L	672*496
	DC.W	$1B
	DC.W	672-1,496-1,672,672,496,672*16,84-1,31-1
	DC.W	$23,$20,$3FF,$3FF,$415,$419,$C6,$96,$95,$E,$2A3,$8C,168*2,8
V640_1008_2_VGA
	DC.L	640*1008/8
	DC.W	$B8
	DC.W	640-1,1008-1,640/8,640,1008,640/8*16,80-1,63-1
	DC.W	$23,$1F,$410,$412,$415,$41A,$C6,$96,$8D,$15,$273,$50,40,$A
V640_1008_4_VGA
	DC.L	640*1008/4
	DC.W	$19
	DC.W	640-1,1008-1,640/4,640,1008,640/4*16,80-1,63-1
	DC.W	$23,$1F,$410,$412,$415,$41A,$17,$12,$11,$2,$20E,$D,80,$A
V672_1008_16_VGA
	DC.L	672*1008/2
	DC.W	$1A
	DC.W	672-1,1008-1,672/2,672,1008,672*16/2,84-1,63-1
	DC.W	$23,$1F,$410,$412,$415,$41A,$C6,$95,$94,$C,$29A,$83,168,$A
V672_1008_256_VGA
	DC.L	672*1008
	DC.W	$1B
	DC.W	672-1,1008-1,672,672,1008,672*16,84-1,63-1
	DC.W	$23,$1F,$40F,$412,$414,$41A,$C6,$96,$95,$E,$2A3,$8C,168*2,$A
	
	
TXT_VGA_320
	DC.B	'THIS IS THE 320*200 OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A VGA MONITOR.',$D,$A
	DC.B	"DON'T TRY THE OTHER MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A
	DC.B	'CHOOSE :',$D,$A
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A
	DC.B	' A -   320   *  248        2    8 * 8     40     31       VGA           9920',$D,$A
	DC.B	' Z -   320   *  248        4    8 * 8     40     31       VGA          19840',$D,$A
	DC.B	' E -   336   *  248       16    8 * 8     42     31       VGA          41664',$D,$A
	DC.B	' R -   336   *  248      256    8 * 8     42     31       VGA          83328',$D,$A
	DC.B	' T -   336   *  248       TC    8 * 8     42     31       VGA         166656',$D,$A,$D,$A
	
	DC.B	' Y -   320   *  496        2    8 *16     40     31       VGA          19840',$D,$A
	DC.B	' U -   320   *  496        4    8 *16     40     31       VGA          39680',$D,$A
	DC.B	' I -   336   *  496       16    8 *16     42     31       VGA          83328',$D,$A
	DC.B	' O -   336   *  496      256    8 *16     42     31       VGA         166656',$D,$A
	DC.B	' P -   336   *  496       TC    8 *16     42     31       VGA         333312',$D,$A,$D,$A
	
	DC.B	' Q -   320   * 1008        2    8 *16     40     63       VGA          40320',$D,$A
	DC.B	' S -   320   * 1008        4    8 *16     40     63       VGA          79360',$D,$A
	DC.B	' D -   336   * 1008       16    8 *16     42     63       VGA         169334',$D,$A
	DC.B	' F -   336   * 1008      256    8 *16     42     63       VGA         338688',$D,$A
	DC.B	' G -   336   * 1008       TC    8 *16     42     63       VGA         677376',$D,$A,0
	EVEN
TAB_VGA_320
	DC.L	V320_248_2_VGA
	DC.L	V320_248_4_VGA
	DC.L	V336_248_16_VGA
	DC.L	V336_248_256_VGA
	DC.L	V336_248_TC_VGA
	DC.L	V320_496_2_VGA
	DC.L	V320_496_4_VGA
	DC.L	V336_496_16_VGA
	DC.L	V336_496_256_VGA
	DC.L	V336_496_TC_VGA
	DC.L	V320_1008_2_VGA
	DC.L	V320_1008_4_VGA
	DC.L	V336_1008_16_VGA
	DC.L	V336_1008_256_VGA
	DC.L	V336_1008_TC_VGA
	DC.L	-1	
V320_248_2_VGA
	DC.L	320*248/8
	DC.W	$110
	DC.W	320-1,248-1,320/8,320,248,320/8*8,40-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C6,$BB,$BF,$50,$25C,$58,20,5
V320_248_4_VGA
	DC.L	320*248/4
	DC.W	$111
	DC.W	320-1,248-1,320/4,320,248,320/4*8,40-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$17,$15,$14,$5,$20D,$C,40,5
V336_248_16_VGA
	DC.L	336*248/2
	DC.W	$112
	DC.W	336-1,248-1,336/2,336,248,336/2*8,42-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C7,$AE,$A9,$24,$29A,$97,84,5
V336_248_256_VGA
	DC.L	336*248
	DC.W	$113
	DC.W	336-1,248-1,336,336,248,336*8,42-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C6,$A7,$A6,$1E,$2A3,$94,168,5
V336_248_TC_VGA
	DC.L	336*248*2
	DC.W	$114
	DC.W	336-1,248-1,336*2,336,248,336*2*8,42-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C6,$94,$94,$D,$2A3,$97,336,5
V320_496_2_VGA
	DC.L	320*496/8
	DC.W	$B0
	DC.W	320-1,496-1,320/8,320,496,320/8*16,40-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C6,$BB,$BF,$50,$25C,$58,20,4
V320_496_4_VGA
	DC.L	320*496/4
	DC.W	$11
	DC.W	320-1,496-1,320/4,320,496,320/4*16,40-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$17,$15,$14,$5,$20D,$C,40,4
V336_496_16_VGA
	DC.L	336*496/2
	DC.W	$12
	DC.W	336-1,496-1,336/2,336,496,336*16/2,42-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C7,$AE,$A9,$24,$29A,$97,84,4
V336_496_256_VGA
	DC.L	336*496
	DC.W	$13
	DC.W	336-1,496-1,336,336,496,336*16,42-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C6,$A7,$A6,$1E,$2A3,$94,168,4
V336_496_TC_VGA
	DC.L	336*496*2
	DC.W	$14
	DC.W	336-1,496-1,336*2,336,496,336*2*16,42-1,31-1
	DC.W	$23,$23,$403,$403,$415,$419,$C6,$94,$94,$D,$2A3,$97,336,4
V320_1008_2_VGA
	DC.L	320*1008/8
	DC.W	$B0
	DC.W	320-1,1008-1,320/8,320,1008,320/8*16,40-1,63-1
	DC.W	$23,$23,$403,$403,$415,$41A,$C6,$BB,$BF,$50,$25C,$58,20,6
V320_1008_4_VGA
	DC.L	320*1008/4
	DC.W	$11
	DC.W	320-1,1008-1,320/4,320,1008,320/4*16,40-1,63-1
	DC.W	$23,$23,$403,$403,$415,$41A,$17,$15,$14,$5,$20D,$C,40,6
V336_1008_16_VGA
	DC.L	336*1008/2
	DC.W	$12
	DC.W	336-1,1008-1,336/2,336,1008,336*16/2,42-1,63-1
	DC.W	$23,$22,$403,$403,$415,$41A,$C7,$AE,$A9,$24,$29A,$97,84,6
V336_1008_256_VGA
	DC.L	336*1008
	DC.W	$13
	DC.W	336-1,1008-1,336,336,1008,336*16,42-1,63-1
	DC.W	$23,$22,$403,$403,$415,$41A,$C6,$A7,$A6,$1E,$2A3,$94,168,6
V336_1008_TC_VGA
	DC.L	336*1008*2
	DC.W	$14
	DC.W	336-1,1008-1,336*2,336,1008,336*2*16,42-1,63-1
	DC.W	$23,$22,$403,$403,$415,$41A,$C6,$94,$94,$D,$2A3,$97,336,6
	
INDIC	DC.B	'    1 ->  TV  50 HZ MENU (PAL)              2 -> TV        60 HZ MENU (NTSC)',$D,$A
	DC.B	'    3 ->  VGA 60 HZ MENU                    4 -> MONOCHROM 70 HZ MENU',$D,$A
	DC.B    '                           <- USE ARROWS ->',0
************************************************************************************************************************
TXT_MONO
	DC.B	$D,$A
	DC.B	'THIS IS THE MONOCHROM OVERSCANED AND/OR INTERLACED MENU',$D,$A
	DC.B	'RUNNING ON A MONOCHROM 70 HZ MONITOR (SM124).',$D,$A
	DC.B	"DON'T TRY THE OTHER MENU IF YOU HAVE NOT A MULTISYNC MONITOR.",$D,$A,$D,$A,$D,$A
	DC.B	'CHOOSE :',$D,$A
	DC.B	'      XMAX     YMAX    COLORS   CHARS    COL   LINE      MODE     SIZE OF SCREEN',$D,$A
	DC.B    ' A -   640      480      2       8*16     80    30    MONO 70 HZ       38400',$D,$A
	DC.B	' Z -   640      960      2       8*16     80    60    MONO 70 HZ       76800',$D,$A,$D,$A,0
	EVEN
TAB_MONO
	DC.L	V640_480_2_MONO
	DC.L	V640_960_2_MONO
	DC.L	-1
V640_480_2_MONO	
	DC.L	640*480/8
	DC.W	$8
	DC.W	640-1,480-1,640/8,640,480,640/8*16,80-1,30-1
	DC.W	$7F3,$23,$2F,$3EA,$3E3,$3EF,$1A,$14,$4,$1F7,$20F,$E,40,8
V640_960_2_MONO	
	DC.L	640*960/8
	DC.W	$8
	DC.W	640-1,960-1,640/8,640,960,640/8*16,80-1,60-1
	DC.W	$7F3,$23,$2F,$3EA,$3E3,$3EE,$1A,$14,$4,$1F7,$20F,$E,40,$A
************************************************************************************************************************
RULE	DC.B	$1B,'E',$D,$A
	DC.B	'NOW YOU CAN INCREASE VIRTUALLY THE SIZE OF YOUR SCREEN',$D,$A,$D,$A
	
	DC.B	'PRESS :',$D,$A
	DC.B	' A  TO ADD BY    8 THE X AXIS           T  TO ADD BY    8 THE Y AXIS',$D,$A
	DC.B	' Z  TO ADD BY   16 THE X AXIS           Y  TO ADD BY   16 THE Y AXIS',$D,$A
	DC.B	' E  TO ADD BY   32 THE X AXIS           U  TO ADD BY   32 THE Y AXIS',$D,$A
RX	DC.B	' R  TO ADD BY 0000 THE X AXIS           I  TO ADD BY 0000 THE Y AXIS',$D,$A,$D,$A
	
	DC.B	' Q  TO SUB BY    8 THE X AXIS           G  TO SUB BY    8 THE Y AXIS',$D,$A
	DC.B	' S  TO SUB BY   16 THE X AXIS           H  TO SUB BY   16 THE Y AXIS',$D,$A
	DC.B	' D  TO SUB BY   32 THE X AXIS           J  TO SUB BY   32 THE Y AXIS',$D,$A
IY	DC.B	' F  TO SUB BY 0000 THE X AXIS           K  TO SUB BY 0000 THE Y AXIS',$D,$A,$D,$A
	
	DC.B	' W          TO RETURN TO MENU',$D,$A
	DC.B	' X          TO CONFIRM USING ROUGH  SCROLL (FOR VGA AND/OR 2 COLORS MODE)',$D,$A
	DC.B	' SPACE BAR  TO CONFIRM USING SMOOTH SCROLL',$D,$A
	DC.B    ' OTHER KEYS TO KEEP THE ORIGINAL CHOSEN SIZE',$D,$A,$D,$A
		
REWRIT	DC.B	'ORIGINAL CHOSEN SIZE : 0000 * 0000      0 000 000 BYTES',$D,$A,0
RE2	DC.B	'NEW      CHOSEN SIZE : 0000 * 0000      0 000 000 BYTES',$D,0
	
	BSS
FLICK		DS.W	1	
ROUGH		DS.W	1	
VIRTUAL		DS.W	1	
X		DS.L	1
Y		DS.L	1
SCREENX		DS.L	1
SCREENY		DS.L	1
OFFSETX		DS.L	1
OFFSETY		DS.L	1
NEWX		DS.W	1
NEWY		DS.W	1
NEWLEN		DS.L	1
PLAN		DS.W	1
OFFSET		DS.W	1
NEWSCREEN	DS.L	1
		DS.W	1
		DS.W	8
		DS.W	14
SAFE		DS.L	1
ECRAN		DS.L	1
PRG_SIZE	DS.L	1	
PARAM		DS.L	1
SAVE_PARAM	DS.L	1
SAVE_A1		DS.L	1
LINE_A		DS.L	1
SAVE_AES	DS.W	11
	
		DS.L	100
PILE		DS.L	1
OLD_SP		DS.L	1
	END