 DC.W 193
 DC.B 117,2
 DC.W 179
 DC.B 95,2
 DC.W 151
 DC.B 91,2
 DC.W 136
 DC.B 102,4
 DC.W 149
 DC.B 90,4
 DC.W 157
 DC.B 102,2
 DC.W 166
 DC.B 97,5
 DC.W 176
 DC.B 101,5
 DC.W 146
 DC.B 100,4
 DC.W 147
 DC.B 104,3
 DC.W 134
 DC.B 112,2
 DC.W 178
 DC.B 107,4
 DC.W 134
 DC.B 105,3
 DC.W 181
 DC.B 110,3
 DC.W 171
 DC.B 100,5
 DC.W 141
 DC.B 107,4
 DC.W 207
 DC.B 76,1
 DC.W 187
 DC.B 107,2
 DC.W 179
 DC.B 102,4
 DC.W 157
 DC.B 100,4
 DC.W 109
 DC.B 111,1
 DC.W 82
 DC.B 133,0
 DC.W 160
 DC.B 57,0
 DC.W 182
 DC.B 104,3
 DC.W 147
 DC.B 79,2
 DC.W 201
 DC.B 120,5
 DC.W 221
 DC.B 70,6
 DC.W 212
 DC.B 123,2
 DC.W 254
 DC.B 133,0
 DC.W 60
 DC.B 92,1
 DC.W 275
 DC.B 132,0
 DC.W 90
 DC.B 72,2
 DC.W 163
 DC.B 20,1
 DC.W 281
 DC.B 180,0
 DC.W 125
 DC.B 76,1
 DC.W 137
 DC.B 91,2
 DC.W 95
 DC.B 135,4
 DC.W 87
 DC.B 92,1
 DC.W 249
 DC.B 73,3
 DC.W 116
 DC.B 156,0
 DC.W 89
 DC.B 102,4
 DC.W 81
 DC.B 92,2
 DC.W 63
 DC.B 117,3
 DC.W 89
 DC.B 83,2
 DC.W 162
 DC.B 107,4
 DC.W 136
 DC.B 69,5
 DC.W 257
 DC.B 94,2
 DC.W 118
 DC.B 43,1
 DC.W 84
 DC.B 39,3
 DC.W 146
 DC.B 139,5
 DC.W 194
 DC.B 118,2
 DC.W 180
 DC.B 94,2
 DC.W 151
 DC.B 91,2
 DC.W 136
 DC.B 102,4
 DC.W 149
 DC.B 90,4
 DC.W 157
 DC.B 102,2
 DC.W 166
 DC.B 97,5
 DC.W 177
 DC.B 101,5
 DC.W 146
 DC.B 100,4
 DC.W 147
 DC.B 104,3
 DC.W 133
 DC.B 113,2
 DC.W 179
 DC.B 107,4
 DC.W 134
 DC.B 105,3
 DC.W 182
 DC.B 111,3
 DC.W 171
 DC.B 100,5
 DC.W 141
 DC.B 107,4
 DC.W 210
 DC.B 74,1
 DC.W 188
 DC.B 108,2
 DC.W 179
 DC.B 102,4
 DC.W 157
 DC.B 100,4
 DC.W 105
 DC.B 112,1
 DC.W 75
 DC.B 137,0
 DC.W 160
 DC.B 52,0
 DC.W 183
 DC.B 105,3
 DC.W 146
 DC.B 78,1
 DC.W 201
 DC.B 120,5
 DC.W 221
 DC.B 70,6
 DC.W 212
 DC.B 123,2
 DC.W 255
 DC.B 134,0
 DC.W 59
 DC.B 92,1
 DC.W 277
 DC.B 133,0
 DC.W 89
 DC.B 72,2
 DC.W 163
 DC.B 18,0
 DC.W 283
 DC.B 181,0
 DC.W 125
 DC.B 75,1
 DC.W 136
 DC.B 91,2
 DC.W 94
 DC.B 136,4
 DC.W 86
 DC.B 91,1
 DC.W 250
 DC.B 73,3
 DC.W 116
 DC.B 157,0
 DC.W 88
 DC.B 102,4
 DC.W 80
 DC.B 92,2
 DC.W 62
 DC.B 118,3
 DC.W 89
 DC.B 83,2
 DC.W 162
 DC.B 107,4
 DC.W 136
 DC.B 69,5
 DC.W 258
 DC.B 94,2
 DC.W 117
 DC.B 42,1
 DC.W 83
 DC.B 39,3
 DC.W 146
 DC.B 139,5
 DC.W 196
 DC.B 119,2
 DC.W 181
 DC.B 94,1
 DC.W 151
 DC.B 91,2
 DC.W 135
 DC.B 102,4
 DC.W 149
 DC.B 90,4
 DC.W 157
 DC.B 102,2
 DC.W 166
 DC.B 97,5
 DC.W 177
 DC.B 101,5
 DC.W 145
 DC.B 100,4
 DC.W 146
 DC.B 104,3
 DC.W 132
 DC.B 113,1
 DC.W 179
 DC.B 107,4
 DC.W 133
 DC.B 105,3
 DC.W 182
 DC.B 111,3
 DC.W 171
 DC.B 100,5
 DC.W 141
 DC.B 108,4
 DC.W 213
 DC.B 73,1
 DC.W 189
 DC.B 108,2
 DC.W 180
 DC.B 102,4
 DC.W 157
 DC.B 100,4
 DC.W 101
 DC.B 113,0
 DC.W 66
 DC.B 140,0
 DC.W 160
 DC.B 45,0
 DC.W 184
 DC.B 105,3
 DC.W 145
 DC.B 77,1
 DC.W 202
 DC.B 120,5
 DC.W 222
 DC.B 69,5
 DC.W 213
 DC.B 123,1
 DC.W 257
 DC.B 134,0
 DC.W 57
 DC.B 92,1
 DC.W 279
 DC.B 133,0
 DC.W 88
 DC.B 71,1
 DC.W 163
 DC.B 17,0
 DC.W 228
 DC.B 145,6
 DC.W 124
 DC.B 75,1
 DC.W 136
 DC.B 91,2
 DC.W 93
 DC.B 136,4
 DC.W 84
 DC.B 91,1
 DC.W 251
 DC.B 73,3
 DC.W 115
 DC.B 157,0
 DC.W 87
 DC.B 102,4
 DC.W 79
 DC.B 92,2
 DC.W 60
 DC.B 118,3
 DC.W 88
 DC.B 83,1
 DC.W 162
 DC.B 107,4
 DC.W 136
 DC.B 69,5
 DC.W 260
 DC.B 94,2
 DC.W 116
 DC.B 42,0
 DC.W 82
 DC.B 38,3
 DC.W 146
 DC.B 139,5
 DC.W 197
 DC.B 120,2
 DC.W 182
 DC.B 94,1
 DC.W 150
 DC.B 90,2
 DC.W 134
 DC.B 102,4
 DC.W 148
 DC.B 90,4
 DC.W 157
 DC.B 102,2
 DC.W 167
 DC.B 97,5
 DC.W 178
 DC.B 101,5
 DC.W 145
 DC.B 100,4
 DC.W 146
 DC.B 105,3
 DC.W 130
 DC.B 114,1
 DC.W 180
 DC.B 108,4
 DC.W 132
 DC.B 105,2
 DC.W 183
 DC.B 111,2
 DC.W 172
 DC.B 100,5
 DC.W 140
 DC.B 108,4
 DC.W 217
 DC.B 71,1
 DC.W 190
 DC.B 108,2
 DC.W 180
 DC.B 102,4
 DC.W 157
 DC.B 100,4
 DC.W 95
 DC.B 114,0
 DC.W 55
 DC.B 145,0
 DC.W 160
 DC.B 36,0
 DC.W 185
 DC.B 105,3
 DC.W 144
 DC.B 75,1
 DC.W 202
 DC.B 120,4
 DC.W 223
 DC.B 69,5
 DC.W 214
 DC.B 124,1
 DC.W 258
 DC.B 135,0
 DC.W 56
 DC.B 91,1
 DC.W 281
 DC.B 134,0
 DC.W 87
 DC.B 71,1
 DC.W 163
 DC.B 16,0
 DC.W 229
 DC.B 145,6
 DC.W 124
 DC.B 75,1
 DC.W 136
 DC.B 91,1
 DC.W 93
 DC.B 136,4
 DC.W 83
 DC.B 91,0
 DC.W 252
 DC.B 72,3
 DC.W 114
 DC.B 158,0
 DC.W 87
 DC.B 102,4
 DC.W 77
 DC.B 92,2
 DC.W 59
 DC.B 118,3
 DC.W 87
 DC.B 83,1
 DC.W 162
 DC.B 107,4
 DC.W 135
 DC.B 68,4
 DC.W 261
 DC.B 94,2
 DC.W 116
 DC.B 41,0
 DC.W 81
 DC.B 37,2
 DC.W 146
 DC.B 140,5
 DC.W 199
 DC.B 121,2
 DC.W 183
 DC.B 94,1
 DC.W 150
 DC.B 90,2
 DC.W 134
 DC.B 103,3
 DC.W 148
 DC.B 90,4
 DC.W 157
 DC.B 102,2
 DC.W 167
 DC.B 97,5
 DC.W 178
 DC.B 101,5
 DC.W 145
 DC.B 100,4
 DC.W 146
 DC.B 105,3
 DC.W 129
 DC.B 115,1
 DC.W 180
 DC.B 108,4
 DC.W 131
 DC.B 106,2
 DC.W 184
 DC.B 112,2
 DC.W 172
 DC.B 100,5
 DC.W 140
 DC.B 108,4
 DC.W 222
 DC.B 68,0
 DC.W 192
 DC.B 109,2
 DC.W 181
 DC.B 102,4
 DC.W 157
 DC.B 100,4
 DC.W 89
 DC.B 116,0
 DC.W 41
 DC.B 152,0
 DC.W 160
 DC.B 24,0
 DC.W 186
 DC.B 105,3
 DC.W 144
 DC.B 74,1
 DC.W 203
 DC.B 121,4
 DC.W 223
 DC.B 69,5
 DC.W 215
 DC.B 124,1
 DC.W 260
 DC.B 135,0
 DC.W 54
 DC.B 91,0
 DC.W 227
 DC.B 119,6
 DC.W 86
 DC.B 70,1
 DC.W 163
 DC.B 14,0
 DC.W 229
 DC.B 146,6
 DC.W 123
 DC.B 74,1
 DC.W 135
 DC.B 90,1
 DC.W 92
 DC.B 137,4
 DC.W 82
 DC.B 91,0
 DC.W 254
 DC.B 72,3
 DC.W 114
 DC.B 159,0
 DC.W 86
 DC.B 102,4
 DC.W 76
 DC.B 92,1
 DC.W 58
 DC.B 118,3
 DC.W 86
 DC.B 83,1
 DC.W 162
 DC.B 107,4
 DC.W 135
 DC.B 68,4
 DC.W 262
 DC.B 94,2
 DC.W 115
 DC.B 40,0
 DC.W 80
 DC.B 36,2
 DC.W 146
 DC.B 140,5
 DC.W 201
 DC.B 122,1
 DC.W 184
 DC.B 93,1
 DC.W 149
 DC.B 89,2
 DC.W 133
 DC.B 103,3
 DC.W 148
 DC.B 89,4
 DC.W 157
 DC.B 102,2
 DC.W 167
 DC.B 97,5
 DC.W 178
 DC.B 101,4
 DC.W 144
 DC.B 100,3
 DC.W 145
 DC.B 105,3
 DC.W 127
 DC.B 116,1
 DC.W 181
 DC.B 108,4
 DC.W 129
 DC.B 106,2
 DC.W 185
 DC.B 112,2
 DC.W 172
 DC.B 100,4
 DC.W 139
 DC.B 108,4
 DC.W 227
 DC.B 66,0
 DC.W 193
 DC.B 109,2
 DC.W 181
 DC.B 102,4
 DC.W 157
 DC.B 100,4
 DC.W 81
 DC.B 118,0
 DC.W 22
 DC.B 160,0
 DC.W 160
 DC.B 92,6
 DC.W 186
 DC.B 105,3
 DC.W 143
 DC.B 72,1
 DC.W 203
 DC.B 121,4
 DC.W 224
 DC.B 68,5
 DC.W 215
 DC.B 124,1
 DC.W 262
 DC.B 136,0
 DC.W 53
 DC.B 91,0
 DC.W 227
 DC.B 119,6
 DC.W 85
 DC.B 70,1
 DC.W 163
 DC.B 13,0
 DC.W 230
 DC.B 146,6
 DC.W 123
 DC.B 74,1
 DC.W 135
 DC.B 90,1
 DC.W 91
 DC.B 137,4
 DC.W 81
 DC.B 91,0
 DC.W 255
 DC.B 72,3
 DC.W 113
 DC.B 160,0
 DC.W 85
 DC.B 102,3
 DC.W 75
 DC.B 92,1
 DC.W 57
 DC.B 118,2
 DC.W 85
 DC.B 82,1
 DC.W 162
 DC.B 107,3
 DC.W 135
 DC.B 68,4
 DC.W 264
 DC.B 94,1
 DC.W 114
 DC.B 39,0
 DC.W 79
 DC.B 36,2
 DC.W 146
 DC.B 141,5
 DC.W 204
 DC.B 123,1
 DC.W 186
 DC.B 93,1
 DC.W 149
 DC.B 89,2
 DC.W 132
 DC.B 103,3
 DC.W 147
 DC.B 89,4
 DC.W 157
 DC.B 102,1
 DC.W 167
 DC.B 97,4
 DC.W 179
 DC.B 101,4
 DC.W 144
 DC.B 100,3
 DC.W 145
 DC.B 105,3
 DC.W 125
 DC.B 117,1
 DC.W 181
 DC.B 108,4
 DC.W 128
 DC.B 106,2
 DC.W 186
 DC.B 113,2
 DC.W 172
 DC.B 100,4
 DC.W 138
 DC.B 109,4
 DC.W 234
 DC.B 62,0
 DC.W 195
 DC.B 110,2
 DC.W 182
 DC.B 102,4
 DC.W 156
 DC.B 100,3
 DC.W 72
 DC.B 120,0
 DC.W 0
 DC.B 171,0
 DC.W 160
 DC.B 92,6
 DC.W 187
 DC.B 105,2
 DC.W 141
 DC.B 71,1
 DC.W 204
 DC.B 121,4
 DC.W 225
 DC.B 68,5
 DC.W 216
 DC.B 125,1
 DC.W 216
 DC.B 120,6
 DC.W 51
 DC.B 91,0
 DC.W 228
 DC.B 119,6
 DC.W 84
 DC.B 70,1
 DC.W 163
 DC.B 12,0
 DC.W 230
 DC.B 146,6
 DC.W 122
 DC.B 74,1
 DC.W 135
 DC.B 90,1
 DC.W 90
 DC.B 138,4
 DC.W 80
 DC.B 91,0
 DC.W 256
 DC.B 71,3
 DC.W 112
 DC.B 161,0
 DC.W 84
 DC.B 102,3
 DC.W 74
 DC.B 92,1
 DC.W 56
 DC.B 119,2
 DC.W 83
 DC.B 82,1
 DC.W 162
 DC.B 107,3
 DC.W 135
 DC.B 67,4
 DC.W 265
 DC.B 93,1
 DC.W 114
 DC.B 38,0
 DC.W 78
 DC.B 35,2
 DC.W 146
 DC.B 141,4
 DC.W 206
 DC.B 124,1
 DC.W 188
 DC.B 92,1
 DC.W 148
 DC.B 88,1
 DC.W 131
 DC.B 103,3
 DC.W 147
 DC.B 89,3
 DC.W 157
 DC.B 102,1
 DC.W 167
 DC.B 97,4
 DC.W 179
 DC.B 101,4
 DC.W 143
 DC.B 100,3
 DC.W 144
 DC.B 105,3
 DC.W 122
 DC.B 118,1
 DC.W 182
 DC.B 109,4
 DC.W 127
 DC.B 106,2
 DC.W 187
 DC.B 113,2
 DC.W 173
 DC.B 100,4
 DC.W 138
 DC.B 109,3
 DC.W 242
 DC.B 58,0
 DC.W 196
 DC.B 110,2
 DC.W 182
 DC.B 103,3
 DC.W 156
 DC.B 100,3
 DC.W 59
 DC.B 123,0
 DC.W 143
 DC.B 107,6
 DC.W 160
 DC.B 92,5
 DC.W 188
 DC.B 106,2
 DC.W 140
 DC.B 69,1
 DC.W 204
 DC.B 121,4
 DC.W 225
 DC.B 68,5
 DC.W 217
 DC.B 125,1
 DC.W 216
 DC.B 120,6
 DC.W 49
 DC.B 91,0
 DC.W 229
 DC.B 119,6
 DC.W 83
 DC.B 69,1
 DC.W 163
 DC.B 10,0
 DC.W 231
 DC.B 147,6
 DC.W 122
 DC.B 73,1
 DC.W 134
 DC.B 90,1
 DC.W 90
 DC.B 138,3
 DC.W 78
 DC.B 91,0
 DC.W 257
 DC.B 71,2
 DC.W 133
 DC.B 134,6
 DC.W 83
 DC.B 102,3
 DC.W 73
 DC.B 92,1
 DC.W 54
 DC.B 119,2
 DC.W 82
 DC.B 82,1
 DC.W 162
 DC.B 107,3
 DC.W 134
 DC.B 67,4
 DC.W 267
 DC.B 93,1
 DC.W 113
 DC.B 37,0
 DC.W 77
 DC.B 34,2
 DC.W 145
 DC.B 142,4
 DC.W 209
 DC.B 126,1
 DC.W 190
 DC.B 92,1
 DC.W 148
 DC.B 88,1
 DC.W 130
 DC.B 103,3
 DC.W 147
 DC.B 88,3
 DC.W 157
 DC.B 102,1
 DC.W 167
 DC.B 97,4
 DC.W 180
 DC.B 101,4
 DC.W 143
 DC.B 100,3
 DC.W 144
 DC.B 105,2
 DC.W 120
 DC.B 119,1
 DC.W 183
 DC.B 109,3
 DC.W 126
 DC.B 107,2
 DC.W 188
 DC.B 114,2
 DC.W 173
 DC.B 100,4
 DC.W 137
 DC.B 109,3
 DC.W 252
 DC.B 53,0
 DC.W 198
 DC.B 111,1
 DC.W 183
 DC.B 103,3
 DC.W 156
 DC.B 100,3
 DC.W 43
 DC.B 126,0
 DC.W 143
 DC.B 107,6
 DC.W 160
 DC.B 92,5
 DC.W 190
 DC.B 106,2
 DC.W 139
 DC.B 66,1
 DC.W 205
 DC.B 122,4
 DC.W 226
 DC.B 67,5
 DC.W 218
 DC.B 125,1
 DC.W 217
 DC.B 120,6
 DC.W 48
 DC.B 91,0
 DC.W 229
 DC.B 119,6
 DC.W 82
 DC.B 69,1
 DC.W 162
 DC.B 50,6
 DC.W 232
 DC.B 147,6
 DC.W 121
 DC.B 73,0
 DC.W 134
 DC.B 90,1
 DC.W 89
 DC.B 139,3
 DC.W 77
 DC.B 91,0
 DC.W 258
 DC.B 71,2
 DC.W 133
 DC.B 134,6
 DC.W 82
 DC.B 102,3
 DC.W 72
 DC.B 92,1
 DC.W 53
 DC.B 119,2
 DC.W 81
 DC.B 82,1
 DC.W 162
 DC.B 107,3
 DC.W 134
 DC.B 67,4
 DC.W 268
 DC.B 93,1
 DC.W 112
 DC.B 36,0
 DC.W 76
 DC.B 33,2
 DC.W 145
 DC.B 142,4
 DC.W 212
 DC.B 127,1
 DC.W 192
 DC.B 91,1
 DC.W 147
 DC.B 87,1
 DC.W 129
 DC.B 103,3
 DC.W 146
 DC.B 88,3
 DC.W 156
 DC.B 103,1
 DC.W 168
 DC.B 97,4
 DC.W 180
 DC.B 101,4
 DC.W 142
 DC.B 100,3
 DC.W 143
 DC.B 106,2
 DC.W 117
 DC.B 121,0
 DC.W 183
 DC.B 109,3
 DC.W 124
 DC.B 107,2
 DC.W 190
 DC.B 115,2
 DC.W 173
 DC.B 100,4
 DC.W 137
 DC.B 109,3
 DC.W 264
 DC.B 47,0
 DC.W 200
 DC.B 111,1
 DC.W 184
 DC.B 103,3
 DC.W 156
 DC.B 100,3
 DC.W 21
 DC.B 132,0
 DC.W 143
 DC.B 107,6
 DC.W 160
 DC.B 92,5
 DC.W 191
 DC.B 106,2
 DC.W 137
 DC.B 64,0
 DC.W 205
 DC.B 122,4
 DC.W 227
 DC.B 67,4
 DC.W 219
 DC.B 126,0
 DC.W 217
 DC.B 120,6
 DC.W 46
 DC.B 91,0
 DC.W 230
 DC.B 119,6
 DC.W 80
 DC.B 68,0
 DC.W 162
 DC.B 50,6
 DC.W 233
 DC.B 148,5
 DC.W 121
 DC.B 73,0
 DC.W 133
 DC.B 90,1
 DC.W 88
 DC.B 139,3
 DC.W 76
 DC.B 90,0
 DC.W 260
 DC.B 70,2
 DC.W 133
 DC.B 134,6
 DC.W 81
 DC.B 102,3
 DC.W 70
 DC.B 92,1
 DC.W 51
 DC.B 119,2
 DC.W 80
 DC.B 81,0
 DC.W 162
 DC.B 107,3
 DC.W 134
 DC.B 66,4
 DC.W 270
 DC.B 93,1
 DC.W 133
 DC.B 64,6
 DC.W 75
 DC.B 32,2
 DC.W 145
 DC.B 142,4
 DC.W 215
 DC.B 129,1
 DC.W 194
 DC.B 91,0
 DC.W 146
 DC.B 86,1
 DC.W 128
 DC.B 103,3
 DC.W 146
 DC.B 88,3
 DC.W 156
 DC.B 103,1
 DC.W 168
 DC.B 97,4
 DC.W 181
 DC.B 101,4
 DC.W 142
 DC.B 100,3
 DC.W 142
 DC.B 106,2
 DC.W 113
 DC.B 123,0
 DC.W 184
 DC.B 109,3
 DC.W 122
 DC.B 107,1
 DC.W 191
 DC.B 115,2
 DC.W 174
 DC.B 100,4
 DC.W 136
 DC.B 110,3
 DC.W 281
 DC.B 39,0
 DC.W 202
 DC.B 112,1
 DC.W 185
 DC.B 103,3
 DC.W 156
 DC.B 100,3
 DC.W 146
 DC.B 103,6
 DC.W 142
 DC.B 107,5
 DC.W 160
 DC.B 92,5
 DC.W 192
 DC.B 106,2
 DC.W 135
 DC.B 60,0
 DC.W 206
 DC.B 122,3
 DC.W 227
 DC.B 67,4
 DC.W 220
 DC.B 126,0
 DC.W 218
 DC.B 120,6
 DC.W 44
 DC.B 90,0
 DC.W 231
 DC.B 120,6
 DC.W 79
 DC.B 68,0
 DC.W 162
 DC.B 49,6
 DC.W 233
 DC.B 148,5
 DC.W 120
 DC.B 72,0
 DC.W 133
 DC.B 90,0
 DC.W 87
 DC.B 140,3
 DC.W 113
 DC.B 94,6
 DC.W 261
 DC.B 70,2
 DC.W 133
 DC.B 135,6
 DC.W 80
 DC.B 102,3
 DC.W 69
 DC.B 91,1
 DC.W 50
 DC.B 120,2
 DC.W 79
 DC.B 81,0
 DC.W 162
 DC.B 107,3
 DC.W 133
 DC.B 66,3
 DC.W 271
 DC.B 93,1
 DC.W 133
 DC.B 64,6
 DC.W 74
 DC.B 31,1
 DC.W 145
 DC.B 143,4
 DC.W 220
 DC.B 132,1
 DC.W 197
 DC.B 90,0
 DC.W 146
 DC.B 86,1
 DC.W 127
 DC.B 103,3
 DC.W 146
 DC.B 87,3
 DC.W 156
 DC.B 103,1
 DC.W 168
 DC.B 97,4
 DC.W 181
 DC.B 101,4
 DC.W 141
 DC.B 100,3
 DC.W 142
 DC.B 106,2
 DC.W 109
 DC.B 125,0
 DC.W 185
 DC.B 110,3
 DC.W 120
 DC.B 108,1
 DC.W 193
 DC.B 116,1
 DC.W 174
 DC.B 100,4
 DC.W 135
 DC.B 110,3
 DC.W 303
 DC.B 28,0
 DC.W 205
 DC.B 112,1
 DC.W 185
 DC.B 103,3
 DC.W 156
 DC.B 100,3
 DC.W 146
 DC.B 103,6
 DC.W 142
 DC.B 107,5
 DC.W 160
 DC.B 91,5
 DC.W 194
 DC.B 107,2
 DC.W 133
 DC.B 57,0
 DC.W 206
 DC.B 122,3
 DC.W 228
 DC.B 66,4
 DC.W 220
 DC.B 127,0
 DC.W 219
 DC.B 121,6
 DC.W 42
 DC.B 90,0
 DC.W 231
 DC.B 120,5
 DC.W 78
 DC.B 67,0
 DC.W 162
 DC.B 49,6
 DC.W 234
 DC.B 149,5
 DC.W 119
 DC.B 72,0
 DC.W 133
 DC.B 89,0
 DC.W 86
 DC.B 140,3
 DC.W 113
 DC.B 94,6
 DC.W 262
 DC.B 70,2
 DC.W 132
 DC.B 135,6
 DC.W 80
 DC.B 102,3
 DC.W 68
 DC.B 91,0
 DC.W 49
 DC.B 120,2
 DC.W 78
 DC.B 81,0
 DC.W 162
 DC.B 108,3
 DC.W 133
 DC.B 66,3
 DC.W 273
 DC.B 93,1
 DC.W 133
 DC.B 64,6
 DC.W 72
 DC.B 30,1
 DC.W 145
 DC.B 143,4
 DC.W 224
 DC.B 134,0
 DC.W 201
 DC.B 89,0
 DC.W 145
 DC.B 85,1
 DC.W 126
 DC.B 103,2
 DC.W 145
 DC.B 87,3
 DC.W 156
 DC.B 103,1
 DC.W 168
 DC.B 97,4
 DC.W 182
 DC.B 101,4
 DC.W 140
 DC.B 100,3
 DC.W 141
 DC.B 106,2
 DC.W 104
 DC.B 127,0
 DC.W 186
 DC.B 110,3
 DC.W 118
 DC.B 108,1
 DC.W 194
 DC.B 117,1
 DC.W 174
 DC.B 100,4
 DC.W 134
 DC.B 110,3
 DC.W 174
 DC.B 92,6
 DC.W 208
 DC.B 113,1
 DC.W 186
 DC.B 103,3
 DC.W 156
 DC.B 100,3
 DC.W 146
 DC.B 103,6
 DC.W 142
 DC.B 107,5
 DC.W 160
 DC.B 91,5
 DC.W 195
 DC.B 107,2
 DC.W 130
 DC.B 52,0
 DC.W 207
 DC.B 123,3
 DC.W 229
 DC.B 66,4
 DC.W 221
 DC.B 127,0
 DC.W 219
 DC.B 121,6
 DC.W 95
 DC.B 94,6
 DC.W 232
 DC.B 120,5
 DC.W 77
 DC.B 67,0
 DC.W 162
 DC.B 48,6
 DC.W 235
 DC.B 149,5
 DC.W 119
 DC.B 71,0
 DC.W 132
 DC.B 89,0
 DC.W 85
 DC.B 140,3
 DC.W 112
 DC.B 94,6
 DC.W 263
 DC.B 69,2
 DC.W 132
 DC.B 135,6
 DC.W 79
 DC.B 102,3
 DC.W 66
 DC.B 91,0
 DC.W 47
 DC.B 120,2
 DC.W 76
 DC.B 80,0
 DC.W 162
 DC.B 108,3
 DC.W 133
 DC.B 65,3
 DC.W 275
 DC.B 93,0
 DC.W 133
 DC.B 63,6
 DC.W 71
 DC.B 29,1
 DC.W 145
 DC.B 144,4
 DC.W 230
 DC.B 137,0
 DC.W 205
 DC.B 88,0
 DC.W 144
 DC.B 84,1
 DC.W 125
 DC.B 104,2
 DC.W 145
 DC.B 86,3
 DC.W 155
 DC.B 104,1
 DC.W 168
 DC.B 97,4
 DC.W 183
 DC.B 101,3
 DC.W 140
 DC.B 100,2
 DC.W 140
 DC.B 107,2
 DC.W 97
 DC.B 131,0
 DC.W 186
 DC.B 110,3
 DC.W 116
 DC.B 109,1
 DC.W 196
 DC.B 118,1
 DC.W 175
 DC.B 100,3
 DC.W 133
 DC.B 111,3
 DC.W 174
 DC.B 92,6
 DC.W 211
 DC.B 114,1
 DC.W 187
 DC.B 103,3
 DC.W 156
 DC.B 100,3
 DC.W 146
 DC.B 103,5
 DC.W 141
 DC.B 107,5
 DC.W 160
 DC.B 91,5
 DC.W 197
 DC.B 108,1
 DC.W 126
 DC.B 46,0
 DC.W 207
 DC.B 123,3
 DC.W 230
 DC.B 66,4
 DC.W 222
 DC.B 127,0
 DC.W 220
 DC.B 121,5
 DC.W 94
 DC.B 94,6
 DC.W 233
 DC.B 120,5
 DC.W 75
 DC.B 66,0
 DC.W 162
 DC.B 48,6
 DC.W 236
 DC.B 150,5
 DC.W 118
 DC.B 71,0
 DC.W 132
 DC.B 89,0
 DC.W 85
 DC.B 141,3
 DC.W 112
 DC.B 94,6
 DC.W 265
 DC.B 69,2
 DC.W 132
 DC.B 136,6
 DC.W 78
 DC.B 102,2
 DC.W 65
 DC.B 91,0
 DC.W 46
 DC.B 120,1
 DC.W 75
 DC.B 80,0
 DC.W 162
 DC.B 108,2
 DC.W 132
 DC.B 65,3
 DC.W 277
 DC.B 93,0
 DC.W 132
 DC.B 63,6
 DC.W 70
 DC.B 28,1
 DC.W 145
 DC.B 144,3
 DC.W 236
 DC.B 140,0
 DC.W 210
 DC.B 87,0
 DC.W 142
 DC.B 82,0
 DC.W 124
 DC.B 104,2
 DC.W 144
 DC.B 86,2
 DC.W 155
 DC.B 104,0
 DC.W 169
 DC.B 96,3
 DC.W 183
 DC.B 101,3
 DC.W 139
 DC.B 100,2
 DC.W 139
 DC.B 107,2
 DC.W 89
 DC.B 135,0
 DC.W 187
 DC.B 111,3
 DC.W 113
 DC.B 109,1
 DC.W 199
 DC.B 119,1
 DC.W 175
 DC.B 100,3
 DC.W 133
 DC.B 111,2
 DC.W 174
 DC.B 92,6
 DC.W 215
 DC.B 115,1
 DC.W 188
 DC.B 103,3
 DC.W 156
 DC.B 100,2
 DC.W 145
 DC.B 103,5
 DC.W 141
 DC.B 108,5
 DC.W 160
 DC.B 91,5
 DC.W 199
 DC.B 108,1
 DC.W 122
 DC.B 39,0
 DC.W 208
 DC.B 123,3
 DC.W 230
 DC.B 65,4
 DC.W 223
 DC.B 128,0
 DC.W 220
 DC.B 121,5
 DC.W 94
 DC.B 94,6
 DC.W 233
 DC.B 120,5
 DC.W 74
 DC.B 66,0
 DC.W 162
 DC.B 47,6
 DC.W 236
 DC.B 150,5
 DC.W 117
 DC.B 70,0
 DC.W 131
 DC.B 89,0
 DC.W 84
 DC.B 141,2
 DC.W 111
 DC.B 94,6
 DC.W 266
 DC.B 68,1
 DC.W 132
 DC.B 136,5
 DC.W 76
 DC.B 102,2
 DC.W 63
 DC.B 91,0
 DC.W 44
 DC.B 121,1
 DC.W 74
 DC.B 80,0
 DC.W 162
 DC.B 108,2
 DC.W 132
 DC.B 64,3
 DC.W 278
 DC.B 93,0
 DC.W 132
 DC.B 63,6
 DC.W 69
 DC.B 27,1
 DC.W 144
 DC.B 145,3
 DC.W 244
 DC.B 145,0
 DC.W 217
 DC.B 85,0
 DC.W 141
 DC.B 81,0
 DC.W 122
 DC.B 104,2
 DC.W 144
 DC.B 86,2
 DC.W 155
 DC.B 104,0
 DC.W 169
 DC.B 96,3
 DC.W 184
 DC.B 101,3
 DC.W 138
 DC.B 100,2
 DC.W 138
 DC.B 107,2
 DC.W 79
 DC.B 140,0
 DC.W 188
 DC.B 111,3
 DC.W 110
 DC.B 110,1
 DC.W 201
 DC.B 120,1
 DC.W 176
 DC.B 100,3
 DC.W 132
 DC.B 111,2
 DC.W 174
 DC.B 92,5
 DC.W 219
 DC.B 116,1
 DC.W 189
 DC.B 103,2
 DC.W 155
 DC.B 100,2
 DC.W 145
 DC.B 103,5
 DC.W 141
 DC.B 108,5
 DC.W 160
 DC.B 91,4
 DC.W 201
 DC.B 108,1
 DC.W 115
 DC.B 29,0
 DC.W 209
 DC.B 123,3
 DC.W 231
 DC.B 65,4
 DC.W 224
 DC.B 128,0
 DC.W 221
 DC.B 121,5
 DC.W 93
 DC.B 94,6
 DC.W 234
 DC.B 121,5
 DC.W 73
 DC.B 65,0
 DC.W 162
 DC.B 47,5
 DC.W 237
 DC.B 151,5
 DC.W 136
 DC.B 83,6
 DC.W 131
 DC.B 89,0
 DC.W 83
 DC.B 142,2
 DC.W 111
 DC.B 94,6
 DC.W 268
 DC.B 68,1
 DC.W 131
 DC.B 136,5
 DC.W 75
 DC.B 102,2
 DC.W 62
 DC.B 91,0
 DC.W 42
 DC.B 121,1
 DC.W 72
 DC.B 79,0
 DC.W 162
 DC.B 108,2
 DC.W 132
 DC.B 64,3
 DC.W 280
 DC.B 93,0
 DC.W 132
 DC.B 62,6
 DC.W 67
 DC.B 26,1
 DC.W 144
 DC.B 145,3
 DC.W 254
 DC.B 150,0
 DC.W 226
 DC.B 83,0
 DC.W 139
 DC.B 79,0
 DC.W 121
 DC.B 104,2
 DC.W 143
 DC.B 85,2
 DC.W 154
 DC.B 105,0
 DC.W 169
 DC.B 96,3
 DC.W 185
 DC.B 101,3
 DC.W 137
 DC.B 100,2
 DC.W 137
 DC.B 108,1
 DC.W 65
 DC.B 147,0
 DC.W 189
 DC.B 111,2
 DC.W 107
 DC.B 111,1
 DC.W 204
 DC.B 122,1
 DC.W 176
 DC.B 100,3
 DC.W 130
 DC.B 112,2
 DC.W 175
 DC.B 92,5
 DC.W 224
 DC.B 118,0
 DC.W 190
 DC.B 104,2
 DC.W 155
 DC.B 100,2
 DC.W 145
 DC.B 103,5
 DC.W 140
 DC.B 108,5
 DC.W 160
 DC.B 91,4
 DC.W 203
 DC.B 109,1
 DC.W 107
 DC.B 16,0
 DC.W 209
 DC.B 124,3
 DC.W 232
 DC.B 65,3
 DC.W 226
 DC.B 129,0
 DC.W 222
 DC.B 122,5
 DC.W 92
 DC.B 94,6
 DC.W 235
 DC.B 121,5
 DC.W 111
 DC.B 80,6
 DC.W 162
 DC.B 46,5
 DC.W 238
 DC.B 151,4
 DC.W 136
 DC.B 83,6
 DC.W 130
 DC.B 89,0
 DC.W 82
 DC.B 143,2
 DC.W 111
 DC.B 94,6
 DC.W 269
 DC.B 68,1
 DC.W 131
 DC.B 137,5
 DC.W 74
 DC.B 102,2
 DC.W 60
 DC.B 91,0
 DC.W 41
 DC.B 121,1
 DC.W 111
 DC.B 88,6
 DC.W 162
 DC.B 108,2
 DC.W 131
 DC.B 63,3
 DC.W 282
 DC.B 92,0
 DC.W 132
 DC.B 62,5
 DC.W 66
 DC.B 25,1
 DC.W 144
 DC.B 146,3
 DC.W 266
 DC.B 156,0
 DC.W 237
 DC.B 80,0
 DC.W 137
 DC.B 77,0
 DC.W 119
 DC.B 104,2
 DC.W 142
 DC.B 84,2
 DC.W 154
 DC.B 105,0
 DC.W 170
 DC.B 96,3
 DC.W 186
 DC.B 101,3
 DC.W 136
 DC.B 100,2
 DC.W 136
 DC.B 108,1
 DC.W 149
 DC.B 105,6
 DC.W 191
 DC.B 112,2
 DC.W 103
 DC.B 112,1
 DC.W 207
 DC.B 123,1
 DC.W 177
 DC.B 100,3
 DC.W 129
 DC.B 112,2
 DC.W 175
 DC.B 92,5
 DC.W 230
 DC.B 120,0
 DC.W 191
 DC.B 104,2
 DC.W 155
 DC.B 100,2
 DC.W 144
 DC.B 103,5
 DC.W 140
 DC.B 108,5
 DC.W 160
 DC.B 90,4
 DC.W 206
 DC.B 109,1
 DC.W 154
 DC.B 91,6
 DC.W 210
 DC.B 124,2
 DC.W 233
 DC.B 64,3
 DC.W 196
 DC.B 116,6
 DC.W 222
 DC.B 122,5
 DC.W 92
 DC.B 94,6
 DC.W 236
 DC.B 121,5
 DC.W 111
 DC.B 80,6
 DC.W 162
 DC.B 46,5
 DC.W 239
 DC.B 152,4
 DC.W 136
 DC.B 83,6
 DC.W 143
 DC.B 93,6
 DC.W 81
 DC.B 143,2
 DC.W 110
 DC.B 94,5
 DC.W 271
 DC.B 67,1
 DC.W 131
 DC.B 137,5
 DC.W 73
 DC.B 102,2
 DC.W 59
 DC.B 90,0
 DC.W 39
 DC.B 122,1
 DC.W 111
 DC.B 88,6
 DC.W 162
 DC.B 108,2
 DC.W 131
 DC.B 63,2
 DC.W 284
 DC.B 92,0
 DC.W 131
 DC.B 62,5
 DC.W 65
 DC.B 24,1
 DC.W 144
 DC.B 147,3
 DC.W 282
 DC.B 165,0
 DC.W 168
 DC.B 97,6
 DC.W 135
 DC.B 75,0
 DC.W 117
 DC.B 105,2
 DC.W 142
 DC.B 84,2
 DC.W 153
 DC.B 106,0
 DC.W 170
 DC.B 96,3
 DC.W 187
 DC.B 101,3
 DC.W 135
 DC.B 100,2
 DC.W 135
 DC.B 109,1
 DC.W 149
 DC.B 105,6
 DC.W 192
 DC.B 112,2
 DC.W 99
 DC.B 113,0
 DC.W 211
 DC.B 125,1
 DC.W 177
 DC.B 100,3
 DC.W 128
 DC.B 113,2
 DC.W 175
 DC.B 92,5
 DC.W 237
 DC.B 122,0
 DC.W 193
 DC.B 104,2
 DC.W 155
 DC.B 100,2
 DC.W 144
 DC.B 103,5
 DC.W 139
 DC.B 108,4
 DC.W 160
 DC.B 90,4
 DC.W 209
 DC.B 110,1
 DC.W 154
 DC.B 91,6
 DC.W 210
 DC.B 124,2
 DC.W 234
 DC.B 64,3
 DC.W 196
 DC.B 116,6
 DC.W 223
 DC.B 122,5
 DC.W 91
 DC.B 94,6
 DC.W 237
 DC.B 121,4
 DC.W 110
 DC.B 80,6
 DC.W 162
 DC.B 45,5
 DC.W 240
 DC.B 152,4
 DC.W 136
 DC.B 83,6
 DC.W 143
 DC.B 93,6
 DC.W 80
 DC.B 144,2
 DC.W 110
 DC.B 94,5
 DC.W 272
 DC.B 67,1
 DC.W 130
 DC.B 137,5
 DC.W 72
 DC.B 102,2
 DC.W 57
 DC.B 90,0
 DC.W 37
 DC.B 122,1
 DC.W 110
 DC.B 88,6
 DC.W 162
 DC.B 108,2
 DC.W 131
 DC.B 63,2
 DC.W 286
 DC.B 92,0
 DC.W 131
 DC.B 61,5
 DC.W 63
 DC.B 23,0
 DC.W 144
 DC.B 147,3
 DC.W 303
 DC.B 176,0
 DC.W 168
 DC.B 97,6
 DC.W 131
 DC.B 71,0
 DC.W 115
 DC.B 105,2
 DC.W 141
 DC.B 83,2
 DC.W 152
 DC.B 107,0
 DC.W 170
 DC.B 96,3
 DC.W 187
 DC.B 101,3
 DC.W 134
 DC.B 100,2
 DC.W 133
 DC.B 109,1
 DC.W 149
 DC.B 105,6
 DC.W 193
 DC.B 113,2
 DC.W 93
 DC.B 114,0
 DC.W 215
 DC.B 127,0
 DC.W 178
 DC.B 100,3
 DC.W 127
 DC.B 114,2
 DC.W 176
 DC.B 91,5
 DC.W 245
 DC.B 124,0
 DC.W 194
 DC.B 104,2
 DC.W 155
 DC.B 100,2
 DC.W 144
 DC.B 103,5
 DC.W 139
 DC.B 109,4
 DC.W 160
 DC.B 90,4
 DC.W 212
 DC.B 111,1
 DC.W 154
 DC.B 91,6
 DC.W 211
 DC.B 125,2
 DC.W 234
 DC.B 63,3
 DC.W 197
 DC.B 116,6
 DC.W 223
 DC.B 122,5
 DC.W 90
 DC.B 94,5
 DC.W 237
 DC.B 122,4
 DC.W 110
 DC.B 80,6
 DC.W 162
 DC.B 45,5
 DC.W 240
 DC.B 153,4
 DC.W 135
 DC.B 83,6
 DC.W 143
 DC.B 93,6
 DC.W 79
 DC.B 144,2
 DC.W 109
 DC.B 94,5
 DC.W 274
 DC.B 66,1
 DC.W 130
 DC.B 138,5
 DC.W 71
 DC.B 102,2
 DC.W 103
 DC.B 94,6
 DC.W 35
 DC.B 122,1
 DC.W 110
 DC.B 88,6
 DC.W 162
 DC.B 108,2
 DC.W 130
 DC.B 62,2
 DC.W 230
 DC.B 95,6
 DC.W 131
 DC.B 61,5
 DC.W 62
 DC.B 22,0
 DC.W 143
 DC.B 148,3
 DC.W 175
 DC.B 108,6
 DC.W 168
 DC.B 97,6
 DC.W 127
 DC.B 67,0
 DC.W 113
 DC.B 105,1
 DC.W 140
 DC.B 82,2
 DC.W 151
 DC.B 108,0
 DC.W 171
 DC.B 96,3
 DC.W 188
 DC.B 101,2
 DC.W 133
 DC.B 100,2
 DC.W 132
 DC.B 110,1
 DC.W 149
 DC.B 105,5
 DC.W 194
 DC.B 113,2
 DC.W 87
 DC.B 115,0
 DC.W 220
 DC.B 130,0
 DC.W 179
 DC.B 100,3
 DC.W 125
 DC.B 114,2
 DC.W 176
 DC.B 91,5
 DC.W 256
 DC.B 127,0
 DC.W 195
 DC.B 104,2
 DC.W 154
 DC.B 100,2
 DC.W 143
 DC.B 103,4
 DC.W 138
 DC.B 109,4
 DC.W 160
 DC.B 90,4
 DC.W 216
 DC.B 112,1
 DC.W 154
 DC.B 91,5
 DC.W 212
 DC.B 125,2
 DC.W 235
 DC.B 63,3
 DC.W 197
 DC.B 116,6
 DC.W 224
 DC.B 123,4
 DC.W 90
 DC.B 94,5
 DC.W 238
 DC.B 122,4
 DC.W 110
 DC.B 80,6
 DC.W 162
 DC.B 44,5
 DC.W 241
 DC.B 154,4
 DC.W 135
 DC.B 83,6
 DC.W 143
 DC.B 93,6
 DC.W 78
 DC.B 145,2
 DC.W 109
 DC.B 94,5
 DC.W 276
 DC.B 66,1
 DC.W 130
 DC.B 138,5
 DC.W 70
 DC.B 102,1
 DC.W 103
 DC.B 94,6
 DC.W 34
 DC.B 123,0
 DC.W 109
 DC.B 88,6
 DC.W 162
 DC.B 108,1
 DC.W 130
 DC.B 62,2
 DC.W 230
 DC.B 95,6
 DC.W 130
 DC.B 60,5
 DC.W 60
 DC.B 21,0
 DC.W 143
 DC.B 148,2
 DC.W 175
 DC.B 108,6
 DC.W 168
 DC.B 97,5
 DC.W 122
 DC.B 62,0
 DC.W 110
 DC.B 105,1
 DC.W 139
 DC.B 82,2
 DC.W 149
 DC.B 110,0
 DC.W 171
 DC.B 96,3
 DC.W 189
 DC.B 101,2
 DC.W 132
 DC.B 100,1
 DC.W 130
 DC.B 111,1
 DC.W 149
 DC.B 105,5
 DC.W 196
 DC.B 114,2
 DC.W 80
 DC.B 117,0
 DC.W 226
 DC.B 133,0
 DC.W 179
 DC.B 100,2
 DC.W 124
 DC.B 115,2
 DC.W 176
 DC.B 91,5
 DC.W 270
 DC.B 131,0
 DC.W 197
 DC.B 105,2
 DC.W 154
 DC.B 100,2
 DC.W 143
 DC.B 103,4
 DC.W 138
 DC.B 109,4
 DC.W 160
 DC.B 89,4
 DC.W 221
 DC.B 113,0
 DC.W 154
 DC.B 91,5
 DC.W 212
 DC.B 125,2
 DC.W 236
 DC.B 62,3
 DC.W 197
 DC.B 116,6
 DC.W 225
 DC.B 123,4
 DC.W 89
 DC.B 94,5
 DC.W 239
 DC.B 122,4
 DC.W 109
 DC.B 80,6
 DC.W 162
 DC.B 44,5
 DC.W 242
 DC.B 154,4
 DC.W 135
 DC.B 82,6
 DC.W 143
 DC.B 93,6
 DC.W 76
 DC.B 145,1
 DC.W 108
 DC.B 94,5
 DC.W 277
 DC.B 65,1
 DC.W 130
 DC.B 139,4
 DC.W 68
 DC.B 103,1
 DC.W 102
 DC.B 94,6
 DC.W 32
 DC.B 123,0
 DC.W 109
 DC.B 88,6
 DC.W 163
 DC.B 109,1
 DC.W 130
 DC.B 61,2
 DC.W 231
 DC.B 95,6
 DC.W 130
 DC.B 60,5
 DC.W 59
 DC.B 19,0
 DC.W 143
 DC.B 149,2
 DC.W 175
 DC.B 108,6
 DC.W 168
 DC.B 97,5
 DC.W 155
 DC.B 95,6
 DC.W 108
 DC.B 106,1
 DC.W 138
 DC.B 81,1
 DC.W 158
 DC.B 101,6
 DC.W 171
 DC.B 96,2
 DC.W 191
 DC.B 102,2
 DC.W 130
 DC.B 100,1
 DC.W 128
 DC.B 112,1
 DC.W 148
 DC.B 105,5
 DC.W 198
 DC.B 115,2
 DC.W 70
 DC.B 119,0
 DC.W 234
 DC.B 137,0
 DC.W 180
 DC.B 100,2
 DC.W 122
 DC.B 116,1
 DC.W 177
 DC.B 91,5
 DC.W 288
 DC.B 136,0
 DC.W 199
 DC.B 105,2
 DC.W 154
 DC.B 100,1
 DC.W 143
 DC.B 103,4
 DC.W 137
 DC.B 109,4
 DC.W 160
 DC.B 89,4
 DC.W 226
 DC.B 114,0
 DC.W 154
 DC.B 91,5
 DC.W 213
 DC.B 126,2
 DC.W 237
 DC.B 62,3
 DC.W 198
 DC.B 116,6
 DC.W 226
 DC.B 123,4
 DC.W 88
 DC.B 94,5
 DC.W 240
 DC.B 122,4
 DC.W 109
 DC.B 79,6
 DC.W 162
 DC.B 43,4
 DC.W 243
 DC.B 155,4
 DC.W 135
 DC.B 82,5
 DC.W 143
 DC.B 93,6
 DC.W 75
 DC.B 146,1
 DC.W 108
 DC.B 94,5
 DC.W 279
 DC.B 65,0
 DC.W 129
 DC.B 139,4
 DC.W 67
 DC.B 103,1
 DC.W 101
 DC.B 94,6
 DC.W 30
 DC.B 123,0
 DC.W 108
 DC.B 88,6
 DC.W 163
 DC.B 109,1
 DC.W 129
 DC.B 61,2
 DC.W 232
 DC.B 95,6
 DC.W 130
 DC.B 60,5
 DC.W 57
 DC.B 18,0
 DC.W 143
 DC.B 150,2
 DC.W 175
 DC.B 108,5
 DC.W 168
 DC.B 97,5
 DC.W 155
 DC.B 95,6
 DC.W 104
 DC.B 106,1
 DC.W 137
 DC.B 80,1
 DC.W 158
 DC.B 101,6
 DC.W 172
 DC.B 95,2
 DC.W 192
 DC.B 102,2
 DC.W 129
 DC.B 100,1
 DC.W 125
 DC.B 112,0
 DC.W 148
 DC.B 105,5
 DC.W 200
 DC.B 116,1
 DC.W 59
 DC.B 121,0
 DC.W 243
 DC.B 141,0
 DC.W 181
 DC.B 100,2
 DC.W 120
 DC.B 116,1
 DC.W 177
 DC.B 91,4
 DC.W 314
 DC.B 144,0
 DC.W 201
 DC.B 105,1
 DC.W 154
 DC.B 100,1
 DC.W 142
 DC.B 104,4
 DC.W 137
 DC.B 110,4
 DC.W 160
 DC.B 89,3
 DC.W 232
 DC.B 115,0
 DC.W 154
 DC.B 90,5
 DC.W 214
 DC.B 126,2
 DC.W 238
 DC.B 62,2
 DC.W 198
 DC.B 117,6
 DC.W 226
 DC.B 123,4
 DC.W 88
 DC.B 94,5
 DC.W 241
 DC.B 123,4
 DC.W 108
 DC.B 79,5
 DC.W 162
 DC.B 42,4
 DC.W 244
 DC.B 155,3
 DC.W 135
 DC.B 82,5
 DC.W 143
 DC.B 93,6
 DC.W 74
 DC.B 147,1
 DC.W 107
 DC.B 94,5
 DC.W 281
 DC.B 64,0
 DC.W 129
 DC.B 140,4
 DC.W 66
 DC.B 103,1
 DC.W 101
 DC.B 94,6
 DC.W 28
 DC.B 124,0
 DC.W 108
 DC.B 88,5
 DC.W 163
 DC.B 109,1
 DC.W 129
 DC.B 60,2
 DC.W 232
 DC.B 95,6
 DC.W 130
 DC.B 59,4
 DC.W 55
 DC.B 17,0
 DC.W 143
 DC.B 150,2
 DC.W 176
 DC.B 108,5
 DC.W 169
 DC.B 97,5
 DC.W 155
 DC.B 95,6
 DC.W 101
 DC.B 106,1
 DC.W 136
 DC.B 79,1
 DC.W 158
 DC.B 101,6
 DC.W 172
 DC.B 95,2
 DC.W 193
 DC.B 102,2
 DC.W 127
 DC.B 100,1
 DC.W 122
 DC.B 114,0
 DC.W 148
 DC.B 105,5
 DC.W 202
 DC.B 116,1
 DC.W 44
 DC.B 124,0
 DC.W 255
 DC.B 147,0
 DC.W 182
 DC.B 100,2
 DC.W 118
 DC.B 117,1
 DC.W 178
 DC.B 90,4
 DC.W 174
 DC.B 104,6
 DC.W 203
 DC.B 105,1
 DC.W 153
 DC.B 100,1
 DC.W 142
 DC.B 104,4
 DC.W 136
 DC.B 110,4
 DC.W 160
 DC.B 89,3
 DC.W 240
 DC.B 117,0
 DC.W 154
 DC.B 90,5
 DC.W 215
 DC.B 126,1
 DC.W 239
 DC.B 61,2
 DC.W 198
 DC.B 117,5
 DC.W 227
 DC.B 124,4
 DC.W 87
 DC.B 94,5
 DC.W 242
 DC.B 123,4
 DC.W 108
 DC.B 79,5
 DC.W 162
 DC.B 42,4
 DC.W 245
 DC.B 156,3
 DC.W 134
 DC.B 82,5
 DC.W 142
 DC.B 93,5
 DC.W 73
 DC.B 147,1
 DC.W 106
 DC.B 94,4
 DC.W 283
 DC.B 64,0
 DC.W 129
 DC.B 140,4
 DC.W 65
 DC.B 103,1
 DC.W 100
 DC.B 94,6
 DC.W 26
 DC.B 124,0
 DC.W 107
 DC.B 88,5
 DC.W 163
 DC.B 109,1
 DC.W 128
 DC.B 60,2
 DC.W 233
 DC.B 95,6
 DC.W 129
 DC.B 59,4
 DC.W 54
 DC.B 15,0
 DC.W 142
 DC.B 151,2
 DC.W 176
 DC.B 108,5
 DC.W 169
 DC.B 97,5
 DC.W 155
 DC.B 95,5
 DC.W 97
 DC.B 107,1
 DC.W 134
 DC.B 78,1
 DC.W 158
 DC.B 101,5
 DC.W 173
 DC.B 95,2
 DC.W 195
 DC.B 102,2
 DC.W 125
 DC.B 100,1
 DC.W 119
 DC.B 115,0
 DC.W 148
 DC.B 105,5
 DC.W 204
 DC.B 117,1
 DC.W 23
 DC.B 129,0
 DC.W 271
 DC.B 155,0
 DC.W 183
 DC.B 100,2
 DC.W 116
 DC.B 118,1
 DC.W 178
 DC.B 90,4
 DC.W 174
 DC.B 104,6
 DC.W 205
 DC.B 106,1
 DC.W 153
 DC.B 100,1
 DC.W 141
 DC.B 104,4
 DC.W 135
 DC.B 110,3
 DC.W 160
 DC.B 88,3
 DC.W 249
 DC.B 119,0
 DC.W 154
 DC.B 90,5
 DC.W 215
 DC.B 127,1
 DC.W 240
 DC.B 61,2
 DC.W 199
 DC.B 117,5
 DC.W 228
 DC.B 124,4
 DC.W 86
 DC.B 94,5
 DC.W 243
 DC.B 123,4
 DC.W 107
 DC.B 79,5
 DC.W 162
 DC.B 41,4
 DC.W 246
 DC.B 157,3
 DC.W 134
 DC.B 82,5
 DC.W 142
 DC.B 93,5
 DC.W 72
 DC.B 148,1
 DC.W 106
 DC.B 94,4
 DC.W 285
 DC.B 63,0
 DC.W 128
 DC.B 140,4
 DC.W 63
 DC.B 103,1
 DC.W 100
 DC.B 94,6
 DC.W 23
 DC.B 125,0
 DC.W 107
 DC.B 87,5
 DC.W 163
 DC.B 109,1
 DC.W 128
 DC.B 59,1
 DC.W 234
 DC.B 95,6
 DC.W 129
 DC.B 58,4
 DC.W 101
 DC.B 53,6
 DC.W 142
 DC.B 151,2
 DC.W 176
 DC.B 109,5
 DC.W 169
 DC.B 97,5
 DC.W 155
 DC.B 95,5
 DC.W 93
 DC.B 107,1
 DC.W 133
 DC.B 76,1
 DC.W 158
 DC.B 101,5
 DC.W 173
 DC.B 95,2
 DC.W 196
 DC.B 102,2
 DC.W 122
 DC.B 100,1
 DC.W 114
 DC.B 116,0
 DC.W 148
 DC.B 105,5
 DC.W 206
 DC.B 118,1
 DC.W 145
 DC.B 103,6
 DC.W 172
 DC.B 106,6
 DC.W 184
 DC.B 100,2
 DC.W 113
 DC.B 119,1
 DC.W 179
 DC.B 90,4
 DC.W 174
 DC.B 104,5
 DC.W 208
 DC.B 106,1
 DC.W 153
 DC.B 100,1
 DC.W 141
 DC.B 104,4
 DC.W 135
 DC.B 110,3
 DC.W 160
 DC.B 88,3
 DC.W 261
 DC.B 121,0
 DC.W 153
 DC.B 90,5
 DC.W 216
 DC.B 127,1
 DC.W 241
 DC.B 60,2
 DC.W 199
 DC.B 117,5
 DC.W 228
 DC.B 124,4
 DC.W 85
 DC.B 94,4
 DC.W 244
 DC.B 123,3
 DC.W 107
 DC.B 79,5
 DC.W 162
 DC.B 41,4
 DC.W 247
 DC.B 157,3
 DC.W 134
 DC.B 82,5
 DC.W 142
 DC.B 93,5
 DC.W 70
 DC.B 149,1
 DC.W 105
 DC.B 94,4
 DC.W 287
 DC.B 62,0
 DC.W 128
 DC.B 141,4
 DC.W 62
 DC.B 103,1
 DC.W 99
 DC.B 94,5
 DC.W 21
 DC.B 125,0
 DC.W 106
 DC.B 87,5
 DC.W 163
 DC.B 109,1
 DC.W 128
 DC.B 58,1
 DC.W 234
 DC.B 95,5
 DC.W 129
 DC.B 58,4
 DC.W 101
 DC.B 53,6
 DC.W 142
 DC.B 152,2
 DC.W 177
 DC.B 109,5
 DC.W 169
 DC.B 97,5
 DC.W 155
 DC.B 95,5
 DC.W 88
 DC.B 108,1
 DC.W 131
 DC.B 75,1
 DC.W 158
 DC.B 101,5
 DC.W 174
 DC.B 95,2
 DC.W 198
 DC.B 102,2
 DC.W 120
 DC.B 100,1
 DC.W 109
 DC.B 118,0
 DC.W 147
 DC.B 106,5
 DC.W 209
 DC.B 119,1
 DC.W 145
 DC.B 103,6
 DC.W 172
 DC.B 106,6
 DC.W 185
 DC.B 100,2
 DC.W 110
 DC.B 121,1
 DC.W 179
 DC.B 90,4
 DC.W 175
 DC.B 104,5
 DC.W 211
 DC.B 106,1
 DC.W 152
 DC.B 100,1
 DC.W 140
 DC.B 104,4
 DC.W 134
 DC.B 111,3
 DC.W 160
 DC.B 88,3
 DC.W 276
 DC.B 125,0
 DC.W 153
 DC.B 90,4
 DC.W 217
 DC.B 127,1
 DC.W 242
 DC.B 60,2
 DC.W 200
 DC.B 117,5
 DC.W 229
 DC.B 124,3
 DC.W 85
 DC.B 94,4
 DC.W 245
 DC.B 124,3
 DC.W 106
 DC.B 78,5
 DC.W 162
 DC.B 40,4
 DC.W 248
 DC.B 158,3
 DC.W 133
 DC.B 81,5
 DC.W 142
 DC.B 93,5
 DC.W 69
 DC.B 150,1
 DC.W 105
 DC.B 94,4
 DC.W 289
 DC.B 62,0
 DC.W 128
 DC.B 141,4
 DC.W 60
 DC.B 103,0
 DC.W 99
 DC.B 94,5
 DC.W 83
 DC.B 114,6
 DC.W 106
 DC.B 87,5
 DC.W 163
 DC.B 109,0
 DC.W 127
 DC.B 58,1
 DC.W 235
 DC.B 95,5
 DC.W 128
 DC.B 57,4
 DC.W 100
 DC.B 52,6
 DC.W 142
 DC.B 153,1
 DC.W 177
 DC.B 109,5
 DC.W 169
 DC.B 97,5
 DC.W 155
 DC.B 95,5
 DC.W 82
 DC.B 109,0
 DC.W 129
 DC.B 73,1
 DC.W 158
 DC.B 101,5
 DC.W 175
 DC.B 94,2
 DC.W 200
 DC.B 102,1
 DC.W 117
 DC.B 100,0
 DC.W 103
 DC.B 121,0
 DC.W 147
 DC.B 106,4
 DC.W 212
 DC.B 121,1
 DC.W 145
 DC.B 103,6
 DC.W 172
 DC.B 106,6
 DC.W 186
 DC.B 100,1
 DC.W 107
 DC.B 122,1
 DC.W 180
 DC.B 89,4
 DC.W 175
 DC.B 104,5
 DC.W 215
 DC.B 107,1
 DC.W 152
 DC.B 100,1
 DC.W 140
 DC.B 104,3
 DC.W 133
 DC.B 111,3
 DC.W 160
 DC.B 87,3
 DC.W 297
 DC.B 129,0
 DC.W 153
 DC.B 89,4
 DC.W 218
 DC.B 128,1
 DC.W 243
 DC.B 59,2
 DC.W 200
 DC.B 117,5
 DC.W 230
 DC.B 125,3
 DC.W 84
 DC.B 94,4
 DC.W 246
 DC.B 124,3
 DC.W 105
 DC.B 78,5
 DC.W 162
 DC.B 39,4
 DC.W 249
 DC.B 159,3
 DC.W 133
 DC.B 81,5
 DC.W 142
 DC.B 93,5
 DC.W 68
 DC.B 150,1
 DC.W 104
 DC.B 93,4
 DC.W 291
 DC.B 61,0
 DC.W 127
 DC.B 142,3
 DC.W 59
 DC.B 103,0
 DC.W 98
 DC.B 94,5
 DC.W 82
 DC.B 114,6
 DC.W 105
 DC.B 87,5
 DC.W 163
 DC.B 110,0
 DC.W 127
 DC.B 57,1
 DC.W 236
 DC.B 95,5
 DC.W 128
 DC.B 57,4
 DC.W 99
 DC.B 52,6
 DC.W 141
 DC.B 154,1
 DC.W 178
 DC.B 109,5
 DC.W 170
 DC.B 97,4
 DC.W 155
 DC.B 95,5
 DC.W 74
 DC.B 110,0
 DC.W 127
 DC.B 71,1
 DC.W 158
 DC.B 101,5
 DC.W 175
 DC.B 94,2
 DC.W 202
 DC.B 102,1
 DC.W 113
 DC.B 100,0
 DC.W 94
 DC.B 124,0
 DC.W 147
 DC.B 106,4
 DC.W 216
 DC.B 122,1
 DC.W 145
 DC.B 103,5
 DC.W 172
 DC.B 106,5
 DC.W 187
 DC.B 100,1
 DC.W 103
 DC.B 124,1
 DC.W 180
 DC.B 89,4
 DC.W 175
 DC.B 104,5
 DC.W 218
 DC.B 107,1
 DC.W 151
 DC.B 100,1
 DC.W 139
 DC.B 104,3
 DC.W 132
 DC.B 111,3
 DC.W 160
 DC.B 87,3
 DC.W 174
 DC.B 103,6
 DC.W 153
 DC.B 89,4
 DC.W 218
 DC.B 128,1
 DC.W 244
 DC.B 58,2
 DC.W 200
 DC.B 118,5
 DC.W 231
 DC.B 125,3
 DC.W 83
 DC.B 94,4
 DC.W 247
 DC.B 124,3
 DC.W 105
 DC.B 78,5
 DC.W 162
 DC.B 39,3
 DC.W 250
 DC.B 160,3
 DC.W 133
 DC.B 81,4
 DC.W 141
 DC.B 93,5
 DC.W 66
 DC.B 151,0
 DC.W 104
 DC.B 93,4
 DC.W 232
 DC.B 78,6
 DC.W 127
 DC.B 142,3
 DC.W 57
 DC.B 103,0
 DC.W 97
 DC.B 94,5
 DC.W 82
 DC.B 114,6
 DC.W 105
 DC.B 87,5
 DC.W 163
 DC.B 110,0
 DC.W 126
 DC.B 57,1
 DC.W 237
 DC.B 95,5
 DC.W 128
 DC.B 56,4
 DC.W 99
 DC.B 51,6
 DC.W 141
 DC.B 154,1
 DC.W 178
 DC.B 109,5
 DC.W 170
 DC.B 97,4
 DC.W 155
 DC.B 95,5
 DC.W 66
 DC.B 111,0
 DC.W 124
 DC.B 69,0
 DC.W 158
 DC.B 101,5
 DC.W 176
 DC.B 94,1
 DC.W 204
 DC.B 102,1
 DC.W 109
 DC.B 100,0
 DC.W 83
 DC.B 128,0
 DC.W 146
 DC.B 106,4
 DC.W 220
 DC.B 124,1
 DC.W 144
 DC.B 103,5
 DC.W 172
 DC.B 106,5
 DC.W 189
 DC.B 100,1
 DC.W 98
 DC.B 126,0
 DC.W 181
 DC.B 89,3
 DC.W 176
 DC.B 104,5
 DC.W 223
 DC.B 108,1
 DC.W 150
 DC.B 100,0
 DC.W 139
 DC.B 104,3
 DC.W 131
 DC.B 112,3
 DC.W 160
 DC.B 86,3
 DC.W 174
 DC.B 103,6
 DC.W 153
 DC.B 89,4
 DC.W 219
 DC.B 129,1
 DC.W 246
 DC.B 58,1
 DC.W 201
 DC.B 118,5
 DC.W 232
 DC.B 125,3
 DC.W 82
 DC.B 93,4
 DC.W 248
 DC.B 125,3
 DC.W 104
 DC.B 78,4
 DC.W 162
 DC.B 38,3
 DC.W 251
 DC.B 160,2
 DC.W 133
 DC.B 81,4
 DC.W 141
 DC.B 93,5
 DC.W 65
 DC.B 152,0
 DC.W 103
 DC.B 93,4
 DC.W 233
 DC.B 78,6
 DC.W 126
 DC.B 143,3
 DC.W 56
 DC.B 103,0
 DC.W 97
 DC.B 94,5
 DC.W 81
 DC.B 114,6
 DC.W 104
 DC.B 87,4
 DC.W 163
 DC.B 110,0
 DC.W 126
 DC.B 56,1
 DC.W 237
 DC.B 95,5
 DC.W 127
 DC.B 56,3
 DC.W 98
 DC.B 51,6
 DC.W 141
 DC.B 155,1
 DC.W 178
 DC.B 110,4
 DC.W 170
 DC.B 97,4
 DC.W 155
 DC.B 95,5
 DC.W 56
 DC.B 112,0
 DC.W 121
 DC.B 66,0
 DC.W 158
 DC.B 101,5
 DC.W 177
 DC.B 94,1
 DC.W 207
 DC.B 103,1
 DC.W 103
 DC.B 100,0
 DC.W 151
 DC.B 103,6
 DC.W 146
 DC.B 106,4
 DC.W 225
 DC.B 126,0
 DC.W 144
 DC.B 103,5
 DC.W 173
 DC.B 106,5
 DC.W 191
 DC.B 100,1
 DC.W 93
 DC.B 128,0
 DC.W 181
 DC.B 89,3
 DC.W 176
 DC.B 104,5
 DC.W 228
 DC.B 109,0
 DC.W 149
 DC.B 100,0
 DC.W 138
 DC.B 104,3
 DC.W 131
 DC.B 112,3
 DC.W 160
 DC.B 86,2
 DC.W 174
 DC.B 103,6
 DC.W 153
 DC.B 89,4
 DC.W 220
 DC.B 129,0
 DC.W 247
 DC.B 57,1
 DC.W 201
 DC.B 118,4
 DC.W 233
 DC.B 126,3
 DC.W 81
 DC.B 93,4
 DC.W 249
 DC.B 125,3
 DC.W 104
 DC.B 77,4
 DC.W 162
 DC.B 37,3
 DC.W 253
 DC.B 161,2
 DC.W 132
 DC.B 81,4
 DC.W 141
 DC.B 93,4
 DC.W 64
 DC.B 153,0
 DC.W 102
 DC.B 93,3
 DC.W 233
 DC.B 78,6
 DC.W 126
 DC.B 143,3
 DC.W 54
 DC.B 103,0
 DC.W 96
 DC.B 94,5
 DC.W 80
 DC.B 114,6
 DC.W 104
 DC.B 87,4
 DC.W 163
 DC.B 110,0
 DC.W 125
 DC.B 55,1
 DC.W 238
 DC.B 95,5
 DC.W 127
 DC.B 55,3
 DC.W 98
 DC.B 50,6
 DC.W 141
 DC.B 156,1
 DC.W 179
 DC.B 110,4
 DC.W 170
 DC.B 97,4
 DC.W 155
 DC.B 95,5
 DC.W 43
 DC.B 113,0
 DC.W 118
 DC.B 63,0
 DC.W 158
 DC.B 101,5
 DC.W 178
 DC.B 93,1
 DC.W 209
 DC.B 103,1
 DC.W 97
 DC.B 100,0
 DC.W 151
 DC.B 103,6
 DC.W 146
 DC.B 106,4
 DC.W 231
 DC.B 128,0
 DC.W 144
 DC.B 103,5
 DC.W 173
 DC.B 106,5
 DC.W 192
 DC.B 100,1
 DC.W 87
 DC.B 131,0
 DC.W 182
 DC.B 88,3
 DC.W 176
 DC.B 104,5
 DC.W 235
 DC.B 110,0
 DC.W 148
 DC.B 100,0
 DC.W 137
 DC.B 105,3
 DC.W 130
 DC.B 113,3
 DC.W 160
 DC.B 85,2
 DC.W 174
 DC.B 103,5
 DC.W 152
 DC.B 88,4
 DC.W 221
 DC.B 130,0
 DC.W 248
 DC.B 57,1
 DC.W 202
 DC.B 118,4
 DC.W 233
 DC.B 126,3
 DC.W 80
 DC.B 93,4
 DC.W 250
 DC.B 125,3
 DC.W 103
 DC.B 77,4
 DC.W 162
 DC.B 36,3
 DC.W 254
 DC.B 162,2
 DC.W 132
 DC.B 80,4
 DC.W 141
 DC.B 93,4
 DC.W 62
 DC.B 153,0
 DC.W 102
 DC.B 93,3
 DC.W 234
 DC.B 78,6
 DC.W 126
 DC.B 144,3
 DC.W 52
 DC.B 103,0
 DC.W 95
 DC.B 94,5
 DC.W 79
 DC.B 114,6
 DC.W 103
 DC.B 87,4
 DC.W 163
 DC.B 110,0
 DC.W 125
 DC.B 55,0
 DC.W 239
 DC.B 95,5
 DC.W 126
 DC.B 55,3
 DC.W 97
 DC.B 50,5
 DC.W 140
 DC.B 157,1
 DC.W 179
 DC.B 110,4
 DC.W 171
 DC.B 97,4
 DC.W 154
 DC.B 94,4
 DC.W 26
 DC.B 115,0
 DC.W 113
 DC.B 59,0
 DC.W 158
 DC.B 101,4
 DC.W 179
 DC.B 93,1
 DC.W 213
 DC.B 103,1
 DC.W 89
 DC.B 100,0
 DC.W 151
 DC.B 103,6
 DC.W 145
 DC.B 107,4
 DC.W 237
 DC.B 131,0
 DC.W 143
 DC.B 103,5
 DC.W 173
 DC.B 106,5
 DC.W 195
 DC.B 100,1
 DC.W 79
 DC.B 134,0
 DC.W 183
 DC.B 88,3
 DC.W 177
 DC.B 104,5
 DC.W 242
 DC.B 111,0
 DC.W 147
 DC.B 100,0
 DC.W 137
 DC.B 105,3
 DC.W 129
 DC.B 113,2
 DC.W 160
 DC.B 85,2
 DC.W 175
 DC.B 103,5
 DC.W 152
 DC.B 88,4
 DC.W 222
 DC.B 130,0
 DC.W 249
 DC.B 56,1
 DC.W 202
 DC.B 118,4
 DC.W 234
 DC.B 126,3
 DC.W 79
 DC.B 93,3
 DC.W 251
 DC.B 125,2
 DC.W 103
 DC.B 77,4
 DC.W 162
 DC.B 36,3
 DC.W 255
 DC.B 163,2
 DC.W 132
 DC.B 80,4
 DC.W 141
 DC.B 92,4
 DC.W 60
 DC.B 154,0
 DC.W 101
 DC.B 93,3
 DC.W 235
 DC.B 78,6
 DC.W 125
 DC.B 144,3
 DC.W 50
 DC.B 103,0
 DC.W 95
 DC.B 94,4
 DC.W 79
 DC.B 114,6
 DC.W 102
 DC.B 86,4
 DC.W 163
 DC.B 110,0
 DC.W 124
 DC.B 54,0
 DC.W 240
 DC.B 95,5
 DC.W 126
 DC.B 54,3
 DC.W 96
 DC.B 50,5
 DC.W 140
 DC.B 158,1
 DC.W 180
 DC.B 110,4
 DC.W 171
 DC.B 97,4
 DC.W 154
 DC.B 94,4
 DC.W 4
 DC.B 118,0
 DC.W 108
 DC.B 54,0
 DC.W 158
 DC.B 101,4
 DC.W 180
 DC.B 93,1
 DC.W 216
 DC.B 103,1
 DC.W 79
 DC.B 100,0
 DC.W 151
 DC.B 103,5
 DC.W 145
 DC.B 107,4
 DC.W 245
 DC.B 134,0
 DC.W 143
 DC.B 103,5
 DC.W 174
 DC.B 107,5
 DC.W 197
 DC.B 100,1
 DC.W 69
 DC.B 138,0
 DC.W 183
 DC.B 88,3
 DC.W 177
 DC.B 105,4
 DC.W 251
 DC.B 112,0
 DC.W 146
 DC.B 100,0
 DC.W 136
 DC.B 105,3
 DC.W 127
 DC.B 114,2
 DC.W 160
 DC.B 84,2
 DC.W 175
 DC.B 103,5
 DC.W 152
 DC.B 88,4
 DC.W 223
 DC.B 130,0
 DC.W 251
 DC.B 56,1
 DC.W 203
 DC.B 119,4
 DC.W 235
 DC.B 127,2
 DC.W 79
 DC.B 93,3
 DC.W 252
 DC.B 126,2
 DC.W 102
 DC.B 77,4
 DC.W 162
 DC.B 35,3
 DC.W 256
 DC.B 163,2
 DC.W 131
 DC.B 80,4
 DC.W 140
 DC.B 92,4
 DC.W 59
 DC.B 155,0
 DC.W 100
 DC.B 93,3
 DC.W 236
 DC.B 77,6
 DC.W 125
 DC.B 145,3
 DC.W 99
 DC.B 102,6
 DC.W 94
 DC.B 94,4
 DC.W 78
 DC.B 115,5
 DC.W 102
 DC.B 86,4
 DC.W 162
 DC.B 106,6
 DC.W 124
 DC.B 53,0
 DC.W 241
 DC.B 95,4
 DC.W 126
 DC.B 54,3
 DC.W 96
 DC.B 49,5
 DC.W 140
 DC.B 158,1
 DC.W 180
 DC.B 111,4
 DC.W 171
 DC.B 97,4
 DC.W 154
 DC.B 94,4
 DC.W 0
 DC.B 122,0
 DC.W 101
 DC.B 49,0
 DC.W 158
 DC.B 101,4
 DC.W 182
 DC.B 92,1
 DC.W 220
 DC.B 104,1
 DC.W 65
 DC.B 100,0
 DC.W 151
 DC.B 103,5
 DC.W 145
 DC.B 107,4
 DC.W 255
 DC.B 138,0
 DC.W 143
 DC.B 103,5
 DC.W 174
 DC.B 107,5
 DC.W 200
 DC.B 100,1
 DC.W 58
 DC.B 143,0
 DC.W 184
 DC.B 87,3
 DC.W 177
 DC.B 105,4
 DC.W 263
 DC.B 113,0
 DC.W 144
 DC.B 100,0
 DC.W 135
 DC.B 105,3
 DC.W 126
 DC.B 114,2
 DC.W 160
 DC.B 84,2
 DC.W 175
 DC.B 103,5
 DC.W 152
 DC.B 87,3
 DC.W 224
 DC.B 131,0
 DC.W 252
 DC.B 55,1
 DC.W 203
 DC.B 119,4
 DC.W 236
 DC.B 127,2
 DC.W 78
 DC.B 93,3
 DC.W 253
 DC.B 126,2
 DC.W 101
 DC.B 76,4
 DC.W 162
 DC.B 34,3
 DC.W 257
 DC.B 164,2
 DC.W 131
 DC.B 80,4
 DC.W 140
 DC.B 92,4
 DC.W 57
 DC.B 156,0
 DC.W 100
 DC.B 93,3
 DC.W 236
 DC.B 77,6
 DC.W 124
 DC.B 145,3
 DC.W 99
 DC.B 102,6
 DC.W 93
 DC.B 94,4
 DC.W 77
 DC.B 115,5
 DC.W 101
 DC.B 86,4
 DC.W 162
 DC.B 106,6
 DC.W 123
 DC.B 53,0
 DC.W 242
 DC.B 95,4
 DC.W 125
 DC.B 53,3
 DC.W 95
 DC.B 48,5
 DC.W 140
 DC.B 159,0
 DC.W 181
 DC.B 111,4
 DC.W 172
 DC.B 96,4
 DC.W 154
 DC.B 94,4
 DC.W 142
 DC.B 102,6
 DC.W 92
 DC.B 41,0
 DC.W 158
 DC.B 101,4
 DC.W 183
 DC.B 92,1
 DC.W 225
 DC.B 104,0
 DC.W 149
 DC.B 100,6
 DC.W 151
 DC.B 103,5
 DC.W 144
 DC.B 107,3
 DC.W 268
 DC.B 143,0
 DC.W 142
 DC.B 103,5
 DC.W 174
 DC.B 107,5
 DC.W 203
 DC.B 100,0
 DC.W 42
 DC.B 150,0
 DC.W 185
 DC.B 87,3
 DC.W 178
 DC.B 105,4
 DC.W 277
 DC.B 115,0
 DC.W 141
 DC.B 100,0
 DC.W 134
 DC.B 105,2
 DC.W 125
 DC.B 115,2
 DC.W 160
 DC.B 83,2
 DC.W 176
 DC.B 103,5
 DC.W 152
 DC.B 87,3
 DC.W 225
 DC.B 131,0
 DC.W 253
 DC.B 54,1
 DC.W 204
 DC.B 119,4
 DC.W 237
 DC.B 127,2
 DC.W 77
 DC.B 93,3
 DC.W 254
 DC.B 126,2
 DC.W 101
 DC.B 76,4
 DC.W 162
 DC.B 33,2
 DC.W 259
 DC.B 165,2
 DC.W 131
 DC.B 80,3
 DC.W 140
 DC.B 92,4
 DC.W 103
 DC.B 131,6
 DC.W 99
 DC.B 93,3
 DC.W 237
 DC.B 77,5
 DC.W 124
 DC.B 146,2
 DC.W 98
 DC.B 102,6
 DC.W 93
 DC.B 94,4
 DC.W 76
 DC.B 115,5
 DC.W 100
 DC.B 86,4
 DC.W 162
 DC.B 106,6
 DC.W 122
 DC.B 52,0
 DC.W 242
 DC.B 95,4
 DC.W 125
 DC.B 53,3
 DC.W 95
 DC.B 48,5
 DC.W 139
 DC.B 160,0
 DC.W 181
 DC.B 111,4
 DC.W 172
 DC.B 96,3
 DC.W 154
 DC.B 94,4
 DC.W 142
 DC.B 102,6
 DC.W 80
 DC.B 30,0
 DC.W 158
 DC.B 101,4
 DC.W 185
 DC.B 91,0
 DC.W 231
 DC.B 104,0
 DC.W 149
 DC.B 100,6
 DC.W 150
 DC.B 103,5
 DC.W 144
 DC.B 107,3
 DC.W 285
 DC.B 150,0
 DC.W 142
 DC.B 103,4
 DC.W 175
 DC.B 107,4
 DC.W 207
 DC.B 100,0
 DC.W 21
 DC.B 159,0
 DC.W 186
 DC.B 86,3
 DC.W 178
 DC.B 105,4
 DC.W 297
 DC.B 118,0
 DC.W 157
 DC.B 100,6
 DC.W 133
 DC.B 106,2
 DC.W 123
 DC.B 115,2
 DC.W 160
 DC.B 82,2
 DC.W 176
 DC.B 103,5
 DC.W 151
 DC.B 87,3
 DC.W 226
 DC.B 132,0
 DC.W 255
 DC.B 54,0
 DC.W 204
 DC.B 119,4
 DC.W 238
 DC.B 128,2
 DC.W 76
 DC.B 93,3
 DC.W 256
 DC.B 127,2
 DC.W 100
 DC.B 76,4
 DC.W 162
 DC.B 32,2
 DC.W 260
 DC.B 166,2
 DC.W 130
 DC.B 79,3
 DC.W 140
 DC.B 92,4
 DC.W 103
 DC.B 131,6
 DC.W 98
 DC.B 93,3
 DC.W 238
 DC.B 77,5
 DC.W 124
 DC.B 147,2
 DC.W 98
 DC.B 102,6
 DC.W 92
 DC.B 93,4
 DC.W 75
 DC.B 115,5
 DC.W 100
 DC.B 86,3
 DC.W 162
 DC.B 106,6
 DC.W 122
 DC.B 51,0
 DC.W 243
 DC.B 95,4
 DC.W 124
 DC.B 52,2
 DC.W 94
 DC.B 47,5
 DC.W 139
 DC.B 161,0
 DC.W 182
 DC.B 111,4
 DC.W 172
 DC.B 96,3
 DC.W 154
 DC.B 94,4
 DC.W 142
 DC.B 102,5
 DC.W 151
 DC.B 92,6
 DC.W 158
 DC.B 101,4
 DC.W 187
 DC.B 90,0
 DC.W 238
 DC.B 105,0
 DC.W 149
 DC.B 100,6
 DC.W 150
 DC.B 103,5
 DC.W 143
 DC.B 108,3
 DC.W 307
 DC.B 158,0
 DC.W 141
 DC.B 103,4
 DC.W 175
 DC.B 107,4
 DC.W 211
 DC.B 100,0
 DC.W 145
 DC.B 106,6
 DC.W 187
 DC.B 86,2
 DC.W 179
 DC.B 105,4
 DC.W 0
 DC.B 122,0
 DC.W 157
 DC.B 100,6
 DC.W 132
 DC.B 106,2
 DC.W 122
 DC.B 116,2
 DC.W 160
 DC.B 81,2
 DC.W 176
 DC.B 103,5
 DC.W 151
 DC.B 86,3
 DC.W 227
 DC.B 133,0
 DC.W 256
 DC.B 53,0
 DC.W 205
 DC.B 120,3
 DC.W 239
 DC.B 128,2
 DC.W 75
 DC.B 93,3
 DC.W 257
 DC.B 127,2
 DC.W 99
 DC.B 76,3
 DC.W 162
 DC.B 32,2
 DC.W 261
 DC.B 167,1
 DC.W 130
 DC.B 79,3
 DC.W 140
 DC.B 92,4
 DC.W 102
 DC.B 131,6
 DC.W 97
 DC.B 93,2
 DC.W 239
 DC.B 76,5
 DC.W 123
 DC.B 147,2
 DC.W 97
 DC.B 102,6
 DC.W 91
 DC.B 93,4
 DC.W 75
 DC.B 115,5
 DC.W 99
 DC.B 86,3
 DC.W 162
 DC.B 106,6
 DC.W 121
 DC.B 50,0
 DC.W 244
 DC.B 95,4
 DC.W 124
 DC.B 52,2
 DC.W 93
 DC.B 47,5
 DC.W 139
 DC.B 162,0
 DC.W 183
 DC.B 112,3
 DC.W 173
 DC.B 96,3
 DC.W 154
 DC.B 94,4
 DC.W 141
 DC.B 102,5
 DC.W 151
 DC.B 92,6
 DC.W 158
 DC.B 101,4
 DC.W 190
 DC.B 89,0
 DC.W 246
 DC.B 105,0
 DC.W 149
 DC.B 100,5
 DC.W 150
 DC.B 103,5
 DC.W 143
 DC.B 108,3
 DC.W 175
 DC.B 106,6
 DC.W 141
 DC.B 103,4
 DC.W 175
 DC.B 107,4
 DC.W 216
 DC.B 100,0
 DC.W 145
 DC.B 106,6
 DC.W 188
 DC.B 85,2
 DC.W 179
 DC.B 105,4
 DC.W 175
 DC.B 102,6
 DC.W 157
 DC.B 100,6
 DC.W 131
 DC.B 106,2
 DC.W 120
 DC.B 117,2
 DC.W 160
 DC.B 80,1
 DC.W 177
 DC.B 103,5
 DC.W 151
 DC.B 86,3
 DC.W 197
 DC.B 118,6
 DC.W 258
 DC.B 52,0
 DC.W 205
 DC.B 120,3
 DC.W 240
 DC.B 128,2
 DC.W 74
 DC.B 93,3
 DC.W 258
 DC.B 128,2
 DC.W 99
 DC.B 75,3
 DC.W 162
 DC.B 31,2
 DC.W 263
 DC.B 168,1
 DC.W 130
 DC.B 79,3
 DC.W 139
 DC.B 92,3
 DC.W 101
 DC.B 132,6
 DC.W 97
 DC.B 93,2
 DC.W 239
 DC.B 76,5
 DC.W 123
 DC.B 148,2
 DC.W 96
 DC.B 102,6
 DC.W 90
 DC.B 93,4
 DC.W 74
 DC.B 115,5
 DC.W 98
 DC.B 85,3
 DC.W 162
 DC.B 106,6
 DC.W 138
 DC.B 72,6
 DC.W 245
 DC.B 95,4
 DC.W 123
 DC.B 51,2
 DC.W 92
 DC.B 46,4
 DC.W 138
 DC.B 163,0
 DC.W 183
 DC.B 112,3
 DC.W 173
 DC.B 96,3
 DC.W 154
 DC.B 94,4
 DC.W 141
 DC.B 102,5
 DC.W 151
 DC.B 92,6
 DC.W 158
 DC.B 101,3
 DC.W 193
 DC.B 88,0
 DC.W 256
 DC.B 106,0
 DC.W 149
 DC.B 100,5
 DC.W 150
 DC.B 103,5
 DC.W 142
 DC.B 108,3
 DC.W 175
 DC.B 106,6
 DC.W 141
 DC.B 104,4
 DC.W 176
 DC.B 108,4
 DC.W 223
 DC.B 100,0
 DC.W 145
 DC.B 106,6
 DC.W 189
 DC.B 85,2
 DC.W 180
 DC.B 105,4
 DC.W 175
 DC.B 102,6
 DC.W 157
 DC.B 100,5
 DC.W 130
 DC.B 106,2
 DC.W 118
 DC.B 117,2
 DC.W 160
 DC.B 79,1
 DC.W 177
 DC.B 103,4
 DC.W 151
 DC.B 85,3
 DC.W 197
 DC.B 118,6
 DC.W 259
 DC.B 51,0
 DC.W 206
 DC.B 120,3
 DC.W 241
 DC.B 129,2
 DC.W 73
 DC.B 93,2
 DC.W 260
 DC.B 128,1
 DC.W 98
 DC.B 75,3
 DC.W 162
 DC.B 30,2
 DC.W 264
 DC.B 169,1
 DC.W 129
 DC.B 79,3
 DC.W 139
 DC.B 92,3
 DC.W 101
 DC.B 132,6
 DC.W 96
 DC.B 93,2
 DC.W 240
 DC.B 76,5
 DC.W 122
 DC.B 148,2
 DC.W 96
 DC.B 102,6
 DC.W 90
 DC.B 93,3
 DC.W 73
 DC.B 115,5
 DC.W 98
 DC.B 85,3
 DC.W 162
 DC.B 106,6
 DC.W 138
 DC.B 72,6
 DC.W 246
 DC.B 95,4
 DC.W 123
 DC.B 50,2
 DC.W 92
 DC.B 46,4
 DC.W 138
 DC.B 164,0
 DC.W 184
 DC.B 113,3
 DC.W 173
 DC.B 96,3
 DC.W 153
 DC.B 93,3
 DC.W 140
 DC.B 102,5
 DC.W 151
 DC.B 92,5
 DC.W 158
 DC.B 101,3
 DC.W 197
 DC.B 87,0
 DC.W 269
 DC.B 107,0
 DC.W 148
 DC.B 100,5
 DC.W 150
 DC.B 103,5
 DC.W 142
 DC.B 108,3
 DC.W 175
 DC.B 106,6
 DC.W 140
 DC.B 104,4
 DC.W 176
 DC.B 108,4
 DC.W 231
 DC.B 100,0
 DC.W 145
 DC.B 106,5
 DC.W 190
 DC.B 84,2
 DC.W 180
 DC.B 105,4
 DC.W 175
 DC.B 102,5
 DC.W 157
 DC.B 100,5
 DC.W 129
 DC.B 107,2
 DC.W 116
 DC.B 118,1
 DC.W 160
 DC.B 78,1
 DC.W 178
 DC.B 103,4
 DC.W 150
 DC.B 85,3
 DC.W 198
 DC.B 118,6
 DC.W 261
 DC.B 51,0
 DC.W 206
 DC.B 120,3
 DC.W 242
 DC.B 129,2
 DC.W 72
 DC.B 93,2
 DC.W 261
 DC.B 128,1
 DC.W 97
 DC.B 75,3
 DC.W 162
 DC.B 29,2
 DC.W 266
 DC.B 170,1
 DC.W 129
 DC.B 78,3
 DC.W 139
 DC.B 92,3
 DC.W 100
 DC.B 132,6
 DC.W 95
 DC.B 92,2
 DC.W 241
 DC.B 76,5
 DC.W 122
 DC.B 149,2
 DC.W 95
 DC.B 102,5
 DC.W 89
 DC.B 93,3
 DC.W 72
 DC.B 116,4
 DC.W 97
 DC.B 85,3
 DC.W 162
 DC.B 106,5
 DC.W 138
 DC.B 72,6
 DC.W 247
 DC.B 94,3
 DC.W 123
 DC.B 50,2
 DC.W 91
 DC.B 45,4
 DC.W 138
 DC.B 165,0
 DC.W 185
 DC.B 113,3
 DC.W 174
 DC.B 96,3
 DC.W 153
 DC.B 93,3
 DC.W 140
 DC.B 102,5
 DC.W 151
 DC.B 92,5
 DC.W 158
 DC.B 101,3
 DC.W 202
 DC.B 85,0
 DC.W 285
 DC.B 108,0
 DC.W 148
 DC.B 100,5
 DC.W 149
 DC.B 103,4
 DC.W 141
 DC.B 109,3
 DC.W 175
 DC.B 106,5
 DC.W 140
 DC.B 104,4
 DC.W 176
 DC.B 108,4
 DC.W 242
 DC.B 100,0
 DC.W 144
 DC.B 106,5
 DC.W 191
 DC.B 84,2
 DC.W 181
 DC.B 106,3
 DC.W 176
 DC.B 102,5
 DC.W 157
 DC.B 100,5
 DC.W 127
 DC.B 107,2
 DC.W 114
 DC.B 119,1
 DC.W 160
 DC.B 77,1
 DC.W 178
 DC.B 103,4
 DC.W 150
 DC.B 84,3
 DC.W 198
 DC.B 118,6
 DC.W 262
 DC.B 50,0
 DC.W 207
 DC.B 120,3
 DC.W 244
 DC.B 130,1
 DC.W 70
 DC.B 93,2
 DC.W 262
 DC.B 129,1
 DC.W 96
 DC.B 75,3
 DC.W 162
 DC.B 28,2
 DC.W 267
 DC.B 171,1
 DC.W 129
 DC.B 78,3
 DC.W 139
 DC.B 92,3
 DC.W 100
 DC.B 133,6
 DC.W 94
 DC.B 92,2
 DC.W 242
 DC.B 75,5
 DC.W 121
 DC.B 150,2
 DC.W 94
 DC.B 102,5
 DC.W 88
 DC.B 93,3
 DC.W 71
 DC.B 116,4
 DC.W 96
 DC.B 85,3
 DC.W 162
 DC.B 106,5
 DC.W 138
 DC.B 72,6
 DC.W 248
 DC.B 94,3
 DC.W 122
 DC.B 49,2
 DC.W 90
 DC.B 45,4
 DC.W 147
 DC.B 136,6
 DC.W 185
 DC.B 113,3
 DC.W 174
 DC.B 96,3
 DC.W 153
 DC.B 93,3
 DC.W 140
 DC.B 102,5
 DC.W 151
 DC.B 92,5
 DC.W 158
 DC.B 101,3
 DC.W 208
 DC.B 83,0
 DC.W 308
 DC.B 109,0
 DC.W 148
 DC.B 100,5
 DC.W 149
 DC.B 103,4
 DC.W 140
 DC.B 109,3
 DC.W 176
 DC.B 106,5
 DC.W 139
 DC.B 104,4
 DC.W 177
 DC.B 108,4
 DC.W 256
 DC.B 100,0
 DC.W 144
 DC.B 106,5
 DC.W 192
 DC.B 83,2
 DC.W 182
 DC.B 106,3
 DC.W 176
 DC.B 102,5
 DC.W 157
 DC.B 100,5
 DC.W 126
 DC.B 107,2
 DC.W 112
 DC.B 120,1
 DC.W 160
 DC.B 76,1
 DC.W 178
 DC.B 104,4
 DC.W 150
 DC.B 84,2
 DC.W 198
 DC.B 118,6
 DC.W 264
 DC.B 49,0
 DC.W 207
 DC.B 121,3
 DC.W 245
 DC.B 130,1
 DC.W 69
 DC.B 92,2
 DC.W 264
 DC.B 129,1
 DC.W 96
 DC.B 74,3
 DC.W 162
 DC.B 27,2
 DC.W 269
 DC.B 172,1
 DC.W 128
 DC.B 78,2
 DC.W 138
 DC.B 92,3
 DC.W 99
 DC.B 133,5
 DC.W 93
 DC.B 92,2
 DC.W 243
 DC.B 75,4
 DC.W 121
 DC.B 150,1
 DC.W 94
 DC.B 102,5
 DC.W 87
 DC.B 93,3
 DC.W 70
 DC.B 116,4
 DC.W 95
 DC.B 85,3
 DC.W 162
 DC.B 106,5
 DC.W 138
 DC.B 71,6
 DC.W 249
 DC.B 94,3
 DC.W 122
 DC.B 48,2
 DC.W 90
 DC.B 44,4
 DC.W 147
 DC.B 136,6
 DC.W 186
 DC.B 114,3
 DC.W 175
 DC.B 96,3
 DC.W 153
 DC.B 93,3
 DC.W 139
 DC.B 102,5
 DC.W 150
 DC.B 92,5
 DC.W 158
 DC.B 101,3
 DC.W 216
 DC.B 81,0
 DC.W 175
 DC.B 101,6
 DC.W 148
 DC.B 100,5
 DC.W 149
 DC.B 103,4
 DC.W 140
 DC.B 109,2
 DC.W 176
 DC.B 106,5
 DC.W 138
 DC.B 104,4
 DC.W 177
 DC.B 108,4
 DC.W 170
 DC.B 100,6
 DC.W 144
 DC.B 106,5
 DC.W 194
 DC.B 82,2
 DC.W 182
 DC.B 106,3
 DC.W 176
 DC.B 102,5
 DC.W 157
 DC.B 100,5
 DC.W 124
 DC.B 108,1
 DC.W 109
 DC.B 122,1
 DC.W 160
 DC.B 74,1
 DC.W 179
 DC.B 104,4
 DC.W 149
 DC.B 83,2
 DC.W 199
 DC.B 119,6
 DC.W 266
 DC.B 48,0
 DC.W 208
 DC.B 121,3
 DC.W 246
 DC.B 130,1
 DC.W 68
 DC.B 92,2
 DC.W 265
 DC.B 130,1
 DC.W 95
 DC.B 74,3
 DC.W 162
 DC.B 26,1
 DC.W 270
 DC.B 173,1
 DC.W 128
 DC.B 78,2
 DC.W 138
 DC.B 92,3
 DC.W 99
 DC.B 133,5
 DC.W 92
 DC.B 92,2
 DC.W 244
 DC.B 75,4
 DC.W 120
 DC.B 151,1
 DC.W 93
 DC.B 102,5
 DC.W 86
 DC.B 93,3
 DC.W 69
 DC.B 116,4
 DC.W 95
 DC.B 85,2
 DC.W 162
 DC.B 106,5
 DC.W 137
 DC.B 71,6
 DC.W 250
 DC.B 94,3
 DC.W 121
 DC.B 48,2
 DC.W 89
 DC.B 43,4
 DC.W 147
 DC.B 136,6
 DC.W 187
 DC.B 114,3
 DC.W 175
 DC.B 96,2
 DC.W 153
 DC.B 93,3
 DC.W 139
 DC.B 102,5
 DC.W 150
 DC.B 91,5
 DC.W 158
 DC.B 101,3
 DC.W 166
 DC.B 97,6
 DC.W 175
 DC.B 101,6
 DC.W 147
 DC.B 100,5
 DC.W 149
 DC.B 104,4
 DC.W 139
 DC.B 110,2
 DC.W 176
 DC.B 106,5
 DC.W 138
 DC.B 104,3
 DC.W 178
 DC.B 109,3
 DC.W 170
 DC.B 100,6
 DC.W 143
 DC.B 106,5
 DC.W 196
 DC.B 81,2
 DC.W 183
 DC.B 106,3
 DC.W 177
 DC.B 102,5
 DC.W 157
 DC.B 100,5
 DC.W 122
 DC.B 108,1
 DC.W 106
 DC.B 123,1
 DC.W 160
 DC.B 72,1
 DC.W 179
 DC.B 104,4
 DC.W 149
 DC.B 83,2
 DC.W 199
 DC.B 119,6
 DC.W 218
 DC.B 71,6
 DC.W 208
 DC.B 121,2
 DC.W 247
 DC.B 131,1
 DC.W 67
 DC.B 92,2
 DC.W 267
 DC.B 130,1
 DC.W 94
 DC.B 74,2
 DC.W 163
 DC.B 25,1
 DC.W 272
 DC.B 174,0
 DC.W 128
 DC.B 77,2
 DC.W 138
 DC.B 91,3
 DC.W 98
 DC.B 134,5
 DC.W 91
 DC.B 92,2
 DC.W 244
 DC.B 75,4
 DC.W 120
 DC.B 152,1
 DC.W 92
 DC.B 102,5
 DC.W 85
 DC.B 93,3
 DC.W 68
 DC.B 116,4
 DC.W 94
 DC.B 84,2
 DC.W 162
 DC.B 106,5
 DC.W 137
 DC.B 71,6
 DC.W 251
 DC.B 94,3
 DC.W 121
 DC.B 47,1
 DC.W 88
 DC.B 43,4
 DC.W 147
 DC.B 137,6
 DC.W 188
 DC.B 115,3
 DC.W 176
 DC.B 95,2
 DC.W 152
 DC.B 92,3
 DC.W 138
 DC.B 102,4
 DC.W 150
 DC.B 91,5
 DC.W 158
 DC.B 101,3
 DC.W 166
 DC.B 97,6
 DC.W 175
 DC.B 101,6
 DC.W 147
 DC.B 100,5
 DC.W 148
 DC.B 104,4
 DC.W 138
 DC.B 110,2
 DC.W 177
 DC.B 106,5
 DC.W 137
 DC.B 104,3
 DC.W 178
 DC.B 109,3
 DC.W 170
 DC.B 100,6
 DC.W 143
 DC.B 107,5
 DC.W 197
 DC.B 81,1
 DC.W 184
 DC.B 106,3
 DC.W 177
 DC.B 102,5
 DC.W 157
 DC.B 100,5
 DC.W 120
 DC.B 109,1
 DC.W 102
 DC.B 125,1
 DC.W 160
 DC.B 70,1
 DC.W 180
 DC.B 104,4
 DC.W 149
 DC.B 82,2
 DC.W 199
 DC.B 119,5
 DC.W 219
 DC.B 71,6
 DC.W 209
 DC.B 122,2
 DC.W 248
 DC.B 131,1
 DC.W 66
 DC.B 92,2
 DC.W 269
 DC.B 130,1
 DC.W 93
 DC.B 73,2
 DC.W 163
 DC.B 24,1
 DC.W 274
 DC.B 175,0
 DC.W 127
 DC.B 77,2
 DC.W 138
 DC.B 91,2
 DC.W 97
 DC.B 134,5
 DC.W 91
 DC.B 92,1
 DC.W 245
 DC.B 74,4
 DC.W 119
 DC.B 153,1
 DC.W 92
 DC.B 102,5
 DC.W 84
 DC.B 93,3
 DC.W 67
 DC.B 117,4
 DC.W 93
 DC.B 84,2
 DC.W 162
 DC.B 106,5
 DC.W 137
 DC.B 70,5
 DC.W 252
 DC.B 94,3
 DC.W 120
 DC.B 46,1
 DC.W 87
 DC.B 42,3
 DC.W 147
 DC.B 137,6
 DC.W 189
 DC.B 115,2
 DC.W 177
 DC.B 95,2
 DC.W 152
 DC.B 92,3
 DC.W 138
 DC.B 102,4
 DC.W 150
 DC.B 91,5
 DC.W 158
 DC.B 101,3
 DC.W 166
 DC.B 97,6
 DC.W 176
 DC.B 101,5
 DC.W 147
 DC.B 100,4
 DC.W 148
 DC.B 104,4
 DC.W 137
 DC.B 111,2
 DC.W 177
 DC.B 107,5
 DC.W 137
 DC.B 104,3
 DC.W 179
 DC.B 109,3
 DC.W 170
 DC.B 100,5
 DC.W 143
 DC.B 107,5
 DC.W 199
 DC.B 80,1
 DC.W 184
 DC.B 107,3
 DC.W 177
 DC.B 102,5
 DC.W 157
 DC.B 100,5
 DC.W 118
 DC.B 109,1
 DC.W 98
 DC.B 126,1
 DC.W 160
 DC.B 68,0
 DC.W 181
 DC.B 104,4
 DC.W 148
 DC.B 81,2
 DC.W 200
 DC.B 119,5
 DC.W 219
 DC.B 71,6
 DC.W 210
 DC.B 122,2
 DC.W 250
 DC.B 132,1
 DC.W 64
 DC.B 92,1
 DC.W 270
 DC.B 131,0
 DC.W 92
 DC.B 73,2
 DC.W 163
 DC.B 23,1
 DC.W 276
 DC.B 176,0
 DC.W 127
 DC.B 77,2
 DC.W 137
 DC.B 91,2
 DC.W 97
 DC.B 134,5
 DC.W 90
 DC.B 92,1
 DC.W 246
 DC.B 74,4
 DC.W 118
 DC.B 153,1
 DC.W 91
 DC.B 102,5
 DC.W 84
 DC.B 93,2
 DC.W 66
 DC.B 117,4
 DC.W 92
 DC.B 84,2
 DC.W 162
 DC.B 106,5
 DC.W 137
 DC.B 70,5
 DC.W 254
 DC.B 94,3
 DC.W 119
 DC.B 46,1
 DC.W 86
 DC.B 41,3
 DC.W 147
 DC.B 138,6
 DC.W 190
 DC.B 116,2
 DC.W 177
 DC.B 95,2
 DC.W 152
 DC.B 92,3
 DC.W 137
 DC.B 102,4
 DC.W 150
 DC.B 91,5
 DC.W 158
 DC.B 101,2
 DC.W 166
 DC.B 97,5
 DC.W 176
 DC.B 101,5
 DC.W 147
 DC.B 100,4
 DC.W 148
 DC.B 104,4
 DC.W 136
 DC.B 111,2
 DC.W 178
 DC.B 107,5
 DC.W 136
 DC.B 105,3
 DC.W 180
 DC.B 110,3
 DC.W 170
 DC.B 100,5
 DC.W 142
 DC.B 107,5
 DC.W 201
 DC.B 79,1
 DC.W 185
 DC.B 107,3
 DC.W 178
 DC.B 102,5
 DC.W 157
 DC.B 100,4
 DC.W 115
 DC.B 110,1
 DC.W 94
 DC.B 128,1
 DC.W 160
 DC.B 65,0
 DC.W 181
 DC.B 104,3
 DC.W 148
 DC.B 81,2
 DC.W 200
 DC.B 119,5
 DC.W 220
 DC.B 70,6
 DC.W 210
 DC.B 122,2
 DC.W 251
 DC.B 132,1
 DC.W 63
 DC.B 92,1
 DC.W 272
 DC.B 131,0
 DC.W 92
 DC.B 73,2
 DC.W 163
 DC.B 22,1
 DC.W 277
 DC.B 178,0
 DC.W 126
 DC.B 76,2
 DC.W 137
 DC.B 91,2
 DC.W 96
 DC.B 135,5
 DC.W 89
 DC.B 92,1
 DC.W 247
 DC.B 74,4
 DC.W 118
 DC.B 154,1
 DC.W 90
 DC.B 102,4
 DC.W 83
 DC.B 93,2
 DC.W 65
 DC.B 117,3
 DC.W 91
 DC.B 84,2
 DC.W 162
 DC.B 106,4
 DC.W 136
 DC.B 70,5
 DC.W 255
 DC.B 94,2
 DC.W 119
 DC.B 45,1
 DC.W 85
 DC.B 41,3
 DC.W 147
 DC.B 138,6
 DC.W 192
 DC.B 117,2
 DC.W 178
 DC.B 95,2
 DC.W 152
 DC.B 92,2
 DC.W 137
 DC.B 102,4
 DC.W 149
 DC.B 91,4
 DC.W 157
 DC.B 102,2
 DC.W 166
 DC.B 97,5
 DC.W 176
 DC.B 101,5
 DC.W 146
 DC.B 100,4
 DC.W 148
 DC.B 104,4
 DC.W 135
 DC.B 112,2
 DC.W 178
 DC.B 107,5
 DC.W 135
 DC.B 105,3
 DC.W 180
 DC.B 110,3
 DC.W 171
 DC.B 100,5
 DC.W 142
 DC.B 107,4
 DC.W 204
 DC.B 77,1
 DC.W 186
 DC.B 107,3
 DC.W 178
 DC.B 102,4
 DC.W 157
 DC.B 100,4
 DC.W 112
 DC.B 110,1
 DC.W 89
 DC.B 131,0
 DC.W 160
 DC.B 61,0
 DC.W 182
 DC.B 104,3
 DC.W 147
 DC.B 80,2
 DC.W 201
 DC.B 120,5
 DC.W 220
 DC.B 70,6
 DC.W 211
 DC.B 122,2
 DC.W 252
 DC.B 133,0
 DC.W 62
 DC.B 92,1
 DC.W 274
 DC.B 132,0
 DC.W 91
 DC.B 72,2
 DC.W 163
 DC.B 21,1
 DC.W 279
 DC.B 179,0
 DC.W 126
 DC.B 76,2
 DC.W 137
 DC.B 91,2
 DC.W 95
 DC.B 135,5
 DC.W 88
 DC.B 92,1
 DC.W 248
 DC.B 74,4
 DC.W 117
 DC.B 155,1
 DC.W 90
 DC.B 102,4
 DC.W 82
 DC.B 93,2
 DC.W 64
 DC.B 117,3
 DC.W 90
 DC.B 84,2
 DC.W 162
 DC.B 106,4
 DC.W 136
 DC.B 70,5
 DC.W 256
 DC.B 94,2
 DC.W 118
 DC.B 44,1
 DC.W 85
 DC.B 40,3
 DC.W 147
 DC.B 138,5
