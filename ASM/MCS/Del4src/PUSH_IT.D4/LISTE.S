	INCBIN	M.MAG
	INCBIN	C.MAG
	INCBIN	S.MAG
	INCBIN	MCS.MAG
;	INCBIN	MAISON.MAG
	INCBIN	ATARI.MAG
	INCBIN	COEUR.MAG
	INCBIN	DEBILE.MAG
	INCBIN	DEL4.MAG
	INCBIN	DISK.MAG
	INCBIN	JOYSTICK.MAG
	INCBIN	MARS.MAG
	INCBIN	OBJET.MAG
	INCBIN	PACMAN.MAG
	INCBIN	PYRAM.MAG
	INCBIN	SPIRALE.MAG
	INCBIN	ST.MAG
	INCBIN	TOMBE.MAG
	INCBIN	VACHE.MAG 
	INCBIN	VERRE.MAG 
	INCBIN	FLAMME.MAG
	INCBIN	ILUVBEER.MAG
	INCBIN	UBGCNP.MAG
	INCBIN	TREE.MAG
	INCBIN	COMFUK.MAG