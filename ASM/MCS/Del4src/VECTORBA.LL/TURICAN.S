TEXT
	CLR.L	-(SP)
	MOVE.W	#32,-(SP)
	TRAP	#$1
	ADDQ.L	#6,SP
	
	MOVE.W	#$2700,SR
	MOVE.L	$70,AD70
	MOVE.L	#VBL,$70
	JSR	ZIK+8
	MOVEQ	#2,D0
	JSR	ZIK+4
	MOVE.W	#$2300,SR
	
WAIT
	BRA	WAIT
	
FIN
	MOVE.W	#$2700,SR
	
	JSR	ZIK+$C
	MOVE.L	AD70,$70
	
	MOVE.W	#$2300,SR
	
	CLR.L	-(SP)
	TRAP	#1
	
VBL
	CMP.B	#$39,$FFFC02
	BEQ.S	FIN
	JSR	ZIK
	RTE
	
AD70
	DC.L	0
ZIK
	INCBIN	TURICAN2.MUS