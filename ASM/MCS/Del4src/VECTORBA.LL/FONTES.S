TEXT
	CLR.L	-(SP)
	MOVE.W	#32,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
	
	MOVE.W	#0,-(SP)
	PEA	$70000
	PEA	$70000
	MOVE.W	#5,-(SP)
	TRAP	#$0E
	ADD.L	#12,SP
	
	MOVE.W	#$0,$FFFF8240.W
	MOVE.W	#$770,$FFFF8242.W
	MOVE.W	#$330,$FFFF8244.W

	LEA	FNT,A0
	LEA	$70000,A1
	MOVE.W	#40*16-1,D1
AFF_FNT
	MOVE.L	(A0)+,(A1)+
	DBRA	D1,AFF_FNT

WAIT_SPACE
	CMP.B	#$39,$FFFC02
	BNE.S	WAIT_SPACE

	MOVE.W	#$777,$FFFF8240.W

	CLR.L	-(SP)
	TRAP	#1
	
MESS
	DC.B	'HELLOA'
FINM
	EVEN
TAB_FNT
M	SET	0
	REPT	13
	DC.L	FNT+M,FNT+M+1
M	SET	M+8
	ENDR
FNT
	INCBIN	COPYB1.IMG