TEXT
	CLR.L	-(SP)
	MOVE.W	#32,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
	
	MOVE.W	#0,-(SP)
	PEA	$70000
	PEA	$70000
	MOVE.W	#5,-(SP)
	TRAP	#$0E
	ADD.L	#12,SP
	
	MOVE.W	#$0,$FFFF8240.W
	MOVE.W	#$440,$FFFF8242.W
	MOVE.W	#$550,$FFFF8244.W
	MOVE.W	#$660,$FFFF8246.W
	MOVE.W	#$770,$FFFF8248.W

WAIT
	MOVE.W	#$25,-(SP)
	TRAP	#$0E
	ADDQ.L	#2,SP

	MOVE.W	#$25,-(SP)
	TRAP	#$0E
	ADDQ.L	#2,SP

	MOVE.W	#$25,-(SP)
	TRAP	#$0E
	ADDQ.L	#2,SP

PEKM
	MOVE.L	#MESS,A0

PEK_SCREEN
	MOVE.L	#$70000,A1
	LEA	TAB_FNT,A2
	MOVEQ	#0,D1
	
	MOVE.B	(A0),D1
	BEQ	WAIT_SPACE
	CMP.B	#1,D1
	BEQ	FIN_TEXTE
	SUB.B	#' ',D1
	ADD.W	D1,D1
	ADD.W	D1,D1
	MOVE.L	(A2,D1.W),A3
M	SET	0
	REPT	8
	MOVE.B	M(A3),M(A1)
	MOVE.B	M+2(A3),M+2(A1)
	MOVE.B	M+4(A3),M+4(A1)
	MOVE.B	M+6(A3),M+6(A1)
	MOVE.B	#$FF,M+1(A1)
	MOVE.B	#$FF,M+3(A1)
	MOVE.B	#$FF,M+5(A1)
	MOVE.B	#$FF,M+7(A1)
M	SET	M+160
	ENDR

	MOVE.B	1(A0),D1
	BEQ	WAIT_SPACE
	CMP.B	#1,D1
	BEQ	FIN_TEXTE
	SUB.B	#' ',D1
	ADD.W	D1,D1
	ADD.W	D1,D1
	MOVE.L	(A2,D1.W),A3
M	SET	0
	REPT	8
	MOVE.B	M(A3),M+1(A1)
	MOVE.B	M+2(A3),M+3(A1)
	MOVE.B	M+4(A3),M+5(A1)
	MOVE.B	M+6(A3),M+7(A1)
	MOVE.B	#$FF,M+8(A1)
	MOVE.B	#$FF,M+10(A1)
	MOVE.B	#$FF,M+12(A1)
	MOVE.B	#$FF,M+14(A1)
M	SET	M+160
	ENDR
	
	ADD.L	#2,PEKM+2
	ADD.L	#8,PEK_SCREEN+2
	ADDQ	#1,CL
	BRA	WAIT

WAIT_SPACE
	BSR	WAIT_VBL2


	MOVE.W	CL,D0
	MOVE.L	PEK_SCREEN+2,A0

EFF
	MOVEM.L	D0/A0,-(SP)
	MOVE.W	#$25,-(SP)
	TRAP	#$E
	ADDQ.L	#2,SP
	MOVE.W	#$25,-(SP)
	TRAP	#$E
	ADDQ.L	#2,SP
	MOVE.W	#$25,-(SP)
	TRAP	#$E
	ADDQ.L	#2,SP
	MOVEM.L	(SP)+,D0/A0

M	SET	0
	REPT	8
	MOVE.W	#0,M(A0)
	MOVE.W	#0,M+2(A0)
	MOVE.W	#0,M+4(A0)
	MOVE.W	#0,M+6(A0)
M	SET	M+160
	ENDR

	SUBQ.L	#8,A0
	DBRA	D0,EFF
FIN
	MOVE.L	#$70000,PEK_SCREEN+2
WAIT_SPACE2
	CMP.B	#$39,$FFFC02
	BEQ.S	FIN_TEXTE

	ADD.L	#1,PEKM+2
	MOVE.W	#0,CL
	BRA	WAIT

FIN_TEXTE
	CMP.B	#$39,$FFFC02
	BNE.S	FIN_TEXTE

	MOVE.W	#$FFFF,320(A0)

	MOVE.W	#$777,$FFFF8240.W

	CLR.L	-(SP)
	TRAP	#1

WAIT_VBL2
	MOVEM.L	D0-D7/A0-A6,-(SP)
	REPT	4
	MOVE.W	#$25,-(SP)
	TRAP	#$E
	ADDQ.L	#2,SP
	ENDR
	MOVEM.L	(SP)+,D0-D7/A0-A6
	RTS
CL
	DC.W	0
MESS
	DC.B	"                 NO !!!!              ",0
	DC.B	"            YOU DON'T DREAM.          ",0
	DC.B	"     THE M.C.S. STRIKES BACK WITH :   ",0
	DC.B	"     THE DELIRIOUS DEMO CHAPTER 4.    ",0
	DC.B	" THIS TIME OUR CREW IS BIGGER THAN FOR",0
	DC.B	"           THE CHAPTER 3.             ",0
	DC.B	"    CREDITS FOR THIS MEGA DELIRIUM :  ",0
	DC.B	"     BOOT CODED BY : THE DREAMER      ",0
	DC.B	"      ( GREAT WORK MY FRIEND )        ",0
	DC.B	"    INTRO CODED BY MAGNUM (IT'S ME)   ",0
	DC.B	"    LEMMING'S RAP BY RAW FROM M.C.S.  ",0
	DC.B	"     (YES WE NOW HAVE A MUSICIAN)     ",0
	DC.B	"    GRAPHIX BY ZORGLUB AND MAGNUM     ",0
	DC.B	"     LOADER CODED BY AXEL FOLLET      ",0
	DC.B	"          LOADER GFX BY ALF           ",0
	DC.B	"     FULL MENU CODED BY THE DREAMER ! ",0
	DC.B	"           MENU GFX BY ALF.           ",0
	DC.B	"          RESET DEMO CODED BY :       ",0
	DC.B	" XERCES (GENESIS) AND MAGNUM (M.C.S.) ",0
	DC.B	"    PROTECTION AND PACKER BY ALTAIR   ",0
	DC.B	"      MONOCHROME CODING BY GADGET     ",0
	DC.B	" AND NOW THE PRESENTATION OF THE WHOLE",0
	DC.B	"                CREW......            ",0
	DC.B	" ALTAIR                          CODER",0
	DC.B	" AXEL FOLLET             CODER-SLEEPER",0
	DC.B	" BUNKER DESIGN       PAINTER-RELATIONS",0
	DC.B	" GADGET         CODER-PUBLIC RELATIONS",0
	DC.B	" GALAHAD                HARDWARE-CODER",0
	DC.B	" JUDGE DEATH                   PAINTER",0
	DC.B	" MAGNUM                  CODER-DRINKER",0
	DC.B	" MARIO                   CODER-PAINTER",0
	DC.B	" P.F.                    CODER-DRINKER",0
	DC.B	" RAW                          MUSICIAN",0
	DC.B	" THE DREAMER                FULL CODER",0
	DC.B	" THE HOOLIGAN         CODER-CRITICIZER",0
	DC.B	" ZORGLUB                  LAZY PAINTER",0
	DC.B	" THANX TO PSYGNOSYS FOR THIS NICE GAME",0
	DC.B	" CALLED LEMMINGS...                   ",0
	DC.B	"            HELLO GOES TO :           ",0
	DC.B	"  MIT (I KNOW THAT YOU LOVE LEMMINGS) ",0
	DC.B	"  GENESIS (XERCES, MICHAEL MAYERS..)  ",0
	DC.B	"  THE BLACK CATS (DOCPROF, CONAN,...) ",0
	DC.B	"    EQUINOX (STARLION, RENKER, EDY)   ",0
	DC.B	"     THE CYBERNETICS (FUNNY GUYS)     ",0
	DC.B	"       AND LAST : JOHN COURAGE        ",0
	DC.B	1,1,1,1
FTEXT
	EVEN
FNT
	INCBIN	COPYB4.IMG
FIN_FNT

SPACE	EQU	FNT+153
TAB_FNT
	DC.L	FNT+153
	DC.L	FNT+160*8+9
	DC.L	FNT+160*8+24
	DC.L	SPACE
	DC.L	SPACE
	DC.L	SPACE
	DC.L	SPACE
	DC.L	FNT+160*8+17
	DC.L	FNT+18*8
	DC.L	FNT+18*8+1
	DC.L	SPACE
	DC.L	SPACE
	DC.L	FNT+160*8+16
	DC.L	SPACE
	DC.L	FNT+160*8
	DC.L	SPACE
M	SET	0
	REPT	5
	DC.L	FNT+8*13+M	* 0 A 9
	DC.L	FNT+8*13+M+1
M	SET	M+8
	ENDR
	DC.L	FNT+8*19		* :
	DC.L	FNT+160*8+8
	DC.L	SPACE
	DC.L	SPACE
	DC.L	SPACE
	DC.L	FNT+160*8+1	* ?
	DC.L	SPACE
M	SET	0
	REPT	13
	DC.L	FNT+M
	DC.L	FNT+M+1
M	SET	M+8
	ENDR

	
