*** HLM DEMO BY THE DREAMER FROM M.C.S FOR DELIRIOUS DEMO IV
*** LA MEMOIRE ECRAN EST APRES LE PROGRAMME.
*** TOUT EST EXPLIQUE POUR LES INTERRUPT ET TRAP

INIT:	PEA	$0		;SUPERVISEUR
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.W	#6,SP
	MOVE.W	#$2700,SR
	
	MOVEM.L	ZERO,D0-D7/A0-A6
	MOVEM.L	D0-D7,$FFFFF8240.W
		
	MOVE.B	#$02,$FFFFF820A.W	;50hz	
	MOVE.B	#$12,$FFFFFC02.W	;COUPE LA SOURIS
	
	LEA	SAVE,A0
	MOVE.L	$68.W,(A0)+
	MOVE.L	$70.W,(A0)+		;SAUVE L'ENCIEN VECTEUR VBL
	MOVE.L	$120.W,(A0)+		;LE TIMER-B
	MOVE.L	$118.W,(A0)+		;LE CLAVIER
	MOVE.L	$134.W,(A0)+		;LE CLAVIER
	MOVE.B	$FFFFFA07.W,(A0)+	;SAUVE INFORMATION
	MOVE.B	$FFFFFA09.W,(A0)+	;TIMER-A
	MOVE.B	$FFFFFA13.W,(A0)+	;AUTORISATION TIMER etc...
	MOVE.B	$FFFFFA17.W,(A0)+	;

	BCLR.B	#$03,$FFFFFA17.W	;FIN IT AUTOMATIQUE!
	MOVE.B	#$00,$FFFFFA09.W
	MOVE.B	#$01,$FFFFFA07.W
	MOVE.B	#$01,$FFFFFA13.W
	MOVE.B	#$00,$FFFFFA1B.W

	BSR	CALC_PHYS
	BSR	AFF_IMG	
	BSR	CLR_YM
	BSR	INTALLE_MUS
	
	MOVEM.L	ZERO,D0-D7/A0-A6
	MOVE.L	#ACTIF,$68.W
	MOVE.L	#VBL,$70.W		
	MOVE.L	#TIMER_B,$120.W	
	MOVE.L	#INACTIF,$118.W		
	MOVE.L	#INACTIF,$134.W		
	
	MOVE.L	#VBL_WAIT,$70.W
	STOP	#$2300
	MOVE.L	#VBL,$70.W

	STOP	#$2100
	STOP	#$2100
	MOVE.W	#$2300,SR
STOP:	BRA.S	STOP	
VBL_WAIT:	RTE	

****************************************************
AFF_IMG:	MOVE.L	PHYS1,A0		|ECRAN 1
	ADD.L	#48+96-16+230*2-8-16-8,A0	|
	MOVE.L	A0,ADR_SC1		|PHYS1 & ADR_SC1
	
	MOVE.L	PHYS1,A0		|ECRAN 2
	ADD.L	#230*(128*2)+(256*32),A0	|
	MOVE.L	A0,PHYS2		|
	ADD.L	#128-32+230*2,A0	|	
	
	SUB.L	#230*8,A0
	MOVE.L	A0,ADR_SC2		|PHYS2 & ADR_SC2

	MOVE.L	PHYS1,A0
	MOVE.W	#((230*274)/4)-1,D0
CLR_SCREEN:	CLR.L	(A0)+
	DBRA	D0,CLR_SCREEN
	RTS
	
****************************************************
CALC_PHYS:	MOVE.L	#ADR_ECR,D0	
	ADD.L	#230*9,D0
	ST	D0
	ADDQ.W	#1,D0
	MOVE.L	D0,PHYS1
	
	LSR.L	#$8,D0
	LEA	$FFFFF8201.W,A0
	MOVEP.W	D0,(A0)
	RTS

****************************************************
CLR_YM:	LEA	$FFFFF8802.W,A4	
	LEA	$FFFFF8800.W,A3	
	MOVEQ	#0,D0
	MOVEQ	#0,D1

	MOVEQ	#$D-1,D2
RESET_YM:	MOVE.B	D1,(A3)
	MOVE.B	D0,(A4)
	ADDQ.W	#1,D1
	DBRA	D2,RESET_YM

	MOVE.B	#$7,(A3)
	MOVE.B	#-1,(A4)
	RTS

****************************************************
INTALLE_MUS:	JSR 	INIT_MAX
	JSR 	INIT_DIGIT			
	RTS
	
****************************************************
PLAY_DIGIT:	TST.W	L0052
	BEQ.S	FIN_DIGIT2

	MOVE    	USP,A5
             MOVE.B 	#$A,$FFFF8800.W
             MOVE.B  	(A5)+,$FFFF8802.W
             MOVE    	A5,USP
             BPL.S   	FIN_DIGIT1
             CLR.W   	L0052
	RTS
             
FIN_DIGIT1:	DCB.W	4,$4E71
             RTS
             
FIN_DIGIT2: 	DCB.W	18,$4E71
	RTS

****************************************************
INIT_PAL:	MOVE.L	ADR_SC1,A3		|5 NOPS
	MOVE.L	ADR_SC2,A2		|5 NOPS
	
	DCB.W	84-10,$4E71
	MOVEM.L	PAL,D0-D7	
	MOVEM.L	D0-D7,(A5)
	MOVEQ	#0,D0
	RTS

****************************************************
******************  ROUTINE VBL ********************
****************************************************

VBL:	MOVE.L	#TIMER_B,$120.W
	CLR.B	$FFFFFA1B.W
	MOVE.B	#100,$FFFFFA21.W
	MOVE.B	#4,$FFFFFA1B.W	
	
	CMPI.B	#$19,$FFFFFC02.W
	BEQ	PAUSE
	CLR.W	PAUSE_MOD
	
	CMPI.L	#315*2,COUNT_RST
	BNE.S	RESTART_RST	
	CLR.L	COUNT_RST
	BRA.S	SUITE_RST
	
RESTART_RST:	ADDQ.L	#2,COUNT_RST
SUITE_RST:	LEA	SIN_TAB,A0
	ADD.L	COUNT_RST,A0
	MOVE.L	A0,RASTERS_SCR+2

	BSR.S	GST_SCROOLING
	JSR	PLAY_MAX
	JSR	NEW_PAL

	CMPI.B	#$39,$FFFFFC02.W
	BEQ.S	THE_END
	RTE

PAUSE:	MOVE.W	#1,PAUSE_MOD
	JSR	PLAY_MAX
	CMPI.B	#$39,$FFFFFC02.W
	BEQ.S	THE_END
	RTE
	
THE_END:	MOVE.W	#$2700,SR
	JMP	FIN

****************************************************
** GESTION DU SCROOLING TEXT VERTICAL(BUFFER TXT) **
****************************************************
GST_SCROOLING:	
	MOVEQ	#0,D0
	MOVE.B	$FFFFFC02.W,D0
	CMPI.B	#$3B+3,D0
	BHS.S	TST_KEY
	CMPI.B	#$3B,D0
	BLO.S	TST_KEY
	SUB.B	#$3B,D0
	LEA	COURBES,A0
	MULU.W	#400,D0
	ADD.L	D0,A0
	MOVE.L	A0,TST_KEY+2
	
TST_KEY:	LEA	COURBES,A0
	ADD.W	ADD_COURBE,A0
	MOVEQ	#0,D0
	MOVE.W	(A0),D0
	EXT.L	D0
	ADD.L	D0,COUNT_SC
	ADDQ.W	#2,ADD_COURBE

	CMPI.W	#400,ADD_COURBE
	BNE.S	CALC_TXTBUF
	CLR.W	ADD_COURBE

***	
CALC_TXTBUF:	LEA	TXT_SC,A0
	LEA	BUFFER_TXT,A1
	
	MOVE.L	COUNT_SC,D0
	MOVE.L	D0,D1
	MOVE.L	D0,D2
	LSR.L	#6,D0	;/64
	ADD.L	D0,A0

	LSR.L	#6,D1	;/64
	LSL.L	#6,D1	;*64
	SUB.L	D1,D2

	LEA	BUFFER_TXT,A2
	ADD.L	D2,A2
	MOVE.L	A2,SCROOL_TXT+2
	MOVEQ	#16,D3
	
	MOVEQ	#10-1,D1
L_SUIV:	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	
	SUB.B	#32,D0
	LSL.W	#8,D0	;(32*16)*D0
	ADD.W	D0,D0
	
	REPT	32
	MOVE.W	D0,(A1)+
	ADD.W	D3,D0
	ENDR
	DBRA	D1,L_SUIV
	
FIN_TXT:	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	CMPI.B	#$F,D0
	BNE.S	NO_END_TXT
	MOVE.L	#64*4,COUNT_SC
NO_END_TXT:	RTS

***************************************
NEW_PAL:	MOVEQ	#0,D0
	MOVE.B	$FFFFFC02.W,D0

	CMPI.B	#$3E,D0
	BEQ.S	NEW_1
	CMPI.B	#$3F,D0
	BEQ.S	NEW_2
	CMPI.B	#$40,D0
	BEQ.S	NEW_3
	CMPI.B	#$41,D0
	BEQ.S	NEW_4
	CMPI.B	#$42,D0
	BEQ.S	NEW_5
	RTS
	
NEW_1:	LEA	PAL_1,A0	
	MOVEM.L	(A0),D0-D2
	MOVEM.L	D0-D2,PAL+2
	RTS

NEW_2:	LEA	PAL_2,A0	
	MOVEM.L	(A0),D0-D2
	MOVEM.L	D0-D2,PAL+2
	RTS
	
NEW_3:	LEA	PAL_3,A0	
	MOVEM.L	(A0),D0-D2
	MOVEM.L	D0-D2,PAL+2
	RTS
	
NEW_4:	LEA	PAL_4,A0	
	MOVEM.L	(A0),D0-D2
	MOVEM.L	D0-D2,PAL+2
	RTS

NEW_5:	LEA	PAL_5,A0	
	MOVEM.L	(A0),D0-D2
	MOVEM.L	D0-D2,PAL+2
	RTS

	
******************** FULL_SCREEN *******************
TIMER_B:	STOP	#$2100		;STAB OPT
	STOP	#$2100
	MOVE.W	#$2700,SR
	
	LEA	$FFFFF820A.W,A0
	LEA	$FFFFF8260.W,A1
	LEA	$FFFFF8209.W,A2
	LEA	$FFFFF8240.W,A5	;2NOPS
RASTERS_SCR:	LEA	SIN_TAB,A4		;3NOPS
SCROOL_TXT:	LEA	$0,A6		;3NOPS
	
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	DCB.W	65,$4E71	
	
	MOVE.B	D0,(A0)		;BORDER HAUT	
	DCB.W	10,$4E71
	MOVE.W	A0,(A0)
	DCB.W	27,$4E71	
	
	SUB.B	(A2),D1
	LSL.L	D1,D1
	DCB.W	42,$4E71		
	
	MOVE.B	D0,(A0)		;BORDER DROITE
	NOP
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71		
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)
	DCB.W	6,$4E71		

; DC.W -768
 
L1:	JSR	L_054	;HARD-SCROOL
L2:	JSR	L_054
L3:	JSR	L_186
L4:	JSR	L_158
L5:	JSR	L_158
L6:	JSR	L_158
	JSR	INIT_PAL	;METS LA PALETTE+???(1 LIGNE)

N	SET	0
	REPT	9
	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|10 NOPS
	ADD.W	#230,A3		|6 NOPS
	ADD.W	#230,A2		|
	
	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS
	
	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS
	
	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	0
	ENDR	
***
	
	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS
	
	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16
***

BORDER_BAS1:	MOVE.W	A0,(A1)	;(1er ligne bas)
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)	
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-11-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVEM.L	(A5)+,D1-D4	|11 NOPS
	MOVE.B	D0,(A0)	
	NOP	
	MOVE.W	A0,(A0)	
	DCB.W	8,$4E71
	MOVE.B	D0,(A0)	
	DCB.W	2,$4E71
	MOVE.W	A0,(A1)	
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16
	
BORDER_BAS2:	MOVE.W	A0,(A1)	;(2eme ligne bas)
	MOVE.W	A0,(A0)	
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)	
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

BORDER_BASS:	REPT	9
	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16
	ENDR

N	SET	0
	REPT	11
	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-6-30-13-34,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16

	MOVE.W	A0,(A1)			
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	DCB.W	89-6-30-13,$4E71
	LEA	D_0+N,A5		|3 NOPS+16V
	ADD.W	(A4)+,A5		|3 NOPS
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	NOP
	MOVEM.L	(A5)+,D1-D4		|11 NOPS
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D1-D4,$FFFFF8240+8*2.W	|11 NOPS
N	SET	N+16
	ENDR


PALZERO:	MOVE.W	A0,(A1)	
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	LEA	FONTS,A5		|6 NOPS
	ADD.W	(A6)+,A5		|
	MOVEM.L	(A5),D1-D4		|21 NOPS
	MOVEM.L	D1-D4,(A3)		|
	MOVEM.L	D1-D4,(A2)		|
	ADD.W	#230,A3		|3 NOPS
	ADD.W	#230,A2		|3 NOPS

	JSR	PLAY_DIGIT		|34 NOPS
	DCB.W	89-30-13-34,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	MOVEQ	#0,D1
	MOVEQ	#0,D2
	MOVEQ	#0,D3
	MOVEQ	#0,D4
	MOVEQ	#0,D5
	MOVEQ	#0,D6
	MOVEQ	#0,D7
	DCB.W	12-7,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D0-D7,$FFFFF8240.W	

	LEA	TAB_HARD,A0
	ADD.L	COUNT_HARD,A0
	MOVE.L	(A0)+,L1+2
	MOVE.L	(A0)+,L2+2
	MOVE.L	(A0)+,L3+2
	MOVE.L	(A0)+,L4+2
	MOVE.L	(A0)+,L5+2
	MOVE.L	(A0)+,L6+2
SWAP_PHYS:	MOVE.L	PHYS1,D0
	ADD.L	(A0),D0
	
	LSR.L	#$8,D0
	LEA	$FFFFF8201.W,A0
	MOVEP.W	D0,(A0)

	TST.W	PAUSE_MOD
	BNE	TT

***1 ECRAN 14*6(448)
	ADD.L	#16,ADR_SC1
	ADD.L	#16,ADR_SC2
	ADD.L	#28,COUNT_HARD

	CMPI.L	#28*(112+3),COUNT_HARD
	BNE.S	TT	
	SUB.L	#16*(112+3),ADR_SC1
	SUB.L	#16*(112+3),ADR_SC2
	CLR.L	COUNT_HARD
	JSR	SWAP_SCREEN
	
TT:	MOVE.W	#$2300,SR
INACTIF:	RTE	

SWAP_SCREEN:	NOT.W	FLAG_SWAP
	TST.W	FLAG_SWAP
	BNE.S	ECRAN_2
	LEA	PHYS1,A0
	MOVE.L	A0,SWAP_PHYS+2
	SUB.L	#230*8,ADR_SC2
	ADD.L	#230*8,ADR_SC1
	RTS
	
ECRAN_2:	LEA	PHYS2,A0
	MOVE.L	A0,SWAP_PHYS+2
	ADD.L	#230*8,ADR_SC2
	SUB.L	#230*8,ADR_SC1
	RTS

ACTIF:	BCLR.B	#0,$FFFFFA0F.W	
	CLR.B	$FFFFFA1B.W
	RTE
	
****************************************************
***** FIN=>ON RETABLIE TOUTES LES INETRUPTIONS *****
****************************************************
FIN:	LEA	SAVE,A0		
	MOVE.L	(A0)+,$68.W
	MOVE.L	(A0)+,$70.W		 
	MOVE.L	(A0)+,$120.W		
	MOVE.L	(A0)+,$118.W		
	MOVE.L	(A0)+,$134.W		
	MOVE.B	(A0)+,$FFFFFA07.W	
	MOVE.B	(A0)+,$FFFFFA09.W	
	MOVE.B	(A0)+,$FFFFFA13.W	
	MOVE.B	(A0)+,$FFFFFA17.W	
	JSR	CLR_YM
	MOVE.B	#$8,$FFFFFC02.W	
	MOVE.W	#$2300,SR		

	MOVE.W	#$777,$FFF8240	
	MOVE.W	#$000,$FFF8246	
	CLR	-(SP)	
	TRAP	#1

****************************************************
********************** DATA ************************
****************************************************
SAVE:	DCB.L	6,0
ZERO:	DCB.L	16,0
PHYS1:	DC.L	0
PHYS2:	DC.L	0
ADR_SC1:	DC.L	0
ADR_SC2:	DC.L	0
COUNT_RST:	DC.L	0
COUNT_HARD:	DC.L	0
COUNT_SC:	DC.L	64*4
FLAG_SWAP:	DC.W	0
ADD_COURBE:	DC.W	0
PAUSE_MOD:	DC.W	0
COUNT_FEED:	DC.W	0
TAMPO_FEED:	DC.W	0
OFFSET:	INCLUDE	"OFF_9.BLK"
PAL:	DC.W	$000,$777,$666,$555,$444,$333,$222,$002
	DC.W	$000,$000,$000,$000,$000,$000,$000,$000

FONTS:	INCBIN	"FONTS.BLK"
SIN_TAB:	INCLUDE	"COURBE.SIN"
	INCLUDE	"COURBE.SIN"

	EVEN
COURBES:	INCBIN	"COURBE1.MAG"
	INCBIN	"COURBE2.MAG"
	INCBIN	"COURBE3.MAG"

	EVEN
MUSIC:	INCLUDE	"TAL_MUS.BLK"
	DCB.B	100,0
	EVEN

TXT_SC:	DC.B	"                    "
	DC.B	" THE DREAMER OF MCS IS NOW ABOUT"
	DC.B	" TO PRESENT HIS LATEST PRODUCTION:"
	DC.B	"     THE    H.L.M    DEMO         "
	DC.B 	" H.L.M, OF COURSE, STANDS FOR -HACKING"
	DC.B	" LOUSY MEN- (WHAT DID YOU EXPECT?) "
	DC.B	"                IT GOES WITHOUT SAYING"
	DC.B	" THAT ALL CODE IS BY THE (INDEED) DREAMER,"
	DC.B	" ALL GRAFIX ARE TOTALY,COMPLETY RIPPED OF THE"
	DC.B	" AMIGAGA, AND THAT THE MUS-WHAT SHALL CALL IT-AK"
	DC.B	" IS BY MAD MAX FROM A PREHISTORIC GAME..."
	DC.B	"            OH!, I ALMOST FORGOT, BUT ALL OF YOU"
	DC.B	" HAD GUESSED, THAT THE TEXT IS TYPED BY THE"
	DC.B	" HOOLIGAN ('THE MASTER OF THE BUDDHA')...       "
	DC.B	" BEFORE STARTING THE BULLSHIT, THE DREAMER WANTS"
	DC.B	" ME TO SAY THE HE CODED THE AMAZING BOOT-SECTOR"
	DC.B 	" (YES, LAMERS, THE BIG-SCROLL WAS A BOOT-SECTOR!!!!)"
	DC.B	"          "
	DC.B	" I HAD SOMETHING REALLY IMPORTANT TO SAY,"
	DC.B	" SOMETHING I THOUGHT EVERYBODY SHOULD KNOW."
	DC.B	"          YOU ALL KNOW THE CUDDLY DEMO, AND, OF"
	DC.B	" COURSE, YOU ALL THINK THAT T.C.B MADE IT. BUT"
	DC.B	" IT ISN'T TRUE AT ALL! YES, IN FACT M C S  M A D E"
	DC.B	"  T H E  C U D L Y  D E M O !       BEFORE YOU"
	DC.B	" THINK I'M ONLY LYING (OR HAVE YOU ALREDY DONE IT?)"
	DC.B	" I WILL EXPLAIN WHAT HAPPENDED:  IN THOSE TIME, A SMALL"
	DC.B	" BUT DYNAMIC GROUP WAS BORN: IT WAS US, MCS. AND"
	DC.B	" WE STARTED A DEMO THAT, AT THE TIME, WOULD'VE BLASTED"
	DC.B	" ALL OTHER GROUPS... WE CALLED IT THE 'BLASTING DEMO'"
	DC.B	"    ALMOST ALL SCREENS WERE FINISHED, AND SO WE WENT"
	DC.B	" TO A FRIEND OF OURS (CALLED 'ZIGGYETTE' (HE WAS"
	DC.B	" GAY) ) TO SAVE ALL THE SOURCE-CODE, GFX AND MUSIX"
	DC.B	" ON HIS HARD DISK.     A WEEK LATER, WE WENT TO HIS"
	DC.B	" HOME, TO FINISH THE DEMO AND RELEASE IT, BUT HE"
	DC.B	" WASN'T THERE ANY MORE!!!! HE HAD MOVED, AND WE"
	DC.B	" NEVER SAW HIM SINCE... THEN, WHEN WE WENT BACK"
	DC.B	" TO OUR RESPECTIVE HOMES, WE ALL NOTICED THAT SOMEONE"
	DC.B	" HAD BROKEN INTO OUR HOMES: ALL THE SOURCE-CODE OF"
	DC.B	" OUR 'BLASTING DEMO' HAD BEEN STOLEN!... TWO MONTHS"
	DC.B	" LATER (WE WERE TRYING TO CODE OUR SCREENS ANEW)"
	DC.B	" WE RECIEVED A DEMO CALLED 'THE CUDDLY DEMO'."
	DC.B	" WE LOOKED AT IT, AND NEARLY DIED OF AN INFARCTUS"
	DC.B	": IT WAS OUR 'BLASTING DEMO' EXECPT THAT ALL THE"
	DC.B	" LOGOS 'BLASTING' HAD BEEN REPLACED BY 'CUDDLY',"
	DC.B	" ALL 'MCS' HAD BEEN REPLACED BY 'TCB' AND ALL"
	DC.B	" 'ALLIANCE' HAD BEEN REPLACED BY 'UNION'...     "
	DC.B	" YOU NOW KNOW THE TRUTH ON THOSE BASTARDS, LYING"
	DC.B	" CAREBEARS...                            "
	DC.B	" I BULLSHIT - IT'S MY JOB! (THE HOOLIGAN)      "
	DC.B	"       WE (THE HOO AND THE DRM) ARE SITTING IN MY"
	DC.B	" ROOM, LISTENING TO (OH YEAH!) 808 STATE, AND"
	DC.B	" I'M TYPING HIS TEXT (REALLY?) AND, OH BOY, AM"
	DC.B	" I BORED! SOMETHING GOOD ABOUT BEEING BORED IS"
	DC.B	" THAT I HAVE LOSDA BULLSHITTING IDEAS!!!!!      "
	DC.B	"    TO BULLSHIT OR NOT TO BULLSHIT, THAT IS THE"
	DC.B	" QUESTION!   IN FACT IT IS SUCH A GOOD QUESTION,"
	DC.B	" I WILL DISCUSS IT! WHY BULLSHIT? WELL, SOME PEOPLE"
	DC.B	" MAKE A LIVNG OUT OF BULLSHITTING (LIKE BUSH OR"
	DC.B	" THATCHER), AND SOME PEOPLE EVEN LOVE IT (LIKE"
	DC.B	" YOU WHO ARE READING THIS)...  OF COURSE, IF YOU"
	DC.B	" ASK A LAMER ABOUT IT, HE WILL ANSWER 'AKEU"
	DC.B	" MERDE DE TAUREAU, AKEU OUAIS' (THE KIND OF"
	DC.B	" ANSWER AN OVR WOULD GIVE)       "
	DC.B	" TALKING ABOUT LAMERS, I HAVE ABOUT 6 AMIGA-GAYS"
	DC.B	" IN MY CLASS, AND IT ISN'T A LEGEND : THEY REALLY"
	DC.B	" ARE S-T-U-P-I-D. I ASKED THEM IF THEY CODED, GRAPHED"
	DC.B	" OR MADE MUSIX, AND THEY LOOKED AT ME WITH THEIR"
	DC.B	" HOORIBLY MUTILATED EYES (THEY GET MUTILATED WHEN"
	DC.B	" YOU LOOK AT AN AMIGA) AND SAID : 'WOT'S THAT???'"
	DC.B	"                        "
	DC.B	" HEY, DO YOU KNOW WHAT HAPPEN AT AN MCS PARTY"
	DC.B	" WHEN ALCOOL AND GIRLS ARE AROUND???          "
	DC.B	" FIRST THE GIRLS:   ZORGLUB TRIES TO GET IN TOUCH"
	DC.B	" WITH EVERY ONE OF THEM (AND MISSES WITH EVERY ONE"
	DC.B	" OF THEM) , MEAT (OR WAS IT M.I.T?)"
	DC.B	" IS REALLY PANICKED BECAUSE HE THINKS ZORGLUB "
	DC.B	" IS FUCKING HIS GIRLFRIEND (WELL, WE DID HELP"
	DC.B	" HIM A BIT TO THINK SO...), AND WHEN WE PLAY"
	DC.B	" MAD MAX MUSIC, THEY ALL START TO DANCE (THE GIRLS"
	DC.B	" AND ZORGLUB, WHO IS TRYING TO SHOW OFF...)    "
	DC.B	"          NOW, THE ALCOOL: PF AND MAGNUM DRINK 16"
	DC.B	" LITERS OF BEER EACH IN THE NIGHT, THE DREAMER"
	DC.B	" DRINKS SOME WEIRD KINDA MIXUPS, AND THEN IS"
	DC.B	" TOTALY,MINDBOGINLY PISSED (READ SOME OTHER TEXTS"
	DC.B	" FOR SOME MORE DETAILS) AND THE HOOLIGAN DRINKS"
	DC.B	" COKE'N'ORANGE JUICE.....                  "
	DC.B	" HEY, DID YOU SEE THE 'PHYLOSOPHICAL DEMO' (THAT"
	DC.B	" SOME STUPID LAMER ALSO CALLED THE 'BORING DEMO')"
	DC.B	" ?   WHAT DID YOU THINK OF IT? (DID YOU SEE IT TILL"
	DC.B	" THE END???? IF SO, WELL DONE!) I THINK IT'S VERY"
	DC.B	" FUNNY, COZ EVERYONE GETS BORED WATCHING IT AND"
	DC.B	" START TO SAY 'RRRRAAAAHHHH' OR 'ET PUIS MERDE'"
	DC.B	" AND SO ON...                   "
	DC.B	" IF YOU WANT SOME DIRTY SCROLL (I MEAN WITH LODSA"
	DC.B	" 'I WANNA FUCK HER BIG, SEXY ARSE! I WAN' HER TO"
	DC.B	" SUCK MY DICK!') , GO AND READ THE BIG (OR WAS IT"
	DC.B	" LONG?) SCROLL, IT'S FULL OF IT!!            "
	DC.B	"      YOU KNOW, I THINK DAVID BOWIE (WHO IS, I THINK"
	DC.B	" A VERY GOOD SINGER,MUSCIAN,ACTOR) SHOULD SUE"
	DC.B	" OVERREPIQUERS FOR USING (AND DEGRADING) THE"
	DC.B	" NAME OF 'ZIGGY STARDUST'. I MEAN, IF MCS HAD USED"
	DC.B	" THE NAME 'ZIGGY STARDUST', DAVID BOWIE WOULD BE"
	DC.B	" PROUD, BUT HE MUST BE ASHAMED THAT OVR USED IT!"
	DC.B	"      THIS GAVE ME A GOOD IDEA: LET'S GET OVR DOWN!"
	DC.B	"......EUH.....WELL.....I THINK IT'S HARD TO GET"
	DC.B	" THEM DOWNER THAN THEY ARE ALLREADY! DID YOU KNOW"
	DC.B	" THAT OVR'S ONLY INVENTION IS NEGATIVE QI?"
	DC.B	" THEY ARE SO STUPID, THAT NEGATIVE QI HAD TO BE"
	DC.B	" INVENTED TO SHOW WHAT THEY WERE!         "
	DC.B	" I HAVE AN INTERRESTING QUIZ: WHAT IS YOUR"
	DC.B	" FAVORITE ENGLISH WORD? I BET YOU NEVER THOUGHT OF IT!"
	DC.B	" MMHHH?.......WELL, MY FAVORITE WORD IS 'NEVERTHELESS'"
	DC.B	"    ISN'T IT A GREAT WORD? NEVERTHELESSNEVERTHELESS"
	DC.B	"NEVERTHELESSNEVERTHELESS...WOW! THAT WAS GOOOOD!"
	DC.B	" MORE ! GIVE ME MORE! CHANGE THE WAVE SO IT GOES"
	DC.B	" SLOWER... NEVERTHELESSNEVERTHELESSNEVERTHELESS"
	DC.B	"NEVERTHELESSNEVERTHELESS...YYYYEEEEAAAAHHHH!"
	DC.B	" WOWOWOWOW! I THINK I'M GONNA QUIT MCS AND CREATE"
	DC.B	" A GROUP CALLED 'THE NEVERTHELESSERS'! "
	DC.B	"    AND OUR MOTO COULD BE 'NEVERTHELESSITY IS"
	DC.B	" OUR POLICY'    YEAH!   OR EVEN BE''ER...LET MA"
	DC.B	" THINK......SOMETHIN' LIKE.... 'THE NEVERTHELESSERS"
	DC.B	" ARE BETTER THAN THE OTHERS'! WHAT DO THINK OF THAT,"
	DC.B	" MMHHH? I WOULD CHANGE MY NAME TO THE"
	DC.B	" HOONEVERTHELESSERLIGAN!!!! RIGH'! AND OUR FIRST DEMO"
	DC.B	" WOULD BE 'TEN WAYS OF NEVERTHELESSING AN ST OR"
	DC.B	" HOW TO CREATE TEN SCREENS WHERE THE WORD 'NEVERTHELESS"
	DC.B	" HAS SENCE'! OUR FIRST SCREEN WOULD START WITH A TEXT"
	DC.B	" SAYING 'THE ST IS GOOD...' AND A BIG 'NEVERTHELESS'"
	DC.B	" ,'IT CAN BE BAD' AND THEN, I WOULD SHOW AN OVR SCREEN!"
	DC.B	"     THE SECOND SCREEN WOULD START BY 'ALL DEMOS HAVE'"
	DC.B	" SCROLLS, BALLS 'N STARS' THEN A BIG 'NEVERTHELESS' , "
	DC.B	" 'I WILL DO IT AGAIN' THEN YOU WOULD SEE A 'CLASSICAL'"
	DC.B	" DEMO...   THE THIRD SCREEN WOULD GO...WELL, YOU"
	DC.B	" WILL DISCOVER, I MAKE THIS DEMO ONE DAY..."
	DC.B	"                            WHAT IS IT I CAN SEE"
	DC.B	" ON TOP OF THIS HILL, LIKE SOMEONE PUSHING THE SUN"
	DC.B	" BEHIND THE HILL...NIGHT FALLS, THIS THING SITS DOWN..."
	DC.B	" IT DOESN'T MOVE...I CAN SEE WOLVES... THEY"
	DC.B	" ARE SUROUNDING HIM... WHAT AM I DOING HERE? I SHOULD"
	DC.B	" GO AND HELP HIM... I CAN'T MOVE... THE WOLVES ARE COMMING"
	DC.B	" TOWARDS ME... I DONT'T WANNA MOVE...I AM NOT EVEN PANNICED"
	DC.B	"... THEY DON'T SEEM AGRESSIVE... THEY JUST GO BYE ME..."
	DC.B	" MORNING COMES, AND THE THING IS STILL THERE... NOW"
	DC.B	" IT IS PULLING THE SKY TO LET THE SUN COME...IT MUST"
	DC.B	" BE GOD...BIRDS FLY AROUND HIM ALL DAY...HE DOEN'T"
	DC.B	" EAT...NEITHER DO I, IN FACT... WHAT IS IT? AND"
	DC.B	"...WHERE AM I? HOW DID GET THERE? ALL REMEBER WAS"
	DC.B	" THAT I WAS DRIVUNG IN A CAR...DRIVING FAST...AND"
	DC.B	" THEN NOTHING...MY MEMORIES SEEM TO COME BACK..."
	DC.B	" COULD IT BE THAT I'M DEAD? AND THAT THIS HEAVEN?"
	DC.B	" OR MAYBE HELL... HEY, THE THING IS MOVING..."
	DC.B	" IT'S COMMING TOWARDS ME....IT LOOKS LIKE A MAN"
	DC.B	" WITH 50 MILLION HEADS...I CAN'T TALK!...WHAT"
	DC.B	" IS HE WEARING? AN...AN MCS TSHIRT! THEN THIS MUST"
	DC.B	" BE H E A V E N....HE IS TALKING TO ME...I CANT'T"
	DC.B	" UNDERSTAND...50 MILLION HEADS TALKING TOGETHER"
	DC.B	" MAKE A LOT OF NOISE...I MANAGED TO HEAR 'I DECIDED"
	DC.B	" TO SEND YOU TO'...TO WHAT?...NO! NOT TO HELL!"
	DC.B	" NNNNNOOOOOOOOOO!!! ........... WHERE AM I? OH NO!"
	DC.B	" AN OVR LOGO! I AM IN H E L L!!!!!REDFHQDQDFQD    "
	DC.B	"                       "
	DC.B	" DO YOU KNOW WE HAVE A FEMALE MEMBER CALED CLOTILDE?"
	DC.B	" WELL, SHE REALLY DOESN'T KNOW A THING ABOUT BULLSHIT!"
	DC.B	" IT WAS AT AXEL'S, AND MAGNUM WAS SHOWING US HIS"
	DC.B	" VECTORBALL, BUT AS AXEL'S SCREEN IS BIG, WE COULDN'T"
	DC.B	" SEE THE LOWER BORDER WHERE THE TEXT WAS. SO SHE"
	DC.B	" ASKED MAGNUM TO TELL US WHAT WAS WRITTEN. OF COUSE,"
	DC.B	" MAG(2) SAID 'NO!'... BUT CLO WOULDN'T UNDERSTAND"
	DC.B	" THAT BULLSHIT HAS TO BE READ, NOT HEARD!!!! I HOPE"
	DC.B	" YOU UNDERSTAND!"
	DC.B	"                 IN MY LIFE I READ ALL SCROLLS I WAS"
	DC.B	" GIVEN EXEPT ONE...THE ONE OF THE 'OH CRAKER, WHAT A"
	DC.B	" SURFER!' THAT IS CALLED 'CARS, YOU STUPID ASSHOLE!'"
	DC.B	" WHERE YOU HAVE A VECTOR BALL SCROLL THAT SPINS AROUND!"
	DC.B	" HOPEFULLY, THE 'WHERE AM I?IN WHICH SHELF ?' BOYS WERE"
	DC.B	" SO STUPID THEY DIDN'T CRIPT IT, SO I JUST HAD TO READ"
	DC.B	" THE MEMORIE... WE CRIPT ALL OF OUR TEXTS! LOOK:"
	DC.B	" DLTFGHQDTGHQDFTGHD,SJ?VBNERID!FGFQDTFGHQMRHUDF"
	DC.B	" HA! SO, YOU SEE! WE NOT STUPID!             "
	DC.B	" BY THE WAY, DO YOU KNOW WHERE THE HIDDEN SCREEN OF"
	DC.B	" THE 'OH! FOOTBALL, WOT A SCORE!TCHER' (THE 'TCHER'"
	DC.B	" WAS ME SNEEZING!).... WELL, I WILL TELL YOU WERE THE"
	DC.B	" HIDDEN SCREEN IS: (WE HAD TO CRACK THE DEMO TO FIND IT)"
	DC.B	" FIRST, TYPE 'THE LOST BOYS WILL NOT LET YOU GET TO THIS"
	DC.B	" HIDDEN SCREEN EASILY' THEN YOU GO AT FULLSPEED (PRESSING"
	DC.B	" ENTER) AND GO THREE TIMES ROUND THE LEVEL!    I KNOW"
	DC.B	" THIS IS HARD WORK, BUT IT REALLY IS WORTH IT! COZ THE"
	DC.B	" HIDDEN SCREEN IS GOOD! (IT WAS A SCREEN WE MADE FOR OUR"
	DC.B	" 'BLASTING DEMO' AND THAT WASN'T INCLUDED IN THE 'CUDDLY"
	DC.B	" DEMO' (WE ALWAYS WONDERED WHY, WE GOT THE ANSWER WHEN WE SAW"
	DC.B	" THE 'OH! FUCKER WOT AN ASSHOLE!') AND THE SECOND ONE"
	DC.B	" PLEASE...)      I HOPE YOU NOTICED THE DIFFERENCE: NOW,"
	DC.B	" I'M NOT ONLY BULLSHITING, I'M DELIRIOUS!!!! (WELL, I'M AN MCS"
	DC.B	" AREN'T I?)                   I JUST HAD AN IDEA:"
	DC.B	" I WILL GIVE ALL THE MEANINGS I KNOW FOR MCS:"
	DC.B	"     MOUVEMENT DES CODERS SAOULS - MEGA CASSOULET SEMOULE"
	DC.B	" - MASTER CODER'S SECT - MEDITERANEEN CAMPING SOCIETY -"
	DC.B	" - MINABLE CONNARD SALOP (DEDICATED TO OVR) -"
	DC.B	" MAIS CONCOMBRE SALADE - MIT COMME SLASH -"
	DC.B	" MONTAGNE CAMPAGNE SUD - MONTER CARRESSER SUCER -"
	DC.B	" MELLIFLUENCE CLIMACTERIC SMITHEREENS - MANNY CLIMAX, SUCKER"
	DC.B	"- MORE COMMING SHIT - (BULL, OF COURSE)-MERCI CLOTILDE POUR LA SODOMIE"
	DC.B	" I HAVE MANY MORE IDEAS, BUT I GUESS YA BORED...."   
	DC.B	"             DIM DA DA TSOIN STOIN... I WONDER WHY I TYPE"
	DC.B	" ALL DIS, COZ YOU HAVE TO BE MCS TO UNDERSTAND...    "
	DC.B	"ZORG ON ZIS FUCKIN' KIBORD:WELL I MUST SAY ZAT THE HOO IS TOTALLY"
	DC.B	" RIGHT SAYING ZAT SQUAREBEERS HAD STOLEN OUR CODE FOR ZE BLASTIN'DEMO"
	DC.B	" NOW WE ARE GONNA  TALK ABOUT THIS SCREEN.DON'T U SINK IT IZ LAME?"
	DC.B	" OEUF CORSE IT IZ THE BRAMEUR WOUH HAD CODED EAT WELL FUCK U I LET ZE KIBORD "
	DC.B	" TOU MAKNEUM"
	DC.B	" YEAAAH I'TS MAGNUM ON THE KEYBOARD... I'M GOING TO BULLSHIT... "
	DC.B	" FIRST OF ALL I WANNA SAY A WORD ABOUT SALAMANDRE DEVELOPMENT."
	DC.B	" IT IS COMPOSED OF TWO CREWS (IF WE CAN CALL THEM CREW !!!) WICH ARE : "
	DC.B	" ROLLERSUCKERS AND TEN DRAGONS. THE LAMEST CREWS EVER MADE.. "
	DC.B	" WE ARE AT P.F.'S HOME PLAYING A STANGE GAME : WHEN SOMEONE BURPS YOU MUST PUT YOUR "
	DC.B	"FINGER ON YOUR FRONTHEAD. IF YOU DON'T THE OTHERS HIT YOU... IT'S A SILLY GAME... "
	DC.B	" THE HOOLIGAN IS COMPLETLY DRUNK BUT HE HASN'T DRINKED A GLASS.. STRANGE GUY."
	DC.B	" GADGET HAS ARRIVED AND P.F. IS IMITATING A MONKEY. NOW SOME WORDS ABOUT ZORGLUB..."
	DC.B	" HE'S A VERY STRANGE GUY. HE WANTS MANY GIRLS BUT HE HAS NONE !!! "
	DC.B	" IF HE HAD A BIG ZOB (AS ME) HE WOULD HAVE LOTSA GIRLS... (45 CM / 10 CM) "
	DC.B	"   ALL THE PEOPLE HERE ARE SO DELIRIOUS.. TORTUE GENIALE IS HERE. HE'S THE GUY WHO WAS TWELVE HOURS ON THE"
	DC.B	" ARCHIMEDE AND WHO ONLY ARRIVED TO USE THE MOUSE.. HE SAID HE'LL MAKE US A SCREEN IS STOS "
	DC.B	"ON FX 7000G. IT'S NOW 11:51:52 SECONDS   53 SECONDS   54 SECONDS  55 SECONDS.. ETC. "
	DC.B	" OK I LEAVE THE KEYBOARD COZ I'VE GOT TO FINISH MY BEER (PELFORHT BRUNE) "
	DC.B	" AND REMEMBER : AXEL F. SAYS : 'FUCK TO GRENOUILLE DEVELOPMENT'. "
	DC.B	" NOW IT'S STEVE, THE WORST CODER OF M.C.S.(NOT OF THE HOOLIGAN: HE'S SO BAD, HE THINKS MOVE.L (A0)+,-(A0)"
	DC.B	" IS USEFULL!!! - END OF NOTE) "
	DC.B	" I'M AXEL'S BROTHER, AND I LIKE BEER AND GIRL LIKE HIM (NOT POSSIBLE SAID MAGNUM!)"
	DC.B	" WE'RE IN P.F.'S HOUSE AND A LOT OF PEOPLE DRINK A LOT"
	DC.B	" ZORGLUB IS SEARCHING SINCE A LOT OF YEARS A GIRL, BUT HE NEVER SAW THAT ONLY DUB'S LOVE HIM"
	DC.B	" ALL M.C.S TOLD ME THAT THE OVR WAS VERY GOOD THE TWO FIRST SECONDS THEY EXIST"   
	DC.B 	"      NOW, I SHOW WHAT MCS COULD MEAN, LET'S SEE ABOUT OTHER GROUPS...         "
	DC.B	"      ST CONNEXION (DES MECS QUI EN ON PAS!) - T'ES PD (TPD - THE PENDRAGONS)"
	DC.B	" STUPIDGUYS (OVERLANDERS...SO MANY NAMES WERE USED FOR THOS BASTARDS, I THOUGHT THIS"
	DC.B	" WAS THE ONLY ORIGINAL STUFF....) - HAHA! I WILL INTERUPT THIS FOR THE LATEST NEWS "
	DC.B	": AXEL JUST PUT DUBS JEANS AND PANTS DOWN IN FRONT EVERYBODY... NOW WE'RE STARTING TO GET"
	DC.B	" AXEL UNDRESSED....BUT...WHERE'S HIS DICK? I CAN'T SEE IT! MAYBE HE DOESN'T HAVE ONE..."
	DC.B	" NOW ZORGLUB IS FUCKING DUBS IN FRONT OF ME! YUCK! WELL, I DID WONDER WHAT THEY WERE DOIN'"
	DC.B	" WITH GADGET IN ZE ROOM...HOOO! I MUSN'T MAKE A BIGLONGWIERDSLOWSCROLL AGAIN! THIS ONE IS"
	DC.B	" VERY DIRTY... RIGHT, LET'S CARRY ON WITH A FRIEND OF OURS: MIT OF NUL EMERDANT XENOPHOBE TACITURNE"
	DC.B	" (NEXT)... HERE ALL THE NAMES WE FOUND FOR HIM... HAHA! STOP ALL! MORE NEWS: MIT HAS JUST BEEN RAPPED"
	DC.B	" BY ZORGLUB... NOW LET'S CARRY ON WITH MIT...- MEAT WORM, Y'S MARE MIT, MITWOCH , MESSERSCH-MIT,"
	DC.B	" MIT ERRANT, MIT HAINE, MIT OSE , MIT RALE, MIT RAILLE, MIT ROND, MIT SOUS BICHI(A GIRL WE KNOW...),"
	DC.B	" DE L'AIR MIT, MIT AU LOGIS , MIT AUX TIQUES, DIM MIT RIENT, MIT ING AERE RIEN, MIT IGER, EDDY MIT CHEVRE,"
	DC.B	" MIT'PAIN, T'ERRES MIT, MON ST MIT CHELLE, MIT TARD, SPOUT-MIT, ROBERT MIT-CHUM, MIT TU TA MAIN OU JE PENSE?,"
	DC.B	" MITU M'INERVER, SOT MIT EST, SODO-MIT, FAUDRAIT PAS DEPASSER LE LIT MIT...WE ARE BEGINING TO BE OUT OF INSPIRATION...",$F

	EVEN
BUFFER_TXT:	DCB.B	640,0	;buffer pour affichage scrool text
		;pour une vbl (calcule en temps reele.)
	EVEN
TAB_HARD:	INCLUDE	"TAB_HAR2.BLK"

;8 VERSION PRE-DECALER-DU LOGO M-C-S(RASTERS) =>24*8
D_0:	DC.W	$000,$000,$200,$300,$300,$200,$000,$000
	DC.W	$000,$200,$400,$400,$400,$400,$200,$000
	DC.W 	$200,$400,$005,$500,$500,$005,$400,$200
	DC.W 	$300,$400,$005,$007,$007,$005,$500,$400
	DC.W 	$300,$400,$005,$700,$600,$005,$500,$400
	DC.W 	$200,$400,$005,$600,$600,$005,$500,$200
	DC.W 	$000,$200,$400,$500,$500,$500,$200,$000
	DC.W 	$000,$000,$200,$300,$300,$200,$000,$000
	DC.W 	$000,$000,$220,$330,$330,$220,$000,$000
	DC.W 	$000,$220,$440,$440,$440,$440,$220,$000
	DC.W 	$220,$440,$005,$007,$007,$005,$440,$220
	DC.W 	$330,$440,$005,$770,$770,$660,$550,$440
	DC.W 	$330,$440,$005,$770,$660,$660,$550,$440
	DC.W 	$220,$440,$005,$007,$007,$005,$550,$220
	DC.W 	$000,$220,$440,$550,$550,$550,$220,$000
	DC.W 	$000,$000,$220,$330,$330,$220,$000,$000
	DC.W 	$000,$000,$020,$030,$030,$020,$000,$000
	DC.W 	$000,$020,$040,$040,$040,$040,$020,$000
	DC.W 	$020,$040,$005,$007,$007,$005,$040,$020
	DC.W 	$030,$040,$050,$007,$070,$060,$050,$040
	DC.W 	$030,$040,$050,$070,$007,$060,$050,$040
	DC.W 	$020,$040,$005,$007,$007,$005,$050,$020
	DC.W 	$000,$020,$040,$050,$050,$050,$020,$000
	DC.W 	$000,$000,$020,$030,$030,$020,$000,$000

D_1:	DC.W 	$000,$200,$300,$300,$200,$000,$000,$000
	DC.W 	$200,$400,$400,$400,$400,$200,$000,$000
	DC.W 	$400,$005,$500,$500,$005,$400,$200,$200
	DC.W 	$400,$005,$007,$007,$005,$500,$400,$300
	DC.W 	$400,$005,$700,$600,$005,$500,$400,$300
	DC.W 	$400,$005,$600,$600,$005,$500,$200,$200
	DC.W 	$200,$400,$500,$500,$500,$200,$000,$000
	DC.W 	$000,$200,$300,$300,$200,$000,$000,$000
	DC.W 	$000,$220,$330,$330,$220,$000,$000,$000
	DC.W 	$220,$440,$440,$440,$440,$220,$000,$000
	DC.W 	$440,$005,$007,$007,$005,$440,$220,$220
	DC.W 	$440,$005,$770,$770,$660,$550,$440,$330
	DC.W 	$440,$005,$770,$660,$660,$550,$440,$330
	DC.W 	$440,$005,$007,$007,$005,$550,$220,$220
	DC.W 	$220,$440,$550,$550,$550,$220,$000,$000
	DC.W 	$000,$220,$330,$330,$220,$000,$000,$000
	DC.W 	$000,$020,$030,$030,$020,$000,$000,$000
	DC.W 	$020,$040,$040,$040,$040,$020,$000,$000
	DC.W 	$040,$005,$007,$007,$005,$040,$020,$020
	DC.W 	$040,$050,$007,$070,$060,$050,$040,$030
	DC.W 	$040,$050,$070,$007,$060,$050,$040,$030
	DC.W 	$040,$005,$007,$007,$005,$050,$020,$020
	DC.W 	$020,$040,$050,$050,$050,$020,$000,$000
	DC.W 	$000,$020,$030,$030,$020,$000,$000,$000

D_2:	DC.W 	$200,$300,$300,$200,$000,$000,$000,$000
	DC.W 	$400,$400,$400,$400,$200,$000,$000,$200
	DC.W 	$005,$500,$500,$005,$400,$200,$200,$400
	DC.W 	$005,$007,$007,$005,$500,$400,$300,$400
	DC.W 	$005,$700,$600,$005,$500,$400,$300,$400
	DC.W 	$005,$600,$600,$005,$500,$200,$200,$400
	DC.W 	$400,$500,$500,$500,$200,$000,$000,$200
	DC.W 	$200,$300,$300,$200,$000,$000,$000,$000
	DC.W 	$220,$330,$330,$220,$000,$000,$000,$000
	DC.W 	$440,$440,$440,$440,$220,$000,$000,$220
	DC.W 	$005,$007,$007,$005,$440,$220,$220,$440
	DC.W 	$005,$770,$770,$660,$550,$440,$330,$440
	DC.W 	$005,$770,$660,$660,$550,$440,$330,$440
	DC.W 	$005,$007,$007,$005,$550,$220,$220,$440
	DC.W 	$440,$550,$550,$550,$220,$000,$000,$220
	DC.W 	$220,$330,$330,$220,$000,$000,$000,$000
	DC.W 	$020,$030,$030,$020,$000,$000,$000,$000
	DC.W 	$040,$040,$040,$040,$020,$000,$000,$020
	DC.W 	$005,$007,$007,$005,$040,$020,$020,$040
	DC.W 	$050,$007,$070,$060,$050,$040,$030,$040
	DC.W 	$050,$070,$007,$060,$050,$040,$030,$040
	DC.W 	$005,$007,$007,$005,$050,$020,$020,$040
	DC.W 	$040,$050,$050,$050,$020,$000,$000,$020
	DC.W 	$020,$030,$030,$020,$000,$000,$000,$000

D_3:	DC.W 	$300,$300,$200,$000,$000,$000,$000,$200
	DC.W 	$400,$400,$400,$200,$000,$000,$200,$400
	DC.W 	$500,$500,$005,$400,$200,$200,$400,$005
	DC.W 	$007,$007,$005,$500,$400,$300,$400,$005
	DC.W 	$700,$600,$005,$500,$400,$300,$400,$005
	DC.W 	$600,$600,$005,$500,$200,$200,$400,$005
	DC.W 	$500,$500,$500,$200,$000,$000,$200,$400
	DC.W 	$300,$300,$200,$000,$000,$000,$000,$200
	DC.W 	$330,$330,$220,$000,$000,$000,$000,$220
	DC.W 	$440,$440,$440,$220,$000,$000,$220,$440
	DC.W 	$007,$007,$005,$440,$220,$220,$440,$005
	DC.W 	$770,$770,$660,$550,$440,$330,$440,$005
	DC.W 	$770,$660,$660,$550,$440,$330,$440,$005
	DC.W 	$007,$007,$005,$550,$220,$220,$440,$005
	DC.W 	$550,$550,$550,$220,$000,$000,$220,$440
	DC.W 	$330,$330,$220,$000,$000,$000,$000,$220
	DC.W 	$030,$030,$020,$000,$000,$000,$000,$020
	DC.W 	$040,$040,$040,$020,$000,$000,$020,$040
	DC.W 	$007,$007,$005,$040,$020,$020,$040,$005
	DC.W 	$007,$070,$060,$050,$040,$030,$040,$050
	DC.W 	$070,$007,$060,$050,$040,$030,$040,$050
	DC.W 	$007,$007,$005,$050,$020,$020,$040,$005
	DC.W 	$050,$050,$050,$020,$000,$000,$020,$040
	DC.W 	$030,$030,$020,$000,$000,$000,$000,$020

D_4:	DC.W 	$300,$200,$000,$000,$000,$000,$200,$300
	DC.W 	$400,$400,$200,$000,$000,$200,$400,$400
	DC.W 	$500,$005,$400,$200,$200,$400,$005,$500
	DC.W 	$007,$005,$500,$400,$300,$400,$005,$007
	DC.W 	$600,$005,$500,$400,$300,$400,$005,$700
	DC.W 	$600,$005,$500,$200,$200,$400,$005,$600
	DC.W 	$500,$500,$200,$000,$000,$200,$400,$500
	DC.W 	$300,$200,$000,$000,$000,$000,$200,$300
	DC.W 	$330,$220,$000,$000,$000,$000,$220,$330
	DC.W 	$440,$440,$220,$000,$000,$220,$440,$440
	DC.W 	$007,$005,$440,$220,$220,$440,$005,$007
	DC.W 	$770,$660,$550,$440,$330,$440,$005,$770
	DC.W 	$660,$660,$550,$440,$330,$440,$005,$770
	DC.W 	$007,$005,$550,$220,$220,$440,$005,$007
	DC.W 	$550,$550,$220,$000,$000,$220,$440,$550
	DC.W 	$330,$220,$000,$000,$000,$000,$220,$330
	DC.W 	$030,$020,$000,$000,$000,$000,$020,$030
	DC.W 	$040,$040,$020,$000,$000,$020,$040,$040
	DC.W 	$007,$005,$040,$020,$020,$040,$005,$007
	DC.W 	$070,$060,$050,$040,$030,$040,$050,$007
	DC.W 	$007,$060,$050,$040,$030,$040,$050,$070
	DC.W 	$007,$005,$050,$020,$020,$040,$005,$007
	DC.W 	$050,$050,$020,$000,$000,$020,$040,$050
	DC.W 	$030,$020,$000,$000,$000,$000,$020,$030

D_5:	DC.W 	$200,$000,$000,$000,$000,$200,$300,$300
	DC.W 	$400,$200,$000,$000,$200,$400,$400,$400
	DC.W 	$005,$400,$200,$200,$400,$005,$500,$500
	DC.W 	$005,$500,$400,$300,$400,$005,$007,$007
	DC.W 	$005,$500,$400,$300,$400,$005,$700,$600
	DC.W 	$005,$500,$200,$200,$400,$005,$600,$600
	DC.W 	$500,$200,$000,$000,$200,$400,$500,$500
	DC.W 	$200,$000,$000,$000,$000,$200,$300,$300
	DC.W 	$220,$000,$000,$000,$000,$220,$330,$330
	DC.W 	$440,$220,$000,$000,$220,$440,$440,$440
	DC.W 	$005,$440,$220,$220,$440,$005,$007,$007
	DC.W 	$660,$550,$440,$330,$440,$005,$770,$770
	DC.W 	$660,$550,$440,$330,$440,$005,$770,$660
	DC.W 	$005,$550,$220,$220,$440,$005,$007,$007
	DC.W 	$550,$220,$000,$000,$220,$440,$550,$550
	DC.W 	$220,$000,$000,$000,$000,$220,$330,$330
	DC.W 	$020,$000,$000,$000,$000,$020,$030,$030
	DC.W 	$040,$020,$000,$000,$020,$040,$040,$040
	DC.W 	$005,$040,$020,$020,$040,$005,$007,$007
	DC.W 	$060,$050,$040,$030,$040,$050,$007,$070
	DC.W 	$060,$050,$040,$030,$040,$050,$070,$007
	DC.W 	$005,$050,$020,$020,$040,$005,$007,$007
	DC.W 	$050,$020,$000,$000,$020,$040,$050,$050
	DC.W 	$020,$000,$000,$000,$000,$020,$030,$030

D_6:	DC.W 	$000,$000,$000,$000,$200,$300,$300,$200
	DC.W 	$200,$000,$000,$200,$400,$400,$400,$400
	DC.W 	$400,$200,$200,$400,$005,$500,$500,$005
	DC.W 	$500,$400,$300,$400,$005,$007,$007,$005
	DC.W 	$500,$400,$300,$400,$005,$700,$600,$005
	DC.W 	$500,$200,$200,$400,$005,$600,$600,$005
	DC.W 	$200,$000,$000,$200,$400,$500,$500,$500
	DC.W 	$000,$000,$000,$000,$200,$300,$300,$200
	DC.W 	$000,$000,$000,$000,$220,$330,$330,$220
	DC.W 	$220,$000,$000,$220,$440,$440,$440,$440
	DC.W 	$440,$220,$220,$440,$005,$007,$007,$005
	DC.W 	$550,$440,$330,$440,$005,$770,$770,$660
	DC.W 	$550,$440,$330,$440,$005,$770,$660,$660
	DC.W 	$550,$220,$220,$440,$005,$007,$007,$005
	DC.W 	$220,$000,$000,$220,$440,$550,$550,$550
	DC.W 	$000,$000,$000,$000,$220,$330,$330,$220
	DC.W 	$000,$000,$000,$000,$020,$030,$030,$020
	DC.W 	$020,$000,$000,$020,$040,$040,$040,$040
	DC.W 	$040,$020,$020,$040,$005,$007,$007,$005
	DC.W 	$050,$040,$030,$040,$050,$007,$070,$060
	DC.W 	$050,$040,$030,$040,$050,$070,$007,$060
	DC.W 	$050,$020,$020,$040,$005,$007,$007,$005
	DC.W 	$020,$000,$000,$020,$040,$050,$050,$050
	DC.W 	$000,$000,$000,$000,$020,$030,$030,$020

D_7:	DC.W 	$000,$000,$000,$200,$300,$300,$200,$000
	DC.W 	$000,$000,$200,$400,$400,$400,$400,$200
	DC.W 	$200,$200,$400,$005,$500,$500,$005,$400
	DC.W 	$400,$300,$400,$005,$007,$007,$005,$500
	DC.W 	$400,$300,$400,$005,$700,$600,$005,$500
	DC.W 	$200,$200,$400,$005,$600,$600,$005,$500
	DC.W 	$000,$000,$200,$400,$500,$500,$500,$200
	DC.W 	$000,$000,$000,$200,$300,$300,$200,$000
	DC.W 	$000,$000,$000,$220,$330,$330,$220,$000
	DC.W 	$000,$000,$220,$440,$440,$440,$440,$220
	DC.W 	$220,$220,$440,$005,$007,$007,$005,$440
	DC.W 	$440,$330,$440,$005,$770,$770,$660,$550
	DC.W 	$440,$330,$440,$005,$770,$660,$660,$550
	DC.W 	$220,$220,$440,$005,$007,$007,$005,$550
	DC.W 	$000,$000,$220,$440,$550,$550,$550,$220
	DC.W 	$000,$000,$000,$220,$330,$330,$220,$000
	DC.W 	$000,$000,$000,$020,$030,$030,$020,$000
	DC.W 	$000,$000,$020,$040,$040,$040,$040,$020
	DC.W 	$020,$020,$040,$005,$007,$007,$005,$040
	DC.W 	$040,$030,$040,$050,$007,$070,$060,$050
	DC.W 	$040,$030,$040,$050,$070,$007,$060,$050
	DC.W 	$020,$020,$040,$005,$007,$007,$005,$050
	DC.W 	$000,$000,$020,$040,$050,$050,$050,$020
	DC.W 	$000,$000,$000,$020,$030,$030,$020,$000
	
PAL_1:	DC.W	$776,$654,$543,$431,$321,$210
PAL_2:	DC.W	$076,$054,$043,$031,$021,$010
PAL_3:	DC.W	$706,$604,$503,$401,$301,$200
PAL_4:	DC.W	$770,$650,$540,$430,$320,$210
PAL_5:	DC.W	$777,$666,$555,$444,$333,$222
	
ADR_ECR:	DC.W	0	
	END	
