*** 'MAIN MENU' BY THE DREAMER FROM.C.S FOR MEGA DELIRIUM DEMO IV
*A6-D7=>ALF_TRACK 

*note pour altair:
*j'utilise aucun trap sauf pour le supervieur et la fin du programme
*mon adresse ecran est calculer sur le premmier multiple 
*	de 256oct apres ma source.
*pour les sauvergardes et restitution des interupts
*	ils son clairement indiqu‚es. 
*la demo selectinonn‚ est contenue dans l'adresse en mots
*	citu‚ au label "DEMO_SELECT.W"

**** DE 0-22 
*WIGGLE IT=>0
*NO SCROOL=>1
*KB-JARDIN=>2
*GENUMAX  =>3	
*NGC      =>4
*CHROMAX  =>5
*HLM DEMO =>6	
*DEL3 EMUL=>7
*VODKA    =>8
*TMF      =>9
*TBC      =>10
*STONE AGE=>11	;PF
*PUSH IT  =>12	
*CULUMNS  =>13
*LEMMING FUCK=>14
*LU       =>15	;TRHUD
*TEKILA   =>16
*BORING   =>17	;alias philosophical demo
*NIGHTMARE=>18	;si problemme memoire=>EN FAIRE UNE DEMO POUR 1040ST (en rajoutent sur le logo du menu 'nightmare' le signe 1040.
*MUFE     =>19	
*HARDCOPY =>20	;TON COPIEUR!
*90deg    =>21
*RASOIRE  =>22	;PAUSE DEMO

*S'il etais possible que tu indique le non de la drive A ou B ou meme C en indice sur les portes des ecrans.
* POUR CELA IL FAUT MODIFIER L'IMAGE PI1(LES NONS DES ECRANS SEULEMENT SANS LES CHANGERS DE PLACE)
* 'BLKMEN.PI1' ET ASSEMBLER LE PROGRAMME SAVE_DEC.S.
* ET LA SAUVERGADE DES NOUVEAUX BLOCK CE FERAS AUTOMATIQUEMENT.

*SI PROBLEMMES TELEPHONNE AU 40-50-25-21(THE DREAMER IT'S ME)
*		   DEMENDER PASCAL.

*bonnes change!, ta du travail en perspective! non?
*ESCUSE MOI POUR LES NONBREUSES FAUTES D'HORTHOGRAPHESSSS.

INIT:	PEA	$0		;SUPERVISEUR
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.W	#6,SP
	MOVE.W	#$2700,SR
	
	MOVEM.L	ZERO,D0-D7/A0-A6
	MOVEM.L	D0-D7,$FFFFF8240.W
		
	MOVE.B	#$02,$FFFFF820A.W	;50hz	
	MOVE.B	#$12,$FFFFFC02.W	;COUPE LA SOURIS
	
	LEA	SAVE,A0
	MOVE.L	$68.W,(A0)+
	MOVE.L	$70.W,(A0)+		;SAUVE L'ENCIEN VECTEUR VBL
	MOVE.L	$120.W,(A0)+		;LE TIMER-B
	MOVE.L	$118.W,(A0)+		;LE CLAVIER
	MOVE.L	$134.W,(A0)+		;LE CLAVIER
	MOVE.B	$FFFFFA07.W,(A0)+	;SAUVE INFORMATION
	MOVE.B	$FFFFFA09.W,(A0)+	;TIMER-A
	MOVE.B	$FFFFFA13.W,(A0)+	;AUTORISATION TIMER etc...
	MOVE.B	$FFFFFA17.W,(A0)+	;

	BCLR.B	#$03,$FFFFFA17.W	;FIN IT AUTOMATIQUE!
	MOVE.B	#$00,$FFFFFA09.W
	MOVE.B	#$01,$FFFFFA07.W
	MOVE.B	#$01,$FFFFFA13.W
	MOVE.B	#$00,$FFFFFA1B.W

	BSR	CALC_PHYS
	BSR	AFF_IMG	
	BSR	CLR_YM
	BSR	INTALLE_MUS
	
	MOVEM.L	ZERO,D0-D7/A0-A6
	MOVE.L	#ACTIF,$68.W
	MOVE.L	#VBL,$70.W		
	MOVE.L	#TIMER_B,$120.W	
	MOVE.L	#INACTIF,$118.W		
	MOVE.L	#INACTIF,$134.W		
	
	MOVE.L	#VBL_WAIT,$70.W
	STOP	#$2300
	MOVE.L	#VBL,$70.W

	STOP	#$2100
	STOP	#$2100
	MOVE.W	#$2300,SR
STOP:	BRA.S	STOP	
VBL_WAIT:	RTE	

****************************************************
AFF_IMG:	MOVE.L	PHYS,A2
	ADD.L	#230*50-96,A2

	MOVE.L	PHYS,A4
	ADD.L	#230*354-96,A4

	LEA	DESIGNE_LEV+(52*19),A0
	LEA	IMG_DECORE,A1
	MOVE.L	A1,A3

	MOVEQ	#18-1,D2
COLS:	MOVEQ	#13-1,D1
BLOCK_SI	MOVE.L	A3,A1
	ADD.L	(A0)+,A1
	MOVEQ	#16-1,D0
AFF_BLOCK:	MOVE.L	(A1),(A2)+
	MOVE.L	(A1)+,(A4)+
	
	MOVE.L	(A1),(A2)+
	MOVE.L	(A1)+,(A4)+
	
	MOVE.L	(A1),(A2)+
	MOVE.L	(A1)+,(A4)+
	
	MOVE.L	(A1),(A2)+
	MOVE.L	(A1)+,(A4)+
	
	LEA	230-16(A2),A2
	LEA	230-16(A4),A4
	DBRA	D0,AFF_BLOCK

	SUB.L	#230*16-16,A2
	SUB.L	#230*16-16,A4
	DBRA	D1,BLOCK_SI

	SUB.L	#(26*4),A0
	ADD.L	#230*15+6+16,A2	
	ADD.L	#230*15+6+16,A4	
	DBRA	D2,COLS
	RTS
	
****************************************************
CALC_PHYS:	MOVE.L	#ADR_ECR,D0	
	ST	D0
	ADDQ.W	#1,D0
	MOVE.L	D0,PHYS
	
	LEA	TAB_HARD,A0
	ADD.L	COUNT_HARD,A0
	ADD.L	24(A0),D0
	
	LSR.L	#$8,D0
	LEA	$FFFFF8201.W,A0
	MOVEP.W	D0,(A0)
	RTS

****************************************************
CLR_YM:	MOVE.L 	#$8080000,$FFFFF8820.W
	MOVE.L 	#$9090000,$FFFFF8820.W		
	MOVE.L	#$A0A0000,$FFFFF8820.W		
	MOVE.L 	#$707FFFF,$FFFFF8820.W		
	RTS

****************************************************
INTALLE_MUS:	BSR	MUSIC
	BSR	IT_MUSIC
	RTS

PLAY_ALF:   	CMPI.W	#18620/8,COUNT	
	BNE.S	NO_END_MUS
	BSR	MUSIC
	BSR	IT_MUSIC
	CLR.W	COUNT
	BRA.S	NO_PLAY
      	
NO_END_MUS:	MOVE.B	#0,CCR
	JSR	PLAY
	LEA	PRE_MUS,A0
	ADD.W	COUNT,A0
	
	MOVEQ	#0,D6
	MOVEQ	#0,D7
	MOVE.B	(A0),D7
	MOVE.W	DECBIT,D6
	LSL.W	D6,D7		
	BTST	#7,D7	
	BNE.S	LBL1
	MOVEQ	#0,D7
	BRA.S	LBL2
	
LBL1:	MOVEQ	#1,D7
LBL2:	ADDQ.W	#1,DECBIT
	CMPI.W	#8,DECBIT
	BNE.S	OCT_SUIV
	CLR.W	DECBIT
	ADDQ.W	#1,COUNT

OCT_SUIV:	MOVE.L   	DIGIT,A6
	TST.W	D7
	BNE.S	NO_PLAY
	MOVE.L	#NO_DIGIT,A6
NO_PLAY:	MOVE.W	D7,S_D7
	MOVEM.L	ZERO,D0-D7/A0-A5
	RTS

	EVEN
COUNT:	DC.W	0
DECBIT:	DC.W	0
DIGIT:	DS.L	1
NO_DIGIT:	DC.L	0
	INCLUDE	"MUSIC.BLK"
	DS.W	90
	EVEN
PRE_MUS:	INCBIN	"PREMUS.BIN"
	EVEN

****************************************************
INIT_PAL:	DCB.W	35+12,$4E71
	DCB.W	32,$4E71
	MOVEM.L	PAL,D0-D7
	MOVEM.L	D0-D7,(A3)
	MOVEQ	#0,D0
	MOVEQ	#0,D7
	MOVE.W	S_D7,D7
	RTS

****************************************************
FEED:	LEA	PAL,A0
	ADD.W	COUNT_FEED,A0

	MOVE.W	(A0),D0
	MOVE.W	D0,D1
	MOVE.W	D1,D2

	MOVEQ	#1,D3
NO_00X:	AND.W	#%00000000111,D0
	BEQ.S	NO_0X0
	SUB.W	D3,D0	

NO_0X0:	AND.W	#%00001110000,D1
	BEQ.S	NO_X00
	SUB.W	D3,D1	

NO_X00:	AND.W	#%11100000000,D2
	BEQ.S	NO_XXX
	SUB.W	D3,D2	
	
NO_XXX:	AND.W	#%00000000111,D0
	AND.W	#%00001110000,D1
	AND.W	#%11100000000,D2
	
	OR.W	D0,D1
	OR.W	D1,D2
	MOVE.W	D2,(A0)
	ADDQ.W	#2,COUNT_FEED
	AND.W	#30,COUNT_FEED
	
CUT_RTS:	LEA	RASTERS,A0
	LEA	END_RST+2,A1
	MOVE.L	A0,A2

	ADD.W	C_RST,A0
	SUB.W	C_RST,A1

	CMP.L	A1,A2
	BHS.S	FIN_CUT_RST
	CLR.W	(A0)
	CLR.W	(A1)
	ADDQ.W	#4,C_RST	
	RTS

FIN_CUT_RST:	MOVE.W	#$2700,SR
	JMP	FIN
	RTS

****************************************************
******************  ROUTINE VBL ********************
****************************************************

VBL:	MOVE.W	#$2700,SR
	MOVE.L	#TIMER_B,$120.W
	CLR.B	$FFFFFA1B.W
	MOVE.B	#100,$FFFFFA21.W
	MOVE.B	#4,$FFFFFA1B.W	
	
	JSR	PLAY_ALF
	JSR	GST_COMMAND	
	MOVEQ	#0,D0
	LEA	LED,A0
LED_ALF:	MOVE.B	#$A,$FFFF8800.W
	MOVE.B	$FFFF8800.W,D0
	MOVE.B	#14,$FFFF8800.W
	MOVE.B	(A0,D0.W),$FFFF8802.W
      	MOVE.W	#$2300,SR

	;MOVE.W	#$777,$FFFFF8240.W
	CMPI.B	#$01,$FFFFFC02.W
	BEQ.S	THE_END
	RTE
	
THE_END:	MOVE.W	#$2700,SR
	JMP	FIN

****************************************************
**** GESTION DU SCROOLING VERTICAL MULTI-SPEED *****
****************************************************
GST_COMMAND:	MOVEQ	#0,D1
	MOVE.L	COUNT_HARD,D0
	DIVU.W	#28,D0
	MOVE.W	D0,D1
	MULU.W	#230,D0
	MOVE.L	PHYS,A0
	SUB.L	D0,A0
	MOVE.L	A0,ADR_SPR

	ANDI.W	#15,D1
	MULU.W	#230,D1
	ADD.L	D1,A0	
	
	ADD.L	#230*300-176-230*(16+8)-16*230+230*29-230*14+230*48-128-16-6,A0
	MOVE.L	A0,NEW_PHYS_1	
	ADD.L	#230*304,A0
	MOVE.L	A0,NEW_PHYS_2
	
	JSR	TST_CLAV
	TST.W	STOP_C
	BEQ.S	NO_STOP_C
	CLR.L	CLAV_UP
	CLR.W	KEY
	JSR	FEED

NO_STOP_C:	TST.B	CLAV_UP
	BEQ.S	NO_UP
	CLR.B	CLAV_UP
	CMP.L	#14*28,SPEED
	BEQ.S	NO_UP
	ADD.L	#28,SPEED

NO_UP:	TST.B	CLAV_DOWN
	BEQ.S	NO_DOWN
	CLR.B	CLAV_DOWN
	CMPI.L	#-14*28,SPEED
	BEQ.S	NO_DOWN
	SUB.L	#28,SPEED

NO_DOWN:	TST.B	CLAV_LEFT
	BEQ.S	NO_LEFT
	TST.L	POS_X
	BEQ.S	NO_LEFT
	SUBQ.L	#4,POS_X
	CLR.B	CLAV_LEFT

NO_LEFT:	TST.B	CLAV_RIGHT
	BEQ.S	NO_RIGHT
	CMPI.L	#384,POS_X
	BEQ.S	NO_RIGHT
	ADDQ.L	#4,POS_X
	CLR.B	CLAV_RIGHT

NO_RIGHT:	TST.L	SPEED	  ;TEST SI VAISSEAU STATIONNE
	BNE.S	NO_STOP
	MOVE.L	SPEED_S,D0
	NEG.L	D0
	MOVE.L	D0,SPEED

NO_STOP:	CMPI.L	#26*(20*15)-2*26,COUNT_AFF	;TEST REBOND UP
	BLS.S	REBOND_1
	TST.L	SPEED
	BLT.S	REBOND_1
	NEG.L	SPEED		;SUB
	BRA.S	REBOND_2
	
REBOND_1:	CMPI.L	#26*18,COUNT_AFF	;TEST REBOND DOWN
	BHS.S	REBOND_2
	TST.L	SPEED
	BGT.S	REBOND_2
	NEG.L	SPEED		;ADD

REBOND_2:	MOVE.L	SPEED,D0
	MOVE.L	D0,SPEED_S

	MOVE.L	SPEED,D0
	ADD.L	D0,COUNT_HARD    
	ADD.L	D0,FLAG_AFF

	CLR.W	DEP_V
	MOVE.L	#DESIGNE_LEV,AUTO_MODIF+2
	TST.L	D0
	BGE.S	DEP_POS
	MOVE.L	#DESIGNE_LEV-52*17,AUTO_MODIF+2
	MOVE.W	#1,DEP_V

DEP_POS:	CMPI.L	#16*28,FLAG_AFF	;TEST DIRECTION HAUT
	BHS.S	BLOCK_S
	SUB.L	#16*28,FLAG_AFF
	ADD.L	#26,COUNT_AFF

BLOCK_S:	CMPI.L	#-16*28,FLAG_AFF	;TEST DIRECTION BAS
	BHS.S	BLOCK_S2
	ADD.L	#16*28,FLAG_AFF
	SUB.L	#26,COUNT_AFF

BLOCK_S2:	CMP.L	#16*28,COUNT_HARD	
	BHS.S	BLOCK_DOWN		
	ADD.L	#28*(320-16),COUNT_HARD
	
BLOCK_DOWN:	CMPI.L	#28*320,COUNT_HARD
	BLS.S	BLOCK_UP
	SUB.L	#28*(320-16),COUNT_HARD 
	
BLOCK_UP:	MOVE.L	POS_X,D0		;GST AFF_VAISSEAU
	MOVE.L	D0,D1
	LSR.W	#4,D0	;/16
	LSL.W	#3,D0	;*8
	MOVE.L	ADR_SPR,A0
	ADD.L	D0,A0	
	ADD.L	#230*(353+115-64)-96,A0
	ADD.L	D0,D0
	SUB.L	D0,D1	
	LSR.W	#2,D1
	
	LEA	IMG_SPRITE,A1
 	MULU.W	#48*33,D1
	ADD.L	D1,A1	

	MOVE.L	A1,SPR_1_1+2		;ADR_SPRITE
	LEA	DEFORM_SPR,A1	;0 a 29(32*4)
	TST.W	DEP_V
	BEQ.S	DEP_UP
	
	;MOVE.L	SPEED,D0		;SCROOL_RST_UP
	;NEG.L	D0
	;DIVU.W	#14,D0
	;MOVE.L	D0,COUNT_RST1
	;CLR.L	COUNT_RST2
	
	TST.L	RECULE_POS
	BEQ.S	RECULE_UP
	SUB.L	#230*4,RECULE_POS
RECULE_UP:	CMPI.L	#(32*4)*31,COUNT_DEF
	BEQ.S	STOP_DEF
	ADD.L	#32*4,COUNT_DEF
	ADD.L	COUNT_DEF,A1
	MOVE.L	A1,SPR_1_3+2
	BRA.S	STOP_DEF

DEP_UP:	;MOVE.L	SPEED,D0		;SCROOL_RST_DOWN
	;DIVU.W	#14,D0
	;MOVE.L	D0,COUNT_RST2
	;CLR.L	COUNT_RST1
	CMPI.L	#230*128,RECULE_POS
	BEQ.S	RECULE_DOWN
	ADD.L	#230*4,RECULE_POS
RECULE_DOWN:	TST.L	COUNT_DEF
	BEQ.S	STOP_DEF
	SUB.L	#32*4,COUNT_DEF
	ADD.L	COUNT_DEF,A1
	MOVE.L	A1,SPR_1_3+2
	
STOP_DEF:	ADD.L	RECULE_POS,A0
	MOVE.L	A0,SPR_1_2+2		;ADR_ECRAN
	MOVE.L	A0,SPR_EFF+2		;ADR POUR AFFACEMENT
	MOVE.L	A0,SPR_EFF2+2	;ADR POUR AFFACEMENT

	LEA	ANIMS,A0
	ADD.W	C_ANIM,A0
	MOVE.W	(A0),D0
	EXT.L	D0
	ADD.L	D0,SPR_1_1+2

	CMP.W	#(2*5)*8-2,C_ANIM
	BNE.S	OK_ANIM
	CLR.W	C_ANIM
	RTS
	
OK_ANIM:	ADDQ.W	#2,C_ANIM
	RTS

TST_CLAV:	MOVEQ	#0,D0
	MOVE.B	$FFFFFC02.W,D0
	MOVE.W	D0,KEY
	
	CMPI.B	#$48,D0
	BNE.S	FLAG_UP
	MOVE.B	#1,CLAV_UP
	RTS
	
FLAG_UP:	CMPI.B	#$50,D0
	BNE.S	FLAG_DOWN
	MOVE.B	#1,CLAV_DOWN
	RTS

FLAG_DOWN:	CMPI.B	#$4B,D0		
	BNE.S	FLAG_LEFT_1
	MOVE.B	#1,CLAV_LEFT
	RTS

FLAG_LEFT_1:	CMPI.B	#$4D,D0
	BNE.S	FLAG_RIGT_1
	MOVE.B	#1,CLAV_RIGHT
FLAG_RIGT_1:	RTS

GST_SCROOL:	LEA	TAB_HARD,A0
	ADD.L	COUNT_HARD,A0
	MOVE.L	(A0)+,L1+2
	MOVE.L	(A0)+,L2+2
	MOVE.L	(A0)+,L3+2
	MOVE.L	(A0)+,L4+2
	MOVE.L	(A0)+,L5+2
	MOVE.L	(A0)+,L6+2
	MOVE.L	PHYS,D0
	ADD.L	(A0),D0
	
	LSR.L	#$8,D0
	LEA	$FFFFF8201.W,A0
	MOVEP.W	D0,(A0)
	
	;MOVE.L	COUNT_RST1,D0
	;MOVE.L	COUNT_RST2,D1

	;ADD.L	D0,SCROOL_RST+2	
	;SUB.L	D1,SCROOL_RST+2	

	CMPI.W	#$39,KEY
	BEQ.S	TST_ECRANS
	RTS
	
TST_ECRANS:	MOVE.L	COUNT_AFF,D0
	MOVE.W	POS_X+2,D1	;Y
	LEA	ECRANS,A0	;block actuellement affiche
	DIVU.W	#26,D0
	
;ici on ajoute position player a pos decors. 
	MOVE.L	RECULE_POS,D3
	DIVU.W	#230,D3
	LSR.W	#4,D3	;/16
	SUB.W	D3,D0
	
	MOVEQ	#(23*2)+6-1,D2	;No de demos!*2
TST_Y:	CMP.W	(A0),D0	 ;on test tous les Y(18 ecrans)
	BEQ.S	TST_X
	ADDQ.W	#6,A0
	DBRA	D2,TST_Y
	RTS

TST_X:	MOVE.W	D1,D2	;et on test les x apres SI Y=
	SUB.W	#32,D1
	ADD.W	#32,D2

	CMP.W	2(A0),D1
	BLO.S	TST_X2
	RTS	

TST_X2:	CMP.W	2(A0),D2
	BHI.S	TST_X3
	RTS
	
TST_X3:	NOT	STOP_C		;ARRETE COMMANDE
	MOVE.W	4(A0),DEMO_SELECT	
	RTS
	;MOVE.W	#$2700,SR
	;JMP	FIN	

************** BORDER HAUT+FULL_SCREEN *************
TIMER_B:	STOP	#$2100		;STAB OPT
	STOP	#$2100
	MOVE.W	#$2700,SR

;SCROOL_RST:	LEA	FIN_RST-2*274,A0	;3 NOPS
	LEA	RASTERS,A0		;3 NOPS
	MOVE.L	A0,USP		;1 NOPS
	LEA	$FFFFF820A.W,A0
	LEA	$FFFFF8260.W,A1
	LEA	$FFFFF8209.W,A2
	LEA	$FFFFF8240.W,A3	;2NOPS
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	DCB.W	67,$4E71	
	
	MOVE.B	D0,(A0)		;BORDER HAUT	
	DCB.W	10,$4E71
	MOVE.W	A0,(A0)
	DCB.W	27,$4E71	
	
	SUB.B	(A2),D1
	LSL.L	D1,D1
	DCB.W	42,$4E71		
	
	MOVE.B	D0,(A0)		;BORDER DROITE
	NOP
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71		
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)
	DCB.W	6,$4E71		

L1:	JSR	L_230	;HARD-SCROOL
L2:	JSR	L_230
L3:	JSR	L_230
L4:	JSR	L_230
L5:	JSR	L_230
L6:	JSR	L_230
	JSR	INIT_PAL	;METS LA PALETTE+???(1 LIGNE)

*DEBUT FULL SCREEN
P	SET	0

******DEBUT SAVE BACK_SPRITE*****
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
SPR_EFF:	LEA	SPR_EFF,A2		|6 NOPS
	LEA	BUFFER,A3		|
	MOVEM.L	230*0(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*0(A3)	|
	MOVEM.L	230*1(A2),D1-D6	
	MOVEM.L	D1-D6,24*1(A3)	
	DCB.W	21,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*2(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*2(A3)	|
	MOVEM.L	230*3(A2),D1-D6	
	MOVEM.L	D1-D6,24*3(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*4(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*4(A3)	|
	MOVEM.L	230*5(A2),D1-D6	
	MOVEM.L	D1-D6,24*5(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*6(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*6(A3)	|
	MOVEM.L	230*7(A2),D1-D6	
	MOVEM.L	D1-D6,24*7(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*8(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*8(A3)	|
	MOVEM.L	230*9(A2),D1-D6	
	MOVEM.L	D1-D6,24*9(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*10(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*10(A3)	|
	MOVEM.L	230*11(A2),D1-D6	
	MOVEM.L	D1-D6,24*11(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*12(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*12(A3)	|
	MOVEM.L	230*13(A2),D1-D6	
	MOVEM.L	D1-D6,24*13(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*14(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*14(A3)	|
	MOVEM.L	230*15(A2),D1-D6	
	MOVEM.L	D1-D6,24*15(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*16(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*16(A3)	|
	MOVEM.L	230*17(A2),D1-D6	
	MOVEM.L	D1-D6,24*17(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*18(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*18(A3)	|
	MOVEM.L	230*19(A2),D1-D6	
	MOVEM.L	D1-D6,24*19(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*20(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*20(A3)	|
	MOVEM.L	230*21(A2),D1-D6	
	MOVEM.L	D1-D6,24*21(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*22(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*22(A3)	|
	MOVEM.L	230*23(A2),D1-D6	
	MOVEM.L	D1-D6,24*23(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*24(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*24(A3)	|
	MOVEM.L	230*25(A2),D1-D6	
	MOVEM.L	D1-D6,24*25(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*26(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*26(A3)	|
	MOVEM.L	230*27(A2),D1-D6	
	MOVEM.L	D1-D6,24*27(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*28(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*28(A3)	|
	MOVEM.L	230*29(A2),D1-D6	
	MOVEM.L	D1-D6,24*29(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	230*30(A2),D1-D6	|31NOPS
	MOVEM.L	D1-D6,24*30(A3)	|
	MOVEM.L	230*31(A2),D1-D6	
	MOVEM.L	D1-D6,24*31(A3)	
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	
************ FIN SAVE BACK VAISSEAU ************


*********************************
***DEBUT AFFICHAGE 1 LIGNE SPR***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
SPR_1_1:	LEA	IMG_SPRITE,A2	;ADR SPRITE		|10 NOPS
SPR_1_2:	LEA	ADR_SPR,A3		;ADR ECRAN 		|
SPR_1_3:	LEA	DEFORM_SPR,A4	;TAB DE DEFORMATION	|
	MOVE.L	A2,A5				|

	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0(A3)		|
	OR.L	D1,0(A3)		|
	AND.L	D4,4(A3)		|
	OR.L	D2,4(A3)		|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8(A3)		|
	OR.L	D1,8(A3)		|
	AND.L	D4,4+8(A3)		|
	OR.L	D2,4+8(A3)		|
	DCB.W	4,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16(A3)
	OR.L	D1,16(A3)
	AND.L	D4,4+16(A3)
	OR.L	D2,4+16(A3)
***FIN AFFICHAGE 1 LIGNE SPR

***DEBUT AFFICHAGE 2eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230(A3)		|
	OR.L	D1,230(A3)		|
	AND.L	D4,4+230(A3)		|
	OR.L	D2,4+230(A3)		|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230(A3)		|
	OR.L	D1,8+230(A3)		|
	AND.L	D4,4+8+230(A3)	|
	OR.L	D2,4+8+230(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230(A3)	|
	OR.L	D1,16+230(A3)	|
	AND.L	D4,4+16+230(A3)	|
	OR.L	D2,4+16+230(A3)	|
***FIN AFFICHAGE 2eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 3eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*2(A3)		|
	OR.L	D1,230*2(A3)		|
	AND.L	D4,4+230*2(A3)	|
	OR.L	D2,4+230*2(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*2(A3)	|
	OR.L	D1,8+230*2(A3)	|
	AND.L	D4,4+8+230*2(A3)	|
	OR.L	D2,4+8+230*2(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*2(A3)	|
	OR.L	D1,16+230*2(A3)	|
	AND.L	D4,4+16+230*2(A3)	|
	OR.L	D2,4+16+230*2(A3)	|
***FIN AFFICHAGE 3eme LIGNE SPR

***DEBUT AFFICHAGE 4eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*3(A3)		|
	OR.L	D1,230*3(A3)		|
	AND.L	D4,4+230*3(A3)	|
	OR.L	D2,4+230*3(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*3(A3)	|
	OR.L	D1,8+230*3(A3)	|
	AND.L	D4,4+8+230*3(A3)	|
	OR.L	D2,4+8+230*3(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*3(A3)	|
	OR.L	D1,16+230*3(A3)	|
	AND.L	D4,4+16+230*3(A3)	|
	OR.L	D2,4+16+230*3(A3)	|
	DCB.W	17,$4E71
***FIN AFFICHAGE 4eme LIGNE SPR
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

***DEBUT AFFICHAGE 5 LIGNE SPR
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVE.L	A5,A2				|
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0+230*4(A3)	|
	OR.L	D1,0+230*4(A3)	|
	AND.L	D4,4+230*4(A3)	|
	OR.L	D2,4+230*4(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*4(A3)	|
	OR.L	D1,8+230*4(A3)	|
	AND.L	D4,4+8+230*4(A3)	|
	OR.L	D2,4+8+230*4(A3)	|
	DCB.W	13,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16+230*4(A3)
	OR.L	D1,16+230*4(A3)
	AND.L	D4,4+16+230*4(A3)
	OR.L	D2,4+16+230*4(A3)
***FIN AFFICHAGE 5 LIGNE SPR

***DEBUT AFFICHAGE 6eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*5(A3)		|
	OR.L	D1,230*5(A3)		|
	AND.L	D4,4+230*5(A3)	|
	OR.L	D2,4+230*5(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*5(A3)	|
	OR.L	D1,8+230*5(A3)	|
	AND.L	D4,4+8+230*5(A3)	|
	OR.L	D2,4+8+230*5(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*5(A3)	|
	OR.L	D1,16+230*5(A3)	|
	AND.L	D4,4+16+230*5(A3)	|
	OR.L	D2,4+16+230*5(A3)	|
***FIN AFFICHAGE 6eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 7eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*6(A3)		|
	OR.L	D1,230*6(A3)		|
	AND.L	D4,4+230*6(A3)	|
	OR.L	D2,4+230*6(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*6(A3)	|
	OR.L	D1,8+230*6(A3)	|
	AND.L	D4,4+8+230*6(A3)	|
	OR.L	D2,4+8+230*6(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*6(A3)	|
	OR.L	D1,16+230*6(A3)	|
	AND.L	D4,4+16+230*6(A3)	|
	OR.L	D2,4+16+230*6(A3)	|
***FIN AFFICHAGE 7eme LIGNE SPR

***DEBUT AFFICHAGE 8eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*7(A3)		|
	OR.L	D1,230*7(A3)		|
	AND.L	D4,4+230*7(A3)	|
	OR.L	D2,4+230*7(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*7(A3)	|
	OR.L	D1,8+230*7(A3)	|
	AND.L	D4,4+8+230*7(A3)	|
	OR.L	D2,4+8+230*7(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*7(A3)	|
	OR.L	D1,16+230*7(A3)	|
	AND.L	D4,4+16+230*7(A3)	|
	OR.L	D2,4+16+230*7(A3)	|
***FIN AFFICHAGE 8eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

***
***DEBUT AFFICHAGE 9 LIGNE SPR
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVE.L	A5,A2				|
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0+230*8(A3)	|
	OR.L	D1,0+230*8(A3)	|
	AND.L	D4,4+230*8(A3)	|
	OR.L	D2,4+230*8(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*8(A3)	|
	OR.L	D1,8+230*8(A3)	|
	AND.L	D4,4+8+230*8(A3)	|
	OR.L	D2,4+8+230*8(A3)	|
	DCB.W	13,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16+230*8(A3)
	OR.L	D1,16+230*8(A3)
	AND.L	D4,4+16+230*8(A3)
	OR.L	D2,4+16+230*8(A3)
***FIN AFFICHAGE 9 LIGNE SPR

***DEBUT AFFICHAGE 10eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*9(A3)		|
	OR.L	D1,230*9(A3)		|
	AND.L	D4,4+230*9(A3)	|
	OR.L	D2,4+230*9(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*9(A3)	|
	OR.L	D1,8+230*9(A3)	|
	AND.L	D4,4+8+230*9(A3)	|
	OR.L	D2,4+8+230*9(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*9(A3)	|
	OR.L	D1,16+230*9(A3)	|
	AND.L	D4,4+16+230*9(A3)	|
	OR.L	D2,4+16+230*9(A3)	|
***FIN AFFICHAGE 10eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 11eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*10(A3)	|
	OR.L	D1,230*10(A3)	|
	AND.L	D4,4+230*10(A3)	|
	OR.L	D2,4+230*10(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*10(A3)	|
	OR.L	D1,8+230*10(A3)	|
	AND.L	D4,4+8+230*10(A3)	|
	OR.L	D2,4+8+230*10(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*10(A3)	|
	OR.L	D1,16+230*10(A3)	|
	AND.L	D4,4+16+230*10(A3)	|
	OR.L	D2,4+16+230*10(A3)	|
***FIN AFFICHAGE 11eme LIGNE SPR

***DEBUT AFFICHAGE 12eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*11(A3)	|
	OR.L	D1,230*11(A3)	|
	AND.L	D4,4+230*11(A3)	|
	OR.L	D2,4+230*11(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*11(A3)	|
	OR.L	D1,8+230*11(A3)	|
	AND.L	D4,4+8+230*11(A3)	|
	OR.L	D2,4+8+230*11(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*11(A3)	|
	OR.L	D1,16+230*11(A3)	|
	AND.L	D4,4+16+230*11(A3)	|
	OR.L	D2,4+16+230*11(A3)	|
***FIN AFFICHAGE 12eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

***
***DEBUT AFFICHAGE 13 LIGNE SPR
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVE.L	A5,A2				|
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0+230*12(A3)	|
	OR.L	D1,0+230*12(A3)	|
	AND.L	D4,4+230*12(A3)	|
	OR.L	D2,4+230*12(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*12(A3)	|
	OR.L	D1,8+230*12(A3)	|
	AND.L	D4,4+8+230*12(A3)	|
	OR.L	D2,4+8+230*12(A3)	|
	DCB.W	13,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16+230*12(A3)
	OR.L	D1,16+230*12(A3)
	AND.L	D4,4+16+230*12(A3)
	OR.L	D2,4+16+230*12(A3)
***FIN AFFICHAGE 13 LIGNE SPR

***DEBUT AFFICHAGE 14eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*13(A3)	|
	OR.L	D1,230*13(A3)	|
	AND.L	D4,4+230*13(A3)	|
	OR.L	D2,4+230*13(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*13(A3)	|
	OR.L	D1,8+230*13(A3)	|
	AND.L	D4,4+8+230*13(A3)	|
	OR.L	D2,4+8+230*13(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*13(A3)	|
	OR.L	D1,16+230*13(A3)	|
	AND.L	D4,4+16+230*13(A3)	|
	OR.L	D2,4+16+230*13(A3)	|
***FIN AFFICHAGE 14eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 15eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*14(A3)	|
	OR.L	D1,230*14(A3)	|
	AND.L	D4,4+230*14(A3)	|
	OR.L	D2,4+230*14(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*14(A3)	|
	OR.L	D1,8+230*14(A3)	|
	AND.L	D4,4+8+230*14(A3)	|
	OR.L	D2,4+8+230*14(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*14(A3)	|
	OR.L	D1,16+230*14(A3)	|
	AND.L	D4,4+16+230*14(A3)	|
	OR.L	D2,4+16+230*14(A3)	|
***FIN AFFICHAGE 15eme LIGNE SPR

***DEBUT AFFICHAGE 16eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*15(A3)	|
	OR.L	D1,230*15(A3)	|
	AND.L	D4,4+230*15(A3)	|
	OR.L	D2,4+230*15(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*15(A3)	|
	OR.L	D1,8+230*15(A3)	|
	AND.L	D4,4+8+230*15(A3)	|
	OR.L	D2,4+8+230*15(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*15(A3)	|
	OR.L	D1,16+230*15(A3)	|
	AND.L	D4,4+16+230*15(A3)	|
	OR.L	D2,4+16+230*15(A3)	|
***FIN AFFICHAGE 16eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	
***

***
***DEBUT AFFICHAGE 17 LIGNE SPR
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVE.L	A5,A2				|
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0+230*16(A3)	|
	OR.L	D1,0+230*16(A3)	|
	AND.L	D4,4+230*16(A3)	|
	OR.L	D2,4+230*16(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*16(A3)	|
	OR.L	D1,8+230*16(A3)	|
	AND.L	D4,4+8+230*16(A3)	|
	OR.L	D2,4+8+230*16(A3)	|
	DCB.W	13,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16+230*16(A3)
	OR.L	D1,16+230*16(A3)
	AND.L	D4,4+16+230*16(A3)
	OR.L	D2,4+16+230*16(A3)
***FIN AFFICHAGE 17 LIGNE SPR

***DEBUT AFFICHAGE 18eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*17(A3)	|
	OR.L	D1,230*17(A3)	|
	AND.L	D4,4+230*17(A3)	|
	OR.L	D2,4+230*17(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*17(A3)	|
	OR.L	D1,8+230*17(A3)	|
	AND.L	D4,4+8+230*17(A3)	|
	OR.L	D2,4+8+230*17(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*17(A3)	|
	OR.L	D1,16+230*17(A3)	|
	AND.L	D4,4+16+230*17(A3)	|
	OR.L	D2,4+16+230*17(A3)	|
***FIN AFFICHAGE 18eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 19eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*18(A3)	|
	OR.L	D1,230*18(A3)	|
	AND.L	D4,4+230*18(A3)	|
	OR.L	D2,4+230*18(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*18(A3)	|
	OR.L	D1,8+230*18(A3)	|
	AND.L	D4,4+8+230*18(A3)	|
	OR.L	D2,4+8+230*18(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*18(A3)	|
	OR.L	D1,16+230*18(A3)	|
	AND.L	D4,4+16+230*18(A3)	|
	OR.L	D2,4+16+230*18(A3)	|
***FIN AFFICHAGE 19eme LIGNE SPR

***DEBUT AFFICHAGE 20eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*19(A3)	|
	OR.L	D1,230*19(A3)	|
	AND.L	D4,4+230*19(A3)	|
	OR.L	D2,4+230*19(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*19(A3)	|
	OR.L	D1,8+230*19(A3)	|
	AND.L	D4,4+8+230*19(A3)	|
	OR.L	D2,4+8+230*19(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*19(A3)	|
	OR.L	D1,16+230*19(A3)	|
	AND.L	D4,4+16+230*19(A3)	|
	OR.L	D2,4+16+230*19(A3)	|
***FIN AFFICHAGE 20eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

***
***DEBUT AFFICHAGE 21 LIGNE SPR
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVE.L	A5,A2				|
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0+230*20(A3)	|
	OR.L	D1,0+230*20(A3)	|
	AND.L	D4,4+230*20(A3)	|
	OR.L	D2,4+230*20(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*20(A3)	|
	OR.L	D1,8+230*20(A3)	|
	AND.L	D4,4+8+230*20(A3)	|
	OR.L	D2,4+8+230*20(A3)	|
	DCB.W	13,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16+230*20(A3)
	OR.L	D1,16+230*20(A3)
	AND.L	D4,4+16+230*20(A3)
	OR.L	D2,4+16+230*20(A3)
***FIN AFFICHAGE 21 LIGNE SPR

***DEBUT AFFICHAGE 22eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*21(A3)	|
	OR.L	D1,230*21(A3)	|
	AND.L	D4,4+230*21(A3)	|
	OR.L	D2,4+230*21(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*21(A3)	|
	OR.L	D1,8+230*21(A3)	|
	AND.L	D4,4+8+230*21(A3)	|
	OR.L	D2,4+8+230*21(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*21(A3)	|
	OR.L	D1,16+230*21(A3)	|
	AND.L	D4,4+16+230*21(A3)	|
	OR.L	D2,4+16+230*21(A3)	|
***FIN AFFICHAGE 22eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 23eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*22(A3)	|
	OR.L	D1,230*22(A3)	|
	AND.L	D4,4+230*22(A3)	|
	OR.L	D2,4+230*22(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*22(A3)	|
	OR.L	D1,8+230*22(A3)	|
	AND.L	D4,4+8+230*22(A3)	|
	OR.L	D2,4+8+230*22(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*22(A3)	|
	OR.L	D1,16+230*22(A3)	|
	AND.L	D4,4+16+230*22(A3)	|
	OR.L	D2,4+16+230*22(A3)	|
***FIN AFFICHAGE 23eme LIGNE SPR

***DEBUT AFFICHAGE 24eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*23(A3)	|
	OR.L	D1,230*23(A3)	|
	AND.L	D4,4+230*23(A3)	|
	OR.L	D2,4+230*23(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*23(A3)	|
	OR.L	D1,8+230*23(A3)	|
	AND.L	D4,4+8+230*23(A3)	|
	OR.L	D2,4+8+230*23(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*23(A3)	|
	OR.L	D1,16+230*23(A3)	|
	AND.L	D4,4+16+230*23(A3)	|
	OR.L	D2,4+16+230*23(A3)	|
***FIN AFFICHAGE 24eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	
***

***
***DEBUT AFFICHAGE 25 LIGNE SPR
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVE.L	A5,A2				|
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0+230*24(A3)	|
	OR.L	D1,0+230*24(A3)	|
	AND.L	D4,4+230*24(A3)	|
	OR.L	D2,4+230*24(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*24(A3)	|
	OR.L	D1,8+230*24(A3)	|
	AND.L	D4,4+8+230*24(A3)	|
	OR.L	D2,4+8+230*24(A3)	|
	DCB.W	13,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16+230*24(A3)
	OR.L	D1,16+230*24(A3)
	AND.L	D4,4+16+230*24(A3)
	OR.L	D2,4+16+230*24(A3)
***FIN AFFICHAGE 25 LIGNE SPR

***DEBUT AFFICHAGE 26eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*25(A3)	|
	OR.L	D1,230*25(A3)	|
	AND.L	D4,4+230*25(A3)	|
	OR.L	D2,4+230*25(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*25(A3)	|
	OR.L	D1,8+230*25(A3)	|
	AND.L	D4,4+8+230*25(A3)	|
	OR.L	D2,4+8+230*25(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*25(A3)	|
	OR.L	D1,16+230*25(A3)	|
	AND.L	D4,4+16+230*25(A3)	|
	OR.L	D2,4+16+230*25(A3)	|
***FIN AFFICHAGE 26eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 27eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*26(A3)	|
	OR.L	D1,230*26(A3)	|
	AND.L	D4,4+230*26(A3)	|
	OR.L	D2,4+230*26(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*26(A3)	|
	OR.L	D1,8+230*26(A3)	|
	AND.L	D4,4+8+230*26(A3)	|
	OR.L	D2,4+8+230*26(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*26(A3)	|
	OR.L	D1,16+230*26(A3)	|
	AND.L	D4,4+16+230*26(A3)	|
	OR.L	D2,4+16+230*26(A3)	|
***FIN AFFICHAGE 27eme LIGNE SPR

***DEBUT AFFICHAGE 28eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*27(A3)	|
	OR.L	D1,230*27(A3)	|
	AND.L	D4,4+230*27(A3)	|
	OR.L	D2,4+230*27(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*27(A3)	|
	OR.L	D1,8+230*27(A3)	|
	AND.L	D4,4+8+230*27(A3)	|
	OR.L	D2,4+8+230*27(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*27(A3)	|
	OR.L	D1,16+230*27(A3)	|
	AND.L	D4,4+16+230*27(A3)	|
	OR.L	D2,4+16+230*27(A3)	|
***FIN AFFICHAGE 28eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

***
***DEBUT AFFICHAGE 29 LIGNE SPR
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVE.L	A5,A2				|
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,0+230*28(A3)	|
	OR.L	D1,0+230*28(A3)	|
	AND.L	D4,4+230*28(A3)	|
	OR.L	D2,4+230*28(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*28(A3)	|
	OR.L	D1,8+230*28(A3)	|
	AND.L	D4,4+8+230*28(A3)	|
	OR.L	D2,4+8+230*28(A3)	|
	DCB.W	13,$4E71		
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4
	AND.L	D3,16+230*28(A3)
	OR.L	D1,16+230*28(A3)
	AND.L	D4,4+16+230*28(A3)
	OR.L	D2,4+16+230*28(A3)
***FIN AFFICHAGE 29 LIGNE SPR

***DEBUT AFFICHAGE 30eme LIGNE SPR

	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*29(A3)	|
	OR.L	D1,230*29(A3)	|
	AND.L	D4,4+230*29(A3)	|
	OR.L	D2,4+230*29(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*29(A3)	|
	OR.L	D1,8+230*29(A3)	|
	AND.L	D4,4+8+230*29(A3)	|
	OR.L	D2,4+8+230*29(A3)	|
	
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*29(A3)	|
	OR.L	D1,16+230*29(A3)	|
	AND.L	D4,4+16+230*29(A3)	|
	OR.L	D2,4+16+230*29(A3)	|
***FIN AFFICHAGE 30eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
***DEBUT AFFICHAGE 31eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*30(A3)	|
	OR.L	D1,230*30(A3)	|
	AND.L	D4,4+230*30(A3)	|
	OR.L	D2,4+230*30(A3)	|

	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*30(A3)	|
	OR.L	D1,8+230*30(A3)	|
	AND.L	D4,4+8+230*30(A3)	|
	OR.L	D2,4+8+230*30(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*30(A3)	|
	OR.L	D1,16+230*30(A3)	|
	AND.L	D4,4+16+230*30(A3)	|
	OR.L	D2,4+16+230*30(A3)	|
***FIN AFFICHAGE 31eme LIGNE SPR

***DEBUT AFFICHAGE 32eme LIGNE SPR
	MOVE.L	A5,A2		|1 nop
	ADD.L	(A4)+,A2		|HOP DEFORM
	MOVEM.L	(A2),D1-D4		|39 NOPS
	AND.L	D3,230*31(A3)	|
	OR.L	D1,230*31(A3)	|
	AND.L	D4,4+230*31(A3)	|
	OR.L	D2,4+230*31(A3)	|
	DCB.W	13,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16(A2),D1-D4		|36 NOPS
	AND.L	D3,8+230*31(A3)	|
	OR.L	D1,8+230*31(A3)	|
	AND.L	D4,4+8+230*31(A3)	|
	OR.L	D2,4+8+230*31(A3)	|

	MOVEM.L	32(A2),D1-D4		|36 NOPS
	AND.L	D3,16+230*31(A3)	|
	OR.L	D1,16+230*31(A3)	|
	AND.L	D4,4+16+230*31(A3)	|
	OR.L	D2,4+16+230*31(A3)	|
***FIN AFFICHAGE 32eme LIGNE SPR
	
	DCB.W	17,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	
***
	REPT	35
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	DCB.W	89,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	DCB.W	89,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	
	ENDR

******* DEBUT AFFICHAGE DECORE (ENVIRON A LA 100eme LIGNE)
***BLOCK 1
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVE.L	NEW_PHYS_1,A2	|5 NOPS
	MOVE.L	NEW_PHYS_2,A4	|5
AUTO_MODIF:	LEA	DESIGNE_LEV,A5	|3 
	ADD.L	COUNT_AFF,A5		;2*6
	ADD.L	COUNT_AFF,A5

	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,(A2)		|10
	MOVEM.L	D1-D4,(A4)		|10

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	DCB.W	10-6,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	MOVEM.L	D1-D4,230(A4)	|11
	NOP
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	
	
***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***END OF BLOCK 1

***BLOCK 2
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***END OF BLOCK 2

***BLOCK 3
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***END OF BLOCK 3

***BLOCK 4
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***END OF BLOCK 4

***BLOCK 5
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***END OF BLOCK 5

***BLOCK 6
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS **
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***END OF BLOCK 6

***BLOCK 7
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***END OF BLOCK 7

***BLOCK 8
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	
***END OF BLOCK 8

***BLOCK 9
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***ICI
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	8,$4E71	;	***
	MOVE.B	D0,(A0)	;60hz	***
	DCB.W	2,$4E71	;	***
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	MOVE.W	A0,(A0)	;50hz	**
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	
***END OF BLOCK 9

***BLOCK 10
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	
***END OF BLOCK 10

	REPT	3
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	DCB.W	89,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	DCB.W	89,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4	
	ENDR

*DEBUT BORDER BAS(2 LIGNE POUR CHANGEMENT+38 LIGNE)
BORDER_BAS1:	MOVE.W	A0,(A1)	;haute rez(1er ligne bas)
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)	;basse rez
	DCB.W	89,$4E71
	MOVE.B	D0,(A0)	;60hz			
	NOP	
	MOVE.W	A0,(A0)	;50hz
	DCB.W	8,$4E71
	MOVE.B	D0,(A0)	;60hz		**
	DCB.W	2,$4E71
	MOVE.W	A0,(A1)	;haute rez
	NOP
	MOVE.B	D0,(A1)	;basse rez
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
	
BORDER_BAS2:	MOVE.W	A0,(A1)	;(2eme ligne bas)
	MOVE.W	A0,(A0)	;50hz		**
	MOVE.B	D0,(A1)
	DCB.W	89,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)	
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

BORDER_BAS:	
***BLOCK 11
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4
***END OF BLOCK 11

***BLOCK 12
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4
***END OF BLOCK 12

***BLOCK 13
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	LEA	16(A2),A2
	LEA	16(A4),A4
	LEA	IMG_DECORE,A3	|3 NOPS
	ADD.L	(A5)+,A3		|4
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,000(A2)	|11
	MOVEM.L	D1-D4,000(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,230(A2)	|11
	MOVEM.L	D1-D4,230(A4)	|11
	DCB.W	12,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,460(A2)	|11
	MOVEM.L	D1-D4,460(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,690(A2)	|11
	MOVEM.L	D1-D4,690(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,920(A2)	|11
	MOVEM.L	D1-D4,920(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1150(A2)	|11
	MOVEM.L	D1-D4,1150(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1380(A2)	|11
	MOVEM.L	D1-D4,1380(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1610(A2)	|11
	MOVEM.L	D1-D4,1610(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,1840(A2)	|11
	MOVEM.L	D1-D4,1840(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2070(A2)	|11
	MOVEM.L	D1-D4,2070(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2300(A2)	|11
	MOVEM.L	D1-D4,2300(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2530(A2)	|11
	MOVEM.L	D1-D4,2530(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4

***
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2760(A2)	|11
	MOVEM.L	D1-D4,2760(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,2990(A2)	|11
	MOVEM.L	D1-D4,2990(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	
	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3220(A2)	|11
	MOVEM.L	D1-D4,3220(A4)	|11

	MOVEM.L	(A3)+,D1-D4		|11 NOPS		
	MOVEM.L	D1-D4,3450(A2)	|11
	MOVEM.L	D1-D4,3450(A4)	|11
	DCB.W	23,$4E71
	
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71		|
P	SET	P+4
***END OF BLOCK 13

******DEBUT RESTORE BACK_SPRITE*****
	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
SPR_EFF2:	LEA	SPR_EFF2,A2		|6 NOPS
	LEA	BUFFER,A3		|
	MOVEM.L	0*24(A3),D1-D6
	MOVEM.L	D1-D6,0*230(A2)
	MOVEM.L	1*24(A3),D1-D6
	MOVEM.L	D1-D6,1*230(A2)
	DCB.W	21,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	2*24(A3),D1-D6
	MOVEM.L	D1-D6,2*230(A2)
	MOVEM.L	3*24(A3),D1-D6
	MOVEM.L	D1-D6,3*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	4*24(A3),D1-D6
	MOVEM.L	D1-D6,4*230(A2)
	MOVEM.L	5*24(A3),D1-D6
	MOVEM.L	D1-D6,5*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	6*24(A3),D1-D6
	MOVEM.L	D1-D6,6*230(A2)
	MOVEM.L	7*24(A3),D1-D6
	MOVEM.L	D1-D6,7*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	8*24(A3),D1-D6
	MOVEM.L	D1-D6,8*230(A2)
	MOVEM.L	9*24(A3),D1-D6
	MOVEM.L	D1-D6,9*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	10*24(A3),D1-D6
	MOVEM.L	D1-D6,10*230(A2)
	MOVEM.L	11*24(A3),D1-D6
	MOVEM.L	D1-D6,11*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	12*24(A3),D1-D6
	MOVEM.L	D1-D6,12*230(A2)
	MOVEM.L	13*24(A3),D1-D6
	MOVEM.L	D1-D6,13*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	14*24(A3),D1-D6
	MOVEM.L	D1-D6,14*230(A2)
	MOVEM.L	15*24(A3),D1-D6
	MOVEM.L	D1-D6,15*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	16*24(A3),D1-D6
	MOVEM.L	D1-D6,16*230(A2)
	MOVEM.L	17*24(A3),D1-D6
	MOVEM.L	D1-D6,17*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	18*24(A3),D1-D6
	MOVEM.L	D1-D6,18*230(A2)
	MOVEM.L	19*24(A3),D1-D6
	MOVEM.L	D1-D6,19*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	20*24(A3),D1-D6
	MOVEM.L	D1-D6,20*230(A2)
	MOVEM.L	21*24(A3),D1-D6
	MOVEM.L	D1-D6,21*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	22*24(A3),D1-D6
	MOVEM.L	D1-D6,22*230(A2)
	MOVEM.L	23*24(A3),D1-D6
	MOVEM.L	D1-D6,23*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	;MOVE.B  	#$A,$5A0(A1)		;5NOPS |FWUU!
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	24*24(A3),D1-D6
	MOVEM.L	D1-D6,24*230(A2)
	MOVEM.L	25*24(A3),D1-D6
	MOVEM.L	D1-D6,25*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	26*24(A3),D1-D6
	MOVEM.L	D1-D6,26*230(A2)
	MOVEM.L	27*24(A3),D1-D6
	MOVEM.L	D1-D6,27*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	

	MOVE.W	A0,(A1)		;LIGNE SANS ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	28*24(A3),D1-D6
	MOVEM.L	D1-D6,28*230(A2)
	MOVEM.L	29*24(A3),D1-D6
	MOVEM.L	D1-D6,29*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	DCB.W	12,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71

	MOVE.W	A0,(A1)		;LIGNE AVEC ALF
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	MOVEM.L	30*24(A3),D1-D6
	MOVEM.L	D1-D6,30*230(A2)
	MOVEM.L	31*24(A3),D1-D6
	MOVEM.L	D1-D6,31*230(A2)
	DCB.W	27,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
      	DCB.W	5,$4E71
      	MOVE.B  	(A6),$5A2(A1)	;5NOPS |
	ADDA.W	D7,A6		;2NOPS |TOTAL:12 NOPS!
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVE.L	USP,A0		|8 NOPS
	MOVE.W	P+2(A0),$FFFFF8240.W	|FOR RASTERS
	LEA	$FFFFF820A.W,A0	|SHIT REG
	DCB.W	3,$4E71
P	SET	P+4	
************ FIN RESTORE BACK VAISSEAU ************

*END OF FULL SCREEN
PALZERO:	MOVE.W	A0,(A1)	;1_LIGNE
	DCB.W	2,$4E71
	MOVE.B	D0,(A1)
	DCB.W	89,$4E71
	MOVE.B	D0,(A0)			
	NOP	
	MOVE.W	A0,(A0)
	MOVEQ	#0,D1
	MOVEQ	#0,D2
	MOVEQ	#0,D3
	MOVEQ	#0,D4
	MOVEQ	#0,D5
	MOVEQ	#0,D6
	MOVEQ	#0,D7
	DCB.W	12-7,$4E71
	MOVE.W	A0,(A1)
	NOP
	MOVE.B	D0,(A1)	
	MOVEM.L	D0-D7,$FFFFF8240.W	
AUT2:	MOVEM.L	PAL_NEW,D0-D7
	MOVEM.L	D0-D7,PAL
	MOVE.L	#PAL,AUT2+4
	MOVE.W	#$2300,SR
	JSR	GST_SCROOL
	
	;MOVE.W	#$070,$FFFFF8240.W
	;DCB.W	128,$4E71
	;MOVE.W	#$000,$FFFFF8240.W
INACTIF:	RTE	

ACTIF:	BCLR.B	#0,$FFFFFA0F.W	
	CLR.B	$FFFFFA1B.W
	RTE
	
****************************************************
***** FIN=>ON RETABLIE TOUTES LES INETRUPTIONS *****
****************************************************
FIN:	JSR	CLR_YM
	LEA	SAVE,A0		;restore les inters
	MOVE.L	(A0)+,$68.W
	MOVE.L	(A0)+,$70.W		 
	MOVE.L	(A0)+,$120.W		
	MOVE.L	(A0)+,$118.W		
	MOVE.L	(A0)+,$134.W		
	MOVE.B	(A0)+,$FFFFFA07.W	
	MOVE.B	(A0)+,$FFFFFA09.W	
	MOVE.B	(A0)+,$FFFFFA13.W	
	MOVE.B	(A0)+,$FFFFFA17.W	
	MOVE.B	#$8,$FFFFFC02.W	;a suprimer
	
	MOVEM.L	ZERO,D0-D7/A0-A6
	MOVEM.L	D0-D7,$FFFFF8240.W	
	MOVE.W	#$2300,SR		;a suprimer

	MOVE.W	#$777,$FFF8240	;a suprimer
	MOVE.W	#$000,$FFF8246	;a suprimer
	CLR	-(SP)	
	TRAP	#1

****************************************************
********************** DATA ************************
****************************************************
	EVEN
SAVE:	DCB.L	6,0
ZERO:	DCB.L	16,0
	EVEN
PHYS:	DC.L	0
NEW_PHYS_1:	DC.L	0
NEW_PHYS_2:	DC.L	0
ADR_SPR:	DC.L	0
COUNT_HARD:	DC.L	(18*16)*28	;28*32
FLAG_AFF:	DC.L	0
COUNT_AFF:	DC.L	18*26	;POSITION VERTICAL BLOCK DE 16(EX:18*16 1 ECRAN)
;COUNT_RST1	DC.L	0	;ADD
;COUNT_RST2	DC.L	0	;SUB
S_D7:	DC.W	0
SPEED_S:	DC.L	28	;ENCIENNE VITESSE(VBL AVANT POUR RETOUR)
SPEED:	DC.L	28	;VITESSE SCROOLING DE 1 A 16*28
POS_X:	DC.L	384/2	;POSITION DE 4 EN 4 HORIZONTALEMENT
DEP_V:	DC.W	0	;DIRCTION DEP. 0=> UP  1=>DOWN(DEFORM)
RECULE_POS:	DC.L	230*128	;RECULE DANS LE SENS INVERSE DE LA MARCHE
COUNT_DEF:	DC.L	0
CLAV_UP:	DC.B	0
CLAV_DOWN:	DC.B	0
CLAV_LEFT:	DC.B	0
CLAV_RIGHT:	DC.B	0
KEY:	DC.W	0
STOP_C:	DC.W	0
COUNT_FEED:	DC.W	0
C_RST:	DC.W	0
C_ANIM:	DC.W	0
	EVEN
OFFSET:	INCLUDE	"OFF_9.BLK"
TAB_HARD:	INCLUDE	"MEGA_TAB.BLK"
	DCB.L 	13,0
DESIGNE_LEV:	INCLUDE	"LEVEL.BLK"
 	DCB.L 	13,0
	EVEN
IMG_DECORE:	INCBIN	"DECORE.BLK"
	INCBIN	"DECORE2.BLK"
	EVEN
IMG_SPRITE:	INCBIN	"SPRITE1.BLK"
	INCBIN	"SPRITE2.BLK"
	INCBIN	"SPRITE3.BLK"
	INCBIN	"SPRITE4.BLK"
	INCBIN	"SPRITE5.BLK"
	EVEN
DEMO_SELECT:	DC.W	0	;DEMO S'LECTIONNE

	;POS ECRAN Y,X*32,No de la Demo.
ECRANS:	DC.W	(300-283),6*32,0	|WIGGLE IT
	DC.W	(301-283),6*32,0	|0

	DC.W	(300-275),5*32,1	|NO SCROLL
	DC.W	(301-275),5*32,1	|1
	
	DC.W	(300-271),12*32,2	|KB-JARDIN 
	DC.W	(301-271),12*32,2	|2

	DC.W	(300-265),1*32,3	|GENUMAX
	DC.W	(301-265),1*32,3	|3

	DC.W	(300-240),5*32,4	|NGC
	DC.W	(301-240),5*32,4	|4

	DC.W	(300-235),11*32,5	|CHROMAX
	DC.W	(301-235),11*32,5	|5

	DC.W	(300-225),12*32,6	|HLM DEMO
	DC.W	(301-225),12*32,6	|6

	DC.W	(300-224),4*32,7	|DEL3 EMULATEUR
	DC.W	(301-224),4*32,7	|7
	
	DC.W	(300-210),2*32,8	|VODKA
	DC.W	(301-210),2*32,8	|8

	DC.W	(298-196),6*32,9	|9
	DC.W	(300-196),6*32,9	|TMF
	DC.W	(301-196),6*32,9	|9

	DC.W	(298-184),4*32,10	|10
	DC.W	(300-184),4*32,10	|TBC
	DC.W	(301-184),4*32,10	|10

	DC.W	(300-169),11*32,11	|STONE AGE
	DC.W	(301-169),11*32,11	|11

	DC.W	(300-163),3*32,12	|PUSH IT
	DC.W	(301-163),3*32,12	|12

	DC.W	(300-139),10*32,13	|COLUMNS
	DC.W	(301-139),10*32,13	|13

	DC.W	(300-132),3*32,14	|LEMMING FUCK
	DC.W	(301-132),3*32,14	|14

	DC.W	(298-126),1*32,15	|15
	DC.W	(300-126),1*32,15	|LU LU
	DC.W	(301-126),1*32,15	|15

	DC.W	(300-122),6*32,16	|TEKILA
	DC.W	(301-122),6*32,16	|16

	DC.W	(300-100),12*32,17	|BORING DEMO
	DC.W	(301-100),12*32,17	|17

	DC.W	(300-88),4*32,18	|NIGHTMARE
	DC.W	(301-88),4*32,18	|18

	DC.W	(300-81),3*32,19	|MUFE
	DC.W	(301-81),3*32,19	|19

	DC.W	(298-70),12*32,20	|20
	DC.W	(300-70),12*32,20	|HARDCOPY
	DC.W	(301-70),12*32,20	|20

	DC.W	(300-58),3*32,21	|90deg DEMO
	DC.W	(301-58),3*32,21	|21

	DC.W	(297-27),3*32,22	|22
	DC.W	(298-27),3*32,22	|22
	DC.W	(300-27),3*32,22	|RASOIRE
	DC.W	(301-27),3*32,22	|22
	
LED:	DC.B	14,14,14,14,14,13,14,14,13,14,13,14,13,14,13 	;JHSDKQSI
	EVEN

PAL:	DS.W	16
PAL_NEW:	DC.W	$000,$222,$333,$444,$555,$777,$404,$505
	DC.W	$616,$040,$060,$421,$532,$643,$007,$007

ANIMS:	DC.W	6336*0,6336*0,6336*0,6336*0,6336*0
	DC.W	6336*1,6336*1,6336*1,6336*1,6336*1
	DC.W	6336*2,6336*2,6336*2,6336*2,6336*2
	DC.W	6336*3,6336*3,6336*3,6336*3,6336*3
	DC.W	6336*4,6336*4,6336*4,6336*4,6336*4
	DC.W	6336*3,6336*3,6336*3,6336*3,6336*3
	DC.W	6336*2,6336*2,6336*2,6336*2,6336*2
	DC.W	6336*1,6336*1,6336*1,6336*1,6336*1

BUFFER:	DCB.B	(32*24)	;BUFFER DE SAUVEGARDE BACK DECOR SPR

DEFORM_SPR:	INCBIN	"DEFORM.BIN"
	EVEN

RASTERS:	DCB.W	10,$760		;10
	DC.W	$740,$760,$760	;*3
	DCB.W	9,$740		;9
	DC.W	$720,$740,$740	;*3
	DCB.W	8,$720		;8
	DC.W	$700,$720,$720	;*3
	DCB.W	7,$700		;7
	DC.W	$600,$700,$700  	;*3
	DCB.W	6,$600	      	;6
	DC.W	$500,$600,$600  	;*3
	DCB.W	5,$500 	      	;5
	DC.W	$400,$500       	;*2
	DCB.W	4,$400	      	;4
	DC.W	$300,$400       	;*2
	DCB.W	3,$300          	;3
	DC.W	$100 	      	;*1
	DCB.W	2,$200	      	;2
	DC.W	$000            	;*1
	DC.W	$100	      	;1
	DCB.W	50,0		;50 (...=126)

	DCB.W	1,$001		;1
	DC.W	$000		;*1
	DCB.W	1,$002		;1
	DC.W	$001		;*1
	DCB.W	2,$003		;2
	DC.W	$002		;*1
	DCB.W	2,$004		;2
	DC.W	$003		;*1
	DCB.W	3,$005		;3
	DC.W	$006,$005		;*2
	DCB.W	3,$006		;3
	DC.W	$007,$006		;*2
	DCB.W	4,$007		;4

	DC.W	$017,$007		;*2
	DCB.W	4,$017		;4	
	DC.W	$027,$017		;*2
	DCB.W	5,$027		;5
	DC.W	$037,$027,$027	;*3
	DCB.W	5,$037		;5
	DC.W	$047,$037,$037	;*3
	DCB.W	6,$047		;6
	DC.W	$057,$047,$047	;*3
	DCB.W	6,$057		;6
	DC.W	$067,$057,$057	;*3
	DCB.W	7,$067		;7
	DC.W	$077,$067,$067	;*3
	DCB.W	7,$077		;7
	
	DC.W	$277,$077,$077	;*3
	DCB.W	8,$277		;8
	DC.W	$477,$277,$277	;*3
	DCB.W	8,$477		;8
	DC.W	$677,$477,$477	;*3
	DCB.W	9,$677		;9
	DC.W	$777,$777,$777	;*3
	DCB.W	20,$777		;9
END_RST:	DC.W	$0
	
ADR_ECR:	DC.W	0	
	END	

	