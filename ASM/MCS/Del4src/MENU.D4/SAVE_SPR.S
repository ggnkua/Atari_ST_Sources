*save sprites

INIT:	CLR.L	-(SP)
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.W	#6,SP

	LEA	IMAGE+34,A0	
	MOVE.L	#BUFFER,A1
	
	MOVE.W	#(33*4)-1,D0		;SAUVE SPRITE AVEC MASk
IN_BUF1:	MOVE.L	(A0),(A1)+		;ENTRELACEE
	MOVE.L	4(A0),(A1)+
	MOVE.L	24(A0),(A1)+
	MOVE.L	28(A0),(A1)+
	MOVE.L	8(A0),(A1)+
	MOVE.L	12(A0),(A1)+
	MOVE.L	32(A0),(A1)+
	MOVE.L	36(A0),(A1)+
	MOVE.L	16(A0),(A1)+
	MOVE.L	20(A0),(A1)+
	MOVE.L	40(A0),(A1)+
	MOVE.L	44(A0),(A1)+
	
	LEA	160(A0),A0
	DBRA	D0,IN_BUF1

	JSR	DISK
	CLR	-(SP)		
	TRAP	#1
	
DISK:	CLR.L	D5
	CLR.L	D0

	CLR.L	-(SP)
	PEA 	FILE
	MOVE.W 	#$3C,-(SP)
	TRAP 	#1		
	ADD.L 	#10,SP	
	MOVE.W 	D0,D5	

	CLR.L	D6
	MOVE.L	#6336,D6

	PEA	BUFFER
	MOVE.L	D6,-(SP)
	MOVE.W	D5,-(SP)
	MOVE.W	#$40,-(SP)
	TRAP	#1
	LEA.L	12(SP),SP

	MOVE.W	D5,-(SP)		;FCLOSE
	MOVE.W	#$3E,-(SP)
	TRAP	#1
	ADDQ.L	#4,SP
	RTS

******** DATA ********
IMAGE:	INCBIN	"\LEM1.PI1"
BUFFER:	DCB.W	6336,0	
FILE:	DC.B	"\SPRITE1.BLK",0
	END
