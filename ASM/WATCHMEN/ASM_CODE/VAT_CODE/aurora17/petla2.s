 dc.w 115,99
 dc.w 121,99
 dc.w 127,99
 dc.w 133,99
 dc.w 139,99
 dc.w 145,99
 dc.w 150,99
 dc.w 156,98
 dc.w 162,98
 dc.w 167,98
 dc.w 172,97
 dc.w 177,97
 dc.w 182,97
 dc.w 186,96
 dc.w 191,95
 dc.w 195,95
 dc.w 199,94
 dc.w 202,94
 dc.w 206,93
 dc.w 209,92
 dc.w 211,92
 dc.w 214,91
 dc.w 216,90
 dc.w 218,89
 dc.w 219,88
 dc.w 220,87
 dc.w 221,87
 dc.w 221,86
 dc.w 221,85
 dc.w 221,84
 dc.w 221,83
 dc.w 220,82
 dc.w 218,80
 dc.w 217,79
 dc.w 215,78
 dc.w 213,77
 dc.w 210,76
 dc.w 207,75
 dc.w 204,74
 dc.w 201,72
 dc.w 197,71
 dc.w 193,70
 dc.w 189,69
 dc.w 184,67
 dc.w 180,66
 dc.w 175,65
 dc.w 170,63
 dc.w 164,62
 dc.w 159,61
 dc.w 153,59
 dc.w 148,58
 dc.w 142,56
 dc.w 136,55
 dc.w 130,54
 dc.w 124,52
 dc.w 118,51
 dc.w 112,50
 dc.w 106,48
 dc.w 100,47
 dc.w 94,45
 dc.w 88,44
 dc.w 82,43
 dc.w 76,41
 dc.w 70,40
 dc.w 64,39
 dc.w 59,37
 dc.w 54,36
 dc.w 49,35
 dc.w 44,33
 dc.w 39,32
 dc.w 35,31
 dc.w 30,29
 dc.w 26,28
 dc.w 23,27
 dc.w 19,26
 dc.w 16,24
 dc.w 13,23
 dc.w 10,22
 dc.w 8,21
 dc.w 6,20
 dc.w 5,19
 dc.w 3,18
 dc.w 2,16
 dc.w 2,15
 dc.w 2,14
 dc.w 2,13
 dc.w 2,13
 dc.w 3,12
 dc.w 4,11
 dc.w 5,10
 dc.w 7,9
 dc.w 9,8
 dc.w 11,7
 dc.w 14,7
 dc.w 17,6
 dc.w 20,5
 dc.w 24,5
 dc.w 28,4
 dc.w 32,4
 dc.w 36,3
 dc.w 41,3
 dc.w 45,2
 dc.w 50,2
 dc.w 56,1
 dc.w 61,1
 dc.w 66,1
 dc.w 72,0
 dc.w 78,0
 dc.w 84,0
 dc.w 90,0
 dc.w 96,0
 dc.w 102,0
 dc.w 108,0
 dc.w 114,0
 dc.w 120,0
 dc.w 126,0
 dc.w 132,0
 dc.w 138,0
 dc.w 144,0
 dc.w 150,0
 dc.w 155,1
 dc.w 161,1
 dc.w 166,1
 dc.w 172,2
 dc.w 177,2
 dc.w 181,2
 dc.w 186,3
 dc.w 190,3
 dc.w 195,4
 dc.w 198,5
 dc.w 202,5
 dc.w 205,6
 dc.w 208,7
 dc.w 211,7
 dc.w 214,8
 dc.w 216,9
 dc.w 217,10
 dc.w 219,11
 dc.w 220,11
 dc.w 221,12
 dc.w 221,13
 dc.w 221,14
 dc.w 221,15
 dc.w 221,16
 dc.w 220,17
 dc.w 219,18
 dc.w 217,20
 dc.w 215,21
 dc.w 213,22
 dc.w 210,23
 dc.w 208,24
 dc.w 205,25
 dc.w 201,27
 dc.w 197,28
 dc.w 194,29
 dc.w 189,30
 dc.w 185,32
 dc.w 180,33
 dc.w 175,34
 dc.w 170,36
 dc.w 165,37
 dc.w 160,38
 dc.w 154,40
 dc.w 148,41
 dc.w 143,42
 dc.w 137,44
 dc.w 131,45
 dc.w 125,47
 dc.w 118,48
 dc.w 112,49
 dc.w 106,51
 dc.w 100,52
 dc.w 94,53
 dc.w 88,55
 dc.w 82,56
 dc.w 76,58
 dc.w 71,59
 dc.w 65,60
 dc.w 60,62
 dc.w 54,63
 dc.w 49,64
 dc.w 44,66
 dc.w 39,67
 dc.w 35,68
 dc.w 31,70
 dc.w 27,71
 dc.w 23,72
 dc.w 19,73
 dc.w 16,75
 dc.w 13,76
 dc.w 11,77
 dc.w 8,78
 dc.w 6,79
 dc.w 5,80
 dc.w 3,81
 dc.w 2,82
 dc.w 2,83
 dc.w 2,84
 dc.w 2,85
 dc.w 2,86
 dc.w 3,87
 dc.w 4,88
 dc.w 5,89
 dc.w 7,90
 dc.w 9,91
 dc.w 11,91
 dc.w 14,92
 dc.w 17,93
 dc.w 20,94
 dc.w 23,94
 dc.w 27,95
 dc.w 31,95
 dc.w 36,96
 dc.w 40,96
 dc.w 45,97
 dc.w 50,97
 dc.w 55,98
 dc.w 60,98
 dc.w 66,98
 dc.w 72,99
 dc.w 77,99
 dc.w 83,99
 dc.w 89,99
 dc.w 95,99
 dc.w 101,99
 dc.w 107,99
