	DC.B	"         AT LONG LAST, CHRISTOPHE FROM THE MEGASEXY WATCHMEN "
	DC.B	"BRINGS YOU THE SOURCE CODE TO THEIR BYTE-BENDER.   THIS "
	DC.B	"ROUTINE WAS CODED ESPECIALLY FOR THE LOADER TO DEF CON ONE, AND SO IT MAY STILL "
	DC.B	"HAVE SOME BITS LEFT OVER IN THE SOURCE CODE...     GREETINGS GO TO THE LOST BOYS (OF COURSE) "
	DC.B	"   MANIKIN AND SPAZ ( I HOPE YOU HAD A GOOD TIME IN GERMANY - I CAN'T WAIT TO SEE YOUR GAME! ) "
	DC.B	"  SAMMY JOE ( 1048576 APOLOGIES FOR FUCKING THIS PROGRAM UP THE LAST TIME! ) IAN, SKUNK, ZOGG, THE CAREBEARS, TEX "
	DC.B	"THE REPLICANTS, AND ALL THE OTHER EUROPEAN CREWS     THE DYNAMIC DUO (HITECH - HAVE YOU WASHED YOUR JEANS YET?) "
	DC.B	"   BAD BREW CREW, NEW ORDER, AND ANYBODY ELSE WHO IS READING THIS! "
	DC.B	"  OK GUYS AND DOLLS, LET'S WRAZZLE!            "
	DC.B	$FF
