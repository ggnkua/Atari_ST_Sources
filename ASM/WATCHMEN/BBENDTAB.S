wave
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 132*160
 dc.w 134*160
 dc.w 135*160
 dc.w 137*160
 dc.w 139*160
 dc.w 140*160
 dc.w 142*160
 dc.w 144*160
 dc.w 145*160
 dc.w 147*160
 dc.w 148*160
 dc.w 149*160
 dc.w 151*160
 dc.w 152*160
 dc.w 153*160
 dc.w 154*160
 dc.w 155*160
 dc.w 156*160
 dc.w 156*160
 dc.w 157*160
 dc.w 158*160
 dc.w 158*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 160*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 158*160
 dc.w 158*160
 dc.w 157*160
 dc.w 156*160
 dc.w 156*160
 dc.w 155*160
 dc.w 154*160
 dc.w 153*160
 dc.w 152*160
 dc.w 151*160
 dc.w 149*160
 dc.w 148*160
 dc.w 147*160
 dc.w 145*160
 dc.w 144*160
 dc.w 142*160
 dc.w 140*160
 dc.w 139*160
 dc.w 137*160
 dc.w 135*160
 dc.w 134*160
 dc.w 132*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 117*160
 dc.w 115*160
 dc.w 114*160
 dc.w 112*160
 dc.w 110*160
 dc.w 109*160
 dc.w 107*160
 dc.w 105*160
 dc.w 104*160
 dc.w 102*160
 dc.w 101*160
 dc.w 100*160
 dc.w 98*160
 dc.w 97*160
 dc.w 96*160
 dc.w 95*160
 dc.w 94*160
 dc.w 93*160
 dc.w 93*160
 dc.w 92*160
 dc.w 91*160
 dc.w 91*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 91*160
 dc.w 91*160
 dc.w 92*160
 dc.w 93*160
 dc.w 93*160
 dc.w 94*160
 dc.w 95*160
 dc.w 96*160
 dc.w 97*160
 dc.w 98*160
 dc.w 100*160
 dc.w 101*160
 dc.w 102*160
 dc.w 104*160
 dc.w 105*160
 dc.w 107*160
 dc.w 109*160
 dc.w 110*160
 dc.w 112*160
 dc.w 114*160
 dc.w 115*160
 dc.w 117*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 132*160
 dc.w 134*160
 dc.w 135*160
 dc.w 137*160
 dc.w 139*160
 dc.w 140*160
 dc.w 142*160
 dc.w 144*160
 dc.w 145*160
 dc.w 147*160
 dc.w 148*160
 dc.w 149*160
 dc.w 151*160
 dc.w 152*160
 dc.w 153*160
 dc.w 154*160
 dc.w 155*160
 dc.w 156*160
 dc.w 156*160
 dc.w 157*160
 dc.w 158*160
 dc.w 158*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 160*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 159*160
 dc.w 158*160
 dc.w 158*160
 dc.w 157*160
 dc.w 156*160
 dc.w 156*160
 dc.w 155*160
 dc.w 154*160
 dc.w 153*160
 dc.w 152*160
 dc.w 151*160
 dc.w 149*160
 dc.w 148*160
 dc.w 147*160
 dc.w 145*160
 dc.w 144*160
 dc.w 142*160
 dc.w 140*160
 dc.w 139*160
 dc.w 137*160
 dc.w 135*160
 dc.w 134*160
 dc.w 132*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 117*160
 dc.w 115*160
 dc.w 114*160
 dc.w 112*160
 dc.w 110*160
 dc.w 109*160
 dc.w 107*160
 dc.w 105*160
 dc.w 104*160
 dc.w 102*160
 dc.w 101*160
 dc.w 100*160
 dc.w 98*160
 dc.w 97*160
 dc.w 96*160
 dc.w 95*160
 dc.w 94*160
 dc.w 93*160
 dc.w 93*160
 dc.w 92*160
 dc.w 91*160
 dc.w 91*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 90*160
 dc.w 91*160
 dc.w 91*160
 dc.w 92*160
 dc.w 93*160
 dc.w 93*160
 dc.w 94*160
 dc.w 95*160
 dc.w 96*160
 dc.w 97*160
 dc.w 98*160
 dc.w 100*160
 dc.w 101*160
 dc.w 102*160
 dc.w 104*160
 dc.w 105*160
 dc.w 107*160
 dc.w 109*160
 dc.w 110*160
 dc.w 112*160
 dc.w 114*160
 dc.w 115*160
 dc.w 117*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 141*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 144*160
 dc.w 145*160
 dc.w 146*160
 dc.w 146*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 153*160
 dc.w 154*160
 dc.w 155*160
 dc.w 155*160
 dc.w 156*160
 dc.w 156*160
 dc.w 157*160
 dc.w 157*160
 dc.w 158*160
 dc.w 158*160
 dc.w 159*160
 dc.w 159*160
 dc.w 160*160
 dc.w 160*160
 dc.w 161*160
 dc.w 161*160
 dc.w 162*160
 dc.w 162*160
 dc.w 163*160
 dc.w 163*160
 dc.w 163*160
 dc.w 164*160
 dc.w 164*160
 dc.w 165*160
 dc.w 165*160
 dc.w 165*160
 dc.w 166*160
 dc.w 166*160
 dc.w 166*160
 dc.w 167*160
 dc.w 167*160
 dc.w 167*160
 dc.w 167*160
 dc.w 168*160
 dc.w 168*160
 dc.w 168*160
 dc.w 168*160
 dc.w 168*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 170*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 168*160
 dc.w 168*160
 dc.w 168*160
 dc.w 168*160
 dc.w 168*160
 dc.w 167*160
 dc.w 167*160
 dc.w 167*160
 dc.w 167*160
 dc.w 166*160
 dc.w 166*160
 dc.w 166*160
 dc.w 165*160
 dc.w 165*160
 dc.w 165*160
 dc.w 164*160
 dc.w 164*160
 dc.w 163*160
 dc.w 163*160
 dc.w 163*160
 dc.w 162*160
 dc.w 162*160
 dc.w 161*160
 dc.w 161*160
 dc.w 160*160
 dc.w 160*160
 dc.w 159*160
 dc.w 159*160
 dc.w 158*160
 dc.w 158*160
 dc.w 157*160
 dc.w 157*160
 dc.w 156*160
 dc.w 156*160
 dc.w 155*160
 dc.w 155*160
 dc.w 154*160
 dc.w 153*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 146*160
 dc.w 146*160
 dc.w 145*160
 dc.w 144*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 141*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 138*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 108*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 105*160
 dc.w 104*160
 dc.w 103*160
 dc.w 103*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 96*160
 dc.w 96*160
 dc.w 95*160
 dc.w 94*160
 dc.w 94*160
 dc.w 93*160
 dc.w 93*160
 dc.w 92*160
 dc.w 92*160
 dc.w 91*160
 dc.w 91*160
 dc.w 90*160
 dc.w 90*160
 dc.w 89*160
 dc.w 89*160
 dc.w 88*160
 dc.w 88*160
 dc.w 87*160
 dc.w 87*160
 dc.w 86*160
 dc.w 86*160
 dc.w 86*160
 dc.w 85*160
 dc.w 85*160
 dc.w 84*160
 dc.w 84*160
 dc.w 84*160
 dc.w 83*160
 dc.w 83*160
 dc.w 83*160
 dc.w 82*160
 dc.w 82*160
 dc.w 82*160
 dc.w 82*160
 dc.w 81*160
 dc.w 81*160
 dc.w 81*160
 dc.w 81*160
 dc.w 81*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 81*160
 dc.w 81*160
 dc.w 81*160
 dc.w 81*160
 dc.w 81*160
 dc.w 82*160
 dc.w 82*160
 dc.w 82*160
 dc.w 82*160
 dc.w 83*160
 dc.w 83*160
 dc.w 83*160
 dc.w 84*160
 dc.w 84*160
 dc.w 84*160
 dc.w 85*160
 dc.w 85*160
 dc.w 86*160
 dc.w 86*160
 dc.w 86*160
 dc.w 87*160
 dc.w 87*160
 dc.w 88*160
 dc.w 88*160
 dc.w 89*160
 dc.w 89*160
 dc.w 90*160
 dc.w 90*160
 dc.w 91*160
 dc.w 91*160
 dc.w 92*160
 dc.w 92*160
 dc.w 93*160
 dc.w 93*160
 dc.w 94*160
 dc.w 94*160
 dc.w 95*160
 dc.w 96*160
 dc.w 96*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 103*160
 dc.w 103*160
 dc.w 104*160
 dc.w 105*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 108*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 111*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 125*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 139*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 124*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 110*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 124*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 124*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 110*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 111*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 125*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 139*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 138*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 124*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 110*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 111*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 125*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 139*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 124*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 125*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 124*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 124*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 124*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 124*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 138*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 153*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 152*160
 dc.w 151*160
 dc.w 151*160
 dc.w 151*160
 dc.w 150*160
 dc.w 150*160
 dc.w 150*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 125*160
 dc.w 125*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 111*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 97*160
 dc.w 98*160
 dc.w 98*160
 dc.w 98*160
 dc.w 99*160
 dc.w 99*160
 dc.w 99*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
 dc.w 124*160
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 131*160
 dc.w 133*160
 dc.w 135*160
 dc.w 136*160
 dc.w 138*160
 dc.w 139*160
 dc.w 141*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 141*160
 dc.w 139*160
 dc.w 138*160
 dc.w 136*160
 dc.w 135*160
 dc.w 133*160
 dc.w 131*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 125*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 118*160
 dc.w 116*160
 dc.w 114*160
 dc.w 113*160
 dc.w 111*160
 dc.w 110*160
 dc.w 108*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 108*160
 dc.w 110*160
 dc.w 111*160
 dc.w 113*160
 dc.w 114*160
 dc.w 116*160
 dc.w 118*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 131*160
 dc.w 133*160
 dc.w 135*160
 dc.w 136*160
 dc.w 138*160
 dc.w 139*160
 dc.w 141*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 141*160
 dc.w 139*160
 dc.w 138*160
 dc.w 136*160
 dc.w 135*160
 dc.w 133*160
 dc.w 131*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 118*160
 dc.w 116*160
 dc.w 114*160
 dc.w 113*160
 dc.w 111*160
 dc.w 110*160
 dc.w 108*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 108*160
 dc.w 110*160
 dc.w 111*160
 dc.w 113*160
 dc.w 114*160
 dc.w 116*160
 dc.w 118*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 124*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 131*160
 dc.w 133*160
 dc.w 135*160
 dc.w 136*160
 dc.w 138*160
 dc.w 139*160
 dc.w 141*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 141*160
 dc.w 139*160
 dc.w 138*160
 dc.w 136*160
 dc.w 135*160
 dc.w 133*160
 dc.w 131*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 125*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 118*160
 dc.w 116*160
 dc.w 114*160
 dc.w 113*160
 dc.w 111*160
 dc.w 110*160
 dc.w 108*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 108*160
 dc.w 110*160
 dc.w 111*160
 dc.w 113*160
 dc.w 114*160
 dc.w 116*160
 dc.w 118*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 131*160
 dc.w 133*160
 dc.w 135*160
 dc.w 136*160
 dc.w 138*160
 dc.w 139*160
 dc.w 141*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 141*160
 dc.w 139*160
 dc.w 138*160
 dc.w 136*160
 dc.w 135*160
 dc.w 133*160
 dc.w 131*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 118*160
 dc.w 116*160
 dc.w 114*160
 dc.w 113*160
 dc.w 111*160
 dc.w 110*160
 dc.w 108*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 108*160
 dc.w 110*160
 dc.w 111*160
 dc.w 113*160
 dc.w 114*160
 dc.w 116*160
 dc.w 118*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 131*160
 dc.w 133*160
 dc.w 135*160
 dc.w 136*160
 dc.w 138*160
 dc.w 139*160
 dc.w 141*160
 dc.w 142*160
 dc.w 143*160
 dc.w 144*160
 dc.w 145*160
 dc.w 146*160
 dc.w 147*160
 dc.w 148*160
 dc.w 148*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 149*160
 dc.w 148*160
 dc.w 148*160
 dc.w 147*160
 dc.w 146*160
 dc.w 145*160
 dc.w 144*160
 dc.w 143*160
 dc.w 142*160
 dc.w 141*160
 dc.w 139*160
 dc.w 138*160
 dc.w 136*160
 dc.w 135*160
 dc.w 133*160
 dc.w 131*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 118*160
 dc.w 116*160
 dc.w 114*160
 dc.w 113*160
 dc.w 111*160
 dc.w 110*160
 dc.w 108*160
 dc.w 107*160
 dc.w 106*160
 dc.w 105*160
 dc.w 104*160
 dc.w 103*160
 dc.w 102*160
 dc.w 101*160
 dc.w 101*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 100*160
 dc.w 101*160
 dc.w 101*160
 dc.w 102*160
 dc.w 103*160
 dc.w 104*160
 dc.w 105*160
 dc.w 106*160
 dc.w 107*160
 dc.w 108*160
 dc.w 110*160
 dc.w 111*160
 dc.w 113*160
 dc.w 114*160
 dc.w 116*160
 dc.w 118*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 132*160
 dc.w 134*160
 dc.w 136*160
 dc.w 138*160
 dc.w 140*160
 dc.w 142*160
 dc.w 144*160
 dc.w 145*160
 dc.w 147*160
 dc.w 149*160
 dc.w 150*160
 dc.w 152*160
 dc.w 153*160
 dc.w 155*160
 dc.w 156*160
 dc.w 158*160
 dc.w 159*160
 dc.w 160*160
 dc.w 161*160
 dc.w 162*160
 dc.w 163*160
 dc.w 164*160
 dc.w 165*160
 dc.w 166*160
 dc.w 167*160
 dc.w 167*160
 dc.w 168*160
 dc.w 168*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 170*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 168*160
 dc.w 168*160
 dc.w 167*160
 dc.w 167*160
 dc.w 166*160
 dc.w 165*160
 dc.w 164*160
 dc.w 163*160
 dc.w 162*160
 dc.w 161*160
 dc.w 160*160
 dc.w 159*160
 dc.w 158*160
 dc.w 156*160
 dc.w 155*160
 dc.w 153*160
 dc.w 152*160
 dc.w 150*160
 dc.w 149*160
 dc.w 147*160
 dc.w 145*160
 dc.w 144*160
 dc.w 142*160
 dc.w 140*160
 dc.w 138*160
 dc.w 136*160
 dc.w 134*160
 dc.w 132*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 125*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 117*160
 dc.w 115*160
 dc.w 113*160
 dc.w 111*160
 dc.w 109*160
 dc.w 107*160
 dc.w 105*160
 dc.w 104*160
 dc.w 102*160
 dc.w 100*160
 dc.w 99*160
 dc.w 97*160
 dc.w 96*160
 dc.w 94*160
 dc.w 93*160
 dc.w 91*160
 dc.w 90*160
 dc.w 89*160
 dc.w 88*160
 dc.w 87*160
 dc.w 86*160
 dc.w 85*160
 dc.w 84*160
 dc.w 83*160
 dc.w 82*160
 dc.w 82*160
 dc.w 81*160
 dc.w 81*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 81*160
 dc.w 81*160
 dc.w 82*160
 dc.w 82*160
 dc.w 83*160
 dc.w 84*160
 dc.w 85*160
 dc.w 86*160
 dc.w 87*160
 dc.w 88*160
 dc.w 89*160
 dc.w 90*160
 dc.w 91*160
 dc.w 93*160
 dc.w 94*160
 dc.w 96*160
 dc.w 97*160
 dc.w 99*160
 dc.w 100*160
 dc.w 102*160
 dc.w 104*160
 dc.w 105*160
 dc.w 107*160
 dc.w 109*160
 dc.w 111*160
 dc.w 113*160
 dc.w 115*160
 dc.w 117*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 128*160
 dc.w 130*160
 dc.w 132*160
 dc.w 134*160
 dc.w 136*160
 dc.w 138*160
 dc.w 140*160
 dc.w 142*160
 dc.w 144*160
 dc.w 145*160
 dc.w 147*160
 dc.w 149*160
 dc.w 150*160
 dc.w 152*160
 dc.w 153*160
 dc.w 155*160
 dc.w 156*160
 dc.w 158*160
 dc.w 159*160
 dc.w 160*160
 dc.w 161*160
 dc.w 162*160
 dc.w 163*160
 dc.w 164*160
 dc.w 165*160
 dc.w 166*160
 dc.w 167*160
 dc.w 167*160
 dc.w 168*160
 dc.w 168*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 170*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 169*160
 dc.w 168*160
 dc.w 168*160
 dc.w 167*160
 dc.w 167*160
 dc.w 166*160
 dc.w 165*160
 dc.w 164*160
 dc.w 163*160
 dc.w 162*160
 dc.w 161*160
 dc.w 160*160
 dc.w 159*160
 dc.w 158*160
 dc.w 156*160
 dc.w 155*160
 dc.w 153*160
 dc.w 152*160
 dc.w 150*160
 dc.w 149*160
 dc.w 147*160
 dc.w 145*160
 dc.w 144*160
 dc.w 142*160
 dc.w 140*160
 dc.w 138*160
 dc.w 136*160
 dc.w 134*160
 dc.w 132*160
 dc.w 130*160
 dc.w 128*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 121*160
 dc.w 119*160
 dc.w 117*160
 dc.w 115*160
 dc.w 113*160
 dc.w 111*160
 dc.w 109*160
 dc.w 107*160
 dc.w 105*160
 dc.w 104*160
 dc.w 102*160
 dc.w 100*160
 dc.w 99*160
 dc.w 97*160
 dc.w 96*160
 dc.w 94*160
 dc.w 93*160
 dc.w 91*160
 dc.w 90*160
 dc.w 89*160
 dc.w 88*160
 dc.w 87*160
 dc.w 86*160
 dc.w 85*160
 dc.w 84*160
 dc.w 83*160
 dc.w 82*160
 dc.w 82*160
 dc.w 81*160
 dc.w 81*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 80*160
 dc.w 81*160
 dc.w 81*160
 dc.w 82*160
 dc.w 82*160
 dc.w 83*160
 dc.w 84*160
 dc.w 85*160
 dc.w 86*160
 dc.w 87*160
 dc.w 88*160
 dc.w 89*160
 dc.w 90*160
 dc.w 91*160
 dc.w 93*160
 dc.w 94*160
 dc.w 96*160
 dc.w 97*160
 dc.w 99*160
 dc.w 100*160
 dc.w 102*160
 dc.w 104*160
 dc.w 105*160
 dc.w 107*160
 dc.w 109*160
 dc.w 111*160
 dc.w 113*160
 dc.w 115*160
 dc.w 117*160
 dc.w 119*160
 dc.w 121*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 139*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 143*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 145*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 143*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 135*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 110*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 106*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 106*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 139*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 143*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 145*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 143*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 110*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 106*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 106*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 115*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 125*160
 dc.w 126*160
 dc.w 127*160
 dc.w 128*160
 dc.w 129*160
 dc.w 130*160
 dc.w 131*160
 dc.w 132*160
 dc.w 133*160
 dc.w 134*160
 dc.w 135*160
 dc.w 135*160
 dc.w 136*160
 dc.w 137*160
 dc.w 138*160
 dc.w 139*160
 dc.w 139*160
 dc.w 140*160
 dc.w 141*160
 dc.w 141*160
 dc.w 142*160
 dc.w 142*160
 dc.w 143*160
 dc.w 143*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 145*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 144*160
 dc.w 143*160
 dc.w 143*160
 dc.w 142*160
 dc.w 142*160
 dc.w 141*160
 dc.w 141*160
 dc.w 140*160
 dc.w 139*160
 dc.w 139*160
 dc.w 138*160
 dc.w 137*160
 dc.w 136*160
 dc.w 135*160
 dc.w 134*160
 dc.w 134*160
 dc.w 133*160
 dc.w 132*160
 dc.w 131*160
 dc.w 130*160
 dc.w 129*160
 dc.w 128*160
 dc.w 127*160
 dc.w 126*160
 dc.w 124*160
 dc.w 123*160
 dc.w 122*160
 dc.w 121*160
 dc.w 120*160
 dc.w 119*160
 dc.w 118*160
 dc.w 117*160
 dc.w 116*160
 dc.w 115*160
 dc.w 114*160
 dc.w 114*160
 dc.w 113*160
 dc.w 112*160
 dc.w 111*160
 dc.w 110*160
 dc.w 110*160
 dc.w 109*160
 dc.w 108*160
 dc.w 108*160
 dc.w 107*160
 dc.w 107*160
 dc.w 106*160
 dc.w 106*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 105*160
 dc.w 106*160
 dc.w 106*160
 dc.w 107*160
 dc.w 107*160
 dc.w 108*160
 dc.w 108*160
 dc.w 109*160
 dc.w 110*160
 dc.w 110*160
 dc.w 111*160
 dc.w 112*160
 dc.w 113*160
 dc.w 114*160
 dc.w 114*160
 dc.w 115*160
 dc.w 116*160
 dc.w 117*160
 dc.w 118*160
 dc.w 119*160
 dc.w 120*160
 dc.w 121*160
 dc.w 122*160
 dc.w 123*160
 dc.w 124*160
