	DC.W 13,0
	DC.L 0,39,160*170
	DC.W 13,0
	DC.L 0,39,160*170

	DC.W 12,0
	DC.L 0,42,160*171
	DC.W 12,0
	DC.L 0,42,160*171

	DC.W 11,0
	DC.L 0,45,160*172
	DC.W 11,0
	DC.L 0,45,160*172

	DC.W 10,0
	DC.L 0,48,160*173
	DC.W 10,0
	DC.L 0,48,160*173

	DC.W 9,0
	DC.L 0,51,160*174
	DC.W 9,0
	DC.L 0,51,160*174

	DC.W 8,0
	DC.L 0,54,160*175
	DC.W 8,0
	DC.L 0,54,160*175

	DC.W 7,0
	DC.L 0,57,160*176
	DC.W 7,0
	DC.L 0,57,160*176

	DC.W 6,0
	DC.L 0,60,160*177
	DC.W 6,0
	DC.L 0,60,160*177

	DC.W 5,0
	DC.L 0,63,160*178
	DC.W 5,0
	DC.L 0,63,160*178

	DC.W 4,0
	DC.L 0,66,160*179
	DC.W 4,0
	DC.L 0,66,160*179

	DC.W 3,0
	DC.L 0,69,160*180
	DC.W 3,0
	DC.L 0,69,160*180

	DC.W 2,0
	DC.L 0,72,160*181
	DC.W 2,0
	DC.L 0,72,160*181

	DC.W 1,0
	DC.L 0,75,160*182
	DC.W 1,0
	DC.L 0,75,160*182

	DC.W 1,-6
	DC.L 75,3,160*182
	DC.W 1,-6
	DC.L 75,3,160*182

	DC.W 2,-6
	DC.L 75,6,160*181
	DC.W 2,-6
	DC.L 75,6,160*181

	DC.W 3,-6
	DC.L 75,9,160*180
	DC.W 3,-6
	DC.L 75,9,160*180

	DC.W 4,-6
	DC.L 75,12,160*179
	DC.W 4,-6
	DC.L 75,12,160*179

	DC.W 5,-6
	DC.L 75,15,160*178
	DC.W 5,-6
	DC.L 75,15,160*178

	DC.W 6,-6
	DC.L 75,18,160*177
	DC.W 6,-6
	DC.L 75,18,160*177

	DC.W 7,-6
	DC.L 75,21,160*176
	DC.W 7,-6
	DC.L 75,21,160*176

	DC.W 8,-6
	DC.L 75,24,160*175
	DC.W 8,-6
	DC.L 75,24,160*175

	DC.W 9,-6
	DC.L 75,27,160*174
	DC.W 9,-6
	DC.L 75,27,160*174

	DC.W 10,-6
	DC.L 75,30,160*173
	DC.W 10,-6
	DC.L 75,30,160*173

	DC.W 11,-6
	DC.L 75,33,160*172
	DC.W 11,-6
	DC.L 75,33,160*172

	DC.W 12,-6
	DC.L 75,36,160*171
	DC.W 12,-6
	DC.L 75,36,160*171

	DC.W 13,-6
	DC.L 75,39,160*170
	DC.W 13,-6
	DC.L 75,39,160*170

	DC.W 12,-6
	DC.L 75,36,160*171
	DC.W 12,-6
	DC.L 75,36,160*171

	DC.W 11,-6
	DC.L 75,33,160*172
	DC.W 11,-6
	DC.L 75,33,160*172

	DC.W 10,-6
	DC.L 75,30,160*173
	DC.W 10,-6
	DC.L 75,30,160*173

	DC.W 9,-6
	DC.L 75,27,160*174
	DC.W 9,-6
	DC.L 75,27,160*174

	DC.W 8,-6
	DC.L 75,24,160*175
	DC.W 8,-6
	DC.L 75,24,160*175

	DC.W 7,-6
	DC.L 75,21,160*176
	DC.W 7,-6
	DC.L 75,21,160*176

	DC.W 6,-6
	DC.L 75,18,160*177
	DC.W 6,-6
	DC.L 75,18,160*177

	DC.W 5,-6
	DC.L 75,15,160*178
	DC.W 5,-6
	DC.L 75,15,160*178

	DC.W 4,-6
	DC.L 75,12,160*179
	DC.W 4,-6
	DC.L 75,12,160*179

	DC.W 3,-6
	DC.L 75,9,160*180
	DC.W 3,-6
	DC.L 75,9,160*180

	DC.W 2,-6
	DC.L 75,6,160*181
	DC.W 2,-6
	DC.L 75,6,160*181

	DC.W 1,-6
	DC.L 75,3,160*182
	DC.W 1,-6
	DC.L 75,3,160*182

	DC.W 1,0
	DC.L 0,75,160*182
	DC.W 1,0
	DC.L 0,75,160*182

	DC.W 2,0
	DC.L 0,72,160*181
	DC.W 2,0
	DC.L 0,72,160*181

	DC.W 3,0
	DC.L 0,69,160*180
	DC.W 3,0
	DC.L 0,69,160*180

	DC.W 4,0
	DC.L 0,66,160*179
	DC.W 4,0
	DC.L 0,66,160*179

	DC.W 5,0
	DC.L 0,63,160*178
	DC.W 5,0
	DC.L 0,63,160*178

	DC.W 6,0
	DC.L 0,60,160*177
	DC.W 6,0
	DC.L 0,60,160*177

	DC.W 7,0
	DC.L 0,57,160*176
	DC.W 7,0
	DC.L 0,57,160*176

	DC.W 8,0
	DC.L 0,54,160*175
	DC.W 8,0
	DC.L 0,54,160*175

	DC.W 9,0
	DC.L 0,51,160*174
	DC.W 9,0
	DC.L 0,51,160*174

	DC.W 10,0
	DC.L 0,48,160*173
	DC.W 10,0
	DC.L 0,48,160*173

	DC.W 11,0
	DC.L 0,45,160*172
	DC.W 11,0
	DC.L 0,45,160*172

	DC.W 12,0
	DC.L 0,42,160*171
	DC.W 12,0
	DC.L 0,42,160*171
