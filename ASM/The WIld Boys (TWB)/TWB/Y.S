	DC.L $78000+(0*160)
	DC.L $78000+(1*160)
	DC.L $78000+(1*160)
	DC.L $78000+(2*160)
	DC.L $78000+(4*160)
	DC.L $78000+(8*160)
	DC.L $78000+(12*160)
	DC.L $78000+(16*160)
	DC.L $78000+(20*160)
	DC.L $78000+(24*160)
	DC.L $78000+(28*160)
	DC.L $78000+(32*160)
	DC.L $78000+(36*160)
	DC.L $78000+(40*160)
	DC.L $78000+(44*160)
	DC.L $78000+(48*160)
	DC.L $78000+(52*160)
	DC.L $78000+(56*160)
	DC.L $78000+(58*160)
	DC.L $78000+(59*160)
	DC.L $78000+(59*160)
	DC.L $78000+(60*160)
	DC.L $78000+(59*160)
	DC.L $78000+(59*160)
	DC.L $78000+(58*160)
	DC.L $78000+(56*160)
	DC.L $78000+(52*160)
	DC.L $78000+(48*160)
	DC.L $78000+(44*160)
	DC.L $78000+(40*160)
	DC.L $78000+(36*160)
	DC.L $78000+(32*160)
	DC.L $78000+(28*160)
	DC.L $78000+(24*160)
	DC.L $78000+(20*160)
	DC.L $78000+(16*160)
	DC.L $78000+(12*160)
	DC.L $78000+(8*160)
	DC.L $78000+(4*160)
	DC.L $78000+(2*160)
	DC.L $78000+(1*160)
	DC.L $78000+(1*160)

