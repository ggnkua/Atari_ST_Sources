C1	SET	$777
C2	SET	$666
C3	SET	$555
C4	SET	$333 
PAL_4	DC.W	$12,C1,C4,C1,C3,C1,C3,C1,C2,C1,C2,C1,C2,C1,C2,C1
PAL_3	DC.W	$12,C2,C1,C1,C4,C2,C1,C1,C3,C2,C1,C1,C3,C2,C1,C1
PAL_2	DC.W	$12,C3,C2,C2,C1,C1,C1,C1,C4,C3,C2,C2,C1,C1,C1,C1
PAL_1	DC.W	$12,C4,C3,C3,C2,C2,C2,C2,C1,C1,C1,C1,C1,C1,C1,C1
