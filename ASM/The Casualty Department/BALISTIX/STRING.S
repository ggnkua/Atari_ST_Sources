STRING	DS.L	1
STRIN2	DS.L	1
	DC.B	0,0,0,0
