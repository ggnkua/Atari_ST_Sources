*	ON ENTRY:
*	D0=TRACK 
*	D1=SECTOR
*	D2=NUMBER OF SECTORS TO LOAD
*	A5=LOAD ADDRESS

RELOCATE_CODE

	PEA	0
	MOVE.W	#32,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7

	LEA	MAIN(PC),A0
	LEA	$CA00,A1
	MOVE.L	#END_OF_CODE-MAIN,D0
RELOC	MOVE.B	(A0)+,(A1)+
	DBF	D0,RELOC


TEST	CLR.L	D0
	MOVE.W	#0,D0		;TRACK
	MOVE.W	#2,D1		;SECTOR
	MOVE.W	#8,D2		;NUMBER OF SECTORS TO READ
	LEA	$30000,A5
	MOVE.L	A5,A4
	BSR	MAIN

	MOVE.L	#$67934691,$2F500	;BOOT SECTOR CODE DID
	MOVE.L	#$15800,$2F600		;THIS ON THE ORIGINAL
	MOVE.W	#$6589,D0		;UNFILED VERSION
	MOVE.W	#$7801,D2		;
	MOVE.W	#$1206,D3		;
	JMP	(A4)


MAIN	MOVEM.L	D0-A6,-(A7)
	BSR	CALC
	BSR	OPEN
	BSR	LSEEK
	BSR	READ
	BSR	CLOSE
	MOVEM.L	(A7)+,D0-A6
	RTS

CALC	SUB.L	#1,D1
	MULU	#5120,D0
	MULU	#512,D1
	ADD.L	D1,D0
	MULU	#512,D2
	MOVE.L	D2,D3		;VALUE FOR READ
	MOVE.L	D0,D6		;VALUE FOR LSEEK
	RTS


OPEN	CLR.W	-(A7)		;FILE TYPE
	PEA	FILE(PC)	;FILE NAME
	MOVE.W	#$3D,-(A7)
	TRAP	#1
	ADD.L	#8,A7
	TST.L	D0
	BMI	EXIT
	MOVE.W	D0,D7
	RTS

LSEEK	MOVE.W	#1,-(A7)	;RELATIVE FROM TOP OF FILE		
	MOVE.W	D0,-(A7)	;FILE HANDLE
	MOVE.L	D6,-(A7)	;OFFSET FROM TOP OF FILE
	MOVE.W	#$42,-(A7)
	TRAP	#1
	ADD.L	#10,A7
	TST.L	D0
	BMI 	EXIT
	CMP.L	D0,D6		;HAS THE FILE POINTER MOVED CORRECTLY ?
	BNE	EXIT
	RTS
	
READ	MOVE.L	A5,-(A7)	;BUFFER FOR FILE
	MOVE.L	D3,-(A7)	;READ D3 BYTES
	MOVE.W	D7,-(A7)	;FILE HANDLE
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADD.L	#12,A7
	TST.L	D0
	BMI 	EXIT
	RTS

CLOSE	MOVE.W	D7,-(A7)
	MOVE.W	#$3E,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	TST.L	D0
	BMI 	EXIT
	RTS

EXIT	CLR.W	-(A7)
	TRAP	#1

	DATA	
	EVEN
FILE	DC.B	"BALLISTI.X",0
	EVEN

END_OF_CODE	DS.B	1