
TRAINER	DC.B	27,"Y",32+17,32+23
	DC.B	"DO YOU WANT TO CHEAT? [Y]es [N]o",0
	even
