 TEXT 
Begin:
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0000:            CMP.L     $466.W,D0 
                  BEQ.S     L0000 
                  MOVE.L    (A7)+,D0
                  BSR       INIT_ECRAN
                  BSR       CALC_PAL_FONTE
                  BSR       INIT_PAL2 
                  LEA       L004D,A0
                  MOVEA.L   ECRAN,A1
                  MOVEA.L   $42E.W,A2 
                  MOVE.L    #$29400,D0
                  SUBA.L    D0,A2 
L0001:            MOVE.L    (A0)+,(A1)+ 
                  CLR.L     (A2)+ 
                  SUBQ.L    #4,D0 
                  BNE.S     L0001 
                  MOVEA.L   ECRAN,A1
L0002:            TST.B     $208.W
                  BEQ.S     L0002 
                  CLR.W     $208.W
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0003:            CMP.L     $466.W,D0 
                  BEQ.S     L0003 
                  MOVE.L    (A7)+,D0
                  MOVE.L    #-1,-$6800.W
                  MOVE.L    A1,([$40C.W],4.W) 
                  MOVE.L    #$A,([$40C.W],$10.W)
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0004:            CMP.L     $466.W,D0 
                  BEQ.S     L0004 
                  MOVE.L    (A7)+,D0
                  CLR.L     -$6800.W
                  MOVE.W    #$FA,D0 
L0005:            MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0006:            CMP.L     $466.W,D0 
                  BEQ.S     L0006 
                  MOVE.L    (A7)+,D0
                  DBF       D0,L0005
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0007:            CMP.L     $466.W,D0 
                  BEQ.S     L0007 
                  MOVE.L    (A7)+,D0
                  MOVE.L    #-1,-$6800.W
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0008:            CMP.L     $466.W,D0 
                  BEQ.S     L0008 
                  MOVE.L    (A7)+,D0
                  MOVE.L    $42E.W,D0 
                  SUBI.L    #$1F400,D0
                  MOVE.L    D0,([$40C.W],4.W) 
                  MOVE.L    #4,([$40C.W],$10.W) 
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0009:            CMP.L     $466.W,D0 
                  BEQ.S     L0009 
                  MOVE.L    (A7)+,D0
                  CLR.L     -$6800.W
                  BSR       INIT_ECRAN
                  BSR       AFFICHE_GRAPH 
                  MOVE.L    ECRAN,([$40C.W],4.W)
                  MOVE.L    #1,([$40C.W],$10.W) 
                  BSR       INIT_PAL_FONTE
                  MOVE.L    #PAL,([$40C.W],$24.W) 
                  MOVE.L    #-$6800,([$40C.W],$28.W)
                  MOVE.W    #$80,([$40C.W],$30.W) 
                  MOVE.L    #TEXT,P_TEXT
                 CLR.W     $208.W
                 BSR       SI_VA 
                  MOVE.L    #TEXT2,P_TEXT 
                  BSR       SI_VA 
                  MOVE.L    #TEXT3,P_TEXT 
                  BSR       SI_VA 
                  LEA       TRANS,A0
                  BSR       RELOC 
                  LEA       L0047(PC),A0
                  MOVE.L    #-$7F7FFF80,D1
                  MOVE.W    #$1F,D0 
L000A:            MOVE.L    D1,(A0)+
                  DBF       D0,L000A
                  MOVE.L    #PAL,([$40C.W],$24.W) 
                  MOVE.L    #-$6800,([$40C.W],$28.W)
                  MOVE.W    #$80,([$40C.W],$30.W) 
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L000B:            CMP.L     $466.W,D0 
                  BEQ.S     L000B 
                  MOVE.L    (A7)+,D0
                  MOVEM.L   ECRAN,A0-A1 
L000C:            TST.B     $208.W
                  BEQ.S     L000C 
                  CLR.W     $208.W
                  JSR       TRANS 
                  RTS 
SI_VA:            BSR       SEARCH_CHAR 
                  MOVEA.L   ECRAN,A1
                  LEA       7760(A1),A1 
                  BSR       AFF_BOUT2 
                  BSR       SEARCH_CHAR 
                  MOVEA.L   ECRAN,A1
                  LEA       19328(A1),A1
                  BSR       AFF_BOUT2 
                  BSR       SEARCH_CHAR 
                  MOVEA.L   ECRAN,A1
                  LEA       30848(A1),A1
                  BSR       AFF_BOUT2 
                  BSR       DISPLAY 
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L000E:            CMP.L     $466.W,D0 
                  BEQ.S     L000E 
                  MOVE.L    (A7)+,D0
                  MOVEA.L   ECRAN,A1
                  LEA       7760(A1),A1 
                  MOVEQ     #0,D0 
                  MOVE.W    #$50,D7 
CLS:              MOVE.W    #$12,D6 
L0010:            MOVE.L    D0,(A1)+
                  MOVE.L    D0,(A1)+
                  MOVE.L    D0,(A1)+
                  MOVE.L    D0,(A1)+
                  DBF       D6,L0010
                  LEA       80(A1),A1 
                  DBF       D7,CLS
                  RTS 
DISPLAY:          MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0012:            CMP.L     $466.W,D0 
                  BEQ.S     L0012 
                  MOVE.L    (A7)+,D0
                  MOVE.L    #PAL,([$40C.W],$24.W) 
                  MOVE.L    #-$6800,([$40C.W],$28.W)
                  MOVE.W    #$80,([$40C.W],$30.W) 
                  MOVE.W    #9,FADE_OK
                  BSR       FADE_UP 
                  TST.W     FADE_OK 
                  BNE.S     DISPLAY 
                  MOVE.W    #$64,D7 
WAIT:             MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0014:            CMP.L     $466.W,D0 
                  BEQ.S     L0014 
                  MOVE.L    (A7)+,D0
                  DBF       D7,WAIT 
L0015:            MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0016:            CMP.L     $466.W,D0 
                  BEQ.S     L0016 
                  MOVE.L    (A7)+,D0
                  MOVE.L    #PAL,([$40C.W],$24.W) 
                  MOVE.L    #-$6800,([$40C.W],$28.W)
                  MOVE.W    #$80,([$40C.W],$30.W) 
                  MOVE.W    #9,FADE_OK
                  BSR       FADE_DOWN 
                  TST.W     FADE_OK 
                  BNE.S     L0015 
                  MOVE.L    D0,-(A7)
                  MOVE.L    $466.W,D0 
L0017:            CMP.L     $466.W,D0 
                  BEQ.S     L0017 
                  MOVE.L    (A7)+,D0
                  MOVE.L    #PAL,([$40C.W],$24.W) 
                  MOVE.L    #-$6800,([$40C.W],$28.W)
                  MOVE.W    #$80,([$40C.W],$30.W) 
                  RTS 
FADE_UP:          LEA       L003E(PC),A4
                  LEA       L0047(PC),A1
                  BSR       L0019 
                  LEA       L0048(PC),A1
                  BSR       L0019 
                  LEA       L0049(PC),A1
                  BSR       L0019 
                  RTS 
L0019:            MOVE.B    (A1),D0 
                  ADDQ.B    #8,D0 
                  CMP.B     (A4)+,D0
                  BCS.S     L001A 
                  SUBQ.W    #1,FADE_OK
                  MOVE.B    (A1),D0 
L001A:            MOVE.B    D0,(A1)+
                  MOVE.B    (A1),D0 
                  ADDQ.B    #8,D0 
                  CMP.B     (A4)+,D0
                  BCS.S     L001B 
                  SUBQ.W    #1,FADE_OK
                  MOVE.B    (A1),D0 
L001B:            MOVE.B    D0,(A1)+
                  ADDQ.L    #1,A1 
                  ADDQ.L    #1,A4 
                  MOVE.B    (A1),D0 
                  ADDQ.B    #8,D0 
                  CMP.B     (A4)+,D0
                  BCS.S     L001C 
                  SUBQ.W    #1,FADE_OK
                  MOVE.B    (A1),D0 
L001C:            MOVE.B    D0,(A1)+
                  RTS 
FADE_DOWN:        LEA       L0047(PC),A1
                  BSR       L001E 
                  LEA       L0048(PC),A1
                  BSR       L001E 
                  LEA       L0049(PC),A1
                  BSR       L001E 
                  RTS 
L001E:            MOVE.B    (A1),D0 
                  SUBQ.B    #8,D0 
                  BCC.S     L001F 
                  SUBQ.W    #1,FADE_OK
                  MOVE.B    (A1),D0 
L001F:            MOVE.B    D0,(A1)+
                  MOVE.B    (A1),D0 
                  SUBQ.B    #8,D0 
                  BCC.S     L0020 
                  SUBQ.W    #1,FADE_OK
                  MOVE.B    (A1),D0 
L0020:            MOVE.B    D0,(A1)+
                  ADDQ.L    #1,A1 
                  MOVE.B    (A1),D0 
                  SUBQ.B    #8,D0 
                  BCC.S     L0021 
                  SUBQ.W    #1,FADE_OK
                  MOVE.B    (A1),D0 
L0021:            MOVE.B    D0,(A1)+
                  RTS 
INIT_PAL_FONTE:   LEA       PAL(PC),A0
                  CLR.L     128(A0) 
                  CLR.L     256(A0) 
                  CLR.L     384(A0) 
                  RTS 
AFFICHE_GRAPH:    LEA       IMG(PC),A0
                  MOVEA.L   ECRAN,A1
                  MOVEA.L   L0052,A2
                  LEA       32(A1),A1 
                  LEA       32(A2),A2 
                  LEA       14976(A1),A1
                  LEA       14976(A2),A2
                  MOVE.W    #$C7,D1 
L0024:            MOVE.W    #$13,D0 
L0025:            MOVE.L    (A0),(A1)+
                  MOVE.L    (A0)+,(A2)+ 
                  MOVE.L    (A0),(A1)+
                  MOVE.L    (A0)+,(A2)+ 
                  MOVE.W    (A0),(A1)+
                  MOVE.W    (A0)+,(A2)+ 
                  ADDQ.W    #6,A1 
                  ADDQ.W    #6,A2 
                  DBF       D0,L0025
                  LEA       64(A1),A1 
                  LEA       64(A2),A2 
                  DBF       D1,L0024
                  RTS 
INIT_ECRAN:       LEA       ECRAN,A1
                  LEA       $300000,A0
                  MOVE.L    A0,D0 
                  ADDQ.W    #4,D0 
                  ANDI.B    #-4,D0
                  MOVE.L    D0,(A1)+
                  MOVEA.L   D0,A2 
                  ADDI.L    #$16800,D0
                  MOVE.L    D0,(A1)+
                  MOVEA.L   D0,A3 
                  MOVE.W    #$59FF,D7 
CLS_SCREEN:       CLR.L     (A2)+ 
                  CLR.L     (A3)+ 
                  DBF       D7,CLS_SCREEN 
                  RTS 
CALC_PAL_FONTE:   LEA       PALETTE_FONTE(PC),A0
                  LEA       TABLE_STE(PC),A1
                  LEA       L004A(PC),A2
                  MOVE.L    #$555,(A2)
                  MOVE.L    #$AAA0FFF,4(A2) 
                  MOVE.W    #3,D7 
L0029:            MOVEQ     #0,D0 
                  MOVEQ     #0,D3 
                  MOVE.W    (A2)+,D0
                  MOVE.L    D0,D1 
                  MOVE.L    D1,D2 
                  ANDI.W    #$F,D0
                  MOVE.B    0(A1,D0.W),D3 
                  LSL.W     #8,D3 
                  SWAP      D3
                  LSR.W     #4,D1 
                  ANDI.W    #$F,D1
                  MOVE.B    0(A1,D1.W),D1 
                  SWAP      D1
                  ADD.L     D1,D3 
                  LSR.W     #8,D2 
                  ANDI.W    #$F,D2
                  ADD.B     0(A1,D2.W),D3 
                  MOVE.L    D3,(A0)+
                  DBF       D7,L0029
                  RTS 
SEARCH_CHAR:      LEA       PBUFFER,A1
                  MOVEA.L   P_TEXT(PC),A0 
L002B:            MOVE.B    (A0)+,D0
                  BMI.S     L0031 
                  BEQ.S     L0030 
                  MOVEQ     #-1,D2
                  LEA       LIST_CHAR(PC),A2
L002C:            MOVE.B    (A2)+,D1
                  BMI.S     L002F 
                  ADDQ.W    #1,D2 
                  CMP.B     D1,D0 
                  BNE.S     L002C 
                  LEA       L004B(PC),A2
                  MOVE.W    D2,D3 
                  SUBI.W    #$14,D2 
                  BMI.S     L002D 
                  LEA       1280(A2),A2 
                  BRA.S     L002E 
L002D:            MOVE.W    D3,D2 
L002E:            LSL.W     #2,D2 
                  ADDA.W    D2,A2 
                  MOVE.L    A2,(A1)+
                  BRA.S     L002B 
L002F:            MOVE.L    #1,(A1)+
                  BRA.S     L002B 
L0030:            MOVE.L    A0,P_TEXT 
                  CLR.L     (A1)
                  RTS 
L0031:            MOVE.L    O_TEXT(PC),P_TEXT 
                  MOVE.L    #-1,(A1)
                  RTS 
AFF_BOUT2:        LEA       PBUFFER,A0
L0033:            MOVE.L    (A0)+,D0
                  BLE.S     L0036 
                  CMP.L     #1,D0 
                  BNE.S     L0034 
                  LEA       16(A1),A1 
                  BRA.S     L0033 
L0034:            MOVEA.L   D0,A2 
                  MOVEQ     #$F,D0
L0035:            MOVE.L    (A2),10(A1) 
                  LEA       80(A2),A2 
                  LEA       384(A1),A1
                  DBF       D0,L0035
                  LEA       -6128(A1),A1
                  BRA.S     L0033 
L0036:            RTS 
INIT_PAL2:        LEA       L0047(PC),A0
                  MOVE.W    #$7F,D0 
L0038:            CLR.L     (A0)+ 
                  DBF       D0,L0038
                  RTS 
RELOC:            MOVE.L    2(A0),D0
                  ADD.L     6(A0),D0
                  ADD.L     14(A0),D0 
                  LEA       28(A0),A0 
                  MOVEA.L   A0,A1 
                  MOVEA.L   A0,A2 
                  MOVE.L    A0,D1 
                  ADDA.L    D0,A1 
                  MOVE.L    (A1)+,D0
                  ADDA.L    D0,A2 
                  ADD.L     D1,(A2) 
                  MOVEQ     #0,D0 
L003A:            MOVE.B    (A1),D0 
                  CLR.B     (A1)+ 
                  TST.B     D0
                  BEQ.S     L003C 
                  CMP.B     #1,D0 
                  BEQ.S     L003B 
                  ADDA.L    D0,A2 
                  ADD.L     D1,(A2) 
                  BRA.S     L003A 
L003B:            LEA       254(A2),A2
                  BRA.S     L003A 
L003C:            RTS 
 DATA 
PALETTE_FONTE:    DCB.W     2,0 
L003E:            DCB.W     6,0 
TABLE_STE:        DC.B      $00,$80,$10,$90,' ',$A0,'0',$B0 
                  DC.B      '@',$C0,'P',$D0,'`',$E0,'p',$F0 
O_TEXT:           DCB.W     2,0 
P_TEXT:           DCB.W     2,0 
TEXT:             DC.B      'PROGRAMM'
                  DC.B      'ING',$00,'   N'
                  DC.B      'EW FACE',$00 
                  DC.B      '   ELEND'
                  DC.B      'IL',$00,$FF
TEXT2:            DC.B      'GRAPHICS'
                  DC.B      ' BY',$00,'    '
                  DC.B      '   FLAN',$00 
                  DC.B      $FF,$00 
TEXT3:            DC.B      'MUSIC BY'
                  DC.B      $00,'    ZIG' 
                  DC.B      'O',$00,$FF,$00 
LIST_CHAR:        DC.B      'ABCDEFGH'
                  DC.B      'IJKLMNOP'
                  DC.B      'QRSTUVWX'
                  DC.B      'YZ!?,.12'
                  DC.B      '34567890'
                  DC.B      $FF,$00 
PAL:              DC.B      $10,$10,$00,$10,$80,$90,$00,$90 
                  DC.B      '``',$00,'ppp',$00,$80
                  DC.B      $80,'P',$00,'@',$90,'`',$00,'P' 
                  DC.B      $D0,$A0,$00,$80,$F0,$C0,$00,$A0 
                  DC.B      $D0,$90,$00,'p',$90,$A0,$00,$A0 
                  DC.B      $C0,$E0,$00,$E0,'PP',$00,'`'
                  DC.B      $B0,$C0,$00,$D0,$D0,$F0,$00,$F0 
                  DC.B      $F0,$F0,$00,$F0,$C0,$80,$00,'p' 
                  DC.B      $A0,'`',$00,'P',$A0,$B0,$00,$C0 
                  DC.B      '@@',$00,'`',$90,'P',$00,'@'
                  DC.B      $B0,'p',$00,'`',$F0,$B0,$00,$90 
                  DC.B      $E0,$A0,$00,$80,$E0,$F0,$00,$D0 
                  DC.B      $E0,$80,$00,$80,$C0,'`',$00,'P' 
                  DC.B      $D0,'p',$00,'p',$B0,$E0,$00,$A0 
                  DC.B      $C0,$F0,$00,$C0,$F0,$90,$00,$00 
                  DC.B      $F0,$B0,$00,$00,$F0,$D0,$00,'`' 
L0047:            DCB.W     64,0
L0048:            DCB.W     64,0
L0049:            DCB.W     321,0 
L004A:            DC.B      $00,$00,$05,$C5,$03,$A3,$07,$E7 
                  DC.B      $04,$B4,$04,$B4,$04,$B4,$04,$B4 
                  DC.B      $06,$BE,$06,$BE,$06,$BE,$06,$BE 
                  DC.B      $0F,$BF,$0F,$BF,$0F,$BF,$0F,$BF 
L004B:
	            DCB.W     18,0
                  DC.B      $00,$F8,$01,'t',$00,$00,$00,$00 
                  DCB.W     16,0
                  DC.B      $00,$04,$00,$0A,$0F,$00,$16,$C0 
                  DCB.W     4,0 
                  DC.B      $00,'p',$00,$B0,$00,$00,$00,$00 
                  DC.B      $00,$FC,$01,$1A,$0F,$F0,$17,$E8 
                  DC.B      $00,$08,$00,$10,$1F,$00,'.',$80 
                  DC.B      $01,$FC,$00,$F8,$1C,$00,'*',$00 
                  DCB.W     6,0 
                  DC.B      $00,'88T',$01,$F0,$06,$E8 
                  DC.B      $00,$1C,$00,'h',$01,$F8,$02,$F4 
                  DC.B      $00,$F8,$01,'t',$00,$1E,$00,',' 
                  DC.B      $1F,$E0,'/',$D0,$07,$C0,$0B,$A0 
                  DC.B      $1F,$80,'/@',$01,$F0,$02,$F0
                  DC.B      $7F,$00,$BC,$80,$03,$FE,$05,$FC 
                  DC.B      '?',$F8,$1F,$FC,$10,$18,'(('
                  DC.B      '?',$80,$1F,$00,$01,$FC,$00,$F8 
                  DC.B      $0F,$00,$16,$80,$1E,$00,'#',$00 
                  DC.B      $1C,'8*T',$01,$F8,$02,$F0 
                  DC.B      '8',$FC,'Uz',$0F,$F8,$17,$F4
                  DC.B      $00,$FE,$01,'|',$07,$FC,$0B,$FA 
                  DC.B      $07,$9E,$0B,'L',$01,$FE,$02,$FE 
                  DC.B      '9',$F0,$16,$E0,$1F,$E0,'/',$D0 
                  DC.B      '?',$E0,'_',$C0,$03,$F0,$01,$F0 
                  DC.B      $FF,$C0,$7F,$A0,$1F,$FE,'/',$FC 
                  DC.B      '><}^x8',$B0,'\'
                  DC.B      '?',$80,$1F,$00,$00,$F8,$01,'t' 
                  DC.B      $0C,$00,$1A,$00,'>',$00,'_',$00 
                  DC.B      '>',$FC,']x',$07,$F8,$0B,$FC
                  DC.B      '}',$E6,':',$DC,$18,'<,Z' 
                  DC.B      $03,$E2,$05,$D6,$0E,$1E,$15,',' 
                  DC.B      $0E,'n',$17,$06,$0F,$C0,$17,$A0 
                  DC.B      ' p(',$B0,'0',$F0,'I`'
                  DC.B      '`',$F0,'1h',$00,$F0,$01,'p'
                  DC.B      $FF,$F0,$E7,$E8,$F8,'<t',$CE
                  DC.B      '|',$1E,'8<',$F8,'|x',$B8 
                  DC.B      $1F,$00,'.',$80,$00,$00,$00,'0' 
                  DC.B      $18,$00,$0C,$00,'>',$00,'|',$00 
                  DC.B      'g',$9C,$CB,'.O',$9C,$17,'l'
                  DC.B      'w',$C6,$EB,$AE,$B0,$1C,'X>'
                  DC.B      $0F,$82,$07,'BX',$0E,$AC,$1E
                  DC.B      $1E,'F',$0C,'f~',$00,'}',$00
                  DC.B      '(0',$1C,'x`p0',$E0 
                  DC.B      '@<`X',$00,'p',$00,$F0
                  DC.B      $E1,$F8,$D2,$F0,$E0,$04,$E0,$18 
                  DC.B      'x>',$F0,$1E,'x',$1C,$B8,'>'
                  DCB.W     2,0 
                  DC.B      $00,'<',$00,'Z',$18,$00,$18,$00 
                  DC.B      '<',$00,'z',$00,$C3,$0C,'G',$1E 
                  DC.B      '^',$04,$ED,$0E,$E3,$86,'WF'
                  DC.B      $E0,$1C,$B0,'>',$1F,$02,$0E,$06 
                  DC.B      $F0,$0E,'x',$1C,$1C,'|',$1E,'>' 
                  DC.B      'q',$00,'x',$80,$18,'8(',$10
                  DC.B      '``0p@',$1C,'@.'
                  DC.B      $00,'p',$00,'p',$C0,'8',$E0,'X' 
                  DC.B      $E0,$00,'`',$00,$F0,'>`~' 
                  DC.B      '8',$1E,'X<',$03,$80,$05,$C0
                  DC.B      $00,'~',$00,$FE,$18,$00,'0',$F8 
                  DC.B      '8',$00,'|',$00,$C3,$0E,'C',$0C 
                  DC.B      '|',$06,$FA,$0C,$C2,$06,$E1,$0E 
                  DC.B      $C0,'<`Z',$1E,$06,'<',$02 
                  DC.B      '`',$1C,'0.',$1E,$00,$0D,'8'
                  DC.B      'q',$80,'-',$00,$00,$18,$00,'8' 
                  DC.B      $10,'`8P@',$0E,'@',$1E
                  DC.B      $0F,$F0,$17,$F8,$E0,$18,'P0'
                  DC.B      'g',$00,$EA,$00,$E2,$1C,$F1,'"' 
                  DC.B      $18,'>8',$1C,$0F,$80,$07,'@'
                  DC.B      $00,$BC,$00,'^',$11,$F8,':',$F4 
                  DC.B      '8',$00,'0',$00,$C3,$0E,$C3,$0C 
                  DC.B      'x',$06,$BC,$04,$C0,$0E,$E2,$14 
                  DC.B      '`x',$C0,$B4,'<',$0E,$18,$04
                  DC.B      ' <pX',$0F,$C0,$17,$B0
                  DC.B      '9',$80,'U',$80,'?',$98,'^\'
                  DC.B      $19,$F8,$0E,$F4,'@',$0E,'`',$0C 
                  DC.B      '<pZ',$B8,'pp',$E0,$BC
                  DC.B      '~',$00,'=',$00,$E3,$80,$E7,'@' 
                  DC.B      $18,'>8|',$07,$00,$0F,$80 
                  DC.B      $1C,$1E,'*',$AC,'?',$FC,$17,$FA 
                  DC.B      '0',$00,'8',$00,$C3,$0E,$E7,$0C 
                  DC.B      '0',$06,'x',$0C,$E0,$1C,$C0,'.' 
                  DC.B      '`',$F0,'1h8',$1C,'pŽ'
                  DC.B      '0x',$00,$B4,$00,$F8,$03,'t'
                  DC.B      $01,$80,$00,$C0,$F8,'|u',$88
                  DC.B      $0F,$FC,$1F,$FA,'`',$08,'@',$04 
                  DC.B      'x8',$B4,$10,'0',$E6,'yP' 
                  DC.B      '0',$00,'p',$00,$E7,$E0,$C3,$D0 
                  DC.B      $19,$EE,$1A,$D6,$07,$80,$03,$00 
                  DC.B      'v',$0E,'=',$16,'<<z',$1E 
                  DC.B      '0',$00,'p',$02,$C7,$0E,$E3,$0C 
                  DC.B      '0',$0E,$18,$04,$E0,$1C,'px'
                  DC.B      '?',$C0,$7F,$A0,'p',$BC,$A0,$18 
                  DC.B      $1F,$E0,'?',$D0,'p<8',$1A 
                  DC.B      $01,$C0,$00,$80,$F0,$0C,$E8,$1E 
                  DC.B      $0C,'>',$0A,'\p',$00,' ',$00
                  DC.B      $F0,$18,'x8',$1B,$0E,'<',$96
                  DC.B      '0',$00,'p',$00,$C7,$F0,$E7,$E0 
                  DC.B      $1F,$06,';',$8E,$03,$C0,$07,$80 
                  DC.B      'g',$06,'r',$0E,'8',$1C,'p>'
                  DC.B      's',$E6,'4',$18,$E3,$0E,$C5,$0C 
                  DC.B      $18,$0C,'0',$1E,$F0,'x`',$BC
                  DC.B      '0',$00,$10,$00,'`',$B8,$F0,$F4 
                  DC.B      $18,$C0,$19,'bX',$1E,$E8,'<'
                  DC.B      $00,$C0,$01,$E0,$E0,$0E,$F0,$0C 
                  DC.B      $08,$1E,$08,'>8',$00,'T',$00
                  DC.B      $F0,$18,$F0,$1C,$0C,$1E,$1E,$0E 
                  DC.B      '0',$00,$18,$00,$C0,'p`',$B8
                  DC.B      '<',$06,'Z',$06,$03,$E0,$01,$C0 
                  DC.B      'g',$06,'7',$0E,'p',$1C,'(:'
                  DC.B      $7F,$FE,$FF,$FE,$E1,$0C,$C2,$1E 
                  DC.B      $1C,$1C,$08,$0E,'p',$F8,$F9,'p' 
                  DC.B      '0',$00,$18,$00,'`p',$C0,$E8
                  DC.B      $18,'b',$0C,$97,'`>',$C8,'^'
                  DC.B      $00,$E0,$01,$C0,$E0,$1E,$F0,'&' 
                  DC.B      '(>',$08,$1E,$1E,$0C,'-',$14
                  DC.B      $F0,$1C,$F8,':',$17,$06,'.',$8E 
                  DC.B      $18,$00,'0',$00,'`0',$D0,'x'
                  DC.B      'X',$06,'8',$0E,$01,$F0,$03,$E8 
                  DC.B      '0',$0E,'o',$1C,'`p',$F0,$B8
                  DC.B      $FF,$FE,$FF,$FE,$E0,$1C,$F1,'.' 
                  DC.B      $0E,$1C,$1C,$1E,'y',$F0,$B0,$E8 
                  DC.B      $18,$00,'0',$00,'A',$E0,$E2,$D0 
                  DC.B      $0C,'7',$18,'k8',$FE,'u|' 
                  DC.B      $00,$E0,$00,$F0,$F0,$F6,'in'
                  DC.B      '(~x',$BC,$0F,$FC,$17,$F8 
                  DC.B      $F8,'~p',$BC,'#',$CE,$05,$A4
                  DC.B      $18,$00,'<',$00,$7F,$F0,'?',$E0 
                  DC.B      '8',$0E,$90,$04,$01,$FC,$00,$F8 
                  DC.B      '8x',$15,$B0,$E0,$F8,'qt' 
                  DC.B      $E0,$0E,'P',$16,$F0,'<`N' 
                  DC.B      $0F,$0C,$06,$1C,'9',$E0,'[',$D0 
                  DC.B      '8',$00,$1C,$00,'G',$B8,$CB,'p' 
                  DC.B      $0C,'>',$1C,$1D,$0F,$FC,$1F,$FA 
                  DC.B      $00,$F0,$00,$E0,'?',$86,'_F'
                  DC.B      '?',$FC,$7F,$FA,$03,$F8,$05,$F4 
                  DC.B      $7F,$EE,$BF,$D6,$00,$FC,$11,'z' 
                  DC.B      $1C,$00,$08,$00,$1F,$C0,'/',$A0 
                  DC.B      '0',$1C,'8',$1E,$00,$F8,$01,$F4 
                  DC.B      $1F,$E0,'/',$C0,$F0,$1E,$E8,'.' 
                  DC.B      '@',$02,$80,$00,$F0,$1C,'x('
                  DC.B      $06,$04,$0F,$0C,$1B,$C0,'-',$A0 
                  DC.B      '8',$00,'t',$00,'~',$18,'=8'
                  DC.B      $1C,$1C,'(:',$03,$F0,$05,$E8
                  DC.B      $00,$F0,$00,$90,$00,$00,$00,$00 
                  DCB.W     14,0
                  DC.B      $01,$E0,$00,'P',$00,$00,$00,$00 
                  DCB.W     6,0 
                  DC.B      $04,$00,$06,$04,$0F,$00,$16,$80 
                  DCB.W     17,0
                  DC.B      $00,$08,$08,$00,$10,$00,$00,$00 
                  DCB.W     29,0
                  DC.B      $1C,$00,'*',$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $10,$08,'8',$1C,$1C,$00,'(',$00 
                  DC.B      $03,$FE,$04,$FE,$01,$E0,$00,'P' 
                  DC.B      $07,$E0,$0B,$D0,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $00,$F8,$01,'x',$01,$F8,$06,$F4 
                  DC.B      $00,$F8,$01,'t',$00,$C0,$01,$E0 
                  DC.B      $01,$F0,$02,$E8,$00,$F8,$01,'|' 
                  DC.B      $0F,$00,$1E,$80,$03,$F0,$05,$F8 
                  DC.B      $03,$F8,$05,$F4,$01,$F0,'"',$E8 
                  DC.B      $07,$06,$06,$0A,$18,$00,'(',$00 
                  DC.B      $00,$1C,'`',$0E,'8',$1C,'T:'
                  DC.B      '>',$00,'^',$08,$0F,$FE,$17,$DE 
                  DC.B      $00,$F8,$01,$F4,$1F,$F8,'/',$F4 
                  DCB.W     4,0 
                  DC.B      $01,$F8,$02,$F0,$07,$FC,$0B,$FA 
                  DC.B      $03,$FC,$05,$CE,$01,$E0,$00,$80 
                  DC.B      $03,'|',$01,$B8,$03,$84,$05,$CE 
                  DC.B      $1F,$E0,$0F,$D8,$06,$1C,$0A,'.' 
                  DC.B      $06,'|',$09,':',$27,$FC,'{',$FE 
                  DC.B      $06,$0E,$0D,$16,'x',$00,'x',$00 
                  DC.B      'cŽ1',$9C,'|<z^'
                  DC.B      'z',$0C,'<',$18,'8',$1E,$1C,'<' 
                  DC.B      $01,$FC,$00,$F8,'?',$FC,'_',$FA 
                  DCB.W     4,0 
                  DC.B      $07,$F0,$03,$F8,$07,$BE,$0F,'\' 
                  DC.B      $07,$CE,$0F,$B4,$01,$80,$03,$E0 
                  DC.B      $02,$1C,$07,'.',$07,$02,$0A,$06 
                  DC.B      $1F,$FE,'=',$FE,$0E,$06,$04,$0A 
                  DC.B      $0C,$1E,$06,',',$1F,'Ž7T' 
                  DC.B      $0C,$0E,$16,$0E,'x',$00,'8',$00 
                  DC.B      'q',$8E,$FB,$86,'>',$F8,']4'
                  DC.B      'x<r^',$1A,'8*',$1C 
                  DC.B      $01,$F0,$03,$E8,$7F,$1E,'<',$AC 
                  DCB.W     4,0 
                  DC.B      $0F,$F0,$16,$E0,$07,$1E,$0B,$BE 
                  DC.B      $07,$86,$0B,'J',$03,$80,$01,$00 
                  DC.B      $04,$0C,$0E,$1A,$0E,$0E,$17,$0A 
                  DC.B      '=',$EE,$1A,$D6,$0E,$02,$05,$06 
                  DC.B      $0C,$0E,$18,$1E,$1F,$06,$0E,$8E 
                  DC.B      $1C,$0E,'(',$06,'8',$02,'|',$00 
                  DC.B      $F1,'Žh',$86,$1F,$F0,'/',$E8
                  DC.B      'p',$1E,'`<',$0E,'0',$16,'x'
                  DC.B      $03,$E0,$01,$C0,'|',$0E,'z',$1E 
                  DCB.W     4,0 
                  DC.B      '<',$E0,$1A,$F0,$03,$1E,$05,$1E 
                  DC.B      $03,$06,$05,$82,$07,$00,$02,$80 
                  DC.B      $0C,$08,$16,$04,$1F,$CC,$0F,$AE 
                  DC.B      '8',$1E,'<,',$07,$02,$0E,$86
                  DC.B      $08,$0E,$1C,$0E,$1E,$06,'=',$06 
                  DC.B      '8',$0E,$1C,$06,'<',$06,$18,$02 
                  DC.B      $E1,'Ž@',$86,$0F,$E0,$17,$F0
                  DC.B      '`',$1E,'0',$1C,$00,'`',$00,$F0 
                  DC.B      $03,$C0,$07,$80,'x',$0E,'t',$1E 
                  DCB.W     4,0 
                  DC.B      'x',$E0,'0',$E0,$00,$1E,$03,'<' 
                  DC.B      $00,$06,$03,$0E,$0E,$00,$17,$10 
                  DC.B      $0F,$C0,$1F,$A0,$1C,$E0,';p'
                  DC.B      $18,'x(',$B4,$07,$CE,$07,$B4
                  DC.B      $08,$0E,$18,$0E,'>',$06,$18,$06 
                  DC.B      '8',$06,'8',$0E,$1C,$0C,'<',$06 
                  DC.B      $C1,$8E,$E0,$86,$0F,$E0,$17,$F0 
                  DC.B      '0<`',$1E,$00,$C0,$01,$80 
                  DC.B      $07,$80,$03,$00,'|',$0E,'r',$1C 
                  DCB.W     4,0 
                  DC.B      '0',$E0,'A',$C0,$00,'<',$00,$1A 
                  DC.B      $00,'>',$00,$1C,'>',$10,$1D,'0' 
                  DC.B      $00,$F0,$01,'h80',$14,'X' 
                  DC.B      $01,$E0,$02,$D0,$0F,$F8,$13,$E4 
                  DC.B      $08,$0E,$1C,$1E,':',$06,'u',$0E 
                  DC.B      '8',$06,'8',$0E,$1C,$18,$0E,$0C 
                  DC.B      $C1,$8E,$C0,$86,$1F,$F0,'/',$E8 
                  DC.B      '8|',$10,'8',$03,$00,$05,$80
                  DC.B      $07,$00,$0F,$80,'`<',$10,'Z'
                  DCB.W     4,0 
                  DC.B      $01,$C0,$00,$E0,$00,$F8,$01,'t' 
                  DC.B      $00,$1C,$00,'(',$7F,$B0,'?`'
                  DC.B      $00,'8',$00,'t0',$18,$18,'0'
                  DC.B      $03,$C0,$05,$80,$19,$F0,'6',$E8 
                  DC.B      $0C,$1E,$1A,'.qŽ)',$04
                  DC.B      '8',$0E,'8',$06,$0E,'8',$1C,$10 
                  DC.B      $C1,$8E,$C0,$86,'?',$F8,'_',$F4 
                  DC.B      $1F,$E0,'?',$D0,$06,$00,$0C,$1C 
                  DC.B      $0F,$80,$07,'@',$00,'p',$00,$A8 
                  DC.B      $00,$00,$00,$E0,$00,$00,$00,$00 
                  DC.B      $01,$C0,$00,$C0,$03,$E0,$05,$D0 
                  DC.B      $00,$0C,$00,$1A,$03,$F0,$0D,$E0 
                  DC.B      $00,'8',$00,$1C,'0',$18,'x',$10 
                  DC.B      $07,$80,$0B,$00,' xp',$B4 
                  DC.B      $07,'>',$0E,$DC,'`',$DC,'pŽ'
                  DC.B      '8',$0E,'<',$0E,$0E,'0',$07,'x' 
                  DC.B      $C1,$8E,$C0,$86,'~',$FC,$BD,'z' 
                  DC.B      $1F,$00,$1E,$80,$08,$1C,$1C,'*' 
                  DC.B      $03,$80,$05,$C0,$00,$C0,$00,' ' 
                  DC.B      $01,$F0,$00,$E0,$00,$00,$00,$00 
                  DC.B      $01,$C0,$03,$80,$0F,$80,$17,'@' 
                  DC.B      $18,$0C,',',$1E,$00,'x',$00,$F4 
                  DC.B      $18,$18,'0<0',$18,'x',$10 
                  DC.B      $0F,$00,$16,$00,'@<`z'
                  DC.B      $03,$FC,$01,$FA,'`|@x'
                  DC.B      '<',$0E,$18,$0E,$07,'p',$0E,$A0 
                  DC.B      $C1,$8E,$C3,$9C,$FC,'~',$FA,$BC 
                  DC.B      '<',$00,$1E,$00,$18,'&0',$0E
                  DCB.W     4,0 
                  DC.B      $01,$F0,$03,$F8,$00,$00,$00,$00 
                  DC.B      $03,$80,$01,$C0,$1C,$00,'+',$00 
                  DC.B      '<',$1C,$1A,'.',$00,$C0,$00,'@' 
                  DC.B      '8',$18,'<<8',$18,'t0'
                  DC.B      $1E,$00,$0F,$00,'@<@>'
                  DC.B      $00,'8',$00,'T@8`t' 
                  DC.B      $1C,$0E,'.',$1E,$07,$E0,$03,$F0 
                  DC.B      $C3,$9E,'e',$AC,'x8',$B4,'t'
                  DC.B      '<',$00,'x',$00,'p',$0E,'8',$1E 
                  DC.B      $1F,$00,'.',$80,$0F,$00,$16,$80 
                  DC.B      $01,$F0,$00,$F8,$1E,$00,'!',$00 
                  DC.B      $03,$80,$07,$80,'0',$F8,$19,'t' 
                  DC.B      '?<>',$DE,$00,$C0,$01,$C0 
                  DC.B      '<8:T<0zX'
                  DC.B      $1E,$00,'=',$00,'@<`~'
                  DC.B      $00,'p',$00,$A8,'`',$F0,'1`'
                  DC.B      $0E,$1E,$15,'.',$03,$E0,$07,$C0 
                  DC.B      $7F,$FC,$FE,$FE,'0',$10,'h8'
                  DC.B      'x',$00,$B4,$00,'?',$F8,$7F,$F4 
                  DC.B      '?',$80,$1F,$00,$1F,$80,$0F,$00 
                  DC.B      $00,$F0,$01,'`?',$00,$1E,$00
                  DC.B      $07,$80,$03,'@#',$FC,'u',$FA
                  DC.B      '?',$FC,$1F,$FA,$01,$C0,$02,$E0 
                  DC.B      '?',$F0,$1F,$F8,'?',$E0,$1F,$F0 
                  DC.B      '>',$00,$1D,$00,'`|0',$BA 
                  DC.B      $03,$E0,$05,$D0,'3',$E8,'}',$D0 
                  DC.B      $07,$FE,$0B,$F6,$03,$C0,$01,$A0 
                  DC.B      '8|t',$B8,$00,$00,'0',$10 
                  DC.B      $08,$00,'4',$00,$1F,$C0,'/',$A0 
                  DC.B      '?',$80,$1F,$00,$1F,$80,$0F,$00 
                  DC.B      $00,$E0,$00,'p?',$00,$1E,$00
                  DC.B      $0F,$C0,$17,$A0,$7F,$FE,'?',$8C 
                  DC.B      $0F,$F8,$17,$F4,$03,$E0,$05,$D0 
                  DC.B      $1F,$E0,'/',$D0,$1F,$C0,'/',$A0 
                  DC.B      '?',$00,'>',$80,'?',$F8,$1F,$F4 
                  DC.B      $1F,$80,'/@',$1F,$84,'/D' 
                  DCB.W     12,0
                  DC.B      $1F,$00,'.',$80,$0F,$00,$16,$80 
                  DC.B      $00,$E0,$01,$C0,$1E,$00,'!',$00 
                  DCB.W     43,0
IMG:              DCB.W     5,0 
                  DC.B      $00,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $00,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $00,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $00,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $00,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $00,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $00,$80,$01,$C0,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $01,$C0,$03,$E0,$00,$00,$00,$00 
                  DCB.W     96,0
                  DC.B      $03,$E5,$03,$E3,$00,$1F,$00,$00 
                  DC.B      $00,$00,'@',$00,$00,$00,'`',$00 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $03,$E0,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$A0,$00,$80,$00,'`',$00 
                  DCB.W     92,0
                  DC.B      $01,'@',$02,$A0,$00,$00,$01,$C0 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $00,$80,$01,$C0,$00,$00,$00,$00 
                  DC.B      $00,$00,$80,$00,$80,$00,$00,$00 
                  DCB.W     92,0
                  DC.B      $00,$80,$00,$80,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $01,$C0,$01,$C0,$00,$00,$01,'@' 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     92,0
                  DC.B      $03,$E0,$03,$E0,$00,$00,$02,' ' 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $07,$F0,$07,$F0,$00,$00,$04,$10 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     92,0
                  DC.B      $07,$F0,$05,$F0,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $07,$F0,$00,$00,$00,$00,$02,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $05,$F0,$00,$00,$02,$00,$07,$F0 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $04,'p',$03,$80,$07,$F0,$07,$F0 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $07,$00,$07,$00,$07,$00,$05,$00 
                  DC.B      $00,$F0,$00,$00,$80,$00,$00,$00 
                  DCB.W     92,0
                  DC.B      $07,$F0,$07,$F0,$07,$F0,$07,$F0 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $0F,$08,$0F,$08,$07,$00,$0D,$08 
                  DC.B      $00,$F0,$00,$00,$80,$00,$00,$00 
                  DCB.W     92,0
                  DC.B      $11,$C4,$16,'4',$09,$C8,$1F,$FC 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $07,$F0,$08,$08,$17,$F4,$1F,$FC 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $0F,$F8,$10,$04,$0F,$F8,$1F,$FC 
                  DCB.W     3,0 
                  DC.B      $80,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     89,0
                  DC.B      $1F,$FC,$00,$00,$1F,$FC,$1F,$FC 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      '?',$FE,' ',$02,$1F,$FC,'?',$FE 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$80,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $1F,$FC,' ',$02,$1F,$FC,$1F,$FC 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      '?',$FE,' ',$02,$1F,$FC,$1F,$FC 
                  DC.B      $00,$00,$80,$00,$00,$00,$80,$00 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $1F,$FC,'@',$01,'?',$FE,'?',$FE 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      '?',$FE,$80,$00,$7F,$FF,$7F,$FF 
                  DCB.W     2,0 
                  DC.B      $80,$00,$80,$00,$80,$00,$00,$00 
                  DCB.W     86,0
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$00 
                  DC.B      $7F,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      '@',$00,$80,$00,$80,$00,$00,$00 
                  DCB.W     85,0
                  DC.B      $00,$02,$00,$02,$00,$01,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$A0,$00,' ',$00 
                  DC.B      $C0,$00,$E0,$00,$00,$00,$00,$00 
                  DCB.W     85,0
                  DC.B      $00,$07,$00,$00,$00,$01,$00,$04 
                  DC.B      $C0,$07,'?',$F8,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$80,$00,'p',$00,$80,$00 
                  DC.B      $C0,$00,$10,$00,$00,$00,$00,$00 
                  DCB.W     83,0
                  DC.B      $00,$07,$00,$04,$00,$01,$00,$05 
                  DC.B      $00,$00,$80,$00,$7F,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$F0,$00,$10,$00 
                  DC.B      $C0,$00,$D0,$00,$00,$00,$00,$00 
                  DCB.W     85,0
                  DC.B      $00,$05,$00,$03,$00,$03,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,'@',$00,$90,$00,$E0,$00 
                  DC.B      $E0,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     84,0
                  DC.B      $00,$07,$00,$01,$00,$03,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $F0,$00,$C0,$00,$E0,$00,$00,$00 
                  DCB.W     86,0
                  DC.B      $00,$07,$00,$01,$00,$03,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $F0,$00,$C0,$00,$E0,$00,$00,$00 
                  DCB.W     86,0
                  DC.B      $00,$07,$00,$01,$00,$03,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $F0,$00,$C0,$00,$E0,$00,$00,$00 
                  DCB.W     86,0
                  DC.B      $00,$07,$00,$01,$00,$03,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $F0,$00,$C0,$00,$E0,$00,$00,$00 
                  DCB.W     85,0
                  DC.B      $00,$05,$00,$04,$00,$03,$00,$07 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      'P',$00,$90,$00,$E0,$00,$F0,$00 
                  DCB.W     86,0
                  DC.B      $00,$02,$00,$05,$00,$00,$00,$01 
                  DC.B      $00,$04,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,' ',$00,$D0,$00 
                  DC.B      $80,$00,$C0,$00,$10,$00,$00,$00 
                  DCB.W     84,0
                  DC.B      $00,$02,$00,$02,$00,$01,$00,$03 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      ' ',$00,$A0,$00,$C0,$00,$E0,$00 
                  DCB.W     87,0
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$7F,$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      '@',$00,$80,$00,$80,$00,$00,$00 
                  DCB.W     91,0
                  DC.B      $BF,$FE,$7F,$FF,$7F,$FF,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     92,0
                  DC.B      '_',$FD,'?',$FE,'?',$FE,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$80,$00 
                  DCB.W     92,0
                  DC.B      '/',$FA,$17,$F4,$1F,$FC,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     91,0
                  DC.B      $1C,$1C,$19,$CC,$02,' ',$13,$E4 
                  DCB.W     3,0 
                  DC.B      $80,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     95,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     95,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     93,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     95,0
                  DC.B      $80,$00,$00,$00,$00,$00,$80,$00 
                  DCB.W     97,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     95,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     97,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     95,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     97,0
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     95,0
                  DC.B      $80,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     92,0
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$01 
                  DC.B      $00,$00,$C0,$00,$00,$00,$00,$00 
                  DC.B      '@',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     87,0
                  DC.B      $00,$01,$00,$01,$00,$00,$00,$01 
                  DC.B      $00,$00,'@',$00,$C0,$00,$00,$00 
                  DC.B      '@',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $00,$01,$00,$00,$00,$00,$80,$00 
                  DC.B      $00,$00,$C0,$00,$00,$00,$00,$00 
                  DCB.W     90,0
                  DC.B      $00,$01,$00,$03,$00,$00,$00,$00 
                  DC.B      $00,$03,'@',$00,'`',$00,$80,$00 
                  DC.B      $00,$00,$E0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$02,$00,$02,$00,$01,$00,$02 
                  DC.B      $00,$01,$E0,$00,' ',$00,$C0,$00 
                  DC.B      ' ',$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     89,0
                  DC.B      $00,$01,$00,$03,$00,$00,$00,$00 
                  DC.B      $00,$00,$80,$00,$A0,$00,$00,$00 
                  DC.B      '@',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     87,0
                  DC.B      $00,$03,$00,$06,$00,$01,$00,$00 
                  DC.B      $00,$07,' ',$00,'0',$00,'@',$00 
                  DC.B      $80,$00,'p',$00,$00,$00,$00,$00 
                  DCB.W     89,0
                  DC.B      $00,$05,$00,$03,$00,$00,$00,$06 
                  DC.B      $A0,$00,$90,$00,$E0,$00,$80,$00 
                  DC.B      'P',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     87,0
                  DC.B      $00,$06,$00,$06,$00,$02,$00,$07 
                  DC.B      $00,$00,$80,$00,$90,$00,$C0,$00 
                  DC.B      $80,$00,'p',$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$05,$00,$05,$00,$01,$00,$07 
                  DC.B      $00,$00,$10,$00,$10,$00,$E0,$00 
                  DC.B      $10,$00,$E0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$06,$00,$06,$00,$03,$00,$06 
                  DC.B      $00,$01,$10,$00,$10,$00,$E0,$00 
                  DC.B      $10,$00,$E0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$04,$00,$04,$00,$03,$00,$04 
                  DC.B      $00,$03,$10,$00,$10,$00,$E0,$00 
                  DC.B      $10,$00,$E0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$04,$00,$04,$00,$01,$00,$04 
                  DC.B      $00,$03,$10,$00,$10,$00,$C0,$00 
                  DC.B      $10,$00,$E0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$04,$00,$04,$00,$00,$00,$04 
                  DC.B      $00,$03,$10,$00,$10,$00,' ',$00 
                  DC.B      $10,$00,$E0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$06,$00,$06,$00,$00,$00,$04 
                  DC.B      $00,$03,'0',$00,'0',$00,' ',$00 
                  DC.B      '0',$00,$C0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$01,$00,$05,$00,$02,$00,$00 
                  DC.B      $00,$05,' ',$00,'0',$00,'`',$00 
                  DC.B      ' ',$00,$D0,$00,$00,$00,$00,$00 
                  DCB.W     88,0
                  DC.B      $00,$02,$00,$02,$00,$01,$00,$02 
                  DC.B      $00,$00,'`',$00,'`',$00,'@',$00 
                  DC.B      '`',$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     89,0
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$01 
                  DC.B      $00,$00,$C0,$00,$00,$00,$00,$00 
                  DC.B      $C0,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     112,0 
                  DC.B      $00,$E0,$02,$08,$00,$E0,$00,$00 
                  DC.B      $03,$F8,$00,$00,$00,$00,$00,$00 
                  DCB.W     77,0
                  DC.B      $00,$01,$00,$07,$00,$00,$00,$01 
                  DC.B      $00,$06,'~',$80,$FF,$C0,$00,$00 
                  DC.B      $00,$80,$00,'@',$00,$00,$00,$00 
                  DCB.W     3,0 
                  DC.B      $01,$10,$04,$04,$01,$10,$00,$E0 
                  DC.B      $07,$1C,$00,$00,$00,$00,$00,$00 
                  DCB.W     77,0
                  DC.B      $00,$04,$00,$19,$00,$02,$00,$03 
                  DC.B      $00,$10,$80,'@',$7F,$F0,$FE,$00 
                  DC.B      $FF,$80,$00,'0',$00,$00,$00,$00 
                  DCB.W     3,0 
                  DC.B      $04,$09,$C7,$F9,'7',$FA,$04,$09 
                  DC.B      $CB,$F4,$00,$00,$80,$00,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     73,0
                  DC.B      $00,$12,$00,'%',$00,$0B,$00,$0F 
                  DC.B      $00,' ',$00,$00,$FF,$C8,$FF,'0' 
                  DC.B      $FF,$C0,$00,$08,$00,$00,$00,$02 
                  DC.B      $00,$01,$00,$00,$00,$02,'_',$FC 
                  DC.B      '`',$02,$7F,$FE,'@',$01,$BF,$FE 
                  DC.B      $A0,$00,$B0,$00,$C0,$00,$A0,$00 
                  DC.B      $10,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $00,'(',$00,'G',$00,$1F,$00,$1F 
                  DC.B      $00,'@',$00,$00,$FF,$F1,$FF,'6' 
                  DC.B      $FF,$C8,$00,'5',$00,$00,$00,$04 
                  DC.B      $00,$00,$00,$01,$00,$06,$7F,$FF 
                  DC.B      $9F,$F8,$FF,$FF,$00,$00,$E0,$07 
                  DC.B      ' ',$00,$A8,$00,$B0,$00,'`',$00 
                  DC.B      $88,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $00,'P',$00,$8F,$00,'?',$00,'?' 
                  DC.B      $00,$80,$00,'8',$FF,$C4,$FF,'=' 
                  DC.B      $FF,$C2,$00,'=',$00,$05,'@',$0C 
                  DC.B      $80,$05,$00,$06,'@',$09,$FF,$FF 
                  DC.B      $7F,$FE,$FF,$FF,$00,$00,$80,$01 
                  DC.B      $D0,$00,'4',$00,$F0,$00,$10,$00 
                  DC.B      $EC,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $00,$A0,$01,$9F,$00,$7F,$00,$7F 
                  DC.B      $01,$00,$01,'~',$FE,$F1,$FF,$7F 
                  DC.B      $FF,$80,$00,$0F,$00,$0B,$10,$19 
                  DC.B      '`',$0B,$80,$0C,'P',$12,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$00 
                  DC.B      $E8,$00,$9A,$00,$F8,$00,$08,$00 
                  DC.B      'v',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $00,$80,$01,$7F,$00,'?',$00,$7F 
                  DC.B      $00,$00,$01,$7F,$FE,$FC,$FF,$7F 
                  DC.B      $FF,$80,$00,$03,$80,$07,'D',$03 
                  DC.B      $D8,$17,' ',$08,$D4,$04,$FF,$FF 
                  DC.B      $FA,$A8,$FF,$FF,$00,$00,$05,'W' 
                  DC.B      $F4,$00,$ED,$00,$FC,$00,$04,$00 
                  DC.B      $1B,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $01,'@',$01,'?',$00,$FF,$00,$FF 
                  DC.B      $00,$00,$01,$7F,$FE,$FF,$FF,$7F 
                  DC.B      $FF,$80,$00,$00,$E0,$1F,$11,'5' 
                  DC.B      $F6,$1F,$08,$10,$F5,'*',$FF,$FF 
                  DC.B      $F5,'@',$FF,$FF,$00,$00,$0A,$BF 
                  DC.B      $FA,$00,$06,$80,$FE,$00,$02,$00 
                  DC.B      $FD,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $01,$00,$00,$FF,$00,$7F,$00,$FF 
                  DC.B      $00,$00,$01,$7F,$FE,$7F,$FF,$FF 
                  DC.B      $FF,$80,$00,$00,$F8,$1F,$E4,'B' 
                  DC.B      $FD,$BF,$02,$00,$1D,']',$FF,$FF 
                  DC.B      $E0,$00,$FF,$FF,$00,$00,$1F,$FF 
                  DC.B      $FD,$00,$03,'@',$FF,$80,$01,$00 
                  DC.B      $FE,'@',$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $00,$80,$00,$7F,$01,$FF,$01,$FF 
                  DC.B      $00,$00,$00,$7F,$FF,'_',$FE,$FF 
                  DC.B      $FF,$80,$00,' ',$FF,$FF,$FC,$04 
                  DC.B      $FF,$FF,$00,$00,$03,$FB,$FF,$E7 
                  DC.B      $00,$18,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FE,'@',$01,'@',$FF,$00,$00,'@' 
                  DC.B      $FF,$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     73,0
                  DC.B      $01,$FF,$00,$FF,$01,$FF,$00,$00 
                  DC.B      $00,$7F,$FF,'*',$FE,$FF,$FF,$80 
                  DC.B      $00,'U',$FF,$FE,$FF,$E0,$FF,$FE 
                  DC.B      $00,$01,$00,$1E,'?',$CF,'@>'
                  DC.B      $7F,$FF,$80,$00,$7F,$F1,$8F,$80 
                  DC.B      'P',$80,$DF,$C0,' ',$80,$DF,$00 
                  DCB.W     75,0
                  DC.B      $01,$00,$00,$FF,$01,$FF,$01,$FF 
                  DC.B      $00,$00,$00,$7F,$FF,$15,$FE,$FF 
                  DC.B      $FF,$80,$00,'j',$FF,$FF,'W',$C0 
                  DC.B      $FF,$FF,$00,$00,$A8,'??',$90
                  DC.B      $80,$7F,$BF,$FF,'@',$0F,$BF,$E0 
                  DC.B      $C7,'@(@',$EF,$00,$10,$80 
                  DC.B      $EF,'@',$00,$00,$00,$00,$00,$00 
                  DCB.W     73,0
                  DC.B      $07,$FF,$01,$FF,$03,$FF,$00,$00 
                  DC.B      $00,$7F,$FF,$00,$FE,$FF,$FF,$80 
                  DC.B      $00,$7F,$FF,$FF,'*',$80,$FF,$FF 
                  DC.B      $00,$00,$D5,$7F,$9F,$A0,'@',$7F 
                  DC.B      $DF,$FF,' ',$1F,$DF,$C0,'g',$00 
                  DC.B      $90,$A0,$F7,$80,$88,$00,'w',$E0 
                  DCB.W     75,0
                  DC.B      $06,$00,$05,$FF,$03,$FF,$03,$FF 
                  DC.B      $00,$00,$00,$7F,$FF,$80,$FE,$FF 
                  DC.B      $FF,$00,$00,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$DF,$C0 
                  DC.B      $00,'?',$DF,$FE,' ?',$DF,$C0
                  DC.B      'w',$E0,$80,'`w',$C0,$88,'`'
                  DC.B      'w',$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $04,$80,$03,$7F,$03,$FF,$03,$FF 
                  DC.B      $00,$00,$02,$7F,$FD,$80,$FE,$FF 
                  DC.B      $FF,$00,$00,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$DF,$CC 
                  DC.B      $00,';',$DF,$D0,' ;',$DF,$C0
                  DC.B      'g',$80,$90,$00,'w',$A0,$88,'@' 
                  DC.B      'w',$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $07,$C0,$08,'?',$03,$FF,$03,$FF 
                  DC.B      $08,$00,$02,$7F,$FD,$80,$FE,$FF 
                  DC.B      $FF,$00,$00,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$9F,$FC 
                  DC.B      '@',$1F,$DF,$E0,' ',$1F,$DF,$E0 
                  DC.B      $F7,$80,$08,'@',$FF,$E0,$00,$00 
                  DC.B      $FF,$C0,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $05,$C0,$0A,'?',$01,$FF,$03,$FF 
                  DC.B      $08,$00,$06,'v',$F9,$09,$FE,$FF 
                  DC.B      $FF,$80,$00,$7F,$BF,$FF,'@',$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$9F,$FD 
                  DC.B      '!',$CA,$BF,$E1,'@',$0A,$BE,'!' 
                  DC.B      $FF,$80,$00,'@',$FF,$C0,$00,$00 
                  DC.B      $FF,$E0,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $01,$E0,$04,$1F,$0F,$FF,$03,$FF 
                  DC.B      $04,$00,$06,'_',$F9,' ',$FE,$FF 
                  DC.B      $FF,$80,$00,$7F,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,';',$FF 
                  DC.B      $85,$E0,$BF,$FF,'@',$00,$BE,$1F 
                  DC.B      $FF,$C0,$00,$00,$FF,$C0,$00,$00 
                  DC.B      $FF,$E0,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $07,$F0,$12,$0F,$07,$FF,$01,$FF 
                  DC.B      $1C,$00,'<%',$C3,$CA,$FC,'{'
                  DC.B      $FF,$98,$00,'g_',$FF,$A0,$00
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,';',$FF 
                  DC.B      '@@{',$FF,$84,$00,'{',$BF 
                  DC.B      $FF,$C0,$00,$00,$FF,$C0,$00,$00 
                  DC.B      $FF,$E0,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $0F,$FF,$0E,$00,$1F,$FF,$09,$FF 
                  DC.B      $00,$00,$F8,'~',$07,$81,$F8,'C' 
                  DC.B      $FF,$80,$00,$7F,$AF,$FF,'W',$80 
                  DC.B      $FF,$FF,$00,$00,$F8,$7F,'y',$EF 
                  DC.B      $04,$00,'}',$EF,$82,$10,'}',$EF 
                  DC.B      $FF,$C0,$00,$00,$FF,$C0,$00,$00 
                  DC.B      $FF,$E0,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $07,$FF,$06,$00,$07,$FF,$09,$FF 
                  DC.B      $10,$00,$00,'e',$FF,$02,$00,$9B 
                  DC.B      $FF,$98,$00,'g_',$FF,$AF,$00
                  DC.B      $FF,$FF,$00,$00,$F0,$FF,'|A'
                  DC.B      $02,$AE,'~',$EF,$81,$10,'~',$EF 
                  DC.B      $FF,$D0,$00,'0',$FF,$F0,$00,'(' 
                  DC.B      $FF,$D8,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $17,$F0,$1E,$0F,$1F,$F0,$11,$FF 
                  DC.B      $00,$00,$00,$FE,$FE,$01,$01,'3' 
                  DC.B      $FF,$00,$00,$FF,$BF,$FF,'\',$00 
                  DC.B      $FF,$FF,$00,$00,$E3,$FF,'>',$07 
                  DC.B      'A',$1F,$7F,$1F,$80,$E0,$7F,$18 
                  DC.B      $FF,$B8,$00,'x',$FF,$F8,$00,'@' 
                  DC.B      $FF,$A0,$00,$00,$00,$00,$00,$00 
                  DCB.W     72,0
                  DC.B      $06,$F7,$0F,$08,$0E,$F7,$11,$F8 
                  DC.B      $08,$07,$01,$F8,$FC,$07,$02,'g' 
                  DC.B      $FE,$00,$01,$FF,'?',$FF,$DA,$00 
                  DC.B      $FF,$FF,$00,$00,$E5,$FF,$07,$C8 
                  DC.B      $08,'?',$0F,$FF,$F0,$07,$7F,$F0 
                  DC.B      'sx',$88,$F8,$FB,$F8,$84,$84
                  DC.B      '{D',$00,$00,$00,$00,$00,$00
                  DCB.W     62,0
                  DC.B      $0C,$00,$00,$00,$0C,$00,$00,$00 
                  DCB.W     6,0 
                  DC.B      $0E,$27,'6',$D8,$1F,$27,$01,$F8 
                  DC.B      '(',$07,$C2,'p<',$8F,$C1,'O'
                  DC.B      '=',$80,$C2,$7F,'?',$BF,$FC,'@' 
                  DC.B      $FF,$FF,$00,$00,$C3,$FF,$03,$D0 
                  DC.B      $84,'?',$87,$FF,'x',$0F,$BF,$E0 
                  DC.B      ':',$F4,$C1,$F4,$FB,$F4,$C5,$08 
                  DC.B      ':',$88,$00,$00,$00,$00,$00,$00 
                  DCB.W     32,0
                  DC.B      $02,$00,$02,$FF,$01,$FF,$01,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$FF,$FC 
                  DCB.W     16,0
                  DC.B      $12,$00,$08,$00,$08,$00,$1E,$00 
                  DC.B      $16,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $0F,$07,'=',$F8,$1F,$07,$00,$F8 
                  DC.B      '2',$07,$E2,$00,$1D,$BF,$E0,$7F 
                  DC.B      $1D,$C0,$E2,'??',$BF,$F8,'@'
                  DC.B      $FF,$FF,$00,$00,$C7,$FF,$83,$C0 
                  DC.B      '@?',$C3,$FF,'<',$1F,$DF,$E0
                  DC.B      '3',$D4,$C9,$D4,';',$D4,$C4,'*' 
                  DC.B      ':*',$00,$00,$00,$00,$00,$00
                  DCB.W     32,0
                  DC.B      $08,$00,$0B,$FF,$07,$FF,$07,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$10,$FF,$EC,$FF,$C4,$FF,$EC 
                  DC.B      $00,$10,$00,$00,$00,$00,$00,$00 
                  DCB.W     12,0
                  DC.B      $08,$00,$12,$00,$08,$00,$16,$00 
                  DC.B      $1E,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $0F,$07,$1C,'z?',$87,$00,$F8
                  DC.B      $13,$05,$E0,$00,$1C,$FF,$E3,'?' 
                  DC.B      $1F,$C0,$E0,'??',$AB,$FC,'T'
                  DC.B      $FF,$FF,$00,$00,$C3,$FF,$E3,$E6 
                  DC.B      $14,$1D,$F7,$E8,$08,$1D,$FF,$E0 
                  DC.B      '2',$C0,$C4,$C0,'6',$C0,$C9,'?' 
                  DC.B      '7?',$00,$00,$E0,$00,'`',$00
                  DC.B      $F0,$00,$10,$00,$00,$00,$00,$00 
                  DCB.W     28,0
                  DC.B      '"',$00,'-',$FF,$13,$FF,$1F,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,'8',$FF,$C4,$FF,$C4,$FF,$C4 
                  DC.B      $00,'8',$00,$00,$00,$00,$00,$00 
                  DCB.W     13,0
                  DC.B      $08,$00,$08,$00,$16,$00,$1E,$00 
                  DCB.W     5,0 
                  DC.B      $1F,$0F,$0C,'6',$1F,$CF,$00,$F0 
                  DC.B      '3',$09,$F0,$00,$0F,$FF,$F0,'?' 
                  DC.B      $0F,$C0,$F0,'??',$97,$F8,'h'
                  DC.B      $FF,$FF,$00,$00,$C7,$FF,$FF,$FE 
                  DC.B      $00,$0F,$FF,$F0,$00,$0F,$FF,$F0 
                  DC.B      'g ',$98,'#',$7F,'!',$80,$DF
                  DC.B      $7F,$DC,$F0,$00,$F0,$00,$F0,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     28,0
                  DC.B      $14,$00,'+',$FF,'W',$FF,$7F,$FF 
                  DC.B      $00,$00,$18,$C0,$FF,$FF,$E7,'?' 
                  DC.B      $FF,$FF,$18,$C0,$00,$10,$FF,$EC 
                  DC.B      $FF,$C4,$FF,$EC,$00,$10,$00,$00 
                  DCB.W     15,0
                  DC.B      $12,$00,$00,$00,$1E,$00,$1E,$00 
                  DCB.W     5,0 
                  DC.B      '?',$FF,'h',$06,'?',$FF,' ',$00 
                  DC.B      'W',$F9,$E0,$00,$1F,$DF,$F0,'?' 
                  DC.B      $0F,$E0,$F0,$1E,'?',$81,$FC,'r' 
                  DC.B      $FF,$F3,$00,$0C,'C',$C3,$FF,$FE 
                  DC.B      $00,$07,$FF,$F0,$00,$07,$FF,$F0 
                  DC.B      $FF,$03,$00,$1F,$FF,$0F,$00,$FC 
                  DC.B      $FF,'b',$F0,$00,$F0,$00,$F0,$00 
                  DC.B      $08,$00,$08,$00,$00,$00,$00,$00 
                  DCB.W     28,0
                  DC.B      '(',$00,'W',$FF,$AF,$FF,$FF,$FF 
                  DC.B      $00,$00,'% ',$FF,$FF,$DA,$DF
                  DC.B      $FF,$FF,'% ',$00,$00,$FF,$FC
                  DC.B      $FF,$FC,$FF,$FC,$00,$00,$00,$00 
                  DCB.W     14,0
                  DC.B      $12,$00,$00,$00,$00,$00,$1E,$00 
                  DC.B      $1E,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $1E,$1F,$19,'Ž_',$9F,' @' 
                  DC.B      $07,$91,$E0,$00,$1F,$FF,$F0,$1F 
                  DC.B      $0F,$E0,$F0,$00,'?',$82,$DA,'c' 
                  DC.B      $FF,$EB,$00,$12,'e',$E9,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FC,$9F,$03,$FF,$FF,$BF,$00,$E0 
                  DC.B      $FF,$10,$90,$00,$90,$00,$90,$00 
                  DC.B      'h',$00,'h',$00,$00,$00,$00,$00 
                  DCB.W     25,0
                  DC.B      $00,$01,$00,$01,$00,$00,'P',$00 
                  DC.B      $AF,$FF,'_',$FF,$FF,$FF,$00,$00 
                  DC.B      $02,$00,$FF,$FF,$FD,$FF,$FF,$FF 
                  DC.B      $02,$00,$00,$00,$FF,$FC,$FF,$FC 
                  DC.B      $FF,$FC,$00,$00,$00,$00,$00,$00 
                  DCB.W     13,0
                  DC.B      $16,$00,$00,$00,$12,$00,$0C,$00 
                  DC.B      $0C,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $1E,'_',$B9,$CC,'?',$DF,$00,'@' 
                  DC.B      $C7,$93,$E0,$00,$1F,$EF,$F0,$1F 
                  DC.B      $0F,$F0,$F0,$00,'?',$80,$DC,'a' 
                  DC.B      $FF,$F1,$00,$00,'c',$F3,'/',$FF 
                  DC.B      $D0,$00,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $E8,'t',$16,$F4,$FE,$F4,$01,$8B 
                  DC.B      $FE,'Kox',$EF,'H',$DF,$80 
                  DC.B      '0',$C0,$BF,$E0,$01,$00,$00,$00 
                  DC.B      $00,$00,$01,$00,$00,$00,$00,$00 
                  DCB.W     20,0
                  DC.B      $00,$01,$00,$02,$00,$03,$00,$00 
                  DC.B      ' ',$00,$DF,$FF,$BF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      'p',$00,$FF,$FC,$8F,$FC,$FF,$FC 
                  DC.B      'p',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     12,0
                  DC.B      ' ',$00,$02,$00,$00,$00,'>',$00 
                  DC.B      '?',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      '`',$1F,'_',$AC,$FF,$9F,'@',$00 
                  DC.B      '?',$F3,$C0,$00,'?',$FF,$F0,$0F 
                  DC.B      $0F,$F0,$E0,$00,$1F,$D1,$FA,'1' 
                  DC.B      $FF,$F1,$00,$11,'%',$E0,$15,$FF 
                  DC.B      $EA,$00,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      'P',$ED,$A8,$FD,$F8,$FB,$07,$06 
                  DC.B      $F9,$17,$80,$17,$FF,$F5,$FF,$F8 
                  DC.B      $7F,$EE,$80,$1C,$00,$00,$00,$00 
                  DCB.W     24,0
                  DC.B      $00,$03,$00,$05,$00,$07,$00,$00 
                  DC.B      $80,$00,$7F,$FF,$BF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $88,$00,$FF,$FC,'w',$FC,$FF,$FC 
                  DC.B      $88,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     12,0
                  DC.B      'P',$00,'"',$00,'1',$00,'N',$00 
                  DC.B      $7F,$80,$00,$00,$00,$01,$00,$00 
                  DC.B      $00,$00,$00,$01,$9F,$FF,$E0,$F8 
                  DC.B      $FF,$FF,$80,$00,'?',$07,$C0,$00 
                  DC.B      '7',$F7,$F8,$0F,$0F,$F8,$C0,$00 
                  DC.B      $1F,$C8,$ED,'0',$FF,$F8,$00,$00 
                  DC.B      '2',$F1,$02,$BA,'}E',$7F,$FF
                  DC.B      $80,$00,$7F,$FF,$80,$A8,'p',$EF 
                  DC.B      $F2,$DF,$0D,'7',$F1,'x',$00,$01 
                  DC.B      $FF,$FD,$FF,$FE,$FF,$FF,$00,$03 
                  DC.B      $C0,$00,'A',$00,$00,$00,$80,$00 
                  DC.B      $01,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     17,0
                  DC.B      $00,$01,$00,$06,$00,$0B,$00,$0F 
                  DC.B      $00,$00,'@',$00,$BF,$FF,$7F,$FF 
                  DC.B      $FF,$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$08,$00 
                  DC.B      $FF,$FC,$F7,$FC,$FF,$FC,$08,$00 
                  DCB.W     15,0
                  DC.B      $80,$00,'w',$00,'p',$80,$AF,$00 
                  DC.B      $DF,$C0,$00,$00,$00,$02,$00,$01 
                  DC.B      $00,$00,$00,$02,'?',$FF,$DF,$C0 
                  DC.B      $FF,$FF,$00,$00,'`?',$80,$00
                  DC.B      'q',$FB,$FE,$07,$0F,$FC,$C0,$00 
                  DC.B      $0F,$EC,$F6,$18,$FF,$FC,$00,$08 
                  DC.B      $19,$F0,$00,$00,'?',$FF,'?',$FF 
                  DC.B      '@',$00,$BF,$FF,$00,$A3,$C0,$BF 
                  DC.B      $C4,$7F,'9',$DC,$81,$E3,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      '`',$00,'a',$00,$80,$00,$C0,$00 
                  DC.B      $C1,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     17,0
                  DC.B      $00,$03,$00,$0C,$00,$17,$00,$1F 
                  DC.B      $00,$00,'@',$00,$BF,$FF,$7F,$FF 
                  DC.B      $FF,$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$0F,$00 
                  DC.B      $FF,$FC,$F0,$FC,$FF,$FC,$0F,$00 
                  DCB.W     10,0
                  DC.B      $00,$01,$00,$00,$00,$01,$00,$00 
                  DC.B      $00,$00,'@',$00,$A7,$80,'``'
                  DC.B      $9F,$80,$FF,$C0,$00,$00,$00,$00 
                  DC.B      $00,$03,$00,$00,$00,$01,$BF,$F8 
                  DC.B      '\',$07,$FF,$FF,$00,$00,$E3,$FF 
                  DC.B      $00,$00,$F0,'{',$FF,$87,$0F,$FC 
                  DC.B      $00,$00,$07,$F6,$FB,$0C,$FF,$FE 
                  DC.B      $00,$04,$0C,$F8,' ',$00,'/',$F8 
                  DC.B      '/',$F8,'0',$07,'@',$00,$10,$81 
                  DC.B      $10,$FD,$19,$FF,$F1,'~',$01,$83 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,'p',$00,$F1,$00,$C0,$00 
                  DC.B      $A0,$00,'a',$00,$00,$00,$00,$00 
                  DCB.W     18,0
                  DC.B      $00,$27,$00,$18,$00,$0F,$00,$1F 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$7F,$FF,$FF,$FF,$00,$00 
                  DC.B      $C0,$00,$DF,$FF,'?',$FF,$FF,$FF 
                  DC.B      $E0,$00,$10,$80,$FF,$FC,$EF,'|' 
                  DC.B      $FF,$FC,$10,$80,$00,$00,$00,$00 
                  DCB.W     8,0 
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$01 
                  DC.B      $00,$01,'@ ',$27,$80,'``' 
                  DC.B      $9F,$80,$FF,$C0,$00,$03,$00,$05 
                  DC.B      $00,$03,$00,$01,$00,$04,$BF,$80 
                  DC.B      'X',$7F,$FF,$FF,$00,$00,$E7,$F0 
                  DC.B      $18,$00,$E0,$03,$FF,$FF,$07,$FC 
                  DC.B      '8',$00,$07,$FB,$C2,$06,$C7,$FF 
                  DC.B      $00,$02,$05,$FC,$08,$00,$08,$00 
                  DC.B      $08,$00,$0F,$FF,$10,$00,'A',$03 
                  DC.B      'A',$FF,'Q',$FF,$C0,$FC,'!',$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,'X',$00,$D9,$00,$E0,$00 
                  DC.B      $B0,$00,'q',$00,$00,$02,$00,$00 
                  DC.B      $00,$00,$00,$02,$00,$00,$00,$00 
                  DCB.W     14,0
                  DC.B      $00,'&',$00,$19,$00,$1E,$00,'?' 
                  DC.B      $00,$00,$80,$03,$7F,$FF,$FF,$FE 
                  DC.B      $FF,$FD,$00,$03,'3@3',$7F 
                  DC.B      $CC,$FF,$FF,$BF,$FF,$C0,$00,$80 
                  DC.B      $FF,$FC,$FF,'|',$FF,$FC,$00,$80 
                  DCB.W     11,0
                  DC.B      $00,$01,$00,$00,$00,$01,$00,$01 
                  DC.B      $00,$00,'C',$80,'@`',$BF,$80
                  DC.B      $FF,$E0,$00,$00,$00,$01,$00,$07 
                  DC.B      $00,$00,$00,$03,$BF,$00,'P',$FF 
                  DC.B      $FF,$FF,$00,$00,$EF,$03,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FC,$01,$03,$FF,$FF,$FC,$00 
                  DC.B      $FE,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FE,$00,$03,$FE 
                  DC.B      $FD,$FF,$FF,$FF,$FE,$01,$80,$00 
                  DC.B      $FF,$FF,$FF,$FF,$7F,$FF,$80,$00 
                  DC.B      $88,$00,$C1,$00,$F0,$00,'x',$00 
                  DC.B      $B1,$00,$00,$00,$00,$04,$00,$00 
                  DC.B      $00,$00,$00,$04,$00,$00,$00,$00 
                  DCB.W     13,0
                  DC.B      $00,$0E,$00,$11,$00,'>',$00,'?' 
                  DC.B      $00,$00,$80,$02,$7F,$FE,$FF,$FD 
                  DC.B      $FF,$FF,$00,$03,'-',$C0,$ED,$DF 
                  DC.B      $F3,'?',$DE,$FF,'?',$E0,$01,$00 
                  DC.B      $FF,$FC,$FE,$FC,$FF,$FC,$01,$00 
                  DCB.W     13,0
                  DC.B      $00,$01,$00,$01,$00,$00,$03,$C0 
                  DC.B      $00,' ',$FF,$C0,$FF,$E0,$00,$03 
                  DC.B      $00,$02,$00,$03,$00,$02,$00,$05 
                  DC.B      $BE,'k',$C1,$9C,$FF,$FF,$00,$7F 
                  DC.B      $7F,$7F,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FE,$00,$81 
                  DC.B      $FF,$FF,$FE,$00,$FF,$7F,$7F,$FF 
                  DC.B      $80,$00,$FF,$FF,$7F,$FF,$FF,$FF 
                  DC.B      $FC,$00,$01,$FE,$FF,$FF,$FF,$FF 
                  DC.B      $FE,$01,'@',$00,$7F,$FF,$FF,$FF 
                  DC.B      $BF,$FF,$C0,$00,'l',$00,$ED,$00 
                  DC.B      $F0,$00,$98,$00,'y',$00,$00,$00 
                  DC.B      $00,$08,$00,$00,$00,$00,$00,$08 
                  DCB.W     15,0
                  DC.B      $00,'>',$00,$01,$00,$1E,$00,$1F 
                  DC.B      $00,' ',$01,$06,$FD,$FF,$FF,$FD 
                  DC.B      $FE,$FB,$03,$06,$00,' ',$FF,$EF 
                  DC.B      $FF,$DF,$FF,$FF,$00,'0',$80,$00 
                  DC.B      $FF,$FC,$7F,$FC,$FF,$FC,$80,$00 
                  DCB.W     11,0
                  DC.B      $00,$01,$00,$01,$00,$02,$00,$02 
                  DC.B      ' ',$00,$D8,$F0,$F8,$00,'G',$F0 
                  DC.B      $B7,$F0,$00,$05,$00,$0F,$00,$07 
                  DC.B      $00,$04,$00,$0A,$DE,'{',$A1,$9C 
                  DC.B      $FF,$FF,$00,$7F,$7F,$7F,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$00 
                  DC.B      $FF,$FF,'?',$FF,$C0,$00,$FF,$FF 
                  DC.B      '?',$FF,$FF,$FF,$FE,$01,$03,$FF 
                  DC.B      $FF,$FF,$FD,$FE,$FE,$01,' ',$00 
                  DC.B      '?',$FF,$FF,$FF,$DF,$FF,$E0,$00 
                  DC.B      '$',$00,$E1,$00,$F8,$00,$DC,$00 
                  DC.B      '9',$00,$00,$10,$00,$10,$00,$00 
                  DC.B      $00,$10,$00,$00,$01,$C0,$06,'@' 
                  DCB.W     2,0 
                  DC.B      $04,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     7,0 
                  DC.B      $00,'&',$00,'9',$00,$06,$00,$1F 
                  DC.B      $00,$00,$02,$06,$FE,$FF,$FF,$FB 
                  DC.B      $FD,$FD,$03,$06,$FE,$18,$FF,$FF 
                  DC.B      $83,$EF,'}',$F7,$FE,$18,$80,$00 
                  DC.B      $FF,$FC,$7F,$FC,$FF,$FC,$80,$00 
                  DC.B      $07,$00,$02,$00,$07,$00,$02,$00 
                  DC.B      $02,$00,$00,$00,$80,$00,$80,$00 
                  DC.B      $80,$00,$80,$00,$00,$01,$00,$00 
                  DCB.W     3,0 
                  DC.B      $00,' ',$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$00,$03,$00,$09,$00,$03 
                  DC.B      $00,$04,$00,$0A,$DE,'[',$A1,$BC 
                  DC.B      $FF,$FF,$00,$7F,$7F,$7F,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,' ',$FF,$FF,$FF,$80 
                  DC.B      $FF,$DF,$9F,$FF,'`',$00,$FF,$FF 
                  DC.B      $1F,$FF,$FF,$FF,$FC,$00,$07,$FF 
                  DC.B      $FF,$FF,$FB,$FF,$F8,$00,'P',$00 
                  DC.B      '_',$FF,$BF,$FF,$EF,$FF,$F0,$00 
                  DC.B      'V',$00,$F7,$00,$F8,$00,$AC,$00 
                  DC.B      ']',$00,$00,' ',$00,' ',$00,$00 
                  DC.B      $00,' ',$00,$00,$03,$C0,$1C,'`' 
                  DC.B      $00,$00,$04,$00,$12,$00,$00,$00 
                  DCB.W     9,0 
                  DC.B      $00,$1A,$00,$05,$00,$1A,$00,$1F 
                  DC.B      $00,$00,$80,$0D,'~',$FF,$FF,$FB 
                  DC.B      $FF,$F6,$01,$0D,$C6,$08,$FE,$FF 
                  DC.B      '}',$F7,$BB,$FF,$C7,$08,'H',$F0 
                  DC.B      '~',$F4,$BF,$FC,$F7,$0C,$C9,$08 
                  DC.B      $07,$80,$00,$00,$07,$80,$07,$00 
                  DC.B      $07,$00,'@',$00,$00,$00,'@',$00 
                  DC.B      '@',$00,'@',$00,$00,$01,$00,$00 
                  DCB.W     3,0 
                  DC.B      ' ',$A0,$00,$80,$00,$00,$00,$00 
                  DC.B      ' ',$00,$00,$03,$00,$0F,$00,$07 
                  DC.B      $00,$00,$00,$0C,$EE,'[',$11,$BC 
                  DC.B      $FF,$FF,$00,$7F,$FE,$7F,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$10,$FF,$FF,$FF,$C0 
                  DC.B      $FF,$EF,$E7,$FF,$98,$00,$FF,$FF 
                  DC.B      $07,$FF,$7F,$FF,$FC,$00,$07,$FF 
                  DC.B      $FB,$FF,$FF,$FF,$FC,$00,$A8,$00 
                  DC.B      $AF,$FF,$DF,$FF,'w',$FF,$F8,$00 
                  DC.B      '#',$00,$F1,$00,$FC,$00,$DF,$00 
                  DC.B      ',',$00,$00,$00,$00,'@',$00,$00 
                  DCB.W     2,0 
                  DC.B      $06,$00,';',$80,$00,$00,$08,$00 
                  DC.B      ' ',$80,$00,$00,$00,$00,$00,$00 
                  DCB.W     7,0 
                  DC.B      $00,$04,$00,$1B,$00,$1C,$00,$1F 
                  DC.B      $00,$00,$11,$0F,$FF,$FF,'~',$F6 
                  DC.B      $EF,$F9,$11,$0F,$83,$08,$FF,$7F 
                  DC.B      $FE,$F7,'}',$FF,$83,$88,$D1,'T' 
                  DC.B      $F5,$EC,$BF,$FC,'o',$FC,$DB,$FC 
                  DC.B      $07,$C0,$00,$00,$07,$C0,$03,$80 
                  DC.B      $03,$80,' ',$00,$00,$00,' ',$00 
                  DCB.W     2,0 
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$00,' ',$00,$00,' ',$00 
                  DC.B      ' ',$00,$00,$00,$00,$07,$00,$03 
                  DC.B      $00,$0F,$00,$00,$00,$04,$C4,';' 
                  DC.B      ';',$DC,$FF,$FF,$00,$1F,$EE,$7F 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$10,$FF,$FF 
                  DC.B      $FF,$E0,$FF,$EF,$FD,$FF,'b',$00 
                  DC.B      $FF,$FF,$01,$FF,$9F,$FF,$F8,$00 
                  DC.B      $03,$FF,$FF,$FF,$FF,$FF,$FC,$00 
                  DC.B      'T',$00,$D7,$FF,$EF,$FF,$BB,$FF 
                  DC.B      '|',$00,'S',$00,$F3,$00,$FC,$00 
                  DC.B      $AF,$00,'^',$00,$00,$00,$00,$80 
                  DCB.W     3,0 
                  DC.B      '8',$00,'f',$00,$00,$00,$00,$00 
                  DC.B      $12,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     8,0 
                  DC.B      $00,$1F,$00,$1F,$00,$1F,$00,$00 
                  DC.B      $09,$0B,$EF,$FF,$FE,$F5,$F7,$FE 
                  DC.B      $19,$0B,'A',$D8,'_',$FF,$BF,'w' 
                  DC.B      $FE,$AF,$E1,$D8,'Z',$FE,$FF,$00 
                  DC.B      $AF,$FF,$F5,$FC,'Y',$FC,$01,$E0 
                  DC.B      $00,$00,$03,$E0,$00,$C0,$00,$C0 
                  DCB.W     2,0 
                  DC.B      $10,$00,$00,$00,$00,$00,$00,$01 
                  DCB.W     4,0 
                  DC.B      $00,$A0,' ',$80,' ',$00,' ',$00 
                  DC.B      $00,$00,$00,$0F,$00,$1B,$00,$07 
                  DC.B      $00,$00,$00,$1C,$C8,$1B,$27,$EC 
                  DC.B      $EF,$FF,$10,$0F,$EF,'?',$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$10,$FF,$FF,$FF,$E0 
                  DC.B      $FF,$EF,$FC,$FF,$02,$00,$FE,$FF 
                  DC.B      $01,$FF,$FE,$FF,$FC,$00,$07,$FF 
                  DC.B      $FF,$FF,$FB,$FF,$FC,$00,'+',$00 
                  DC.B      $EB,$FF,$F7,$FF,$DC,$FF,'?',$00 
                  DC.B      ' ',$00,$F1,$00,$FE,$00,$DE,$00 
                  DC.B      '.',$00,$01,$00,$01,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'p',$00,$9C,$00,$00,$00,$00,$00 
                  DC.B      '$',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     8,0 
                  DC.B      $00,$1F,$00,$1F,$00,$1F,$00,$00 
                  DC.B      $1F,$0A,$FF,$FF,$F2,$F5,$ED,$FF 
                  DC.B      $1F,$0A,$A2,$D8,$FB,$FF,']',$AF 
                  DC.B      $FF,'w',$A6,$D8,'a',$BF,$ED,$C0 
                  DC.B      $9F,$FF,$FE,$FF,'r',$FF,$80,$F0 
                  DC.B      $00,$00,$C0,$F0,$00,'`',$00,'`' 
                  DCB.W     5,0 
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$00,$A0,' ',$00,' ',$00 
                  DC.B      ' ',$00,$00,$80,$00,$0F,$00,$16 
                  DC.B      $00,$0F,$00,$00,$00,$11,$9E,$0B 
                  DC.B      'u',$FC,$FF,$FF,$14,$0F,$CF,$9F 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,'5',$FF,$FF 
                  DC.B      $FF,$C0,$FF,$CA,$81,$FF,$7F,$00 
                  DC.B      $FF,$FF,$01,$FF,$FE,$FF,$FC,$00 
                  DC.B      $07,$FF,$FF,$FF,$FB,$FF,$FC,$00 
                  DC.B      $15,$C0,$F5,$FF,$FB,$FF,$EE,'?' 
                  DC.B      $1F,$C0,'P',$00,$F1,$00,$FE,$00 
                  DC.B      $AE,$00,'^',$00,$02,$00,$02,$01 
                  DCB.W     3,0 
                  DC.B      $C0,$00,'0',$00,$00,$00,$00,$00 
                  DC.B      $10,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     8,0 
                  DC.B      $00,$1F,$00,$1F,$00,$1F,$00,$00 
                  DC.B      $03,$0A,$FF,$FF,$FC,$F5,$FF,$FF 
                  DC.B      $03,$0A,'AP_',$FF,$BF,$AF 
                  DC.B      $FE,$FF,$E1,'P',$E0,$1B,$FF,$9C 
                  DC.B      $9F,$FF,$7F,$EF,$E0,'o',$E0,'x' 
                  DC.B      $00,$00,$F0,'x',$C0,'0',$C0,'0' 
                  DCB.W     5,0 
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$00,'  ',$00,' ',$80
                  DC.B      ' ',$80,$00,$00,$00,$07,$00,$06 
                  DC.B      $00,$17,$00,$00,$00,$09,$AD,$0B 
                  DC.B      'v',$FC,$EF,$FF,'&',$0F,$DF,$DF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$F6,$00,'-',$FF,$FF 
                  DC.B      $FF,$80,$FF,$DB,$CF,$7F,'?',$00 
                  DC.B      $FF,$7F,$0F,$FF,$F0,$7F,$F8,$00 
                  DC.B      $07,$FF,$FF,$FF,$FF,$FF,$F8,$00 
                  DC.B      $0B,'p',$FB,$7F,$FC,$FF,$F7,$8F 
                  DC.B      $0F,$F0,$A1,$00,$E1,$00,$FE,$00 
                  DC.B      '^',$00,$BE,$00,$04,$01,$00,$02 
                  DCB.W     4,0 
                  DC.B      $C0,$00,$00,$00,$00,$00,'@',$00 
                  DCB.W     11,0
                  DC.B      $00,$1F,$00,$1F,$00,$1F,$00,$00 
                  DC.B      '_',$0A,$DF,$FF,$E0,$F5,$BF,$FF 
                  DC.B      $7F,$0A,$03,'P',$FF,$FF,$FE,$AF 
                  DC.B      $FD,$FF,$03,'P`',$00,$7F,$FC
                  DC.B      $9F,$FC,$FF,$FC,$E0,$00,'x<'
                  DC.B      $00,$00,$FC,'<0',$18,'0',$18
                  DCB.W     5,0 
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$00,'  ',$00,' ',$80
                  DC.B      ' ',$80,$00,$00,$00,$0F,$00,$0E 
                  DC.B      $00,$0F,$00,$08,$00,$11,$8D,$9B 
                  DC.B      'Fl',$CF,$FF,$07,$0F,$EF,$FF
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$E6,$00,$15,$FF,$F7 
                  DC.B      $FF,$88,$FF,$F3,'x',$7F,$08,$00 
                  DC.B      'x',$7F,$8F,$FF,'p',$7F,$F8,$00 
                  DC.B      $07,$FF,$FF,$FF,$FF,$FF,$F8,$00 
                  DC.B      $02,$D9,$FE,$DF,$FF,'?',$FD,$E6 
                  DC.B      $03,$F9,'a',$00,$E1,$00,$FE,$00 
                  DC.B      $9E,$00,'~',$00,$08,$02,$00,$05 
                  DC.B      $03,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     14,0
                  DC.B      $1D,$00,$1F,$1F,$00,$1F,$11,$1F 
                  DC.B      $00,$00,$07,$8A,$FF,$BF,$FC,'u' 
                  DC.B      $FB,$FF,$07,$CA,'?X',$BF,$FF
                  DC.B      $C1,$AF,$FE,$F7,$7F,'X',$FA,$00 
                  DC.B      $FB,$FC,$07,$FC,$FD,$FC,$FE,$00 
                  DC.B      $0E,$0E,$00,$00,$1E,$0E,$0C,$04 
                  DC.B      $0C,$04,$08,$00,$10,$00,$18,$00 
                  DC.B      $18,$00,$18,$00,$00,$01,$00,$00 
                  DCB.W     3,0 
                  DC.B      $0B,$E0,'+',$C0,$F4,$00,$FF,$C0 
                  DC.B      $DF,$C0,$00,$1F,$00,$16,$00,$1F 
                  DC.B      $00,$10,$00,$09,$85,'{N',$FC
                  DC.B      $EF,$FF,$0F,$FF,$CF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$E6,$00,$11,$FF,$F7,$FF,$C8 
                  DC.B      $FF,$F7,$AB,$1F,$D8,$00,$FB,$1F 
                  DC.B      $8F,$FF,'s',$1F,$F8,$00,$07,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$F8,$00,$00,$02 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FD,$00,$02 
                  DC.B      $C3,$00,$C2,$00,$FC,$00,'>',$00 
                  DC.B      $FE,$00,$10,$AE,$02,$AE,$05,'q' 
                  DC.B      $11,$DF,$00,$FE,$00,$00,$80,$00 
                  DCB.W     13,0
                  DC.B      $27,$80,'?',$9F,$00,$1F,'"',$9F 
                  DC.B      $08,$00,$0C,$BB,$FD,$BF,$FB,$D6 
                  DC.B      $F7,'m',$0E,$FB,$80,'Y',$FF,$FF 
                  DC.B      $7F,$AE,$FF,$F7,$80,'Y',$F0,$00 
                  DC.B      $FF,$FC,$DF,$FC,'/',$FC,$F0,$00 
                  DC.B      $07,$06,$00,$00,$07,$06,$02,$02 
                  DC.B      $02,$02,$1C,$00,$00,$00,$1C,$00 
                  DC.B      $18,$00,$18,$00,$00,$01,$00,$00 
                  DCB.W     3,0 
                  DC.B      $0B,$E0,'+',$C0,$F4,$00,$FF,$C0 
                  DC.B      $DF,$C0,$00,$0F,$00,$16,$00,$1F 
                  DC.B      $00,$00,$00,$09,$85,'{N',$FC
                  DC.B      $CF,$FF,$0F,$FF,$EF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$E2,$00,$05,$FF,$E7,$FF,$F8 
                  DC.B      $FF,$E7,$B8,$7F,$B8,$00,$B8,$7F 
                  DC.B      $FF,$FF,$00,$7F,$F8,$00,$03,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FC,$00,$00,'+' 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$D4,$00,'+' 
                  DC.B      $83,$00,$80,$00,$FC,$00,'|',$00 
                  DC.B      $FE,$00,'#',$0D,$01,$19,$04,$00 
                  DC.B      '!',$01,$01,$11,$80,$00,$00,$00 
                  DCB.W     13,0
                  DC.B      $19,$C0,'=',$DF,$00,$1F,$19,'_' 
                  DC.B      $00,$00,'<8',$FF,$FF,$E7,$EF
                  DC.B      $DB,$D7,'<8',$FF,$9B,$FF,$FF
                  DC.B      $80,'u',$7F,$EE,$FF,$9B,'8',$00 
                  DC.B      $FF,$FC,$E7,$FC,$DF,$FC,'8',$00 
                  DC.B      $01,$01,$00,$00,$01,$01,$01,$00 
                  DC.B      $01,$00,$0C,$00,$00,$00,$0E,$00 
                  DC.B      $04,$00,$04,$00,$00,$01,$00,$00 
                  DCB.W     3,0 
                  DC.B      $0B,$E0,'+',$C0,$F4,$00,$FF,$C0 
                  DC.B      $DF,$C0,$00,$1F,$00,$10,$00,$1F 
                  DC.B      $00,$10,$00,$0F,$A5,'{~',$FC
                  DC.B      $EF,$FF,'/',$FF,$DF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FD,$00,$01,$FF,$FD,$FF,$FF 
                  DC.B      $FF,$FC,$01,$BF,$00,$00,$01,$BF 
                  DC.B      $FF,$FF,$01,$BF,$FC,$00,$05,$FF 
                  DC.B      $FF,$FF,$FB,$FF,$FA,$00,$00,$F0 
                  DC.B      $FF,$F0,$FF,$FF,$FF,$0F,$00,$FF 
                  DC.B      $05,$00,$06,$00,$F8,$00,$FD,$00 
                  DC.B      $FC,$00,'C',$0D,$01,$D0,$04,$C0 
                  DC.B      $00,$C0,'D',$00,$80,$00,$00,$00 
                  DCB.W     3,0 
                  DC.B      $00,$02,$00,$02,$00,$01,$00,$02 
                  DCB.W     6,0 
                  DC.B      'L',$80,'|',$DF,$00,$1F,'D',$9F 
                  DC.B      $10,$00,'0',$18,$FF,$FB,$DF,$F7 
                  DC.B      $EF,$EF,'0',$1C,$08,$0E,$FF,$FF 
                  DC.B      $F7,$FB,$FF,$F5,$08,$0E,$0C,$00 
                  DC.B      $FF,$FC,$FB,$FC,$F7,$FC,$0C,$00 
                  DC.B      $00,$80,$00,$00,$00,$81,$00,$00 
                  DC.B      $00,$00,$02,$00,$00,$00,$06,$00 
                  DC.B      $02,$00,$02,$00,$00,$01,$00,$00 
                  DCB.W     3,0 
                  DC.B      $0B,$E0,'+',$C0,$F4,$00,$FF,$C0 
                  DC.B      $DF,$C0,$00,$0F,$00,$08,$00,$1F 
                  DC.B      $00,$08,$00,$07,$C5,'{.',$FC
                  DC.B      $EF,$FF,$0F,$FF,$DF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$10,$CF,$00,$00,$10,$CF 
                  DC.B      $FF,$FF,$10,$CF,$FE,$1F,$02,$1F 
                  DC.B      $FF,$FF,$FD,$E0,$FD,$FF,$FC,$00 
                  DC.B      $FC,$00,$FF,$FF,$03,$FF,$FF,$FF 
                  DC.B      $0D,$00,$08,$00,$F0,$00,$F9,$00 
                  DC.B      $F8,$00,$82,$1D,$02,$B1,$04,$80 
                  DC.B      $02,$81,$86,$00,$80,$00,$80,$00 
                  DC.B      $00,$00,$80,$00,$80,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $80,$00,$00,$00,$80,$00,$00,$00 
                  DC.B      $00,$00,$B0,'@',$FC,$DF,$00,$1F 
                  DC.B      $B0,$1F,$04,$80,$00,$1D,$FF,$FD 
                  DC.B      $FF,$EB,$FF,$F6,$00,$1F,$08,'>' 
                  DC.B      $FF,$FF,$F7,$E3,$FF,$DD,$08,'>' 
                  DC.B      $00,$00,$FD,$FC,$FF,$FC,$FF,$FC 
                  DC.B      $02,$00,$00,'0',$00,' ',$00,'8' 
                  DC.B      $00,' ',$00,$00,$81,$00,$00,$00 
                  DC.B      $83,$00,$00,$00,$00,$00,$00,$01 
                  DCB.W     4,0 
                  DC.B      $0B,$E0,'+',$C0,$F4,$00,$FF,$C0 
                  DC.B      $DF,$C0,$00,$07,$00,$04,$00,$0F 
                  DC.B      $00,$04,$00,$03,$D7,'{<',$FC
                  DC.B      $FF,$FF,$1F,$FF,$EF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$EF,$7F,$00,$00,$EF,$7F 
                  DC.B      $FF,$FF,$EF,$7F,$FF,$C0,$00,'@' 
                  DC.B      $FF,$BF,$FF,$7F,$FF,$FF,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      '=',$00,'$',$00,$C0,$01,$E0,$01 
                  DC.B      $F1,$00,$03,',',$02,$F4,$01,$80 
                  DC.B      $06,$90,$03,$00,$80,$00,$80,$00 
                  DC.B      $00,$00,$80,$00,$80,$00,$00,$0D 
                  DC.B      $00,$01,$00,$1E,$00,$01,$00,$00 
                  DC.B      '`',$00,' ',$00,'@',$00,' ',$00 
                  DC.B      $00,$00,'L',$C0,$F4,$DF,$10,$1F 
                  DC.B      'T',$9F,' ',$00,$00,'7',$FF,$FF 
                  DC.B      $FF,$DC,$FF,$EB,$00,'7',$FF,$F6 
                  DC.B      $FF,$FF,$1C,']',$E3,$AB,$FF,$F6 
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$FF,$FC 
                  DC.B      $00,$00,$00,'?',$00,$11,$00,'?' 
                  DC.B      $00,$1F,$00,$0E,$80,$00,$00,$00 
                  DC.B      $C0,$80,$00,$00,$00,$00,$00,$01 
                  DCB.W     4,0 
                  DC.B      $0B,$E0,'+',$C0,$F4,$00,$FF,$C0 
                  DC.B      $DF,$C0,$00,$03,$00,$0A,$00,$07 
                  DC.B      $00,$02,$00,$09,$EF,'{',$14,$FC 
                  DC.B      $FF,$FF,$07,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$F3,$FF,$00,$00,$F3,$FF 
                  DC.B      $FF,$FF,$F3,$FF,$FF,'p',$00,$F0 
                  DC.B      $FF,$EF,$FF,$1F,$FF,$9F,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      'q',$00,'P',$02,$80,$00,$C0,$02 
                  DC.B      $E1,$00,$03,$18,$03,$E4,$01,$80 
                  DC.B      $06,$A0,$02,$00,$80,$00,$80,$00 
                  DC.B      $00,$00,$80,$00,$80,$00,$00,$1E 
                  DC.B      $00,$0C,$00,'3',$00,$0C,$00,$00 
                  DC.B      ' ',$01,$00,$01,'`',$00,$00,$01 
                  DC.B      $00,$00,$16,'@',$E2,$DF,$08,$1F 
                  DC.B      $0A,$1F,'`',$00,$00,'#',$FF,$FF 
                  DC.B      $FF,$DE,$FF,$FD,$00,'#>',$E3
                  DC.B      $FF,$FF,$EB,$BD,$D5,'^>',$E3
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$FF,$FC 
                  DC.B      $00,$00,$00,$0F,$00,$04,$00,$0F 
                  DC.B      $00,$07,$00,$03,$F0,$00,'`',$00 
                  DC.B      $F0,$00,$E0,$00,$80,$00,$00,$01 
                  DCB.W     4,0 
                  DC.B      '+',$E0,'+',$C0,$F4,$00,$DF,$C0 
                  DC.B      $FF,$C0,$00,$01,$00,$04,$00,$01 
                  DC.B      $00,$00,$00,$07,$FF,$FB,$00,$FC 
                  DC.B      $FF,$FF,$03,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FD,$FF,$00,$00,$FD,$FF 
                  DC.B      $FF,$FF,$FD,$FF,$FF,'\',$00,'|' 
                  DC.B      $FF,'{',$FF,$87,$FF,$A7,$00,$07 
                  DC.B      $00,$07,$FF,$F8,$FF,$FF,$FF,$FF 
                  DC.B      $C0,$00,$80,$04,$01,$00,$81,$04 
                  DC.B      $C0,$00,$03,$18,$03,$CC,$01,$C0 
                  DC.B      $06,$A0,$02,'D',$80,$00,$80,$00 
                  DC.B      $00,$00,$80,$00,$80,$00,$00,'A' 
                  DC.B      $00,'@',$00,$01,$00,'@',$00,$00 
                  DC.B      '`',$00,'@',$01,' ',$00,'@',$00 
                  DC.B      $00,$00,$B9,$80,$B0,$DF,$06,$1F 
                  DC.B      $A6,$1F,$00,$00,$00,'b',$FF,$FF 
                  DC.B      $FF,$BD,$FF,$DF,$00,'b',$18,'#' 
                  DC.B      $FF,$FF,$F7,$DE,$EF,$FD,$18,'#' 
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$FF,$FC 
                  DC.B      $00,$00,$00,$03,$00,$00,$00,$03 
                  DC.B      $00,$01,$00,$01,$F8,$00,'0',$00 
                  DC.B      $F8,$00,$F0,$00,$C0,$00,$00,$01 
                  DC.B      $00,$01,$00,$00,$00,$00,$00,$00 
                  DC.B      $0B,$E0,$0B,$E0,$F4,$00,$FF,$C0 
                  DC.B      $FF,$C0,$00,$00,$00,$01,$00,$03 
                  DCB.W     2,0 
                  DC.B      $FE,$FB,$01,$FC,$FF,$FF,$03,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,'V',$00,'^',$FF,']',$FF,$A3 
                  DC.B      $FF,$AB,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$B8,$00,$F8,$08 
                  DC.B      'y',$00,$C1,$08,$80,$00,$03,'I' 
                  DC.B      $03,'(',$01,$ED,$06,$98,$02,$E6 
                  DC.B      $80,$00,$80,$00,$00,$00,$80,$00 
                  DC.B      $80,$00,$00,$19,$00,$00,$00,$1D 
                  DCB.W     2,0 
                  DC.B      '@',$F6,'A',$0F,'5',$FC,'B',$04 
                  DC.B      $0C,$F1,$06,$C0,$B4,'_',$01,$1F 
                  DC.B      $05,'_',$80,$00,$01,$C6,$FF,$FF 
                  DC.B      $FF,'}',$FE,$BB,$01,$C6,$08,'!' 
                  DC.B      $FF,$FF,$F7,$DE,$FF,$FF,$08,'!' 
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$FF,$FC 
                  DC.B      $00,$00,$00,$01,$00,$00,$00,$01 
                  DCB.W     2,0 
                  DC.B      $FA,$00,$18,$00,$FA,$80,$FC,$00 
                  DC.B      $E0,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$C0,$80,'@',$00,$00,$00,$00 
                  DC.B      $00,$00,$00,$01,$00,$03,$00,$01 
                  DC.B      $00,$01,$00,$02,$FE,$FB,$01,$FC 
                  DC.B      $FF,$FF,$03,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$06,$00,'_' 
                  DC.B      $FF,']',$FF,$A3,$FF,$FA,$92,'?' 
                  DC.B      $DB,$BF,'m',$C0,$FF,$FF,$B6,$7F 
                  DC.B      $FC,$00,$ED,$10,'|',$00,$91,$10 
                  DC.B      $80,$00,$03,'F',$03,'6',$01,$F6 
                  DC.B      $06,$8E,$02,$F1,$00,$00,$00,$00 
                  DC.B      $80,$00,$80,$00,$00,$00,$00,'4' 
                  DC.B      $00,$10,$00,'/',$00,$10,$00,$00 
                  DC.B      $0F,$FF,$17,$C1,$DF,$FF,' ',$01 
                  DC.B      'H>3',$00,'s',$1F,$00,$9F 
                  DC.B      $12,$9F,$C0,$00,$01,$FE,$FF,$FF 
                  DC.B      $FE,$01,$FF,$FF,$01,$FE,$08,'!' 
                  DC.B      $FF,$FF,$F7,$DF,$FF,$FE,$08,'!' 
                  DC.B      $80,$00,$FF,$FC,$7F,$FC,$FF,$FC 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$00,$8C,$00,$FF,'@',$FE,$00 
                  DC.B      'r',$00,$80,$00,$00,'_',$00,'l' 
                  DC.B      $FF,$BF,$FF,$C0,$00,$00,$FD,'?' 
                  DC.B      $03,$D8,$FE,$FF,$01,$00,$00,$18 
                  DC.B      $80,$00,'@',$09,$FF,$F0,'?',$F0 
                  DC.B      '~',$FB,$81,$FC,$FF,$FF,$01,$FF 
                  DC.B      $7F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,'V',$00,'_',$FF,']',$FF,$A3 
                  DC.B      $FF,$AA,$92,'%',$DB,$B5,'m',$DA 
                  DC.B      $FF,$FF,$B6,'o',$D4,$00,$ED,' ' 
                  DC.B      '| ',$91,' ',$A8,$00,$03,$C3
                  DC.B      $03,$B3,$09,'s',$06,$8F,$02,$F0 
                  DCB.W     2,0 
                  DC.B      $80,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$00,'G',$00,$00,$00,$01 
                  DC.B      '?',$FF,'_',$F0,$7F,$FF,$80,$00 
                  DC.B      ' ',$0F,$C1,$80,'s',$9F,$80,$1F 
                  DC.B      $00,$9F,$92,$00,$00,$06,$FC,$FF 
                  DC.B      $FF,$FD,$FF,$FB,$03,$06,$18,'.' 
                  DC.B      $FF,$EE,$F7,$D1,$EF,$FF,$18,'?' 
                  DC.B      $80,'p',$FF,$8C,$7F,$FC,$FF,$FC 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,'@',$04,$00,$FF,'@',$7F,$80 
                  DC.B      '{',$00,$00,$00,$00,'/',$00,'0' 
                  DC.B      $FF,$DF,$FF,$E0,'?',$80,$80,'W' 
                  DC.B      '@',$09,$FF,$FE,'?',$E1,$00,$0C 
                  DC.B      $00,$00,$00,$04,$FF,$F8,$FF,$F8 
                  DC.B      $BF,$FB,$C1,$FC,$FF,$FF,$81,$FF 
                  DC.B      '?',$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$82,$00,$1F,$FF,$9D,$FF,$E3 
                  DC.B      $FF,$FE,$92,'%',$DB,$B5,'m',$DA 
                  DC.B      $FF,$FF,$B6,'o',$D5,$00,$FC,'@' 
                  DC.B      '}@�@',$A8,$00,$03,$C3
                  DC.B      $03,$B3,$19,$F3,$06,$0F,$0A,'p' 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$81,$00,$80,$00,$05 
                  DC.B      $00,$82,$00,$05,$FF,$FF,$FF,$00 
                  DC.B      $FF,$FF,$00,$00,$00,$FF,$E3,$00 
                  DC.B      '#',$1F,$80,$1F,'"',$1F,$80,$00 
                  DC.B      $84,'C',$FF,$FF,$FF,$FE,'{',$BD 
                  DC.B      $84,'C',$F8,'E',$FF,$FD,'g',$BE 
                  DC.B      $9F,$FB,$F8,'G',$C0,$88,$FF,'t' 
                  DC.B      '?',$8C,$FF,$FC,$C0,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      '/',$E0,$02,$00,$7F,$E0,$7F,$C0 
                  DC.B      '-',$C0,$00,$00,$00,$16,$00,$19 
                  DC.B      $FF,$EF,$FF,$F0,$1F,$C0,$A0,$1E 
                  DC.B      $00,$18,$FF,$F7,$7F,$E9,$00,$06 
                  DC.B      $00,$08,$00,$02,$FF,$FC,$FF,$FC 
                  DC.B      '_',$FB,'a',$FC,$FF,$FF,'A',$FF 
                  DC.B      $1F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$8A,$00,$0B,$FF,$89,$FF,$F7 
                  DC.B      $FF,$F6,$92,'%',$DB,$A5,'m',$DA 
                  DC.B      $FF,$FF,$B6,$7F,$D5,$00,$F4,$80 
                  DC.B      'u',$80,$89,$80,$A8,$00,$03,$C3 
                  DC.B      $02,$B3,'1',$F3,$0E,$0F,$13,'p' 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$07,$00,$01,$00,$0F 
                  DC.B      $00,$00,$00,$0E,$FF,$FF,$FC,$00 
                  DC.B      $FF,$FF,$00,$00,$03,$FF,$82,$00 
                  DC.B      'g',$1F,$80,$1F,$00,$1F,$A4,$00 
                  DC.B      '@',$00,'{',$BF,$FF,$FF,$BF,$FF 
                  DC.B      $C4,'@',$9F,$80,$9F,$FF,$F0,$7F 
                  DC.B      'o',$FF,$FF,$80,$00,$00,$FF,$FC 
                  DC.B      $FF,'t',$FF,$8C,$00,'p',$00,$00 
                  DCB.W     4,0 
                  DC.B      'o',$F0,$02,$00,'?',$F0,$7F,$E0 
                  DC.B      '-',$E0,$00,$00,$00,$0F,$00,$09 
                  DC.B      $FF,$F6,$FF,$F9,$0F,$C0,$B0,$27 
                  DC.B      $00,$10,$FF,$FF,$7F,$E9,$00,$03 
                  DC.B      $00,$0C,$00,$01,$FF,$FE,$FF,$FE 
                  DC.B      $0F,$FB,$13,$FC,'?',$FF,$03,$FF 
                  DC.B      $0F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$86,$00,$0F,$FF,$8D,$FF,$F3 
                  DC.B      $FF,$FA,$92,'%',$DB,'5m',$DA
                  DC.B      $FF,$FF,$B6,$EF,$90,$00,$D5,$00 
                  DC.B      'U',$0C,$A9,$03,$EC,$04,$03,$F3 
                  DC.B      $01,$F0,$00,$0C,$FD,$FC,$01,$F3 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$00,$00,$0F,$00,$03,$00,$1F 
                  DC.B      $00,$00,$00,$1C,$FF,$CC,$F0,' ' 
                  DC.B      $FF,$E0,$00,$13,$0F,$E0,'G',$00 
                  DC.B      $C7,$1F,$80,$1F,'E',$1F,$80,$00 
                  DC.B      'd@',$FF,$FF,$BB,$BF,$DF,$FF
                  DC.B      'd@',$08,$00,$FF,$FF,$F7,$FF
                  DC.B      $FF,$FF,$08,$00,$01,'t',$FE,$88 
                  DC.B      $FF,$FC,$FF,$04,$00,$F8,$00,$00 
                  DCB.W     4,0 
                  DC.B      'U',$F8,$00,$00,'?',$F8,'?',$F0 
                  DC.B      $15,$F0,$00,$00,$00,$03,$00,$05 
                  DC.B      $FF,$FE,$FF,$F9,$07,$C0,$98,';' 
                  DC.B      $00,$14,$FF,$EF,$7F,$F9,$00,$01 
                  DC.B      $80,$0E,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $87,$FB,$0F,$FC,$9F,$FF,$0F,$FF 
                  DC.B      $0F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$C2,$00,$7F,$FF,$DD,$FF,$BF 
                  DC.B      $FF,$82,$92,'%',$DB,$A5,'m',$DA 
                  DC.B      $FF,$FF,$B6,$7F,$D4,$00,$D7,$FE 
                  DC.B      'T',$01,$A8,$00,$AB,$FE,$00,$00 
                  DC.B      '#',$FF,$DC,$00,$00,$00,$AF,$FF 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$1F,$00,$00,$00,'?' 
                  DC.B      $00,$00,$00,'?',$FF,$B3,$C0,$0C 
                  DC.B      $FF,$80,$00,'L?',$8C,$02,$00
                  DC.B      'N',$1F,'1',$FF,$B1,$FF,'H',$00 
                  DC.B      'd@',$FF,$FF,$DB,$BF,$BF,$FF
                  DC.B      'd@',$08,$00,$FF,$FF,$F7,$FF
                  DC.B      $FF,$FF,$08,$00,$02,$00,$FD,$FC 
                  DC.B      $FE,$FA,$FF,$04,$00,$F8,$00,$00 
                  DCB.W     4,0 
                  DC.B      'E',$F8,'@',$00,'?',$F8,'?',$F8 
                  DC.B      $05,$F8,$00,$00,$00,$06,$00,$04 
                  DC.B      $FF,$FB,$FF,$FD,$03,$E0,$9C,$1F 
                  DC.B      $00,$06,$FF,$FB,$7F,$FD,$00,$00 
                  DC.B      $C0,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $87,$FB,$0F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FC,$1E,$07,$EE,$FD,$FD,$FB,$F3 
                  DC.B      $F8,$03,$92,'%',$DB,'5m',$DA
                  DC.B      $FF,$FF,$B6,$EF,$93,$9F,$94,$FF 
                  DC.B      $14,$00,$E8,$1F,$EC,$00,'s',$FF 
                  DC.B      's',$FF,$8C,$00,'s',$FF,$08,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$01,$00,$02,$00,'O' 
                  DC.B      $00,'0',$00,$0F,$FF,'A',$00,$0E 
                  DC.B      $FF,$00,$00,$BE,$FF,'>',$8D,$00 
                  DC.B      'x',$1F,$00,$FF,$0A,$FF,'1',$00 
                  DC.B      '$@',$FF,$FF,$DB,$BF,$FF,$FF
                  DC.B      '$@',$08,$00,$FF,$FF,$F7,$FF
                  DC.B      $FF,$FF,$08,$00,$17,$FE,$EC,$00 
                  DC.B      $F7,$FE,$F8,$01,$03,$FE,$00,$00 
                  DC.B      $00,$00,$C0,$00,$00,$00,$80,$00 
                  DC.B      $01,'<@',$00,'?',$FC,'?',$F8
                  DC.B      $01,'8',$00,$00,$00,$02,$00,$00 
                  DC.B      $FF,$FF,$FF,$FD,$01,$E0,$9E,$1A 
                  DC.B      $00,$00,$FF,$FF,$7F,$FD,$00,$00 
                  DC.B      $E0,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $07,$FB,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F9,$FA,$06,$AF,$FF,$FD,$FF,'S' 
                  DC.B      $F8,$06,$92,'%',$92,$A5,'m',$DA 
                  DC.B      $FF,$FF,$FF,$7F,$80,$FF,$D5,$FF 
                  DC.B      'T',$00,$AA,$FF,$BE,$00,$F7,$FF 
                  DC.B      $F7,$FF,$08,$00,$F7,$FF,$08,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,'1',$00,$08,$00,'{' 
                  DC.B      $00,$04,$00,'{',$FE,$80,$00,$0F 
                  DC.B      $FE,$00,$01,$7F,$FE,$7F,'G',$81 
                  DC.B      $B8,$1F,$02,$7F,'�~',$82,$81
                  DC.B      $7F,$E8,$7F,$EF,$80,$1F,$FF,$F7 
                  DC.B      $FF,$F8,$08,$00,$FF,$FF,$F7,$FF 
                  DC.B      $FF,$FF,$08,$00,$BF,$FF,'`',$C0 
                  DC.B      $BF,$FF,$C0,$00,$1F,'?',$C0,$00 
                  DC.B      $00,$00,$D8,$00,' ',$00,$D0,$00 
                  DC.B      'A<@',$00,'?',$FC,$7F,$FC 
                  DC.B      $01,'<',$00,$00,$00,$02,$00,$00 
                  DC.B      $FF,$FF,$FF,$FD,$00,$E0,$9F,$18 
                  DC.B      $00,$02,$FF,$FF,$7F,$FD,$00,$00 
                  DC.B      $F0,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $07,$FB,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FD,'R',$02,$BA,$FF,$F9,$FD,'G' 
                  DC.B      $FA,$AF,$92,'%',$DB,'%m',$DA
                  DC.B      $FF,$FF,$B6,$FF,$11,$FF,$B5,$FF 
                  DC.B      $B4,$00,'K',$FF,$0E,$00,$F7,$FF 
                  DC.B      $F7,$FF,$08,$00,$F7,$FF,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,',',$00,$02,$00,'.' 
                  DC.B      $00,'Q',$00,'.',$FD,$00,$00,$8F 
                  DC.B      $FC,$80,$02,$7F,$FC,$FF,$1B,$80 
                  DC.B      $E4,$1F,$06,$7F,$E1,$7F,$E6,$80 
                  DC.B      '"@',$FF,$FF,$DD,$BF,$FF,$FF
                  DC.B      '"@',$1C,$02,$FF,$FD,$F7,$FE
                  DC.B      $EB,$FF,$1C,$00,$FF,$FF,$8F,$80 
                  DC.B      $FF,$FF,$00,$00,'p',$7F,$F0,$00 
                  DC.B      $00,$00,$F6,$00,$08,$00,$F4,$00 
                  DC.B      $00,$16,$08,$00,$7F,$FE,$07,$FC 
                  DC.B      'p',$14,$00,$00,$00,$02,$00,$00 
                  DC.B      $FF,$FF,$FF,$FD,$00,'p',$8F,$8A 
                  DC.B      $00,$02,$FF,$FD,$7F,$FF,$00,$00 
                  DC.B      $F8,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FB,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F5,'F',$0F,$F3,$FF,$F5,$F0,$0B 
                  DC.B      $FA,$BE,$92,'%',$92,'%m',$DA
                  DC.B      $FF,$FF,$FF,$FF,$C1,$FF,$D1,$FF 
                  DC.B      $D0,$00,$EF,$FF,$0E,$00,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,'f',$00,$19,$00,$FF 
                  DC.B      $00,$10,$00,'o',$FB,$00,$01,$CF 
                  DC.B      $F9,$C0,$04,'?',$F8,$BF,$1A,$80 
                  DC.B      $E0,$1F,$02,$7F,$E5,$7F,$E2,$80 
                  DC.B      '"@',$EF,$FF,$DD,$BF,$FF,$FF
                  DC.B      '2@',$1C,$07,$FF,$FB,$E7,$FF
                  DC.B      $FB,$FC,$1C,$00,$FF,$FF,$7F,$00 
                  DC.B      $FF,$FF,$00,$00,$80,$FF,$F8,$00 
                  DC.B      $00,$00,$FB,$00,$04,$00,$FA,$00 
                  DC.B      ' ',$16,$01,$00,$7F,$FE,$00,$FE 
                  DC.B      $1E,$16,$00,$00,$00,$02,$00,$00 
                  DC.B      $FF,$FF,$FF,$FD,$00,'0',$8F,$CD 
                  DC.B      $80,$00,$FF,$FF,$7F,$FF,$00,$00 
                  DC.B      $FC,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$FB,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F5,'N',$0D,'F',$FD,'O',$F2,$B1 
                  DC.B      $FA,$B9,$92,'&',$DB,$27,'m',$D9 
                  DC.B      $FF,$FE,$B6,$FE,$E1,$FF,$F4,$0B 
                  DC.B      $F4,$00,$EB,$80,$0E,$00,$ED,'I' 
                  DC.B      $FF,$FF,$00,$00,$00,$01,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,'o',$00,$08,$01,'o' 
                  DC.B      $00,$08,$00,$E7,$F4,$04,$0B,$D3 
                  DC.B      $FB,$D0,$00,$AF,$FB,$7F,$06,$80 
                  DC.B      $F9,$1F,$03,$7F,$F8,$FF,$FA,$00 
                  DC.B      $12,$7F,$DF,$FF,$ED,$80,$FF,$FF 
                  DC.B      '2',$7F,$FE,$C7,$FE,$C4,'k?'
                  DC.B      $95,$F8,$FF,$FB,$FF,$FF,$FF,$00 
                  DC.B      $FF,$FF,$00,$00,$00,$FF,$FE,$00 
                  DC.B      $00,$00,$FE,$80,$01,$00,$FE,$80 
                  DC.B      $08,$04,$00,'A',$1F,$FE,$00,'>' 
                  DC.B      $07,$85,$00,$00,$00,$03,$00,$01 
                  DC.B      $FF,$FE,$FF,$FD,$00,$10,$CF,$EF 
                  DC.B      '@',$00,$BF,$FF,$7F,$FF,$00,$00 
                  DC.B      $FE,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,'{',$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F1,$1F,$0D,'O',$FD,'_',$F2,$A0 
                  DC.B      $FE,$F0,$92,'%',$92,$27,$ED,$DB 
                  DC.B      $7F,$FD,$7F,$FC,$E0,$C0,$EF,'`' 
                  DC.B      $EF,$E0,$F7,$80,$00,$10,$00,$01 
                  DC.B      $00,$03,$00,$00,$00,$01,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$01,$E7,$00,$08,$01,$EF 
                  DC.B      $02,$00,$05,$EF,$F4,'F',$01,$E9 
                  DC.B      $F1,$E0,$0A,$1F,$F2,$BF,$07,$80 
                  DC.B      $F8,$1F,$03,$7F,$FC,$FF,$FF,$00 
                  DC.B      $1B,$A0,$DB,$BF,$EC,$7F,$F7,$DF 
                  DC.B      '?',$E0,'&',$1F,$FF,$E9,$DB,$FF 
                  DC.B      $FD,$F0,'&',$06,$FF,$FF,$FA,$00 
                  DC.B      $FF,$FF,$00,$00,$05,$FF,$FF,$00 
                  DC.B      $00,$00,$FF,'@',$00,$80,$FF,'@' 
                  DC.B      $03,$00,$00,$11,$03,$FE,$00,$0E 
                  DC.B      $00,$E0,$00,$00,$00,$03,$00,$01 
                  DC.B      $FF,$FE,$FF,$FD,$00,$08,'O',$F7 
                  DC.B      $C0,$00,$BF,$FF,$7F,$FF,$00,$00 
                  DC.B      $FF,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F4,'_',$05,'N',$F5,'_',$FA,$A0 
                  DC.B      $FB,$B1,$FE,$7F,$D1,$FF,$FF,$FF 
                  DC.B      $00,$7F,'/',$80,$F1,$E0,$F8,$BF 
                  DC.B      $F9,$F0,$F7,'@',$06,$0F,$00,$01 
                  DC.B      $FF,$FF,$00,$00,$00,$01,$FF,$FC 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$03,$FF,$00,$10,$03,$FF 
                  DC.B      $04,$10,$03,$EF,$E8,$0F,$10,$D0 
                  DC.B      $F0,$C0,$07,'?',$F7,$7F,$9F,$83 
                  DC.B      '`',$1F,$03,'~',$FC,$FD,$FF,$03 
                  DC.B      $FD,$00,$FD,$FF,$03,$FF,$FE,$FF 
                  DC.B      $FF,$00,'f,',$FF,$D2,$DB,$EE
                  DC.B      $BD,$F1,'f',$0E,$FF,$FF,'u',$00 
                  DC.B      $FF,$FF,$00,$00,$8A,$FF,$FF,$80 
                  DC.B      $00,$00,$FF,$A0,$00,'@',$FF,$80 
                  DC.B      $00,$81,$00,$04,$03,$FE,$00,$03 
                  DC.B      $03,'x',$00,$00,$00,$02,$00,$00 
                  DC.B      $FF,$FF,$FF,$FD,$00,$00,$87,$FF 
                  DC.B      $80,$00,$7F,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$8F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F1,'?',$0D,'_',$FD,$7F,$F2,$80 
                  DC.B      $FE,$E0,$FF,$8F,$A0,'o',$FF,$EF 
                  DC.B      $00,$1F,'_',$C0,$F3,'_',$F5,'/' 
                  DC.B      $F7,'p',$F8,$DF,$02,$A0,$FF,$FD 
                  DC.B      $FF,$FF,$00,$00,$FF,$FD,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$03,$EF,$00,$10,$03,$FF 
                  DC.B      $04,$00,$03,$FF,$E8,$1F,$00,'`' 
                  DC.B      $E0,'@',$17,$BF,$E7,$FF,$FB,$8A 
                  DC.B      $00,$1A,$07,'}',$F8,$F7,$FF,$0F 
                  DC.B      $08,$00,$EF,$FF,$FF,$FF,$F7,$FF 
                  DC.B      $18,$00,'b',$18,$FB,$E9,$BD,$D9 
                  DC.B      $DF,$E6,'f',$11,$FF,$FF,$EA,$00 
                  DC.B      $FF,$FF,$00,$00,$15,$FF,$FE,$C0 
                  DC.B      $01,$00,$FF,$E0,$00,$00,$FF,$E0 
                  DC.B      $02,'P',$02,$01,$03,$FF,$00,$00 
                  DC.B      $01,$8E,$00,$00,$00,$02,$00,$00 
                  DC.B      $FF,$FF,$FF,$FD,$00,$00,$07,$FB 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$CF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F4,'?',$05,';',$F5,'?',$FA,$C0 
                  DC.B      $FB,$C4,$FE,$D3,'A+',$FF,$FB
                  DC.B      $00,$07,$BF,$F8,$F9,$DD,$FE,'O' 
                  DC.B      $FF,$D0,$F8,'0',$03,$A0,'H',$01 
                  DC.B      $FF,$FF,$00,$00,$00,$01,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$FF,$00,$00,$04,$FF 
                  DC.B      $01,$00,$02,$FF,$F0,'7',$00,$80 
                  DC.B      $E0,$80,$0F,$7F,$EF,$FF,$BD,$84 
                  DC.B      $06,$17,'7',$7F,$8C,$FB,$CB,$0C 
                  DC.B      'P',$00,$DF,$FF,$FF,$FF,$AF,$FF 
                  DC.B      'p',$00,'Fy',$FF,$BC,$BD,$FD
                  DC.B      $FB,$C2,'F',$05,$FF,$FF,$D4,$00 
                  DC.B      $FF,$FF,$00,$00,'+',$FF,$FE,'@' 
                  DC.B      $00,$00,$FE,'P',$01,$A0,$FE,'@' 
                  DC.B      $00,$04,$00,$00,$07,$CF,$00,$00 
                  DC.B      $03,$83,$00,$00,$00,$07,$00,$07 
                  DC.B      $FF,$FA,$FF,$FD,$00,$00,$07,$F9 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$EF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F1,$FF,$0C,'>',$FD,$FF,$F2,$00 
                  DC.B      $FF,$C1,$FF,$A0,$80,'^',$FF,$FE 
                  DC.B      $00,$01,$7F,$FC,$F9,$DF,$FA,$0F 
                  DC.B      $FB,$D0,$FC,'?',$03,$E0,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$7F,$00,$00,$01,$7F 
                  DC.B      $00,$00,$00,$FF,$D0,$27,' ',$C8 
                  DC.B      $E0,$88,$0F,'w',$EF,$F7,$F5,$C0 
                  DC.B      $06,$1F,'o',$1F,$94,$BF,$9B,'`' 
                  DC.B      $80,$00,$BF,$FF,$FF,$FF,$7F,$FF 
                  DC.B      $C0,$00,$C2,'=',$FF,$D8,$BD,$BD 
                  DC.B      $7F,$C2,$C2,'%',$FF,$FF,$A8,$00 
                  DC.B      $FF,$FF,$00,$00,'W',$FF,$FE,' ' 
                  DC.B      $01,'@',$FF,'p',$00,$80,$FF,'p' 
                  DC.B      $0A,$01,$04,$00,$0E,$C3,$01,$00 
                  DC.B      $0E,$80,$00,$00,$00,$07,$00,$05 
                  DC.B      $FF,$FA,$FF,$FD,$00,$00,$03,$FC 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F1,$FF,$01,$FD,$F1,$FF,$FE,$00 
                  DC.B      $FE,$02,$FF,$D0,' /',$FF,$FF
                  DC.B      $00,$00,$DF,$FE,'x^{ž'
                  DC.B      '{',$D1,$FC,$27,$03,$E0,'m',$FF 
                  DC.B      $DB,$C3,$00,$00,'I™ ',$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,'~',$00,$01,$00,$FF 
                  DC.B      $00,$00,$00,$7F,$D0,'O',$01,$10 
                  DC.B      $C1,$10,'.',$EF,$CF,$EF,'}',$A1 
                  DC.B      $0E,$1F,'o',$1F,$1C,$DE,$93,'a' 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$C3,'|',$FF,$D9,'}',$FD 
                  DC.B      $BE,$82,$C3,'%',$FF,$FF,$14,$00 
                  DC.B      $FF,$FF,$00,$00,$EB,$FF,$FE,' ' 
                  DC.B      $01,$80,$FF,$A0,$00,'P',$FF,$A0 
                  DC.B      '7',$00,'.',$00,$7F,'@ ',$80
                  DC.B      $19,$00,$00,$00,$00,$05,$00,$07 
                  DC.B      $FF,$FA,$FF,$FD,$00,$00,$03,$FD 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F3,$FF,$01,$BE,$F3,$FF,$FC,$00 
                  DC.B      $FE,'A',$FE,$E8,$81,$17,$FF,$FF 
                  DC.B      $00,$00,$7F,$FF,'8',$1B,$BA,$CF 
                  DC.B      $BA,$D0,'}3',$02,$E4,'$',$E7
                  DC.B      $FF,$BD,$00,$00,'$',$C3,$DB,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,'~',$00,$00,$00,'~' 
                  DC.B      $00,$01,$00,'~',$E0,$1F,$00,$A0 
                  DC.B      $C0,' ',$1F,$DF,$DF,$DF,$ED,$80 
                  DC.B      $1E,'_',$EF,'?',$1C,$FF,$13,'@' 
                  DC.B      $00,$00,$FF,$FE,$FF,$FF,$FF,$FF 
                  DC.B      $00,$01,$83,'|',$FF,$BA,'~',$FE 
                  DC.B      $FD,$81,$83,'F?',$FF,'H',$00
                  DC.B      $7F,$FF,$80,$00,'w',$FF,$FE,$C0 
                  DC.B      $00,'0',$FE,$F0,$01,$00,$FE,$F0 
                  DC.B      '`',$80,'Y',$00,'y',$A0,'F@'
                  DC.B      '9',$80,$00,$00,$00,$02,$00,$02 
                  DC.B      $FF,$FD,$FF,$FF,$00,$00,$03,$FD 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $F3,$FF,$1F,'5',$FF,$FF,$EC,$00 
                  DC.B      $E0,$CA,$FF,$B4,$00,'K',$FF,$FF 
                  DC.B      $00,$00,$FF,$FE,$18,$13,$DA,$DF 
                  DC.B      $DA,$D0,'=#',$82,'d',$FF,$DB
                  DC.B      $FF,$BD,$00,$00,$FF,$99,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,'>',$00,$00,$00,'>' 
                  DC.B      $00,'A',$00,'>',$A0,$9E,'C@'
                  DC.B      $C0,'@',$1F,$BE,$DF,$BF,$F8,$80 
                  DC.B      $1B,'_',$DB,'?<',$FF,'"@' 
                  DC.B      $00,$B9,$FF,$B9,$FF,$C6,$FF,$7F 
                  DC.B      $00,$FF,$B9,'|',$C7,$BA,$FE,$FE 
                  DC.B      $7F,$81,$81,'G',$0F,$FF,$10,$00 
                  DC.B      $1F,$FF,$E0,$00,$9F,$FF,$F8,$C0 
                  DC.B      $05,'0',$FD,$F0,$02,$00,$FD,$F0 
                  DC.B      $06,$00,'l@',$EE,'@',$11,$A0
                  DC.B      'j@',$00,$00,$00,$00,$00,$00
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$03,$FC 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      '?',$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $8F,$BF,$F3,'~',$FF,$FF,'|',$00 
                  DC.B      $00,$C1,$FF,$E8,'@',$17,$FF,$FF 
                  DC.B      $00,$00,$BF,$FF,$00,$03,$C2,$DE 
                  DC.B      $C2,$D1,'="',$02,'|',$FF,$FF
                  DC.B      '?',$DB,$C0,$00,'?',$99,$00,$00 
                  DC.B      ' ',$00,$A0,$00,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,'>',$00,$00,$00,'~' 
                  DC.B      $00,$01,$00,'~',$A3,$CF,$00,$00 
                  DC.B      $80,$01,'_',$FE,$9F,$FE,$DA,$80 
                  DC.B      '<_',$DE,'?9',$FF,'&@'
                  DC.B      $80,$17,$FF,$F7,$FF,$F8,$FF,$EF 
                  DC.B      $A0,$1F,'E',$FA,$BB,$BF,$C6,$FF 
                  DC.B      $FF,$00,$01,$C7,$00,$7F,$01,$80 
                  DC.B      $01,$FF,$FE,$00,$E1,$FF,$81,$80 
                  DC.B      'bp',$E3,$F0,$1C,$00,$E3,$C0
                  DC.B      $B3,$80,$F4,' ',$F7,$B0,$88,'@' 
                  DC.B      'G',$A0,$00,$00,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$01,$FE 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $1F,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$01,$FF,$FF,$FF,$FE,$FF,$FE 
                  DC.B      $FF,$BF,'(}',$FF,$FF,$D4,$00
                  DC.B      $03,$C2,$FF,$F4,$00,$0B,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$00,$0E,$E2,'N' 
                  DC.B      $E2,'B',$1D,$BF,$82,'p?',$FF
                  DC.B      $FF,$BD,$E0,$00,'?Z',$80,$00
                  DC.B      '0',$00,$90,$00,$00,$00,' ',$00 
                  DC.B      $80,$00,$00,'>',$00,$00,$00,'~' 
                  DC.B      $00,$01,$00,'>',$C3,$ED,$04,$00 
                  DC.B      $80,$01,'?',$FC,$BF,$FE,$F3,$80 
                  DC.B      '4',$1F,$B6,'?y',$FF,'F',$C0
                  DC.B      $01,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $05,$00,$11,$F8,$C7,$B2,$BA,'z' 
                  DC.B      $EF,$85,$11,$CF,$00,$00,$06,$00 
                  DC.B      $06,$00,$F9,$FF,$FE,$00,$0F,$00 
                  DC.B      $10,$F0,$1F,$F1,$E0,$00,$1F,$C0 
                  DC.B      '9',$C0,$E2,' ',$FB,$F0,$04,$00 
                  DC.B      $DB,$F0,$00,$00,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$01,$FE 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $07,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FE 
                  DC.B      $FF,'?',$AA,$FA,$FF,$FF,'T',$00 
                  DC.B      $01,$C5,$FF,$A8,$00,'W',$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$00,$07,$D2,$8B 
                  DC.B      $D2,$8F,'-x',$02,$F4,$9F,$DB
                  DC.B      $7F,$BD,$F0,$00,$1F,$18,$E0,$00 
                  DC.B      '(',$00,$A8,$00,$10,$00,$18,$00 
                  DC.B      $80,$00,$00,$1E,$00,$00,$00,$1E 
                  DC.B      $00,'!',$00,$1E,$CC,$FB,$10,$00 
                  DC.B      $80,$03,'<',$F8,$BF,$FC,$F7,$00 
                  DC.B      'x',$DF,'~',$7F,$F1,$BF,$8E,$C0 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $80,$00,'8x',$A3,$B0,$FF,$F8
                  DC.B      $C7,$87,$18,'O',$0F,$FF,$10,$00 
                  DC.B      $1F,$FF,$E0,$00,$FF,$FF,$FE,$01 
                  DC.B      $01,$F1,$FF,$F1,$00,$01,$FF,$80 
                  DC.B      $BC,$E0,'A',$00,$FD,$E0,$02,$10 
                  DC.B      $FD,$E0,$00,$00,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$01,$FE 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FE 
                  DC.B      $D5,'?',$AE,$FC,$FF,$FF,'P',$00 
                  DC.B      '+',$C3,$FF,$F4,$80,$0B,$FF,$FF 
                  DC.B      $00,$00,$7F,$FE,$00,$07,$EB,$FB 
                  DC.B      $EB,$F7,$14,$F8,$83,$04,$CF,$FF 
                  DC.B      $BF,$FF,$F8,$00,$0F,$FF,'p',$00 
                  DC.B      '(',$00,$A8,$00,$10,$00,'0',$00 
                  DC.B      $80,$00,$00,$1C,$00,$02,$00,'>' 
                  DC.B      $00,$01,$00,'>',$B0,'?',$00,$00 
                  DC.B      $80,$07,'p8',$BF,$F8,'e@' 
                  DC.B      $EA,$1F,'n?',$F0,$BF,$8D,$CE
                  DC.B      $00,$09,$FF,$F6,$FF,$F9,$FF,$FF 
                  DC.B      $00,'@|x',$C3,$FC,$FF,$FC 
                  DC.B      $83,$83,'<',$07,$1F,$FF,' ',$00 
                  DC.B      '?',$FF,$C0,$00,$FF,$FF,$FC,$10 
                  DC.B      $03,$F1,$FF,$F3,$00,$10,$FF,$01 
                  DC.B      $9E,$F0,'`',$00,$FE,$F0,$01,$00 
                  DC.B      $FE,$F0,$00,$00,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$01,$FE 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$0F,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $00,$1B,$8F,$FC,$0F,$FF,$8F,$FF 
                  DC.B      $8F,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FE 
                  DC.B      'U',$FF,$90,$BA,$D5,$FF,'o@'
                  DC.B      $AA,$05,$FF,$E8,$00,$17,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$00,'S',$D3,$FB 
                  DC.B      $D3,'S-',$AC,$00,$04,$C0,$00
                  DC.B      $B7,$FF,$F0,$00,$08,$00,'w',$FF 
                  DC.B      $14,$00,$14,$00,$08,$00,$0C,$00 
                  DC.B      $00,$00,$00,$08,$00,$05,$00,$0D 
                  DC.B      $00,$12,$00,$0D,$D0,$97,$00,$00 
                  DC.B      $C0,$06,' ',$11,$CF,$F9,$CD,$80 
                  DC.B      $D0,$1F,$DC,$7F,$E2,$7F,$0D,$8E 
                  DC.B      $06,$07,$FF,$FC,$FF,$F7,$FF,$F8 
                  DC.B      $FF,$03,'|<',$03,$DA,$FF,$BE
                  DC.B      $83,$C1,'|',$27,'?',$FF,'@',$00 
                  DC.B      $7F,$FF,$80,$00,$FF,$FF,$F8,$03 
                  DC.B      $07,$E2,$FF,$E3,$00,$02,$FE,$11 
                  DC.B      $CF,$F0,'0',$00,$FF,$F0,$00,$00 
                  DC.B      $FF,$F0,$00,$00,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      ' ',$00,'?',$FF,$DF,$FF,$DF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$03 
                  DC.B      $00,$04,$FF,$FF,$FF,$FB,$FF,$FB 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FE,'U',$7F,'U',$FC 
                  DC.B      'U',$FF,$AA,$00,$AA,$83,$FF,$B0 
                  DC.B      $00,'O',$FF,$FF,$00,$00,$FF,$FE 
                  DC.B      $01,$03,$EB,$F9,$EB,'S',$14,$AC 
                  DC.B      $00,'V',$E4,$00,$DB,$FE,$FC,$00 
                  DC.B      $00,$00,';',$FE,$14,$00,$14,$00 
                  DC.B      $08,$00,$18,$00,$00,$00,$00,$01 
                  DC.B      $00,$02,$00,$03,$00,$0C,$00,$03 
                  DC.B      $E4,$8F,$00,$01,$E0,$0D,$18,$03 
                  DC.B      $E3,$F2,$8A,$0B,$B4,$DF,$BD,$FF 
                  DC.B      $C3,$FF,$18,$CF,$00,$07,$FF,$F8 
                  DC.B      $FF,$F7,$FF,$F8,$FF,$07,'|',$7F 
                  DC.B      $03,$BD,$7F,$FF,$83,$C0,'|',$02 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$E0,'!',$1F,$E3,$FF,$F7 
                  DC.B      $00,' ',$F8,$02,$9F,$E0,'x',$00 
                  DC.B      $FF,$E0,$18,$10,$E7,$E0,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$00,'?',$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FE,'U?QZ'
                  DC.B      'U',$7F,$AE,$80,$AA,$E5,$FF,$E8 
                  DC.B      $00,$17,$FF,$FF,$00,$00,$FF,$FD 
                  DC.B      $00,$09,$D3,$AB,$D3,$0B,',',$F4 
                  DC.B      $01,'V',$E7,$FE,$DF,$FF,$FC,$00 
                  DC.B      $07,$FE,'8',$01,$0A,$00,$88,$00 
                  DC.B      $06,$00,$04,$00,$80,$00,$00,$03 
                  DC.B      $00,$00,$00,$07,$00,$00,$00,$07 
                  DC.B      $FD,$8F,$00,$03,$FC,$0B,$02,$07 
                  DC.B      $FC,$F4,$14,$00,'h',$DF,'{',$FF 
                  DC.B      $87,$FF,'0',$C5,$0D,$07,$F3,$F8 
                  DC.B      $FF,$F7,$FF,$F8,$FF,$27,$FC,$1F 
                  DC.B      $03,$EE,$FF,$DF,$03,$E0,$FC,$11 
                  DC.B      $FF,$FF,$80,$00,$FF,$FF,$00,$00 
                  DC.B      $7F,$FF,$C0,$07,'?',$C7,$FF,$C7 
                  DC.B      $00,$04,$F0,' ',$07,$C0,$E4,$00 
                  DC.B      $FF,$D0,$04,' ',$FB,$C0,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$00,'?',$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$01,$FF,$FF 
                  DC.B      $FF,$FE,$FF,$FE,$05,$1F,'Q',$1C 
                  DC.B      'U',$1F,$AA,$E0,$FE,$E3,$FE,$D0 
                  DC.B      $81,'/',$FF,$FF,$00,$00,$7F,$FE 
                  DC.B      $00,'!',$A2,$A8,$A0,'!_',$DE
                  DC.B      $01,'W',$E3,$7F,$99,$FF,$F8,$00 
                  DC.B      $04,$7F,'p',$00,$01,$00,$80,$00 
                  DC.B      $0F,$00,$00,$00,$8E,$00,$00,$00 
                  DC.B      $00,$00,$00,$02,$00,$01,$00,$02 
                  DC.B      $FF,$8E,$00,$06,$FE,$06,$00,$0F 
                  DC.B      $FF,'x(',$00,$D6,$FF,$F7,$FF
                  DC.B      $0F,$FF,'f',$E4,'4',$01,$CF,$FE 
                  DC.B      $FF,$FB,$FF,$FC,'~',$03,$C6,'/' 
                  DC.B      '9',$D5,$FF,$EF,$03,$F0,$FC,$0A 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,'O',$FF,$CE,$FF,$EF 
                  DC.B      $00,'H',$C0,$01,$27,$80,$E4,$00 
                  DC.B      $FB,$A0,' @',$DF,$80,$00,$00
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$00,'?',$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FE,$05,$1F,$05,$08 
                  DC.B      $05,$1F,$FA,$E0,$FA,$F7,$FB,$A0 
                  DC.B      $04,'_',$FF,$FF,$00,$00,$FF,$FC 
                  DC.B      $00,$89,$C6,$A3,$C4,$8B,';t'
                  DC.B      $01,'^',$E2,'?',$9F,$FF,$FC,$00 
                  DC.B      $02,'?q',$C0,$0C,'0',$80,'P'
                  DC.B      $0F,'p',$00,$90,$83,'h',$00,$00 
                  DC.B      $00,$00,$00,$01,$00,$00,$00,$00 
                  DC.B      '?0',$00,$83,$BE,$83,'@|' 
                  DC.B      $BF,$B1,$D0,$04,$06,$9F,$CF,$FF 
                  DC.B      '?',$FF,$C6,$84,'  ',$FF,$DD
                  DC.B      $FF,$E3,$FF,$FE,'j',$01,$8D,$17 
                  DC.B      'r',$E8,$FD,$F7,$03,$F8,$FC,$07 
                  DC.B      $FF,$F8,$00,$07,$FF,$FF,$00,$00 
                  DC.B      $FF,$FE,$00,$9F,$FF,$9E,$FF,$DF 
                  DC.B      $00,$90,$00,$01,$07,$00,$C0,$00 
                  DC.B      $F7,'@',$00,$80,$FB,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$7F 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $80,$00,'?',$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$01,$FF,$FF 
                  DC.B      $FF,$FE,$FF,$FE,$04,$0F,$01,$04 
                  DC.B      $05,$0F,$FA,$F0,$FF,$FB,$FF,'P' 
                  DC.B      $00,$AF,$FF,$FF,$00,$00,$FF,$F8 
                  DC.B      $00,$27,$8A,$AB,$88,'/w',$D0
                  DC.B      $05,'\',$E1,$FF,$9D,$FF,$FE,$00 
                  DC.B      $01,$FF,'r',$00,$02,$1C,$80,'$' 
                  DC.B      $07,$BC,$00,'D',$85,$BA,$00,$00 
                  DCB.W     4,0 
                  DC.B      $1E,$81,$00,'~_',$FF,'!',$00
                  DC.B      '^',$FF,'`',$04,$16,$9F,$1F,$FF 
                  DC.B      $DF,$FF,'6',$84,$02,'_',$FD,$B8 
                  DC.B      $FF,$DF,$FF,$E0,'J',$07,$1C,$88 
                  DC.B      $EB,'u',$FE,$FB,$01,$FE,$F6,$01 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$C0,$02,'>',$FE,'-',$FE,$BF 
                  DC.B      $02,' ',$01,$13,'L',$00,$CC,$00 
                  DC.B      $F0,$80,'C',$00,$BC,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$7F 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $80,$00,'?',$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$01,$FF,$FF 
                  DC.B      $FF,$FE,$FF,$FE,$00,$07,$04,$00 
                  DC.B      $04,$07,$FB,$F8,$FF,$FF,$EA,$80 
                  DC.B      $15,$7F,$FF,$FF,$00,$00,$FF,$F8 
                  DC.B      $00,$9F,$1A,$AE,$10,$BF,$EF,'@' 
                  DC.B      $05,'q',$E3,$FF,$1F,$FF,$FE,$00 
                  DC.B      $03,$FF,$F0,$00,$05,$0E,$80,$1E 
                  DC.B      $07,$DE,$00,'"',$86,$D1,$00,$00 
                  DCB.W     4,0 
                  DC.B      $06,$E1,$00,$1C,'7',$FC,$09,$03 
                  DC.B      $16,$F8,$80,$00,$04,$9F,$7F,$FF 
                  DC.B      $7F,$FF,$84,$80,$0A,$7F,$F7,$B0 
                  DC.B      $FF,$FF,$FF,$C0,'J',$0F,'?@'
                  DC.B      $C8,$BE,$FF,'}',$00,$FF,$F7,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$C0,$04,'~',$FC,'Y',$FE,$7F 
                  DC.B      $04,'@',$00,$27,$08,$00,$88,$00 
                  DC.B      $E4,$00,$00,$00,$F8,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$7F 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,'$' 
                  DC.B      $80,'$?',$DB,$FF,$FF,$FF,$E7
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$12,$03 
                  DC.B      $12,$00,$ED,$FF,$FF,$FF,$F3,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FE,$00,$01,$FF,$FF 
                  DC.B      $FF,$FE,$FF,$FF,$00,$87,$03,$F8 
                  DC.B      $03,$FF,$FC,'|',$FF,$03,$F4,$00 
                  DC.B      $0B,$FE,$FF,$FE,$00,$01,$FF,$E0 
                  DC.B      $0A,$FF,'*',$B8,'*',$FF,$D5,$00 
                  DC.B      $15,'G',$E3,$FF,$1F,$FF,$FE,$00 
                  DC.B      $02,$01,$F0,$00,$07,$FF,$80,$0C 
                  DC.B      $07,$FF,$00,$00,$87,$F3,$80,$00 
                  DC.B      $80,$00,$C0,$01,$80,$00,$00,$00 
                  DC.B      '=',$E8,$00,$10,$BF,$F7,'B',$07 
                  DC.B      $BD,$E8,$00,$00,$00,$9F,$FF,$FF 
                  DC.B      $FF,$FF,$00,$80,$00,'_',$FF,$A0 
                  DC.B      $FF,$DF,$FF,$E0,'H',$1F,'?',$A1 
                  DC.B      $C9,'^',$FF,$BF,$00,$7F,$F6,$80 
                  DC.B      $00,$00,$7F,$FF,$FF,$FF,$80,$00 
                  DC.B      $7F,$FC,$00,$FC,$F8,$B3,$FD,$FF 
                  DC.B      $00,$80,$00,'O',$08,$00,$88,$00 
                  DC.B      $E0,$00,$00,$00,$F8,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$7F 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$1A 
                  DC.B      $80,$1A,'?',$FD,$FF,$E7,$FF,$C3 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,',',$03 
                  DC.B      ',',$00,$DF,$FF,$F3,$FF,$E1,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$08,$7F,'?',$AA 
                  DC.B      '?',$FF,$C7,$D4,$F0,$01,$C0,$00 
                  DC.B      '?',$F0,$FF,$F0,$00,$0F,$FF,$00 
                  DC.B      $03,$FF,'J',$E0,'C',$FF,$BC,$00 
                  DC.B      '5',$1F,$C1,$FD,'=',$FF,$FE,$00 
                  DC.B      $01,$FD,$F2,$00,$07,$FF,$81,$FE 
                  DC.B      $07,$FF,$00,$00,$86,$01,$E0,$00 
                  DC.B      $00,$00,$EC,$03,$10,$00,$E8,$01 
                  DC.B      $FD,$9C,$F2,'`',$FD,$E3,$02,$0B 
                  DC.B      $0D,$E4,$00,$00,$00,$9F,$FF,$FF 
                  DC.B      $FF,$FF,$00,$80,$08,$27,$FF,$D8 
                  DC.B      $FF,$E7,$FF,$F8,'H',$07,$7F,$D0 
                  DC.B      $99,$AE,$FF,$DD,$00,'?',$E6,'@' 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$01,$FC,$F9,'s',$FF,$FF 
                  DC.B      $01,$00,$C0,$8E,$10,$00,$90,$00 
                  DC.B      $C8,$00,$00,$00,'0',$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$7F 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$1D 
                  DC.B      $C0,$1D,'?',$FE,$FF,$E3,$FF,$C1 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,'\',$03 
                  DC.B      '\',$00,$BF,$FF,$E3,$FF,$C1,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$87,$C4,$FA,$BB 
                  DC.B      $FF,$EE,'}U',$00,'* ',$01 
                  DC.B      '_',$C6,$7F,$C7,$80,'8',$E0,$01 
                  DC.B      $FF,$FE,$00,$01,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$03,'}',$FF,$FF,$FC,$00 
                  DC.B      $00,'}',$F0,$00,$07,$FE,$80,'}' 
                  DC.B      $07,$FF,$00,$00,$87,$83,$FC,$01 
                  DC.B      'p',$01,$FD,$87,$02,$00,$8D,$02 
                  DC.B      $FD,$8C,$E6,'p',$FD,$F3,$02,$07 
                  DC.B      $19,$C0,$00,$00,$00,$1F,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$E0,$04,$BF,$FB 
                  DC.B      $FF,$FD,$FF,$FE,$E0,$01,$FF,$F3 
                  DC.B      '0',$CC,$FF,$F3,$00,$1E,$CF,'!' 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$07,$F8,$F9,$E7,$FF,$FF 
                  DC.B      $00,$00,$FE,$1E,$80,$00,$80,$00 
                  DC.B      $B0,$00,$80,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,'?' 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$1E 
                  DC.B      $C0,$1E,'?',$FF,$FF,$E1,$FF,$C0 
                  DC.B      $80,$00,$80,$00,$7F,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$BC,$03,$BC,$00,$7F,$FF 
                  DC.B      $C3,$FF,$81,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,$FE 
                  DC.B      $00,$01,$FF,$FF,$FF,$C3,$FF,$FE 
                  DC.B      '}P',$AA,$CD,$FF,$D8,$D5,'7'
                  DC.B      $02,$AA,$FF,$FF,'@',$00,$FF,$FF 
                  DC.B      $00,$00,$BF,$FF,$FF,$E8,$00,$17 
                  DC.B      $FF,$FF,$00,$00,$FF,$FE,$00,$FD 
                  DC.B      '[',$FF,$18,$00,$E4,'}',$E3,$00 
                  DC.B      $00,$FE,$87,$01,$07,$FF,$00,$00 
                  DC.B      $87,$FF,$7F,$83,$9E,$03,$FF,$BF 
                  DC.B      $00,'@',$E1,$A4,$FB,$84,$C6,'x' 
                  DC.B      $FB,$FB,$04,$03,'9',$C0,$00,$00 
                  DC.B      $00,$1F,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      '@',$0B,$BF,$F6,$FF,$FB,$FF,$FC 
                  DC.B      $E0,$01,$FF,$FF,'`p',$FF,$FF
                  DC.B      $00,$00,$9F,$8F,$FF,$FF,$FC,$00 
                  DC.B      $FF,$FF,$00,$00,$03,$FF,$FF,$F0 
                  DC.B      $01,$8F,$FF,$FF,$00,$00,$FE,'|' 
                  DCB.W     2,0 
                  DC.B      $80,$00,$00,$00,$80,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,'?' 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$1F 
                  DC.B      $C0,$1F,'?',$FF,$FF,$E0,$FF,$C0 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$7F,$FF,'|',$03 
                  DC.B      '|',$00,$FF,$FF,$83,$FF,$01,$FF 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$19,$FF,$FF 
                  DC.B      $FF,$82,$FF,$E4,$C5,'A',$B5,$15 
                  DC.B      $E5,'EZ',$BA,'*',$EE,$FF,$EF
                  DC.B      $D0,$10,$FF,$FF,$00,$00,'/',$FF 
                  DC.B      $FF,'P',$00,$AD,$FF,$FC,$00,$03 
                  DC.B      $FF,$FB,$00,$FD,$F1,$FF,$00,$00 
                  DC.B      $F0,'}',$F1,$00,$00,$BE,$87,$81 
                  DC.B      $07,$BF,$00,$C0,$86,'?',$7F,$E7 
                  DC.B      $07,$83,$7F,$EF,$80,$10,'xl'
                  DC.B      $FB,$82,$8C,'x',$FB,$F9,$04,$05 
                  DC.B      's',$E2,$00,$00,$00,$1F,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$A0,$0F,$FF,$F4 
                  DC.B      $FF,$FF,$FF,$F8,$E0,$03,$FF,$FF 
                  DC.B      $00,'9',$FF,$FF,$00,$00,$FF,$C6 
                  DC.B      $FF,$FF,$F0,$00,$FF,$FF,$00,$00 
                  DC.B      $0F,$FF,$FF,$E1,$00,$1F,$FF,$FF 
                  DC.B      $00,$01,$FF,$FC,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,'?' 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$1F 
                  DC.B      $C0,$1F,'?',$FF,$FF,$E0,$FF,$C0 
                  DC.B      '@',$01,'@',$01,$BF,$FE,$FF,$FF 
                  DC.B      $7F,$FF,'|',$03,'|',$00,$FF,$FF 
                  DC.B      $83,$FF,$01,$FF,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$FF,'_' 
                  DC.B      $00,'-',$FF,$7F,$FF,$80,$FF,$F2 
                  DC.B      $15,'W',$C0,$03,$95,'Wz',$A8
                  DC.B      $AF,$FC,$FF,$F8,$E0,$07,$FF,$FF 
                  DC.B      $00,$00,$1F,$FF,$AA,$80,'U{'
                  DC.B      $FF,$F8,$00,$07,$FF,$F7,$00,$FD 
                  DC.B      $FF,$FF,$00,$00,$F8,'}',$FF,$00 
                  DC.B      $03,$1E,$83,'a',$03,$7F,$03,$80 
                  DC.B      $84,$7F,$1F,$FF,'a',$F7,$7F,$FF 
                  DC.B      $80,$00,'~',$08,$F7,$02,$0C,$F8 
                  DC.B      $FF,$F9,$08,$05,$F3,$E2,$00,$00 
                  DC.B      $00,$1F,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      '@',$0B,$FF,$F4,$FF,$FB,$FF,$FC 
                  DC.B      '@',$03,$C1,$FF,$1A,$03,$E7,$FF 
                  DC.B      '<',$00,$C3,$FC,$FF,$FF,$E8,$00 
                  DC.B      $FF,$FF,$00,$00,$17,$FF,$FF,$C2 
                  DC.B      $00,'>',$FF,$FF,$00,$02,$FF,$F8 
                  DCB.W     5,0 
                  DC.B      $02,$00,$00,$00,$01,$FF,$FD,$FF 
                  DC.B      $FC,$00,$00,$03,$00,$00,$FF,$FC 
                  DC.B      $FF,$FD,$00,$02,$C0,$1F,'@',$1F 
                  DC.B      '?',$FF,'?',$E0,'?',$C0,$80,$00 
                  DC.B      $80,$00,$FF,$FF,$7F,$FF,'?',$FE 
                  DC.B      $FC,$03,$FC,$00,$FF,$FF,$03,$FF 
                  DC.B      $01,$FF,$FF,$FF,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$EF,$00,$15 
                  DC.B      $FF,$FF,$FF,$C0,$FF,':E',$FF
                  DC.B      $10,$FF,'E',$FF,$FA,$00,$AF,$00 
                  DC.B      $FF,$F4,$D4,$0B,$FF,$FF,$00,$00 
                  DC.B      '+',$FF,'T',$00,$AB,$EF,$FF,$E0 
                  DC.B      $00,$1F,$FF,$DF,$04,$FD,$FF,$FF 
                  DC.B      $00,$00,$F8,'}',$FB,$00,$02,$00 
                  DC.B      $82,$EF,$06,$EF,$03,$10,$80,$CE 
                  DC.B      $07,$FF,'x~',$7F,$FF,$80,$00
                  DC.B      'O',$81,$F7,$82,$18,'x',$FF,$F9 
                  DC.B      $08,$07,$E7,$E0,$00,$00,$00,$1F 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$05 
                  DC.B      $FF,$FA,$FF,$FD,$FF,$FE,$00,$01 
                  DC.B      ' ',$FF,'_',$07,$BD,$FF,$FE,$00 
                  DC.B      $01,$F8,$FF,$FF,$D2,$00,$FF,$FF 
                  DC.B      $00,$00,'-',$FF,$FF,$84,$00,'|' 
                  DC.B      $FF,$FE,$00,$04,$FF,$F0,$00,$00 
                  DCB.W     6,0 
                  DC.B      $03,$FF,$FF,$FF,$FC,$00,$00,$03 
                  DC.B      $00,$00,$FF,$FC,$FF,$FD,$00,$02 
                  DC.B      $C0,',',$00,',?',$DF,$FF,$F3
                  DC.B      '?',$E0,$A0,$02,$A0,$02,$DF,$FD 
                  DC.B      $7F,$FF,'?~',$9A,$03,$9A,$00
                  DC.B      $FD,$FF,'g',$FF,$03,$FF,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$F7,$00,$0B,$FF,$FF,$FF,$E0 
                  DC.B      $FF,$1C,$FF,$FF,$FF,$F7,$FF,$FF 
                  DC.B      $00,$00,$00,$08,$FF,$F8,'`',$07 
                  DC.B      $FF,$FF,$00,$00,$9F,$FF,$00,$00 
                  DC.B      $FF,$BF,$FF,$80,$00,$7F,$FF,$7F 
                  DC.B      $18,$FD,$E7,$FF,$00,$00,$F8,'}' 
                  DC.B      $FF,$00,$00,' ',$81,$BE,$03,$BE 
                  DC.B      $00,'a',$80,$0C,'#',$FF,'<',$1C 
                  DC.B      '?',$FF,$A0,$00,$07,$E3,$EF,$02 
                  DC.B      $18,$F8,$FF,$F9,$10,$07,$E7,$E0 
                  DC.B      $00,$04,$00,$1B,$FF,$F1,$FF,$FB 
                  DC.B      $00,$04,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$00,$7F,$FF,$87 
                  DC.B      $FE,$FF,$FF,$00,$00,$F8,$FF,$FF 
                  DC.B      $A8,$00,$FF,$FF,$00,$00,'W',$FF 
                  DC.B      $FF,$08,$00,$F8,$FF,$FC,$00,$08 
                  DC.B      $FF,$E0,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$FF,$FF,$FF,$FC,$00,$00,$03 
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$00,$02 
                  DC.B      $C0,$0D,$00,$0D,'?',$FE,$FF,$F3 
                  DC.B      '?',$E1,'@',$01,'@',$01,$FF,$FF 
                  DC.B      $BF,$FE,$1D,'|X',$00,'X',$00
                  DC.B      $BF,$FF,$E7,$FF,'C',$FC,$07,$FF 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$07,$FF 
                  DC.B      $FF,$FF,$00,$7F,$FF,$FF,$FF,$00 
                  DC.B      $FF,$80,$FF,$FF,$FF,$E7,$FF,$FF 
                  DC.B      $00,$00,$00,$18,$FF,$EC,$C8,$13 
                  DC.B      $FF,$FF,$00,$00,'7',$FF,$00,$06 
                  DC.B      $FF,'y',$FF,$00,$00,$FF,$FE,$FF 
                  DC.B      '$',$FD,$D3,$FF,$10,$00,$FC,'}' 
                  DC.B      $EF,$00,$00,$C0,$80,$DC,$00,$DD 
                  DC.B      $00,$E2,$81,$19,$10,$FF,$1F,$00 
                  DC.B      $1F,$FF,$10,$00,$A1,$FF,$EE,$82 
                  DC.B      '1x',$EF,$F9,$10,$05,$CF,$E0
                  DC.B      $00,$0E,$00,$11,$FF,$F1,$FF,$F1 
                  DC.B      $00,$0E,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$00,'?',$FF,$C7 
                  DC.B      $FF,$7F,$FF,$80,$00,'x',$FF,$FF 
                  DC.B      '@',$00,$FF,$FF,$00,$00,$BF,$FF 
                  DC.B      $FE,$10,$01,$F0,$FF,$F8,$00,$10 
                  DC.B      $FF,$C0,$00,$00,$00,$00,$00,$00 
                  DCB.W     3,0 
                  DC.B      $00,$01,$03,$FE,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$FE,$00,$FD,$FC,$FF,$FD 
                  DC.B      $00,$02,$C0,$15,$00,$15,'?',$EE 
                  DC.B      $7F,$FB,'?',$F1,$80,$00,$80,$00 
                  DC.B      $7F,$FF,$FF,$FF,$9D,'\',$D4,$03 
                  DC.B      $D4,$00,';',$FF,$EF,$FF,$C7,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FF,$FF,$00,$F1,$FF,$FF 
                  DC.B      $FE,$00,$FF,$0E,$FF,$FF,'UO'
                  DC.B      $FF,$FF,$00,$00,$AA,$B0,$FF,$FA 
                  DC.B      $A2,$05,$FF,$FF,$00,$00,']',$FF 
                  DC.B      $01,$89,$F2,'t',$F2,$04,$0D,$FF 
                  DC.B      $E1,$FB,'/}',$C3,$FF,$04,$00
                  DC.B      $F8,'}',$F8,$00,$00,$00,$80,'8' 
                  DC.B      $01,$BA,$00,'D',$80,$B3,$08,'?' 
                  DC.B      $0F,$C0,$0F,$FF,$08,$00,$10,$7F 
                  DC.B      $DF,$02,'p',$F8,$DF,$F9,' ',$05 
                  DC.B      $8F,$E0,$00,$04,$00,$1B,$FF,$F1 
                  DC.B      $FF,$FB,$00,$04,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,'?' 
                  DC.B      $FF,$CF,$FF,$BF,$FF,$C0,$00,'0' 
                  DC.B      $FF,$FF,$90,$00,$FF,$FF,$00,$00 
                  DC.B      'o',$FF,$FC,$00,$03,$E0,$FF,$F0 
                  DC.B      $00,$00,$FF,$D0,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $00,$07,$03,$FB,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$87,$80,'{|',$FF,$FC
                  DC.B      $00,$02,$C0,$0A,$00,$0A,'?',$F7 
                  DC.B      $BF,$FD,'?',$F8,$C8,$09,$C8,$09 
                  DC.B      '7',$F6,$FF,$FF,$D8,$0D,$A8,$03 
                  DC.B      $A8,$00,'w',$FF,$DF,$FF,$8F,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FF,$87,$00,'{',$FF,$FF 
                  DC.B      $FF,$00,$FF,$FC,$FF,$FF,$00,$1E 
                  DC.B      $FF,$FF,$00,$00,$FF,$E1,$FF,$ED 
                  DC.B      $C0,$12,$FF,$FF,$00,$00,'?',$FF 
                  DC.B      $00,$CB,$F8,'0',$F9,$01,$06,$FE 
                  DC.B      $E1,$FE,'?',$FD,$C3,$FF,$1C,$00 
                  DC.B      $E3,$FD,$E0,$00,$00,$00,$80,$01 
                  DC.B      $00,'T',$00,$08,$80,'7',$04,$0F 
                  DC.B      $07,$F0,$07,$FF,$04,$00,$08,$1F 
                  DC.B      $BE,$03,$E1,$FA,$BF,$FA,'@',$06 
                  DC.B      $1F,$E1,$00,$00,$00,$1F,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,'?' 
                  DC.B      $FF,$8F,$FF,$FF,$FF,$C0,$00,'0' 
                  DC.B      $FF,$FF,'@',$00,$FF,$FF,$00,$00 
                  DC.B      $BF,$FF,$FE,$00,$01,$E0,$FF,$F8 
                  DC.B      $00,$00,$FF,$D0,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $00,$0E,$03,$FD,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$F1,$C0,'~',$FC,$FF,$FD 
                  DC.B      $00,$02,$C0,$05,$00,$05,'?',$FB 
                  DC.B      $7F,$FE,'?',$FC,'f3f3'
                  DC.B      $99,$CC,$FF,$FF,'g',$F3,'P',$03 
                  DC.B      'P',$00,$EF,$FF,$BF,$FF,$1F,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FF,$0F,$00,$C6,$FF,$CF 
                  DC.B      $FF,'0',$FF,$F9,$AA,$BF,'U_'
                  DC.B      $FF,$FF,$00,$00,$FF,$E0,$FF,$FE 
                  DC.B      $A8,$01,$FF,$FF,$00,$00,'W',$FF 
                  DC.B      $01,$CF,$F9,'0',$F9,$C7,$07,'8' 
                  DC.B      $F0,'8?',$FD,$C3,$FF,$18,$00
                  DC.B      $E7,$FD,$E4,$00,$00,$03,$80,$05 
                  DCB.W     2,0 
                  DC.B      $80,$02,$02,$01,$83,$FF,$03,$FF 
                  DC.B      $02,$00,$80,$0E,'}',$03,'B',$FA 
                  DC.B      $FF,$FA,$80,$07,'?',$E0,$00,$00 
                  DC.B      $00,$1F,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$00,'?',$FF,$9E,$FF,$FF 
                  DC.B      $FF,$C0,$00,'!',$FF,$FF,$88,$00 
                  DC.B      $FF,$FF,$00,$00,'w',$FF,$FD,$10 
                  DC.B      $02,$F0,$FF,$F8,$00,$10,$FF,$C8 
                  DCB.W     6,0 
                  DC.B      $00,$19,$03,$F6,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$FC,'`',$8B,$BC,$FF,$FC 
                  DC.B      $00,$02,$C0,$02,$00,$02,'?',$FD 
                  DC.B      $BF,$FF,'?',$FE,'P',$05,'P',$05 
                  DC.B      $AF,$FA,$FF,$FF,'_',$FD,' ',$03 
                  DC.B      ' ',$00,$DF,$FF,$FF,$FF,'?',$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FF,$BD,$00,$1A,$FF,$BF 
                  DC.B      $FF,$C0,$FF,$E7,$00,'?',$FF,$FE 
                  DC.B      $FF,$FF,$00,$00,$FF,$C1,$FF,$FB 
                  DC.B      $D2,$04,$FF,$FF,$00,$00,'-',$FF 
                  DC.B      $00,$CF,$FC,'0',$FC,$06,$03,$F9 
                  DC.B      $F0,$F9,$01,$01,$FE,$FF,'~',$00 
                  DC.B      $81,$01,$FF,$00,$00,$01,$80,$02 
                  DCB.W     2,0 
                  DC.B      $80,$01,$80,$02,$C0,$FE,$01,$FF 
                  DC.B      $00,$01,'@',$FC,$FE,$01,$81,$F0 
                  DC.B      $FF,$F0,$00,$0F,$7F,$E0,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DCB.W     2,0 
                  DC.B      $F0,$00,$F0,$00,$00,$00,$00,$7F 
                  DC.B      $00,']',$00,$7F,$00,'@',$00,'"' 
                  DC.B      $FF,$FF,' ',$00,$FF,$FF,$00,$00 
                  DC.B      $DF,$FF,$FE,$08,$01,$F8,$FF,$F8 
                  DC.B      $00,$08,$FF,$C0,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $00,'1',$03,$EF,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$8C,'0w',$DC,$FF,$FD
                  DC.B      $00,$02,$C0,$00,$00,$00,'?',$FF 
                  DC.B      $7F,$FF,'?',$FF,$A0,$02,$A0,$02 
                  DC.B      '_',$FD,$FF,$FF,$BF,$FE,$80,$03 
                  DC.B      $80,$00,$7F,$FF,$FF,$FF,$FF,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FF,$F2,$00,')',$FF,$FB 
                  DC.B      $FF,$84,$FF,$DF,'8?',$80,'?'
                  DC.B      $80,'?',$7F,$C0,$F8,$00,$FF,$EE 
                  DC.B      $A0,$11,$FF,$FF,$00,$00,'_',$FF 
                  DC.B      $80,$FF,'|',$00,$FC,$FF,$03,$00 
                  DC.B      $F8,$FF,$87,$FF,'X',$7F,$C0,$00 
                  DC.B      '?',$FF,$FF,$80,$00,$00,$80,$01 
                  DCB.W     2,0 
                  DC.B      $80,$00,$C0,$FF,'`',$00,$01,$FD 
                  DC.B      $00,$00,$A0,$FF,$FD,$01,$02,$F0 
                  DC.B      $FF,$F0,$00,$0F,$FF,$E0,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $10,$00,$00,$00,$E0,$00,$F0,$00 
                  DC.B      $00,$00,$00,'?',$00,'z',$00,$7F 
                  DC.B      $00,$00,$00,$05,$FF,$FF,$00,$00 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FD,$00 
                  DC.B      $02,$F8,$FF,$FC,$00,$00,$FF,$E0 
                  DCB.W     6,0 
                  DC.B      $00,'a',$03,$DF,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$04,$18,$FF,$F4,$FF,$FC 
                  DC.B      $00,$02,$C0,$01,$00,$01,'?',$FE 
                  DC.B      '?',$FF,'?',$FF,'@',$01,'@',$01 
                  DC.B      $BF,$FE,$FF,$FF,$7F,$FF,'@',$03 
                  DC.B      '@',$00,$BF,$FF,$FF,$FF,$7F,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FF,$E6,$1C,$11,$FE,'w' 
                  DC.B      $FF,$88,$FF,$FF,'I',$FF,' >'
                  DC.B      ' ?',$FF,$C0,$DF,$C1,$FF,$FB
                  DC.B      $C8,$04,$FF,$FF,$00,$00,'7',$FF 
                  DC.B      $00,$FF,$FC,$00,$FC,$00,$03,$FF 
                  DC.B      $F8,$FF,$FF,$80,$00,$7F,$00,$00 
                  DC.B      $FF,$80,$FF,$FF,$00,$00,$00,$00 
                  DCB.W     3,0 
                  DC.B      '`',$FF,$B8,$00,$00,$FB,$00,$00 
                  DC.B      'I',$FF,$FA,$01,$05,$F0,$FF,$F0 
                  DC.B      $00,$0E,$FF,$C0,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$10,$00 
                  DC.B      $00,$00,$E0,$0E,$E8,$00,$04,$00 
                  DC.B      $00,$7F,$00,'<',$00,$7F,$00,$00 
                  DC.B      $00,'C',$FF,$FF,$90,$00,$FF,$FF 
                  DC.B      $00,$00,'o',$FF,$FE,$80,$01,'x' 
                  DC.B      $FF,$FC,$00,$00,$FF,$E4,$00,$00 
                  DCB.W     5,0 
                  DC.B      $00,$C1,$03,$7F,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$CC,$18,$B7,$EC,$FF,$FC 
                  DC.B      $00,$02,$C0,$00,$00,$00,'?',$FF 
                  DC.B      '?',$FF,'?',$FE,$88,$08,$88,$08 
                  DC.B      'w',$F7,$FF,$FF,$FF,$FF,$80,$03 
                  DC.B      $80,$00,$7F,$FF,$FF,$FF,$BF,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FE,'L93',$FD,'7' 
                  DC.B      $FF,$C8,$FA,$FF,'Y',$FF,$00,'?' 
                  DC.B      $08,'?',$F7,$C0,$F7,$C0,$FF,$FE 
                  DC.B      $A2,$01,$FF,$FF,$00,$00,']',$FF 
                  DC.B      $80,$FE,'|',$01,$FC,$00,$03,$FF 
                  DC.B      $F8,$FF,$00,$00,'~~~',$00 
                  DC.B      $81,$80,$FF,$FE,$00,$00,$00,$00 
                  DCB.W     3,0 
                  DC.B      '9',$FF,'O',$00,$01,$E7,$01,$00 
                  DC.B      '2',$FF,$FC,$01,$03,$F0,$FF,$F0 
                  DC.B      $00,$0E,$FF,$C0,$80,$00,$00,$00 
                  DC.B      $7F,$FF,$FF,$FF,$00,$00,' ',$0C 
                  DC.B      $10,$0C,$D0,$1F,$FC,$08,$00,$02 
                  DC.B      $00,$7F,$00,':',$00,$7F,$00,$00 
                  DC.B      $00,'E',$FF,$EF,$00,$10,$FF,$FF 
                  DC.B      $00,$00,$FF,$FF,$FD,$04,$02,$FC 
                  DC.B      $FF,$FC,$00,$04,$FF,$E0,$00,$00 
                  DCB.W     5,0 
                  DC.B      $00,$C1,$03,$BE,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$DC,$0C,$EB,$F8,$FF,$FC 
                  DC.B      $00,$02,$C0,$02,$00,$02,'?',$FD 
                  DC.B      '?',$FF,'?',$FE,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$F7,$F7,' ',$03 
                  DC.B      ' ',$00,$DF,$FF,$FF,$FF,$BF,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FE,$DE,'p',$00,$FC,'D' 
                  DC.B      $FF,$BB,$F3,$BB,'|',$7F,$07,$BE 
                  DC.B      '7',$FF,$CB,$C0,$C8,$01,$FF,'w' 
                  DC.B      $D0,$C8,$FF,$FF,$00,$00,'/',$BF 
                  DC.B      '@',$FF,$BE,$00,$FE,$FF,$01,$00 
                  DC.B      $F8,$FF,$C3,$FE,'4',$7F,$F0,$00 
                  DC.B      $0F,$FE,$FF,$81,$00,$04,$80,$04 
                  DC.B      $00,$15,$00,$0A,$80,$10,$1F,$FF 
                  DC.B      '0',$00,$00,$1F,$00,$00,$0F,$FF 
                  DC.B      $FA,$01,$05,$F0,$FF,$F0,$00,$0E 
                  DC.B      $FF,$80,'@',$00,$00,$00,$BF,$FF 
                  DC.B      $BF,$FF,'@',$00,' ',$0C,$00,$0B 
                  DC.B      $C0,$7F,$FC,$00,$00,$06,$00,$7F 
                  DC.B      $00,'4',$80,$7F,$00,$00,$80,'K' 
                  DC.B      $FF,$D7,'@8',$FF,$FF,$00,$10
                  DC.B      $BF,$EF,$FE,$80,$01,'|',$FF,$FC 
                  DC.B      $00,$00,$FF,$E0,$00,$00,$00,$00 
                  DC.B      'l',$00,$00,$00,$00,$00,$00,$00 
                  DC.B      $01,$80,$02,$FF,$FF,$FF,$FC,$00 
                  DC.B      $08,$03,$10,$0C,$FF,$F4,$FF,$FC 
                  DC.B      $00,$02,$C0,$01,$00,$01,'?',$FE 
                  DC.B      '?',$FF,'?',$FD,$14,$14,$14,$14 
                  DC.B      $EB,$EB,$FF,$FF,$F7,$F7,'@',$03 
                  DC.B      '@',$00,$BF,$FF,$FF,$FF,$DF,$FC 
                  DC.B      $FF,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $03,$FF,$FF,$E0,$E0,'?',$FD,$BF 
                  DC.B      $FE,'_',$E2,'@B',$7F,$BF,$FB
                  DC.B      $FF,$7F,$1C,$80,$E1,$84,$FF,'}' 
                  DC.B      $A4,$C2,$FF,$FF,$00,$00,'[',$BF 
                  DC.B      $80,$FA,'~',$02,$FE,$06,$01,$FD 
                  DC.B      $FC,$FD,$FF,$DB,$00,$7F,$00,$00 
                  DC.B      $FF,$DB,$FF,$A4,$00,'(',$80,$0C 
                  DC.B      $00,'-',$00,$12,$80,$05,$07,$FF 
                  DC.B      $0E,$00,$01,$FF,$06,$00,$09,$FF 
                  DC.B      $F4,$01,$0B,$F0,$FF,$F1,$00,$0E 
                  DC.B      $FF,$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      $00,'@',$00,'o',$00,$FF,$08,'@' 
                  DC.B      $14,$17,$00,$7F,$80,$00,$C0,$7F 
                  DC.B      $00,$00,'@',$7F,$FF,$D7,$00,'8' 
                  DC.B      $FF,$FF,$00,$10,$FF,$EF,$FF,$00 
                  DC.B      $00,$FC,$FF,$FC,$00,$00,$FF,$E1 
                  DC.B      '|',$00,$10,$00,'~',$00,$90,$00 
                  DC.B      'l',$00,$00,$00,$01,$80,$03,$7F 
                  DC.B      $FF,$FF,$FC,$00,$00,$01,'8',$04 
                  DC.B      $D7,$FE,$FF,$FE,$00,$00,$C0,$01 
                  DC.B      $00,$01,'?',$FE,'?',$FF,'?',$FD 
                  DC.B      $14,$14,$14,$14,$EB,$EB,$FF,$FF 
                  DC.B      $F7,$F7,'@',$03,'@',$00,$BF,$FF 
                  DC.B      $FF,$FF,$DF,$FC,$FF,$FF,$00,$01 
                  DC.B      $FF,$FF,$FF,$FF,$03,$FF,$F8,$12 
                  DC.B      $C7,$F9,$FF,$FB,$FF,$E4,$C0,$0F 
                  DC.B      '@',$7F,$FF,$FE,$F0,$7F,$0F,$80 
                  DC.B      $BF,$81,$FF,$7F,$D0,$C0,$FF,$FF 
                  DC.B      $00,$00,'/',$BF,'`',$FF,$9E,$06 
                  DC.B      $FE,$07,$01,$F8,$FC,$F9,$00,'_' 
                  DC.B      '~[~',$08,$81,$DF,$7F,$84 
                  DC.B      $00,$17,$80,$1E,$00,'?',$00,$00 
                  DC.B      $80,')',$01,$FF,$00,$00,$81,$FF 
                  DC.B      $00,$00,$01,$FF,$F8,$08,$07,$FF 
                  DC.B      $FF,$F8,$00,$07,$FF,'0',$80,$00 
                  DC.B      $80,$00,$03,$80,$00,$00,$00,$00 
                  DC.B      $00,'#',$00,'t',$01,$F7,$00,$08 
                  DC.B      $00,$07,$80,'F@9',$E0,'~' 
                  DC.B      $00,$7F,$A0,$00,$0F,$EF,$B0,$10 
                  DC.B      $7F,$FF,$C0,$00,'?',$FF,$FF,$83 
                  DC.B      $00,'l',$FF,$F3,$00,$1C,$FF,$E3 
                  DC.B      $CA,$00,$A4,$00,$EF,$00,$10,$00 
                  DC.B      'N',$00,$00,$00,$01,$00,$03,$FF 
                  DC.B      $FF,$FF,$FC,$00,' ',$01,'Y',$E4 
                  DC.B      $B6,$DE,$FF,$FF,$00,$00,$C0,$00 
                  DC.B      $00,$00,'?',$FF,'?',$FF,'?',$FD 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$F7,$F7,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$DF,$FC 
                  DC.B      $FC,$07,$00,$03,$FF,$FF,$FF,$FF 
                  DC.B      $00,$07,$FC,$0B,$8E,$06,$FE,$0F 
                  DC.B      $F1,$F0,$83,$FD,'b',$7F,$DF,$FB 
                  DC.B      $F7,$FF,$09,$80,$BC,$04,$CF,$00 
                  DC.B      $F0,$FE,$CF,$01,'?',$FF,$00,$00 
                  DC.B      'p',$F6,$0E,$05,$FE,$F7,$81,$08 
                  DC.B      '|',$FA,'?',$DB,$C0,'[',$C0,$00 
                  DC.B      '?',$DB,$FF,$80,$00,$17,$80,$0C 
                  DC.B      $00,$1F,$00,' ',$80,$1B,$81,$FF 
                  DC.B      $00,$00,$81,$FF,$00,$00,$01,$FF 
                  DC.B      $F0,'`',$0F,$FF,$FF,$E0,$00,$1F 
                  DC.B      $FE,$80,$80,$80,$03,$00,$06,'@' 
                  DC.B      $83,$80,$01,$80,$01,$1F,$01,$A7 
                  DC.B      $03,$FF,$01,$00,$00,'X',$C0,$00 
                  DC.B      ' ',$7F,$F0,$FF,$00,$FF,$C0,$00 
                  DC.B      ' ',$00,$DF,$FF,$E0,$00,$FF,$FF 
                  DC.B      $00,$00,'x',$C3,$03,'=',$FC,$FF 
                  DC.B      $87,$FC,'x',$02,$D5,$00,$8A,$00 
                  DC.B      $DF,$00,' ',$00,'_',$00,$00,$00 
                  DC.B      $01,$01,$03,$FE,$FF,$FF,$FC,$00 
                  DC.B      $08,$01,$F1,$F4,$7F,$AE,$FF,$FF 
                  DC.B      ' ',$00,$C0,$00,$00,$00,'?',$FF 
                  DC.B      '?',$FF,'?',$FD,$08,$08,$08,$08 
                  DC.B      $F7,$F7,$FF,$FF,$FF,$FF,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$DF,$FF 
                  DC.B      $E0,$FF,$1F,$03,$80,$FF,$FF,$FF 
                  DC.B      $80,$03,$E0,$0B,$00,$1E,$E0,$1F 
                  DC.B      $FF,$E0,$1F,$F5,'a',$0C,$DF,$B3 
                  DC.B      $FF,$CF,$0E,$7F,$B0,$80,$00,$18 
                  DC.B      $FF,$E7,$FF,$F8,$FF,$FF,$00,$00 
                  DC.B      $00,$F5,$F0,$0A,$0F,$0F,$FF,$F0 
                  DC.B      $00,$FF,$FF,$DB,$80,'[',$C0,$00 
                  DC.B      '?',$DB,$7F,$80,$00,'<',$80,$02 
                  DC.B      $00,'>',$00,$01,$80,'>',$01,$FF 
                  DC.B      $00,$00,$81,$FF,$00,$00,$81,$FF 
                  DC.B      $E1,'H',$1F,$B7,$FF,'x',$00,$FF 
                  DC.B      $FE,$00,$05,'@',$02,$80,$83,' ' 
                  DC.B      $84,$C0,$05,$C0,$01,$9F,$01,'N' 
                  DC.B      $03,$DF,$00,' ',$00,$91,$C0,$01 
                  DC.B      ' ',$FE,$F8,$7F,$00,$FF,$F0,$00 
                  DC.B      $0C,$06,$F3,$F9,$0F,$FE,$FF,$FF 
                  DC.B      $00,$00,$00,$03,$FF,$FF,'/',$FB 
                  DC.B      $FF,$FC,$00,$00,$A4,$00,'[',$00 
                  DC.B      $FF,$00,$00,$00,$FE,$00,$00,$00 
                  DC.B      $01,$0F,$03,$FF,$FF,$FF,$FC,$00 
                  DC.B      $08,$01,$F1,$B4,$FF,'N',$FF,$FF 
                  DC.B      $00,$00,$C0,$00,$00,$00,'?',$FF 
                  DC.B      '?',$FF,'?',$FD,$00,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FC,$1F,$00,$03 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$DF,$FF 
                  DC.B      $E0,$FF,$1F,$02,$80,$FF,$FF,$FF 
                  DC.B      $80,$02,$E2,'-',$07,$FB,$E7,$FF 
                  DC.B      $F9,$C0,$1C,$16,$E0,' __' 
                  DC.B      $F8,$BF,$07,$FF,$BF,$00,$0F,$FC 
                  DC.B      $F0,$03,$FF,$FC,$FF,$FF,$00,$00 
                  DC.B      $00,$EF,$E8,$01,$17,$0F,$FF,$F0 
                  DC.B      $00,$FE,$80,';>',$1B,$BE,$00
                  DC.B      'A',$FB,$BF,$A0,$00,';',$80,$07 
                  DC.B      $00,'?',$00,$00,$80,'<',$03,'w' 
                  DC.B      $03,$8C,$0F,'w',$82,$F8,$04,$03 
                  DC.B      $C9,$04,'>',$FB,$F9,$FC,$07,$FF 
                  DC.B      $F0,$00,'B',$A0,$C4,'@',$02,$80 
                  DC.B      $85,'`',$06,$E0,$00,$BF,$01,'\' 
                  DC.B      $07,$FF,$00,$00,$00,$E3,$E0,$02 
                  DC.B      $10,$FD,$F8,'~',$00,$FF,$F8,$00 
                  DC.B      $00,$00,$FF,$FF,$DF,$FF,$FF,$FF 
                  DC.B      $00,$00,$D0,$07,'/',$FB,$D7,$F7 
                  DC.B      $FF,$F8,$00,$04,$F8,$00,$87,$00 
                  DC.B      $FF,$00,$00,$00,'|',$00,$00,$00 
                  DC.B      $01,$18,$03,$F7,$FF,$FF,$FC,$00 
                  DC.B      $00,$01,'|4',$9B,$DE,$FF,$FF
                  DC.B      $00,$00,$C0,$01,$00,$01,'?',$FE 
                  DC.B      '?',$FF,'?',$FD,$03,$E0,$03,$E0 
                  DC.B      $FF,$FF,$FC,$1F,$F8,$0F,'@',$03 
                  DC.B      '@',$00,$BF,$FF,$FF,$FF,$DF,$FF 
                  DC.B      $E1,$FF,$1E,$00,$81,$FF,$BF,$FF 
                  DC.B      $C0,$00,$E9,'7',$1F,$AD,$FF,$BF 
                  DC.B      $E6,'@',$10,$DA,$F0,'@',$0F,$BF 
                  DC.B      $F8,$7F,$07,$FF,$FF,$00,$07,$E8 
                  DC.B      $F8,$17,$FF,$E8,$FF,$FF,$00,$00 
                  DC.B      $00,$EF,$F4,$10,$0B,$1F,$FF,$E0 
                  DC.B      $00,$FF,'?',$DB,$C0,'[',$E0,$00 
                  DC.B      $1F,$DB,$7F,$80,$00,$0B,$80,'6' 
                  DC.B      $00,'?',$00,$00,$80,'=',$08,$00 
                  DC.B      $8F,$FF,$BF,$FF,$09,$FF,$90,$00 
                  DC.B      $00,$06,$FF,$F9,$FF,$FE,$FF,$FF 
                  DC.B      $00,$00,'@',$00,$C7,' ',$02,$10 
                  DC.B      $85,$E0,$05,' ',$06,$7F,$04,$B8 
                  DC.B      $0F,$FF,$04,$00,$03,'G',$E0,$81 
                  DC.B      $18,'~',$FC,$FD,$00,$7F,$F8,$80 
                  DC.B      $00,$00,$FF,$FF,$EF,$FF,$FF,$FF 
                  DC.B      $00,$00,'8',$7F,$C7,$F7,$BB,$7F 
                  DC.B      $FF,$80,$00,$08,$F9,$00,$E7,$00 
                  DC.B      $FF,$00,$01,$00,$1C,$00,$00,$00 
                  DC.B      $01,$B3,$03,'o',$FF,$FF,$FC,$00 
                  DC.B      $00,$01,$9E,$14,'m',$FE,$FF,$FF 
                  DC.B      $00,$00,$C0,'a',$00,'a?ž' 
                  DC.B      '?',$FF,'?',$E1,$05,$D0,$05,$D0 
                  DC.B      $FB,$EF,$FE,'?',$FC,$1F,'C',$03 
                  DC.B      'C',$00,$BC,$FF,$FF,$FF,$C3,$FF 
                  DC.B      $E3,$FF,$1C,$02,$83,$FF,$9F,$FF 
                  DC.B      $E0,$02,$F8,'?',$0C,'4',$FC,'?' 
                  DC.B      $E3,$C0,$17,$CB,$F0,$00,$0F,$FF 
                  DC.B      $FF,$7F,$07,$FF,$F8,$00,$0B,$D0 
                  DC.B      $F4,'/',$FF,$D0,$FF,$FF,$00,$00 
                  DC.B      $03,'O',$F8,$10,$07,$1F,$FC,$E0 
                  DC.B      $03,$FF,$CF,$DB,$10,$7F,$D0,$00 
                  DC.B      '/',$DB,$DF,$A4,$00,$06,$80,$18 
                  DC.B      $00,$1E,$00,'!',$80,$1E,$10,$00 
                  DC.B      $19,$FF,'y',$FF,$97,$FF,' ',$00 
                  DC.B      $00,$06,$FF,$F9,$FF,$FE,$FF,$FF 
                  DC.B      $00,$00,'@',$10,$85,$E0,$00,'@' 
                  DC.B      $C7,$B0,$05,$B0,$06,$7F,$05,' ' 
                  DC.B      $0F,$7F,$00,$80,$02,'_',$87,$FC 
                  DC.B      '{',$FB,$FF,$FC,$00,$07,$FC,$00 
                  DC.B      $80,$00,$7F,$FF,$F7,$FF,$FF,$FF 
                  DC.B      $00,$00,'}',$FF,$83,$EF,'}',$FF 
                  DC.B      $FE,$00,$00,$10,$F8,$00,$86,$00 
                  DC.B      $FE,$00,$00,$00,'y',$00,$00,$00 
                  DC.B      $01,$A3,$02,$FD,$FF,$FF,$FC,$00 
                  DC.B      $00,'!',$8F,$14,$F6,$FE,$FF,$FF 
                  DC.B      $00,$00,$C0,$02,$00,$02,'?',$FD 
                  DC.B      '?',$FF,'?',$FE,$02,$A0,$02,$A0 
                  DC.B      $FD,$DF,$FF,$7F,$FE,'? ',$03
                  DC.B      ' ',$00,$DF,$FF,$FF,$FF,$BF,$FF 
                  DC.B      $E7,$FF,$18,$01,$87,$FF,$9F,$FF 
                  DC.B      $E0,$03,$F0,'?',$00,'0',$F0,'?' 
                  DC.B      $EF,$C0,$1F,$CF,$F8,$80,$07,$7F 
                  DC.B      $F8,$FF,$07,$FF,$FF,$00,$05,$E8 
                  DC.B      $FA,$17,$FF,$E8,$FF,$FF,$00,$00 
                  DC.B      $03,'_',$F7,$80,$0B,$9F,$FC,'`' 
                  DC.B      $00,$FF,$80,$7F,'f',$7F,$E6,$00 
                  DC.B      $19,$FF,$A7,$80,$00,$05,$80,$1A 
                  DC.B      $00,'?',$00,$00,$80,'?c',$00
                  DC.B      $B2,$FF,$F3,$FF,'/',$FF,$80,$00 
                  DC.B      $10,$02,$DF,$FD,$EF,$FE,$FF,$FF 
                  DC.B      '0',$00,'D',$00,$83,$F0,$00,'(' 
                  DC.B      $C7,$D0,$07,$D0,$06,$FC,$05,$03 
                  DC.B      $0F,$FF,$04,$00,$03,$FE,$03,$FC 
                  DC.B      $FC,$FF,$FF,$FC,$00,$03,$1F,$00 
                  DC.B      'H',$00,$B7,$FF,'{',$FE,$FF,$FF 
                  DC.B      $00,$00,'3',$FF,$CE,$0E,$F3,$FF 
                  DC.B      $FC,$00,$01,$F1,$F0,$00,$0E,$00 
                  DC.B      $FF,$00,$00,$00,$F8,$00,$00,' ' 
                  DC.B      $00,$91,$03,$EE,$FF,$FF,$FC,$00 
                  DC.B      $00,$E1,$83,$14,$FD,$EE,$FF,$FE 
                  DC.B      $00,$00,$C0,$02,$00,$02,'?',$FD 
                  DC.B      '?',$FF,'?',$FE,$81,'@�@' 
                  DC.B      '~',$BF,$FF,$FF,$FF,$7F,$A0,$03 
                  DC.B      $A0,$00,'_',$FF,$FF,$FF,$BF,$FF 
                  DC.B      $AF,$FF,$10,$00,$CF,$FF,$DF,$FF 
                  DC.B      $A0,$03,$F9,$1F,$93,$F1,$FB,$FF 
                  DC.B      $EC,$E0,$86,$0E,$F8,$80,'G',$7F 
                  DC.B      $FC,$FF,$03,$FF,$BF,$00,$02,$F4 
                  DC.B      $FD,$0B,$FF,$F4,$FF,$FF,$00,$00 
                  DC.B      $07,$DF,$FF,' ',$07,$BF,$F8,'@' 
                  DC.B      $00,$FF,$A7,$FF,'@',$7F,$E0,$00 
                  DC.B      $1F,$FF,$E7,$80,$00,$27,$80,$18 
                  DC.B      $00,'?',$00,$00,$80,$1F,$0E,$80 
                  DC.B      $AF,$7F,$EE,$FF,$1F,$FF,$C0,$00 
                  DC.B      ' ',$02,$F9,$FD,$DF,$FE,$FF,$FF 
                  DC.B      '&',$00,'D',$0C,$07,$F4,$80,$00 
                  DC.B      $C3,$FC,$07,$F8,$03,$E0,$02,$1F 
                  DC.B      $07,$FF,$02,$00,$01,$F0,'!',$FC 
                  DC.B      $DE,$03,$FF,$FD,$00,$03,$7F,$FC 
                  DC.B      $B4,$01,'K',$FE,$B7,$FF,$FF,$FF 
                  DC.B      $00,$00,'&',$F7,$D9,$1E,'g',$F7 
                  DC.B      $FC,$08,$03,$E1,$F2,$00,$0E,$00 
                  DC.B      $FE,$00,$02,$00,$F0,$00,$00,$10 
                  DC.B      $00,$C9,$03,'w',$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$81,$EC,'~',$D8,$FF,$FC 
                  DC.B      $00,$02,$C0,$09,$00,$09,'?',$F6 
                  DC.B      '?',$FF,'?',$F9,'@',$01,'@',$01 
                  DC.B      $BF,$FE,$FF,$FF,$7F,$7F,'H',$03 
                  DC.B      'H',$00,$B7,$FF,$FF,$FF,'O',$FF 
                  DC.B      $9F,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $80,$03,$FC,$9F,'W',$D8,$FF,$DF 
                  DC.B      $EB,' ',$C0,'g',$FF,$80,$A3,$7F 
                  DC.B      $FF,$FF,$00,$FF,'\',$00,$01,'x' 
                  DC.B      $FE,$87,$FF,$F8,$FF,$FF,$00,$00 
                  DC.B      $07,$FF,$FF,$00,$07,$FF,$F8,$00 
                  DC.B      $00,$FF,$C7,$FF,' ',$7F,$E0,$00 
                  DC.B      $1F,$FF,$E7,$80,$00,$03,$80,$1C 
                  DC.B      $00,'?',$00,$00,$80,$1F,$1F,'@' 
                  DC.B      $9E,$BF,$9E,$7F,'~',$FF,$81,$00 
                  DC.B      '"',$00,$FE,$FE,$DD,$FD,$FF,$FF 
                  DC.B      '#',$00,'@',$07,$01,'y',$85,$00 
                  DC.B      $C2,$F9,$01,'|',$00,$00,$00,$7F 
                  DC.B      $01,$FF,$00,$00,$00,$C3,'P',$0C 
                  DC.B      $AF,$F7,$FF,$FF,$00,$03,$FF,$F8 
                  DC.B      'H',$00,$B7,$FF,$CF,$FF,$FF,$FF 
                  DC.B      $00,$00,$8F,'/r',$FC,$8F,$EF
                  DC.B      $FC,$10,$01,$C3,$E4,$00,$1C,$00 
                  DC.B      $FE,$00,$04,$00,$F0,$00,$00,$08 
                  DC.B      $00,'g',$03,$DE,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$00,$18,$FF,$EC,$FF,$FC 
                  DC.B      $00,$02,$C0,'$',$00,'$?',$DB
                  DC.B      '?',$FF,'?',$E7,$A0,$02,$A0,$02 
                  DC.B      '_',$FD,$FF,$FF,$BF,'~',$92,$03 
                  DC.B      $92,$00,'m',$FF,$FF,$FF,$F3,$FF 
                  DC.B      $9F,$FF,$00,$00,$FF,$FF,$FF,$FF 
                  DC.B      $80,$03,$FE,$0F,'3',$09,$FF,$0F 
                  DC.B      $EC,$F0,$E1,$F6,$FF,$80,$7F,$7F 
                  DC.B      $FF,$FF,$00,$FF,$80,$00,$02,$F4 
                  DC.B      $FD,$0B,$FF,$F4,$FF,$FF,$00,$00 
                  DC.B      $07,$FF,$FF,$80,$07,$FF,$F8,$00 
                  DC.B      $00,$7F,$C7,$DB,' {',$E0,$00
                  DC.B      $1F,$9B,$E7,$80,$00,'?',$80,$00 
                  DC.B      $00,'?',$00,$00,$80,$1F,'@r'
                  DC.B      $B9,$BD,$F9,$F3,$06,$0F,'@@'
                  DC.B      $11,$03,$DF,$7F,$EE,$FB,$FF,$FC 
                  DC.B      '1',$80,$80,$07,$FF,$BC,$FF,$80 
                  DC.B      $01,'x~',$BF,$80,$02,$80,$1D
                  DC.B      $00,$DF,$80,' ',$00,'_',$A8,$1A 
                  DC.B      'W',$ED,$FF,$FB,$00,$07,$FF,$F0 
                  DC.B      ' ',$00,$DF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,'^',$EE,$A1,$B9,$DE,$EF 
                  DC.B      $FF,$10,$00,'G',$08,$00,$F8,$00 
                  DC.B      $FC,$00,$08,$00,$E0,$00,$00,$00 
                  DC.B      $00,'p',$03,$AF,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$00,'8',$FF,$D4,$FF,$FC 
                  DC.B      $00,$02,$C0,$01,$80,$01,'?',$FE 
                  DC.B      '?',$FF,'?',$FF,'H',$09,'H',$09 
                  DC.B      $B7,$F6,$FF,$FF,'Oy@',$00 
                  DC.B      '@',$00,$BF,$FC,$FF,$FC,$7F,$FC 
                  DC.B      $1F,$FC,$00,$00,$7F,$FC,$7F,$FC 
                  DC.B      $00,$00,$1C,$0F,$10,$0C,$1C,$0F 
                  DC.B      $0F,$F0,$03,$F3,$FF,$80,$FF,$7F 
                  DC.B      $FF,$FF,$00,$FF,$00,$00,$01,'x' 
                  DC.B      $FE,$87,$FF,$F8,$FF,$FF,$00,$00 
                  DC.B      $07,$FF,$FF,$C0,$07,$FF,$F8,$00 
                  DC.B      $00,'?',$C0,$1F,$0F,$7F,$CF,$00 
                  DC.B      '0',$9F,$CF,$A0,$00,$1E,$80,$01 
                  DC.B      $00,'?',$00,$00,$80,'?',$7F,$FF 
                  DC.B      $9F,$FF,$FF,$FF,$00,$00,'`',$00 
                  DC.B      $09,$87,$EC,$FE,'vw',$FE,$F8
                  DC.B      $1B,$81,$FC,$01,$FB,$F8,$FF,$C4 
                  DC.B      $00,'8',$04,$FC,$E0,$05,' ',$0A 
                  DC.B      $00,'/ ',$10,$80,$0F,'T',$01
                  DC.B      $AB,'>',$FF,$01,$00,'?',$FF,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,'?\',$C0,$B3,$FF,'_'
                  DC.B      $FF,$A0,$00,'O',$10,$00,$F0,$00 
                  DC.B      $F8,$00,$10,$00,$C0,$00,$00,$00 
                  DC.B      $00,'<',$03,$DB,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$00,$F1,$FF,'l',$FF,$FC 
                  DC.B      $00,$02,$C0,$02,'@',$02,'?',$FD 
                  DC.B      '?',$FF,'?',$FE,$90,$04,$90,$04 
                  DC.B      'o',$FB,$FF,$FF,$F0,$07,$A0,$00 
                  DC.B      $A0,$00,'_',$FC,$FF,$FC,$BF,$FC 
                  DC.B      $1F,$FC,$00,$00,'?',$FC,'?',$FC 
                  DC.B      $00,$00,$1C,$87,$01,$FC,$15,$FF 
                  DC.B      $0E,'x',$13,$03,$FF,$80,'x',$7F 
                  DC.B      $FF,$FF,$00,$FF,$87,$00,$02,$F4 
                  DC.B      $FD,$0B,$FF,$F4,$FF,$FF,$00,$00 
                  DC.B      $07,$FF,$F9,$F0,$07,$FF,$F8,$00 
                  DC.B      $06,$0F,$88,$1B,'@{',$C0,$00
                  DC.B      '?',$9B,$CF,$E0,$00,$1F,$80,$18 
                  DC.B      $00,$1F,$00,' ',$80,$07,$7F,$FF 
                  DC.B      $9F,$FF,$FF,$FF,$00,$00,'`',$00 
                  DC.B      $C7,$8D,$B4,$FF,$F8,'o|',$F2
                  DC.B      $0F,$80,$E0,$02,$DF,$FE,$FF,$C0 
                  DC.B      $00,'> ',$FC,$F0,$07,$10,$08
                  DC.B      $00,$1F,$10,$00,'@',$17,$EA,$01 
                  DC.B      $15,'>',$FF,$81,$00,'?',$FF,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DC.B      $00,$00,$1E,'_',$E1,$B0,$FE,'_' 
                  DC.B      $FF,$A0,$00,'O',$00,$00,$E0,$00 
                  DC.B      $E0,$00,$00,$00,$90,$00,$00,$00 
                  DC.B      $00,$0F,$03,$F6,$FF,$FF,$FC,$00 
                  DC.B      $00,$03,$8F,$C0,'s',$BC,$FF,$FC 
                  DC.B      $00,$02,$C0,$01,$80,$01,'?',$FE 
                  DC.B      '?',$FF,'?',$FD,$04,$10,$05,'P' 
                  DC.B      $FB,$EF,$FF,$FF,$FC,$1F,'@',$00 
                  DC.B      '@',$00,$BF,$FC,$FF,$FC,$DF,$FC 
                  DCB.W     5,0 
                  DC.B      $04,'G',$13,$E6,$11,$E7,$07,$98 
                  DC.B      $12,'9',$FF,$00,'`',$FF,$FF,$7F 
                  DC.B      $00,$FF,$9F,$00,$01,'x',$FE,$87 
                  DC.B      $FF,$F8,$FF,$FF,$00,$00,$03,$FF 
                  DC.B      $F4,'x',$0F,$FF,$F8,$00,$07,$87 
                  DC.B      $1F,$FF,$80,$7F,$80,$00,$7F,$FF 
                  DC.B      $9F,$80,$00,'>',$80,$1D,$00,'?' 
                  DC.B      $00,$00,$80,'#',$7F,$FF,$80,$FF 
                  DC.B      $FF,$FF,$00,$00,$7F,$00,$C3,'+' 
                  DC.B      $BB,'_',$FC,$EF,$7F,$F4,$07,$80 
                  DC.B      $80,'#',$7F,$1D,$FF,$00,$00,$FD 
                  DC.B      $80,'>x',$06,$08,$01,$00,$17
                  DC.B      $08,$08,' ',$07,$BD,'!B',$1E
                  DC.B      $FF,$81,$00,'?',$FF,$80,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      '>',$7F,$C1,$E0,$FE,$7F,$FF,$80 
                  DC.B      $00,$1F,' ',$00,$E0,$00,$F0,$00 
                  DC.B      ' ',$00,$80,$00,$00,$00,$00,$03 
                  DC.B      $03,$FD,$FF,$FF,$FC,$00,$00,$03 
                  DC.B      $FF,$01,$FC,$FC,$FF,$FC,$00,$02 
                  DC.B      $C0,$04,'@',$04,'?',$FB,'?',$FF 
                  DC.B      '?',$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FC,$1F,$10,$00,$10,$00 
                  DC.B      $EF,$FC,$FF,$FC,$FF,$FC,$00,$00 
                  DCB.W     4,0 
                  DC.B      $02,$07,$10,$06,$10,$07,$03,$F8 
                  DC.B      $03,$F9,$FE,'@',$01,'?',$FF,$FF 
                  DC.B      $00,$FF,$FF,$00,$02,$F4,$FD,$0B 
                  DC.B      $FF,$F4,$FF,$FF,$00,$00,$05,$FF 
                  DC.B      $EA,'8',$17,$FF,$F8,$00,$07,$C7 
                  DC.B      '9',$FF,'<',$7F,'<',$00,$C3,$81 
                  DC.B      $07,$80,$00,'?',$80,$1C,$00,$FF 
                  DC.B      $00,$00,$80,'c',$7F,$FF,$80,$00 
                  DC.B      $FF,$FF,$00,$00,$7F,$FF,$80,'o' 
                  DC.B      $7F,$8E,$FF,$FF,$FF,$F0,$00,$01 
                  DC.B      $00,$F1,$FC,$8E,$FC,$E2,$03,$9C 
                  DC.B      $00,$1D,$BC,$03,$84,$04,$00,$0F 
                  DC.B      $84,$00,$10,$0B,$F7,'!',$08,'>' 
                  DC.B      $FF,$01,$00,$9F,$FF,$00,$00,$00 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      '|',$7F,$83,'`',$FC,$FF,$FF,$80 
                  DC.B      $00,$1F,$00,$00,$C0,$00,$C0,$00 
                  DC.B      $00,$00,' ',$00,$00,$00,$00,$00 
                  DC.B      $03,$FF,$03,$FF,$00,$00,$00,$03 
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$00,$02 
                  DC.B      $C0,$00,$80,$00,'?',$FF,'?',$FF 
                  DC.B      '?',$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$00 
                  DC.B      $FF,$FC,$FF,$FC,$FF,$FC,$00,$00 
                  DCB.W     4,0 
                  DC.B      $02,'#',$00,'~',$02,$7F,$11,$9C 
                  DC.B      $01,$C1,$F0,$C0,$0F,'?',$FF,$7F 
                  DC.B      $00,$7F,$FF,$80,$05,$F8,$FA,$07 
                  DC.B      $FF,$F8,$FF,$FF,$00,$00,$00,$FE 
                  DC.B      $F3,$01,$0F,$FF,$FC,$00,$03,$FF 
                  DC.B      '&',$0B,$0F,$1D,$0F,$00,$F0,$89 
                  DC.B      '9',$90,$00,$BE,$80,'M',$06,$FF 
                  DC.B      $01,$00,$82,$B3,$07,$FF,$F8,$00 
                  DC.B      $FF,$FF,$00,$00,$7F,$FF,$81,$C6 
                  DC.B      '~-',$FF,$DF,$FF,$F0,$00,$0A
                  DC.B      $03,'{',$FB,$84,$FA,'p',$06,$8E 
                  DC.B      $01,$8E,$9C,$01,$02,$02,$00,$0F 
                  DC.B      $00,$00,$8A,$05,$FF,$12,$02,$8D 
                  DC.B      $FF,$83,$00,$0F,$FD,$10,$00,$01 
                  DC.B      $FF,$FE,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $F8,$7F,$06,$C0,$F9,$7F,$FF,$80 
                  DC.B      $00,'?',$00,$00,$C0,$00,$E0,$00 
                  DCB.W     4,0 
                  DC.B      $03,$FF,$03,$FF,$00,$00,$00,$03 
                  DC.B      $00,$01,$FF,$FC,$FF,$FC,$00,$02 
                  DC.B      $C0,$00,'@',$00,'?',$FF,'?',$FF 
                  DC.B      '?',$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$00 
                  DC.B      $FF,$FC,$FF,$FC,$FF,$FC,$00,$00 
                  DCB.W     4,0 
                  DC.B      $10,$93,$11,$FB,$13,$FB,$10,'d' 
                  DC.B      $01,$0C,$F1,' ',$0E,$DF,$FF,'?' 
                  DC.B      $00,$FF,$FF,$80,$03,$F4,$FC,$0B 
                  DC.B      $FF,$F4,$FF,$FF,$00,$00,$00,'>' 
                  DC.B      $E0,$C0,$1C,$FE,$FF,$01,$00,$FE 
                  DC.B      '9',$0B,$03,$1F,$03,$00,$FC,$89 
                  DC.B      '>',$90,$00,'?',$83,$C0,$0B,$FF 
                  DC.B      $04,$00,$80,'?',$00,'W',$FF,$A8 
                  DC.B      $FF,$FF,$00,$00,$7F,$FF,$87,$04 
                  DC.B      'x',$CB,$FF,'?',$FF,$F0,$00,$0C 
                  DC.B      $00,$FD,$F0,$03,$F1,'8',$0C,$C7 
                  DC.B      $02,$C6,$CE,$00,$02,$01,$00,$07 
                  DC.B      $00,$00,'D',$02,$FF,$1C,'T',$93 
                  DC.B      $FF,$87,$00,$07,$AB,$08,$00,$1F 
                  DC.B      $FF,$E0,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $E0,'~',$1D,'A',$E2,$FF,$FF,$80 
                  DC.B      $00,'?@',$00,$C0,$00,$C0,$00
                  DC.B      '@',$00,$00,$00,$00,$00,$00,$00 
                  DC.B      $03,$FF,$03,$FF,$00,$00,$00,$03 
                  DC.B      $00,$00,$FF,$FC,$FF,$FC,$00,$02 
                  DC.B      $C0,$00,$C0,$00,'?',$FF,'?',$FF 
                  DC.B      '?',$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$00 
                  DC.B      $FF,$FC,$FF,$FC,$FF,$FC,$00,$00 
                  DCB.W     4,0 
                  DC.B      $00,'C',$01,$E3,$11,$E3,$00,$9C 
                  DC.B      $11,'<',$F3,'P',$0C,$AF,$FF,$9F 
                  DC.B      $00,$BF,$FF,'@',$07,$E8,$F8,$17 
                  DC.B      $FF,$E8,$FF,$FF,$00,$00,$04,$1C 
                  DC.B      $D2,'"(>',$FB,$C1,$06,'>' 
                  DC.B      $7F,$8B,$00,$1F,$00,$00,$FF,$89 
                  DC.B      $7F,$90,$00,$FE,$84,$C1,$0C,$FF 
                  DC.B      $03,$C0,$88,'?',$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$00,$00,'@',$00,'<',$08 
                  DC.B      $C3,$8F,'|{',$FF,$F8,$00,$00
                  DC.B      $08,'>',$C8,'@',$CA,$9C,'8b'
                  DC.B      $04,'b',$E6,$00,$80,$00,$00,$02 
                  DC.B      $80,$01,' ',$00,$FF,$0E,'(',$09 
                  DC.B      $FF,$03,$00,$83,$D7,$04,$01,$FF 
                  DC.B      $FE,$00,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,'|',$FA,$03,$05,$FF,$FF,$80 
                  DC.B      $00,'~ I',$B4,$ED,$80,$00 
                  DC.B      ' IT',$A4,$02,$00,$00,$00 
                  DC.B      $01,$FF,$01,$FF,$00,$00,$00,$03 
                  DC.B      $00,$01,$FF,$FC,$FF,$FC,$00,$02 
                  DC.B      $C0,$00,$C0,$00,'?',$FF,'?',$FF 
                  DC.B      '?',$FF,$00,$00,$00,$00,$FF,$FF 
                  DC.B      $FF,$FF,$FF,$FF,$00,$00,$00,$00 
                  DC.B      $FF,$FC,$FF,$FC,$FF,$FC,$00,$00 
                  DCB.W     4,0 
                  DC.B      $11,$09,$00,$9F,$11,$9F,$00,'f' 
                  DC.B      $00,$F0,$FE,'(',$81,$D7,$FE,$0F 
                  DC.B      $01,$DF,$7F,$E0,$0B,$D0,$F4,'/' 
                  DC.B      $FF,$D0,$FF,$FF,$00,$00,$00,$00 
                  DC.B      $A7,$00,'X',$00,$FF,$FF,$07,$00 
                  DC.B      's',$9D,'x',$1F,'x',$00,$87,$9D 
                  DC.B      $0F,$80,$00,$1E,$80,$01,$0B,$DF 
                  DC.B      $00,' ',$87,$DF,$14,$00,$84,$00 
                  DC.B      $FC,$00,$07,$FF,$08,$00,$B0,$00 
                  DC.B      'N',$04,$B1,$F4,$7F,$F3,$80,$0C 
                  DC.B      $10,'^',$10,' ',$14,$0E,$F0,'p' 
                  DC.B      $08,'p~',$00,'D',$00,$00,$01
                  DC.B      'D',$00,$12,$01,'~',$03,$00,$02 
                  DC.B      '~',$80,$81,$00,'~',$81,$FF,$F8 
                  DC.B      $00,$07,$FF,$F8,$FF,$FF,$00,$00 
                  DC.B      $00,'x',$D4,'G+',$BF,$FF,$80
                  DC.B      $00,'<',$84,$AD,$84,$AD,$C0,$00 
                  DC.B      $84,$AD,$00,$00,$00,$00,$00,$00 
                  DCB.W     10,0
                  DC.B      '?',$FF,'?',$FF,'?',$FF,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FC,$FF,$FC,$FF,$FC,$00,$00 
                  DCB.W     4,0 
                  DC.B      $00,$A5,$00,$7F,$11,$7F,$00,$98 
                  DC.B      $00,$C2,$FE,'V',$81,$E9,$FE,$E7 
                  DC.B      $01,'/',$7F,$90,$0F,$A0,$F0,'_' 
                  DC.B      $FF,$A0,$FF,$FF,$00,$00,$0E,$00 
                  DC.B      'A',$00,$B7,$00,$F0,$FF,$0F,$80 
                  DC.B      $CC,$80,$1E,$7F,$1E,$00,$E1,$80 
                  DC.B      $F3,$FF,$00,$0E,$00,$01,$04,$EF 
                  DC.B      $00,$10,$03,'.',$00,$00,$00,$00 
                  DC.B      $00,$00,$80,$00,$00,$00,'p2'
                  DC.B      'H',$12,$07,$CA,'O',$E3,$10,$04 
                  DC.B      ' .`',$12,'hD',$A0,'8'
                  DC.B      $10,':',$1E,$00,'0',$00,$00,$00 
                  DC.B      $10,$00,'$',$00,$1C,$01,' ',$01 
                  DC.B      $BD,$80,'B',$00,$9D,$00,$FF,$80 
                  DC.B      $00,'~',$7F,'�',$7F,$FF,$80,$00 
                  DC.B      $00,$A1,$A0,$BF,'_?',$FF,'!'
                  DC.B      $00,$18,'d',$A9,'t',$AD,$80,$00 
                  DC.B      'd',$A9,$10,$04,$00,$00,$00,$00 
                  DCB.W     10,0
                  DC.B      '?',$FF,'?',$FF,'?',$FF,$00,$00 
                  DC.B      $00,$00,$FF,$FF,$FF,$FF,$FF,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FC,$FF,$FC,$FF,$FC,$00,$00 
                  DCB.W     4,0 
                  DC.B      $00,'P',$00,'x',$00,$F8,$00,$27 
                  DC.B      $00,$0F,$FC,'$',$C3,$F9,$FF,$F2 
                  DC.B      $03,$CB,'<',$1C,$DF,'@ ',$BA
                  DC.B      $FF,'E',$FF,$FF,$00,$00,$11,$80 
                  DC.B      $0A,$00,$E3,$80,$EC,$7F,$1F,$80 
                  DC.B      $F2,$A0,$06,'|',$06,$00,$F9,$A0 
                  DC.B      $FD,$9C,$00,'$',$00,$02,$00,'6' 
                  DC.B      $00,$09,$00,$16,$00,$00,$00,$00 
                  DC.B      $80,$00,$00,$00,$80,$00,$00,$01 
                  DC.B      $00,$01,$00,$05,$00,$01,$00,$02 
                  DC.B      $C0,$14,$C0,$0C,$D0,' ',$C0,$18 
                  DC.B      ' ',$1C,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      'L',$00,'0',$00,'H',$00,'`',$00 
                  DC.B      '_',$F4,$00,$0B,$1F,$FF,' ',$00 
                  DC.B      $03,$12,$01,$1E,$FC,'?',$FC,$12 
                  DC.B      $02,$00,'D',$E9,'D',$EB,$00,$00 
                  DC.B      'D',$E9,$00,$02,$00,$00,$00,$00 
                  DCB.W     9,0 
                  DC.B      ' ',$00,'?',$FF,$1F,$FF,$1F,$FF 
                  DCB.W     2,0 
                  DC.B      $FF,$FF,$FF,$FF,$FF,$FF,$00,$00 
                  DC.B      $00,$04,$FF,$FC,$FF,$F8,$FF,$F8 
                  DCB.W     5,0 
                  DC.B      $00,'b',$00,$27,$00,$27,$00,'Y' 
                  DC.B      $00,'\',$F8,$00,$C7,$FF,$F8,$00 
                  DC.B      $07,$FF,'?',$FF,$C6,$00,$09,$F4 
                  DC.B      '6',$0B,'?',$FF,$C0,$00,'`',$00 
                  DC.B      $1F,$C0,$80,$00,$9F,$FF,$7F,$C0 
                  DC.B      $FE,' ',$00,'|',$80,$00,'~ '
                  DC.B      $FE,$1C,$00,$0E,$00,$00,$00,$1F 
                  DCB.W     27,0
                  DC.B      $1C,$00,$10,$00,$03,$FF,$0B,$FF 
                  DC.B      $04,$00,$0C,$00,$04,$00,$F0,$00 
                  DC.B      $F0,$00,$08,$00,'F',$AB,'F',$AB 
                  DC.B      $00,$00,'F',$AB,$00,$00
L004D		equ	*+18 
		incbin	fendrago.tg1                  
                  
                  
TRANS:            DC.B      '`',$1A,$00,$00,$0B,$18,$00,$00 
                  DC.B      'X',$F8,$00,$00,$00,$00,$00,$00 
                  DC.B      $06,$90,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'N',$F9,$00,$00,$00,$06,'#',$C8 
                  DC.B      $00,$00,$0B,'`#',$C9,$00,$00
                  DC.B      $0B,'da',$00,$05,$A8,'/',$00
                  DC.B      ' 8',$04,'f',$B0,$B8,$04,'f'
                  DC.B      'g',$FA,' ',$1F,' z',$0B,':'
                  DC.B      'r',$00,'0<',$00,$EF,'1A' 
                  DC.B      $00,$0A,'1A',$00,$1A,'1A' 
                  DC.B      $00,'*1A',$00,':1A' 
                  DC.B      $00,'J1A',$00,'Z1A' 
                  DC.B      $00,'j1A',$00,'z1A' 
                  DC.B      $00,$8A,'1A',$00,'š1A'
                  DC.B      $00,$AA,'1A',$00,$BA,'1A' 
                  DC.B      $00,$CA,'1A',$00,$DA,'1A' 
                  DC.B      $00,$EA,'1A',$00,$FA,'1A' 
                  DC.B      $01,$0A,'1A',$01,$1A,'1A' 
                  DC.B      $01,'*1A',$01,':1A' 
                  DC.B      $01,'J1A',$01,'Z1A' 
                  DC.B      $01,'j1A',$01,'zA',$E8
                  DC.B      $01,$80,'Q',$C8,$FF,'ša',$00
                  DC.B      $00,'.a',$00,$00,'Ta',$00 
                  DC.B      $01,'dA',$FA,$0A,$BC,' ',$18
                  DC.B      '!',$10,'!@',$00,$04,'!',$A8
                  DC.B      $00,$04,$01,$E2,$04,$0C,$00,$04 
                  DC.B      'Jy',$00,$00,$00,$C4,'j',$00
                  DC.B      $FF,'VNu',$00,$C8,'Xy'
                  DC.B      $00,$00,$0B,$82,$02,'y',$03,$FF 
                  DC.B      $00,$00,$0B,$82,$04,'y',$00,'d' 
                  DC.B      $00,$00,$0B,'|',$0C,'y',$03,' ' 
                  DC.B      $00,$00,$0B,'|n',$08,'3',$FC
                  DC.B      $FF,$FF,$00,$00,$00,$C4,'Nu'
                  DC.B      'A',$FA,$0A,$92,'G',$FA,$0A,$B6 
                  DC.B      'C',$FA,$0A,$DA,'E',$FA,$0E,$D6 
                  DC.B      'I',$FA,$0A,'|0',$1C,'4',$1C
                  DC.B      '8',$1C,'22',$00,$00,'01' 
                  DC.B      $00,$00,'62 ',$00,'41'
                  DC.B      ' ',$00,':2@',$00,'81'
                  DC.B      '@',$00,'~',$0F,'<',$04,$CD,$C2 
                  DC.B      $EE,$A6,'0',$C6,'<',$04,$CD,$C1 
                  DC.B      $EE,$A6,$CD,$C3,$EE,$A6,'0',$86 
                  DC.B      '<',$00,$CD,$C5,$EE,$A6,$9D,'X' 
                  DC.B      '<',$00,$CD,$C4,$EE,$A6,$CD,$C3 
                  DC.B      $EE,$A6,'0',$86,'<',$01,$CD,$C5 
                  DC.B      $EE,$A6,$DD,'X<',$02,$CD,$C5
                  DC.B      $EE,$A6,'0',$C6,'<',$01,$CD,$C3 
                  DC.B      $EE,$A6,$CD,$C5,$EE,$A6,'0',$86 
                  DC.B      '<',$00,$CD,$C4,$EE,$A6,$DD,'X' 
                  DC.B      '<',$03,$CD,$C0,$EE,$A6,$CD,$C5 
                  DC.B      $EE,$A6,'0',$86,'<',$01,$CD,$C4 
                  DC.B      $EE,$A6,$9D,'XDC0',$C3
                  DC.B      '<',$01,$CD,$C2,$EE,$A6,'0',$C6 
                  DC.B      $C1,$C2,$EE,$A0,'0',$C0,'A',$FA 
                  DC.B      $09,$EC,'"z',$09,$84,'$z' 
                  DC.B      $09,$CC,'G',$FA,$09,$D0,'<',$19 
                  DC.B      'L',$91,$00,$07,$C1,$D8,$C3,$D8 
                  DC.B      $C5,$D8,$D0,$81,$D0,$82,$EE,$A0 
                  DC.B      $D0,'k',$00,$04,'L',$91,$00,$0E 
                  DC.B      $C3,$D8,$C5,$D8,$C7,$D8,$D2,$82 
                  DC.B      $D2,$83,$EE,$A1,$D2,'k',$00,$06 
                  DC.B      'L',$99,$00,$1C,$C5,$D8,$C7,$D8 
                  DC.B      $C9,$D8,$D4,$83,$D4,$84,$EE,$A2 
                  DC.B      $E1,$88,$E1,$89,$D4,'k',$00,$08 
                  DC.B      'H',$C2,$81,$C2,$83,$C2,$D0,'S' 
                  DC.B      $D2,'k',$00,$02,'H',$92,$00,$03 
                  DC.B      'XJA',$E8,$FF,$EE,'Q',$CE 
                  DC.B      $FF,$A8,'Nu*z',$09,'f'
                  DC.B      '&z',$09,$1A,'?',$1B,'a',$00
                  DC.B      $04,$1A,'0',$1B,'?',$00,'a',$00 
                  DC.B      $04,'<0',$1F,'J9',$00,$00 
                  DC.B      $06,$8C,'g',$0C,'G',$F3,$02,$04 
                  DC.B      'SWj',$E2,'TONu'
                  DC.B      'N',$F0,$05,$B2,$00,$00,$06,$8E 
                  DC.B      $00,$00,'8',$1B,'L',$B5,$00,$03 
                  DC.B      'D',$00,'8',$13,'L',$B5,$00,$0C 
                  DC.B      'D',$00,'a',$00,$08,' 8',$1B
                  DC.B      'L',$B5,$00,$03,'D',$00,'8',$13 
                  DC.B      'L',$B5,$00,$0C,'D',$00,'a',$00 
                  DC.B      $08,$0C,'8',$1B,'L',$B5,$00,$03 
                  DC.B      'D',$00,'8',$13,'L',$B5,$00,$0C 
                  DC.B      'D',$00,'a',$00,$07,$F8,'8',$1B 
                  DC.B      'L',$B5,$00,$03,'D',$00,'8',$13 
                  DC.B      'L',$B5,$00,$0C,'D',$00,'a',$00 
                  DC.B      $07,$E4,'8',$1B,'L',$B5,$00,$03 
                  DC.B      'D',$00,'8',$13,'L',$B5,$00,$0C 
                  DC.B      'D',$00,'a',$00,$07,$D0,'8',$1B 
                  DC.B      'L',$B5,$00,$03,'D',$00,'8',$13 
                  DC.B      'L',$B5,$00,$0C,'D',$00,'a',$00 
                  DC.B      $07,$BC,'8',$1B,'L',$B5,$00,$03 
                  DC.B      'D',$00,'8',$13,'L',$B5,$00,$0C 
                  DC.B      'D',$00,'a',$00,$07,$A8,'8',$1B 
                  DC.B      'L',$B5,$00,$03,'D',$00,'8',$13 
                  DC.B      'L',$B5,$00,$0C,'D',$00,'a',$00 
                  DC.B      $07,$94,'0:',$08,$94,'2:' 
                  DC.B      $08,$92,$92,'@n',$0C,'XK' 
                  DC.B      'SWj',$00,$FF,'"TO' 
                  DC.B      'Nu>',$01,' y',$00,$00
                  DC.B      $0B,'`TK4',$1B,$D4,'B'
                  DC.B      $D0,$C2,'I',$FA,'\`M',$FA 
                  DC.B      '^N',$D1,$F0,$05,$B0,$00,$00
                  DC.B      $06,$AE,'I',$F4,$02,$00,'M',$F6 
                  DC.B      $02,$00,'HSa',$00,$00,$0E 
                  DC.B      '&_SWj',$00,$FE,$E8 
                  DC.B      'TONuHU&<'
                  DC.B      $00,$00,$04,'<$HG',$FA
                  DC.B      ' ,C',$FA,'E',$A8,'t',$FF 
                  DC.B      '0',$1C,'2',$1E,' 3',$04,$00
                  DC.B      '"1',$14,$00,' J',$D0,$C0 
                  DC.B      $92,'@*C*u',$10,$00 
                  DC.B      'N',$D5,'1B',$01,'`1B'
                  DC.B      $01,'P1B',$01,'@1B' 
                  DC.B      $01,'01B',$01,' 1B' 
                  DC.B      $01,$10,'1B',$01,$00,'1B' 
                  DC.B      $00,$F0,'1B',$00,$E0,'1B' 
                  DC.B      $00,$D0,'1B',$00,$C0,'1B' 
                  DC.B      $00,$B0,'1B',$00,$A0,'1B' 
                  DC.B      $00,$90,'1B',$00,$80,'1B' 
                  DC.B      $00,'p1B',$00,'`1B' 
                  DC.B      $00,'P1B',$00,'@1B' 
                  DC.B      $00,'01B',$00,' 1B' 
                  DC.B      $00,$10,'H@�P0',$01 
                  DC.B      'HA',$83,'p',$00,$00,'E',$EA
                  DC.B      $01,$80,'Q',$CF,$FF,'|*_' 
                  DC.B      'Nu',$C2,$80,'HA',$83,'P' 
                  DC.B      'E',$EA,$01,$80,'Q',$CF,$FF,'j' 
                  DC.B      '*_Nu',$00,$00,$03,$BE
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$BE 
                  DC.B      $00,$00,$03,$BE,$00,$00,$03,$CA 
                  DCB.W     7,0 
                  DC.B      $03,$B2,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$AE,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$AA,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$A6,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$A2,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$9E,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$9A,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$96,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$92,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$8E,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$8A,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$86,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,$82,$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'~',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'z',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'v',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'r',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'n',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'j',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'f',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'b',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'^',$00,$00,$00,$00,$00,$00 
                  DCB.W     4,0 
                  DC.B      $03,'Z',$00,$00,$00,$00,$00,$00 
                  DCB.W     3,0 
                  DC.B      'A',$FA,$1D,$A6,'C',$FA,'C"'
                  DC.B      't',$00,'v',$00,'0<',$00,$17
                  DC.B      'E',$FA,$0E,$06,'G',$FA,$0E,'"' 
                  DC.B      '2<',$00,$0F,'4',$1A,'6',$1B
                  DC.B      'HBHC ',$C2,'"',$C3 
                  DC.B      'HBHCQ',$C9,$FF,$EE 
                  DC.B      $06,$82,$00,$10,$00,$00,$06,$83 
                  DC.B      $00,$10,$00,$00,'Q',$C8,$FF,$D2 
                  DC.B      'A',$FA,$1D,'fC',$FA,'B',$E2
                  DC.B      'E',$E8,$06,$00,'G',$E9,$06,$00 
                  DC.B      ' ',$10,'"',$11,'$*',$FF,$FC
                  DC.B      '&+',$FF,$FC,'8<',$01,$7F 
                  DC.B      '!',$00,'#',$01,'$',$C2,'&',$C3 
                  DC.B      'Q',$CC,$FF,$F6,'Nu3',$FC 
                  DC.B      $00,$EF,$00,$00,$0B,'pBy' 
                  DC.B      $00,$00,$0B,'rNu',$B2,'z' 
                  DC.B      $05,'4l',$06,'3',$C1,$00,$00
                  DC.B      $0B,'p',$B6,'z',$05,'*o',$06
                  DC.B      '3',$C3,$00,$00,$0B,'rNu' 
                  DC.B      '0',$13,'25',$04,$00,'45' 
                  DC.B      $04,$02,'0+',$00,$02,'65' 
                  DC.B      $04,$00,'85',$04,$02,'0+' 
                  DC.B      $00,$04,':5',$04,$00,'<5' 
                  DC.B      $04,$02,$96,'A',$98,'BšA' 
                  DC.B      $9C,'B',$CD,$C3,$CB,$C4,$9A,$86 
                  DC.B      '[',$F9,$00,$00,$06,$8C,'Nu'
                  DCB.W     2,0 
                  DC.B      $02,$DA,$00,$00,$02,$C6,$00,$00 
                  DC.B      $02,$B2,$00,$00,$02,$9E,$00,$00 
                  DC.B      $02,$8A,$00,$00,$02,'v',$00,$00 
                  DC.B      $02,'b',$00,$00,$02,'N',$00,$00 
                  DCB.W     2,0 
                  DC.B      $01,$80,$00,$00,$03,$00,$00,$00 
                  DC.B      $04,$80,$00,$00,$06,$00,$00,$00 
                  DC.B      $07,$80,$00,$00,$09,$00,$00,$00 
                  DC.B      $0A,$80,$00,$00,$0C,$00,$00,$00 
                  DC.B      $0D,$80,$00,$00,$0F,$00,$00,$00 
                  DC.B      $10,$80,$00,$00,$12,$00,$00,$00 
                  DC.B      $13,$80,$00,$00,$15,$00,$00,$00 
                  DC.B      $16,$80,$00,$00,$18,$00,$00,$00 
                  DC.B      $19,$80,$00,$00,$1B,$00,$00,$00 
                  DC.B      $1C,$80,$00,$00,$1E,$00,$00,$00 
                  DC.B      $1F,$80,$00,$00,'!',$00,$00,$00 
                  DC.B      '"',$80,$00,$00,'$',$00,$00,$00 
                  DC.B      '%',$80,$00,$00,$27,$00,$00,$00 
                  DC.B      '(',$80,$00,$00,'*',$00,$00,$00 
                  DC.B      '+',$80,$00,$00,'-',$00,$00,$00 
                  DC.B      '.',$80,$00,$00,'0',$00,$00,$00 
                  DC.B      '1',$80,$00,$00,'3',$00,$00,$00 
                  DC.B      '4',$80,$00,$00,'6',$00,$00,$00 
                  DC.B      '7',$80,$00,$00,'9',$00,$00,$00 
                  DC.B      ':',$80,$00,$00,'<',$00,$00,$00 
                  DC.B      '=',$80,$00,$00,'?',$00,$00,$00 
                  DC.B      '@',$80,$00,$00,'B',$00,$00,$00 
                  DC.B      'C',$80,$00,$00,'E',$00,$00,$00 
                  DC.B      'F',$80,$00,$00,'H',$00,$00,$00 
                  DC.B      'I',$80,$00,$00,'K',$00,$00,$00 
                  DC.B      'L',$80,$00,$00,'N',$00,$00,$00 
                  DC.B      'O',$80,$00,$00,'Q',$00,$00,$00 
                  DC.B      'R',$80,$00,$00,'T',$00,$00,$00 
                  DC.B      'U',$80,$00,$00,'W',$00,$00,$00 
                  DC.B      'X',$80,$00,$00,'Z',$00,$00,$00 
                  DC.B      '[',$80,$00,$00,']',$00,$00,$00 
                  DC.B      '^',$80,$00,$00,'`',$00,$00,$00 
                  DC.B      'a',$80,$00,$00,'c',$00,$00,$00 
                  DC.B      'd',$80,$00,$00,'f',$00,$00,$00 
                  DC.B      'g',$80,$00,$00,'i',$00,$00,$00 
                  DC.B      'j',$80,$00,$00,'l',$00,$00,$00 
                  DC.B      'm',$80,$00,$00,'o',$00,$00,$00 
                  DC.B      'p',$80,$00,$00,'r',$00,$00,$00 
                  DC.B      's',$80,$00,$00,'u',$00,$00,$00 
                  DC.B      'v',$80,$00,$00,'x',$00,$00,$00 
                  DC.B      'y',$80,$00,$00,'{',$00,$00,$00 
                  DC.B      '|',$80,$00,$00,'~',$00,$00,$00 
                  DC.B      $7F,$80,$00,$00,$81,$00,$00,$00 
                  DC.B      $82,$80,$00,$00,$84,$00,$00,$00 
                  DC.B      $85,$80,$00,$00,$87,$00,$00,$00 
                  DC.B      $88,$80,$00,$00,$8A,$00,$00,$00 
                  DC.B      $8B,$80,$00,$00,$8D,$00,$00,$00 
                  DC.B      $8E,$80,$00,$00,$90,$00,$00,$00 
                  DC.B      $91,$80,$00,$00,$93,$00,$00,$00 
                  DC.B      $94,$80,$00,$00,$96,$00,$00,$00 
                  DC.B      $97,$80,$00,$00,$99,$00,$00,$00 
                  DC.B      $9A,$80,$00,$00,$9C,$00,$00,$00 
                  DC.B      $9D,$80,$00,$00,$9F,$00,$00,$00 
                  DC.B      $A0,$80,$00,$00,$A2,$00,$00,$00 
                  DC.B      $A3,$80,$00,$00,$A5,$00,$00,$00 
                  DC.B      $A6,$80,$00,$00,$A8,$00,$00,$00 
                  DC.B      $A9,$80,$00,$00,$AB,$00,$00,$00 
                  DC.B      $AC,$80,$00,$00,$AE,$00,$00,$00 
                  DC.B      $AF,$80,$00,$00,$B1,$00,$00,$00 
                  DC.B      $B2,$80,$00,$00,$B4,$00,$00,$00 
                  DC.B      $B5,$80,$00,$00,$B7,$00,$00,$00 
                  DC.B      $B8,$80,$00,$00,$BA,$00,$00,$00 
                  DC.B      $BB,$80,$00,$00,$BD,$00,$00,$00 
                  DC.B      $BE,$80,$00,$00,$C0,$00,$00,$00 
                  DC.B      $C1,$80,$00,$00,$C3,$00,$00,$00 
                  DC.B      $C4,$80,$00,$00,$C6,$00,$00,$00 
                  DC.B      $C7,$80,$00,$00,$C9,$00,$00,$00 
                  DC.B      $CA,$80,$00,$00,$CC,$00,$00,$00 
                  DC.B      $CD,$80,$00,$00,$CF,$00,$00,$00 
                  DC.B      $D0,$80,$00,$00,$D2,$00,$00,$00 
                  DC.B      $D3,$80,$00,$00,$D5,$00,$00,$00 
                  DC.B      $D6,$80,$00,$00,$D8,$00,$00,$00 
                  DC.B      $D9,$80,$00,$00,$DB,$00,$00,$00 
                  DC.B      $DC,$80,$00,$00,$DE,$00,$00,$00 
                  DC.B      $DF,$80,$00,$00,$E1,$00,$00,$00 
                  DC.B      $E2,$80,$00,$00,$E4,$00,$00,$00 
                  DC.B      $E5,$80,$00,$00,$E7,$00,$00,$00 
                  DC.B      $E8,$80,$00,$00,$EA,$00,$00,$00 
                  DC.B      $EB,$80,$00,$00,$ED,$00,$00,$00 
                  DC.B      $EE,$80,$00,$00,$F0,$00,$00,$00 
                  DC.B      $F1,$80,$00,$00,$F3,$00,$00,$00 
                  DC.B      $F4,$80,$00,$00,$F6,$00,$00,$00 
                  DC.B      $F7,$80,$00,$00,$F9,$00,$00,$00 
                  DC.B      $FA,$80,$00,$00,$FC,$00,$00,$00 
                  DC.B      $FD,$80,$00,$00,$FF,$00,$00,$01 
                  DC.B      $00,$80,$00,$01,$02,$00,$00,$01 
                  DC.B      $03,$80,$00,$01,$05,$00,$00,$01 
                  DC.B      $06,$80,$00,$01,$08,$00,$00,$01 
                  DC.B      $09,$80,$00,$01,$0B,$00,$00,$01 
                  DC.B      $0C,$80,$00,$01,$0E,$00,$00,$01 
                  DC.B      $0F,$80,$00,$01,$11,$00,$00,$01 
                  DC.B      $12,$80,$00,$01,$14,$00,$00,$01 
                  DC.B      $15,$80,$00,$01,$17,$00,$00,$01 
                  DC.B      $18,$80,$00,$01,$1A,$00,$00,$01 
                  DC.B      $1B,$80,$00,$01,$1D,$00,$00,$01 
                  DC.B      $1E,$80,$00,$01,' ',$00,$00,$01 
                  DC.B      '!',$80,$00,$01,'#',$00,$00,$01 
                  DC.B      '$',$80,$00,$01,'&',$00,$00,$01 
                  DC.B      $27,$80,$00,$01,')',$00,$00,$01 
                  DC.B      '*',$80,$00,$01,',',$00,$00,$01 
                  DC.B      '-',$80,$00,$01,'/',$00,$00,$01 
                  DC.B      '0',$80,$00,$01,'2',$00,$00,$01 
                  DC.B      '3',$80,$00,$01,'5',$00,$00,$01 
                  DC.B      '6',$80,$00,$01,'8',$00,$00,$01 
                  DC.B      '9',$80,$00,$01,';',$00,$00,$01 
                  DC.B      '<',$80,$00,$01,'>',$00,$00,$01 
                  DC.B      '?',$80,$00,$01,'A',$00,$00,$01 
                  DC.B      'B',$80,$00,$01,'D',$00,$00,$01 
                  DC.B      'E',$80,$00,$01,'G',$00,$00,$01 
                  DC.B      'H',$80,$00,$01,'J',$00,$00,$01 
                  DC.B      'K',$80,$00,$01,'M',$00,$00,$01 
                  DC.B      'N',$80,$00,$01,'P',$00,$00,$01 
                  DC.B      'Q',$80,$00,$01,'S',$00,$00,$01 
                  DC.B      'T',$80,$00,$01,'V',$00,$00,$01 
                  DC.B      'W',$80,$00,$01,'Y',$00,$00,$01 
                  DC.B      'Z',$80,$00,$01,'\',$00,$00,$01 
                  DC.B      ']',$80,$00,$01,'_',$00,$00,$01 
                  DC.B      '`',$80,$00,$01,'b',$00,$00,$01 
                  DC.B      'c',$80,$00,$01,'e',$00,'Nu'
                  DC.B      'x',$00,$B6,'Ag',$F8,'n',$0A
                  DC.B      $C1,'B',$C3,'CM',$FA,'V',$DC
                  DC.B      '`',$04,'M',$FA,'T',$E4,$B2,'|' 
                  DC.B      $00,$EE,'n',$E2,'JAj',$16 
                  DC.B      '>',$03,'k',$DA,$9E,'A<',$02
                  DC.B      $9C,'@',$CD,$C3,$8D,$C7,$9C,'B' 
                  DC.B      'DF0',$06,'r',$00,$B6,'|' 
                  DC.B      $00,$EE,'o',$1A,'>',$03,$9E,'A' 
                  DC.B      '<',$02,$9C,'@:<',$00,$EE 
                  DC.B      'šA',$CD,$C5,$8D,$C7,$DC,'@'
                  DC.B      '4',$06,'6<',$00,$EE,'a',$00
                  DC.B      $FB,'v>',$03,'8',$02,$98,'@'
                  DC.B      ':',$03,'šAg',$98,'k',$96 
                  DC.B      $9E,'A',$DC,$C1,$DC,$C1,'H',$C4 
                  DC.B      $EF,$84,$89,$C5,'H',$C4,$E1,$84 
                  DC.B      $D8,$84,'H@0',$04,'g',$12 
                  DC.B      $06,'@',$80,$00,'H@HD'
                  DC.B      '<',$C0,$D1,$84,'Q',$CF,$FF,$FA 
                  DC.B      'NuHDg',$0C,'H@'
                  DC.B      '<',$C0,$D0,'DQ',$CF,$FF,$FA
                  DC.B      'NuH@<',$C0,'Q',$CF 
                  DC.B      $FF,$FC,'Nu',$00,$08,$00,$01
                  DC.B      $00,$08,$00,$12,$00,$00,$0B,'(' 
                  DC.B      $00,$00,$0B,'B',$00,$03,$FD,$80 
                  DC.B      $FD,$80,$FF,'`',$FD,$80,$02,$80 
                  DC.B      $FF,'`',$02,$80,$02,$80,$FF,'`' 
                  DC.B      $02,$80,$FD,$80,$FF,'`',$00,$01 
                  DC.B      $00,$04,$00,$00,$00,$01,$00,$02 
                  DC.B      $00,$03,$00,$00,$00,$05,$00,$04 
                  DC.B      $00,$00,$00,$03,$00,$02,$00,$01 
                  DC.B      $00,$00,$00,$05,$00,$00,$00,$00 
                  DCB.W     5,0 
                  DC.B      'cH',$00,$00,$00,$00,$00,$C0
                  DC.B      $00,'d',$00,$00,$00,$00,'0',$D4 
                  DC.B      $00,$04,$00,$04,$00,$00,$00,$00 
                  DCB.W     39,0
                  DC.B      $7F,$FF,$7F,$FD,$7F,$F5,$7F,$E9 
                  DC.B      $7F,$D8,$7F,$C2,$7F,$A7,$7F,$87 
                  DC.B      $7F,'b',$7F,'8',$7F,$09,'~',$D5 
                  DC.B      '~',$9D,'~_~',$1D,'}',$D6 
                  DC.B      '}',$8A,'}9|',$E3,'|',$89 
                  DC.B      '|){',$C5,'{\z',$EF 
                  DC.B      'z|z',$05,'y',$89,'y',$09 
                  DC.B      'x„w',$FA,'wlv',$D9 
                  DC.B      'vAu',$A5,'u',$04,'t_'
                  DC.B      's',$B5,'s',$07,'rUqž'
                  DC.B      'p',$E2,'p"o^n',$96 
                  DC.B      'm',$C9,'l',$F9,'l$kJ'
                  DC.B      'jmi',$8C,'h',$A6,'g',$BC 
                  DC.B      'f',$CF,'e',$DD,'d',$E8,'c',$EF 
                  DC.B      'b',$F1,'a',$F0,'`',$EC,'_',$E3 
                  DC.B      '^',$D7,']',$C7,'\',$B4,'[',$9C 
                  DC.B      'Z',$82,'YdXBW',$1D 
                  DC.B      'U',$F5,'T',$C9,'S',$9B,'Rh'
                  DC.B      'Q3O',$FB,'N',$BF,'M�'
                  DC.B      'L?J',$FB,'I',$B3,'Hi'
                  DC.B      'G',$1C,'E',$CD,'DzC%'
                  DC.B      'A',$CE,'@s?',$17,'=',$B8 
                  DC.B      '<V:',$F2,'9',$8C,'8$'
                  DC.B      '6',$BA,'5M3',$DE,'2n'
                  DC.B      '0',$FB,'/',$87,'.',$10,',',$98 
                  DC.B      '+',$1F,')',$A3,'(&&',$A8 
                  DC.B      '%(#',$A6,'"# ',$9F 
                  DC.B      $1F,$19,$1D,$93,$1C,$0B,$1A,$82 
                  DC.B      $18,$F8,$17,'m',$15,$E2,$14,'U' 
                  DC.B      $12,$C8,$11,'9',$0F,$AB,$0E,$1B 
                  DC.B      $0C,$8B,$0A,$FB,$09,'j',$07,$D9 
                  DC.B      $06,'G',$04,$B6,$03,'$',$01,$92 
                  DC.B      $00,$00,$FE,'n',$FC,$DC,$FB,'J' 
                  DC.B      $F9,$B9,$F8,$27,$F6,$96,$F5,$05 
                  DC.B      $F3,'u',$F1,$E5,$F0,'U',$EE,$C7 
                  DC.B      $ED,'8',$EB,$AB,$EA,$1E,$E8,$93 
                  DC.B      $E7,$08,$E5,'~',$E3,$F5,$E2,'m' 
                  DC.B      $E0,$E7,$DF,'a',$DD,$DD,$DC,'Z' 
                  DC.B      $DA,$D8,$D9,'X',$D7,$DA,$D6,']' 
                  DC.B      $D4,$E1,$D3,'h',$D1,$F0,$D0,'y' 
                  DC.B      $CF,$05,$CD,$92,$CC,'"',$CA,$B3 
                  DC.B      $C9,'F',$C7,$DC,$C6,'t',$C5,$0E 
                  DC.B      $C3,$AA,$C2,'H',$C0,$E9,$BF,$8D 
                  DC.B      $BE,'2',$BC,$DB,$BB,$86,$BA,'3' 
                  DC.B      $B8,$E4,$B7,$97,$B6,'M',$B5,$05 
                  DC.B      $B3,$C1,$B2,$7F,$B1,'A',$B0,$05 
                  DC.B      $AE,$CD,$AD,$98,$AC,'e',$AB,'7' 
                  DC.B      $AA,$0B,$A8,$E3,$A7,$BE,$A6,$9C 
                  DC.B      $A5,'~',$A4,'d',$A3,'L',$A2,'9' 
                  DC.B      $A1,')',$A0,$1D,$9F,$14,$9E,$10 
                  DC.B      $9D,$0F,$9C,$11,$9B,$18,'š#'
                  DC.B      '™1',$98,'D',$97,'Z',$96,'t'
                  DC.B      $95,$93,$94,$B6,$93,$DC,$93,$07 
                  DC.B      $92,'7',$91,'j',$90,$A2,$8F,$DE 
                  DC.B      $8F,$1E,'Žb',$8D,$AB,$8C,$F9
                  DC.B      $8C,'K',$8B,$A1,$8A,$FC,$8A,'[' 
                  DC.B      $89,$BF,$89,$27,$88,$94,$88,$06 
                  DC.B      $87,'|',$86,$F7,$86,'w',$85,$FB 
                  DC.B      $85,$84,$85,$11,$84,$A4,$84,';' 
                  DC.B      $83,$D7,$83,'w',$83,$1D,$82,$C7 
                  DC.B      $82,'v',$82,'*',$81,$E3,$81,$A1 
                  DC.B      $81,'c�+',$80,$F7,$80,$C8 
                  DC.B      $80,$9E,$80,'y',$80,'Y',$80,'>' 
                  DC.B      $80,'(',$80,$17,$80,$0B,$80,$03 
                  DC.B      $80,$01,$80,$03,$80,$0B,$80,$17 
                  DC.B      $80,'(',$80,'>',$80,'Y',$80,'y' 
                  DC.B      $80,$9E,$80,$C8,$80,$F7,$81,'+' 
                  DC.B      '�c',$81,$A1,$81,$E3,$82,'*'
                  DC.B      $82,'v',$82,$C7,$83,$1D,$83,'w' 
                  DC.B      $83,$D7,$84,';',$84,$A4,$85,$11 
                  DC.B      $85,$84,$85,$FB,$86,'w',$86,$F7 
                  DC.B      $87,'|',$88,$06,$88,$94,$89,$27 
                  DC.B      $89,$BF,$8A,'[',$8A,$FC,$8B,$A1 
                  DC.B      $8C,'K',$8C,$F9,$8D,$AB,'Žb'
                  DC.B      $8F,$1E,$8F,$DE,$90,$A2,$91,'j' 
                  DC.B      $92,'7',$93,$07,$93,$DC,$94,$B6 
                  DC.B      $95,$93,$96,'t',$97,'Z',$98,'D' 
                  DC.B      '™1š#',$9B,$18,$9C,$11
                  DC.B      $9D,$0F,$9E,$10,$9F,$14,$A0,$1D 
                  DC.B      $A1,')',$A2,'9',$A3,'L',$A4,'d' 
                  DC.B      $A5,'~',$A6,$9C,$A7,$BE,$A8,$E3 
                  DC.B      $AA,$0B,$AB,'7',$AC,'e',$AD,$98 
                  DC.B      $AE,$CD,$B0,$05,$B1,'A',$B2,$7F 
                  DC.B      $B3,$C1,$B5,$05,$B6,'M',$B7,$97 
                  DC.B      $B8,$E4,$BA,'3',$BB,$86,$BC,$DB 
                  DC.B      $BE,'2',$BF,$8D,$C0,$E9,$C2,'H' 
                  DC.B      $C3,$AA,$C5,$0E,$C6,'t',$C7,$DC 
                  DC.B      $C9,'F',$CA,$B3,$CC,'"',$CD,$92 
                  DC.B      $CF,$05,$D0,'y',$D1,$F0,$D3,'h' 
                  DC.B      $D4,$E1,$D6,']',$D7,$DA,$D9,'X' 
                  DC.B      $DA,$D8,$DC,'Z',$DD,$DD,$DF,'a' 
                  DC.B      $E0,$E7,$E2,'m',$E3,$F5,$E5,'~' 
                  DC.B      $E7,$08,$E8,$93,$EA,$1E,$EB,$AB 
                  DC.B      $ED,'8',$EE,$C7,$F0,'U',$F1,$E5 
                  DC.B      $F3,'u',$F5,$05,$F6,$96,$F8,$27 
                  DC.B      $F9,$B9,$FB,'J',$FC,$DC,$FE,'n' 
                  DC.B      $00,$00,$01,$92,$03,'$',$04,$B6 
                  DC.B      $06,'G',$07,$D9,$09,'j',$0A,$FB 
                  DC.B      $0C,$8B,$0E,$1B,$0F,$AB,$11,'9' 
                  DC.B      $12,$C8,$14,'U',$15,$E2,$17,'m' 
                  DC.B      $18,$F8,$1A,$82,$1C,$0B,$1D,$93 
                  DC.B      $1F,$19,' ',$9F,'"##',$A6 
                  DC.B      '%(&',$A8,'(&)',$A3 
                  DC.B      '+',$1F,',',$98,'.',$10,'/',$87 
                  DC.B      '0',$FB,'2n3',$DE,'5M'
                  DC.B      '6',$BA,'8$9',$8C,':',$F2 
                  DC.B      '<V=',$B8,'?',$17,'@s'
                  DC.B      'A',$CE,'C%DzE',$CD 
                  DC.B      'G',$1C,'HiI',$B3,'J',$FB 
                  DC.B      'L?M�N',$BF,'O',$FB 
                  DC.B      'Q3RhS',$9B,'T',$C9 
                  DC.B      'U',$F5,'W',$1D,'XBYd'
                  DC.B      'Z',$82,'[',$9C,'\',$B4,']',$C7 
                  DC.B      '^',$D7,'_',$E3,'`',$EC,'a',$F0 
                  DC.B      'b',$F1,'c',$EF,'d',$E8,'e',$DD 
                  DC.B      'f',$CF,'g',$BC,'h',$A6,'i',$8C 
                  DC.B      'jmkJl$l',$F9 
                  DC.B      'm',$C9,'n',$96,'o^p"'
                  DC.B      'p',$E2,'qžrUs',$07 
                  DC.B      's',$B5,'t_u',$04,'u',$A5 
                  DC.B      'vAv',$D9,'wlw',$FA 
                  DC.B      'x„y',$09,'y',$89,'z',$05 
                  DC.B      'z|z',$EF,'{\{',$C5 
                  DC.B      '|)|',$89,'|',$E3,'}9'
                  DC.B      '}',$8A,'}',$D6,'~',$1D,'~_'
                  DC.B      '~',$9D,'~',$D5,$7F,$09,$7F,'8' 
                  DC.B      $7F,'b',$7F,$87,$7F,$A7,$7F,$C2 
                  DC.B      $7F,$D8,$7F,$E9,$7F,$F5,$7F,$FD 
                  DC.B      $00,$00,$01,$92,$03,'$',$04,$B6 
                  DC.B      $06,'G',$07,$D9,$09,'j',$0A,$FB 
                  DC.B      $0C,$8B,$0E,$1B,$0F,$AB,$11,'9' 
                  DC.B      $12,$C8,$14,'U',$15,$E2,$17,'m' 
                  DC.B      $18,$F8,$1A,$82,$1C,$0B,$1D,$93 
                  DC.B      $1F,$19,' ',$9F,'"##',$A6 
                  DC.B      '%(&',$A8,'(&)',$A3 
                  DC.B      '+',$1F,',',$98,'.',$10,'/',$87 
                  DC.B      '0',$FB,'2n3',$DE,'5M'
                  DC.B      '6',$BA,'8$9',$8C,':',$F2 
                  DC.B      '<V=',$B8,'?',$17,'@s'
                  DC.B      'A',$CE,'C%DzE',$CD 
                  DC.B      'G',$1C,'HiI',$B3,'J',$FB 
                  DC.B      'L?M�N',$BF,'O',$FB 
                  DC.B      'Q3RhS',$9B,'T',$C9 
                  DC.B      'U',$F5,'W',$1D,'XBYd'
                  DC.B      'Z',$82,'[',$9C,'\',$B4,']',$C7 
                  DC.B      '^',$D7,'_',$E3,'`',$EC,'a',$F0 
                  DC.B      'b',$F1,'c',$EF,'d',$E8,'e',$DD 
                  DC.B      'f',$CF,'g',$BC,'h',$A6,'i',$8C 
                  DC.B      'jmkJl$l',$F9 
                  DC.B      'm',$C9,'n',$96,'o^p"'
                  DC.B      'p',$E2,'qžrUs',$07 
                  DC.B      's',$B5,'t_u',$04,'u',$A5 
                  DC.B      'vAv',$D9,'wlw',$FA 
                  DC.B      'x„y',$09,'y',$89,'z',$05 
                  DC.B      'z|z',$EF,'{\{',$C5 
                  DC.B      '|)|',$89,'|',$E3,'}9'
                  DC.B      '}',$8A,'}',$D6,'~',$1D,'~_'
                  DC.B      '~',$9D,'~',$D5,$7F,$09,$7F,'8' 
                  DC.B      $7F,'b',$7F,$87,$7F,$A7,$7F,$C2 
                  DC.B      $7F,$D8,$7F,$E9,$7F,$F5,$7F,$FD 
                  DC.B      $7F,$FF,$7F,$FD,$7F,$F5,$7F,$E9 
                  DC.B      $7F,$D8,$7F,$C2,$7F,$A7,$7F,$87 
                  DC.B      $7F,'b',$7F,'8',$7F,$09,'~',$D5 
                  DC.B      '~',$9D,'~_~',$1D,'}',$D6 
                  DC.B      '}',$8A,'}9|',$E3,'|',$89 
                  DC.B      '|){',$C5,'{\z',$EF 
                  DC.B      'z|z',$05,'y',$89,'y',$09 
                  DC.B      'x„w',$FA,'wlv',$D9 
                  DC.B      'vAu',$A5,'u',$04,'t_'
                  DC.B      's',$B5,'s',$07,'rUqž'
                  DC.B      'p',$E2,'p"o^n',$96 
                  DC.B      'm',$C9,'l',$F9,'l$kJ'
                  DC.B      'jmi',$8C,'h',$A6,'g',$BC 
                  DC.B      'f',$CF,'e',$DD,'d',$E8,'c',$EF 
                  DC.B      'b',$F1,'a',$F0,'`',$EC,'_',$E3 
                  DC.B      '^',$D7,']',$C7,'\',$B4,'[',$9C 
                  DC.B      'Z',$82,'YdXBW',$1D 
                  DC.B      'U',$F5,'T',$C9,'S',$9B,'Rh'
                  DC.B      'Q3O',$FB,'N',$BF,'M�'
                  DC.B      'L?J',$FB,'I',$B3,'Hi'
                  DC.B      'G',$1C,'E',$CD,'DzC%'
                  DC.B      'A',$CE,'@s?',$17,'=',$B8 
                  DC.B      '<V:',$F2,'9',$8C,'8$'
                  DC.B      '6',$BA,'5M3',$DE,'2n'
                  DC.B      '0',$FB,'/',$87,'.',$10,',',$98 
                  DC.B      '+',$1F,')',$A3,'(&&',$A8 
                  DC.B      '%(#',$A6,'"# ',$9F 
                  DC.B      $1F,$19,$1D,$93,$1C,$0B,$1A,$82 
                  DC.B      $18,$F8,$17,'m',$15,$E2,$14,'U' 
                  DC.B      $12,$C8,$11,'9',$0F,$AB,$0E,$1B 
                  DC.B      $0C,$8B,$0A,$FB,$09,'j',$07,$D9 
                  DC.B      $06,'G',$04,$B6,$03,'$',$01,$92 
                  DC.B      $00,$00,$FE,'n',$FC,$DC,$FB,'J' 
                  DC.B      $F9,$B9,$F8,$27,$F6,$96,$F5,$05 
                  DC.B      $F3,'u',$F1,$E5,$F0,'U',$EE,$C7 
                  DC.B      $ED,'8',$EB,$AB,$EA,$1E,$E8,$93 
                  DC.B      $E7,$08,$E5,'~',$E3,$F5,$E2,'m' 
                  DC.B      $E0,$E7,$DF,'a',$DD,$DD,$DC,'Z' 
                  DC.B      $DA,$D8,$D9,'X',$D7,$DA,$D6,']' 
                  DC.B      $D4,$E1,$D3,'h',$D1,$F0,$D0,'y' 
                  DC.B      $CF,$05,$CD,$92,$CC,'"',$CA,$B3 
                  DC.B      $C9,'F',$C7,$DC,$C6,'t',$C5,$0E 
                  DC.B      $C3,$AA,$C2,'H',$C0,$E9,$BF,$8D 
                  DC.B      $BE,'2',$BC,$DB,$BB,$86,$BA,'3' 
                  DC.B      $B8,$E4,$B7,$97,$B6,'M',$B5,$05 
                  DC.B      $B3,$C1,$B2,$7F,$B1,'A',$B0,$05 
                  DC.B      $AE,$CD,$AD,$98,$AC,'e',$AB,'7' 
                  DC.B      $AA,$0B,$A8,$E3,$A7,$BE,$A6,$9C 
                  DC.B      $A5,'~',$A4,'d',$A3,'L',$A2,'9' 
                  DC.B      $A1,')',$A0,$1D,$9F,$14,$9E,$10 
                  DC.B      $9D,$0F,$9C,$11,$9B,$18,'š#'
                  DC.B      '™1',$98,'D',$97,'Z',$96,'t'
                  DC.B      $95,$93,$94,$B6,$93,$DC,$93,$07 
                  DC.B      $92,'7',$91,'j',$90,$A2,$8F,$DE 
                  DC.B      $8F,$1E,'Žb',$8D,$AB,$8C,$F9
                  DC.B      $8C,'K',$8B,$A1,$8A,$FC,$8A,'[' 
                  DC.B      $89,$BF,$89,$27,$88,$94,$88,$06 
                  DC.B      $87,'|',$86,$F7,$86,'w',$85,$FB 
                  DC.B      $85,$84,$85,$11,$84,$A4,$84,';' 
                  DC.B      $83,$D7,$83,'w',$83,$1D,$82,$C7 
                  DC.B      $82,'v',$82,'*',$81,$E3,$81,$A1 
                  DC.B      $81,'c�+',$80,$F7,$80,$C8 
                  DC.B      $80,$9E,$80,'y',$80,'Y',$80,'>' 
                  DC.B      $80,'(',$80,$17,$80,$0B,$80,$03 
                  DC.B      $80,$01,$80,$03,$80,$0B,$80,$17 
                  DC.B      $80,'(',$80,'>',$80,'Y',$80,'y' 
                  DC.B      $80,$9E,$80,$C8,$80,$F7,$81,'+' 
                  DC.B      '�c',$81,$A1,$81,$E3,$82,'*'
                  DC.B      $82,'v',$82,$C7,$83,$1D,$83,'w' 
                  DC.B      $83,$D7,$84,';',$84,$A4,$85,$11 
                  DC.B      $85,$84,$85,$FB,$86,'w',$86,$F7 
                  DC.B      $87,'|',$88,$06,$88,$94,$89,$27 
                  DC.B      $89,$BF,$8A,'[',$8A,$FC,$8B,$A1 
                  DC.B      $8C,'K',$8C,$F9,$8D,$AB,'Žb'
                  DC.B      $8F,$1E,$8F,$DE,$90,$A2,$91,'j' 
                  DC.B      $92,'7',$93,$07,$93,$DC,$94,$B6 
                  DC.B      $95,$93,$96,'t',$97,'Z',$98,'D' 
                  DC.B      '™1š#',$9B,$18,$9C,$11
                  DC.B      $9D,$0F,$9E,$10,$9F,$14,$A0,$1D 
                  DC.B      $A1,')',$A2,'9',$A3,'L',$A4,'d' 
                  DC.B      $A5,'~',$A6,$9C,$A7,$BE,$A8,$E3 
                  DC.B      $AA,$0B,$AB,'7',$AC,'e',$AD,$98 
                  DC.B      $AE,$CD,$B0,$05,$B1,'A',$B2,$7F 
                  DC.B      $B3,$C1,$B5,$05,$B6,'M',$B7,$97 
                  DC.B      $B8,$E4,$BA,'3',$BB,$86,$BC,$DB 
                  DC.B      $BE,'2',$BF,$8D,$C0,$E9,$C2,'H' 
                  DC.B      $C3,$AA,$C5,$0E,$C6,'t',$C7,$DC 
                  DC.B      $C9,'F',$CA,$B3,$CC,'"',$CD,$92 
                  DC.B      $CF,$05,$D0,'y',$D1,$F0,$D3,'h' 
                  DC.B      $D4,$E1,$D6,']',$D7,$DA,$D9,'X' 
                  DC.B      $DA,$D8,$DC,'Z',$DD,$DD,$DF,'a' 
                  DC.B      $E0,$E7,$E2,'m',$E3,$F5,$E5,'~' 
                  DC.B      $E7,$08,$E8,$93,$EA,$1E,$EB,$AB 
                  DC.B      $ED,'8',$EE,$C7,$F0,'U',$F1,$E5 
                  DC.B      $F3,'u',$F5,$05,$F6,$96,$F8,$27 
                  DC.B      $F9,$B9,$FB,'J',$FC,$DC,$FE,'n' 
                  DC.B      $FF,$FF,$7F,$FF,'?',$FF,$1F,$FF 
                  DC.B      $0F,$FF,$07,$FF,$03,$FF,$01,$FF 
                  DC.B      $00,$FF,$00,$7F,$00,'?',$00,$1F 
                  DC.B      $00,$0F,$00,$07,$00,$03,$00,$01 
                  DC.B      $00,$00,$80,$00,$C0,$00,$E0,$00 
                  DC.B      $F0,$00,$F8,$00,$FC,$00,$FE,$00 
                  DC.B      $FF,$00,$FF,$80,$FF,$C0,$FF,$E0 
                  DC.B      $FF,$F0,$FF,$F8,$FF,$FC,$FF,$FE 
                  DCB.W     10238,0 
                  DC.B      'BOB',$00,$00,$00,$00,$00 
                  DC.B      $A2,$00,$00,$00,$02,':VB' 
                  DC.B      'L',$00,$00,$00,$00,$00,$A2,$00 
                  DC.B      $00,$00,$00,$16,'CLIP'
                  DCB.W     2,0 
                  DC.B      $A2,$00,$00,$00,$0A,$CC,'CL'
                  DC.B      'IP3',$00,$00,$00,$A2,$00 
                  DC.B      $00,$00,$0A,$FE,'CLIP'
                  DC.B      '4',$00,$00,$00,$A2,$00,$00,$00 
                  DC.B      $0B,$0E,'CMAX2',$00 
                  DC.B      $00,$00,$A4,$00,$00,$00,'Pd'
                  DC.B      'CMIN2',$00,$00,$00 
                  DC.B      $A4,$00,$00,$00,'*',$E4,'EC'
                  DC.B      'RAN',$00,$00,$00,$A4,$00 
                  DC.B      $00,$00,$0B,'`LINE' 
                  DC.B      '1',$00,$00,$00,$A4,$00,$00,$00 
                  DC.B      $0B,'BLIST1',$00
                  DC.B      $00,$00,$A2,$00,$00,$00,$0A,$F4 
                  DC.B      'LIST2',$00,$00,$00 
                  DC.B      $A2,$00,$00,$00,$0B,$04,'LI'
                  DC.B      'ST3',$00,$00,$00,$A2,$00 
                  DC.B      $00,$00,$0B,$10,'OBJE'
                  DC.B      'T',$00,$00,$00,$A4,$00,$00,$00 
                  DC.B      $0B,' RET_7',$00
                  DC.B      $00,$00,$A2,$00,$00,$00,$03,'@' 
                  DC.B      'START',$00,$00,$00 
                  DC.B      $A2,$00,$00,$00,$00,$06,'OB'
                  DC.B      'JET1',$00,$00,$A4,$00
                  DC.B      $00,$00,$0B,'(END_' 
                  DC.B      'BOB',$00,$A2,$00,$00,$00 
                  DC.B      $02,$DA,'NO_NEG'
                  DC.B      'A',$00,$A2,$00,$00,$00,$0A,$A2 
                  DC.B      'NO_SWAP',$00 
                  DC.B      $A2,$00,$00,$00,$0A,'~X_' 
                  DC.B      'ANGLE',$00,$A4,$00 
                  DC.B      $00,$00,$0B,'~Y_AN' 
                  DC.B      'GLE',$00,$A4,$00,$00,$00 
                  DC.B      $0B,$80,'Z_ANGL'
                  DC.B      'E',$00,$A4,$00,$00,$00,$0B,$82 
                  DC.B      'END_LIST'
                  DC.B      $A2,$00,$00,$00,$03,$B2,'LI'
                  DC.B      'ST_JMP',$A2,$00
                  DC.B      $00,$00,$04,'<MASK' 
                  DC.B      '1_RE',$A4,$00,$00,$00
                  DC.B      $13,$D4,'MASK2_'
                  DC.B      'RE',$A4,$00,$00,$00,$13,$F4
                  DC.B      'OK_VISIB'
                  DC.B      $A2,$00,$00,$00,$06,$8C,'PT'
                  DC.B      'R_ANIM',$A2,$00
                  DC.B      $00,$00,$00,$C4,'X_CE'
                  DC.B      'NTRE',$A4,$00,$00,$00
                  DC.B      $0B,'tY_CENT' 
                  DC.B      'RE',$A4,$00,$00,$00,$0B,'v'
                  DC.B      'COS_TABL'
                  DC.B      $A4,'H',$00,$00,$0B,$D4,'E',$00 
                  DCB.W     6,0 
                  DC.B      'MASK_XMA'
                  DC.B      $A4,'H',$00,$00,'H',$E4,'X',$00 
                  DCB.W     6,0 
                  DC.B      'MASK_XMI'
                  DC.B      $A4,'H',$00,$00,'#dN',$00 
                  DCB.W     6,0 
                  DC.B      'MEME_MAS'
                  DC.B      $A2,'H',$00,$00,$03,$CA,'K',$00 
                  DCB.W     6,0 
                  DC.B      'NBR_POIN'
                  DC.B      $A2,'H',$00,$00,$01,$A8,'T',$00 
                  DCB.W     6,0 
                  DC.B      'NEW_OBJE'
                  DC.B      $A4,'H',$00,$00,$0B,'lT',$00
                  DCB.W     6,0 
                  DC.B      'SIN_TABL'
                  DC.B      $A4,'H',$00,$00,$0F,$D4,'E',$00 
                  DCB.W     6,0 
                  DC.B      'TABLE_16'
                  DC.B      $A2,'H',$00,$00,$06,$AE,'0',$00 
                  DCB.W     6,0 
                  DC.B      'YOP_POIN'
                  DC.B      $A4,'H',$00,$00,$0B,$18,'T',$00 
                  DCB.W     6,0 
                  DC.B      'CLS_SCRE'
                  DC.B      $A2,'H',$00,$00,$00,'.EN' 
                  DCB.W     6,0 
                  DC.B      'FACE_VIS'
                  DC.B      $A2,'H',$00,$00,$02,'0IB' 
                  DCB.W     6,0 
                  DC.B      'MASK_DEC'
                  DC.B      $A2,'H',$00,$00,$05,$D8,'AL'
                  DCB.W     6,0 
                  DC.B      'PASS_TRA'
                  DC.B      $A2,'H',$00,$00,$03,$BE,'CE'
                  DCB.W     6,0 
                  DC.B      'TABLE_XM'
                  DC.B      $A4,'H',$00,$00,'aVAX'
                  DCB.W     6,0 
                  DC.B      'TABLE_XM'
                  DC.B      $A4,'H',$00,$00,'_dIN'
                  DCB.W     6,0 
                  DC.B      'TEST_VIS'
                  DC.B      $A2,'H',$00,$00,$06,'TIB' 
                  DCB.W     6,0 
                  DC.B      'TRACE_LI'
                  DC.B      $A2,'H',$00,$00,$0A,'lNE' 
                  DCB.W     6,0 
                  DC.B      'Y_MAX_FA'
                  DC.B      $A4,'H',$00,$00,$0B,'rCE' 
                  DCB.W     6,0 
                  DC.B      'Y_MIN_FA'
                  DC.B      $A4,'H',$00,$00,$0B,'pCE' 
                  DCB.W     6,0 
                  DC.B      'NO_MORE_'
                  DC.B      $A2,'H',$00,$00,$0A,$C2,'L.'
                  DC.B      '.',$00,$00,$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'AFFICHE_'
                  DC.B      $A2,'H',$00,$00,$03,',LI' 
                  DC.B      'NE',$00,$00,$00,$00,$00,$00
                  DCB.W     2,0 
                  DC.B      'ANIM_SUR'
                  DC.B      $A2,'H',$00,$00,$00,$C6,'FA'
                  DC.B      'CE',$00,$00,$00,$00,$00,$00
                  DCB.W     2,0 
                  DC.B      'NEXT_SUR'
                  DC.B      $A2,'H',$00,$00,$02,$0E,'FA'
                  DC.B      'CE',$00,$00,$00,$00,$00,$00
                  DCB.W     2,0 
                  DC.B      'NO_MAXI_'
                  DC.B      $A2,'H',$00,$00,$06,'RFA' 
                  DC.B      'CE',$00,$00,$00,$00,$00,$00
                  DCB.W     2,0 
                  DC.B      'SAVE_MAT'
                  DC.B      $A4,'H',$00,$00,$0B,$84,'RI'
                  DC.B      'CE',$00,$00,$00,$00,$00,$00
                  DCB.W     2,0 
                  DC.B      'COPY_CLI'
                  DC.B      $A2,'H',$00,$00,$06,$1C,'PP'
                  DC.B      'ING',$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'NO_MINUS'
                  DC.B      $A2,'H',$00,$00,$06,'F_F' 
                  DC.B      'ACE',$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'ROTATION'
                  DC.B      $A2,'H',$00,$00,$00,$F0,'X_'
                  DC.B      'Y_Z',$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'X_OBSERV'
                  DC.B      $A4,'H',$00,$00,$0B,'xAT' 
                  DC.B      'EUR',$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'Y_OBSERV'
                  DC.B      $A4,'H',$00,$00,$0B,'zAT' 
                  DC.B      'EUR',$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'Z_OBSERV'
                  DC.B      $A4,'H',$00,$00,$0B,'|AT' 
                  DC.B      'EUR',$00,$00,$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'BASE_CLS'
                  DC.B      $A4,'H',$00,$00,$0B,'h_E' 
                  DC.B      'CRAN',$00,$00,$00,$00
                  DCB.W     2,0 
                  DC.B      'OFFSET_S'
                  DC.B      $A2,'H',$00,$00,$05,$CC,'UI'
                  DC.B      'VANT',$00,$00,$00,$00
                  DCB.W     2,0 
                  DC.B      'AFFICHE_'
                  DC.B      $A2,'H',$00,$00,$02,$04,'SU'
                  DC.B      'RFACE',$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'EXTEND_R'
                  DC.B      $A4,'H',$00,$00,$0B,$AC,'EG'
                  DC.B      'ISTER',$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'NEW_COOR'
                  DC.B      $A4,'H',$00,$00,'cHD_'
                  DC.B      'OBJET',$00,$00,$00 
                  DCB.W     2,0 
                  DC.B      'RETURN_F'
                  DC.B      $A2,'H',$00,$00,$0A,'jRO' 
                  DC.B      'M_LINE',$00,$00
                  DCB.W     2,0 
                  DC.B      'SUITE_TR'
                  DC.B      $A2,'H',$00,$00,$0A,$82,'AC'
                  DC.B      'E_LINE',$00,$00
                  DCB.W     2,0 
                  DC.B      'CONSTRUC'
                  DC.B      $A2,'H',$00,$00,$05,$FC,'T_'
                  DC.B      'CLIPPING'
                  DCB.W     2,0 
                  DC.B      'END_NBR_'
                  DC.B      $A2,'H',$00,$00,$06,'ŽLI' 
                  DC.B      'NE_BLOCK'
                  DCB.W     2,0 
                  DC.B      'BASE_CLS'
                  DC.B      $A4,'H',$00,$00,$14,$14,'_E'
                  DC.B      'CRAN_DAT'
                  DC.B      'A',$00,$00,$00,'INIT'
                  DC.B      '_YMI',$A2,'H',$00,$00
                  DC.B      $06,'*N_YMAX' 
                  DC.B      '_FACE',$00,$00,$00 
                  DC.B      'NORMAL_T'
                  DC.B      $A2,'H',$00,$00,$02,$F2,'RA'
                  DC.B      'CE_SURFA'
                  DC.B      'CE',$00,$00,'SEAR' 
                  DC.B      'CH_Y',$A2,'H',$00,$00
                  DC.B      $06,':MIN_YM' 
                  DC.B      'AX_FACE',$00 
                  DC.B      'PREPART_'
                  DC.B      $A2,'H',$00,$00,$05,$BC,'TA'
                  DC.B      'BLE_REMP'
                  DC.B      'LISS',$00,$00,$00,$02
                  DC.B      $06,$06,$AC,$0E,$08,$08,$08,$0A 
                  DC.B      $01,'6',$16,$C2,$18,'"',$AC,$04 
                  DC.B      $04,$04,$04,$04,$04,$04,$04,$04 
                  DC.B      $04,$04,$04,$04,$04,$04,$04,$04 
                  DC.B      $04,$04,$04,$04,$04,$04,$04,$10 
                  DC.B      $10,$10,$10,$10,$10,$10,$10,$10 
                  DC.B      $10,$10,$10,$10,$10,$10,$10,$10 
                  DC.B      $10,$10,$10,$10,$10,$10,$82,$06 
                  DC.B      $0E,$0C,'8',$08,$04,$04,$04,$04 
                  DC.B      $04,$04,$04,$01,$01,$01,$01,'~' 
                  DC.B      $04,'H',$00,$00,$00,$00,$03,$F1 
                  DC.B      $00,$00,$00,$07,$00,$00,$00,$00 
                  DC.B      'HEADDBGV'
                  DC.B      '01',$00,$00,$00,$00,$00,$00
                  DCB.W     5,0 
                  DC.B      $03,$F1,$00,$00,$02,$18,$00,$00 
                  DC.B      $00,$00,'LINE',$00,$00
                  DC.B      $00,$07,'D:\EVO'
                  DC.B      'LUTIO\CR'
                  DC.B      'EDIT\PLA'
                  DC.B      'QUE2.S',$00,$00
                  DC.B      $00,$07,$00,$00,$00,$00,$00,$00 
                  DC.B      $00,$0A,$00,$00,$00,$06,$00,$00 
                  DC.B      $00,$0B,$00,$00,$00,$0C,$00,$00 
                  DC.B      $00,$0C,$00,$00,$00,$12,$00,$00 
                  DC.B      $00,$0E,$00,$00,$00,$16,$00,$00 
                  DC.B      $00,$0F,$00,$00,$00,'$',$00,$00 
                  DC.B      $00,$10,$00,$00,$00,'(',$00,$00 
                  DC.B      $00,$11,$00,$00,$00,'*',$00,$00 
                  DC.B      $00,$18,$00,$00,$00,$8E,$00,$00 
                  DC.B      $00,$19,$00,$00,$00,$92,$00,$00 
                  DC.B      $00,$1A,$00,$00,$00,$96,$00,$00 
                  DC.B      $00,$1B,$00,$00,$00,$9A,$00,$00 
                  DC.B      $00,$1C,$00,$00,$00,$9E,$00,$00 
                  DC.B      $00,$1D,$00,$00,$00,$A2,$00,$00 
                  DC.B      $00,$1E,$00,$00,$00,$A6,$00,$00 
                  DC.B      $00,$1F,$00,$00,$00,$A8,$00,$00 
                  DC.B      $00,' ',$00,$00,$00,$AA,$00,$00 
                  DC.B      $00,'"',$00,$00,$00,$AE,$00,$00 
                  DC.B      $00,'$',$00,$00,$00,$B8,$00,$00 
                  DC.B      $00,'%',$00,$00,$00,$BE,$00,$00 
                  DC.B      $00,'&',$00,$00,$00,$C2,$00,$00 
                  DC.B      $00,'(',$00,$00,$00,$C4,$00,$00 
                  DC.B      $00,'+',$00,$00,$00,$C6,$00,$00 
                  DC.B      $00,',',$00,$00,$00,$CC,$00,$00 
                  DC.B      $00,'-',$00,$00,$00,$D4,$00,$00 
                  DC.B      $00,'.',$00,$00,$00,$DC,$00,$00 
                  DC.B      $00,'/',$00,$00,$00,$E4,$00,$00 
                  DC.B      $00,'0',$00,$00,$00,$E6,$00,$00 
                  DC.B      $00,'2',$00,$00,$00,$EE,$00,$00 
                  DC.B      $00,'6',$00,$00,$00,$F0,$00,$00 
                  DC.B      $00,'7',$00,$00,$00,$F4,$00,$00 
                  DC.B      $00,'8',$00,$00,$00,$F8,$00,$00 
                  DC.B      $00,'9',$00,$00,$00,$FC,$00,$00 
                  DC.B      $00,':',$00,$00,$01,$00,$00,$00 
                  DC.B      $00,'<',$00,$00,$01,$04,$00,$00 
                  DC.B      $00,'=',$00,$00,$01,$06,$00,$00 
                  DC.B      $00,'>',$00,$00,$01,$08,$00,$00 
                  DC.B      $00,'?',$00,$00,$01,$0A,$00,$00 
                  DC.B      $00,'@',$00,$00,$01,$0E,$00,$00 
                  DC.B      $00,'A',$00,$00,$01,$12,$00,$00 
                  DC.B      $00,'B',$00,$00,$01,$16,$00,$00 
                  DC.B      $00,'C',$00,$00,$01,$1A,$00,$00 
                  DC.B      $00,'D',$00,$00,$01,$1E,$00,$00 
                  DC.B      $00,'E',$00,$00,$01,'"',$00,$00 
                  DC.B      $00,'G',$00,$00,$01,'$',$00,$00 
                  DC.B      $00,'H',$00,$00,$01,'&',$00,$00 
                  DC.B      $00,'I',$00,$00,$01,'(',$00,$00 
                  DC.B      $00,'J',$00,$00,$01,'*',$00,$00 
                  DC.B      $00,'L',$00,$00,$01,',',$00,$00 
                  DC.B      $00,'M',$00,$00,$01,'.',$00,$00 
                  DC.B      $00,'N',$00,$00,$01,'0',$00,$00 
                  DC.B      $00,'O',$00,$00,$01,'2',$00,$00 
                  DC.B      $00,'P',$00,$00,$01,'4',$00,$00 
                  DC.B      $00,'Q',$00,$00,$01,'6',$00,$00 
                  DC.B      $00,'R',$00,$00,$01,'8',$00,$00 
                  DC.B      $00,'S',$00,$00,$01,':',$00,$00 
                  DC.B      $00,'T',$00,$00,$01,'<',$00,$00 
                  DC.B      $00,'U',$00,$00,$01,'>',$00,$00 
                  DC.B      $00,'W',$00,$00,$01,'@',$00,$00 
                  DC.B      $00,'X',$00,$00,$01,'B',$00,$00 
                  DC.B      $00,'Y',$00,$00,$01,'D',$00,$00 
                  DC.B      $00,'Z',$00,$00,$01,'F',$00,$00 
                  DC.B      $00,'[',$00,$00,$01,'H',$00,$00 
                  DC.B      $00,'\',$00,$00,$01,'J',$00,$00 
                  DC.B      $00,']',$00,$00,$01,'L',$00,$00 
                  DC.B      $00,'^',$00,$00,$01,'N',$00,$00 
                  DC.B      $00,'_',$00,$00,$01,'P',$00,$00 
                  DC.B      $00,'`',$00,$00,$01,'R',$00,$00 
                  DC.B      $00,'b',$00,$00,$01,'T',$00,$00 
                  DC.B      $00,'c',$00,$00,$01,'V',$00,$00 
                  DC.B      $00,'d',$00,$00,$01,'X',$00,$00 
                  DC.B      $00,'e',$00,$00,$01,'Z',$00,$00 
                  DC.B      $00,'g',$00,$00,$01,'\',$00,$00 
                  DC.B      $00,'h',$00,$00,$01,'^',$00,$00 
                  DC.B      $00,'i',$00,$00,$01,'`',$00,$00 
                  DC.B      $00,'j',$00,$00,$01,'b',$00,$00 
                  DC.B      $00,'k',$00,$00,$01,'d',$00,$00 
                  DC.B      $00,'l',$00,$00,$01,'f',$00,$00 
                  DC.B      $00,'m',$00,$00,$01,'h',$00,$00 
                  DC.B      $00,'n',$00,$00,$01,'j',$00,$00 
                  DC.B      $00,'o',$00,$00,$01,'l',$00,$00 
                  DC.B      $00,'p',$00,$00,$01,'n',$00,$00 
                  DC.B      $00,'r',$00,$00,$01,'p',$00,$00 
                  DC.B      $00,'s',$00,$00,$01,'r',$00,$00 
                  DC.B      $00,'t',$00,$00,$01,'t',$00,$00 
                  DC.B      $00,'u',$00,$00,$01,'v',$00,$00 
                  DC.B      $00,'v',$00,$00,$01,'x',$00,$00 
                  DC.B      $00,'w',$00,$00,$01,'z',$00,$00 
                  DC.B      $00,'x',$00,$00,$01,'|',$00,$00 
                  DC.B      $00,'y',$00,$00,$01,'~',$00,$00 
                  DC.B      $00,'z',$00,$00,$01,$80,$00,$00 
                  DC.B      $00,'{',$00,$00,$01,$82,$00,$00 
                  DC.B      $00,'}',$00,$00,$01,$84,$00,$00 
                  DC.B      $00,'~',$00,$00,$01,$86,$00,$00 
                  DC.B      $00,$80,$00,$00,$01,$88,$00,$00 
                  DC.B      $00,$81,$00,$00,$01,$8A,$00,$00 
                  DC.B      $00,$82,$00,$00,$01,$8C,$00,$00 
                  DC.B      $00,$83,$00,$00,$01,$8E,$00,$00 
                  DC.B      $00,$85,$00,$00,$01,$90,$00,$00 
                  DC.B      $00,$86,$00,$00,$01,$92,$00,$00 
                  DC.B      $00,$87,$00,$00,$01,$94,$00,$00 
                  DC.B      $00,$8A,$00,$00,$01,$96,$00,$00 
                  DC.B      $00,$8C,$00,$00,$01,$9A,$00,$00 
                  DC.B      $00,$8D,$00,$00,$01,$9E,$00,$00 
                  DC.B      $00,$8F,$00,$00,$01,$A2,$00,$00 
                  DC.B      $00,$91,$00,$00,$01,$A6,$00,$00 
                  DC.B      $00,$93,$00,$00,$01,$A8,$00,$00 
                  DC.B      $00,$94,$00,$00,$01,$AC,$00,$00 
                  DC.B      $00,$95,$00,$00,$01,$AE,$00,$00 
                  DC.B      $00,$96,$00,$00,$01,$B0,$00,$00 
                  DC.B      $00,$97,$00,$00,$01,$B2,$00,$00 
                  DC.B      $00,$98,$00,$00,$01,$B4,$00,$00 
                  DC.B      $00,$99,$00,$00,$01,$B6,$00,$00 
                  DC.B      $00,$9A,$00,$00,$01,$B8,$00,$00 
                  DC.B      $00,$9B,$00,$00,$01,$BC,$00,$00 
                  DC.B      $00,$9C,$00,$00,$01,$C0,$00,$00 
                  DC.B      $00,$9D,$00,$00,$01,$C2,$00,$00 
                  DC.B      $00,$9E,$00,$00,$01,$C4,$00,$00 
                  DC.B      $00,$9F,$00,$00,$01,$C6,$00,$00 
                  DC.B      $00,$A0,$00,$00,$01,$C8,$00,$00 
                  DC.B      $00,$A1,$00,$00,$01,$CA,$00,$00 
                  DC.B      $00,$A2,$00,$00,$01,$CC,$00,$00 
                  DC.B      $00,$A3,$00,$00,$01,$D0,$00,$00 
                  DC.B      $00,$A4,$00,$00,$01,$D4,$00,$00 
                  DC.B      $00,$A5,$00,$00,$01,$D6,$00,$00 
                  DC.B      $00,$A6,$00,$00,$01,$D8,$00,$00 
                  DC.B      $00,$A7,$00,$00,$01,$DA,$00,$00 
                  DC.B      $00,$A8,$00,$00,$01,$DC,$00,$00 
                  DC.B      $00,$A9,$00,$00,$01,$DE,$00,$00 
                  DC.B      $00,$AB,$00,$00,$01,$E0,$00,$00 
                  DC.B      $00,$AC,$00,$00,$01,$E2,$00,$00 
                  DC.B      $00,$AE,$00,$00,$01,$E4,$00,$00 
                  DC.B      $00,$AF,$00,$00,$01,$E8,$00,$00 
                  DC.B      $00,$B0,$00,$00,$01,$EA,$00,$00 
                  DC.B      $00,$B1,$00,$00,$01,$EC,$00,$00 
                  DC.B      $00,$B2,$00,$00,$01,$EE,$00,$00 
                  DC.B      $00,$B3,$00,$00,$01,$F0,$00,$00 
                  DC.B      $00,$B6,$00,$00,$01,$F4,$00,$00 
                  DC.B      $00,$B7,$00,$00,$01,$F8,$00,$00 
                  DC.B      $00,$BD,$00,$00,$01,$FA,$00,$00 
                  DC.B      $00,$BE,$00,$00,$01,$FE,$00,$00 
                  DC.B      $00,$BF,$00,$00,$02,$02,$00,$00 
                  DC.B      $00,$CD,$00,$00,$02,$04,$00,$00 
                  DC.B      $00,$CE,$00,$00,$02,$08,$00,$00 
                  DC.B      $00,$CF,$00,$00,$02,$0C,$00,$00 
                  DC.B      $00,$D3,$00,$00,$02,$0E,$00,$00 
                  DC.B      $00,$D4,$00,$00,$02,$12,$00,$00 
                  DC.B      $00,$D7,$00,$00,$02,$14,$00,$00 
                  DC.B      $00,$D8,$00,$00,$02,$16,$00,$00 
                  DC.B      $00,$DA,$00,$00,$02,$1A,$00,$00 
                  DC.B      $00,$DC,$00,$00,$02,$1C,$00,$00 
                  DC.B      $00,$DD,$00,$00,$02,'"',$00,$00 
                  DC.B      $00,$E2,$00,$00,$02,'$',$00,$00 
                  DC.B      $00,$E4,$00,$00,$02,'(',$00,$00 
                  DC.B      $00,$E6,$00,$00,$02,'*',$00,$00 
                  DC.B      $00,$E7,$00,$00,$02,',',$00,$00 
                  DC.B      $00,$E8,$00,$00,$02,'.',$00,$00 
                  DC.B      $00,$F3,$00,$00,$02,'0',$00,$00 
                  DC.B      $00,$FE,$00,$00,$02,$DA,$00,$00 
                  DC.B      $00,$FF,$00,$00,$02,$DE,$00,$00 
                  DC.B      $01,$00,$00,$00,$02,$E2,$00,$00 
                  DC.B      $01,$01,$00,$00,$02,$E4,$00,$00 
                  DC.B      $01,$03,$00,$00,$02,$E6,$00,$00 
                  DC.B      $01,$04,$00,$00,$02,$E8,$00,$00 
                  DC.B      $01,$05,$00,$00,$02,$EA,$00,$00 
                  DC.B      $01,$06,$00,$00,$02,$EE,$00,$00 
                  DC.B      $01,$07,$00,$00,$02,$F0,$00,$00 
                  DC.B      $01,$0A,$00,$00,$02,$F2,$00,$00 
                  DC.B      $01,$0C,$00,$00,$02,$F4,$00,$00 
                  DC.B      $01,$0D,$00,$00,$02,$FA,$00,$00 
                  DC.B      $01,$0F,$00,$00,$02,$FC,$00,$00 
                  DC.B      $01,$11,$00,$00,$02,$FE,$00,$00 
                  DC.B      $01,$12,$00,$00,$03,$00,$00,$00 
                  DC.B      $01,$16,$00,$00,$03,$02,$00,$00 
                  DC.B      $01,$17,$00,$00,$03,$06,$00,$00 
                  DC.B      $01,$19,$00,$00,$03,$0A,$00,$00 
                  DC.B      $01,$1A,$00,$00,$03,$12,$00,$00 
                  DC.B      $01,$1B,$00,$00,$03,$16,$00,$00 
                  DC.B      $01,$1D,$00,$00,$03,$1A,$00,$00 
                  DC.B      $01,$1E,$00,$00,$03,$1C,$00,$00 
                  DC.B      $01,$1F,$00,$00,$03,' ',$00,$00 
                  DC.B      $01,'!',$00,$00,$03,'"',$00,$00 
                  DC.B      $01,'"',$00,$00,$03,'$',$00,$00 
                  DC.B      $01,'#',$00,$00,$03,'(',$00,$00 
                  DC.B      $01,'$',$00,$00,$03,'*',$00,$00 
                  DC.B      $01,'6',$00,$00,$06,'*',$00,$00 
                  DC.B      $01,'7',$00,$00,$06,'2',$00,$00 
                  DC.B      $01,'8',$00,$00,$06,'8',$00,$00 
                  DC.B      $01,'<',$00,$00,$06,':',$00,$00 
                  DC.B      $01,'=',$00,$00,$06,'>',$00,$00 
                  DC.B      $01,'>',$00,$00,$06,'@',$00,$00 
                  DC.B      $01,'@',$00,$00,$06,'F',$00,$00 
                  DC.B      $01,'A',$00,$00,$06,'J',$00,$00 
                  DC.B      $01,'B',$00,$00,$06,'L',$00,$00 
                  DC.B      $01,'D',$00,$00,$06,'R',$00,$00 
                  DC.B      $01,'H',$00,$00,$06,'T',$00,$00 
                  DC.B      $01,'I',$00,$00,$06,'V',$00,$00 
                  DC.B      $01,'J',$00,$00,$06,'Z',$00,$00 
                  DC.B      $01,'L',$00,$00,$06,'^',$00,$00 
                  DC.B      $01,'M',$00,$00,$06,'b',$00,$00 
                  DC.B      $01,'N',$00,$00,$06,'f',$00,$00 
                  DC.B      $01,'P',$00,$00,$06,'j',$00,$00 
                  DC.B      $01,'Q',$00,$00,$06,'n',$00,$00 
                  DC.B      $01,'R',$00,$00,$06,'r',$00,$00 
                  DC.B      $01,'T',$00,$00,$06,'v',$00,$00 
                  DC.B      $01,'U',$00,$00,$06,'x',$00,$00 
                  DC.B      $01,'V',$00,$00,$06,'z',$00,$00 
                  DC.B      $01,'W',$00,$00,$06,'|',$00,$00 
                  DC.B      $01,'X',$00,$00,$06,'~',$00,$00 
                  DC.B      $01,'Y',$00,$00,$06,$80,$00,$00 
                  DC.B      $01,'Z',$00,$00,$06,$82,$00,$00 
                  DC.B      $01,'[',$00,$00,$06,$84,$00,$00 
                  DC.B      $01,'\',$00,$00,$06,$8A,$00,$00 
                  DC.B      $01,'^',$00,$00,$06,$8C,$00,$00 
                  DC.B      $01,'r',$00,$00,$0A,'j',$00,$00 
                  DC.B      $01,$95,$00,$00,$0A,'l',$00,$00 
                  DC.B      $01,$96,$00,$00,$0A,'n',$00,$00 
                  DC.B      $01,$97,$00,$00,$0A,'p',$00,$00 
                  DC.B      $01,$98,$00,$00,$0A,'r',$00,$00 
                  DC.B      $01,$99,$00,$00,$0A,'t',$00,$00 
                  DC.B      $01,$9A,$00,$00,$0A,'v',$00,$00 
                  DC.B      $01,$9C,$00,$00,$0A,'x',$00,$00 
                  DC.B      $01,$9D,$00,$00,$0A,'|',$00,$00 
                  DC.B      $01,$9F,$00,$00,$0A,'~',$00,$00 
                  DC.B      $01,$A1,$00,$00,$0A,$82,$00,$00 
                  DC.B      $01,$A2,$00,$00,$0A,$C2,$00,$00 
                  DC.B      $01,$A3,$00,$00,$0A,$C6,$00,$00 
                  DC.B      $01,$A4,$00,$00,$0A,$C8,$00,$00 
                  DC.B      $01,$A5,$00,$00,$0A,$CA,$00,$00 
                  DC.B      $01,$A7,$00,$00,$0A,$CC,$00,$00 
                  DC.B      $01,$A8,$00,$00,$0A,$CE,$00,$00 
                  DC.B      $01,$A9,$00,$00,$0A,$D0,$00,$00 
                  DC.B      $01,$AA,$00,$00,$0A,$D2,$00,$00 
                  DC.B      $01,$AB,$00,$00,$0A,$D4,$00,$00 
                  DC.B      $01,$AD,$00,$00,$0A,$D6,$00,$00 
                  DC.B      $01,$AE,$00,$00,$0A,$D8,$00,$00 
                  DC.B      $01,$B0,$00,$00,$0A,$DA,$00,$00 
                  DC.B      $01,$B1,$00,$00,$0A,$DC,$00,$00 
                  DC.B      $01,$B2,$00,$00,$0A,$DE,$00,$00 
                  DC.B      $01,$B3,$00,$00,$0A,$E0,$00,$00 
                  DC.B      $01,$B4,$00,$00,$0A,$E2,$00,$00 
                  DC.B      $01,$B5,$00,$00,$0A,$E4,$00,$00 
                  DC.B      $01,$B8,$00,$00,$0A,$E6,$00,$00 
                  DC.B      $01,$B9,$00,$00,$0A,$E8,$00,$00 
                  DC.B      $01,$BA,$00,$00,$0A,$EA,$00,$00 
                  DC.B      $01,$BB,$00,$00,$0A,$EC,$00,$00 
                  DC.B      $01,$BC,$00,$00,$0A,$F0,$00,$00 
                  DC.B      $01,$BD,$00,$00,$0A,$F2,$00,$00 
                  DC.B      $01,$BF,$00,$00,$0A,$F4,$00,$00 
                  DC.B      $01,$C0,$00,$00,$0A,$F6,$00,$00 
                  DC.B      $01,$C1,$00,$00,$0A,$F8,$00,$00 
                  DC.B      $01,$C2,$00,$00,$0A,$FC,$00,$00 
                  DC.B      $01,$C5,$00,$00,$0A,$FE,$00,$00 
                  DC.B      $01,$C6,$00,$00,$0B,$00,$00,$00 
                  DC.B      $01,$C7,$00,$00,$0B,$02,$00,$00 
                  DC.B      $01,$C9,$00,$00,$0B,$04,$00,$00 
                  DC.B      $01,$CA,$00,$00,$0B,$06,$00,$00 
                  DC.B      $01,$CB,$00,$00,$0B,$08,$00,$00 
                  DC.B      $01,$CC,$00,$00,$0B,$0C,$00,$00 
                  DC.B      $01,$CF,$00,$00,$0B,$0E,$00,$00 
                  DC.B      $01,$D1,$00,$00,$0B,$10,$00,$00 
                  DC.B      $01,$D2,$00,$00,$0B,$12,$00,$00 
                  DC.B      $01,$D3,$00,$00,$0B,$16,$00,$00 
                  DC.B      $03,$F1,$00,$00,$00,$94,$00,$00 
                  DC.B      $00,$00,'LINE',$00,$00
                  DC.B      $00,$03,'REMPL1'
                  DC.B      'O2.S',$00,$00,$00,$00
                  DC.B      $00,$12,$00,$00,$03,',',$00,$00 
                  DC.B      $00,$13,$00,$00,$03,'.',$00,$00 
                  DC.B      $00,$14,$00,$00,$03,'4',$00,$00 
                  DC.B      $00,$15,$00,$00,$03,'6',$00,$00 
                  DC.B      $00,$16,$00,$00,$03,':',$00,$00 
                  DC.B      $00,$17,$00,$00,$03,'>',$00,$00 
                  DC.B      $00,$1A,$00,$00,$03,'@',$00,$00 
                  DC.B      $00,$1B,$00,$00,$03,'B',$00,$00 
                  DC.B      $00,$1D,$00,$00,$03,'D',$00,$00 
                  DC.B      $00,$1E,$00,$00,$03,'H',$00,$00 
                  DC.B      $00,' ',$00,$00,$03,'L',$00,$00 
                  DC.B      $00,'!',$00,$00,$03,'N',$00,$00 
                  DC.B      $00,'#',$00,$00,$03,'P',$00,$00 
                  DC.B      $00,'%',$00,$00,$03,'R',$00,$00 
                  DC.B      $00,'&',$00,$00,$03,'T',$00,$00 
                  DC.B      $00,$27,$00,$00,$03,'X',$00,$00 
                  DC.B      $00,'0',$00,$00,$03,$B2,$00,$00 
                  DC.B      $00,'1',$00,$00,$03,$B4,$00,$00 
                  DC.B      $00,'2',$00,$00,$03,$B6,$00,$00 
                  DC.B      $00,'4',$00,$00,$03,$B8,$00,$00 
                  DC.B      $00,'5',$00,$00,$03,$BA,$00,$00 
                  DC.B      $00,'7',$00,$00,$03,$BE,$00,$00 
                  DC.B      $00,'8',$00,$00,$03,$C2,$00,$00 
                  DC.B      $00,'9',$00,$00,$03,$C6,$00,$00 
                  DC.B      $00,':',$00,$00,$03,$C8,$00,$00 
                  DC.B      $00,'=',$00,$00,$03,$CA,$00,$00 
                  DC.B      $00,'>',$00,$00,$03,$CC,$00,$00 
                  DC.B      $00,'?',$00,$00,$03,$CE,$00,$00 
                  DC.B      $00,'@',$00,$00,$03,$D0,$00,$00 
                  DC.B      $00,'A',$00,$00,$03,$D4,$00,$00 
                  DC.B      $00,'B',$00,$00,$03,$D8,$00,$00 
                  DC.B      $00,'C',$00,$00,$03,$DA,$00,$00 
                  DC.B      $00,'J',$00,$00,$04,'<',$00,$00 
                  DC.B      $00,'K',$00,$00,$04,'@',$00,$00 
                  DC.B      $00,'L',$00,$00,$04,'D',$00,$00 
                  DC.B      $00,'M',$00,$00,$04,'H',$00,$00 
                  DC.B      $00,'Y',$00,$00,$05,$BC,$00,$00 
                  DC.B      $00,'Z',$00,$00,$05,$C0,$00,$00 
                  DC.B      $00,'\',$00,$00,$05,$C4,$00,$00 
                  DC.B      $00,']',$00,$00,$05,$C6,$00,$00 
                  DC.B      $00,'_',$00,$00,$05,$C8,$00,$00 
                  DC.B      $00,'b',$00,$00,$05,$CC,$00,$00 
                  DC.B      $00,'c',$00,$00,$05,$D0,$00,$00 
                  DC.B      $00,'e',$00,$00,$05,$D4,$00,$00 
                  DC.B      $00,'h',$00,$00,$05,$D8,$00,$00 
                  DC.B      $00,'i',$00,$00,$05,$DA,$00,$00 
                  DC.B      $00,'k',$00,$00,$05,$DC,$00,$00 
                  DC.B      $00,'l',$00,$00,$05,$DE,$00,$00 
                  DC.B      $00,'n',$00,$00,$05,$E0,$00,$00 
                  DC.B      $00,'o',$00,$00,$05,$E2,$00,$00 
                  DC.B      $00,'p',$00,$00,$05,$E4,$00,$00 
                  DC.B      $00,'q',$00,$00,$05,$E6,$00,$00 
                  DC.B      $00,'r',$00,$00,$05,$E8,$00,$00 
                  DC.B      $00,'t',$00,$00,$05,$EC,$00,$00 
                  DC.B      $00,'u',$00,$00,$05,$F2,$00,$00 
                  DC.B      $00,'v',$00,$00,$05,$F8,$00,$00 
                  DC.B      $00,'x',$00,$00,$05,$FC,$00,$00 
                  DC.B      $00,'y',$00,$00,$06,$00,$00,$00 
                  DC.B      $00,'z',$00,$00,$06,$04,$00,$00 
                  DC.B      $00,'{',$00,$00,$06,$08,$00,$00 
                  DC.B      $00,'|',$00,$00,$06,$0C,$00,$00 
                  DC.B      $00,'}',$00,$00,$06,$0E,$00,$00 
                  DC.B      $00,'~',$00,$00,$06,$10,$00,$00 
                  DC.B      $00,$7F,$00,$00,$06,$14,$00,$00 
                  DC.B      $00,$80,$00,$00,$06,$18,$00,$00 
                  DC.B      $00,$82,$00,$00,$06,$1C,$00,$00 
                  DC.B      $00,$83,$00,$00,$06,$1E,$00,$00 
                  DC.B      $00,$84,$00,$00,$06,' ',$00,$00 
                  DC.B      $00,$85,$00,$00,$06,'"',$00,$00 
                  DC.B      $00,$86,$00,$00,$06,'$',$00,$00 
                  DC.B      $00,$87,$00,$00,$06,'(' 
 BSS
FADE_OK:          DS.W      1 
PBUFFER:          DS.B      160 
ECRAN:            DS.L      1 
L0052:            DS.B      202776
ZUEND: END
