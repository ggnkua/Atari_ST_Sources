	move.w	#3,-(sp)
	trap	#14

A	incbin	intro.tg2