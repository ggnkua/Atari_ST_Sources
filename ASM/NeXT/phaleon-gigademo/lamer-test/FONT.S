;Palette of FONT.PI1: Saved by NEOchrome V2.25 by Chaos, Inc.
		dc.w	$0000,$0707,$0716,$0725,$0734,$0743,$0752,$0761
		dc.w	$0770,$0057,$0027,$0001,$0507,$0707,$0000,$0777
