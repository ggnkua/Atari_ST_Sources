'
'
'  Ordre … respecter pour les questions:
'  - Francais
'  - Anglais
'  - Allemand
'
' Le d‚limiteur de fin de question est '*'
' Le d‚limiteur de fin de fichier est '**'
'
'  Et on ‚vite les grosses ruses du style '*' '**' … suivre. Merci !
'
' Codage du statut de la ligne:
' - Aucun signe devant  Ligne de texte normal 
' - Un '.', s‚lectionnable, mais mauvaise r‚ponse.
' - Un '#', s‚lectionnable, et r‚ponse exacte.
'
' (Remarque: l'espacement avant ou aprŠs n'a aucune importance.)
'
'         1         2         3        3
'123456789012345678901234567890123456789
'
Quelle ‚tait la couleur du cheval blanc
d'Henri 4 ???
. gris !
. rouge
# $777
. $fbc0
. cyan
*
;
; 1ere question stupide
;
What was the color of the white horse of
Henri the fourth ???
. grey
. red
# $777
. $fbc0
. cyan
*
Welche Farbe hat das weiže Pferd
Henris des vierten ???
. grau
. rot
# $777
. $fbc0
. cyan
*
;
; A v‚rifier...
;
De combien de registres de couleur
le TT dispose t'il ?
. 16
# 256
## 272
. 4 096
.. 16 777 216  
*
How many color registers had the
Atari TT workstation ?
. 16
# 256
## 272
. 4 096
.. 16 777 216  
*
Wieviele Farbe Register hat das TT
Komputer ?
. 16
# 256
## 272
. 4 096
.. 16 777 216  
*
;
; Sp‚cial !
;
Combien y a t'il de coders dans
Next ?
.. 1
. 2
# 3
## 4
. 5
.. 6
* 
How many coders are there in 'Next' ?
.. 1
. 2
# 3
## 4
. 5
.. 6
* 
Wieviele Coders gibt es in 'Next' ?
.. 1
. 2
# 3
## 4
. 5
.. 6
* 
;
; Une derniere pour finir
;
Quelle est la taille en Koctets
du loader de la compile des charts ?
..0,5 Ko
..18 Ko
#3 Ko
.9 Ko
.6 Ko
*
What is the size in kilobytes
of the Charts Compilation loader ?
..0,5 Ko
..18 Ko
#3 Ko
.9 Ko
.6 Ko
*
Wie ist die 'taille' von die
'Charts Compilation' laden prg ?
..0,5 Ko
..18 Ko
#3 Ko
.9 Ko
.6 Ko
*
' mit a l'abboie
Quel est le groupe Fran‡ais le
plus connu ??
#OVR
#NeXT
##ST Connexion
*
What is the best french team ??
#OVR
#NeXT
##ST Connexion
*
Wer ist das bestes Franz”sichen
team ??
#OVR
#NeXT
##ST Connexion
*
De quelle ville est NeXT ??
..PARIS
#MARSEILLE
##ANGERS
*
Where are NeXT coming from ??
..PARIS
#MARSEILLE
##ANGERS
*
Von welche Statd ist NeXT ??
..PARIS
#MARSEILLE
##ANGERS
*
Quel est le LEADER de NeXT ??
.ZAE
#DBUG II
#MIT
*
Wo is the leader of NeXT ??
.ZAE
#DBUG II
#MIT
*
Wer ist der BEST in NeXT ??
.ZAE
#DBUG II
#MIT
*
Est ce que ZAE est toujours
vivant ??
##Qui sait !!
#OUI !
.NON !
*
Is ZAE still alive ??
##Who knows !!
#Yes !
.No !
*
Ist ZAE schon tot ??
##Wer weiá !!
# Ja !
. Nein
*
Pourquoi NeXT n'est pas ds
THE UNION ??
..Nous sommes mauvais
#Personne ne nous l'a demand‚
##OVR y est deja...
*
Why isn't NeXT already in 
THE UNION ??
..We are too lame
#Anybody has asking for us
##OVR is already in !
*
Warum ist NeXT schon nicht
in THE UNION ??
..Wir sind so schelcht
#niemand fragt uns
##OVR ist schon in T. U.
*
Quel est la moyenne d'age des
membres de NeXT ??
..35 ans
.25
#21
##19
..16 ans
*
What is the Average age of the
NeXT Members ??
..35 years old
.25 years old
#21 years old
##19 years old
..16 years old
' a traduire en allmend !
*
What is the Average age of the
NeXT Members ??
..35 years old
.25 years old
#21 years old
##19 years old
..16 years old
*
**
