 TEXT 
Begin:
  DC.B   $00,$77,$07,$77,$00,$77,$07,$77
  DC.B   $00,$77,$07,$77,$00,$77,$07,$77
  DC.B   $00,$77,$07,$77,$01,$77,$07,$77
  DC.B   $00,$77,$07,$77,$01,$77,$07,$77
  DC.B   $00,$77,$07,$77,$01,$77,$07,$77
  DC.B   $01,$77,$07,$77,$01,$77,$07,$77
  DC.B   $02,$77,$07,$77,$01,$77,$07,$77
  DC.B   $02,$77,$07,$77,$01,$77,$07,$77
  DC.B   $02,$77,$07,$77,$02,$77,$07,$77
  DC.B   $02,$77,$07,$77,$02,$77,$07,$77
  DC.B   $03,$77,$07,$77,$02,$77,$07,$77
  DC.B   $03,$77,$07,$77,$02,$77,$07,$77
  DC.B   $03,$77,$07,$77,$03,$77,$07,$77
  DC.B   $03,$77,$07,$77,$04,$77,$07,$77
  DC.B   $03,$77,$07,$77,$04,$77,$07,$77
  DC.B   $04,$77,$07,$77,$04,$77,$07,$77
  DC.B   $04,$77,$07,$77,$04,$77,$07,$77
  DC.B   $04,$77,$07,$77,$05,$77,$07,$77
  DC.B   $04,$77,$07,$77,$04,$77,$07,$77
  DC.B   $05,$77,$07,$77,$04,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $04,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$07,$77,$05,$77,$07,$77
  DC.B   $05,$77,$06,$66,$06,$77,$06,$66
  DC.B   $05,$77,$06,$66,$06,$77,$06,$66
  DC.B   $05,$77,$06,$66,$06,$77,$06,$66
  DC.B   $06,$77,$06,$66,$06,$77,$06,$66
  DC.B   $06,$77,$06,$66,$06,$77,$06,$66
  DC.B   $06,$77,$06,$66,$06,$77,$06,$66
  DC.B   $06,$77,$06,$66,$06,$77,$06,$66
  DC.B   $07,$77,$06,$66,$06,$77,$06,$66
  DC.B   $07,$77,$06,$66,$07,$77,$06,$66
  DC.B   $07,$77,$06,$66,$07,$77,$06,$66
  DC.B   $07,$76,$06,$66,$07,$76,$06,$66
  DC.B   $07,$75,$06,$66,$07,$75,$06,$66
  DC.B   $07,$74,$06,$66,$07,$74,$06,$66
  DC.B   $07,$73,$06,$66,$07,$73,$06,$66
  DC.B   $07,$72,$06,$66,$07,$72,$06,$66
  DC.B   $07,$71,$06,$66,$07,$71,$06,$66
  DC.B   $07,$70,$06,$66,$07,$60,$06,$66
  DC.B   $07,$60,$06,$66,$07,$50,$06,$66
  DC.B   $07,$40,$06,$66,$07,$50,$06,$66
  DC.B   $07,$40,$06,$66,$07,$30,$06,$66
  DC.B   $07,$40,$06,$66,$07,$30,$06,$66
  DC.B   $07,$20,$06,$66,$07,$30,$06,$66
  DC.B   $07,$20,$06,$66,$07,$10,$06,$66
  DC.B   $07,$20,$06,$66,$07,$10,$06,$66
  DC.B   $07,$00,$06,$66,$07,$10,$06,$66
  DC.B   $07,$00,$06,$66,$07,$01,$06,$66
  DC.B   $07,$01,$06,$66,$07,$12,$06,$66
  DC.B   $07,$13,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $04,$44,$06,$66,$04,$44,$06,$66
  DC.B   $06,$72,$04,$61,$06,$72,$04,$61
  DC.B   $06,$72,$04,$61,$06,$72,$04,$61
  DC.B   $06,$72,$04,$61,$06,$72,$04,$61
  DC.B   $06,$72,$04,$61,$06,$72,$04,$61
  DC.B   $06,$72,$04,$61
ZUEND: END
