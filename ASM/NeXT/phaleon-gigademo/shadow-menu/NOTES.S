* Notes pour le player LAP *

DO0 = $000
REB0 = $100
RE0 = $200
MIB0 = $300
MI0 = $400
FA0 = $500
SOLB0 = $600
SOL0 = $700
LAB0 = $800
LA0 = $900
SIB0 = $A00
SI0 = $B00
DO1 = $C00
REB1 = $D00
RE1 = $E00
MIB1 = $F00
MI1 = $1000
FA1 = $1100
SOLB1 = $1200
SOL1 = $1300
LAB1 = $1400
LA1 = $1500
SIB1 = $1600
SI1 = $1700
DO2 = $1800
REB2 = $1900
RE2 = $1A00
MIB2 = $1B00
MI2 = $1C00
FA2 = $1D00
SOLB2 = $1E00
SOL2 = $1F00
LAB2 = $2000
LA2 = $2100
SIB2 = $2200
SI2 = $2300
DO3 = $2400
REB3 = $2500
RE3 = $2600
MIB3 = $2700
MI3 = $2800
FA3 = $2900
SOLB3 = $2A00
SOL3 = $2B00
LAB3 = $2C00
LA3 = $2D00
SIB3 = $2E00
SI3 = $2F00
DO4 = $3000
REB4 = $3100
RE4 = $3200
MIB4 = $3300
MI4 = $3400
FA4 = $3500
SOLB4 = $3600
SOL4 = $3700
LAB4 = $3800
LA4 = $3900
SIB4 = $3A00
SI4 = $3B00

