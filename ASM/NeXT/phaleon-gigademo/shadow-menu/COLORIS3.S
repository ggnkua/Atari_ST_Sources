 dc.w $000,$200
 dc.w $177,$200
 dc.w $177,$200
 dc.w $177,$200
 dc.w $176,$200
 dc.w $277,$200
 dc.w $176,$200
 dc.w $276,$200
 dc.w $276,$200
 dc.w $276,$200
 dc.w $275,$200
 dc.w $376,$200
 dc.w $275,$200
 dc.w $375,$200
 dc.w $375,$200
 dc.w $375,$200
 dc.w $374,$200
 dc.w $475,$200
 dc.w $374,$200
 dc.w $474,$200
 dc.w $474,$200
 dc.w $474,$200
 dc.w $473,$200
 dc.w $574,$200
 dc.w $473,$200
 dc.w $573,$200
 dc.w $573,$200
 dc.w $573,$200
 dc.w $572,$200
 dc.w $673,$200
 dc.w $572,$200
 dc.w $672,$200
 dc.w $672,$200
 dc.w $672,$200
 dc.w $672,$200
 dc.w $771,$200
 dc.w $672,$200
 dc.w $771,$200
 dc.w $771,$200
 dc.w $771,$200
 dc.w $770,$200
 dc.w $771,$200
 dc.w $771,$200
 dc.w $771,$200
 dc.w $771,$200
 dc.w $772,$200
 dc.w $771,$200
 dc.w $772,$200
 dc.w $772,$200
 dc.w $772,$200
 dc.w $772,$200
 dc.w $773,$200
 dc.w $772,$200
 dc.w $773,$200
 dc.w $773,$200
 dc.w $773,$200
 dc.w $773,$200
 

****** montagnes *******
 dc.w $774,0
 dc.w $773,0
 dc.w $774,0
 dc.w $774,0
 dc.w $774,0
 dc.w $764,0
 dc.w $775,0
 dc.w $764,0
 dc.w $765,0
 dc.w $765,0
 dc.w $755,0
 dc.w $765,0
 dc.w $756,0
 dc.w $755,0
 dc.w $756,0
 dc.w $746,0
 dc.w $756,0
 dc.w $746,0
 dc.w $747,0
 dc.w $746,0
 dc.w $737,0
 dc.w $747,0
 dc.w $737,0
 dc.w $737,0
 dc.w $737,0
 dc.w $727,0
 dc.w $637,0
 dc.w $627,0
 dc.w $527,0
 dc.w $527,0
 dc.w $417,0
 dc.w $427,0
 dc.w $317,0
 dc.w $316,0
 dc.w $215,0
 dc.w $204,0
 dc.w $113,0
 dc.w $102,0
 dc.w $001,0
 dc.w $000,0
 
 
 
 
 
 
 

*
*21

 dcb.l 24+6+12+1,0 * noir monts en couleur 0 en dessous du sprite ...
******* verdure ********

 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461

 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140

 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
