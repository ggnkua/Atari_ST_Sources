 dc.w $000,$200
 dc.w $100,$200
 dc.w $100,$200
 dc.w $200,$200
 dc.w $100,$200
 dc.w $200,$200
 dc.w $200,$200
 dc.w $300,$200
 dc.w $200,$200
 dc.w $300,$200
 dc.w $300,$200
 dc.w $400,$200
 dc.w $300,$200
 dc.w $400,$200
 dc.w $400,$200
 dc.w $500,$200
 dc.w $400,$200
 dc.w $500,$200
 dc.w $500,$200
 dc.w $600,$200
 dc.w $500,$200
 dc.w $600,$200
 dc.w $600,$200
 dc.w $700,$200
 dc.w $600,$200
 dc.w $700,$200
 dc.w $700,$200
 dc.w $701,$200
 dc.w $700,$200
 dc.w $701,$200
 dc.w $701,$200
 dc.w $702,$200
 dc.w $701,$200
 dc.w $702,$200
 dc.w $702,$200
 dc.w $703,$200
 dc.w $702,$200
 dc.w $703,$200
 dc.w $703,$200
 dc.w $704,$200
 dc.w $703,$200
 dc.w $704,$200
 dc.w $704,$200
 dc.w $705,$200
 dc.w $704,$200
 dc.w $705,$200
 dc.w $705,$200
 dc.w $706,$200
 dc.w $705,$200
 dc.w $706,$200
 dc.w $706,$200
 dc.w $707,$200
 dc.w $706,$200
 dc.w $707,$200
 dc.w $707,$200
 dc.w $717,$200
 dc.w $707,$200
 

****** montagnes *******
 dc.w $717,0
 dc.w $717,0
 dc.w $727,0
 dc.w $717,0
 dc.w $727,0
 dc.w $727,0
 dc.w $737,0
 dc.w $727,0
 dc.w $737,0
 dc.w $737,0
 dc.w $737,0
 dc.w $747,0
 dc.w $737,0
 dc.w $747,0
 dc.w $747,0
 dc.w $747,0
 dc.w $757,0
 dc.w $747,0
 dc.w $757,0
 dc.w $757,0
 dc.w $757,0
 dc.w $767,0
 dc.w $757,0
 dc.w $767,0
 dc.w $767,0
 dc.w $767,0
 dc.w $767,0
 dc.w $767,0
 dc.w $777,0
 dc.w $767,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 dc.w $777,0
 
 
 
 
 
 
 

*
*21

 dcb.l 24+6+12+1,0 * noir monts en couleur 0 en dessous du sprite ...
******* verdure ********

 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461

 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140

 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
