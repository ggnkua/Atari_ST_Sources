nste0
* C3 
 dc.w 0,1,1,1,2,2,2,3,3,3,4,4,4,5,5,5,6,6,6,6,7,7,7,8,8,8,9,9,9,10
 dc.w 10,10,11,11,11,12,12,12,13,13,13,14,14,14,15,15,15,16,16,16,17,17,17,18,18,18,19,19,19,19
 dc.w 20,20,20,21,21,21,22,22,22,23,23,23,24,24,24,25,25,25,26,26,26,27,27,27,28,28,28,29,29,29
 dc.w 30,30,30,31,31,31,31,32,32,32,33,33,33,34,34,34,35,35,35,36,36,36,37,37,37,38,38,38,39,39
 dc.w 39,40,40,40,41,41


nste1
* C#3
 dc.w 0,1,1,1,2,2,2,3,3,3,4,4,4,5,5,6,6,6,7,7,7,8,8,8,9,9,9,10,10,10
 dc.w 11,11,11,12,12,12,13,13,13,14,14,14,15,15,15,16,16,17,17,17,18,18,18,19,19,19,20,20,20,21
 dc.w 21,21,22,22,22,23,23,23,24,24,24,25,25,25,26,26,26,27,27,28,28,28,29,29,29,30,30,30,31,31
 dc.w 31,32,32,32,33,33,33,34,34,34,35,35,35,36,36,36,37,37,37,38,38,39,39,39,40,40,40,41,41,41
 dc.w 42,42,42,43,43,43


nste2
* D3 
 dc.w 0,1,1,1,2,2,3,3,3,4,4,4,5,5,5,6,6,7,7,7,8,8,8,9,9,9,10,10,11,11
 dc.w 11,12,12,12,13,13,13,14,14,15,15,15,16,16,16,17,17,17,18,18,19,19,19,20,20,20,21,21,22,22
 dc.w 22,23,23,23,24,24,24,25,25,26,26,26,27,27,27,28,28,28,29,29,30,30,30,31,31,31,32,32,32,33
 dc.w 33,34,34,34,35,35,35,36,36,36,37,37,38,38,38,39,39,39,40,40,40,41,41,42,42,42,43,43,43,44
 dc.w 44,44,45,45,46,46


nste3
* D#3
 dc.w 0,1,1,2,2,2,3,3,3,4,4,5,5,5,6,6,7,7,7,8,8,8,9,9,10,10,10,11,11,12
 dc.w 12,12,13,13,14,14,14,15,15,15,16,16,17,17,17,18,18,19,19,19,20,20,20,21,21,22,22,22,23,23
 dc.w 24,24,24,25,25,25,26,26,27,27,27,28,28,29,29,29,30,30,31,31,31,32,32,32,33,33,34,34,34,35
 dc.w 35,36,36,36,37,37,37,38,38,39,39,39,40,40,41,41,41,42,42,42,43,43,44,44,44,45,45,46,46,46
 dc.w 47,47,47,48,48,49


nste4
* E3 
 dc.w 0,1,1,2,2,2,3,3,4,4,4,5,5,6,6,7,7,7,8,8,9,9,9,10,10,11,11,11,12,12
 dc.w 13,13,13,14,14,15,15,16,16,16,17,17,18,18,18,19,19,20,20,20,21,21,22,22,22,23,23,24,24,25
 dc.w 25,25,26,26,27,27,27,28,28,29,29,29,30,30,31,31,31,32,32,33,33,34,34,34,35,35,36,36,36,37
 dc.w 37,38,38,38,39,39,40,40,40,41,41,42,42,43,43,43,44,44,45,45,45,46,46,47,47,47,48,48,49,49
 dc.w 49,50,50,51,51,52


nste5
* F3 
 dc.w 0,1,1,2,2,3,3,3,4,4,5,5,6,6,7,7,7,8,8,9,9,10,10,10,11,11,12,12,13,13
 dc.w 13,14,14,15,15,16,16,16,17,17,18,18,19,19,20,20,20,21,21,22,22,23,23,23,24,24,25,25,26,26
 dc.w 26,27,27,28,28,29,29,29,30,30,31,31,32,32,33,33,33,34,34,35,35,36,36,36,37,37,38,38,39,39
 dc.w 39,40,40,41,41,42,42,42,43,43,44,44,45,45,46,46,46,47,47,48,48,49,49,49,50,50,51,51,52,52
 dc.w 52,53,53,54,54,55


nste6
* F#3
 dc.w 0,1,1,2,2,3,3,4,4,5,5,6,6,6,7,7,8,8,9,9,10,10,11,11,11,12,12,13,13,14
 dc.w 14,15,15,16,16,17,17,17,18,18,19,19,20,20,21,21,22,22,22,23,23,24,24,25,25,26,26,27,27,28
 dc.w 28,28,29,29,30,30,31,31,32,32,33,33,34,34,34,35,35,36,36,37,37,38,38,39,39,39,40,40,41,41
 dc.w 42,42,43,43,44,44,45,45,45,46,46,47,47,48,48,49,49,50,50,51,51,51,52,52,53,53,54,54,55,55
 dc.w 56,56,56,57,57,58


nste7
* G3 
 dc.w 0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8,9,9,10,10,11,11,12,12,13,13,14,14,15
 dc.w 15,16,16,17,17,18,18,18,19,19,20,20,21,21,22,22,23,23,24,24,25,25,26,26,27,27,28,28,29,29
 dc.w 30,30,31,31,32,32,33,33,34,34,35,35,36,36,36,37,37,38,38,39,39,40,40,41,41,42,42,43,43,44
 dc.w 44,45,45,46,46,47,47,48,48,49,49,50,50,51,51,52,52,53,53,54,54,54,55,55,56,56,57,57,58,58
 dc.w 59,59,60,60,61,61


nste8
* G#3
 dc.w 1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8,9,9,10,10,11,11,12,12,13,13,14,14,15,15
 dc.w 16,16,17,18,18,19,19,20,20,21,21,22,22,23,23,24,24,25,25,26,26,27,27,28,28,29,29,30,30,31
 dc.w 31,32,32,33,33,34,35,35,36,36,37,37,38,38,39,39,40,40,41,41,42,42,43,43,44,44,45,45,46,46
 dc.w 47,47,48,48,49,49,50,51,51,52,52,53,53,54,54,55,55,56,56,57,57,58,58,59,59,60,60,61,61,62
 dc.w 62,63,63,64,64,65


nste9
* A3 
 dc.w 1,1,2,2,3,3,4,4,5,5,6,7,7,8,8,9,9,10,10,11,11,12,13,13,14,14,15,15,16,16
 dc.w 17,17,18,19,19,20,20,21,21,22,22,23,23,24,25,25,26,26,27,27,28,28,29,29,30,31,31,32,32,33
 dc.w 33,34,34,35,35,36,37,37,38,38,39,39,40,40,41,41,42,43,43,44,44,45,45,46,46,47,48,48,49,49
 dc.w 50,50,51,51,52,52,53,54,54,55,55,56,56,57,57,58,58,59,60,60,61,61,62,62,63,63,64,64,65,66
 dc.w 66,67,67,68,68,69


nste10
* A#3
 dc.w 1,1,2,2,3,3,4,5,5,6,6,7,8,8,9,9,10,10,11,12,12,13,13,14,14,15,16,16,17,17
 dc.w 18,19,19,20,20,21,21,22,23,23,24,24,25,25,26,27,27,28,28,29,30,30,31,31,32,32,33,34,34,35
 dc.w 35,36,36,37,38,38,39,39,40,40,41,42,42,43,43,44,45,45,46,46,47,47,48,49,49,50,50,51,51,52
 dc.w 53,53,54,54,55,56,56,57,57,58,58,59,60,60,61,61,62,62,63,64,64,65,65,66,67,67,68,68,69,69
 dc.w 70,71,71,72,72,73


nste11
* B3 
 dc.w 1,1,2,2,3,4,4,5,6,6,7,7,8,9,9,10,10,11,12,12,13,13,14,15,15,16,17,17,18,18
 dc.w 19,20,20,21,21,22,23,23,24,25,25,26,26,27,28,28,29,29,30,31,31,32,32,33,34,34,35,36,36,37
 dc.w 37,38,39,39,40,40,41,42,42,43,44,44,45,45,46,47,47,48,48,49,50,50,51,51,52,53,53,54,55,55
 dc.w 56,56,57,58,58,59,59,60,61,61,62,63,63,64,64,65,66,66,67,67,68,69,69,70,70,71,72,72,73,74
 dc.w 74,75,75,76,77,77


nste12
* C4 
 dc.w 1,1,2,3,3,4,5,5,6,6,7,8,8,9,10,10,11,12,12,13,14,14,15,16,16,17,18,18,19,19
 dc.w 20,21,21,22,23,23,24,25,25,26,27,27,28,29,29,30,31,31,32,32,33,34,34,35,36,36,37,38,38,39
 dc.w 40,40,41,42,42,43,44,44,45,45,46,47,47,48,49,49,50,51,51,52,53,53,54,55,55,56,56,57,58,58
 dc.w 59,60,60,61,62,62,63,64,64,65,66,66,67,68,68,69,69,70,71,71,72,73,73,74,75,75,76,77,77,78
 dc.w 79,79,80,81,81,82


nste13
* C#4
 dc.w 1,1,2,3,3,4,5,6,6,7,8,8,9,10,10,11,12,12,13,14,14,15,16,17,17,18,19,19,20,21
 dc.w 21,22,23,23,24,25,25,26,27,28,28,29,30,30,31,32,32,33,34,34,35,36,36,37,38,39,39,40,41,41
 dc.w 42,43,43,44,45,45,46,47,47,48,49,50,50,51,52,52,53,54,54,55,56,56,57,58,58,59,60,61,61,62
 dc.w 63,63,64,65,65,66,67,67,68,69,69,70,71,72,72,73,74,74,75,76,76,77,78,78,79,80,80,81,82,83
 dc.w 83,84,85,85,86,87


nste14
* D4 
 dc.w 1,1,2,3,4,4,5,6,7,7,8,9,9,10,11,12,12,13,14,15,15,16,17,17,18,19,20,20,21,22
 dc.w 23,23,24,25,26,26,27,28,28,29,30,31,31,32,33,34,34,35,36,36,37,38,39,39,40,41,42,42,43,44
 dc.w 44,45,46,47,47,48,49,50,50,51,52,52,53,54,55,55,56,57,58,58,59,60,60,61,62,63,63,64,65,66
 dc.w 66,67,68,69,69,70,71,71,72,73,74,74,75,76,77,77,78,79,79,80,81,82,82,83,84,85,85,86,87,87
 dc.w 88,89,90,90,91,92


nste15
* D#4
 dc.w 1,2,2,3,4,5,5,6,7,8,8,9,10,11,12,12,13,14,15,15,16,17,18,19,19,20,21,22,22,23
 dc.w 24,25,25,26,27,28,29,29,30,31,32,32,33,34,35,36,36,37,38,39,39,40,41,42,42,43,44,45,46,46
 dc.w 47,48,49,49,50,51,52,53,53,54,55,56,56,57,58,59,59,60,61,62,63,63,64,65,66,66,67,68,69,69
 dc.w 70,71,72,73,73,74,75,76,76,77,78,79,80,80,81,82,83,83,84,85,86,86,87,88,89,90,90,91,92,93
 dc.w 93,94,95,96,97,97


nste16
* E4 
 dc.w 1,2,2,3,4,5,6,7,7,8,9,10,11,11,12,13,14,15,16,16,17,18,19,20,20,21,22,23,24,25
 dc.w 25,26,27,28,29,29,30,31,32,33,34,34,35,36,37,38,38,39,40,41,42,43,43,44,45,46,47,47,48,49
 dc.w 50,51,52,52,53,54,55,56,56,57,58,59,60,61,61,62,63,64,65,65,66,67,68,69,70,70,71,72,73,74
 dc.w 74,75,76,77,78,79,79,80,81,82,83,83,84,85,86,87,88,88,89,90,91,92,92,93,94,95,96,97,97,98
 dc.w 99,100,101,101,102,103


nste17
* F4 
 dc.w 1,2,3,3,4,5,6,7,8,9,10,10,11,12,13,14,15,16,16,17,18,19,20,21,22,23,23,24,25,26
 dc.w 27,28,29,29,30,31,32,33,34,35,36,36,37,38,39,40,41,42,42,43,44,45,46,47,48,49,49,50,51,52
 dc.w 53,54,55,55,56,57,58,59,60,61,62,62,63,64,65,66,67,68,68,69,70,71,72,73,74,75,75,76,77,78
 dc.w 79,80,81,81,82,83,84,85,86,87,88,88,89,90,91,92,93,94,94,95,96,97,98,99,100,101,101,102,103,104
 dc.w 105,106,107,107,108,109


nste18
* F#4
 dc.w 1,2,3,4,5,6,6,7,8,9,10,11,12,13,14,15,16,17,17,18,19,20,21,22,23,24,25,26,27,28
 dc.w 28,29,30,31,32,33,34,35,36,37,38,39,39,40,41,42,43,44,45,46,47,48,49,50,51,51,52,53,54,55
 dc.w 56,57,58,59,60,61,62,62,63,64,65,66,67,68,69,70,71,72,73,73,74,75,76,77,78,79,80,81,82,83
 dc.w 84,84,85,86,87,88,89,90,91,92,93,94,95,96,96,97,98,99,100,101,102,103,104,105,106,107,107,108,109,110
 dc.w 111,112,113,114,115,116


nste19
* G4 
 dc.w 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,18,19,20,21,22,23,24,25,26,27,28,29
 dc.w 30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,54,55,56,57,58
 dc.w 59,60,61,62,63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88
 dc.w 89,90,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117
 dc.w 118,119,120,121,122,123


nste20
* G#4
 dc.w 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,18,19,20,21,22,23,24,25,26,27,28,29,30,31
 dc.w 32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,51,52,53,54,55,56,57,58,59,60,61,62
 dc.w 63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,85,86,87,88,89,90,91,92,93
 dc.w 94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,118,119,120,121,122,123,124
 dc.w 125,126,127,128,129,130


nste21
* A4 
 dc.w 1,2,3,4,5,7,8,9,10,11,12,13,14,15,16,17,19,20,21,22,23,24,25,26,27,28,29,31,32,33
 dc.w 34,35,36,37,38,39,40,41,43,44,45,46,47,48,49,50,51,52,54,55,56,57,58,59,60,61,62,63,64,66
 dc.w 67,68,69,70,71,72,73,74,75,76,78,79,80,81,82,83,84,85,86,87,88,90,91,92,93,94,95,96,97,98
 dc.w 99,100,102,103,104,105,106,107,108,109,110,111,112,114,115,116,117,118,119,120,121,122,123,124,126,127,128,129,130,131
 dc.w 132,133,134,135,137,138


nste22
* A#4
 dc.w 1,2,3,5,6,7,8,9,10,12,13,14,15,16,17,19,20,21,22,23,24,25,27,28,29,30,31,32,34,35
 dc.w 36,37,38,39,40,42,43,44,45,46,47,49,50,51,52,53,54,56,57,58,59,60,61,62,64,65,66,67,68,69
 dc.w 71,72,73,74,75,76,78,79,80,81,82,83,84,86,87,88,89,90,91,93,94,95,96,97,98,99,101,102,103,104
 dc.w 105,106,108,109,110,111,112,113,115,116,117,118,119,120,121,123,124,125,126,127,128,130,131,132,133,134,135,137,138,139
 dc.w 140,141,142,143,145,146


nste23
* B4 
 dc.w 1,2,4,5,6,7,9,10,11,12,13,15,16,17,18,20,21,22,23,25,26,27,28,29,31,32,33,34,36,37
 dc.w 38,39,40,42,43,44,45,47,48,49,50,51,53,54,55,56,58,59,60,61,63,64,65,66,67,69,70,71,72,74
 dc.w 75,76,77,78,80,81,82,83,85,86,87,88,89,91,92,93,94,96,97,98,99,101,102,103,104,105,107,108,109,110
 dc.w 112,113,114,115,116,118,119,120,121,123,124,125,126,127,129,130,131,132,134,135,136,137,139,140,141,142,143,145,146,147
 dc.w 148,150,151,152,153,154


nste24
* C5 
 dc.w 1,3,4,5,6,8,9,10,12,13,14,16,17,18,19,21,22,23,25,26,27,29,30,31,32,34,35,36,38,39
 dc.w 40,42,43,44,45,47,48,49,51,52,53,55,56,57,58,60,61,62,64,65,66,68,69,70,71,73,74,75,77,78
 dc.w 79,81,82,83,84,86,87,88,90,91,92,94,95,96,97,99,100,101,103,104,105,106,108,109,110,112,113,114,116,117
 dc.w 118,119,121,122,123,125,126,127,129,130,131,132,134,135,136,138,139,140,142,143,144,145,147,148,149,151,152,153,155,156
 dc.w 157,158,160,161,162,164


nste25
* C#5
 dc.w 1,3,4,6,7,8,10,11,12,14,15,17,18,19,21,22,23,25,26,28,29,30,32,33,34,36,37,39,40,41
 dc.w 43,44,45,47,48,50,51,52,54,55,56,58,59,61,62,63,65,66,67,69,70,72,73,74,76,77,78,80,81,83
 dc.w 84,85,87,88,89,91,92,94,95,96,98,99,100,102,103,105,106,107,109,110,111,113,114,116,117,118,120,121,122,124
 dc.w 125,127,128,129,131,132,133,135,136,138,139,140,142,143,144,146,147,149,150,151,153,154,155,157,158,160,161,162,164,165
 dc.w 166,168,169,171,172,173


nste26
* D5 
 dc.w 1,3,4,6,7,9,10,12,13,15,16,17,19,20,22,23,25,26,28,29,31,32,34,35,36,38,39,41,42,44
 dc.w 45,47,48,50,51,52,54,55,57,58,60,61,63,64,66,67,69,70,71,73,74,76,77,79,80,82,83,85,86,87
 dc.w 89,90,92,93,95,96,98,99,101,102,103,105,106,108,109,111,112,114,115,117,118,120,121,122,124,125,127,128,130,131
 dc.w 133,134,136,137,138,140,141,143,144,146,147,149,150,152,153,155,156,157,159,160,162,163,165,166,168,169,171,172,173,175
 dc.w 176,178,179,181,182,184


nste27
* D#5
 dc.w 2,3,5,6,8,9,11,12,14,15,17,19,20,22,23,25,26,28,29,31,32,34,36,37,39,40,42,43,45,46
 dc.w 48,49,51,53,54,56,57,59,60,62,63,65,66,68,69,71,73,74,76,77,79,80,82,83,85,86,88,90,91,93
 dc.w 94,96,97,99,100,102,103,105,107,108,110,111,113,114,116,117,119,120,122,124,125,127,128,130,131,133,134,136,137,139
 dc.w 141,142,144,145,147,148,150,151,153,154,156,158,159,161,162,164,165,167,168,170,171,173,175,176,178,179,181,182,184,185
 dc.w 187,188,190,191,193,195


nste28
* E5 
 dc.w 2,3,5,7,8,10,11,13,15,16,18,20,21,23,25,26,28,29,31,33,34,36,38,39,41,43,44,46,47,49
 dc.w 51,52,54,56,57,59,61,62,64,65,67,69,70,72,74,75,77,79,80,82,83,85,87,88,90,92,93,95,97,98
 dc.w 100,101,103,105,106,108,110,111,113,115,116,118,119,121,123,124,126,128,129,131,133,134,136,137,139,141,142,144,146,147
 dc.w 149,151,152,154,155,157,159,160,162,164,165,167,169,170,172,173,175,177,178,180,182,183,185,187,188,190,191,193,195,196
 dc.w 198,200,201,203,205,206


nste29
* F5 
 dc.w 2,3,5,7,9,10,12,14,16,17,19,21,23,24,26,28,29,31,33,35,36,38,40,42,43,45,47,49,50,52
 dc.w 54,55,57,59,61,62,64,66,68,69,71,73,75,76,78,80,81,83,85,87,88,90,92,94,95,97,99,101,102,104
 dc.w 106,107,109,111,113,114,116,118,120,121,123,125,127,128,130,132,133,135,137,139,140,142,144,146,147,149,151,153,154,156
 dc.w 158,159,161,163,165,166,168,170,172,173,175,177,179,180,182,184,185,187,189,191,192,194,196,198,199,201,203,205,206,208
 dc.w 210,211,213,215,217,218


nste30
* F#5
 dc.w 2,4,6,7,9,11,13,15,17,18,20,22,24,26,28,29,31,33,35,37,39,40,42,44,46,48,50,51,53,55
 dc.w 57,59,61,62,64,66,68,70,72,73,75,77,79,81,83,84,86,88,90,92,94,96,97,99,101,103,105,107,108,110
 dc.w 112,114,116,118,119,121,123,125,127,129,130,132,134,136,138,140,141,143,145,147,149,151,152,154,156,158,160,162,163,165
 dc.w 167,169,171,173,174,176,178,180,182,184,185,187,189,191,193,195,197,198,200,202,204,206,208,209,211,213,215,217,219,220
 dc.w 222,224,226,228,230,231


nste31
* G5 
 dc.w 2,4,6,8,10,12,14,16,18,19,21,23,25,27,29,31,33,35,37,39,41,43,45,47,49,51,53,54,56,58
 dc.w 60,62,64,66,68,70,72,74,76,78,80,82,84,86,88,90,91,93,95,97,99,101,103,105,107,109,111,113,115,117
 dc.w 119,121,123,125,126,128,130,132,134,136,138,140,142,144,146,148,150,152,154,156,158,160,161,163,165,167,169,171,173,175
 dc.w 177,179,181,183,185,187,189,191,193,195,197,198,200,202,204,206,208,210,212,214,216,218,220,222,224,226,228,230,232,233
 dc.w 235,237,239,241,243,245


nste32
* G#5
 dc.w 2,4,6,8,10,12,14,16,19,21,23,25,27,29,31,33,35,37,39,41,43,45,47,49,52,54,56,58,60,62
 dc.w 64,66,68,70,72,74,76,78,80,82,85,87,89,91,93,95,97,99,101,103,105,107,109,111,113,115,118,120,122,124
 dc.w 126,128,130,132,134,136,138,140,142,144,146,148,150,153,155,157,159,161,163,165,167,169,171,173,175,177,179,181,183,186
 dc.w 188,190,192,194,196,198,200,202,204,206,208,210,212,214,216,219,221,223,225,227,229,231,233,235,237,239,241,243,245,247
 dc.w 249,251,254,256,258,260


nste33
* A5 
 dc.w 2,4,7,9,11,13,15,17,20,22,24,26,28,31,33,35,37,39,41,44,46,48,50,52,55,57,59,61,63,66
 dc.w 68,70,72,74,76,79,81,83,85,87,90,92,94,96,98,100,103,105,107,109,111,114,116,118,120,122,124,127,129,131
 dc.w 133,135,138,140,142,144,146,149,151,153,155,157,159,162,164,166,168,170,173,175,177,179,181,183,186,188,190,192,194,197
 dc.w 199,201,203,205,207,210,212,214,216,218,221,223,225,227,229,232,234,236,238,240,242,245,247,249,251,253,256,258,260,262
 dc.w 264,266,269,271,273,275


nste34
* A#5
 dc.w 2,5,7,9,12,14,16,19,21,23,25,28,30,32,35,37,39,42,44,46,49,51,53,56,58,60,62,65,67,69
 dc.w 72,74,76,79,81,83,86,88,90,93,95,97,99,102,104,106,109,111,113,116,118,120,123,125,127,130,132,134,137,139
 dc.w 141,143,146,148,150,153,155,157,160,162,164,167,169,171,174,176,178,180,183,185,187,190,192,194,197,199,201,204,206,208
 dc.w 211,213,215,218,220,222,224,227,229,231,234,236,238,241,243,245,248,250,252,255,257,259,261,264,266,268,271,273,275,278
 dc.w 280,282,285,287,289,292


nste35
* B5 
 dc.w 2,5,7,10,12,15,17,20,22,25,27,29,32,34,37,39,42,44,47,49,51,54,56,59,61,64,66,69,71,74
 dc.w 76,78,81,83,86,88,91,93,96,98,101,103,105,108,110,113,115,118,120,123,125,127,130,132,135,137,140,142,145,147
 dc.w 150,152,154,157,159,162,164,167,169,172,174,177,179,181,184,186,189,191,194,196,199,201,203,206,208,211,213,216,218,221
 dc.w 223,226,228,230,233,235,238,240,243,245,248,250,253,255,257,260,262,265,267,270,272,275,277,279,282,284,287,289,292,294
 dc.w 297,299,302,304,306,309


nste36
* C6
 dc.w 3,5,8,10,13,16,18,21,23,26,29,31,34,36,39,42,44,47,49,52,55,57,60,62,65,68,70,73,75,78
 dc.w 81,83,86,88,91,94,96,99,101,104,106,109,112,114,117,119,122,125,127,130,132,135,138,140,143,145,148,151,153,156
 dc.w 158,161,164,166,169,171,174,177,179,182,184,187,190,192,195,197,200,203,205,208,210,213,216,218,221,223,226,229,231,234
 dc.w 236,239,242,244,247,249,252,255,257,260,262,265,268,270,273,275,278,281,283,286,288,291,293,296,299,301,304,306,309,312
 dc.w 314,317,319,322,325,327


