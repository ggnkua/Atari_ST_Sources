*  dc.w   $04,$44,$06,$66,$0444
*  dc.w   $04,$44,$06,$66,$04,$44,$06,$66
*  dc.w   $04,$44,$06,$66,$04,$44,$06,$66
*  dc.w   $04,$44,$06,$66,$04,$44,$06,$66
*  dc.w   $04,$44,$06,$66,$04,$44,$06,$66
*  dc.w   $04,$44,$06,$66,$04,$44,$06,$66
*  dc.w   $04,$44,$06,$66,$04,$44,$06,$66
*  dc.w   $04,$44,$06,$66,$04,$44,$06,$66
*  dc.w   $06,$72,$04,$61,$06,$72,$04,$61
*  dc.w   $06,$72,$04,$61,$06,$72,$04,$61
*  dc.w   $06,$72,$04,$61,$06,$72,$04,$61
*  dc.w   $06,$72,$04,$61,$06,$72,$04,$61
*  dc.w   $06,$72,$04,$61
*






 dc.w $077,$200
 dc.w $077,$200
 dc.w $077,$200
 dc.w $077,$200
 dc.w $077,$200
 dc.w $077,$200
 dc.w $177,$200
 dc.w $077,$200
 dc.w $177,$200
 dc.w $077,$200
 dc.w $177,$200
 dc.w $177,$200
 dc.w $277,$200
 dc.w $177,$200
 dc.w $277,$200
 dc.w $177,$200
 dc.w $277,$200
 dc.w $177,$200
 dc.w $277,$200
 dc.w $277,$200
 dc.w $277,$200
 dc.w $377,$200
 dc.w $277,$200
 dc.w $377,$200
 dc.w $277,$200
 dc.w $377,$200
 dc.w $377,$200
 dc.w $377,$200
 dc.w $477,$200
 dc.w $377,$200
 dc.w $477,$200
 dc.w $477,$200
 dc.w $477,$200
 dc.w $477,$200
 dc.w $477,$200
 dc.w $477,$200
 dc.w $577,$200
 dc.w $477,$200
 dc.w $477,$200
 dc.w $577,$200
 dc.w $477,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $477,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200
 dc.w $577,$200


****** montagnes *******
 dc.w $577,$0
 dc.w $677,$0
 dc.w $577,$0
 dc.w $677,$0
 dc.w $577,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $677,$0
 dc.w $777,$0
 dc.w $677,$0
 dc.w $777,$0
 dc.w $777,$0
 dc.w $776,$0

  dc.w $0776,0
  dc.w $0775,0
  dc.w $0775,0
  dc.w $0774,0
  dc.w $0774,0
  dc.w $0773,0
  dc.w $0773,0
  dc.w $0772,0
  dc.w $0772,0
  dc.w $0771,0
  dc.w $0771,0
  dc.w $0770,0
  dc.w $0760,0
  dc.w $0760,0
  dc.w $0750,0
  dc.w $0740,0
  dc.w $0750,0
  dc.w $0740,0
  dc.w $0730,0
  dc.w $0740,0
  dc.w $0730,0

*  dc.w $0720
*  dc.w $0730
*  dc.w $0720
*  dc.w $0710
*  dc.w $0720
*  dc.w $0710
*  dc.w $0700
*  dc.w $0710
*  dc.w $0700
*  dc.w $0701
*  dc.w $0701
*  dc.w $0712
*  dc.w $0713
*  dc.w $0444
*
*21

 dcb.l 24+6+12+1,0 * noir monts en couleur 0 en dessous du sprite ...
******* verdure ********

 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461

 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140

 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
