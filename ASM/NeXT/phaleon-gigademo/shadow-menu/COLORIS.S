 dc.w $017,$200
 dc.w $017,$200
 dc.w $017,$200
 dc.w $027,$200
 dc.w $017,$200
 dc.w $017,$200
 dc.w $027,$200
 dc.w $017,$200
 dc.w $027,$200
 dc.w $017,$200
 dc.w $027,$200
 dc.w $017,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $017,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $137,$200
 dc.w $027,$200
 dc.w $027,$200
 dc.w $137,$200
 dc.w $027,$200
 dc.w $137,$200
 dc.w $027,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $027,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $137,$200
 dc.w $237,$200
 dc.w $137,$200
 dc.w $237,$200
 dc.w $137,$200
 dc.w $237,$200
 dc.w $237,$200
 dc.w $137,$200
 dc.w $237,$200
 dc.w $237,$200
 dc.w $237,$200
 dc.w $237,$200
 dc.w $237,$200


****** montagnes *******
 dc.w $237,$0
 dc.w $237,$0
 dc.w $337,$0
 dc.w $237,$0
 dc.w $337,$0
 dc.w $237,$0
 dc.w $337,$0
 dc.w $337,$0
 dc.w $237,$0
 dc.w $337,$0
 dc.w $337,$0
 dc.w $337,$0
 dc.w $337,$0
 dc.w $337,$0
 dc.w $447,$0
 dc.w $337,$0
 dc.w $337,$0
 dc.w $447,$0
 dc.w $337,$0
 dc.w $447,$0
 dc.w $447,$0
 dc.w $337,$0
 dc.w $447,$0
 dc.w $447,$0
 dc.w $447,$0
 dc.w $447,$0
 dc.w $557,$0
 dc.w $447,$0
 dc.w $447,$0
 dc.w $557,$0
 dc.w $447,$0
 dc.w $557,$0
 dc.w $557,$0
 dc.w $447,$0
 dc.w $557,$0
 dc.w $557,$0
 dc.w $557,$0
 dc.w $657,$0
 dc.w $557,$0
 dc.w $557,$0

 dcb.l 24+6+12+1,0 * noir monts en couleur 0 en dessous du sprite ...
******* verdure ********

 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461
 dc.w $672,$461

 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$461
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140
 dc.w $351,$140

 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
 dc.w $030,$140
