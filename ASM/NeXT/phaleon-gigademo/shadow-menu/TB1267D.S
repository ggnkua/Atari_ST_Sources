nste0
* C3 
 dc.w 1,1,2,3,3,4,5,5,6,6,7,8,8,9,10,10,11,12,12,13,14,14,15,16,16,17,18,18,19,19
 dc.w 20,21,21,22,23,23,24,25,25,26,27,27,28,29,29,30,31,31,32,32,33,34,34,35,36,36,37,38,38,39
 dc.w 40,40,41,42,42,43,44,44,45,45,46,47,47,48,49,49,50,51,51,52,53,53,54,55,55,56,56,57,58,58
 dc.w 59,60,60,61,62,62,63,64,64,65,66,66,67,68,68,69,69,70,71,71,72,73,73,74,75,75,76,77,77,78
 dc.w 79,79,80,81,81,82


nste1
* C#3
 dc.w 1,1,2,3,3,4,5,6,6,7,8,8,9,10,10,11,12,12,13,14,14,15,16,17,17,18,19,19,20,21
 dc.w 21,22,23,23,24,25,25,26,27,28,28,29,30,30,31,32,32,33,34,34,35,36,36,37,38,39,39,40,41,41
 dc.w 42,43,43,44,45,45,46,47,47,48,49,50,50,51,52,52,53,54,54,55,56,56,57,58,58,59,60,61,61,62
 dc.w 63,63,64,65,65,66,67,67,68,69,69,70,71,72,72,73,74,74,75,76,76,77,78,78,79,80,80,81,82,83
 dc.w 83,84,85,85,86,87


nste2
* D3 
 dc.w 1,1,2,3,4,4,5,6,7,7,8,9,9,10,11,12,12,13,14,15,15,16,17,17,18,19,20,20,21,22
 dc.w 23,23,24,25,26,26,27,28,28,29,30,31,31,32,33,34,34,35,36,36,37,38,39,39,40,41,42,42,43,44
 dc.w 44,45,46,47,47,48,49,50,50,51,52,52,53,54,55,55,56,57,58,58,59,60,60,61,62,63,63,64,65,66
 dc.w 66,67,68,69,69,70,71,71,72,73,74,74,75,76,77,77,78,79,79,80,81,82,82,83,84,85,85,86,87,87
 dc.w 88,89,90,90,91,92


nste3
* D#3
 dc.w 1,2,2,3,4,5,5,6,7,8,8,9,10,11,12,12,13,14,15,15,16,17,18,19,19,20,21,22,22,23
 dc.w 24,25,25,26,27,28,29,29,30,31,32,32,33,34,35,36,36,37,38,39,39,40,41,42,42,43,44,45,46,46
 dc.w 47,48,49,49,50,51,52,53,53,54,55,56,56,57,58,59,59,60,61,62,63,63,64,65,66,66,67,68,69,70
 dc.w 70,71,72,73,73,74,75,76,76,77,78,79,80,80,81,82,83,83,84,85,86,86,87,88,89,90,90,91,92,93
 dc.w 93,94,95,96,97,97


nste4
* E3 
 dc.w 1,2,2,3,4,5,6,7,7,8,9,10,11,11,12,13,14,15,16,16,17,18,19,20,20,21,22,23,24,25
 dc.w 25,26,27,28,29,29,30,31,32,33,34,34,35,36,37,38,38,39,40,41,42,43,43,44,45,46,47,47,48,49
 dc.w 50,51,52,52,53,54,55,56,56,57,58,59,60,61,61,62,63,64,65,65,66,67,68,69,70,70,71,72,73,74
 dc.w 74,75,76,77,78,79,79,80,81,82,83,83,84,85,86,87,88,88,89,90,91,92,92,93,94,95,96,97,97,98
 dc.w 99,100,101,101,102,103


nste5
* F3 
 dc.w 1,2,3,3,4,5,6,7,8,9,10,10,11,12,13,14,15,16,16,17,18,19,20,21,22,23,23,24,25,26
 dc.w 27,28,29,29,30,31,32,33,34,35,36,36,37,38,39,40,41,42,42,43,44,45,46,47,48,49,49,50,51,52
 dc.w 53,54,55,55,56,57,58,59,60,61,62,62,63,64,65,66,67,68,68,69,70,71,72,73,74,75,75,76,77,78
 dc.w 79,80,81,81,82,83,84,85,86,87,88,88,89,90,91,92,93,94,94,95,96,97,98,99,100,101,101,102,103,104
 dc.w 105,106,107,107,108,109


nste6
* F#3
 dc.w 1,2,3,4,5,6,6,7,8,9,10,11,12,13,14,15,16,17,17,18,19,20,21,22,23,24,25,26,27,28
 dc.w 28,29,30,31,32,33,34,35,36,37,38,39,39,40,41,42,43,44,45,46,47,48,49,50,51,51,52,53,54,55
 dc.w 56,57,58,59,60,61,62,62,63,64,65,66,67,68,69,70,71,72,73,73,74,75,76,77,78,79,80,81,82,83
 dc.w 84,84,85,86,87,88,89,90,91,92,93,94,95,96,96,97,98,99,100,101,102,103,104,105,106,107,107,108,109,110
 dc.w 111,112,113,114,115,116


nste7
* G3 
 dc.w 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,18,19,20,21,22,23,24,25,26,27,28,29
 dc.w 30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,54,55,56,57,58
 dc.w 59,60,61,62,63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88
 dc.w 89,90,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117
 dc.w 118,119,120,121,122,123


nste8
* G#3
 dc.w 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,18,19,20,21,22,23,24,25,26,27,28,29,30,31
 dc.w 32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,51,52,53,54,55,56,57,58,59,60,61,62
 dc.w 63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,85,86,87,88,89,90,91,92,93
 dc.w 94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,118,119,120,121,122,123,124
 dc.w 125,126,127,128,129,130


nste9
* A3 
 dc.w 1,2,3,4,5,7,8,9,10,11,12,13,14,15,16,17,19,20,21,22,23,24,25,26,27,28,29,31,32,33
 dc.w 34,35,36,37,38,39,40,41,43,44,45,46,47,48,49,50,51,52,54,55,56,57,58,59,60,61,62,63,64,66
 dc.w 67,68,69,70,71,72,73,74,75,76,78,79,80,81,82,83,84,85,86,87,88,90,91,92,93,94,95,96,97,98
 dc.w 99,100,102,103,104,105,106,107,108,109,110,111,112,114,115,116,117,118,119,120,121,122,123,124,126,127,128,129,130,131
 dc.w 132,133,134,135,137,138


nste10
* A#3
 dc.w 1,2,3,5,6,7,8,9,10,12,13,14,15,16,17,19,20,21,22,23,24,25,27,28,29,30,31,32,34,35
 dc.w 36,37,38,39,40,42,43,44,45,46,47,49,50,51,52,53,54,56,57,58,59,60,61,62,64,65,66,67,68,69
 dc.w 71,72,73,74,75,76,78,79,80,81,82,83,84,86,87,88,89,90,91,93,94,95,96,97,98,100,101,102,103,104
 dc.w 105,106,108,109,110,111,112,113,115,116,117,118,119,120,121,123,124,125,126,127,128,130,131,132,133,134,135,137,138,139
 dc.w 140,141,142,143,145,146


nste11
* B3 
 dc.w 1,2,4,5,6,7,9,10,11,12,13,15,16,17,18,20,21,22,23,25,26,27,28,29,31,32,33,34,36,37
 dc.w 38,39,40,42,43,44,45,47,48,49,50,51,53,54,55,56,58,59,60,61,63,64,65,66,67,69,70,71,72,74
 dc.w 75,76,77,78,80,81,82,83,85,86,87,88,89,91,92,93,94,96,97,98,99,101,102,103,104,105,107,108,109,110
 dc.w 112,113,114,115,116,118,119,120,121,123,124,125,126,127,129,130,131,132,134,135,136,137,139,140,141,142,143,145,146,147
 dc.w 148,150,151,152,153,154


nste12
* C4 
 dc.w 1,3,4,5,6,8,9,10,12,13,14,16,17,18,19,21,22,23,25,26,27,29,30,31,32,34,35,36,38,39
 dc.w 40,42,43,44,45,47,48,49,51,52,53,55,56,57,58,60,61,62,64,65,66,68,69,70,71,73,74,75,77,78
 dc.w 79,81,82,83,84,86,87,88,90,91,92,94,95,96,97,99,100,101,103,104,105,106,108,109,110,112,113,114,116,117
 dc.w 118,119,121,122,123,125,126,127,129,130,131,132,134,135,136,138,139,140,142,143,144,145,147,148,149,151,152,153,155,156
 dc.w 157,158,160,161,162,164


nste13
* C#4
 dc.w 1,3,4,6,7,8,10,11,12,14,15,17,18,19,21,22,23,25,26,28,29,30,32,33,34,36,37,39,40,41
 dc.w 43,44,45,47,48,50,51,52,54,55,56,58,59,61,62,63,65,66,67,69,70,72,73,74,76,77,78,80,81,83
 dc.w 84,85,87,88,89,91,92,94,95,96,98,99,100,102,103,105,106,107,109,110,111,113,114,116,117,118,120,121,122,124
 dc.w 125,127,128,129,131,132,133,135,136,138,139,140,142,143,144,146,147,149,150,151,153,154,155,157,158,160,161,162,164,165
 dc.w 166,168,169,171,172,173


nste14
* D4 
 dc.w 1,3,4,6,7,9,10,12,13,15,16,17,19,20,22,23,25,26,28,29,31,32,34,35,36,38,39,41,42,44
 dc.w 45,47,48,50,51,52,54,55,57,58,60,61,63,64,66,67,69,70,71,73,74,76,77,79,80,82,83,85,86,87
 dc.w 89,90,92,93,95,96,98,99,101,102,104,105,106,108,109,111,112,114,115,117,118,120,121,122,124,125,127,128,130,131
 dc.w 133,134,136,137,138,140,141,143,144,146,147,149,150,152,153,155,156,157,159,160,162,163,165,166,168,169,171,172,173,175
 dc.w 176,178,179,181,182,184


nste15
* D#4
 dc.w 2,3,5,6,8,9,11,12,14,15,17,19,20,22,23,25,26,28,29,31,32,34,36,37,39,40,42,43,45,46
 dc.w 48,49,51,53,54,56,57,59,60,62,63,65,66,68,70,71,73,74,76,77,79,80,82,83,85,86,88,90,91,93
 dc.w 94,96,97,99,100,102,103,105,107,108,110,111,113,114,116,117,119,120,122,124,125,127,128,130,131,133,134,136,137,139
 dc.w 141,142,144,145,147,148,150,151,153,154,156,158,159,161,162,164,165,167,168,170,171,173,175,176,178,179,181,182,184,185
 dc.w 187,188,190,192,193,195


nste16
* E4 
 dc.w 2,3,5,7,8,10,11,13,15,16,18,20,21,23,25,26,28,29,31,33,34,36,38,39,41,43,44,46,47,49
 dc.w 51,52,54,56,57,59,61,62,64,65,67,69,70,72,74,75,77,79,80,82,83,85,87,88,90,92,93,95,97,98
 dc.w 100,101,103,105,106,108,110,111,113,115,116,118,119,121,123,124,126,128,129,131,133,134,136,137,139,141,142,144,146,147
 dc.w 149,151,152,154,155,157,159,160,162,164,165,167,169,170,172,173,175,177,178,180,182,183,185,187,188,190,191,193,195,196
 dc.w 198,200,201,203,205,206


nste17
* F4 
 dc.w 2,3,5,7,9,10,12,14,16,17,19,21,23,24,26,28,29,31,33,35,36,38,40,42,43,45,47,49,50,52
 dc.w 54,55,57,59,61,62,64,66,68,69,71,73,75,76,78,80,81,83,85,87,88,90,92,94,95,97,99,101,102,104
 dc.w 106,107,109,111,113,114,116,118,120,121,123,125,127,128,130,132,133,135,137,139,140,142,144,146,147,149,151,153,154,156
 dc.w 158,159,161,163,165,166,168,170,172,173,175,177,179,180,182,184,185,187,189,191,192,194,196,198,199,201,203,205,206,208
 dc.w 210,211,213,215,217,218


nste18
* F#4
 dc.w 2,4,6,7,9,11,13,15,17,18,20,22,24,26,28,29,31,33,35,37,39,40,42,44,46,48,50,51,53,55
 dc.w 57,59,61,62,64,66,68,70,72,73,75,77,79,81,83,84,86,88,90,92,94,96,97,99,101,103,105,107,108,110
 dc.w 112,114,116,118,119,121,123,125,127,129,130,132,134,136,138,140,141,143,145,147,149,151,152,154,156,158,160,162,163,165
 dc.w 167,169,171,173,174,176,178,180,182,184,186,187,189,191,193,195,197,198,200,202,204,206,208,209,211,213,215,217,219,220
 dc.w 222,224,226,228,230,231


nste19
* G4 
 dc.w 2,4,6,8,10,12,14,16,18,19,21,23,25,27,29,31,33,35,37,39,41,43,45,47,49,51,53,54,56,58
 dc.w 60,62,64,66,68,70,72,74,76,78,80,82,84,86,88,90,91,93,95,97,99,101,103,105,107,109,111,113,115,117
 dc.w 119,121,123,125,126,128,130,132,134,136,138,140,142,144,146,148,150,152,154,156,158,160,162,163,165,167,169,171,173,175
 dc.w 177,179,181,183,185,187,189,191,193,195,197,198,200,202,204,206,208,210,212,214,216,218,220,222,224,226,228,230,232,234
 dc.w 235,237,239,241,243,245


nste20
* G#4
 dc.w 2,4,6,8,10,12,14,16,19,21,23,25,27,29,31,33,35,37,39,41,43,45,47,49,52,54,56,58,60,62
 dc.w 64,66,68,70,72,74,76,78,80,82,85,87,89,91,93,95,97,99,101,103,105,107,109,111,113,115,118,120,122,124
 dc.w 126,128,130,132,134,136,138,140,142,144,146,148,150,153,155,157,159,161,163,165,167,169,171,173,175,177,179,181,183,186
 dc.w 188,190,192,194,196,198,200,202,204,206,208,210,212,214,216,219,221,223,225,227,229,231,233,235,237,239,241,243,245,247
 dc.w 249,252,254,256,258,260


nste21
* A4 
 dc.w 2,4,7,9,11,13,15,17,20,22,24,26,28,31,33,35,37,39,41,44,46,48,50,52,55,57,59,61,63,66
 dc.w 68,70,72,74,76,79,81,83,85,87,90,92,94,96,98,100,103,105,107,109,111,114,116,118,120,122,124,127,129,131
 dc.w 133,135,138,140,142,144,146,149,151,153,155,157,159,162,164,166,168,170,173,175,177,179,181,183,186,188,190,192,194,197
 dc.w 199,201,203,205,207,210,212,214,216,218,221,223,225,227,229,232,234,236,238,240,242,245,247,249,251,253,256,258,260,262
 dc.w 264,266,269,271,273,275


nste22
* A#4
 dc.w 2,5,7,9,12,14,16,19,21,23,25,28,30,32,35,37,39,42,44,46,49,51,53,56,58,60,62,65,67,69
 dc.w 72,74,76,79,81,83,86,88,90,93,95,97,100,102,104,106,109,111,113,116,118,120,123,125,127,130,132,134,137,139
 dc.w 141,143,146,148,150,153,155,157,160,162,164,167,169,171,174,176,178,180,183,185,187,190,192,194,197,199,201,204,206,208
 dc.w 211,213,215,218,220,222,224,227,229,231,234,236,238,241,243,245,248,250,252,255,257,259,261,264,266,268,271,273,275,278
 dc.w 280,282,285,287,289,292


nste23
* B4 
 dc.w 2,5,7,10,12,15,17,20,22,25,27,29,32,34,37,39,42,44,47,49,51,54,56,59,61,64,66,69,71,74
 dc.w 76,78,81,83,86,88,91,93,96,98,101,103,105,108,110,113,115,118,120,123,125,127,130,132,135,137,140,142,145,147
 dc.w 150,152,154,157,159,162,164,167,169,172,174,177,179,181,184,186,189,191,194,196,199,201,203,206,208,211,213,216,218,221
 dc.w 223,226,228,230,233,235,238,240,243,245,248,250,253,255,257,260,262,265,267,270,272,275,277,279,282,284,287,289,292,294
 dc.w 297,299,302,304,306,309


nste24
* C5 
 dc.w 3,5,8,10,13,16,18,21,23,26,29,31,34,36,39,42,44,47,49,52,55,57,60,62,65,68,70,73,75,78
 dc.w 81,83,86,88,91,94,96,99,101,104,106,109,112,114,117,119,122,125,127,130,132,135,138,140,143,145,148,151,153,156
 dc.w 158,161,164,166,169,171,174,177,179,182,184,187,190,192,195,197,200,203,205,208,210,213,216,218,221,223,226,229,231,234
 dc.w 236,239,242,244,247,249,252,255,257,260,262,265,268,270,273,275,278,281,283,286,288,291,294,296,299,301,304,307,309,312
 dc.w 314,317,319,322,325,327


nste25
* C#5
 dc.w 3,6,8,11,14,17,19,22,25,28,30,33,36,39,41,44,47,50,52,55,58,61,63,66,69,72,74,77,80,83
 dc.w 85,88,91,94,96,99,102,105,107,110,113,116,118,121,124,127,129,132,135,138,140,143,146,149,151,154,157,160,162,165
 dc.w 168,171,173,176,179,182,184,187,190,193,195,198,201,204,206,209,212,215,217,220,223,226,228,231,234,237,239,242,245,248
 dc.w 250,253,256,259,261,264,267,270,272,275,278,281,283,286,289,292,294,297,300,303,305,308,311,314,316,319,322,325,327,330
 dc.w 333,336,338,341,344,347


nste26
* D5 
 dc.w 3,6,9,12,15,17,20,23,26,29,32,35,38,41,44,47,50,52,55,58,61,64,67,70,73,76,79,82,85,87
 dc.w 90,93,96,99,102,105,108,111,114,117,120,122,125,128,131,134,137,140,143,146,149,152,155,157,160,163,166,169,172,175
 dc.w 178,181,184,187,190,192,195,198,201,204,207,210,213,216,219,222,224,227,230,233,236,239,242,245,248,251,254,257,259,262
 dc.w 265,268,271,274,277,280,283,286,289,292,294,297,300,303,306,309,312,315,318,321,324,327,329,332,335,338,341,344,347,350
 dc.w 353,356,359,362,364,367


nste27
* D#5
 dc.w 3,6,9,12,15,19,22,25,28,31,34,37,40,43,46,49,53,56,59,62,65,68,71,74,77,80,83,86,90,93
 dc.w 96,99,102,105,108,111,114,117,120,124,127,130,133,136,139,142,145,148,151,154,158,161,164,167,170,173,176,179,182,185
 dc.w 188,192,195,198,201,204,207,210,213,216,219,222,225,229,232,235,238,241,244,247,250,253,256,259,263,266,269,272,275,278
 dc.w 281,284,287,290,293,297,300,303,306,309,312,315,318,321,324,327,331,334,337,340,343,346,349,352,355,358,361,364,368,371
 dc.w 374,377,380,383,386,389


nste28
* E5 
 dc.w 3,7,10,13,16,20,23,26,29,33,36,39,43,46,49,52,56,59,62,65,69,72,75,79,82,85,88,92,95,98
 dc.w 101,105,108,111,115,118,121,124,128,131,134,137,141,144,147,151,154,157,160,164,167,170,173,177,180,183,187,190,193,196
 dc.w 200,203,206,209,213,216,219,223,226,229,232,236,239,242,245,249,252,255,259,262,265,268,272,275,278,281,285,288,291,295
 dc.w 298,301,304,308,311,314,317,321,324,327,331,334,337,340,344,347,350,353,357,360,363,367,370,373,376,380,383,386,389,393
 dc.w 396,399,403,406,409,412


nste29
* F5 
 dc.w 3,7,10,14,17,21,24,28,31,35,38,42,45,49,52,55,59,62,66,69,73,76,80,83,87,90,94,97,101,104
 dc.w 107,111,114,118,121,125,128,132,135,139,142,146,149,153,156,159,163,166,170,173,177,180,184,187,191,194,198,201,205,208
 dc.w 211,215,218,222,225,229,232,236,239,243,246,250,253,257,260,264,267,270,274,277,281,284,288,291,295,298,302,305,309,312
 dc.w 316,319,322,326,329,333,336,340,343,347,350,354,357,361,364,368,371,374,378,381,385,388,392,395,399,402,406,409,413,416
 dc.w 420,423,426,430,433,437


nste30
* F#5
 dc.w 4,7,11,15,18,22,26,29,33,37,40,44,48,51,55,59,62,66,70,73,77,81,84,88,92,96,99,103,107,110
 dc.w 114,118,121,125,129,132,136,140,143,147,151,154,158,162,165,169,173,176,180,184,187,191,195,198,202,206,209,213,217,220
 dc.w 224,228,231,235,239,242,246,250,253,257,261,264,268,272,276,279,283,287,290,294,298,301,305,309,312,316,320,323,327,331
 dc.w 334,338,342,345,349,353,356,360,364,367,371,375,378,382,386,389,393,397,400,404,408,411,415,419,422,426,430,433,437,441
 dc.w 444,448,452,455,459,463


nste31
* G5 
 dc.w 4,8,12,16,19,23,27,31,35,39,43,47,51,54,58,62,66,70,74,78,82,86,90,93,97,101,105,109,113,117
 dc.w 121,125,128,132,136,140,144,148,152,156,160,163,167,171,175,179,183,187,191,195,198,202,206,210,214,218,222,226,230,234
 dc.w 237,241,245,249,253,257,261,265,269,272,276,280,284,288,292,296,300,304,307,311,315,319,323,327,331,335,339,342,346,350
 dc.w 354,358,362,366,370,374,378,381,385,389,393,397,401,405,409,413,416,420,424,428,432,436,440,444,448,451,455,459,463,467
 dc.w 471,475,479,483,486,490


nste32
* G#5
 dc.w 4,8,12,16,21,25,29,33,37,41,45,49,54,58,62,66,70,74,78,82,87,91,95,99,103,107,111,115,120,124
 dc.w 128,132,136,140,144,148,153,157,161,165,169,173,177,181,186,190,194,198,202,206,210,214,219,223,227,231,235,239,243,247
 dc.w 252,256,260,264,268,272,276,280,285,289,293,297,301,305,309,313,317,322,326,330,334,338,342,346,350,355,359,363,367,371
 dc.w 375,379,383,388,392,396,400,404,408,412,416,421,425,429,433,437,441,445,449,454,458,462,466,470,474,478,482,487,491,495
 dc.w 499,503,507,511,515,520


nste33
* A5 
 dc.w 4,9,13,17,22,26,31,35,39,44,48,52,57,61,66,70,74,79,83,87,92,96,100,105,109,114,118,122,127,131
 dc.w 135,140,144,149,153,157,162,166,170,175,179,183,188,192,197,201,205,210,214,218,223,227,232,236,240,245,249,253,258,262
 dc.w 266,271,275,280,284,288,293,297,301,306,310,315,319,323,328,332,336,341,345,349,354,358,363,367,371,376,380,384,389,393
 dc.w 398,402,406,411,415,419,424,428,432,437,441,446,450,454,459,463,467,472,476,481,485,489,494,498,502,507,511,515,520,524
 dc.w 529,533,537,542,546,550


nste34
* A#5
 dc.w 5,9,14,19,23,28,32,37,42,46,51,56,60,65,69,74,79,83,88,93,97,102,106,111,116,120,125,130,134,139
 dc.w 143,148,153,157,162,167,171,176,180,185,190,194,199,204,208,213,218,222,227,231,236,241,245,250,255,259,264,268,273,278
 dc.w 282,287,292,296,301,305,310,315,319,324,329,333,338,342,347,352,356,361,366,370,375,380,384,389,393,398,403,407,412,417
 dc.w 421,426,430,435,440,444,449,454,458,463,467,472,477,481,486,491,495,500,504,509,514,518,523,528,532,537,541,546,551,555
 dc.w 560,565,569,574,579,583


nste35
* B5 
 dc.w 5,10,15,20,25,29,34,39,44,49,54,59,64,69,74,78,83,88,93,98,103,108,113,118,123,127,132,137,142,147
 dc.w 152,157,162,167,172,177,181,186,191,196,201,206,211,216,221,226,230,235,240,245,250,255,260,265,270,275,279,284,289,294
 dc.w 299,304,309,314,319,324,329,333,338,343,348,353,358,363,368,373,378,382,387,392,397,402,407,412,417,422,427,431,436,441
 dc.w 446,451,456,461,466,471,476,481,485,490,495,500,505,510,515,520,525,530,534,539,544,549,554,559,564,569,574,579,584,588
 dc.w 593,598,603,608,613,618


nste36
* C6
 dc.w 5,10,16,21,26,31,36,42,47,52,57,62,68,73,78,83,88,94,99,104,109,114,119,125,130,135,140,145,151,156
 dc.w 161,166,171,177,182,187,192,197,203,208,213,218,223,229,234,239,244,249,255,260,265,270,275,281,286,291,296,301,307,312
 dc.w 317,322,327,332,338,343,348,353,358,364,369,374,379,384,390,395,400,405,410,416,421,426,431,436,442,447,452,457,462,468
 dc.w 473,478,483,488,494,499,504,509,514,519,525,530,535,540,545,551,556,561,566,571,577,582,587,592,597,603,608,613,618,623
 dc.w 629,634,639,644,649,655


