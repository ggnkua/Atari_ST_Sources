*-------------------------------------------
* liste des screens installes sur le disk 2
*  dc x,p,s,f

*  x nombre de secteurs ke prend le fichier sur disk
*  p piste de depart
*  s secteur de depart (non compris)
*  f face de depart 


* tsb.dat Taille :$0000405E \00016478 octets.
*  a partir de la piste :\00000001 , secteur :\00000001  , face 0
*  jusqu'a la piste :\00000004 , secteur :\00000004 , face 0
 dc 0033,0001,0001,0

* aenigmat.dat Taille :$00005ACC \00023244 octets.
*  a partir de la piste :\00000004 , secteur :\00000004  , face 0
*  jusqu'a la piste :\00000008 , secteur :\00000010 , face 0
 dc 0046,0004,0004,0

* chaotic3.dat Taille :$00008538 \00034104 octets.
*  a partir de la piste :\00000008 , secteur :\00000010  , face 0
*  jusqu'a la piste :\00000015 , secteur :\00000007 , face 0
 dc 0067,0008,0010,0

* dnt_crew.dat Taille :$000130B4 \00078004 octets.
*  a partir de la piste :\00000015 , secteur :\00000007  , face 0
*  jusqu'a la piste :\00000030 , secteur :\00000010 , face 0
 dc 0153,0015,0007,0

* fh.dat Taille :$0000AF34 \00044852 octets.
*  a partir de la piste :\00000030 , secteur :\00000010  , face 0
*  jusqu'a la piste :\00000039 , secteur :\00000008 , face 0
 dc 0088,0030,0010,0

* foxx.dat Taille :$00004B88 \00019336 octets.
*  a partir de la piste :\00000039 , secteur :\00000008  , face 0
*  jusqu'a la piste :\00000043 , secteur :\00000006 , face 0
 dc 0038,0039,0008,0

* fullball.dat Taille :$00014544 \00083268 octets.
*  a partir de la piste :\00000043 , secteur :\00000006  , face 0
*  jusqu'a la piste :\00000059 , secteur :\00000009 , face 0
 dc 0163,0043,0006,0

* krom.dat Taille :$00021E54 \00138836 octets.
*  a partir de la piste :\00000059 , secteur :\00000009  , face 0
*  jusqu'a la piste :\00000005 , secteur :\00000001 , face 1
 dc 0272,0059,0009,0

* lem.dat Taille :$000344B6 \00214198 octets.
*  a partir de la piste :\00000005 , secteur :\00000001  , face 1
*  jusqu'a la piste :\00000046 , secteur :\00000010 , face 1
 dc 0419,0005,0001,1

* nf.dat Taille :$00006FA6 \00028582 octets.
*  a partir de la piste :\00000046 , secteur :\00000010  , face 1
*  jusqu'a la piste :\00000052 , secteur :\00000006 , face 1
 dc 0056,0046,0010,1

* tnc1.dat Taille :$00018458 \00099416 octets.
*  a partir de la piste :\00000052 , secteur :\00000006  , face 1
*  jusqu'a la piste :\00000072 , secteur :\00000001 , face 1
 dc 0195,0052,0006,1
