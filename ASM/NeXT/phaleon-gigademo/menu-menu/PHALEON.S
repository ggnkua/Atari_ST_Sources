 dc.b "                -NEXT-, IN IT'S COURTESY OF QUEST "
 dc.b "FOR PERFECTION PROUDLY WELCOMES YOU "
 dc.b "TO THE ULTIMATE BRAINBLASTING "
 dc.b "EXPERIENCE          THE PHALEON DEMO "                     
 dc.b "             "
 dc.b " 2 YEARS, 4 DISKS, 17 DIES, A QUANTITY " 
 dc.b "OF COKE EQUAL TO SWITZERLAND'S PRODUCTION, " 
 dc.b "SOME COMPUTERS (AND LAMERS) SACRIFIED...  "    
 dc.b "BUT HERE IT IS THE ONE YOU WERE ALL WAITING " 
 dc.b "FOR (TO SAY THE TRUTH : THE ONE THAT EVEN "  
 dc.b "OURSELVES WERE WAITING FOR...) THE ULTIMATE "
 dc.b "GIGA-DEMO, THE ANSWER TO CENTURIES OF HUMAN "
 dc.b "QUEST FOR PERFECTION, THE...       O.K.    O.K. "   
 dc.b "IT'S PROBABLY A BIT TOO MUCH BUT YOU " 
 dc.b "MUST ADMIT IT WORTHS IT !     NO ONE CAN IMAGINE "
 dc.b "HOW MUCH WORK THIS DEMO MEANS....      WELL, "
 dc.b "NOT THAT -I- PERSONALLY WORKED A LOT ON IT BUT "
 dc.b "BET THE CODERS DID !       TO GET THIS DEMO FINISHED "
 dc.b "THEY'VE ABANDONNED EVERYTHING : BEER-GIRLS-BEACH, "
 dc.b " ALL THESE THINGS THAT MAKES LIFE'S NOT A BITCH "        
 dc.b "  SOME OF YOU (MAINLY THE LAMERS) MUST BE WONDERING " 
 dc.b "-WHY ?-      WELL               THAT'S -THE- QUESTION "       
 dc.b "       NO DOUBT THAT WE'LL FIND AN ANSWER TO IT "
 dc.b "   QUITE SOON...   WELL, HOPE SO....       PHALEON WAS "
 dc.b "MEANT TO BE THE BIGGEST DEMO EVER REALEASED AND I "
 dc.b "THINK THAT IT'S, SO FAR, ONE OF THE "
 dc.b "MOST ORIGINAL       ALL OF US SINCERLY HOPE YOU'LL "
 dc.b "ENJOY IT AND I BET YOU WILL !  "        


 dc.b "BY THE WAY, I WANT TO INFORM YOU THAT WE HAVE "
 dc.b "CREATED A FUNDATION AND THAT ALL DONATIONS ARE"
 dc.b " WELCOME : SEND YOUR OLD CLOTHES, TOYS, POWDER"
 dc.b " MILK, CHOCOLATE OR CIGARETTES AND YOU'LL SAVE"
 dc.b " FIVE HUMAN LIFES FROM FAMINE AND DYSENTERY"
 dc.b "       SEND ALL DONATIONS TO :             "
 dc.b "THE -NEXT- FUNDATION FOR -NEXT- MEMBERS"
 dc.b "        6 RUE GEORGE SAND          "
 dc.b "  49100  ANGERS  - FRANCE   "
 DC.B "            I REPEAT            "
 dc.b "THE -NEXT- FUNDATION FOR -NEXT- MEMBERS"
 dc.b "        6 RUE GEORGE SAND          "
 dc.b "  49100  ANGERS  - FRANCE                 "


 DC.B " (EH ZAO ! J'AI "
 dc.b "MALHEUREUSEMENT OUBLIE L'ADRESSE DE MARSEILLE MAIS "
 dc.b " C'EST PAS GRAVE ON T'ENVERRA LE LAIT EN"
 dc.b " POUDRE)                                 "
 dc.b " AFTER THIS HUMANITARIAN INTERLUDE LET'S DEAL WITH"
 dc.b " SOME USUAL TECHNICAL INFORMATIONS CONCERNING"
 dc.b " PHALEON               THE DEMO INCLUDES"
 dc.b " 34 SCREENS TO BE LOADED FROM 4 DIFFERENT MENUS"
 dc.b " TO BE LOADED FROM 1 BIG MAIN MENU TO BE LOADED "
 dc.b "FROM THE FIRST DISK TO BE PUTED IN YOUR COMPUTER"
 dc.b "...         PHALEON ALSO SUPPORTS DISK CHANGES,"
 dc.b " EXTRA MEMORY, EXTERNAL DRIVE AND INCLUDES A STE"
 dc.b " DETECTION    LAST BUT NOT LEAST WE MANAGED TO "
 dc.b "CREATE A VIRUS THAT WILL INFECT YOUR HARD DISK"
 dc.b " EVEN IF THIS ONE IS SWITCHED OFF (IT'S GONNA"
 dc.b " BE A HARD TIME FOR BRAINLESS LAMERS...) TO GET "
 dc.b "THE ANTIDOTE TO THIS VIRUS (IF YOU READ THIS IT MEANS "
 dc.b "THAT YOUR HARD DISK IS ALREADY INFECTED) THEN SEND"
 dc.b " 50 FRANCS TO THE -NEXT- FUNDATION FOR -NEXT- MEMBERS"
 dc.b " MENTIONNED ABOVE          THE VIRUS CAN'T BE DETECTED"
 dc.b " AND MAY DESTROY YOUR DATAS AT ANY TIME : SO HURRY UP !"
 dc.b "       BY THE WAY, WE'RE NOW WORKING ON A VIRUS THAT "
 dc.b "WOULD DESTROY YOUR COMPUTER EVEN IF YOU DON'T PUT THE DISK"
 dc.b " INTO THE DRIVE AND THIS VIRUS WILL ALSO BE ABLE TO OPEN"
 dc.b " THE DOOR WHEN SOMEONE RINGS, WASH DISHES AND TAKE OUT "
 dc.b "FOR A WALK YOUR DOG.....                           "
 dc.b " DON'T SMILE : I BET HUNDREDS OF LAMERS ARE ACTUALLY "
 dc.b "QUITE WORRIED....                                 "    
 dc.b "                           AT LAST, A GIGA "
 dc.b "GREETING TO ALL THE PEOPLE THAT MADE OF COMPUTER SUCH "
 dc.b "A FUN :  HACKERS, CODERS, SWAPPERS, GFX MEN, MUSICIANS.... "
 dc.b "SUCH NAMES AS   B.O.S.S.      THE BLADE RUNNERS     "
 dc.b " TEX         STCS         THE REPLICANTS     TCB......"
 dc.b "THINK ABOUT ALL THE GREAT TIME WE HAD, OF ALL THE THINGS "
 dc.b "WE LEARNED, ALL THE PEOPLE WE MET TRY TO WONDER WHAT "
 dc.b "WOULD HAVE BEEN OUR LIFE WITHOUT THIS "
 dc.b "SMALL PLASTIC STUFF CALLED COMPUTER AND THOSE "
 dc.b "PEOPLE WHO MADE OF IT PROBABLY THE COOLEST PERIOD OF OUR LIFE "                              