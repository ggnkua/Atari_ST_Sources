*-------------------------------------------
* liste des screens installes sur le disk 2
*  dc x,p,s,f

*  x nombre de secteurs ke prend le fichier sur disk
*  p piste de depart
*  s secteur de depart (non compris)
*  f face de depart 


* exp.dat Taille :$000071B4 \00029108 octets.
*  a partir de la piste :\00000057 , secteur :\00000004  , face 0
*  jusqu'a la piste :\00000063 , secteur :\00000001 , face 0
 dc 0057,0057,0004,0

* budnext.dat Taille :$0002DF96 \00188310 octets.
*  a partir de la piste :\00000063 , secteur :\00000001  , face 0
*  jusqu'a la piste :\00000017 , secteur :\00000009 , face 1
 dc 0368,0063,0001,0

* mine.dat Taille :$0001135E \00070494 octets.
*  a partir de la piste :\00000017 , secteur :\00000009  , face 1
*  jusqu'a la piste :\00000031 , secteur :\00000007 , face 1
 dc 0138,0017,0009,1

* tnc2.dat Taille :$0000920A \00037386 octets.
*  a partir de la piste :\00000031 , secteur :\00000007  , face 1
*  jusqu'a la piste :\00000039 , secteur :\00000001 , face 1
 dc 0074,0031,0007,1

* illusion.dat Taille :$00028522 \00165154 octets.
*  a partir de la piste :\00000039 , secteur :\00000001  , face 1
*  jusqu'a la piste :\00000071 , secteur :\00000004 , face 1
 dc 0323,0039,0001,1
