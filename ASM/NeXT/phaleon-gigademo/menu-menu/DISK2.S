*-------------------------------------------
* liste des screens installes sur le disk 2
*  dc x,p,s,f

*  x nombre de secteurs ke prend le fichier sur disk
*  p piste de depart
*  s secteur de depart (non compris)
*  f face de depart 


* acf.dat Taille :$0001CAA2 \00051874 octets.
*  a partir de la piste :\00000001 , secteur :\00000001  , face 0
*  jusqu'a la piste :\00000024 , secteur :\00000001 , face 0
 dc 0230,0001,0001,0

* aggress.dat Taille :$00012CC2 \00011458 octets.
*  a partir de la piste :\00000024 , secteur :\00000001  , face 0
*  jusqu'a la piste :\00000039 , secteur :\00000002 , face 0
 dc 0151,0024,0001,0

* chaotic1.dat Taille :$0000B128 \00045352 octets.
*  a partir de la piste :\00000039 , secteur :\00000002  , face 0
*  jusqu'a la piste :\00000048 , secteur :\00000001 , face 0
 dc 0089,0039,0002,0

* chaotic2.dat Taille :$00004A96 \00019094 octets.
*  a partir de la piste :\00000048 , secteur :\00000001  , face 0
*  jusqu'a la piste :\00000051 , secteur :\00000009 , face 0
 dc 0038,0048,0001,0

* deltafor.dat Taille :$00007E76 \00032374 octets.
*  a partir de la piste :\00000051 , secteur :\00000009  , face 0
*  jusqu'a la piste :\00000058 , secteur :\00000003 , face 0
 dc 0064,0051,0009,0

* fm.dat Taille :$00013E0E \00015886 octets.
*  a partir de la piste :\00000058 , secteur :\00000003  , face 0
*  jusqu'a la piste :\00000074 , secteur :\00000003 , face 0
 dc 0160,0058,0003,0

* fraggles.dat Taille :$0000E3AA \00058282 octets.
*  a partir de la piste :\00000074 , secteur :\00000003  , face 0
*  jusqu'a la piste :\00000003 , secteur :\00000007 , face 1
 dc 0114,0074,0003,0

* hmd.dat Taille :$00008D32 \00036146 octets.
*  a partir de la piste :\00000003 , secteur :\00000007  , face 1
*  jusqu'a la piste :\00000010 , secteur :\00000008 , face 1
 dc 0071,0003,0007,1

* legacy.dat Taille :$00008444 \00033860 octets.
*  a partir de la piste :\00000010 , secteur :\00000008  , face 1
*  jusqu'a la piste :\00000017 , secteur :\00000005 , face 1
 dc 0067,0010,0008,1

* megabust.dat Taille :$00004CB8 \00019640 octets.
*  a partir de la piste :\00000017 , secteur :\00000005  , face 1
*  jusqu'a la piste :\00000021 , secteur :\00000004 , face 1
 dc 0039,0017,0005,1

* mjjprod.dat Taille :$0000759C \00030108 octets.
*  a partir de la piste :\00000021 , secteur :\00000004  , face 1
*  jusqu'a la piste :\00000027 , secteur :\00000003 , face 1
 dc 0059,0021,0004,1

* mystic.dat Taille :$0001A4FE \00042238 octets.
*  a partir de la piste :\00000027 , secteur :\00000003  , face 1
*  jusqu'a la piste :\00000048 , secteur :\00000004 , face 1
 dc 0211,0027,0003,1

* naos.dat Taille :$00006B84 \00027524 octets.
*  a partir de la piste :\00000048 , secteur :\00000004  , face 1
*  jusqu'a la piste :\00000053 , secteur :\00000008 , face 1
 dc 0054,0048,0004,1

* newline.dat Taille :$00004E62 \00020066 octets.
*  a partir de la piste :\00000053 , secteur :\00000008  , face 1
*  jusqu'a la piste :\00000057 , secteur :\00000008 , face 1
 dc 0040,0053,0008,1

* nsm.dat Taille :$000055F4 \00022004 octets.
*  a partir de la piste :\00000057 , secteur :\00000008  , face 1
*  jusqu'a la piste :\00000062 , secteur :\00000001 , face 1
 dc 0043,0057,0008,1

* tcb.dat Taille :$00002314 \00008980 octets.
*  a partir de la piste :\00000062 , secteur :\00000001  , face 1
*  jusqu'a la piste :\00000063 , secteur :\00000009 , face 1
 dc 0018,0062,0001,1

* tcr.dat Taille :$00007BAA \00031658 octets.
*  a partir de la piste :\00000063 , secteur :\00000009  , face 1
*  jusqu'a la piste :\00000070 , secteur :\00000001 , face 1
 dc 0062,0063,0009,1
