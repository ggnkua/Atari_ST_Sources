*-------------------------------------------
* liste des screens installes sur le disk 2
*  dc x,p,s,f

*  x nombre de secteurs ke prend le fichier sur disk
*  p piste de depart
*  s secteur de depart (non compris)
*  f face de depart 


* dungeon.dat Taille :$000035C0 \00013760 octets.
*  a partir de la piste :\00000003 , secteur :\00000001  , face 0
*  jusqu'a la piste :\00000005 , secteur :\00000008 , face 0
 dc 0027,0003,0001,0
