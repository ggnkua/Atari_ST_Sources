;Palette of ARR_PLAN.IFF: Saved by NEOchrome V2.25 by Chaos, Inc.
		dc.w	$0000,$0001,$0112,$0002,$0003,$0004,$0111,$0222
		dc.w	$0333,$0555,$0310,$0421,$0543,$0654,$0665,$0776
