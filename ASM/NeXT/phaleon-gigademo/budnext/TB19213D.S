n0
* C3 
 dc.w 0,1,1,2,2,3,3,4,4,4,5,5,6,6,7,7,8,8,9,9,9,10,10,11,11,12,12,13,13,13
 dc.w 14,14,15,15,16,16,17,17,17,18,18,19,19,20,20,21,21,22,22,22,23,23,24,24,25,25,26,26,26,27
 dc.w 27,28,28,29,29,30,30,30,31,31,32,32,33,33,34,34,35,35,35,36,36,37,37,38,38,39,39,39,40,40
 dc.w 41,41,42,42,43,43,44,44,44,45,45,46,46,47,47,48,48,48,49,49,50,50,51,51,52,52,52,53,53,54
 dc.w 54,55,55,56,56,57,57,57,58,58,59,59,60,60,61,61,61,62,62,63,63,64,64,65,65,65,66,66,67,67
 dc.w 68,68,69,69,70,70,70,71,71,72,72,73,73,74,74,74,75,75,76,76,77,77,78,78,78,79,79,80,80,81
 dc.w 81,82,82,83,83,83,84,84,85,85,86,86


n1
* C#3
 dc.w 0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8,9,9,10,10,10,11,11,12,12,13,13,14,14
 dc.w 15,15,16,16,17,17,18,18,19,19,19,20,20,21,21,22,22,23,23,24,24,25,25,26,26,27,27,28,28,29
 dc.w 29,29,30,30,31,31,32,32,33,33,34,34,35,35,36,36,37,37,38,38,38,39,39,40,40,41,41,42,42,43
 dc.w 43,44,44,45,45,46,46,47,47,48,48,48,49,49,50,50,51,51,52,52,53,53,54,54,55,55,56,56,57,57
 dc.w 57,58,58,59,59,60,60,61,61,62,62,63,63,64,64,65,65,66,66,67,67,67,68,68,69,69,70,70,71,71
 dc.w 72,72,73,73,74,74,75,75,76,76,76,77,77,78,78,79,79,80,80,81,81,82,82,83,83,84,84,85,85,86
 dc.w 86,86,87,87,88,88,89,89,90,90,91,91


n2
* D3 
 dc.w 1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8,9,9,10,10,11,11,12,12,13,13,14,14,15,15
 dc.w 16,16,17,17,18,18,19,19,20,20,21,21,22,22,23,23,24,24,25,25,26,26,27,27,28,28,29,29,30,30
 dc.w 31,31,32,32,33,33,34,34,35,35,36,36,37,37,38,38,39,39,40,40,41,41,42,42,43,43,44,44,45,45
 dc.w 46,46,47,47,48,48,49,49,50,50,51,51,52,52,53,53,54,54,55,55,56,56,57,57,58,58,59,59,60,60
 dc.w 61,61,62,62,63,63,64,64,65,65,66,66,67,67,68,68,69,69,70,70,71,71,72,72,73,73,74,75,75,76
 dc.w 76,77,77,78,78,79,79,80,80,81,81,82,82,83,83,84,84,85,85,86,86,87,87,88,88,89,89,90,90,91
 dc.w 91,92,92,93,93,94,94,95,95,96,96,97


n3
* D#3
 dc.w 1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,9,9,10,10,11,11,12,12,13,13,14,14,15,15,16
 dc.w 17,17,18,18,19,19,20,20,21,21,22,22,23,23,24,25,25,26,26,27,27,28,28,29,29,30,30,31,31,32
 dc.w 33,33,34,34,35,35,36,36,37,37,38,38,39,39,40,41,41,42,42,43,43,44,44,45,45,46,46,47,47,48
 dc.w 49,49,50,50,51,51,52,52,53,53,54,54,55,55,56,57,57,58,58,59,59,60,60,61,61,62,62,63,63,64
 dc.w 65,65,66,66,67,67,68,68,69,69,70,70,71,71,72,73,73,74,74,75,75,76,76,77,77,78,78,79,79,80
 dc.w 81,81,82,82,83,83,84,84,85,85,86,86,87,87,88,89,89,90,90,91,91,92,92,93,93,94,94,95,95,96
 dc.w 97,97,98,98,99,99,100,100,101,101,102,102


n4
* E3 
 dc.w 1,1,2,2,3,3,4,5,5,6,6,7,7,8,8,9,10,10,11,11,12,12,13,14,14,15,15,16,16,17
 dc.w 18,18,19,19,20,20,21,21,22,23,23,24,24,25,25,26,27,27,28,28,29,29,30,31,31,32,32,33,33,34
 dc.w 34,35,36,36,37,37,38,38,39,40,40,41,41,42,42,43,44,44,45,45,46,46,47,47,48,49,49,50,50,51
 dc.w 51,52,53,53,54,54,55,55,56,57,57,58,58,59,59,60,60,61,62,62,63,63,64,64,65,66,66,67,67,68
 dc.w 68,69,70,70,71,71,72,72,73,73,74,75,75,76,76,77,77,78,79,79,80,80,81,81,82,82,83,84,84,85
 dc.w 85,86,86,87,88,88,89,89,90,90,91,92,92,93,93,94,94,95,95,96,97,97,98,98,99,99,100,101,101,102
 dc.w 102,103,103,104,105,105,106,106,107,107,108,108


n5
* F3 
 dc.w 1,1,2,2,3,4,4,5,5,6,7,7,8,8,9,10,10,11,11,12,13,13,14,14,15,16,16,17,17,18
 dc.w 19,19,20,20,21,22,22,23,23,24,25,25,26,26,27,28,28,29,29,30,31,31,32,32,33,34,34,35,35,36
 dc.w 37,37,38,38,39,40,40,41,41,42,43,43,44,44,45,45,46,47,47,48,48,49,50,50,51,51,52,53,53,54
 dc.w 54,55,56,56,57,57,58,59,59,60,60,61,62,62,63,63,64,65,65,66,66,67,68,68,69,69,70,71,71,72
 dc.w 72,73,74,74,75,75,76,77,77,78,78,79,80,80,81,81,82,83,83,84,84,85,86,86,87,87,88,89,89,90
 dc.w 90,91,92,92,93,93,94,95,95,96,96,97,98,98,99,99,100,101,101,102,102,103,104,104,105,105,106,107,107,108
 dc.w 108,109,110,110,111,111,112,113,113,114,114,115


n6
* F#3
 dc.w 1,1,2,3,3,4,4,5,6,6,7,8,8,9,10,10,11,11,12,13,13,14,15,15,16,16,17,18,18,19
 dc.w 20,20,21,22,22,23,23,24,25,25,26,27,27,28,29,29,30,30,31,32,32,33,34,34,35,36,36,37,37,38
 dc.w 39,39,40,41,41,42,42,43,44,44,45,46,46,47,48,48,49,49,50,51,51,52,53,53,54,55,55,56,56,57
 dc.w 58,58,59,60,60,61,62,62,63,63,64,65,65,66,67,67,68,68,69,70,70,71,72,72,73,74,74,75,75,76
 dc.w 77,77,78,79,79,80,81,81,82,82,83,84,84,85,86,86,87,88,88,89,89,90,91,91,92,93,93,94,95,95
 dc.w 96,96,97,98,98,99,100,100,101,101,102,103,103,104,105,105,106,107,107,108,108,109,110,110,111,112,112,113,114,114
 dc.w 115,115,116,117,117,118,119,119,120,121,121,122


n7
* G3 
 dc.w 1,1,2,3,3,4,5,5,6,7,7,8,9,9,10,11,11,12,13,13,14,15,15,16,17,17,18,19,19,20
 dc.w 21,22,22,23,24,24,25,26,26,27,28,28,29,30,30,31,32,32,33,34,34,35,36,36,37,38,38,39,40,40
 dc.w 41,42,42,43,44,44,45,46,46,47,48,48,49,50,50,51,52,52,53,54,54,55,56,56,57,58,58,59,60,60
 dc.w 61,62,62,63,64,65,65,66,67,67,68,69,69,70,71,71,72,73,73,74,75,75,76,77,77,78,79,79,80,81
 dc.w 81,82,83,83,84,85,85,86,87,87,88,89,89,90,91,91,92,93,93,94,95,95,96,97,97,98,99,99,100,101
 dc.w 101,102,103,103,104,105,105,106,107,108,108,109,110,110,111,112,112,113,114,114,115,116,116,117,118,118,119,120,120,121
 dc.w 122,122,123,124,124,125,126,126,127,128,128,129


n8
* G#3
 dc.w 1,1,2,3,4,4,5,6,6,7,8,9,9,10,11,11,12,13,14,14,15,16,16,17,18,19,19,20,21,21
 dc.w 22,23,23,24,25,26,26,27,28,28,29,30,31,31,32,33,33,34,35,36,36,37,38,38,39,40,41,41,42,43
 dc.w 43,44,45,46,46,47,48,48,49,50,51,51,52,53,53,54,55,56,56,57,58,58,59,60,61,61,62,63,63,64
 dc.w 65,65,66,67,68,68,69,70,70,71,72,73,73,74,75,75,76,77,78,78,79,80,80,81,82,83,83,84,85,85
 dc.w 86,87,88,88,89,90,90,91,92,93,93,94,95,95,96,97,98,98,99,100,100,101,102,103,103,104,105,105,106,107
 dc.w 107,108,109,110,110,111,112,112,113,114,115,115,116,117,117,118,119,120,120,121,122,122,123,124,125,125,126,127,127,128
 dc.w 129,130,130,131,132,132,133,134,135,135,136,137


n9
* A3 
 dc.w 1,2,2,3,4,5,5,6,7,8,8,9,10,11,11,12,13,14,14,15,16,17,17,18,19,20,20,21,22,23
 dc.w 23,24,25,26,26,27,28,29,29,30,31,32,32,33,34,35,35,36,37,38,38,39,40,41,41,42,43,44,45,45
 dc.w 46,47,48,48,49,50,51,51,52,53,54,54,55,56,57,57,58,59,60,60,61,62,63,63,64,65,66,66,67,68
 dc.w 69,69,70,71,72,72,73,74,75,75,76,77,78,78,79,80,81,81,82,83,84,84,85,86,87,87,88,89,90,91
 dc.w 91,92,93,94,94,95,96,97,97,98,99,100,100,101,102,103,103,104,105,106,106,107,108,109,109,110,111,112,112,113
 dc.w 114,115,115,116,117,118,118,119,120,121,121,122,123,124,124,125,126,127,127,128,129,130,130,131,132,133,134,134,135,136
 dc.w 137,137,138,139,140,140,141,142,143,143,144,145


n10
* A#3
 dc.w 1,2,2,3,4,5,6,6,7,8,9,10,10,11,12,13,14,14,15,16,17,18,18,19,20,21,22,22,23,24
 dc.w 25,26,26,27,28,29,30,30,31,32,33,34,34,35,36,37,38,38,39,40,41,42,42,43,44,45,46,46,47,48
 dc.w 49,50,50,51,52,53,54,54,55,56,57,58,58,59,60,61,62,62,63,64,65,66,66,67,68,69,70,70,71,72
 dc.w 73,74,74,75,76,77,78,78,79,80,81,82,82,83,84,85,86,86,87,88,89,89,90,91,92,93,93,94,95,96
 dc.w 97,97,98,99,100,101,101,102,103,104,105,105,106,107,108,109,109,110,111,112,113,113,114,115,116,117,117,118,119,120
 dc.w 121,121,122,123,124,125,125,126,127,128,129,129,130,131,132,133,133,134,135,136,137,137,138,139,140,141,141,142,143,144
 dc.w 145,145,146,147,148,149,149,150,151,152,153,153


n11
* B3 
 dc.w 1,2,3,3,4,5,6,7,8,8,9,10,11,12,13,14,14,15,16,17,18,19,19,20,21,22,23,24,25,25
 dc.w 26,27,28,29,30,30,31,32,33,34,35,36,36,37,38,39,40,41,41,42,43,44,45,46,47,47,48,49,50,51
 dc.w 52,52,53,54,55,56,57,58,58,59,60,61,62,63,63,64,65,66,67,68,69,69,70,71,72,73,74,75,75,76
 dc.w 77,78,79,80,80,81,82,83,84,85,86,86,87,88,89,90,91,91,92,93,94,95,96,97,97,98,99,100,101,102
 dc.w 102,103,104,105,106,107,108,108,109,110,111,112,113,113,114,115,116,117,118,119,119,120,121,122,123,124,124,125,126,127
 dc.w 128,129,130,130,131,132,133,134,135,135,136,137,138,139,140,141,141,142,143,144,145,146,146,147,148,149,150,151,152,152
 dc.w 153,154,155,156,157,157,158,159,160,161,162,163


n12
* C4 
 dc.w 1,2,3,4,4,5,6,7,8,9,10,11,12,13,13,14,15,16,17,18,19,20,21,22,22,23,24,25,26,27
 dc.w 28,29,30,30,31,32,33,34,35,36,37,38,39,39,40,41,42,43,44,45,46,47,48,48,49,50,51,52,53,54
 dc.w 55,56,57,57,58,59,60,61,62,63,64,65,65,66,67,68,69,70,71,72,73,74,74,75,76,77,78,79,80,81
 dc.w 82,83,83,84,85,86,87,88,89,90,91,91,92,93,94,95,96,97,98,99,100,100,101,102,103,104,105,106,107,108
 dc.w 109,109,110,111,112,113,114,115,116,117,118,118,119,120,121,122,123,124,125,126,126,127,128,129,130,131,132,133,134,135
 dc.w 135,136,137,138,139,140,141,142,143,144,144,145,146,147,148,149,150,151,152,152,153,154,155,156,157,158,159,160,161,161
 dc.w 162,163,164,165,166,167,168,169,170,170,171,172


n13
* C#4
 dc.w 1,2,3,4,5,6,7,8,9,10,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29
 dc.w 29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,48,49,50,51,52,53,54,55,56,57
 dc.w 58,59,60,61,62,63,64,65,66,67,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86
 dc.w 86,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,105,106,107,108,109,110,111,112,113,114
 dc.w 115,116,117,118,119,120,121,122,123,124,124,125,126,127,128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143
 dc.w 143,144,145,146,147,148,149,150,151,152,153,154,155,156,157,158,159,160,161,162,162,163,164,165,166,167,168,169,170,171
 dc.w 172,173,174,175,176,177,178,179,180,181,182,182


n14
* D4 
 dc.w 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30
 dc.w 31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60
 dc.w 61,62,63,64,65,66,67,68,69,70,71,72,73,75,76,77,78,79,80,81,82,83,84,85,86,87,88,89,90,91
 dc.w 92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117,118,119,120,121
 dc.w 122,123,124,125,126,127,128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144,145,146,147,148,149,150,151
 dc.w 152,153,154,155,156,157,158,159,160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,176,177,178,179,180,181
 dc.w 182,183,184,185,186,187,188,189,190,191,192,193


n15
* D#4
 dc.w 1,2,3,4,5,6,7,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,25,26,27,28,29,30,31,32
 dc.w 33,34,35,36,37,38,39,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,57,58,59,60,61,62,63,64
 dc.w 65,66,67,68,69,70,71,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,89,90,91,92,93,94,95,96
 dc.w 97,98,99,100,101,102,103,105,106,107,108,109,110,111,112,113,114,115,116,117,118,119,121,122,123,124,125,126,127,128
 dc.w 129,130,131,132,133,134,135,137,138,139,140,141,142,143,144,145,146,147,148,149,150,151,153,154,155,156,157,158,159,160
 dc.w 161,162,163,164,165,166,167,169,170,171,172,173,174,175,176,177,178,179,180,181,182,183,185,186,187,188,189,190,191,192
 dc.w 193,194,195,196,197,198,199,201,202,203,204,205


n16
* E4 
 dc.w 1,2,3,5,6,7,8,9,10,11,12,14,15,16,17,18,19,20,21,23,24,25,26,27,28,29,31,32,33,34
 dc.w 35,36,37,38,40,41,42,43,44,45,46,47,49,50,51,52,53,54,55,57,58,59,60,61,62,63,64,66,67,68
 dc.w 69,70,71,72,73,75,76,77,78,79,80,81,82,84,85,86,87,88,89,90,92,93,94,95,96,97,98,99,101,102
 dc.w 103,104,105,106,107,108,110,111,112,113,114,115,116,118,119,120,121,122,123,124,125,127,128,129,130,131,132,133,134,136
 dc.w 137,138,139,140,141,142,144,145,146,147,148,149,150,151,153,154,155,156,157,158,159,160,162,163,164,165,166,167,168,170
 dc.w 171,172,173,174,175,176,177,179,180,181,182,183,184,185,186,188,189,190,191,192,193,194,196,197,198,199,200,201,202,203
 dc.w 205,206,207,208,209,210,211,212,214,215,216,217


n17
* F4 
 dc.w 1,2,4,5,6,7,8,10,11,12,13,14,16,17,18,19,20,22,23,24,25,26,28,29,30,31,32,34,35,36
 dc.w 37,38,40,41,42,43,44,45,47,48,49,50,51,53,54,55,56,57,59,60,61,62,63,65,66,67,68,69,71,72
 dc.w 73,74,75,77,78,79,80,81,83,84,85,86,87,89,90,91,92,93,95,96,97,98,99,101,102,103,104,105,107,108
 dc.w 109,110,111,113,114,115,116,117,119,120,121,122,123,125,126,127,128,129,131,132,133,134,135,136,138,139,140,141,142,144
 dc.w 145,146,147,148,150,151,152,153,154,156,157,158,159,160,162,163,164,165,166,168,169,170,171,172,174,175,176,177,178,180
 dc.w 181,182,183,184,186,187,188,189,190,192,193,194,195,196,198,199,200,201,202,204,205,206,207,208,210,211,212,213,214,216
 dc.w 217,218,219,220,221,223,224,225,226,227,229,230


n18
* F#4
 dc.w 1,3,4,5,6,8,9,10,11,13,14,15,16,18,19,20,22,23,24,25,27,28,29,30,32,33,34,36,37,38
 dc.w 39,41,42,43,44,46,47,48,49,51,52,53,55,56,57,58,60,61,62,63,65,66,67,68,70,71,72,74,75,76
 dc.w 77,79,80,81,82,84,85,86,88,89,90,91,93,94,95,96,98,99,100,101,103,104,105,107,108,109,110,112,113,114
 dc.w 115,117,118,119,121,122,123,124,126,127,128,129,131,132,133,134,136,137,138,140,141,142,143,145,146,147,148,150,151,152
 dc.w 153,155,156,157,159,160,161,162,164,165,166,167,169,170,171,173,174,175,176,178,179,180,181,183,184,185,186,188,189,190
 dc.w 192,193,194,195,197,198,199,200,202,203,204,205,207,208,209,211,212,213,214,216,217,218,219,221,222,223,225,226,227,228
 dc.w 230,231,232,233,235,236,237,238,240,241,242,244


n19
* G4 
 dc.w 1,3,4,5,7,8,9,11,12,13,15,16,17,19,20,22,23,24,26,27,28,30,31,32,34,35,36,38,39,40
 dc.w 42,43,44,46,47,48,50,51,52,54,55,56,58,59,60,62,63,65,66,67,69,70,71,73,74,75,77,78,79,81
 dc.w 82,83,85,86,87,89,90,91,93,94,95,97,98,99,101,102,103,105,106,108,109,110,112,113,114,116,117,118,120,121
 dc.w 122,124,125,126,128,129,130,132,133,134,136,137,138,140,141,142,144,145,146,148,149,151,152,153,155,156,157,159,160,161
 dc.w 163,164,165,167,168,169,171,172,173,175,176,177,179,180,181,183,184,185,187,188,189,191,192,194,195,196,198,199,200,202
 dc.w 203,204,206,207,208,210,211,212,214,215,216,218,219,220,222,223,224,226,227,228,230,231,232,234,235,237,238,239,241,242
 dc.w 243,245,246,247,249,250,251,253,254,255,257,258


n20
* G#4
 dc.w 1,3,4,6,7,9,10,11,13,14,16,17,19,20,21,23,24,26,27,28,30,31,33,34,36,37,38,40,41,43
 dc.w 44,46,47,48,50,51,53,54,56,57,58,60,61,63,64,65,67,68,70,71,73,74,75,77,78,80,81,83,84,85
 dc.w 87,88,90,91,93,94,95,97,98,100,101,103,104,105,107,108,110,111,112,114,115,117,118,120,121,122,124,125,127,128
 dc.w 130,131,132,134,135,137,138,140,141,142,144,145,147,148,150,151,152,154,155,157,158,159,161,162,164,165,167,168,169,171
 dc.w 172,174,175,177,178,179,181,182,184,185,187,188,189,191,192,194,195,196,198,199,201,202,204,205,206,208,209,211,212,214
 dc.w 215,216,218,219,221,222,224,225,226,228,229,231,232,234,235,236,238,239,241,242,243,245,246,248,249,251,252,253,255,256
 dc.w 258,259,261,262,263,265,266,268,269,271,272,273


n21
* A4 
 dc.w 2,3,5,6,8,9,11,12,14,15,17,18,20,21,23,24,26,27,29,30,32,33,35,36,38,39,41,42,44,45
 dc.w 47,48,50,51,53,54,56,57,59,60,62,63,65,66,68,69,71,72,74,75,77,78,80,81,83,84,86,87,89,91
 dc.w 92,94,95,97,98,100,101,103,104,106,107,109,110,112,113,115,116,118,119,121,122,124,125,127,128,130,131,133,134,136
 dc.w 137,139,140,142,143,145,146,148,149,151,152,154,155,157,158,160,161,163,164,166,167,169,170,172,173,175,176,178,180,181
 dc.w 183,184,186,187,189,190,192,193,195,196,198,199,201,202,204,205,207,208,210,211,213,214,216,217,219,220,222,223,225,226
 dc.w 228,229,231,232,234,235,237,238,240,241,243,244,246,247,249,250,252,253,255,256,258,259,261,262,264,265,267,269,270,272
 dc.w 273,275,276,278,279,281,282,284,285,287,288,290


n22
* A#4
 dc.w 2,3,5,6,8,10,11,13,14,16,18,19,21,22,24,26,27,29,30,32,34,35,37,38,40,42,43,45,46,48
 dc.w 50,51,53,54,56,58,59,61,62,64,66,67,69,70,72,74,75,77,78,80,82,83,85,86,88,89,91,93,94,96
 dc.w 97,99,101,102,104,105,107,109,110,112,113,115,117,118,120,121,123,125,126,128,129,131,133,134,136,137,139,141,142,144
 dc.w 145,147,149,150,152,153,155,157,158,160,161,163,165,166,168,169,171,173,174,176,177,179,181,182,184,185,187,189,190,192
 dc.w 193,195,197,198,200,201,203,205,206,208,209,211,213,214,216,217,219,221,222,224,225,227,229,230,232,233,235,237,238,240
 dc.w 241,243,245,246,248,249,251,253,254,256,257,259,261,262,264,265,267,268,270,272,273,275,276,278,280,281,283,284,286,288
 dc.w 289,291,292,294,296,297,299,300,302,304,305,307


n23
* B4 
 dc.w 2,3,5,7,8,10,12,14,15,17,19,20,22,24,25,27,29,30,32,34,36,37,39,41,42,44,46,47,49,51
 dc.w 52,54,56,58,59,61,63,64,66,68,69,71,73,75,76,78,80,81,83,85,86,88,90,91,93,95,97,98,100,102
 dc.w 103,105,107,108,110,112,113,115,117,119,120,122,124,125,127,129,130,132,134,135,137,139,141,142,144,146,147,149,151,152
 dc.w 154,156,157,159,161,163,164,166,168,169,171,173,174,176,178,179,181,183,185,186,188,190,191,193,195,196,198,200,201,203
 dc.w 205,207,208,210,212,213,215,217,218,220,222,224,225,227,229,230,232,234,235,237,239,240,242,244,246,247,249,251,252,254
 dc.w 256,257,259,261,262,264,266,268,269,271,273,274,276,278,279,281,283,284,286,288,290,291,293,295,296,298,300,301,303,305
 dc.w 306,308,310,312,313,315,317,318,320,322,323,325


n24
* C5 
 dc.w 2,4,5,7,9,11,13,14,16,18,20,22,23,25,27,29,30,32,34,36,38,39,41,43,45,47,48,50,52,54
 dc.w 56,57,59,61,63,65,66,68,70,72,74,75,77,79,81,83,84,86,88,90,91,93,95,97,99,100,102,104,106,108
 dc.w 109,111,113,115,117,118,120,122,124,126,127,129,131,133,135,136,138,140,142,144,145,147,149,151,152,154,156,158,160,161
 dc.w 163,165,167,169,170,172,174,176,178,179,181,183,185,187,188,190,192,194,196,197,199,201,203,205,206,208,210,212,213,215
 dc.w 217,219,221,222,224,226,228,230,231,233,235,237,239,240,242,244,246,248,249,251,253,255,257,258,260,262,264,265,267,269
 dc.w 271,273,274,276,278,280,282,283,285,287,289,291,292,294,296,298,300,301,303,305,307,309,310,312,314,316,318,319,321,323
 dc.w 325,326,328,330,332,334,335,337,339,341,343,344


n25
* C#5
 dc.w 2,4,6,8,10,11,13,15,17,19,21,23,25,27,29,30,32,34,36,38,40,42,44,46,48,49,51,53,55,57
 dc.w 59,61,63,65,67,68,70,72,74,76,78,80,82,84,86,87,89,91,93,95,97,99,101,103,105,106,108,110,112,114
 dc.w 116,118,120,122,124,125,127,129,131,133,135,137,139,141,143,144,146,148,150,152,154,156,158,160,162,163,165,167,169,171
 dc.w 173,175,177,179,181,182,184,186,188,190,192,194,196,198,200,201,203,205,207,209,211,213,215,217,219,220,222,224,226,228
 dc.w 230,232,234,236,238,239,241,243,245,247,249,251,253,255,257,258,260,262,264,266,268,270,272,274,276,277,279,281,283,285
 dc.w 287,289,291,293,295,296,298,300,302,304,306,308,310,312,314,315,317,319,321,323,325,327,329,331,333,335,336,338,340,342
 dc.w 344,346,348,350,352,354,355,357,359,361,363,365


n26
* D5 
 dc.w 2,4,6,8,10,12,14,16,18,20,22,24,26,28,30,32,34,36,38,40,42,44,46,48,50,52,54,56,58,60
 dc.w 62,64,66,68,70,72,75,77,79,81,83,85,87,89,91,93,95,97,99,101,103,105,107,109,111,113,115,117,119,121
 dc.w 123,125,127,129,131,133,135,137,139,141,143,145,147,149,151,153,155,157,159,161,163,165,167,169,171,173,175,177,179,181
 dc.w 183,185,187,189,191,193,195,197,199,201,203,205,207,209,211,213,215,217,219,221,224,226,228,230,232,234,236,238,240,242
 dc.w 244,246,248,250,252,254,256,258,260,262,264,266,268,270,272,274,276,278,280,282,284,286,288,290,292,294,296,298,300,302
 dc.w 304,306,308,310,312,314,316,318,320,322,324,326,328,330,332,334,336,338,340,342,344,346,348,350,352,354,356,358,360,362
 dc.w 364,366,368,371,373,375,377,379,381,383,385,387


n27
* D#5
 dc.w 2,4,6,9,11,13,15,17,19,21,23,26,28,30,32,34,36,38,41,43,45,47,49,51,53,55,58,60,62,64
 dc.w 66,68,70,73,75,77,79,81,83,85,87,90,92,94,96,98,100,102,105,107,109,111,113,115,117,119,122,124,126,128
 dc.w 130,132,134,137,139,141,143,145,147,149,151,154,156,158,160,162,164,166,169,171,173,175,177,179,181,183,186,188,190,192
 dc.w 194,196,198,201,203,205,207,209,211,213,215,218,220,222,224,226,228,230,233,235,237,239,241,243,245,247,250,252,254,256
 dc.w 258,260,262,265,267,269,271,273,275,277,279,282,284,286,288,290,292,294,297,299,301,303,305,307,309,311,314,316,318,320
 dc.w 322,324,326,329,331,333,335,337,339,341,343,346,348,350,352,354,356,358,361,363,365,367,369,371,373,375,378,380,382,384
 dc.w 386,388,390,393,395,397,399,401,403,405,407,410


n28
* E5 
 dc.w 2,5,7,9,11,14,16,18,20,23,25,27,29,32,34,36,38,41,43,45,47,50,52,54,57,59,61,63,66,68
 dc.w 70,72,75,77,79,81,84,86,88,90,93,95,97,99,102,104,106,108,111,113,115,118,120,122,124,127,129,131,133,136
 dc.w 138,140,142,145,147,149,151,154,156,158,160,163,165,167,170,172,174,176,179,181,183,185,188,190,192,194,197,199,201,203
 dc.w 206,208,210,212,215,217,219,221,224,226,228,231,233,235,237,240,242,244,246,249,251,253,255,258,260,262,264,267,269,271
 dc.w 273,276,278,280,283,285,287,289,292,294,296,298,301,303,305,307,310,312,314,316,319,321,323,325,328,330,332,335,337,339
 dc.w 341,344,346,348,350,353,355,357,359,362,364,366,368,371,373,375,377,380,382,384,386,389,391,393,396,398,400,402,405,407
 dc.w 409,411,414,416,418,420,423,425,427,429,432,434


n29
* F5 
 dc.w 2,5,7,10,12,14,17,19,22,24,26,29,31,34,36,38,41,43,45,48,50,53,55,57,60,62,65,67,69,72
 dc.w 74,77,79,81,84,86,89,91,93,96,98,101,103,105,108,110,113,115,117,120,122,125,127,129,132,134,136,139,141,144
 dc.w 146,148,151,153,156,158,160,163,165,168,170,172,175,177,180,182,184,187,189,192,194,196,199,201,204,206,208,211,213,216
 dc.w 218,220,223,225,227,230,232,235,237,239,242,244,247,249,251,254,256,259,261,263,266,268,271,273,275,278,280,283,285,287
 dc.w 290,292,295,297,299,302,304,307,309,311,314,316,318,321,323,326,328,330,333,335,338,340,342,345,347,350,352,354,357,359
 dc.w 362,364,366,369,371,374,376,378,381,383,386,388,390,393,395,398,400,402,405,407,409,412,414,417,419,421,424,426,429,431
 dc.w 433,436,438,441,443,445,448,450,453,455,457,460


n30
* F#5
 dc.w 3,5,8,10,13,15,18,20,23,25,28,30,33,36,38,41,43,46,48,51,53,56,58,61,63,66,68,71,74,76
 dc.w 79,81,84,86,89,91,94,96,99,101,104,107,109,112,114,117,119,122,124,127,129,132,134,137,140,142,145,147,150,152
 dc.w 155,157,160,162,165,167,170,173,175,178,180,183,185,188,190,193,195,198,200,203,205,208,211,213,216,218,221,223,226,228
 dc.w 231,233,236,238,241,244,246,249,251,254,256,259,261,264,266,269,271,274,277,279,282,284,287,289,292,294,297,299,302,304
 dc.w 307,310,312,315,317,320,322,325,327,330,332,335,337,340,342,345,348,350,353,355,358,360,363,365,368,370,373,375,378,381
 dc.w 383,386,388,391,393,396,398,401,403,406,408,411,414,416,419,421,424,426,429,431,434,436,439,441,444,447,449,452,454,457
 dc.w 459,462,464,467,469,472,474,477,479,482,485,487


n31
* G5 
 dc.w 3,5,8,11,13,16,19,22,24,27,30,32,35,38,40,43,46,48,51,54,56,59,62,65,67,70,73,75,78,81
 dc.w 83,86,89,91,94,97,99,102,105,108,110,113,116,118,121,124,126,129,132,134,137,140,142,145,148,151,153,156,159,161
 dc.w 164,167,169,172,175,177,180,183,185,188,191,194,196,199,202,204,207,210,212,215,218,220,223,226,228,231,234,237,239,242
 dc.w 245,247,250,253,255,258,261,263,266,269,271,274,277,280,282,285,288,290,293,296,298,301,304,306,309,312,314,317,320,323
 dc.w 325,328,331,333,336,339,341,344,347,349,352,355,357,360,363,366,368,371,374,376,379,382,384,387,390,392,395,398,400,403
 dc.w 406,409,411,414,417,419,422,425,427,430,433,435,438,441,443,446,449,452,454,457,460,462,465,468,470,473,476,478,481,484
 dc.w 486,489,492,495,497,500,503,505,508,511,513,516


n32
* G#5
 dc.w 3,6,9,11,14,17,20,23,26,28,31,34,37,40,43,46,48,51,54,57,60,63,65,68,71,74,77,80,83,85
 dc.w 88,91,94,97,100,103,105,108,111,114,117,120,122,125,128,131,134,137,140,142,145,148,151,154,157,159,162,165,168,171
 dc.w 174,177,179,182,185,188,191,194,196,199,202,205,208,211,214,216,219,222,225,228,231,234,236,239,242,245,248,251,253,256
 dc.w 259,262,265,268,271,273,276,279,282,285,288,290,293,296,299,302,305,308,310,313,316,319,322,325,327,330,333,336,339,342
 dc.w 345,347,350,353,356,359,362,365,367,370,373,376,379,382,384,387,390,393,396,399,402,404,407,410,413,416,419,421,424,427
 dc.w 430,433,436,439,441,444,447,450,453,456,458,461,464,467,470,473,476,478,481,484,487,490,493,495,498,501,504,507,510,513
 dc.w 515,518,521,524,527,530,533,535,538,541,544,547


n33
* A5 
 dc.w 3,6,9,12,15,18,21,24,27,30,33,36,39,42,45,48,51,54,57,60,63,66,69,72,75,78,81,84,87,91
 dc.w 94,97,100,103,106,109,112,115,118,121,124,127,130,133,136,139,142,145,148,151,154,157,160,163,166,169,172,175,178,181
 dc.w 184,187,190,193,196,199,202,205,208,211,214,217,220,223,226,229,232,235,238,241,244,247,250,253,256,259,262,265,269,272
 dc.w 275,278,281,284,287,290,293,296,299,302,305,308,311,314,317,320,323,326,329,332,335,338,341,344,347,350,353,356,359,362
 dc.w 365,368,371,374,377,380,383,386,389,392,395,398,401,404,407,410,413,416,419,422,425,428,431,434,437,440,443,447,450,453
 dc.w 456,459,462,465,468,471,474,477,480,483,486,489,492,495,498,501,504,507,510,513,516,519,522,525,528,531,534,537,540,543
 dc.w 546,549,552,555,558,561,564,567,570,573,576,579


n34
* A#5
 dc.w 3,6,10,13,16,19,22,26,29,32,35,38,42,45,48,51,54,58,61,64,67,70,74,77,80,83,86,89,93,96
 dc.w 99,102,105,109,112,115,118,121,125,128,131,134,137,141,144,147,150,153,157,160,163,166,169,173,176,179,182,185,189,192
 dc.w 195,198,201,205,208,211,214,217,221,224,227,230,233,237,240,243,246,249,253,256,259,262,265,268,272,275,278,281,284,288
 dc.w 291,294,297,300,304,307,310,313,316,320,323,326,329,332,336,339,342,345,348,352,355,358,361,364,368,371,374,377,380,384
 dc.w 387,390,393,396,400,403,406,409,412,416,419,422,425,428,432,435,438,441,444,447,451,454,457,460,463,467,470,473,476,479
 dc.w 483,486,489,492,495,499,502,505,508,511,515,518,521,524,527,531,534,537,540,543,547,550,553,556,559,563,566,569,572,575
 dc.w 579,582,585,588,591,595,598,601,604,607,611,614


n35
* B5 
 dc.w 3,7,10,14,17,20,24,27,30,34,37,41,44,47,51,54,58,61,64,68,71,75,78,81,85,88,91,95,98,102
 dc.w 105,108,112,115,119,122,125,129,132,135,139,142,146,149,152,156,159,163,166,169,173,176,179,183,186,190,193,196,200,203
 dc.w 207,210,213,217,220,224,227,230,234,237,240,244,247,251,254,257,261,264,268,271,274,278,281,284,288,291,295,298,301,305
 dc.w 308,312,315,318,322,325,328,332,335,339,342,345,349,352,356,359,362,366,369,373,376,379,383,386,389,393,396,400,403,406
 dc.w 410,413,417,420,423,427,430,433,437,440,444,447,450,454,457,461,464,467,471,474,477,481,484,488,491,494,498,501,505,508
 dc.w 511,515,518,522,525,528,532,535,538,542,545,549,552,555,559,562,566,569,572,576,579,582,586,589,593,596,599,603,606,610
 dc.w 613,616,620,623,626,630,633,637,640,643,647,650


n36
* C6
 dc.w 4,7,11,14,18,22,25,29,32,36,39,43,47,50,54,57,61,65,68,72,75,79,83,86,90,93,97,100,104,108
 dc.w 111,115,118,122,126,129,133,136,140,144,147,151,154,158,161,165,169,172,176,179,183,187,190,194,197,201,205,208,212,215
 dc.w 219,222,226,230,233,237,240,244,248,251,255,258,262,265,269,273,276,280,283,287,291,294,298,301,305,309,312,316,319,323
 dc.w 326,330,334,337,341,344,348,352,355,359,362,366,370,373,377,380,384,387,391,395,398,402,405,409,413,416,420,423,427,431
 dc.w 434,438,441,445,448,452,456,459,463,466,470,474,477,481,484,488,492,495,499,502,506,509,513,517,520,524,527,531,535,538
 dc.w 542,545,549,553,556,560,563,567,570,574,578,581,585,588,592,596,599,603,606,610,614,617,621,624,628,631,635,639,642,646
 dc.w 649,653,657,660,664,667,671,675,678,682,685,689


