;Palette of ARR_PLA3.IFF: Saved by NEOchrome V2.25 by Chaos, Inc.
		dc.w	$0000,$0037,$0444,$0112,$0223,$0334,$0222,$0333
		dc.w	$0555,$0777,$0721,$0730,$0740,$0750,$0763,$0770
