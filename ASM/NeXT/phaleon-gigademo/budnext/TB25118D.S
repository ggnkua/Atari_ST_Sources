nste0
* C3 
 dc.w 0,1,1,1,2,2,2,3,3,3,4,4,4,5,5,6,6,6,7,7,7,8,8,8,9,9,9,10,10,10
 dc.w 11,11,11,12,12,12,13,13,13,14,14,14,15,15,15,16,16,17,17,17,18,18,18,19,19,19,20,20,20,21
 dc.w 21,21,22,22,22,23,23,23,24,24,24,25,25,25,26,26,26,27,27,28,28,28,29,29,29,30,30,30,31,31
 dc.w 31,32,32,32,33,33,33,34,34,34,35,35,35,36,36,36,37,37,37,38,38,39,39,39,40,40,40,41,41,41
 dc.w 42,42,42,43,43,43,44,44,44,45,45,45,46,46,46,47,47,47,48,48,48,49,49,50,50,50,51,51,51,52
 dc.w 52,52,53,53,53,54,54,54,55,55,55,56,56,56,57,57,57,58,58,58,59,59,60,60,60,61,61,61,62,62
 dc.w 62,63,63,63,64,64,64,65,65,65,66,66,66,67,67,67,68,68,68,69,69,69,70,70,71,71,71,72,72,72
 dc.w 73,73,73,74,74,74,75,75,75,76,76,76,77,77,77,78,78,78,79,79,79,80,80,80,81,81,82,82,82,83
 dc.w 83,83,84,84,84,85,85,85,86,86,86


nste1
* C#3
 dc.w 0,1,1,1,2,2,3,3,3,4,4,4,5,5,5,6,6,7,7,7,8,8,8,9,9,9,10,10,11,11
 dc.w 11,12,12,12,13,13,13,14,14,15,15,15,16,16,16,17,17,17,18,18,19,19,19,20,20,20,21,21,22,22
 dc.w 22,23,23,23,24,24,24,25,25,26,26,26,27,27,27,28,28,28,29,29,30,30,30,31,31,31,32,32,32,33
 dc.w 33,34,34,34,35,35,35,36,36,36,37,37,38,38,38,39,39,39,40,40,40,41,41,42,42,42,43,43,43,44
 dc.w 44,44,45,45,46,46,46,47,47,47,48,48,48,49,49,50,50,50,51,51,51,52,52,52,53,53,54,54,54,55
 dc.w 55,55,56,56,56,57,57,58,58,58,59,59,59,60,60,60,61,61,62,62,62,63,63,63,64,64,65,65,65,66
 dc.w 66,66,67,67,67,68,68,69,69,69,70,70,70,71,71,71,72,72,73,73,73,74,74,74,75,75,75,76,76,77
 dc.w 77,77,78,78,78,79,79,79,80,80,81,81,81,82,82,82,83,83,83,84,84,85,85,85,86,86,86,87,87,87
 dc.w 88,88,89,89,89,90,90,90,91,91,91


nste2
* D3 
 dc.w 0,1,1,2,2,2,3,3,3,4,4,5,5,5,6,6,7,7,7,8,8,8,9,9,10,10,10,11,11,12
 dc.w 12,12,13,13,14,14,14,15,15,15,16,16,17,17,17,18,18,19,19,19,20,20,20,21,21,22,22,22,23,23
 dc.w 24,24,24,25,25,25,26,26,27,27,27,28,28,29,29,29,30,30,31,31,31,32,32,32,33,33,34,34,34,35
 dc.w 35,36,36,36,37,37,37,38,38,39,39,39,40,40,41,41,41,42,42,42,43,43,44,44,44,45,45,46,46,46
 dc.w 47,47,47,48,48,49,49,49,50,50,51,51,51,52,52,53,53,53,54,54,54,55,55,56,56,56,57,57,58,58
 dc.w 58,59,59,59,60,60,61,61,61,62,62,63,63,63,64,64,64,65,65,66,66,66,67,67,68,68,68,69,69,69
 dc.w 70,70,71,71,71,72,72,73,73,73,74,74,75,75,75,76,76,76,77,77,78,78,78,79,79,80,80,80,81,81
 dc.w 81,82,82,83,83,83,84,84,85,85,85,86,86,86,87,87,88,88,88,89,89,90,90,90,91,91,92,92,92,93
 dc.w 93,93,94,94,95,95,95,96,96,97,97


nste3
* D#3
 dc.w 0,1,1,2,2,2,3,3,4,4,4,5,5,6,6,7,7,7,8,8,9,9,9,10,10,11,11,11,12,12
 dc.w 13,13,13,14,14,15,15,16,16,16,17,17,18,18,18,19,19,20,20,20,21,21,22,22,22,23,23,24,24,25
 dc.w 25,25,26,26,27,27,27,28,28,29,29,29,30,30,31,31,31,32,32,33,33,34,34,34,35,35,36,36,36,37
 dc.w 37,38,38,38,39,39,40,40,40,41,41,42,42,43,43,43,44,44,45,45,45,46,46,47,47,47,48,48,49,49
 dc.w 49,50,50,51,51,52,52,52,53,53,54,54,54,55,55,56,56,56,57,57,58,58,58,59,59,60,60,61,61,61
 dc.w 62,62,63,63,63,64,64,65,65,65,66,66,67,67,67,68,68,69,69,70,70,70,71,71,72,72,72,73,73,74
 dc.w 74,74,75,75,76,76,76,77,77,78,78,79,79,79,80,80,81,81,81,82,82,83,83,83,84,84,85,85,85,86
 dc.w 86,87,87,88,88,88,89,89,90,90,90,91,91,92,92,92,93,93,94,94,94,95,95,96,96,97,97,97,98,98
 dc.w 99,99,99,100,100,101,101,101,102,102,103


nste4
* E3 
 dc.w 0,1,1,2,2,3,3,3,4,4,5,5,6,6,7,7,7,8,8,9,9,10,10,10,11,11,12,12,13,13
 dc.w 13,14,14,15,15,16,16,16,17,17,18,18,19,19,20,20,20,21,21,22,22,23,23,23,24,24,25,25,26,26
 dc.w 26,27,27,28,28,29,29,29,30,30,31,31,32,32,33,33,33,34,34,35,35,36,36,36,37,37,38,38,39,39
 dc.w 39,40,40,41,41,42,42,42,43,43,44,44,45,45,46,46,46,47,47,48,48,49,49,49,50,50,51,51,52,52
 dc.w 52,53,53,54,54,55,55,55,56,56,57,57,58,58,59,59,59,60,60,61,61,62,62,62,63,63,64,64,65,65
 dc.w 65,66,66,67,67,68,68,68,69,69,70,70,71,71,72,72,72,73,73,74,74,75,75,75,76,76,77,77,78,78
 dc.w 78,79,79,80,80,81,81,81,82,82,83,83,84,84,85,85,85,86,86,87,87,88,88,88,89,89,90,90,91,91
 dc.w 91,92,92,93,93,94,94,94,95,95,96,96,97,97,98,98,98,99,99,100,100,101,101,101,102,102,103,103,104,104
 dc.w 104,105,105,106,106,107,107,107,108,108,109


nste5
* F3 
 dc.w 0,1,1,2,2,3,3,4,4,5,5,6,6,6,7,7,8,8,9,9,10,10,11,11,11,12,12,13,13,14
 dc.w 14,15,15,16,16,17,17,17,18,18,19,19,20,20,21,21,22,22,22,23,23,24,24,25,25,26,26,27,27,28
 dc.w 28,28,29,29,30,30,31,31,32,32,33,33,34,34,34,35,35,36,36,37,37,38,38,39,39,39,40,40,41,41
 dc.w 42,42,43,43,44,44,45,45,45,46,46,47,47,48,48,49,49,50,50,51,51,51,52,52,53,53,54,54,55,55
 dc.w 56,56,56,57,57,58,58,59,59,60,60,61,61,62,62,62,63,63,64,64,65,65,66,66,67,67,67,68,68,69
 dc.w 69,70,70,71,71,72,72,73,73,73,74,74,75,75,76,76,77,77,78,78,79,79,79,80,80,81,81,82,82,83
 dc.w 83,84,84,84,85,85,86,86,87,87,88,88,89,89,90,90,90,91,91,92,92,93,93,94,94,95,95,96,96,96
 dc.w 97,97,98,98,99,99,100,100,101,101,101,102,102,103,103,104,104,105,105,106,106,107,107,107,108,108,109,109,110,110
 dc.w 111,111,112,112,112,113,113,114,114,115,115


nste6
* F#3
 dc.w 0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8,9,9,10,10,11,11,12,12,13,13,14,14,15
 dc.w 15,16,16,17,17,18,18,18,19,19,20,20,21,21,22,22,23,23,24,24,25,25,26,26,27,27,28,28,29,29
 dc.w 30,30,31,31,32,32,33,33,34,34,35,35,36,36,36,37,37,38,38,39,39,40,40,41,41,42,42,43,43,44
 dc.w 44,45,45,46,46,47,47,48,48,49,49,50,50,51,51,52,52,53,53,54,54,54,55,55,56,56,57,57,58,58
 dc.w 59,59,60,60,61,61,62,62,63,63,64,64,65,65,66,66,67,67,68,68,69,69,70,70,71,71,72,72,72,73
 dc.w 73,74,74,75,75,76,76,77,77,78,78,79,79,80,80,81,81,82,82,83,83,84,84,85,85,86,86,87,87,88
 dc.w 88,89,89,90,90,90,91,91,92,92,93,93,94,94,95,95,96,96,97,97,98,98,99,99,100,100,101,101,102,102
 dc.w 103,103,104,104,105,105,106,106,107,107,108,108,108,109,109,110,110,111,111,112,112,113,113,114,114,115,115,116,116,117
 dc.w 117,118,118,119,119,120,120,121,121,122,122


nste7
* G3 
 dc.w 1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8,9,9,10,10,11,11,12,12,13,13,14,14,15,15
 dc.w 16,16,17,18,18,19,19,20,20,21,21,22,22,23,23,24,24,25,25,26,26,27,27,28,28,29,29,30,30,31
 dc.w 31,32,32,33,33,34,35,35,36,36,37,37,38,38,39,39,40,40,41,41,42,42,43,43,44,44,45,45,46,46
 dc.w 47,47,48,48,49,49,50,51,51,52,52,53,53,54,54,55,55,56,56,57,57,58,58,59,59,60,60,61,61,62
 dc.w 62,63,63,64,64,65,65,66,66,67,68,68,69,69,70,70,71,71,72,72,73,73,74,74,75,75,76,76,77,77
 dc.w 78,78,79,79,80,80,81,81,82,82,83,83,84,85,85,86,86,87,87,88,88,89,89,90,90,91,91,92,92,93
 dc.w 93,94,94,95,95,96,96,97,97,98,98,99,99,100,100,101,102,102,103,103,104,104,105,105,106,106,107,107,108,108
 dc.w 109,109,110,110,111,111,112,112,113,113,114,114,115,115,116,116,117,118,118,119,119,120,120,121,121,122,122,123,123,124
 dc.w 124,125,125,126,126,127,127,128,128,129,129


nste8
* G#3
 dc.w 1,1,2,2,3,3,4,4,5,5,6,7,7,8,8,9,9,10,10,11,11,12,13,13,14,14,15,15,16,16
 dc.w 17,17,18,19,19,20,20,21,21,22,22,23,23,24,25,25,26,26,27,27,28,28,29,29,30,31,31,32,32,33
 dc.w 33,34,34,35,35,36,37,37,38,38,39,39,40,40,41,41,42,43,43,44,44,45,45,46,46,47,48,48,49,49
 dc.w 50,50,51,51,52,52,53,54,54,55,55,56,56,57,57,58,58,59,60,60,61,61,62,62,63,63,64,64,65,66
 dc.w 66,67,67,68,68,69,69,70,70,71,72,72,73,73,74,74,75,75,76,76,77,78,78,79,79,80,80,81,81,82
 dc.w 82,83,84,84,85,85,86,86,87,87,88,88,89,90,90,91,91,92,92,93,93,94,94,95,96,96,97,97,98,98
 dc.w 99,99,100,100,101,102,102,103,103,104,104,105,105,106,106,107,108,108,109,109,110,110,111,111,112,112,113,114,114,115
 dc.w 115,116,116,117,117,118,118,119,120,120,121,121,122,122,123,123,124,124,125,126,126,127,127,128,128,129,129,130,130,131
 dc.w 132,132,133,133,134,134,135,135,136,137,137


nste9
* A3 
 dc.w 1,1,2,2,3,3,4,5,5,6,6,7,8,8,9,9,10,10,11,12,12,13,13,14,14,15,16,16,17,17
 dc.w 18,19,19,20,20,21,21,22,23,23,24,24,25,25,26,27,27,28,28,29,30,30,31,31,32,32,33,34,34,35
 dc.w 35,36,36,37,38,38,39,39,40,40,41,42,42,43,43,44,45,45,46,46,47,47,48,49,49,50,50,51,51,52
 dc.w 53,53,54,54,55,56,56,57,57,58,58,59,60,60,61,61,62,62,63,64,64,65,65,66,67,67,68,68,69,69
 dc.w 70,71,71,72,72,73,73,74,75,75,76,76,77,78,78,79,79,80,80,81,82,82,83,83,84,84,85,86,86,87
 dc.w 87,88,89,89,90,90,91,91,92,93,93,94,94,95,95,96,97,97,98,98,99,99,100,101,101,102,102,103,104,104
 dc.w 105,105,106,106,107,108,108,109,109,110,110,111,112,112,113,113,114,115,115,116,116,117,117,118,119,119,120,120,121,121
 dc.w 122,123,123,124,124,125,126,126,127,127,128,128,129,130,130,131,131,132,132,133,134,134,135,135,136,137,137,138,138,139
 dc.w 139,140,141,141,142,142,143,143,144,145,145


nste10
* A#3
 dc.w 1,1,2,2,3,4,4,5,6,6,7,7,8,9,9,10,10,11,12,12,13,13,14,15,15,16,17,17,18,18
 dc.w 19,20,20,21,21,22,23,23,24,25,25,26,26,27,28,28,29,29,30,31,31,32,32,33,34,34,35,36,36,37
 dc.w 37,38,39,39,40,40,41,42,42,43,44,44,45,45,46,47,47,48,48,49,50,50,51,51,52,53,53,54,55,55
 dc.w 56,56,57,58,58,59,59,60,61,61,62,63,63,64,64,65,66,66,67,67,68,69,69,70,70,71,72,72,73,74
 dc.w 74,75,75,76,77,77,78,78,79,80,80,81,82,82,83,83,84,85,85,86,86,87,88,88,89,89,90,91,91,92
 dc.w 93,93,94,94,95,96,96,97,97,98,99,99,100,101,101,102,102,103,104,104,105,105,106,107,107,108,108,109,110,110
 dc.w 111,112,112,113,113,114,115,115,116,116,117,118,118,119,120,120,121,121,122,123,123,124,124,125,126,126,127,127,128,129
 dc.w 129,130,131,131,132,132,133,134,134,135,135,136,137,137,138,139,139,140,140,141,142,142,143,143,144,145,145,146,146,147
 dc.w 148,148,149,150,150,151,151,152,153,153,154


nste11
* B3 
 dc.w 1,1,2,3,3,4,5,5,6,6,7,8,8,9,10,10,11,12,12,13,14,14,15,16,16,17,18,18,19,19
 dc.w 20,21,21,22,23,23,24,25,25,26,27,27,28,29,29,30,31,31,32,32,33,34,34,35,36,36,37,38,38,39
 dc.w 40,40,41,42,42,43,44,44,45,45,46,47,47,48,49,49,50,51,51,52,53,53,54,55,55,56,56,57,58,58
 dc.w 59,60,60,61,62,62,63,64,64,65,66,66,67,68,68,69,69,70,71,71,72,73,73,74,75,75,76,77,77,78
 dc.w 79,79,80,81,81,82,82,83,84,84,85,86,86,87,88,88,89,90,90,91,92,92,93,94,94,95,95,96,97,97
 dc.w 98,99,99,100,101,101,102,103,103,104,105,105,106,106,107,108,108,109,110,110,111,112,112,113,114,114,115,116,116,117
 dc.w 118,118,119,119,120,121,121,122,123,123,124,125,125,126,127,127,128,129,129,130,131,131,132,132,133,134,134,135,136,136
 dc.w 137,138,138,139,140,140,141,142,142,143,143,144,145,145,146,147,147,148,149,149,150,151,151,152,153,153,154,155,155,156
 dc.w 156,157,158,158,159,160,160,161,162,162,163


nste12
* C4 
 dc.w 1,1,2,3,3,4,5,6,6,7,8,8,9,10,10,11,12,12,13,14,14,15,16,17,17,18,19,19,20,21
 dc.w 21,22,23,23,24,25,25,26,27,28,28,29,30,30,31,32,32,33,34,34,35,36,36,37,38,39,39,40,41,41
 dc.w 42,43,43,44,45,45,46,47,47,48,49,50,50,51,52,52,53,54,54,55,56,56,57,58,58,59,60,61,61,62
 dc.w 63,63,64,65,65,66,67,67,68,69,69,70,71,72,72,73,74,74,75,76,76,77,78,78,79,80,80,81,82,83
 dc.w 83,84,85,85,86,87,87,88,89,89,90,91,91,92,93,94,94,95,96,96,97,98,98,99,100,100,101,102,103,103
 dc.w 104,105,105,106,107,107,108,109,109,110,111,111,112,113,114,114,115,116,116,117,118,118,119,120,120,121,122,122,123,124
 dc.w 125,125,126,127,127,128,129,129,130,131,131,132,133,133,134,135,136,136,137,138,138,139,140,140,141,142,142,143,144,144
 dc.w 145,146,147,147,148,149,149,150,151,151,152,153,153,154,155,155,156,157,158,158,159,160,160,161,162,162,163,164,164,165
 dc.w 166,166,167,168,169,169,170,171,171,172,173


nste13
* C#4
 dc.w 1,1,2,3,4,4,5,6,7,7,8,9,9,10,11,12,12,13,14,15,15,16,17,17,18,19,20,20,21,22
 dc.w 23,23,24,25,26,26,27,28,28,29,30,31,31,32,33,34,34,35,36,36,37,38,39,39,40,41,42,42,43,44
 dc.w 44,45,46,47,47,48,49,50,50,51,52,52,53,54,55,55,56,57,58,58,59,60,60,61,62,63,63,64,65,66
 dc.w 66,67,68,69,69,70,71,71,72,73,74,74,75,76,77,77,78,79,79,80,81,82,82,83,84,85,85,86,87,87
 dc.w 88,89,90,90,91,92,93,93,94,95,95,96,97,98,98,99,100,101,101,102,103,103,104,105,106,106,107,108,109,109
 dc.w 110,111,112,112,113,114,114,115,116,117,117,118,119,120,120,121,122,122,123,124,125,125,126,127,128,128,129,130,130,131
 dc.w 132,133,133,134,135,136,136,137,138,138,139,140,141,141,142,143,144,144,145,146,146,147,148,149,149,150,151,152,152,153
 dc.w 154,155,155,156,157,157,158,159,160,160,161,162,163,163,164,165,165,166,167,168,168,169,170,171,171,172,173,173,174,175
 dc.w 176,176,177,178,179,179,180,181,181,182,183


nste14
* D4 
 dc.w 1,2,2,3,4,5,5,6,7,8,8,9,10,11,12,12,13,14,15,15,16,17,18,19,19,20,21,22,22,23
 dc.w 24,25,25,26,27,28,29,29,30,31,32,32,33,34,35,36,36,37,38,39,39,40,41,42,42,43,44,45,46,46
 dc.w 47,48,49,49,50,51,52,53,53,54,55,56,56,57,58,59,59,60,61,62,63,63,64,65,66,66,67,68,69,69
 dc.w 70,71,72,73,73,74,75,76,76,77,78,79,80,80,81,82,83,83,84,85,86,86,87,88,89,90,90,91,92,93
 dc.w 93,94,95,96,97,97,98,99,100,100,101,102,103,103,104,105,106,107,107,108,109,110,110,111,112,113,114,114,115,116
 dc.w 117,117,118,119,120,120,121,122,123,124,124,125,126,127,127,128,129,130,130,131,132,133,134,134,135,136,137,137,138,139
 dc.w 140,141,141,142,143,144,144,145,146,147,147,148,149,150,151,151,152,153,154,154,155,156,157,158,158,159,160,161,161,162
 dc.w 163,164,164,165,166,167,168,168,169,170,171,171,172,173,174,175,175,176,177,178,178,179,180,181,181,182,183,184,185,185
 dc.w 186,187,188,188,189,190,191,191,192,193,194


nste15
* D#4
 dc.w 1,2,2,3,4,5,6,7,7,8,9,10,11,11,12,13,14,15,16,16,17,18,19,20,20,21,22,23,24,25
 dc.w 25,26,27,28,29,29,30,31,32,33,34,34,35,36,37,38,38,39,40,41,42,43,43,44,45,46,47,47,48,49
 dc.w 50,51,52,52,53,54,55,56,56,57,58,59,60,61,61,62,63,64,65,65,66,67,68,69,70,70,71,72,73,74
 dc.w 74,75,76,77,78,79,79,80,81,82,83,83,84,85,86,87,88,88,89,90,91,92,92,93,94,95,96,97,97,98
 dc.w 99,100,101,101,102,103,104,105,106,106,107,108,109,110,110,111,112,113,114,115,115,116,117,118,119,119,120,121,122,123
 dc.w 124,124,125,126,127,128,128,129,130,131,132,133,133,134,135,136,137,137,138,139,140,141,142,142,143,144,145,146,146,147
 dc.w 148,149,150,151,151,152,153,154,155,155,156,157,158,159,160,160,161,162,163,164,164,165,166,167,168,169,169,170,171,172
 dc.w 173,173,174,175,176,177,178,178,179,180,181,182,182,183,184,185,186,187,187,188,189,190,191,191,192,193,194,195,196,196
 dc.w 197,198,199,200,200,201,202,203,204,205,205


nste16
* E4 
 dc.w 1,2,3,3,4,5,6,7,8,9,10,10,11,12,13,14,15,16,16,17,18,19,20,21,22,23,23,24,25,26
 dc.w 27,28,29,29,30,31,32,33,34,35,36,36,37,38,39,40,41,42,42,43,44,45,46,47,48,49,49,50,51,52
 dc.w 53,54,55,55,56,57,58,59,60,61,62,62,63,64,65,66,67,68,68,69,70,71,72,73,74,75,75,76,77,78
 dc.w 79,80,81,81,82,83,84,85,86,87,88,88,89,90,91,92,93,94,94,95,96,97,98,99,100,101,101,102,103,104
 dc.w 105,106,107,107,108,109,110,111,112,113,114,114,115,116,117,118,119,120,120,121,122,123,124,125,126,127,127,128,129,130
 dc.w 131,132,133,133,134,135,136,137,138,139,140,140,141,142,143,144,145,146,146,147,148,149,150,151,152,153,153,154,155,156
 dc.w 157,158,159,159,160,161,162,163,164,165,166,166,167,168,169,170,171,172,172,173,174,175,176,177,178,179,179,180,181,182
 dc.w 183,184,185,185,186,187,188,189,190,191,192,192,193,194,195,196,197,198,198,199,200,201,202,203,204,205,205,206,207,208
 dc.w 209,210,211,211,212,213,214,215,216,217,218


nste17
* F4 
 dc.w 1,2,3,4,5,6,6,7,8,9,10,11,12,13,14,15,16,17,17,18,19,20,21,22,23,24,25,26,27,28
 dc.w 28,29,30,31,32,33,34,35,36,37,38,39,39,40,41,42,43,44,45,46,47,48,49,50,51,51,52,53,54,55
 dc.w 56,57,58,59,60,61,62,62,63,64,65,66,67,68,69,70,71,72,73,73,74,75,76,77,78,79,80,81,82,83
 dc.w 84,84,85,86,87,88,89,90,91,92,93,94,95,96,96,97,98,99,100,101,102,103,104,105,106,107,107,108,109,110
 dc.w 111,112,113,114,115,116,117,118,118,119,120,121,122,123,124,125,126,127,128,129,129,130,131,132,133,134,135,136,137,138
 dc.w 139,140,140,141,142,143,144,145,146,147,148,149,150,151,152,152,153,154,155,156,157,158,159,160,161,162,163,163,164,165
 dc.w 166,167,168,169,170,171,172,173,174,174,175,176,177,178,179,180,181,182,183,184,185,185,186,187,188,189,190,191,192,193
 dc.w 194,195,196,197,197,198,199,200,201,202,203,204,205,206,207,208,208,209,210,211,212,213,214,215,216,217,218,219,219,220
 dc.w 221,222,223,224,225,226,227,228,229,230,230


nste18
* F#4
 dc.w 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,18,19,20,21,22,23,24,25,26,27,28,29
 dc.w 30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,54,55,56,57,58
 dc.w 59,60,61,62,63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88
 dc.w 89,90,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117
 dc.w 118,119,120,121,122,123,124,125,126,126,127,128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144,145,146
 dc.w 147,148,149,150,151,152,153,154,155,156,157,158,159,160,161,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175
 dc.w 176,177,178,179,180,181,182,183,184,185,186,187,188,189,190,191,192,193,194,195,196,197,197,198,199,200,201,202,203,204
 dc.w 205,206,207,208,209,210,211,212,213,214,215,216,217,218,219,220,221,222,223,224,225,226,227,228,229,230,231,232,233,233
 dc.w 234,235,236,237,238,239,240,241,242,243,244


nste19
* G4 
 dc.w 1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,18,19,20,21,22,23,24,25,26,27,28,29,30,31
 dc.w 32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,51,52,53,54,55,56,57,58,59,60,61,62
 dc.w 63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,85,86,87,88,89,90,91,92,93
 dc.w 94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,118,119,120,121,122,123,124
 dc.w 125,126,127,128,129,130,131,132,133,134,135,136,137,138,139,140,141,142,143,144,145,146,147,148,149,150,152,153,154,155
 dc.w 156,157,158,159,160,161,162,163,164,165,166,167,168,169,170,171,172,173,174,175,176,177,178,179,180,181,182,183,184,186
 dc.w 187,188,189,190,191,192,193,194,195,196,197,198,199,200,201,202,203,204,205,206,207,208,209,210,211,212,213,214,215,216
 dc.w 217,219,220,221,222,223,224,225,226,227,228,229,230,231,232,233,234,235,236,237,238,239,240,241,242,243,244,245,246,247
 dc.w 248,249,250,251,253,254,255,256,257,258,259


nste20
* G#4
 dc.w 1,2,3,4,5,7,8,9,10,11,12,13,14,15,16,17,19,20,21,22,23,24,25,26,27,28,29,31,32,33
 dc.w 34,35,36,37,38,39,40,41,43,44,45,46,47,48,49,50,51,52,54,55,56,57,58,59,60,61,62,63,64,66
 dc.w 67,68,69,70,71,72,73,74,75,76,78,79,80,81,82,83,84,85,86,87,88,90,91,92,93,94,95,96,97,98
 dc.w 99,100,102,103,104,105,106,107,108,109,110,111,112,114,115,116,117,118,119,120,121,122,123,124,126,127,128,129,130,131
 dc.w 132,133,134,135,137,138,139,140,141,142,143,144,145,146,147,149,150,151,152,153,154,155,156,157,158,159,161,162,163,164
 dc.w 165,166,167,168,169,170,171,173,174,175,176,177,178,179,180,181,182,183,185,186,187,188,189,190,191,192,193,194,195,197
 dc.w 198,199,200,201,202,203,204,205,206,207,209,210,211,212,213,214,215,216,217,218,219,221,222,223,224,225,226,227,228,229
 dc.w 230,232,233,234,235,236,237,238,239,240,241,242,244,245,246,247,248,249,250,251,252,253,254,256,257,258,259,260,261,262
 dc.w 263,264,265,266,268,269,270,271,272,273,274


nste21
* A4 
 dc.w 1,2,3,5,6,7,8,9,10,12,13,14,15,16,17,19,20,21,22,23,24,25,27,28,29,30,31,32,34,35
 dc.w 36,37,38,39,40,42,43,44,45,46,47,49,50,51,52,53,54,56,57,58,59,60,61,62,64,65,66,67,68,69
 dc.w 71,72,73,74,75,76,78,79,80,81,82,83,84,86,87,88,89,90,91,93,94,95,96,97,98,99,101,102,103,104
 dc.w 105,106,108,109,110,111,112,113,115,116,117,118,119,120,121,123,124,125,126,127,128,130,131,132,133,134,135,137,138,139
 dc.w 140,141,142,143,145,146,147,148,149,150,152,153,154,155,156,157,159,160,161,162,163,164,165,167,168,169,170,171,172,174
 dc.w 175,176,177,178,179,180,182,183,184,185,186,187,189,190,191,192,193,194,196,197,198,199,200,201,202,204,205,206,207,208
 dc.w 209,211,212,213,214,215,216,218,219,220,221,222,223,224,226,227,228,229,230,231,233,234,235,236,237,238,239,241,242,243
 dc.w 244,245,246,248,249,250,251,252,253,255,256,257,258,259,260,261,263,264,265,266,267,268,270,271,272,273,274,275,277,278
 dc.w 279,280,281,282,283,285,286,287,288,289,290


nste22
* A#4
 dc.w 1,2,4,5,6,7,9,10,11,12,13,15,16,17,18,20,21,22,23,25,26,27,28,29,31,32,33,34,36,37
 dc.w 38,39,40,42,43,44,45,47,48,49,50,51,53,54,55,56,58,59,60,61,63,64,65,66,67,69,70,71,72,74
 dc.w 75,76,77,78,80,81,82,83,85,86,87,88,89,91,92,93,94,96,97,98,99,101,102,103,104,105,107,108,109,110
 dc.w 112,113,114,115,116,118,119,120,121,123,124,125,126,127,129,130,131,132,134,135,136,137,139,140,141,142,143,145,146,147
 dc.w 148,150,151,152,153,154,156,157,158,159,161,162,163,164,165,167,168,169,170,172,173,174,175,177,178,179,180,181,183,184
 dc.w 185,186,188,189,190,191,192,194,195,196,197,199,200,201,202,203,205,206,207,208,210,211,212,213,215,216,217,218,219,221
 dc.w 222,223,224,226,227,228,229,230,232,233,234,235,237,238,239,240,241,243,244,245,246,248,249,250,251,253,254,255,256,257
 dc.w 259,260,261,262,264,265,266,267,268,270,271,272,273,275,276,277,278,279,281,282,283,284,286,287,288,289,291,292,293,294
 dc.w 295,297,298,299,300,302,303,304,305,306,308


nste23
* B4 
 dc.w 1,3,4,5,6,8,9,10,12,13,14,16,17,18,19,21,22,23,25,26,27,29,30,31,32,34,35,36,38,39
 dc.w 40,42,43,44,45,47,48,49,51,52,53,55,56,57,58,60,61,62,64,65,66,68,69,70,71,73,74,75,77,78
 dc.w 79,81,82,83,84,86,87,88,90,91,92,94,95,96,97,99,100,101,103,104,105,106,108,109,110,112,113,114,116,117
 dc.w 118,119,121,122,123,125,126,127,129,130,131,132,134,135,136,138,139,140,142,143,144,145,147,148,149,151,152,153,155,156
 dc.w 157,158,160,161,162,164,165,166,168,169,170,171,173,174,175,177,178,179,181,182,183,184,186,187,188,190,191,192,193,195
 dc.w 196,197,199,200,201,203,204,205,206,208,209,210,212,213,214,216,217,218,219,221,222,223,225,226,227,229,230,231,232,234
 dc.w 235,236,238,239,240,242,243,244,245,247,248,249,251,252,253,255,256,257,258,260,261,262,264,265,266,268,269,270,271,273
 dc.w 274,275,277,278,279,281,282,283,284,286,287,288,290,291,292,293,295,296,297,299,300,301,303,304,305,306,308,309,310,312
 dc.w 313,314,316,317,318,319,321,322,323,325,326


nste24
* C5 
 dc.w 1,3,4,6,7,8,10,11,12,14,15,17,18,19,21,22,23,25,26,28,29,30,32,33,34,36,37,39,40,41
 dc.w 43,44,45,47,48,50,51,52,54,55,56,58,59,61,62,63,65,66,67,69,70,72,73,74,76,77,78,80,81,83
 dc.w 84,85,87,88,89,91,92,94,95,96,98,99,100,102,103,105,106,107,109,110,111,113,114,116,117,118,120,121,122,124
 dc.w 125,127,128,129,131,132,133,135,136,138,139,140,142,143,144,146,147,149,150,151,153,154,155,157,158,160,161,162,164,165
 dc.w 166,168,169,171,172,173,175,176,177,179,180,182,183,184,186,187,188,190,191,193,194,195,197,198,199,201,202,204,205,206
 dc.w 208,209,211,212,213,215,216,217,219,220,222,223,224,226,227,228,230,231,233,234,235,237,238,239,241,242,244,245,246,248
 dc.w 249,250,252,253,255,256,257,259,260,261,263,264,266,267,268,270,271,272,274,275,277,278,279,281,282,283,285,286,288,289
 dc.w 290,292,293,294,296,297,299,300,301,303,304,305,307,308,310,311,312,314,315,316,318,319,321,322,323,325,326,327,329,330
 dc.w 332,333,334,336,337,338,340,341,343,344,345


nste25
* C#5
 dc.w 1,3,4,6,7,9,10,12,13,15,16,17,19,20,22,23,25,26,28,29,31,32,34,35,36,38,39,41,42,44
 dc.w 45,47,48,50,51,52,54,55,57,58,60,61,63,64,66,67,69,70,71,73,74,76,77,79,80,82,83,85,86,87
 dc.w 89,90,92,93,95,96,98,99,101,102,103,105,106,108,109,111,112,114,115,117,118,120,121,122,124,125,127,128,130,131
 dc.w 133,134,136,137,138,140,141,143,144,146,147,149,150,152,153,155,156,157,159,160,162,163,165,166,168,169,171,172,173,175
 dc.w 176,178,179,181,182,184,185,187,188,189,191,192,194,195,197,198,200,201,203,204,206,207,208,210,211,213,214,216,217,219
 dc.w 220,222,223,224,226,227,229,230,232,233,235,236,238,239,241,242,243,245,246,248,249,251,252,254,255,257,258,259,261,262
 dc.w 264,265,267,268,270,271,273,274,275,277,278,280,281,283,284,286,287,289,290,292,293,294,296,297,299,300,302,303,305,306
 dc.w 308,309,310,312,313,315,316,318,319,321,322,324,325,327,328,329,331,332,334,335,337,338,340,341,343,344,345,347,348,350
 dc.w 351,353,354,356,357,359,360,362,363,364,366


nste26
* D5 
 dc.w 2,3,5,6,8,9,11,12,14,15,17,19,20,22,23,25,26,28,29,31,32,34,36,37,39,40,42,43,45,46
 dc.w 48,49,51,53,54,56,57,59,60,62,63,65,66,68,69,71,73,74,76,77,79,80,82,83,85,86,88,90,91,93
 dc.w 94,96,97,99,100,102,103,105,107,108,110,111,113,114,116,117,119,120,122,124,125,127,128,130,131,133,134,136,137,139
 dc.w 141,142,144,145,147,148,150,151,153,154,156,158,159,161,162,164,165,167,168,170,171,173,175,176,178,179,181,182,184,185
 dc.w 187,188,190,191,193,195,196,198,199,201,202,204,205,207,208,210,212,213,215,216,218,219,221,222,224,225,227,229,230,232
 dc.w 233,235,236,238,239,241,242,244,246,247,249,250,252,253,255,256,258,259,261,263,264,266,267,269,270,272,273,275,276,278
 dc.w 280,281,283,284,286,287,289,290,292,293,295,297,298,300,301,303,304,306,307,309,310,312,314,315,317,318,320,321,323,324
 dc.w 326,327,329,330,332,334,335,337,338,340,341,343,344,346,347,349,351,352,354,355,357,358,360,361,363,364,366,368,369,371
 dc.w 372,374,375,377,378,380,381,383,385,386,388


nste27
* D#5
 dc.w 2,3,5,7,8,10,11,13,15,16,18,20,21,23,25,26,28,29,31,33,34,36,38,39,41,43,44,46,47,49
 dc.w 51,52,54,56,57,59,61,62,64,65,67,69,70,72,74,75,77,79,80,82,83,85,87,88,90,92,93,95,97,98
 dc.w 100,101,103,105,106,108,110,111,113,115,116,118,119,121,123,124,126,128,129,131,133,134,136,137,139,141,142,144,146,147
 dc.w 149,151,152,154,155,157,159,160,162,164,165,167,169,170,172,173,175,177,178,180,182,183,185,187,188,190,191,193,195,196
 dc.w 198,200,201,203,205,206,208,209,211,213,214,216,218,219,221,223,224,226,227,229,231,232,234,236,237,239,241,242,244,245
 dc.w 247,249,250,252,254,255,257,259,260,262,263,265,267,268,270,272,273,275,277,278,280,281,283,285,286,288,290,291,293,295
 dc.w 296,298,299,301,303,304,306,308,309,311,313,314,316,317,319,321,322,324,326,327,329,331,332,334,335,337,339,340,342,344
 dc.w 345,347,349,350,352,353,355,357,358,360,362,363,365,367,368,370,371,373,375,376,378,380,381,383,385,386,388,389,391,393
 dc.w 394,396,398,399,401,402,404,406,407,409,411


nste28
* E5 
 dc.w 2,3,5,7,9,10,12,14,16,17,19,21,23,24,26,28,29,31,33,35,36,38,40,42,43,45,47,49,50,52
 dc.w 54,55,57,59,61,62,64,66,68,69,71,73,75,76,78,80,81,83,85,87,88,90,92,94,95,97,99,101,102,104
 dc.w 106,107,109,111,113,114,116,118,120,121,123,125,127,128,130,132,133,135,137,139,140,142,144,146,147,149,151,153,154,156
 dc.w 158,159,161,163,165,166,168,170,172,173,175,177,179,180,182,184,185,187,189,191,192,194,196,198,199,201,203,205,206,208
 dc.w 210,211,213,215,217,218,220,222,224,225,227,229,231,232,234,236,237,239,241,243,244,246,248,250,251,253,255,257,258,260
 dc.w 262,263,265,267,269,270,272,274,276,277,279,281,283,284,286,288,289,291,293,295,296,298,300,302,303,305,307,309,310,312
 dc.w 314,315,317,319,321,322,324,326,328,329,331,333,335,336,338,340,341,343,345,347,348,350,352,354,355,357,359,361,362,364
 dc.w 366,367,369,371,373,374,376,378,380,381,383,385,387,388,390,392,393,395,397,399,400,402,404,406,407,409,411,413,414,416
 dc.w 418,419,421,423,425,426,428,430,432,433,435


nste29
* F5 
 dc.w 2,4,6,7,9,11,13,15,17,18,20,22,24,26,28,29,31,33,35,37,39,40,42,44,46,48,50,51,53,55
 dc.w 57,59,61,62,64,66,68,70,72,73,75,77,79,81,83,84,86,88,90,92,94,96,97,99,101,103,105,107,108,110
 dc.w 112,114,116,118,119,121,123,125,127,129,130,132,134,136,138,140,141,143,145,147,149,151,152,154,156,158,160,162,163,165
 dc.w 167,169,171,173,174,176,178,180,182,184,185,187,189,191,193,195,197,198,200,202,204,206,208,209,211,213,215,217,219,220
 dc.w 222,224,226,228,230,231,233,235,237,239,241,242,244,246,248,250,252,253,255,257,259,261,263,264,266,268,270,272,274,275
 dc.w 277,279,281,283,285,287,288,290,292,294,296,298,299,301,303,305,307,309,310,312,314,316,318,320,321,323,325,327,329,331
 dc.w 332,334,336,338,340,342,343,345,347,349,351,353,354,356,358,360,362,364,365,367,369,371,373,375,376,378,380,382,384,386
 dc.w 388,389,391,393,395,397,399,400,402,404,406,408,410,411,413,415,417,419,421,422,424,426,428,430,432,433,435,437,439,441
 dc.w 443,444,446,448,450,452,454,455,457,459,461


nste30
* F#5
 dc.w 2,4,6,8,10,12,14,16,18,19,21,23,25,27,29,31,33,35,37,39,41,43,45,47,49,51,53,54,56,58
 dc.w 60,62,64,66,68,70,72,74,76,78,80,82,84,86,88,90,91,93,95,97,99,101,103,105,107,109,111,113,115,117
 dc.w 119,121,123,125,126,128,130,132,134,136,138,140,142,144,146,148,150,152,154,156,158,160,161,163,165,167,169,171,173,175
 dc.w 177,179,181,183,185,187,189,191,193,195,197,198,200,202,204,206,208,210,212,214,216,218,220,222,224,226,228,230,232,233
 dc.w 235,237,239,241,243,245,247,249,251,253,255,257,259,261,263,265,267,269,270,272,274,276,278,280,282,284,286,288,290,292
 dc.w 294,296,298,300,302,304,305,307,309,311,313,315,317,319,321,323,325,327,329,331,333,335,337,339,341,342,344,346,348,350
 dc.w 352,354,356,358,360,362,364,366,368,370,372,374,376,377,379,381,383,385,387,389,391,393,395,397,399,401,403,405,407,409
 dc.w 411,412,414,416,418,420,422,424,426,428,430,432,434,436,438,440,442,444,446,448,449,451,453,455,457,459,461,463,465,467
 dc.w 469,471,473,475,477,479,481,483,484,486,488


nste31
* G5 
 dc.w 2,4,6,8,10,12,14,16,19,21,23,25,27,29,31,33,35,37,39,41,43,45,47,49,52,54,56,58,60,62
 dc.w 64,66,68,70,72,74,76,78,80,82,85,87,89,91,93,95,97,99,101,103,105,107,109,111,113,115,118,120,122,124
 dc.w 126,128,130,132,134,136,138,140,142,144,146,148,150,153,155,157,159,161,163,165,167,169,171,173,175,177,179,181,183,186
 dc.w 188,190,192,194,196,198,200,202,204,206,208,210,212,214,216,219,221,223,225,227,229,231,233,235,237,239,241,243,245,247
 dc.w 249,251,254,256,258,260,262,264,266,268,270,272,274,276,278,280,282,284,287,289,291,293,295,297,299,301,303,305,307,309
 dc.w 311,313,315,317,320,322,324,326,328,330,332,334,336,338,340,342,344,346,348,350,353,355,357,359,361,363,365,367,369,371
 dc.w 373,375,377,379,381,383,385,388,390,392,394,396,398,400,402,404,406,408,410,412,414,416,418,421,423,425,427,429,431,433
 dc.w 435,437,439,441,443,445,447,449,451,454,456,458,460,462,464,466,468,470,472,474,476,478,480,482,484,487,489,491,493,495
 dc.w 497,499,501,503,505,507,509,511,513,515,517


nste32
* G#5
 dc.w 2,4,7,9,11,13,15,17,20,22,24,26,28,31,33,35,37,39,41,44,46,48,50,52,55,57,59,61,63,66
 dc.w 68,70,72,74,76,79,81,83,85,87,90,92,94,96,98,100,103,105,107,109,111,114,116,118,120,122,124,127,129,131
 dc.w 133,135,138,140,142,144,146,149,151,153,155,157,159,162,164,166,168,170,173,175,177,179,181,183,186,188,190,192,194,197
 dc.w 199,201,203,205,207,210,212,214,216,218,221,223,225,227,229,232,234,236,238,240,242,245,247,249,251,253,256,258,260,262
 dc.w 264,266,269,271,273,275,277,280,282,284,286,288,290,293,295,297,299,301,304,306,308,310,312,315,317,319,321,323,325,328
 dc.w 330,332,334,336,339,341,343,345,347,349,352,354,356,358,360,363,365,367,369,371,373,376,378,380,382,384,387,389,391,393
 dc.w 395,397,400,402,404,406,408,411,413,415,417,419,422,424,426,428,430,432,435,437,439,441,443,446,448,450,452,454,456,459
 dc.w 461,463,465,467,470,472,474,476,478,480,483,485,487,489,491,494,496,498,500,502,505,507,509,511,513,515,518,520,522,524
 dc.w 526,529,531,533,535,537,539,542,544,546,548


nste33
* A5 
 dc.w 2,5,7,9,12,14,16,19,21,23,25,28,30,32,35,37,39,42,44,46,49,51,53,56,58,60,62,65,67,69
 dc.w 72,74,76,79,81,83,86,88,90,93,95,97,99,102,104,106,109,111,113,116,118,120,123,125,127,130,132,134,137,139
 dc.w 141,143,146,148,150,153,155,157,160,162,164,167,169,171,174,176,178,180,183,185,187,190,192,194,197,199,201,204,206,208
 dc.w 211,213,215,218,220,222,224,227,229,231,234,236,238,241,243,245,248,250,252,255,257,259,261,264,266,268,271,273,275,278
 dc.w 280,282,285,287,289,292,294,296,298,301,303,305,308,310,312,315,317,319,322,324,326,329,331,333,336,338,340,342,345,347
 dc.w 349,352,354,356,359,361,363,366,368,370,373,375,377,379,382,384,386,389,391,393,396,398,400,403,405,407,410,412,414,417
 dc.w 419,421,423,426,428,430,433,435,437,440,442,444,447,449,451,454,456,458,460,463,465,467,470,472,474,477,479,481,484,486
 dc.w 488,491,493,495,497,500,502,504,507,509,511,514,516,518,521,523,525,528,530,532,535,537,539,541,544,546,548,551,553,555
 dc.w 558,560,562,565,567,569,572,574,576,578,581


nste34
* A#5
 dc.w 2,5,7,10,12,15,17,20,22,25,27,29,32,34,37,39,42,44,47,49,51,54,56,59,61,64,66,69,71,74
 dc.w 76,78,81,83,86,88,91,93,96,98,101,103,105,108,110,113,115,118,120,123,125,127,130,132,135,137,140,142,145,147
 dc.w 150,152,154,157,159,162,164,167,169,172,174,177,179,181,184,186,189,191,194,196,199,201,203,206,208,211,213,216,218,221
 dc.w 223,226,228,230,233,235,238,240,243,245,248,250,253,255,257,260,262,265,267,270,272,275,277,279,282,284,287,289,292,294
 dc.w 297,299,302,304,306,309,311,314,316,319,321,324,326,328,331,333,336,338,341,343,346,348,351,353,355,358,360,363,365,368
 dc.w 370,373,375,378,380,382,385,387,390,392,395,397,400,402,404,407,409,412,414,417,419,422,424,427,429,431,434,436,439,441
 dc.w 444,446,449,451,454,456,458,461,463,466,468,471,473,476,478,480,483,485,488,490,493,495,498,500,503,505,507,510,512,515
 dc.w 517,520,522,525,527,530,532,534,537,539,542,544,547,549,552,554,556,559,561,564,566,569,571,574,576,579,581,583,586,588
 dc.w 591,593,596,598,601,603,606,608,610,613,615


nste35
* B5 
 dc.w 3,5,8,10,13,16,18,21,23,26,29,31,34,36,39,42,44,47,49,52,55,57,60,62,65,68,70,73,75,78
 dc.w 81,83,86,88,91,94,96,99,101,104,106,109,112,114,117,119,122,125,127,130,132,135,138,140,143,145,148,151,153,156
 dc.w 158,161,164,166,169,171,174,177,179,182,184,187,190,192,195,197,200,203,205,208,210,213,216,218,221,223,226,229,231,234
 dc.w 236,239,242,244,247,249,252,255,257,260,262,265,268,270,273,275,278,281,283,286,288,291,293,296,299,301,304,306,309,312
 dc.w 314,317,319,322,325,327,330,332,335,338,340,343,345,348,351,353,356,358,361,364,366,369,371,374,377,379,382,384,387,390
 dc.w 392,395,397,400,403,405,408,410,413,416,418,421,423,426,429,431,434,436,439,442,444,447,449,452,455,457,460,462,465,468
 dc.w 470,473,475,478,480,483,486,488,491,493,496,499,501,504,506,509,512,514,517,519,522,525,527,530,532,535,538,540,543,545
 dc.w 548,551,553,556,558,561,564,566,569,571,574,577,579,582,584,587,590,592,595,597,600,603,605,608,610,613,616,618,621,623
 dc.w 626,629,631,634,636,639,642,644,647,649,652


nste36
* C6
 dc.w 3,6,8,11,14,17,19,22,25,28,30,33,36,39,41,44,47,50,52,55,58,61,63,66,69,72,74,77,80,83
 dc.w 85,88,91,94,96,99,102,105,107,110,113,116,118,121,124,127,129,132,135,138,140,143,146,149,151,154,157,160,162,165
 dc.w 168,171,173,176,179,182,184,187,190,193,195,198,201,204,206,209,212,215,217,220,223,226,228,231,234,237,239,242,245,248
 dc.w 250,253,256,259,261,264,267,270,272,275,278,281,283,286,289,292,294,297,300,303,305,308,311,314,316,319,322,325,327,330
 dc.w 333,336,338,341,344,347,349,352,355,358,360,363,366,369,371,374,377,380,382,385,388,391,393,396,399,402,405,407,410,413
 dc.w 416,418,421,424,427,429,432,435,438,440,443,446,449,451,454,457,460,462,465,468,471,473,476,479,482,484,487,490,493,495
 dc.w 498,501,504,506,509,512,515,517,520,523,526,528,531,534,537,539,542,545,548,550,553,556,559,561,564,567,570,572,575,578
 dc.w 581,583,586,589,592,594,597,600,603,605,608,611,614,616,619,622,625,627,630,633,636,638,641,644,647,649,652,655,658,660
 dc.w 663,666,669,671,674,677,680,682,685,688,691


