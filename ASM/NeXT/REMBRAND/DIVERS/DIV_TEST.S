 move.l #5000,d0
 move.l #0,d1
 
 divul.l #3,d0:d1
 dcb 50,$4e71
    