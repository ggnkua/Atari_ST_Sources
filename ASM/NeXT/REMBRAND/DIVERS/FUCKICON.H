/* Indice du ressource pour FUCKICON */

#define FUCK_ICON 0   /* Formulaire/Dialogue */
