deb
 incbin "D:\GRAPHES\<_IMAGES.__>\IFF\quadri_7.iff"
fin
 dc.b "DBUG"
 dc.b "NEXT"
 dcb.b 5000,0
 