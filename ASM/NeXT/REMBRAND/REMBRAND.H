/* Indice du ressource pour REMBRAND */

#define menu_accessoires 0   /* Arbre menu */
#define titre_rembrandt 3   /* TITLE dans l'arbre MENU_ACCESSOIRES */
#define titre_fichier 4   /* TITLE dans l'arbre MENU_ACCESSOIRES */
#define titre_reglage 5   /* TITLE dans l'arbre MENU_ACCESSOIRES */
#define menu_a_propos_de 8   /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_charger 17  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_charger_com 18  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_sauver 20  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_sauver_sous 21  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_quitter 23  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_executer 25  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define fond_reglage 26  /* BOX dans l'arbre MENU_ACCESSOIRES */
#define menu_langage 27  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_preferences 29  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_memoire 30  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_drivers 31  /* STRING dans l'arbre MENU_ACCESSOIRES */
#define menu_sauve_prefs 33  /* STRING dans l'arbre MENU_ACCESSOIRES */

#define page_principale 1   /* Formulaire/Dialogue */
#define fonds    0   /* BOX dans l'arbre PAGE_PRINCIPALE */
#define sauver_fichier 1   /* BOXTEXT dans l'arbre PAGE_PRINCIPALE */
#define effacer_image 2   /* BOXTEXT dans l'arbre PAGE_PRINCIPALE */
#define dessiner 3   /* BOXTEXT dans l'arbre PAGE_PRINCIPALE */
#define reglage_image 4   /* BOXTEXT dans l'arbre PAGE_PRINCIPALE */
#define charger_fichier 5   /* BOXTEXT dans l'arbre PAGE_PRINCIPALE */
#define infos_image 6   /* BOXTEXT dans l'arbre PAGE_PRINCIPALE */
#define charger_par_type 7   /* BOXTEXT dans l'arbre PAGE_PRINCIPALE */

#define infos    2   /* Formulaire/Dialogue */
#define quitte_infos 1   /* BOXTEXT dans l'arbre INFOS */
#define plus_infos 3   /* BOXTEXT dans l'arbre INFOS */
#define copyright_infos 4   /* TEXT dans l'arbre INFOS */

#define shareware_info 3   /* Formulaire/Dialogue */
#define share_bouton 5   /* BOXTEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_1 6   /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_2 7   /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_3 8   /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_4 9   /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_5 10  /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_6 11  /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_7 12  /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_8 13  /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_9 14  /* TEXT dans l'arbre SHAREWARE_INFO */
#define share_txt_10 15  /* TEXT dans l'arbre SHAREWARE_INFO */

#define falcon_only 4   /* Formulaire/Dialogue */
#define retour_bureau 10  /* BUTTON dans l'arbre FALCON_ONLY */

#define pas_nvdi 5   /* Formulaire/Dialogue */

#define parametre_ecran 6   /* Formulaire/Dialogue */
#define txt_overscan 1   /* TEXT dans l'arbre PARAMETRE_ECRAN */
#define txt_dbl_hauteur 2   /* TEXT dans l'arbre PARAMETRE_ECRAN */
#define txt_dbl_largeur 3   /* TEXT dans l'arbre PARAMETRE_ECRAN */
#define double_largeur 4   /* BUTTON dans l'arbre PARAMETRE_ECRAN */
#define overscan 5   /* BUTTON dans l'arbre PARAMETRE_ECRAN */
#define double_hauteur 6   /* BUTTON dans l'arbre PARAMETRE_ECRAN */
#define confirme_params 7   /* BOXTEXT dans l'arbre PARAMETRE_ECRAN */
#define annule_params 8   /* BOXTEXT dans l'arbre PARAMETRE_ECRAN */
#define resolution_ecran 9   /* BOXTEXT dans l'arbre PARAMETRE_ECRAN */
#define type_moniteur 11  /* TEXT dans l'arbre PARAMETRE_ECRAN */
#define update_tailles 13  /* BOX dans l'arbre PARAMETRE_ECRAN */
#define x_resolution 14  /* FBOXTEXT dans l'arbre PARAMETRE_ECRAN */
#define y_resolution 15  /* FBOXTEXT dans l'arbre PARAMETRE_ECRAN */
#define taille_image 16  /* TEXT dans l'arbre PARAMETRE_ECRAN */

#define info_image 7   /* Formulaire/Dialogue */
#define inf_confirme 1   /* BOXTEXT dans l'arbre INFO_IMAGE */
#define inf_annule 2   /* BOXTEXT dans l'arbre INFO_IMAGE */
#define inf_texte_1 4   /* FTEXT dans l'arbre INFO_IMAGE */
#define inf_texte_2 5   /* FTEXT dans l'arbre INFO_IMAGE */
#define inf_texte_3 6   /* FTEXT dans l'arbre INFO_IMAGE */
#define inf_numero_image 7   /* FTEXT dans l'arbre INFO_IMAGE */
#define inf_texte_4 8   /* FTEXT dans l'arbre INFO_IMAGE */
#define inf_nom_image 10  /* FTEXT dans l'arbre INFO_IMAGE */

#define redimensionne 8   /* Formulaire/Dialogue */
#define adapte_taille 1   /* BOXTEXT dans l'arbre REDIMENSIONNE */
#define annule_taille 2   /* BOXTEXT dans l'arbre REDIMENSIONNE */
#define confirme_taille 3   /* BOXTEXT dans l'arbre REDIMENSIONNE */
#define sauve_et_efface 4   /* BOXTEXT dans l'arbre REDIMENSIONNE */

#define preference 9   /* Formulaire/Dialogue */
#define ok_preferences 3   /* BOXTEXT dans l'arbre PREFERENCE */
#define non_preferences 4   /* BOXTEXT dans l'arbre PREFERENCE */
#define pref_backup 5   /* BUTTON dans l'arbre PREFERENCE */
#define pref_shrink_box 6   /* BUTTON dans l'arbre PREFERENCE */
#define pref_maj_palette 8   /* BUTTON dans l'arbre PREFERENCE */

#define regle_memoire 10  /* Formulaire/Dialogue */
#define confirmer 1   /* BOXTEXT dans l'arbre REGLE_MEMOIRE */
#define annuler  2   /* BOXTEXT dans l'arbre REGLE_MEMOIRE */
#define mthodepourla 18  /* TEXT dans l'arbre REGLE_MEMOIRE */

#define format_sauve 11  /* Formulaire/Dialogue */
#define sauve_tga_16bit 1   /* TEXT dans l'arbre FORMAT_SAUVE */
#define sauve_tcp 2   /* TEXT dans l'arbre FORMAT_SAUVE */
#define sauve_annule 3   /* BOXTEXT dans l'arbre FORMAT_SAUVE */
#define sauve_confirme 4   /* BOXTEXT dans l'arbre FORMAT_SAUVE */
#define sauve_coke 5   /* TEXT dans l'arbre FORMAT_SAUVE */
#define sauve_tga_24bit 9   /* TEXT dans l'arbre FORMAT_SAUVE */

#define choix_driver 12  /* Formulaire/Dialogue */
#define confirme_rim 1   /* BOXTEXT dans l'arbre CHOIX_DRIVER */
#define fonds_scrolling 2   /* BOX dans l'arbre CHOIX_DRIVER */
#define rim_monte 3   /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_1 4   /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_2 5   /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_3 6   /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_4 7   /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_5 8   /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_6 9   /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_7 10  /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_8 11  /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_9 12  /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_10 13  /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_11 14  /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_12 15  /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_13 16  /* TEXT dans l'arbre CHOIX_DRIVER */
#define titre_rim_14 17  /* TEXT dans l'arbre CHOIX_DRIVER */
#define rim_descend 18  /* TEXT dans l'arbre CHOIX_DRIVER */
#define annuler_rim 19  /* BOXTEXT dans l'arbre CHOIX_DRIVER */

#define chargement_image 13  /* Formulaire/Dialogue */
#define chargement_quoi 1   /* TEXT dans l'arbre CHARGEMENT_IMAGE */
#define chargement_form 2   /* TEXT dans l'arbre CHARGEMENT_IMAGE */
#define chargement_nom 3   /* TEXT dans l'arbre CHARGEMENT_IMAGE */

#define sauvegarde_image 14  /* Formulaire/Dialogue */

#define charge_driver 15  /* Formulaire/Dialogue */

#define hierarchique 16  /* Formulaire/Dialogue */
#define back_langue 1   /* BOX dans l'arbre HIERARCHIQUE */
#define menu_francais 2   /* STRING dans l'arbre HIERARCHIQUE */
#define menu_anglais 3   /* STRING dans l'arbre HIERARCHIQUE */
#define menu_allemand 4   /* STRING dans l'arbre HIERARCHIQUE */
#define menu_espagnol 5   /* STRING dans l'arbre HIERARCHIQUE */
#define menu_italien 6   /* STRING dans l'arbre HIERARCHIQUE */
