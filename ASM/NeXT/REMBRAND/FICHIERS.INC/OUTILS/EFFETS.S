 TEXT
 
routine_effet_assombrir
routine_effet_Вclaicir
routine_effet_nВgatif
routine_effet_hflou
routine_effet_gflou
routine_effet_gris
 bsr boite_alerte
 rts
