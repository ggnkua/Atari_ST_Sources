; Fichier g‚n‚r‚ automatiquement: Ne rien toucher !!!

;########### Nouvel arbre dans la ressource:
arbre_menu_accessoires	EQU 0
objet_titre_rembrandt	EQU 3
objet_titre_fichier	EQU 4
objet_titre_reglage	EQU 5
objet_menu_a_propos_de	EQU 8
objet_menu_charger	EQU 17
objet_menu_charger_com	EQU 18
objet_menu_sauver	EQU 20
objet_menu_sauver_sous	EQU 21
objet_menu_quitter	EQU 23
objet_menu_executer	EQU 25
objet_fond_reglage	EQU 26
objet_menu_langage	EQU 27
objet_menu_preferences	EQU 29
objet_menu_memoire	EQU 30
objet_menu_drivers	EQU 31
objet_menu_sauve_prefs	EQU 33

;########### Nouvel arbre dans la ressource:
arbre_page_principale	EQU 1
objet_fonds	EQU 0
objet_sauver_fichier	EQU 1
objet_effacer_image	EQU 2
objet_dessiner	EQU 3
objet_reglage_image	EQU 4
objet_charger_fichier	EQU 5
objet_infos_image	EQU 6
objet_charger_par_type	EQU 7

;########### Nouvel arbre dans la ressource:
arbre_infos	EQU 2
objet_quitte_infos	EQU 1
objet_plus_infos	EQU 3
objet_copyright_infos	EQU 4

;########### Nouvel arbre dans la ressource:
arbre_shareware_info	EQU 3
objet_share_bouton	EQU 5
objet_share_txt_1	EQU 6
objet_share_txt_2	EQU 7
objet_share_txt_3	EQU 8
objet_share_txt_4	EQU 9
objet_share_txt_5	EQU 10
objet_share_txt_6	EQU 11
objet_share_txt_7	EQU 12
objet_share_txt_8	EQU 13
objet_share_txt_9	EQU 14
objet_share_txt_10	EQU 15

;########### Nouvel arbre dans la ressource:
arbre_falcon_only	EQU 4
objet_retour_bureau	EQU 10

;########### Nouvel arbre dans la ressource:
arbre_pas_nvdi	EQU 5

;########### Nouvel arbre dans la ressource:
arbre_parametre_ecran	EQU 6
objet_txt_overscan	EQU 1
objet_txt_dbl_hauteur	EQU 2
objet_txt_dbl_largeur	EQU 3
objet_double_largeur	EQU 4
objet_overscan	EQU 5
objet_double_hauteur	EQU 6
objet_confirme_params	EQU 7
objet_annule_params	EQU 8
objet_resolution_ecran	EQU 9
objet_type_moniteur	EQU 11
objet_update_tailles	EQU 13
objet_x_resolution	EQU 14
objet_y_resolution	EQU 15
objet_taille_image	EQU 16

;########### Nouvel arbre dans la ressource:
arbre_info_image	EQU 7
objet_inf_confirme	EQU 1
objet_inf_annule	EQU 2
objet_inf_texte_1	EQU 4
objet_inf_texte_2	EQU 5
objet_inf_texte_3	EQU 6
objet_inf_numero_image	EQU 7
objet_inf_texte_4	EQU 8
objet_inf_nom_image	EQU 10

;########### Nouvel arbre dans la ressource:
arbre_redimensionne	EQU 8
objet_adapte_taille	EQU 1
objet_annule_taille	EQU 2
objet_confirme_taille	EQU 3
objet_sauve_et_efface	EQU 4

;########### Nouvel arbre dans la ressource:
arbre_preference	EQU 9
objet_ok_preferences	EQU 3
objet_non_preferences	EQU 4
objet_pref_backup	EQU 5
objet_pref_shrink_box	EQU 6
objet_pref_maj_palette	EQU 8

;########### Nouvel arbre dans la ressource:
arbre_regle_memoire	EQU 10
objet_confirmer	EQU 1
objet_annuler	EQU 2
objet_mthodepourla	EQU 18

;########### Nouvel arbre dans la ressource:
arbre_format_sauve	EQU 11
objet_sauve_tga_16bit	EQU 1
objet_sauve_tcp	EQU 2
objet_sauve_annule	EQU 3
objet_sauve_confirme	EQU 4
objet_sauve_coke	EQU 5
objet_sauve_tga_24bit	EQU 9

;########### Nouvel arbre dans la ressource:
arbre_choix_driver	EQU 12
objet_confirme_rim	EQU 1
objet_fonds_scrolling	EQU 2
objet_rim_monte	EQU 3
objet_titre_rim_1	EQU 4
objet_titre_rim_2	EQU 5
objet_titre_rim_3	EQU 6
objet_titre_rim_4	EQU 7
objet_titre_rim_5	EQU 8
objet_titre_rim_6	EQU 9
objet_titre_rim_7	EQU 10
objet_titre_rim_8	EQU 11
objet_titre_rim_9	EQU 12
objet_titre_rim_10	EQU 13
objet_titre_rim_11	EQU 14
objet_titre_rim_12	EQU 15
objet_titre_rim_13	EQU 16
objet_titre_rim_14	EQU 17
objet_rim_descend	EQU 18
objet_annuler_rim	EQU 19

;########### Nouvel arbre dans la ressource:
arbre_chargement_image	EQU 13
objet_chargement_quoi	EQU 1
objet_chargement_form	EQU 2
objet_chargement_nom	EQU 3

;########### Nouvel arbre dans la ressource:
arbre_sauvegarde_image	EQU 14

;########### Nouvel arbre dans la ressource:
arbre_charge_driver	EQU 15

;########### Nouvel arbre dans la ressource:
arbre_hierarchique	EQU 16
objet_back_langue	EQU 1
objet_menu_francais	EQU 2
objet_menu_anglais	EQU 3
objet_menu_allemand	EQU 4
objet_menu_espagnol	EQU 5
objet_menu_italien	EQU 6

 TEXT

initialise_ressource
 lea liste_arbres,a0
.loop
 move (a0)+,d0
 bmi.s .fin_boucle
 move.l (a0)+,a1
 movem.l a0/a1,-(sp)
 rsrc_gaddr #0,d0
 move.l addr_out,(a1)
 bsr transforme_formulaire
 movem.l (sp)+,a0/a1
 bra.s .loop
.fin_boucle
 rts

 DATA

 even

liste_arbres
 dc.w arbre_menu_accessoires
 dc.l ptr_menu_accessoires
 dc.w arbre_page_principale
 dc.l ptr_page_principale
 dc.w arbre_infos
 dc.l ptr_infos
 dc.w arbre_shareware_info
 dc.l ptr_shareware_info
 dc.w arbre_falcon_only
 dc.l ptr_falcon_only
 dc.w arbre_pas_nvdi
 dc.l ptr_pas_nvdi
 dc.w arbre_parametre_ecran
 dc.l ptr_parametre_ecran
 dc.w arbre_info_image
 dc.l ptr_info_image
 dc.w arbre_redimensionne
 dc.l ptr_redimensionne
 dc.w arbre_preference
 dc.l ptr_preference
 dc.w arbre_regle_memoire
 dc.l ptr_regle_memoire
 dc.w arbre_format_sauve
 dc.l ptr_format_sauve
 dc.w arbre_choix_driver
 dc.l ptr_choix_driver
 dc.w arbre_chargement_image
 dc.l ptr_chargement_image
 dc.w arbre_sauvegarde_image
 dc.l ptr_sauvegarde_image
 dc.w arbre_charge_driver
 dc.l ptr_charge_driver
 dc.w arbre_hierarchique
 dc.l ptr_hierarchique
 dc.w -1


 BSS

 even
ptr_menu_accessoires ds.l 1
ptr_page_principale ds.l 1
ptr_infos ds.l 1
ptr_shareware_info ds.l 1
ptr_falcon_only ds.l 1
ptr_pas_nvdi ds.l 1
ptr_parametre_ecran ds.l 1
ptr_info_image ds.l 1
ptr_redimensionne ds.l 1
ptr_preference ds.l 1
ptr_regle_memoire ds.l 1
ptr_format_sauve ds.l 1
ptr_choix_driver ds.l 1
ptr_chargement_image ds.l 1
ptr_sauvegarde_image ds.l 1
ptr_charge_driver ds.l 1
ptr_hierarchique ds.l 1

