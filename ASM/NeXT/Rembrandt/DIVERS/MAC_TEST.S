tagada=1

zap macro
 move #\1,d0
 endm
 
 nop
 nop
 nop
 
 zap tagada