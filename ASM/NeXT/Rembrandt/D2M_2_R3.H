/* Indice du ressource pour D2M_2_R3 */

#define FORM36   0   /* Formulaire/Dialogue */
