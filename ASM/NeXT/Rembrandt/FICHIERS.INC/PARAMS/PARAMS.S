; REMBRANDT 3.0 - ╜  Dbug II
;
; Module de gestion du fichier de paramВtrage. (1.1)
;

 ifeq _main_part
 <pREMB_xxx.S>q doit Иtre assemblВ !!!
 END
 endc
 
 section TEXT

mВmorise_chemin_rembrandt
 move.l adresse_basepage,a0
 move.l $24(a0),a0		-> Page de base du pКre (le bureau...)
 move.l $7C(a0),a0		-> Ligne de commande du pКre
 move.l $36(a0),a0		??? Chemin d'accКs au fils... (Mwai... enfin, ca marche !)

 lea chemin_paramВtrage,a1
 move.l a1,a2
.recopie
 move.b (a0)+,(a1)+
 bne.s .recopie
.ote_extension
 move.b -(a1),d0
 cmp.b #"\",d0
 beq .fin_recherche
 cmp.b #":",d0
 beq .fin_recherche
 cmp.l a2,a1
 bne.s .ote_extension   
.fin_recherche 
 clr.b 1(a1)
 rts

;%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
;%%                                                     %%
;%%  Chargement du fichier de paramВtrage REMBRAND.INF  %%
;%%                                                     %%
;%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%

charge_paramВtrage_image
 ifeq debug
 lea chemin_fichier,a0		En procВdant ainsi, on peut rВutiliser le
 lea chemin_paramВtrage,a1	meme chemin pour charger et sauver.
 bsr copie_chaine_texte
 subq #1,a1			On efface le zВro final...
 move.l #'REMB',(a1)+
 move.l #'RAND',(a1)+
 move.l #'.INF',(a1)+
 clr.b (a1)+			...et on le rajoute Е la fin.

* fsel_exinput #chemin_paramВtrage,#nom_fichier,#txt_chargement_par_nom
   
 move #1,-(sp)			Ouvre le fichier REMBRAND.INF
 pea chemin_paramВtrage		en lecture avec FOpen
 move #$3d,-(sp)
 trap #1
 addq #8,sp
 tst d0
 bmi .erreur
 move d0,handle

 pea paramВtrage_dВbut		Lecture des informations
 pea longueur_paramВtrage	du fichier de paramВtrage.
 move handle,-(sp)
 move #$3f,-(sp)
 trap #1
 lea 12(sp),sp
 tst.l d0
 bmi .erreur

 move handle,-(sp)	Fermeture du fichier de paramВtrage
 move #$3e,-(sp)	Normalement, il ne devrait pas y avoir
 trap #1		d'erreur !
 addq #4,sp
 tst d0
 beq .pas_erreur
.erreur

* boite_alerte #1,#alert_charge_paramВtrage	On emmerde pas !
.pas_erreur
 endc
 
***** Maintenant, il faut transfВrer ces paramВtrages dans les variables 
***** de travail standard.

 move.b paramВtrage_overscan,flag_overscan
 move.b paramВtrage_double_largeur,flag_double_largeur
 move.b paramВtrage_double_hauteur,flag_double_hauteur
 move.b paramВtrage_shrink_box,flag_shrink_box
 move.b paramВtrage_format_pic,flag_format_pic
 move.b paramВtrage_fileselect,flag_fileselect
 move.b paramВtrage_recopier_palette,flag_recopier_palette
 move paramВtrage_largeur_image,largeur_image
 move paramВtrage_hauteur_image,hauteur_image
 move.w paramВtrage_format_chargement,format_dВfaut_chargement
 move.w paramВtrage_format_sauvegarde,format_dВfaut_sauvegarde

 move largeur_image,d0
 mulu hauteur_image,d0
 move.l d0,taille_image
 bsr valide_paramВtrages
 rts

;%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%
;%%                                                     %%
;%%  Sauvegarde du fichier de paramВtrage REMBRAND.INF  %%
;%%                                                     %%
;%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%%

sauve_paramВtrage_image
 lea paramВtrage_dВbut,a0	Il faut mettre Е jour la ligne d'info, sinon
 move.l #'Remb',(a0)+		on ne saura pas de quelle version vient ce
 move.l #'rand',(a0)+		fichier de sauvegarde...
 move.l #'t V3',(a0)+
 move.l #'.06 ',(a0)+
 move.l #'с Fr',(a0)+

***** Avant de sauver, on rВcupКre les informations de travail standard.

 move.b flag_overscan,paramВtrage_overscan
 move.b flag_double_largeur,paramВtrage_double_largeur
 move.b flag_double_hauteur,paramВtrage_double_hauteur
 move.b flag_shrink_box,paramВtrage_shrink_box
 move.b flag_format_pic,paramВtrage_format_pic
 move.b flag_fileselect,paramВtrage_fileselect
 move.b flag_recopier_palette,paramВtrage_recopier_palette
 move.w format_dВfaut_chargement,paramВtrage_format_chargement
 move.w format_dВfaut_sauvegarde,paramВtrage_format_sauvegarde
 move largeur_image,paramВtrage_largeur_image
 move hauteur_image,paramВtrage_hauteur_image

 move #0,-(sp)			Ouvre le fichier REMBRAND.INF
 pea chemin_paramВtrage		en Вcriture avec FCrВate
 move #$3c,-(sp)
 trap #1
 addq #8,sp
 tst d0
 bmi .erreur
 move d0,handle

 pea paramВtrage_dВbut		Рcriture des informations
 pea longueur_paramВtrage	dans le fichier de paramВtrage.
 move handle,-(sp)
 move #$40,-(sp)
 trap #1
 lea 12(sp),sp
 tst.l d0
 bmi .erreur

 move handle,-(sp)	Fermeture du fichier de paramВtrage
 move #$3e,-(sp)	Normalement, il ne devrait pas y avoir
 trap #1		d'erreur !
 addq #4,sp
 tst d0
 bmi .erreur   
 rts
  
.erreur 
 boite_alerte #1,#alert_sauve_paramВtrage
 rts


	DATA
	  
; Format du fichier de paramВtrage de Rembrandt.
;     12345678901234567890
; .b "Rembrandt V3.05 с Fr" 20 CaractКres d'information
; .w Drapeau Overscan On/Off (IgnorВ en mode VGA)
; .w Drapeau rВsolution doublВe (InterlacВ en RVB-Simple ligne en VGA)
; .w RВsolution en X
; .w RВsolution en Y
; .w Drapeau GROW/SHRINK BOX
; .w Drapeau de choix des fichiers (par un type dВfini/par l'extension)
;
paramВtrage_dВbut
 dc.b "Rembrandt V3.06 с Fr"
paramВtrage_overscan
 dc.w 0				Pas d'overscan
paramВtrage_double_largeur
 dc.w 0				Simple largeur (40 colonnes)
paramВtrage_double_hauteur
 dc.w 0				Simple hauteur (200 lignes non interlacВes)
paramВtrage_largeur_image
 dc.w 320*2
paramВtrage_hauteur_image
 dc.w 200
paramВtrage_shrink_box
 dc.w 0				Pas d'animation GROW/SHRINK BOX
paramВtrage_format_pic
 dc.w 0				Mode 'type de fichier' par dВfaut.
paramВtrage_fileselect
 dc.w 0				On utilise le FileSelector du systКme
paramВtrage_format_chargement
 dc.w 0				Par dВfaut, on charge le GIF
paramВtrage_format_sauvegarde
 dc.w objet_sauve_tcp		Mais on sauve en mode TCP
paramВtrage_recopier_palette
 dc.w 0




longueur_paramВtrage=*-paramВtrage_dВbut
