***** Alertes concernant le module {DISK_OPS.S}

 even
alert_ok
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Ok, routine acced‚e !!!]"
 dc.b "[Continuer]",0
.anglais
 dc.b "[1][Ok, routine accessed !!!]"
 dc.b "[Continue]",0
.allemand
 dc.b "[1][Ok, routine accessed !!!]"
 dc.b "[Ja...]",0


 even
alert_manque_chunk
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Ce fichier est incomplet !|Il manque des CHUNKS.]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][Uncomplete file !| Missing CHUNKS.]"
 
.allemand


 even
alert_fichier_non_trouve
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Je ne trouve pas ce fichier|sur le disk]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][I can't locate this file|on the specified drive]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][I can't locate this file|on the specified drive]"
 dc.b "[Abbruch]",0


 even
alert_mauvaise_extension
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][L'extension de ce fichier|"
 dc.b "ne figure pas parmis les|"
 dc.b "formats connus.]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][I don't know the file|"
 dc.b "corresponding to this|"
 dc.b "extension.]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][I don't know the file|"
 dc.b "corresponding to this|"
 dc.b "extension.]"
 dc.b "[Abbruch]",0


 even
alert_ouverture_impossible
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Impossible d'ouvrir ce fichier !!!]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][It's impossible to open this file !!!]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][It's impossible to open this file !!!]"
 dc.b "[Abbruch]",0


 even
alert_durant_lecture
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Impossible de lire ce fichier !!!]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][It's impossible to read this file !!!]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][It's impossible to read this file !!!]"
 dc.b "[Abbruch]",0


 even
alert_fermeture_impossible
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Impossible de fermer ce fichier !!!]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][It's impossible to close this file !!!]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][It's impossible to close this file !!!]"
 dc.b "[Abbruch]",0




 even
alert_m‚moire_d‚packing
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Il n'y a plus assez de m‚moire|pour d‚compacter ce fichier !]" 
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][There isn't enough memory|for unpacking this file !]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][There isn't enough memory|for unpacking this file !]"
 dc.b "[Abruch]",0


 even
alert_compactage_inconnu
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][La m‚thode de compactage|"
 dc.b "de ce fichier est inconnue.]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][This file was packed|"
 dc.b "using an unknow method.]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][This file was packed|"
 dc.b "using an unknow method.]"
 dc.b "[Abruch]",0


 even 
alert_prism_pack‚
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][PAck‚ !!!!][GASP]",0
.anglais
 dc.b "[1][Packed !!!][GOSH]",0
.allemand
 dc.b "[1][Packen !!!][Arsh]",0
 
 
 even
alert_format_chargement
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][L'image charg‚e ne correspond|"
 dc.b "pas au format sp‚cifi‚.]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][This picture isn't of the|"
 dc.b "specified file format.]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][This picture isn't of the|"
 dc.b "specified file format.]"
 dc.b "[Abruch]",0

 
 even
alert_format_non_impl‚ment‚
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Erreur interne:|"
 dc.b "M‚thode de chargement non|"
 dc.b "encore impl‚ment‚e !!!]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[1][Internal error:|"
 dc.b "Loading method not|"
 dc.b "yet implemented !!!]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[1][Internal error:|"
 dc.b "Loading method not|"
 dc.b "yet implemented !!!]"
 dc.b "[Abruch]",0


 even
alert_m‚moire_chargement
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[3][Il n'y a pas suffisament de|"
 dc.b "m‚moire pour proc‚der au|"
 dc.b "chargement de cette image]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[3][There isn't enoough memory|"
 dc.b "for loading this picture]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[3][There isn't enoough memory|"
 dc.b "for loading this picture]"
 dc.b "[Abruch]",0


 even
alert_m‚moire_sauvegarde
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[3][Il n'y a pas suffisament de|"
 dc.b "m‚moire pour proc‚der … la|"
 dc.b "sauvegarde de cette image]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[3][There isn't enough memory|"
 dc.b "for saving this picture]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[3][There isn't enough memory|"
 dc.b "for saving this picture]"
 dc.b "[Abruch]",0


 even
alert_couleurs_exportation
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[3][Cette image est compos‚e de|"
 dc.b "plus de 256 teintes. Il m'est|"
 dc.b "impossible de l'exporter...]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[3][There are more than 256 colors.|"
 dc.b "Exportation is impossible...]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[3][There are more than 256 colors.|"
 dc.b "Exportation is impossible...]"
 dc.b "[Abruch]",0


 even
alert_disk_plein
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[3][Il n'y a pas suffisament de|"
 dc.b "place sur ce disk pour|"
 dc.b "proc‚der … la sauvegarde|"
 dc.b "de cette image]"
 dc.b "[Annuler]",0
.anglais
 dc.b "[3][Disk full.]"
 dc.b "[Cancel]",0
.allemand
 dc.b "[3][Disk full.]"
 dc.b "[Abruch]",0


 even
alert_rim_absent
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[3][Il n'y a pas de fichiers RIM|"
 dc.b "dans le r‚pertoire sp‚cifi‚:|"
 dc.b "V‚rifiez le chemin d'accŠs.]"
 dc.b "[Continuer]",0
.anglais
 dc.b "[3][There are'nt any RIM|"
 dc.b "in the specified folder:|"
 dc.b "Control acces path.]"
 dc.b "[Continue]",0
.allemand
 dc.b "[3][There are'nt any RIM|"
 dc.b "in the specified folder:|"
 dc.b "Control acces path.]"
 dc.b "[Continue]",0


 even
alert_rim_m‚moire
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[3][Il n'y a pas assez de m‚moire|"
 dc.b "pour charger les fichiers RIM.]"
 dc.b "[Continuer]",0
.anglais
 dc.b "[3][There isn't enough memory|"
 dc.b "for loading RIM drivers.]"
 dc.b "[Continue]",0
.allemand
 dc.b "[3][There isn't enough memory|"
 dc.b "for loading RIM drivers.]"
 dc.b "[Continue]",0


 even
alert_rim_chargement
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[3][Une erreur est survenue durant|"
 dc.b "le chargement des fichiers RIM:||"
 dc.b "L'op‚ration est annul‚e.]"
 dc.b "[Continuer]",0
.anglais
 dc.b "[3][Error while loading RIM]"
 dc.b "[Continue]",0 
.allemand
 dc.b "[3][Error while loading RIM]"
 dc.b "[Continue]",0 


 even
alert_rim_pas_charg‚s 
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Les drivers RIM ne sont pas|"
 dc.b "pr‚sents en m‚moire. Utilisez la|"
 dc.b "boite de pr‚f‚rences pour y|"
 dc.b "rem‚dier.]"
 dc.b "[Continuer]",0
.anglais
 dc.b "[1][No RIM drivers in memory.|"
 dc.b "Use preferences...]"
 dc.b "[Continue]",0
.allemand
 dc.b "[1][No RIM drivers in memory.|"
 dc.b "Use preferences...]"
 dc.b "[Continue]",0


 even
alert_infos_rim
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
 dc.b "[1][Informations sur le driver:|"
 dc.b "Nom: Degas Elite|"
 dc.b "Num‚ro de version: 1.02|"
 dc.b "Taille en octets: 672|"
 dc.b "Nom du fichier: DEGAS.RIM]"
 dc.b "[Charger|Changer|Annuler]",0  
.anglais
 dc.b "[1][Informations sur le driver:|"
 dc.b "Nom: Degas Elite|"
 dc.b "Num‚ro de version: 1.02|"
 dc.b "Taille en octets: 672|"
 dc.b "Nom du fichier: DEGAS.RIM]"
 dc.b "[Charger|Changer|Annuler]",0  
.allemand
 dc.b "[1][Informations sur le driver:|"
 dc.b "Nom: Degas Elite|"
 dc.b "Num‚ro de version: 1.02|"
 dc.b "Taille en octets: 672|"
 dc.b "Nom du fichier: DEGAS.RIM]"
 dc.b "[Charger|Changer|Annuler]",0  


 even
alert_nombre_rim
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
.anglais
.allemand
 dc.b "[3]["
adresse_nombre_rim
 dc.b "            |"
 dc.b "Drivers RIM localis‚s]"
 dc.b "[Waouh !]",0


 even
alert_image_non_reconnue
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
.anglais
.allemand
 dc.b "[1][Le RIM s‚lectionn‚ n'a pas|"
 dc.b "r‚ussi … identifier l'image|"
 dc.b "choisie.]"
 dc.b "[D‚sol‚]",0


 even 
alert_image_reconnue_1
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
.anglais
.allemand
 dc.b "[1][L'image a ‚t‚ reconnue|"
 dc.b "par le driver RIM choisi.|"
 dc.b "(avec une palette...)]" 
 dc.b "[Okkkai !!!]",0

 even 
alert_image_reconnue_2
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
.anglais
.allemand
 dc.b "[1][L'image a ‚t‚ reconnue|"
 dc.b "par le driver RIM choisi.|"
 dc.b "(sans palette...)]" 
 dc.b "[Okkkai !!!]",0

 even
alert_pas_asser_info
 dc.l .fran‡ais
 dc.l .anglais
 dc.l .allemand
.fran‡ais
.anglais
.allemand
 dc.b "[1][Le RIM d‚clare qu'il|"
 dc.b "n'a pas asser d'infos !!!|"
 dc.b "(Y'a un gros BUG !!!)]" 
 dc.b "[Gasp...]",0
