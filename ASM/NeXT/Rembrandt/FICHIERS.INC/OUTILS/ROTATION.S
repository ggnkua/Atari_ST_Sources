 TEXT
 
routine_rotation_90gauche
routine_rotation_90droite
routine_rotation_vflip
routine_rotation_hflip
 bsr boite_alerte
 rts 
