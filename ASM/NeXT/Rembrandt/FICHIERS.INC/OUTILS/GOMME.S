 TEXT
 
routine_gomme_fine
routine_gomme_moyenne
 bsr boite_alerte
 rts
