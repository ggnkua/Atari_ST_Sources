
#define	FORM1	    0

#define HEAR	    2
#define blocs	    3
#define finfoin	    4
#define TAILLEIN	    5
#define OFFSETIN	    6
#define lenghtloo	    7
#define numeroin	    8
#define nameint	    9
#define volume_inf	   10
#define numeromax	   11
#define volume	   12
#define sam	   13
#define filter	   14
#define setfreq	   15
#define load_sample	   20
#define save_sample	   21
#define next_instr	   22
#define end_instr	   23

#define	FORM2	    1


#define	FORM3	    2


#define	FORM4	    3

#define FREQ0	    4
#define FREQ5	    5
#define FREQ1	    6
#define FREQ6	    7
#define FREQ2	    8
#define FREQ7	    9
#define FREQ3	   10
#define FREQ8	   11
#define FREQ4	   12
#define FREQ9	   13

#define	FORM5	    4


#define	SPEED	    5

#define VITEEDIT	    3
#define exitspeed	    4

#define	PITCH	    6

#define exitsplit	    2
#define canalmoi	    3
#define CHALMIDI	    5
#define CANALPLU	    7
#define LOADPITCH	    8
#define SAVEPITCH	    9
#define LINSTRUM	   10
#define MIDINoteInstT	   11
#define D3	   13
#define C_3	   14
#define F3	   15
#define E3	   16
#define d_3	   17
#define f_3	   18
#define G3	   19
#define g_3	   20
#define A3	   21
#define E4	   22
#define F4	   23
#define f_4	   24
#define D_4	   25
#define G4	   26
#define d4	   27
#define C_4	   28
#define c4	   29
#define B3	   30
#define a_3	   31
#define g_4	   32
#define A4	   33
#define a_4	   34
#define B4	   35
#define C5	   36
#define c_5	   37
#define D5	   38
#define d_5	   39
#define E5	   40
#define F5	   41
#define f_5	   42
#define G_5	   43
#define g5	   44
#define A5	   45
#define a_5	   46
#define B5	   47
#define C6	   48
#define c3	   49
#define af_def_track	   87
#define DEFTRACK	   89
#define DEFTRACKP	   90
#define DEFTRACKM	   91
#define af_def_note	   92
#define mi_st_p	   94
#define mi_st_m	   95
#define mi_st	   96
#define tnoteoff	   97

#define	MIDI	    7

#define RECSTART	    3
#define RECCANC	    4
#define PATCHGO	    5
#define INSNA	    6
#define VELOCITY	    7
#define SPEEDGO	    8
#define PATTREC	    9
#define MODULATI	   10
#define PITCHBEN	   11

#define	INSTRUM	    8

#define NBIM	    4
#define exitins0	    5
#define exitins1	    6
#define inedit	    8
#define INPLUS	   10
#define NBCOUR	   12
#define INMOIN	   13

#define	PATTERN	    9

#define exitpattern	    2
#define posmod	    7
#define patmod	    8
#define POSPLUS	    9
#define POSMOIN	   10
#define patplus	   11
#define patmoin	   12
#define patnum	   13
#define posnumb	   14
#define recposstart	   15
#define recposmoin	   16
#define recposplus	   17
#define recposend	   19
#define recposendmoin	   20
#define recposendplus	   21
#define clearpos	   22
#define confsaisi	   23
#define savepos	   24
#define loadpos	   25

#define	MIDI_REC	   10

#define midi_edit	   17
#define midi_rec_sync	   24
#define exit_rec	   29
#define start_midi_rec	   32

#define	first_loading	   11

#define fmusname	    5
#define fpat	    6
#define finstrument	    7
#define fposition	    8
#define fpattern	    9
#define fspeed	   10
#define frestart	   11

#define	saving	   12

#define spat	    6
#define spos	    7
#define sin	    8
#define slenpat	    9
#define slenpos	   10
#define slenin	   11
#define stotallen	   12
#define smusname	   13
#define sspeed	   14
#define srestart	   15
#define bsmod	   18
#define bslow	   19
#define save_mod	   24
#define cancel_save_mod	   25

#define	saving_mod	   13

#define trace_operation	    2
#define operation	    4
#define line1	    6
#define line2	    7
#define line3	    8
#define line4	    9
#define line5	   10
#define line6	   11
#define line7	   12
#define line8	   13
#define line9	   14
#define line10	   15
#define line11	   16
#define line12	   17
#define line13	   18
