couleurs
 rept 2
;
; Un petit rouge ?
;
 dc.w $555,$544,$533,$522,$522,$522,$522,$500,$555,$544,$533,$522,$522,$522,$522,$500
 dc.w $544,$500,$500,$500,$500,$500,$500,$200,$544,$500,$500,$500,$500,$500,$500,$200
 dc.w $533,$500,$500,$500,$500,$500,$500,$200,$533,$500,$500,$500,$500,$500,$500,$200
 dc.w $522,$500,$500,$500,$500,$500,$500,$200,$522,$500,$500,$500,$500,$500,$500,$200
 dc.w $522,$500,$500,$500,$500,$500,$500,$200,$522,$500,$500,$500,$500,$500,$500,$200
 dc.w $522,$500,$500,$500,$500,$500,$500,$200,$522,$500,$500,$500,$500,$500,$500,$200
 dc.w $522,$500,$500,$500,$500,$500,$500,$200,$522,$500,$500,$500,$500,$500,$500,$200
 dc.w $500,$200,$200,$200,$200,$200,$200,$100,$500,$200,$200,$200,$200,$200,$200,$100
;
; Un petit rouge ?
;
 dc.w $555,$544,$533,$522,$522,$522,$522,$510,$555,$544,$533,$522,$522,$522,$522,$510
 dc.w $544,$510,$510,$510,$510,$510,$510,$200,$544,$510,$510,$510,$510,$510,$510,$200
 dc.w $533,$510,$510,$510,$510,$510,$510,$200,$533,$510,$510,$510,$510,$510,$510,$200
 dc.w $522,$510,$510,$510,$510,$510,$510,$200,$522,$510,$510,$510,$510,$510,$510,$200
 dc.w $522,$510,$510,$510,$510,$510,$510,$200,$522,$510,$510,$510,$510,$510,$510,$200
 dc.w $522,$510,$510,$510,$510,$510,$510,$200,$522,$510,$510,$510,$510,$510,$510,$200
 dc.w $522,$510,$510,$510,$510,$510,$510,$200,$522,$510,$510,$510,$510,$510,$510,$200
 dc.w $510,$200,$200,$200,$200,$200,$200,$100,$510,$200,$200,$200,$200,$200,$200,$100
;
; Un orange...
;
 dc.w $555,$544,$533,$532,$532,$532,$532,$520,$555,$544,$533,$532,$532,$532,$532,$520
 dc.w $544,$520,$520,$520,$520,$520,$520,$220,$544,$520,$520,$520,$520,$520,$520,$220
 dc.w $533,$520,$520,$520,$520,$520,$520,$220,$533,$520,$520,$520,$520,$520,$520,$220
 dc.w $532,$520,$520,$520,$520,$520,$520,$220,$532,$520,$520,$520,$520,$520,$520,$220
 dc.w $532,$520,$520,$520,$520,$520,$520,$220,$532,$520,$520,$520,$520,$520,$520,$220
 dc.w $532,$520,$520,$520,$520,$520,$520,$220,$532,$520,$520,$520,$520,$520,$520,$220
 dc.w $532,$520,$520,$520,$520,$520,$520,$220,$532,$520,$520,$520,$520,$520,$520,$220
 dc.w $520,$220,$220,$220,$220,$220,$220,$110,$520,$220,$220,$220,$220,$220,$220,$110
;
; Un orange...
;
 dc.w $555,$544,$533,$532,$532,$532,$532,$530,$555,$544,$533,$532,$532,$532,$532,$530
 dc.w $544,$530,$530,$530,$530,$530,$530,$220,$544,$530,$530,$530,$530,$530,$530,$220
 dc.w $533,$530,$530,$530,$530,$530,$530,$220,$533,$530,$530,$530,$530,$530,$530,$220
 dc.w $532,$530,$530,$530,$530,$530,$530,$220,$532,$530,$530,$530,$530,$530,$530,$220
 dc.w $532,$530,$530,$530,$530,$530,$530,$220,$532,$530,$530,$530,$530,$530,$530,$220
 dc.w $532,$530,$530,$530,$530,$530,$530,$220,$532,$530,$530,$530,$530,$530,$530,$220
 dc.w $532,$530,$530,$530,$530,$530,$530,$220,$532,$530,$530,$530,$530,$530,$530,$220
 dc.w $530,$220,$220,$220,$220,$220,$220,$110,$530,$220,$220,$220,$220,$220,$220,$110
;
; Un orange...
;
 dc.w $555,$554,$553,$552,$552,$552,$552,$540,$555,$554,$553,$552,$552,$552,$552,$540
 dc.w $554,$540,$540,$540,$540,$540,$540,$220,$554,$540,$540,$540,$540,$540,$540,$220
 dc.w $553,$540,$540,$540,$540,$540,$540,$220,$553,$540,$540,$540,$540,$540,$540,$220
 dc.w $552,$540,$540,$540,$540,$540,$540,$220,$552,$540,$540,$540,$540,$540,$540,$220
 dc.w $552,$540,$540,$540,$540,$540,$540,$220,$552,$540,$540,$540,$540,$540,$540,$220
 dc.w $552,$540,$540,$540,$540,$540,$540,$220,$552,$540,$540,$540,$540,$540,$540,$220
 dc.w $552,$540,$540,$540,$540,$540,$540,$220,$552,$540,$540,$540,$540,$540,$540,$220
 dc.w $540,$220,$220,$220,$220,$220,$220,$110,$540,$220,$220,$220,$220,$220,$220,$110
;
; Du jaune !
;  
 dc.w $555,$554,$553,$552,$552,$552,$552,$550,$555,$554,$553,$552,$552,$552,$552,$550
 dc.w $554,$550,$550,$550,$550,$550,$550,$220,$554,$550,$550,$550,$550,$550,$550,$220
 dc.w $553,$550,$550,$550,$550,$550,$550,$220,$553,$550,$550,$550,$550,$550,$550,$220
 dc.w $552,$550,$550,$550,$550,$550,$550,$220,$552,$550,$550,$550,$550,$550,$550,$220
 dc.w $552,$550,$550,$550,$550,$550,$550,$220,$552,$550,$550,$550,$550,$550,$550,$220
 dc.w $552,$550,$550,$550,$550,$550,$550,$220,$552,$550,$550,$550,$550,$550,$550,$220
 dc.w $552,$550,$550,$550,$550,$550,$550,$220,$552,$550,$550,$550,$550,$550,$550,$220
 dc.w $550,$220,$220,$220,$220,$220,$220,$110,$550,$220,$220,$220,$220,$220,$220,$110
;
; Du jaune !
;  
 dc.w $555,$554,$553,$552,$552,$552,$552,$450,$555,$554,$553,$552,$552,$552,$552,$450
 dc.w $554,$450,$450,$450,$450,$450,$450,$220,$554,$450,$450,$450,$450,$450,$450,$220
 dc.w $553,$450,$450,$450,$450,$450,$450,$220,$553,$450,$450,$450,$450,$450,$450,$220
 dc.w $552,$450,$450,$450,$450,$450,$450,$220,$552,$450,$450,$450,$450,$450,$450,$220
 dc.w $552,$450,$450,$450,$450,$450,$450,$220,$552,$450,$450,$450,$450,$450,$450,$220
 dc.w $552,$450,$450,$450,$450,$450,$450,$220,$552,$450,$450,$450,$450,$450,$450,$220
 dc.w $552,$450,$450,$450,$450,$450,$450,$220,$552,$450,$450,$450,$450,$450,$450,$220
 dc.w $450,$220,$220,$220,$220,$220,$220,$110,$450,$220,$220,$220,$220,$220,$220,$110
;
; Du jaune !
;  
 dc.w $555,$554,$553,$552,$552,$552,$552,$350,$555,$554,$553,$552,$552,$552,$552,$350
 dc.w $554,$350,$350,$350,$350,$350,$350,$220,$554,$350,$350,$350,$350,$350,$350,$220
 dc.w $553,$350,$350,$350,$350,$350,$350,$220,$553,$350,$350,$350,$350,$350,$350,$220
 dc.w $552,$350,$350,$350,$350,$350,$350,$220,$552,$350,$350,$350,$350,$350,$350,$220
 dc.w $552,$350,$350,$350,$350,$350,$350,$220,$552,$350,$350,$350,$350,$350,$350,$220
 dc.w $552,$350,$350,$350,$350,$350,$350,$220,$552,$350,$350,$350,$350,$350,$350,$220
 dc.w $552,$350,$350,$350,$350,$350,$350,$220,$552,$350,$350,$350,$350,$350,$350,$220
 dc.w $350,$220,$220,$220,$220,$220,$220,$110,$350,$220,$220,$220,$220,$220,$220,$110
;
; Du jaune !
;  
 dc.w $555,$554,$553,$552,$552,$552,$552,$250,$555,$554,$553,$552,$552,$552,$552,$250
 dc.w $554,$250,$250,$250,$250,$250,$250,$220,$554,$250,$250,$250,$250,$250,$250,$220
 dc.w $553,$250,$250,$250,$250,$250,$250,$220,$553,$250,$250,$250,$250,$250,$250,$220
 dc.w $552,$250,$250,$250,$250,$250,$250,$220,$552,$250,$250,$250,$250,$250,$250,$220
 dc.w $552,$250,$250,$250,$250,$250,$250,$220,$552,$250,$250,$250,$250,$250,$250,$220
 dc.w $552,$250,$250,$250,$250,$250,$250,$220,$552,$250,$250,$250,$250,$250,$250,$220
 dc.w $552,$250,$250,$250,$250,$250,$250,$220,$552,$250,$250,$250,$250,$250,$250,$220
 dc.w $250,$220,$220,$220,$220,$220,$220,$110,$250,$220,$220,$220,$220,$220,$220,$110
;
; Du jaune !
;  
 dc.w $555,$554,$553,$552,$552,$552,$552,$150,$555,$554,$553,$552,$552,$552,$552,$150
 dc.w $554,$150,$150,$150,$150,$150,$150,$220,$554,$150,$150,$150,$150,$150,$150,$220
 dc.w $553,$150,$150,$150,$150,$150,$150,$220,$553,$150,$150,$150,$150,$150,$150,$220
 dc.w $552,$150,$150,$150,$150,$150,$150,$220,$552,$150,$150,$150,$150,$150,$150,$220
 dc.w $552,$150,$150,$150,$150,$150,$150,$220,$552,$150,$150,$150,$150,$150,$150,$220
 dc.w $552,$150,$150,$150,$150,$150,$150,$220,$552,$150,$150,$150,$150,$150,$150,$220
 dc.w $552,$150,$150,$150,$150,$150,$150,$220,$552,$150,$150,$150,$150,$150,$150,$220
 dc.w $150,$220,$220,$220,$220,$220,$220,$110,$150,$220,$220,$220,$220,$220,$220,$110
;
; Le vert
;
 dc.w $555,$454,$353,$252,$252,$252,$252,$050,$555,$454,$353,$252,$252,$252,$252,$050
 dc.w $454,$050,$050,$050,$050,$050,$050,$220,$454,$050,$050,$050,$050,$050,$050,$020
 dc.w $353,$050,$050,$050,$050,$050,$050,$020,$353,$050,$050,$050,$050,$050,$050,$020
 dc.w $252,$050,$050,$050,$050,$050,$050,$020,$252,$050,$050,$050,$050,$050,$050,$020
 dc.w $252,$050,$050,$050,$050,$050,$050,$020,$252,$050,$050,$050,$050,$050,$050,$020
 dc.w $252,$050,$050,$050,$050,$050,$050,$020,$252,$050,$050,$050,$050,$050,$050,$020
 dc.w $252,$050,$050,$050,$050,$050,$050,$020,$252,$050,$050,$050,$050,$050,$050,$020
 dc.w $050,$020,$020,$020,$020,$020,$020,$010,$050,$020,$020,$020,$020,$020,$020,$010
;
; Le vert
;
 dc.w $555,$454,$353,$252,$252,$252,$252,$051,$555,$454,$353,$252,$252,$252,$252,$051
 dc.w $454,$051,$051,$051,$051,$051,$051,$220,$454,$051,$051,$051,$051,$051,$051,$020
 dc.w $353,$051,$051,$051,$051,$051,$051,$020,$353,$051,$051,$051,$051,$051,$051,$020
 dc.w $252,$051,$051,$051,$051,$051,$051,$020,$252,$051,$051,$051,$051,$051,$051,$020
 dc.w $252,$051,$051,$051,$051,$051,$051,$020,$252,$051,$051,$051,$051,$051,$051,$020
 dc.w $252,$051,$051,$051,$051,$051,$051,$020,$252,$051,$051,$051,$051,$051,$051,$020
 dc.w $252,$051,$051,$051,$051,$051,$051,$020,$252,$051,$051,$051,$051,$051,$051,$020
 dc.w $051,$020,$020,$020,$020,$020,$020,$010,$051,$020,$020,$020,$020,$020,$020,$010
;
; Vert clair
;
 dc.w $555,$453,$353,$253,$253,$253,$253,$052,$555,$455,$353,$253,$253,$253,$253,$052
 dc.w $453,$052,$052,$052,$052,$052,$052,$022,$453,$052,$052,$052,$052,$052,$052,$022
 dc.w $353,$052,$052,$052,$052,$052,$052,$022,$353,$052,$052,$052,$052,$052,$052,$022
 dc.w $253,$052,$052,$052,$052,$052,$052,$022,$253,$052,$052,$052,$052,$052,$052,$022
 dc.w $253,$052,$052,$052,$052,$052,$052,$022,$253,$052,$052,$052,$052,$052,$052,$022
 dc.w $253,$052,$052,$052,$052,$052,$052,$022,$253,$052,$052,$052,$052,$052,$052,$022
 dc.w $253,$052,$052,$052,$052,$052,$052,$022,$253,$052,$052,$052,$052,$052,$052,$022
 dc.w $052,$022,$022,$022,$022,$022,$022,$011,$052,$022,$022,$022,$022,$022,$022,$011
;
; Vert clair
;
 dc.w $555,$453,$353,$253,$253,$253,$253,$053,$555,$455,$353,$253,$253,$253,$253,$053
 dc.w $453,$053,$053,$053,$053,$053,$053,$022,$453,$053,$053,$053,$053,$053,$053,$022
 dc.w $353,$053,$053,$053,$053,$053,$053,$022,$353,$053,$053,$053,$053,$053,$053,$022
 dc.w $253,$053,$053,$053,$053,$053,$053,$022,$253,$053,$053,$053,$053,$053,$053,$022
 dc.w $253,$053,$053,$053,$053,$053,$053,$022,$253,$053,$053,$053,$053,$053,$053,$022
 dc.w $253,$053,$053,$053,$053,$053,$053,$022,$253,$053,$053,$053,$053,$053,$053,$022
 dc.w $253,$053,$053,$053,$053,$053,$053,$022,$253,$053,$053,$053,$053,$053,$053,$022
 dc.w $053,$022,$022,$022,$022,$022,$022,$011,$053,$022,$022,$022,$022,$022,$022,$011
;
; Vert clair
;
 dc.w $555,$453,$353,$253,$253,$253,$253,$054,$555,$455,$353,$253,$253,$253,$253,$054
 dc.w $453,$054,$054,$054,$054,$054,$054,$022,$453,$054,$054,$054,$054,$054,$054,$022
 dc.w $353,$054,$054,$054,$054,$054,$054,$022,$353,$054,$054,$054,$054,$054,$054,$022
 dc.w $253,$054,$054,$054,$054,$054,$054,$022,$253,$054,$054,$054,$054,$054,$054,$022
 dc.w $253,$054,$054,$054,$054,$054,$054,$022,$253,$054,$054,$054,$054,$054,$054,$022
 dc.w $253,$054,$054,$054,$054,$054,$054,$022,$253,$054,$054,$054,$054,$054,$054,$022
 dc.w $253,$054,$054,$054,$054,$054,$054,$022,$253,$054,$054,$054,$054,$054,$054,$022
 dc.w $054,$022,$022,$022,$022,$022,$022,$011,$054,$022,$022,$022,$022,$022,$022,$011
;
; Le ciel
;
 dc.w $555,$455,$355,$255,$255,$255,$255,$055,$555,$455,$355,$255,$255,$255,$255,$055
 dc.w $455,$055,$055,$055,$055,$055,$055,$022,$455,$055,$055,$055,$055,$055,$055,$022
 dc.w $355,$055,$055,$055,$055,$055,$055,$022,$355,$055,$055,$055,$055,$055,$055,$022
 dc.w $255,$055,$055,$055,$055,$055,$055,$022,$255,$055,$055,$055,$055,$055,$055,$022
 dc.w $255,$055,$055,$055,$055,$055,$055,$022,$255,$055,$055,$055,$055,$055,$055,$022
 dc.w $255,$055,$055,$055,$055,$055,$055,$022,$255,$055,$055,$055,$055,$055,$055,$022
 dc.w $255,$055,$055,$055,$055,$055,$055,$022,$255,$055,$055,$055,$055,$055,$055,$022
 dc.w $055,$022,$022,$022,$022,$022,$022,$011,$055,$022,$022,$022,$022,$022,$022,$011
;
; Ciel fonc‚...Clair... ( Ca commence … etre dur ...)
;
 dc.w $555,$455,$345,$245,$245,$245,$245,$045,$555,$455,$345,$245,$245,$245,$245,$045
 dc.w $455,$045,$045,$045,$045,$045,$045,$022,$455,$045,$045,$045,$045,$045,$045,$022
 dc.w $345,$045,$045,$045,$045,$045,$045,$022,$345,$045,$045,$045,$045,$045,$045,$022
 dc.w $245,$045,$045,$045,$045,$045,$045,$022,$245,$045,$045,$045,$045,$045,$045,$022
 dc.w $245,$045,$045,$045,$045,$045,$045,$022,$245,$045,$045,$045,$045,$045,$045,$022
 dc.w $245,$045,$045,$045,$045,$045,$045,$022,$245,$045,$045,$045,$045,$045,$045,$022
 dc.w $245,$045,$045,$045,$045,$045,$045,$022,$245,$045,$045,$045,$045,$045,$045,$022
 dc.w $045,$022,$022,$022,$022,$022,$022,$011,$045,$022,$022,$022,$022,$022,$022,$011
;
; Ciel fonc‚... ( Ca commence … etre dur ...)
;
 dc.w $555,$445,$345,$235,$235,$235,$235,$035,$555,$445,$345,$235,$235,$235,$235,$035
 dc.w $445,$035,$035,$035,$035,$035,$035,$022,$445,$035,$035,$035,$035,$035,$035,$022
 dc.w $345,$035,$035,$035,$035,$035,$035,$022,$345,$035,$035,$035,$035,$035,$035,$022
 dc.w $235,$035,$035,$035,$035,$035,$035,$022,$235,$035,$035,$035,$035,$035,$035,$022
 dc.w $235,$035,$035,$035,$035,$035,$035,$022,$235,$035,$035,$035,$035,$035,$035,$022
 dc.w $235,$035,$035,$035,$035,$035,$035,$022,$235,$035,$035,$035,$035,$035,$035,$022
 dc.w $235,$035,$035,$035,$035,$035,$035,$022,$235,$035,$035,$035,$035,$035,$035,$022
 dc.w $035,$022,$022,$022,$022,$022,$022,$011,$035,$022,$022,$022,$022,$022,$022,$011
;
; Ciel fonc‚... ( Ca commence … etre dur ...)
;
 dc.w $555,$445,$345,$235,$235,$235,$235,$025,$555,$445,$345,$235,$235,$235,$235,$025
 dc.w $445,$025,$025,$025,$025,$025,$025,$022,$445,$025,$025,$025,$025,$025,$025,$022
 dc.w $345,$025,$025,$025,$025,$025,$025,$022,$345,$025,$025,$025,$025,$025,$025,$022
 dc.w $235,$025,$025,$025,$025,$025,$025,$022,$235,$025,$025,$025,$025,$025,$025,$022
 dc.w $235,$025,$025,$025,$025,$025,$025,$022,$235,$025,$025,$025,$025,$025,$025,$022
 dc.w $235,$025,$025,$025,$025,$025,$025,$022,$235,$025,$025,$025,$025,$025,$025,$022
 dc.w $235,$025,$025,$025,$025,$025,$025,$022,$235,$025,$025,$025,$025,$025,$025,$022
 dc.w $025,$022,$022,$022,$022,$022,$022,$011,$025,$022,$022,$022,$022,$022,$022,$011
;
; Ciel fonc‚... ( Ca commence … etre dur ...)
;
 dc.w $555,$445,$345,$235,$235,$235,$235,$015,$555,$445,$345,$235,$235,$235,$235,$015
 dc.w $445,$015,$015,$015,$015,$015,$015,$022,$445,$015,$015,$015,$015,$015,$015,$022
 dc.w $345,$015,$015,$015,$015,$015,$015,$022,$345,$015,$015,$015,$015,$015,$015,$022
 dc.w $235,$015,$015,$015,$015,$015,$015,$022,$235,$015,$015,$015,$015,$015,$015,$022
 dc.w $235,$015,$015,$015,$015,$015,$015,$022,$235,$015,$015,$015,$015,$015,$015,$022
 dc.w $235,$015,$015,$015,$015,$015,$015,$022,$235,$015,$015,$015,$015,$015,$015,$022
 dc.w $235,$015,$015,$015,$015,$015,$015,$022,$235,$015,$015,$015,$015,$015,$015,$022
 dc.w $015,$022,$022,$022,$022,$022,$022,$011,$015,$022,$022,$022,$022,$022,$022,$011
;
; Le roy
;
 dc.w $555,$445,$335,$225,$225,$225,$225,$005,$555,$445,$335,$225,$225,$225,$225,$005
 dc.w $445,$005,$005,$005,$005,$005,$005,$002,$445,$005,$005,$005,$005,$005,$005,$002
 dc.w $335,$005,$005,$005,$005,$005,$005,$002,$335,$005,$005,$005,$005,$005,$005,$002
 dc.w $225,$005,$005,$005,$005,$005,$005,$002,$225,$005,$005,$005,$005,$005,$005,$002
 dc.w $225,$005,$005,$005,$005,$005,$005,$002,$225,$005,$005,$005,$005,$005,$005,$002
 dc.w $225,$005,$005,$005,$005,$005,$005,$002,$225,$005,$005,$005,$005,$005,$005,$002
 dc.w $225,$005,$005,$005,$005,$005,$005,$002,$225,$005,$005,$005,$005,$005,$005,$002
 dc.w $005,$002,$002,$002,$002,$002,$002,$001,$005,$002,$002,$002,$002,$002,$002,$001
;
; Le roy
;
 dc.w $555,$445,$335,$225,$225,$225,$225,$105,$555,$445,$335,$225,$225,$225,$225,$105
 dc.w $445,$105,$105,$105,$105,$105,$105,$002,$445,$105,$105,$105,$105,$105,$105,$002
 dc.w $335,$105,$105,$105,$105,$105,$105,$002,$335,$105,$105,$105,$105,$105,$105,$002
 dc.w $225,$105,$105,$105,$105,$105,$105,$002,$225,$105,$105,$105,$105,$105,$105,$002
 dc.w $225,$105,$105,$105,$105,$105,$105,$002,$225,$105,$105,$105,$105,$105,$105,$002
 dc.w $225,$105,$105,$105,$105,$105,$105,$002,$225,$105,$105,$105,$105,$105,$105,$002
 dc.w $225,$105,$105,$105,$105,$105,$105,$002,$225,$105,$105,$105,$105,$105,$105,$002
 dc.w $105,$002,$002,$002,$002,$002,$002,$001,$105,$002,$002,$002,$002,$002,$002,$001
;
; Bleu roy-violac‚...
;
 dc.w $555,$445,$335,$225,$225,$225,$225,$205,$555,$445,$335,$225,$225,$225,$225,$205
 dc.w $445,$205,$205,$205,$205,$205,$205,$002,$445,$205,$205,$205,$205,$205,$205,$002
 dc.w $335,$205,$205,$205,$205,$205,$205,$002,$335,$205,$205,$205,$205,$205,$205,$002
 dc.w $225,$205,$205,$205,$205,$205,$205,$002,$225,$205,$205,$205,$205,$205,$205,$002
 dc.w $225,$205,$205,$205,$205,$205,$205,$002,$225,$205,$205,$205,$205,$205,$205,$002
 dc.w $225,$205,$205,$205,$205,$205,$205,$002,$225,$205,$205,$205,$205,$205,$205,$002
 dc.w $225,$205,$205,$205,$205,$205,$205,$002,$225,$205,$205,$205,$205,$205,$205,$002
 dc.w $205,$002,$002,$002,$002,$002,$002,$001,$205,$002,$002,$002,$002,$002,$002,$001
;
; Bleu roy-violac‚...
;
 dc.w $555,$445,$335,$325,$325,$325,$325,$305,$555,$445,$335,$325,$325,$325,$325,$305
 dc.w $445,$305,$305,$305,$305,$305,$305,$002,$445,$305,$305,$305,$305,$305,$305,$002
 dc.w $335,$305,$305,$305,$305,$305,$305,$002,$335,$305,$305,$305,$305,$305,$305,$002
 dc.w $325,$305,$305,$305,$305,$305,$305,$002,$325,$305,$305,$305,$305,$305,$305,$002
 dc.w $325,$305,$305,$305,$305,$305,$305,$002,$325,$305,$305,$305,$305,$305,$305,$002
 dc.w $325,$305,$305,$305,$305,$305,$305,$002,$325,$305,$305,$305,$305,$305,$305,$002
 dc.w $325,$305,$305,$305,$305,$305,$305,$002,$325,$305,$305,$305,$305,$305,$305,$002
 dc.w $305,$002,$002,$002,$002,$002,$002,$001,$305,$002,$002,$002,$002,$002,$002,$001
;
; Bleu roy-violac‚...
;
 dc.w $555,$445,$435,$425,$425,$425,$425,$405,$555,$445,$435,$425,$425,$425,$425,$405
 dc.w $445,$405,$405,$405,$405,$405,$405,$002,$445,$405,$405,$405,$405,$405,$405,$002
 dc.w $435,$405,$405,$405,$405,$405,$405,$002,$435,$405,$405,$405,$405,$405,$405,$002
 dc.w $425,$405,$405,$405,$405,$405,$405,$002,$425,$405,$405,$405,$405,$405,$405,$002
 dc.w $425,$405,$405,$405,$405,$405,$405,$002,$425,$405,$405,$405,$405,$405,$405,$002
 dc.w $425,$405,$405,$405,$405,$405,$405,$002,$425,$405,$405,$405,$405,$405,$405,$002
 dc.w $425,$405,$405,$405,$405,$405,$405,$002,$425,$405,$405,$405,$405,$405,$405,$002
 dc.w $405,$002,$002,$002,$002,$002,$002,$001,$405,$002,$002,$002,$002,$002,$002,$001
;
; Le violet
;
 dc.w $555,$545,$535,$525,$525,$525,$525,$505,$555,$545,$535,$525,$525,$525,$525,$505
 dc.w $545,$505,$505,$505,$505,$505,$505,$202,$545,$505,$505,$505,$505,$505,$505,$202
 dc.w $535,$505,$505,$505,$505,$505,$505,$202,$535,$505,$505,$505,$505,$505,$505,$202
 dc.w $525,$505,$505,$505,$505,$505,$505,$202,$525,$505,$505,$505,$505,$505,$505,$202
 dc.w $525,$505,$505,$505,$505,$505,$505,$202,$525,$505,$505,$505,$505,$505,$505,$202
 dc.w $525,$505,$505,$505,$505,$505,$505,$202,$525,$505,$505,$505,$505,$505,$505,$202
 dc.w $525,$505,$505,$505,$505,$505,$505,$202,$525,$505,$505,$505,$505,$505,$505,$202
 dc.w $505,$202,$202,$202,$202,$202,$202,$101,$505,$202,$202,$202,$202,$202,$202,$101
;
; Le violet
;
 dc.w $555,$545,$535,$525,$525,$525,$525,$504,$555,$545,$535,$525,$525,$525,$525,$504
 dc.w $545,$504,$504,$504,$504,$504,$504,$202,$545,$504,$504,$504,$504,$504,$504,$202
 dc.w $535,$504,$504,$504,$504,$504,$504,$202,$535,$504,$504,$504,$504,$504,$504,$202
 dc.w $525,$504,$504,$504,$504,$504,$504,$202,$525,$504,$504,$504,$504,$504,$504,$202
 dc.w $525,$504,$504,$504,$504,$504,$504,$202,$525,$504,$504,$504,$504,$504,$504,$202
 dc.w $525,$504,$504,$504,$504,$504,$504,$202,$525,$504,$504,$504,$504,$504,$504,$202
 dc.w $525,$504,$504,$504,$504,$504,$504,$202,$525,$504,$504,$504,$504,$504,$504,$202
 dc.w $504,$202,$202,$202,$202,$202,$202,$101,$504,$202,$202,$202,$202,$202,$202,$101
;
; Le violet
;
 dc.w $555,$545,$535,$525,$525,$525,$525,$503,$555,$545,$535,$525,$525,$525,$525,$503
 dc.w $545,$503,$503,$503,$503,$503,$503,$202,$545,$503,$503,$503,$503,$503,$503,$202
 dc.w $535,$503,$503,$503,$503,$503,$503,$202,$535,$503,$503,$503,$503,$503,$503,$202
 dc.w $525,$503,$503,$503,$503,$503,$503,$202,$525,$503,$503,$503,$503,$503,$503,$202
 dc.w $525,$503,$503,$503,$503,$503,$503,$202,$525,$503,$503,$503,$503,$503,$503,$202
 dc.w $525,$503,$503,$503,$503,$503,$503,$202,$525,$503,$503,$503,$503,$503,$503,$202
 dc.w $525,$503,$503,$503,$503,$503,$503,$202,$525,$503,$503,$503,$503,$503,$503,$202
 dc.w $503,$202,$202,$202,$202,$202,$202,$101,$503,$202,$202,$202,$202,$202,$202,$101
;
; Violet rougeatre
;
 dc.w $555,$545,$535,$525,$525,$525,$525,$502,$555,$545,$535,$525,$525,$525,$525,$502
 dc.w $545,$502,$502,$502,$502,$502,$502,$202,$545,$502,$502,$502,$502,$502,$502,$202
 dc.w $535,$502,$502,$502,$502,$502,$502,$202,$535,$502,$502,$502,$502,$502,$502,$202
 dc.w $525,$502,$502,$502,$502,$502,$502,$202,$525,$502,$502,$502,$502,$502,$502,$202
 dc.w $525,$502,$502,$502,$502,$502,$502,$202,$525,$502,$502,$502,$502,$502,$502,$202
 dc.w $525,$502,$502,$502,$502,$502,$502,$202,$525,$502,$502,$502,$502,$502,$502,$202
 dc.w $525,$502,$502,$502,$502,$502,$502,$202,$525,$502,$502,$502,$502,$502,$502,$202
 dc.w $502,$202,$202,$202,$202,$202,$202,$101,$502,$202,$202,$202,$202,$202,$202,$101
;
; Violet rougeatre
;
 dc.w $555,$545,$535,$525,$525,$525,$525,$501,$555,$545,$535,$525,$525,$525,$525,$501
 dc.w $545,$501,$501,$501,$501,$501,$501,$202,$545,$501,$501,$501,$501,$501,$501,$202
 dc.w $535,$501,$501,$501,$501,$501,$501,$202,$535,$501,$501,$501,$501,$501,$501,$202
 dc.w $525,$501,$501,$501,$501,$501,$501,$202,$525,$501,$501,$501,$501,$501,$501,$202
 dc.w $525,$501,$501,$501,$501,$501,$501,$202,$525,$501,$501,$501,$501,$501,$501,$202
 dc.w $525,$501,$501,$501,$501,$501,$501,$202,$525,$501,$501,$501,$501,$501,$501,$202
 dc.w $525,$501,$501,$501,$501,$501,$501,$202,$525,$501,$501,$501,$501,$501,$501,$202
 dc.w $501,$202,$202,$202,$202,$202,$202,$101,$501,$202,$202,$202,$202,$202,$202,$101
 endr

fin

