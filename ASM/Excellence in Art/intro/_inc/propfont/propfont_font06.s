; Calibri Light
*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $00C8
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0FFF,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$5000,$0000
		dc.w	$2800,$0000
		dc.w	$7800,$0000
		dc.w	$E100,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$A000,$0000
		dc.w	$2800,$0000
		dc.w	$8000,$0000
		dc.w	$A200,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$8000,$0000
		dc.w	$A400,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$2800,$0000
		dc.w	$6000,$0000
		dc.w	$E800,$0000
		dc.w	$6400,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$1800,$0000
		dc.w	$0F00,$0000
		dc.w	$9400,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$0800,$0000
		dc.w	$1500,$0000
		dc.w	$8C00,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$8800,$0000
		dc.w	$2500,$0000
		dc.w	$8C00,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$7000,$0000
		dc.w	$4700,$0000
		dc.w	$7200,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$7000,$0000
		dc.w	$6000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$1800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$A000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$2800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$0800,$0000
		dc.w	$2800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$7000,$0000
		dc.w	$4800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$1000,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$FC00,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$7000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$3800,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$3000,$0000
		dc.w	$F800,$0000
		dc.w	$6000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$1000,$0000
		dc.w	$7000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$F800,$0000
		dc.w	$6000,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$4000,$0000
		dc.w	$7000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9000,$0000
		dc.w	$1E00,$0000
		dc.w	$1000,$0000
		dc.w	$F000,$0000
		dc.w	$3800,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$3800,$0000
		dc.w	$8400,$0000
		dc.w	$1000,$0000
		dc.w	$6180,$0000
		dc.w	$1000,$0000
		dc.w	$9000,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$4400,$0000
		dc.w	$8400,$0000
		dc.w	$1000,$0000
		dc.w	$5C80,$0000
		dc.w	$2800,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8400,$0000
		dc.w	$6000,$0000
		dc.w	$A480,$0000
		dc.w	$2800,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$8400,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$FC00,$0000
		dc.w	$4000,$0000
		dc.w	$A480,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$9C00,$0000
		dc.w	$8400,$0000
		dc.w	$4000,$0000
		dc.w	$A980,$0000
		dc.w	$7C00,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8400,$0000
		dc.w	$8400,$0000
		dc.w	$0000,$0000
		dc.w	$B700,$0000
		dc.w	$8200,$0000
		dc.w	$8800,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$4400,$0000
		dc.w	$8400,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$8200,$0000
		dc.w	$F000,$0000
		dc.w	$3800,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$3C00,$0000
		dc.w	$8400,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3E00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$FF80,$0000
		dc.w	$FE00,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$C180,$0000
		dc.w	$C400,$0000
		dc.w	$3C00,$0000
		dc.w	$F000,$0000
		dc.w	$3C00,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$C180,$0000
		dc.w	$C400,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$A280,$0000
		dc.w	$A400,$0000
		dc.w	$8200,$0000
		dc.w	$8800,$0000
		dc.w	$8200,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$A280,$0000
		dc.w	$A400,$0000
		dc.w	$8200,$0000
		dc.w	$8800,$0000
		dc.w	$8200,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$9480,$0000
		dc.w	$9400,$0000
		dc.w	$8200,$0000
		dc.w	$F000,$0000
		dc.w	$8200,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$9480,$0000
		dc.w	$9400,$0000
		dc.w	$8200,$0000
		dc.w	$8000,$0000
		dc.w	$8200,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$9480,$0000
		dc.w	$8C00,$0000
		dc.w	$4400,$0000
		dc.w	$8000,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$8800,$0000
		dc.w	$F000,$0000
		dc.w	$8880,$0000
		dc.w	$8400,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$7E00,$0000
		dc.w	$8400,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0100,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$FF80,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$F800,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$FE00,$0000
		dc.w	$8400,$0000
		dc.w	$8200,$0000
		dc.w	$8420,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$8400,$0000
		dc.w	$8200,$0000
		dc.w	$8620,$0000
		dc.w	$5000,$0000
		dc.w	$5000,$0000
		dc.w	$0800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$8400,$0000
		dc.w	$4400,$0000
		dc.w	$4A40,$0000
		dc.w	$5000,$0000
		dc.w	$5000,$0000
		dc.w	$1000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$6000,$0000
		dc.w	$1000,$0000
		dc.w	$8400,$0000
		dc.w	$4400,$0000
		dc.w	$4A40,$0000
		dc.w	$2000,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$1800,$0000
		dc.w	$1000,$0000
		dc.w	$8400,$0000
		dc.w	$2800,$0000
		dc.w	$2940,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$1000,$0000
		dc.w	$8400,$0000
		dc.w	$2800,$0000
		dc.w	$2940,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$CC00,$0000
		dc.w	$2800,$0000
		dc.w	$3180,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$7000,$0000
		dc.w	$1000,$0000
		dc.w	$7800,$0000
		dc.w	$1000,$0000
		dc.w	$1080,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0800,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FFC0,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$7800,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$F700,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$8880,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$8880,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$6000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$8880,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$8880,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$7000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$8880,$0000
		dc.w	$8800,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$FF80,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$E000,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8880,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$F000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8880,$0000
		dc.w	$5000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$5500,$0000
		dc.w	$2000,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$3000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$5500,$0000
		dc.w	$2000,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$2200,$0000
		dc.w	$5000,$0000
		dc.w	$5000,$0000
		dc.w	$8000,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$3000,$0000
		dc.w	$7800,$0000
		dc.w	$2000,$0000
		dc.w	$2200,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$F000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$FF80,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2800,$0000
		dc.w	$2800,$0000
		dc.w	$2400,$0000
		dc.w	$4800,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$1000,$0000
		dc.w	$3C00,$0000
		dc.w	$8400,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$1000,$0000
		dc.w	$4400,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$2800,$0000
		dc.w	$2800,$0000
		dc.w	$8200,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$2800,$0000
		dc.w	$2800,$0000
		dc.w	$8200,$0000
		dc.w	$8400,$0000
		dc.w	$F000,$0000
		dc.w	$1000,$0000
		dc.w	$1000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$8200,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$7C00,$0000
		dc.w	$7C00,$0000
		dc.w	$8200,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$8200,$0000
		dc.w	$8200,$0000
		dc.w	$4400,$0000
		dc.w	$CC00,$0000
		dc.w	$8000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$8200,$0000
		dc.w	$8200,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$8800,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
