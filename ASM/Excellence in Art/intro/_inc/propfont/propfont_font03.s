*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $00C8
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0FFF,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$1000,$0000
		dc.w	$C000,$0000
		dc.w	$D800,$0000
		dc.w	$3300,$0000
		dc.w	$7E00,$0000
		dc.w	$4100,$0000
		dc.w	$7C00,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$D600,$0000
		dc.w	$C000,$0000
		dc.w	$D800,$0000
		dc.w	$FFC0,$0000
		dc.w	$D800,$0000
		dc.w	$A300,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$3800,$0000
		dc.w	$C000,$0000
		dc.w	$D800,$0000
		dc.w	$FFC0,$0000
		dc.w	$D800,$0000
		dc.w	$4600,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$3300,$0000
		dc.w	$7E00,$0000
		dc.w	$0C00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$3800,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$3300,$0000
		dc.w	$1B00,$0000
		dc.w	$1800,$0000
		dc.w	$C600,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$D600,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FFC0,$0000
		dc.w	$1B00,$0000
		dc.w	$3100,$0000
		dc.w	$C600,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$1000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$FFC0,$0000
		dc.w	$1B00,$0000
		dc.w	$6280,$0000
		dc.w	$C600,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$3300,$0000
		dc.w	$FE00,$0000
		dc.w	$4100,$0000
		dc.w	$7C00,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$FFC0,$0000
		dc.w	$FF00,$0000
		dc.w	$FF80,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$FE00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0180,$0000
		dc.w	$3C00,$0000
		dc.w	$6000,$0000
		dc.w	$7C00,$0000
		dc.w	$FE00,$0000
		dc.w	$1C00,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$6600,$0000
		dc.w	$E000,$0000
		dc.w	$C600,$0000
		dc.w	$0C00,$0000
		dc.w	$3C00,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0600,$0000
		dc.w	$CB00,$0000
		dc.w	$6000,$0000
		dc.w	$0600,$0000
		dc.w	$1800,$0000
		dc.w	$6C00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$CB00,$0000
		dc.w	$6000,$0000
		dc.w	$0C00,$0000
		dc.w	$3800,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$D300,$0000
		dc.w	$6000,$0000
		dc.w	$3800,$0000
		dc.w	$0C00,$0000
		dc.w	$FE00,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$D300,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0600,$0000
		dc.w	$0C00,$0000
		dc.w	$1800,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$6600,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$E600,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$3C00,$0000
		dc.w	$F000,$0000
		dc.w	$FE00,$0000
		dc.w	$7C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FF00,$0000
		dc.w	$E000,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$FF80,$0000
		dc.w	$FF00,$0000
		dc.w	$F000,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$3800,$0000
		dc.w	$FE00,$0000
		dc.w	$7C00,$0000
		dc.w	$7C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$0600,$0000
		dc.w	$C600,$0000
		dc.w	$C600,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$C600,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0C00,$0000
		dc.w	$7C00,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0600,$0000
		dc.w	$C600,$0000
		dc.w	$1800,$0000
		dc.w	$C600,$0000
		dc.w	$7C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$0600,$0000
		dc.w	$C600,$0000
		dc.w	$3000,$0000
		dc.w	$C600,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$C600,$0000
		dc.w	$C600,$0000
		dc.w	$3000,$0000
		dc.w	$C600,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$7C00,$0000
		dc.w	$7C00,$0000
		dc.w	$3000,$0000
		dc.w	$7C00,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$7F00,$0000
		dc.w	$7E00,$0000
		dc.w	$FE00,$0000
		dc.w	$7E00,$0000
		dc.w	$FC00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$7E00,$0000
		dc.w	$C300,$0000
		dc.w	$C600,$0000
		dc.w	$C180,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$0600,$0000
		dc.w	$CD80,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$3C00,$0000
		dc.w	$D580,$0000
		dc.w	$C300,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$CF00,$0000
		dc.w	$FF00,$0000
		dc.w	$3000,$0000
		dc.w	$DD80,$0000
		dc.w	$FF00,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$0000,$0000
		dc.w	$C700,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$3000,$0000
		dc.w	$7F00,$0000
		dc.w	$C300,$0000
		dc.w	$FE00,$0000
		dc.w	$7E00,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$7E00,$0000
		dc.w	$C300,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$7F80,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C060,$0000
		dc.w	$C300,$0000
		dc.w	$7E00,$0000
		dc.w	$FE00,$0000
		dc.w	$7E00,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$E0E0,$0000
		dc.w	$E300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$F1E0,$0000
		dc.w	$F300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$DB60,$0000
		dc.w	$DB00,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CE60,$0000
		dc.w	$CF00,$0000
		dc.w	$C300,$0000
		dc.w	$FE00,$0000
		dc.w	$C300,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$C460,$0000
		dc.w	$C700,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$CF00,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$C600,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C060,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$CF00,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$7C00,$0000
		dc.w	$C300,$0000
		dc.w	$FE00,$0000
		dc.w	$C060,$0000
		dc.w	$C300,$0000
		dc.w	$7E00,$0000
		dc.w	$C000,$0000
		dc.w	$7F00,$0000
		dc.w	$C300,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FFE0,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$7E00,$0000
		dc.w	$FF00,$0000
		dc.w	$C300,$0000
		dc.w	$C600,$0000
		dc.w	$C630,$0000
		dc.w	$C180,$0000
		dc.w	$C300,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$C300,$0000
		dc.w	$C600,$0000
		dc.w	$C630,$0000
		dc.w	$E380,$0000
		dc.w	$C300,$0000
		dc.w	$0600,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$C300,$0000
		dc.w	$4400,$0000
		dc.w	$4620,$0000
		dc.w	$7700,$0000
		dc.w	$6600,$0000
		dc.w	$0C00,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$7E00,$0000
		dc.w	$1800,$0000
		dc.w	$C300,$0000
		dc.w	$6C00,$0000
		dc.w	$6F60,$0000
		dc.w	$1C00,$0000
		dc.w	$3C00,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$0300,$0000
		dc.w	$1800,$0000
		dc.w	$C300,$0000
		dc.w	$6C00,$0000
		dc.w	$6F60,$0000
		dc.w	$3E00,$0000
		dc.w	$1800,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$0300,$0000
		dc.w	$1800,$0000
		dc.w	$C300,$0000
		dc.w	$3800,$0000
		dc.w	$39C0,$0000
		dc.w	$7700,$0000
		dc.w	$1800,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$0600,$0000
		dc.w	$0300,$0000
		dc.w	$1800,$0000
		dc.w	$C300,$0000
		dc.w	$3800,$0000
		dc.w	$39C0,$0000
		dc.w	$E380,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0300,$0000
		dc.w	$FE00,$0000
		dc.w	$1800,$0000
		dc.w	$7E00,$0000
		dc.w	$1000,$0000
		dc.w	$1080,$0000
		dc.w	$C180,$0000
		dc.w	$1800,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$0180,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FFF0,$0000
		dc.w	$FF80,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$F000,$0000
		dc.w	$FF80,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$3C00,$0000
		dc.w	$3000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$D800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3E00,$0000
		dc.w	$FE00,$0000
		dc.w	$7E00,$0000
		dc.w	$7F00,$0000
		dc.w	$7E00,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7F00,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$FF00,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7F00,$0000
		dc.w	$FE00,$0000
		dc.w	$7F00,$0000
		dc.w	$7F00,$0000
		dc.w	$7E00,$0000
		dc.w	$6000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7E00,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$FFE0,$0000
		dc.w	$FE00,$0000
		dc.w	$7E00,$0000
		dc.w	$FE00,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$C630,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$C630,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$C630,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$7F00,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C630,$0000
		dc.w	$C300,$0000
		dc.w	$7E00,$0000
		dc.w	$FE00,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$3E00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$FFF0,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7F00,$0000
		dc.w	$FC00,$0000
		dc.w	$7C00,$0000
		dc.w	$F800,$0000
		dc.w	$C300,$0000
		dc.w	$C600,$0000
		dc.w	$C630,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$FF00,$0000
		dc.w	$C300,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C300,$0000
		dc.w	$C600,$0000
		dc.w	$C630,$0000
		dc.w	$E700,$0000
		dc.w	$C300,$0000
		dc.w	$0F00,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$7E00,$0000
		dc.w	$6000,$0000
		dc.w	$C300,$0000
		dc.w	$6C00,$0000
		dc.w	$6F60,$0000
		dc.w	$3C00,$0000
		dc.w	$C300,$0000
		dc.w	$3C00,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$0300,$0000
		dc.w	$6000,$0000
		dc.w	$C300,$0000
		dc.w	$3800,$0000
		dc.w	$39C0,$0000
		dc.w	$E700,$0000
		dc.w	$C300,$0000
		dc.w	$F000,$0000
		dc.w	$7F00,$0000
		dc.w	$C000,$0000
		dc.w	$FE00,$0000
		dc.w	$3C00,$0000
		dc.w	$7E00,$0000
		dc.w	$1000,$0000
		dc.w	$1080,$0000
		dc.w	$C300,$0000
		dc.w	$7F00,$0000
		dc.w	$FF00,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$0300,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3E00,$0000
		dc.w	$0000,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FFF0,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0600,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2400,$0000
		dc.w	$6600,$0000
		dc.w	$6600,$0000
		dc.w	$6600,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3C00,$0000
		dc.w	$6600,$0000
		dc.w	$6600,$0000
		dc.w	$6600,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1C00,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$7E00,$0000
		dc.w	$7E00,$0000
		dc.w	$7E00,$0000
		dc.w	$C300,$0000
		dc.w	$FF00,$0000
		dc.w	$1400,$0000
		dc.w	$3600,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$1C00,$0000
		dc.w	$3600,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$FC00,$0000
		dc.w	$3E00,$0000
		dc.w	$3E00,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$0300,$0000
		dc.w	$0300,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$7F00,$0000
		dc.w	$7F00,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$7E00,$0000
		dc.w	$7E00,$0000
		dc.w	$FF80,$0000
		dc.w	$7F00,$0000
		dc.w	$7F00,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF80,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6600,$0000
		dc.w	$6600,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6600,$0000
		dc.w	$6600,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7E00,$0000
		dc.w	$C300,$0000
		dc.w	$7E00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C300,$0000
		dc.w	$C300,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7E00,$0000
		dc.w	$7E00,$0000
		dc.w	$7C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$FE00,$0000
		dc.w	$FF80,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
