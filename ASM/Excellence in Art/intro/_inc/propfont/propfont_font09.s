; MSX
*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $00C8
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0FFF,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$A000,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$A000,$0000
		dc.w	$5000,$0000
		dc.w	$7800,$0000
		dc.w	$C800,$0000
		dc.w	$A000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$A800,$0000
		dc.w	$8000,$0000
		dc.w	$A000,$0000
		dc.w	$F800,$0000
		dc.w	$A000,$0000
		dc.w	$1000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$A800,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$2800,$0000
		dc.w	$4000,$0000
		dc.w	$9000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$F000,$0000
		dc.w	$9800,$0000
		dc.w	$9800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$A800,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$1800,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$1000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$6000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$3000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$9800,$0000
		dc.w	$A000,$0000
		dc.w	$0800,$0000
		dc.w	$0800,$0000
		dc.w	$5000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$A800,$0000
		dc.w	$2000,$0000
		dc.w	$1000,$0000
		dc.w	$3000,$0000
		dc.w	$9000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$C800,$0000
		dc.w	$2000,$0000
		dc.w	$6000,$0000
		dc.w	$0800,$0000
		dc.w	$F800,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$6000,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$1000,$0000
		dc.w	$F000,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$E000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$F000,$0000
		dc.w	$3000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$4800,$0000
		dc.w	$4800,$0000
		dc.w	$5000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$6800,$0000
		dc.w	$8800,$0000
		dc.w	$7000,$0000
		dc.w	$8000,$0000
		dc.w	$4800,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$B800,$0000
		dc.w	$F800,$0000
		dc.w	$2000,$0000
		dc.w	$A800,$0000
		dc.w	$F800,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$A800,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$4800,$0000
		dc.w	$5000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$8800,$0000
		dc.w	$F000,$0000
		dc.w	$3000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$3800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$D800,$0000
		dc.w	$C800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$A800,$0000
		dc.w	$C800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$A800,$0000
		dc.w	$A800,$0000
		dc.w	$8800,$0000
		dc.w	$F000,$0000
		dc.w	$8800,$0000
		dc.w	$F000,$0000
		dc.w	$4000,$0000
		dc.w	$9000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$9800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$A800,$0000
		dc.w	$A000,$0000
		dc.w	$4000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$9800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$E000,$0000
		dc.w	$6000,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$7000,$0000
		dc.w	$8000,$0000
		dc.w	$6800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$F800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$A800,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$A800,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$D800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$2000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$2800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$B000,$0000
		dc.w	$7000,$0000
		dc.w	$6800,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$C800,$0000
		dc.w	$8800,$0000
		dc.w	$9800,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$C800,$0000
		dc.w	$8800,$0000
		dc.w	$9800,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$B000,$0000
		dc.w	$7000,$0000
		dc.w	$6800,$0000
		dc.w	$7000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6800,$0000
		dc.w	$F000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$D000,$0000
		dc.w	$B000,$0000
		dc.w	$7000,$0000
		dc.w	$B000,$0000
		dc.w	$9800,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$A000,$0000
		dc.w	$4000,$0000
		dc.w	$A800,$0000
		dc.w	$C800,$0000
		dc.w	$8800,$0000
		dc.w	$C800,$0000
		dc.w	$9800,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$A800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$C800,$0000
		dc.w	$6800,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$A000,$0000
		dc.w	$4000,$0000
		dc.w	$A800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$B000,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$E000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$E000,$0000
		dc.w	$A800,$0000
		dc.w	$8800,$0000
		dc.w	$7000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6800,$0000
		dc.w	$B000,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$F800,$0000
		dc.w	$9800,$0000
		dc.w	$C800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$9800,$0000
		dc.w	$8000,$0000
		dc.w	$F000,$0000
		dc.w	$4000,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$A800,$0000
		dc.w	$2000,$0000
		dc.w	$9800,$0000
		dc.w	$2000,$0000
		dc.w	$6800,$0000
		dc.w	$8000,$0000
		dc.w	$0800,$0000
		dc.w	$4800,$0000
		dc.w	$9000,$0000
		dc.w	$5000,$0000
		dc.w	$A800,$0000
		dc.w	$5000,$0000
		dc.w	$6800,$0000
		dc.w	$4000,$0000
		dc.w	$0800,$0000
		dc.w	$8000,$0000
		dc.w	$F000,$0000
		dc.w	$3000,$0000
		dc.w	$6800,$0000
		dc.w	$2000,$0000
		dc.w	$5000,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$F800,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$A800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
