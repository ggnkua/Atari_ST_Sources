; Some magic... 
 include stedemo.s
 