;	LE GREETING SCREEN
;
;DEBUT: 31/10/90
;FINI : 10/07/91
;DURE DU SCROLL TEXT:	11'
;TAILLE EN RAM      :   49919 octets
;FICHIER A INCLURE  :	red_sect.red
;		n_logo  .inc
;
;
;
;
;
;
;
;
;
;
;	CODE DE PrinST
;  REMARQUE INPORTANTE: ce code est un tres bon exemple d'anti obtimisation
;cela est du au simple fait que je l'ai redige il y a 8 mois et que a cette
;epoque j'en etais a mon deusieme screen code en ASM. voila ,s'il est dans
;la space,c parceque contrairement a certain, je n'ai pas honte de mes 
;anciennes realistations...(source orginial es GFA ASM)
;
;
;  2eme REMARQUE: il n'y a pas beaucoup de commentaires dans se source, 
;c'est parceque il n'y a pas grand chose qui merite d'etre commentВe... 
;
;

;	lanver le sous programe en supervisor mode.
	move	#0,-(sp)
	move.l	#-1,-(sp)
	move.l	#-1,-(sp)
	move	#5,-(sp)
	trap	#14
	add.l	#12,sp

	move.l	#programe,-(sp)
	move	#$26,-(sp)
	trap	#14
	addq.l	#6,sp

	move	#1,-(sp)
	move.l	#-1,-(sp)
	move.l	#-1,-(sp)
	move	#5,-(sp)
	trap	#14
	add.l	#12,sp

	clr	-(sp)
	trap	#1
programe 
;	crВe la table de corespondance des caracteres
	move	#91,d0
	lea.l	caractere,a0
	move.l	#chr_des,d1
boucle	add.l	d1,(a0)+
	dbra	d0,boucle
	move.l	#text,cotext
;	adresse de l'ecran   + effacer l'ecran
	move.l	$ffff8200.w,d0
	lsl	#8,d0
	movea.l	d0,a0
	move.l	d0,adrscr
	move.l	#7999,d0
eff 	clr.l	(a0)+
	dbra	d0,eff
	lea	music,a0
	moveq	#3,d0
	jsr	(a0)
	move.b	$fffa07,v_fffa07
	clr.b	$fffa07
	move.b	$fffa09,v_fffa09
	clr.b	$fffa09
	bset	#0,$fffa07
	move.b	$fffa13,v_fffa13
	bset	#0,$fffa13
	move.l	$120,v_120
	move.l	#hbl,$120
	move.b	$fffa1b,v_fffa1b
	move.b	#8,$fffa1b
	move.b	$fffa21,v_fffa21
	move.b	#1,$fffa21	
	move.l	$70,v_70
	move.l	#vbl2,$70
	movea.l	#table_c,a6
	move.l	#dessin1,adrsv
	lea.l	couleurs,a0
	movea.l	#$ff8240,a1
	REPT 8
	move.l	(a0)+,(a1)+
	ENDR 
;	affiche l'ecran
	movea.l	adrscr,a0
	lea.l	dessin2,a1
	move	#99,d0
	move.l	#$0,$ff8240
	move.l	#$07700770,$ff8244
	move.l	#$05500550,$ff8248
	move.l	#$04400440,$ff824c
	move.l	#$03300330,$ff8250
	move.l	#$02200220,$ff8254
	move.l	#$01100110,$ff8258
	move.l	#$00000777,$ff825c
aff_scr	REPT 5
	clr	(a0)+
	clr	(a0)+
	clr	(a0)+
	clr	(a0)+
	ENDR 
	REPT 10
	clr	(a0)+
	move	(a1)+,(a0)+
	move	(a1)+,(a0)+
	move	(a1)+,(a0)+
	ENDR 
	REPT 5
	clr	(a0)+
	clr	(a0)+
	clr	(a0)+
	clr	(a0)+
	ENDR 
;	         attendre une synchro ecran.
	move.b    #0,flag_vbl
vsync	cmpi.b    #1,flag_vbl
	bne       vsync
	dbra      d0,aff_scr
	move.l    #vbl,$70
big_bouc
;         effectue le scroll horizontal 8 par 8
	movea.l	adrscr,a0
	adda.l	#24156,a0
	lea.l	buffer,a1
	move.l	#48,d7
boucle_scroll
	move.b	7(a0),6(a0)
	move.b	14(a0),7(a0)
	move.b	15(a0),14(a0)
	move.b	22(a0),15(a0)
	move.b	23(a0),22(a0)
	move.b	30(a0),23(a0)
	move.b	31(a0),30(a0)
	move.b	38(a0),31(a0)
	move.b	39(a0),38(a0)
	move.b	46(a0),39(a0)
	move.b	47(a0),46(a0)
	move.b	54(a0),47(a0)
	move.b	55(a0),54(a0)
	move.b	62(a0),55(a0)
	move.b	63(a0),62(a0)
	move.b	70(a0),63(a0)
	move.b	71(a0),70(a0)
	move.b	78(a0),71(a0)
	move.b	79(a0),78(a0)
	move.b	86(a0),79(a0)
	move.b	87(a0),86(a0)
	move.b	94(a0),87(a0)
	move.b	95(a0),94(a0)
	move.b	102(a0),95(a0)
	move.b	103(a0),102(a0)
	move.b	110(a0),103(a0)
	move.b	111(a0),110(a0)
	move.b	118(a0),111(a0)
	move.b	119(a0),118(a0)
	move.b	126(a0),119(a0)
	move.b	127(a0),126(a0)
	move.b	134(a0),127(a0)
	move.b	135(a0),134(a0)
	move.b	142(a0),135(a0)
	move.b	143(a0),142(a0)
	move.b	150(a0),143(a0)
	move.b	151(a0),150(a0)
	move.b	158(a0),151(a0)
	move.b	159(a0),158(a0)
	move.b	(a1),159(a0)
	move.b	1(a1),(a1)
	move.b	2(a1),1(a1)
	move.b	3(a1),2(a1)
	move.b	4(a1),3(a1)
	move.b	5(a1),4(a1)
	addq.l	#6,a1
	adda.l	#160,a0
	dbra	d7,boucle_scroll
	addq.b	#1,cmp_car
	cmpi.b	#6,cmp_car
	bne	pass_scroll
;         afficher  le new caractere dans le buffer
	clr.b	cmp_car
	movea.l	cotext,a0
	clr.l	d7
	move.b	(a0)+,d7
	cmpa.l	#endtext,a0
	bne	found
	movea.l	#text,a0
found	move.l	a0,cotext
	lea.l	caractere,a0
	lsl	#2,d7
	movea.l	(a0,d7.w),a1
	lea.l	buffer,a0
	REPT 15
	move.l	(a1)+,(a0)+
	move.l	(a1)+,(a0)+
	move.l	(a1)+,(a0)+
	move.l	(a1)+,(a0)+
	move.l	(a1)+,(a0)+
	ENDR 
pass_scroll        
;	         attend la pression d'espace...
vsync3	cmp.l	#l150,a6
	bne	vsync3
	cmpi.b	#$39,-$3fe
	beq	sorti
	bra	big_bouc
sorti	move.b	#$7,$ff8800
	move.b	#$ff,$ff8802
	move.l	v_70,$70
	move.b	v_fffa21,$fffa21
	move.b	v_fffa1b,$fffa1b
	move.b	$fffa13,v_fffa13
	move.l	v_120,$120
	move.b	v_fffa09,$fffa09
	move.b	v_fffa07,$fffa07
	move.l	#$07770000,$ff8240
	move	#$0000,$ff825e
	rts       
;------------------------------------------------
;|	les routines VBL & HBL		|
;------------------------------------------------
hbl	move.l	(a6)+,$ff8240
	move	(a6)+,$ff8244
	cmp.l	#l150,a6
	bne	hblr
	move.l	#0,$ff8242
	move.l	#0,$ff8246
	move.l	#0,$ff824a
	move.l	#0,$ff824e
	move.l	#0,$ff8252
	move.l	#0,$ff8256
	move.l	#0,$ff825a
	move.l	#0,$ff825e
hblr	bclr	#0,$fffa0f	;fin iterup pour mfp
	rte       
vbl2	movem.l	a0-a1,-(sp)
	lea.l	couleurs,a0
	lea	$ffff8240.w,a1
	REPT 8
	move.l	(a0)+,(a1)+
	ENDR
	lea	table_c,a6
	move.b	#1,flag_vbl
	movem.l	(sp)+,a0-a1
	rte       
vbl	movea.l	#table_c,a6
	movem.l	d0-d7/a0-a5,-(sp)
	lea.l	couleurs,a0
	lea	$ffff8240.w,a1
	REPT 8
	move.l	(a0)+,(a1)+
	ENDR 
	movem.l	d0-a6,-(sp)
	lea	music,a0
	jsr	8(a0)
	movem.l	(sp)+,d0-a6
;	         affiche les volumetres
	move.b	#8,$ff8801
	clr.l	d0
	move.b	$ff8800,d0
	movea.l	adrscr,a0
	adda.l	#18450,a0
	clr	d1
	move	#15,d2
aff_voice1	move	#$ffff,(a0)
	move	#$ffff,8(a0)
	adda.l	#160,a0
	move	d1,(a0)
	move	d1,8(a0)
	adda.l	#160,a0
	cmp.b	d0,d2
	bne	bou_vo1
	not	d1
bou_vo1	dbra	d2,aff_voice1
	move.b	#9,$ff8801
	clr.l	d0
	move.b	$ff8800,d0
	movea.l	adrscr,a0
	adda.l	#18474,a0
	clr	d1
	move	#15,d2
aff_voice2	move	#$ffff,(a0)
	move	#$ffff,8(a0)
	adda.l	#160,a0
	move	d1,(a0)
	move	d1,8(a0)
	adda.l	#160,a0
	cmp.b	d0,d2
	bne	bou_vo2
	not	d1
bou_vo2	dbra	d2,aff_voice2
	move.b	#10,$ff8801
	clr.l	d0
	move.b	$ff8800,d0
	movea.l	adrscr,a0
	adda.l	#18498,a0
	clr	d1
	move	#15,d2
aff_voice3	move	#$ffff,(a0)
	move	#$ffff,8(a0)
	adda.l	#160,a0
	move	d1,(a0)
	move	d1,8(a0)
	adda.l	#160,a0
	cmp.b	d0,d2
	bne	bou_vo3
	not	d1
bou_vo3	dbra	d2,aff_voice3
	move.b	#1,flag_vbl
	addq.b	#1,vbl_cmp
	cmpi.b	#2,vbl_cmp
	bne	no_cylindre
	clr.b	vbl_cmp
;         cree le scrolling sur cylindre gauche
	movea.l	adrscr,a0
	movea.l	a0,a3
	adda.l	#120,a3
	movea.l	adrsv,a1
	movea.l	#table_cyl,a2
	move	#149,d1
cree_cylindre      
	movea.l	adrsv,a1
	adda.l	(a2)+,a1
	REPT 5
	move	(a1),(a0)
	move	(a1)+,(a3)
	addq.l	#8,a0
	addq.l	#8,a3
	ENDR 
	adda.l	#120,a0
	adda.l	#120,a3
	dbra	d1,cree_cylindre
	addi.l	#10,adrsv
	cmpi.l	#endessin1-1000,adrsv
	bne	no_cylindre
	move.l	#dessin1,adrsv
no_cylindre	not.b	etoile
	tst.b	etoile
	bne	fin_vbl
;	         affichage des etoile
	lea.l	pos_etoile,a1
	move	#$1d,d7
bouc1_et	clr.l	d0
	clr.l	d1
	clr.l	d2
	clr.l	d3
	clr.l	d4
	clr.l	d5
	movea.l	adrscr,a0
	adda.l	#$28,a0
	move.b	(a1)+,d1
	move.b	(a1)+,d2
	move.b	(a1)+,d3
	move.b	(a1)+,d4
	movea.l	a0,a2
	move.b	d1,d5
	andi.b	#$f0,d1
	lsr.b	#1,d1
	adda.l	d1,a2
	move.l	d2,d6
	mulu	#160,d6
	adda.l	d6,a2
	clr	(a2)
	move.b	d5,d1
	cmpi.b	#$7f,d3
	bcs	additionx
	subi.b	#$80,d3
	sub.b	d3,d1
	bra	mvty
additionx	add.b	d3,d1
mvty	cmpi.b	#$7f,d4
	bcs	additiony
	subi.b	#$80,d4
	sub.b	d4,d2
	bra	cmp_pos
additiony	add.b	d4,d2
cmp_pos	cmpi.b	#160,d1
	bcs	pos_cas2
	move.b	#$50,d1
	move.b	#$32,d2
pos_cas2	cmpi.b	#$64,d2
	bcs	aff_pts
	move.b	#$50,d1
	move.b	#$32,d2
aff_pts	subq.l	#$4,a1
	move.b	d1,(a1)+
	move.b	d2,(a1)+
	addq.l	#$2,a1
	move.b	d1,d5
	andi.b	#$f0,d1
	lsr.b	#$1,d1
	mulu	#160,d2
	adda.l	d2,a0
	adda.l	d1,a0
	andi.b	#$f,d5
	move	#-$8000,d6
	lsr	d5,d6
	move	d6,(a0)
	dbra	d7,bouc1_et
fin_vbl	movem.l	(sp)+,d0-d7/a0-a5
	rte       
	BSS 
;
;	         domaine des variables
;
;         mots long
v_70	DS.l 1
v_120	DS.l 1
adrscr	DS.l 1
adrsv	DS.l 1
cotext	DS.l 1
;	mots
	DS.w 30
buffer	DS.w 300
	DS.w 30
;	octets
v_fffa07	DS.b 1
v_fffa09	DS.b 1
v_fffa1b	DS.b 1
v_fffa21	DS.b 1
v_fffa13	DS.b 1
flag_vbl	DS.b 1
vbl_cmp	DS.b 1
etoile	DS.b 1
cmp_car	DS.b 1
	DATA 
table_cyl	dc.l 0,20,40,50,60,70,80,90,100,100,110,110,120,120,120,130,130,130,140,140,140,140,150,150,150,150,150,160,160,160,160,170,170,170,180
	dc.l 180,180,190,190,200,200,210,220,230,240,250,260,270,290,310
	dc.l 320,340,360,370,380,390,400,410,420,420,430,430,440,440,440,450,450,450,460,460,460,460,470,470,470,470,470
	dc.l 480,480,480,480,490,490,490,500,500,500,510,510,520,520,530,540,550,560,570,580,590,610,630
	dc.l 640,660,680,690,700,710,720,730,740,740,750,750,760,760,760,770,770,770,780,780,780,780,790,790,790,790,790
	dc.l 800,800,800,800,810,810,810,820,820,820,830,830,840,840,850,860,870,880,890,900,910,930,950
	dc.l 960,980,1000,1010,1020,1030,1040,1050,1060,1060,1070,1070,1080,1080,1080,1090,1090,1090,1100,1100,1100
	dc.l 1100,1110,1110,1110,1110,1110,1120,1120,1120,1120,1130,1130,1130,1140,1140,1140,1150,1150,1160,1160,1170,1180,1190,1200,1210
	dc.l 1220,1240,1260
couleurs	dc.w $0,$0,$770,$770,$550,$550,$440,$440,$330,$330,$220,$220,$110,$110,$0,$777
pos_etoile	dc.b 0,0,1,2
	dc.b 97,12,3,0
	dc.b 150,80,1,3
	dc.b 100,50,2,2
	dc.b 50,100,1,1
	dc.b 46,79,0,3
	dc.b 155,98,1,2
	dc.b 33,60,2,1
	dc.b 0,0,129,2
	dc.b 97,12,131,0
	dc.b 150,80,129,3
	dc.b 100,50,130,2
	dc.b 50,100,129,1
	dc.b 46,79,128,3
	dc.b 155,98,129,2
	dc.b 33,60,130,1
	dc.b 0,0,1,130
	dc.b 97,12,3,128
	dc.b 150,80,1,131
	dc.b 100,50,2,130
	dc.b 50,100,1,129
	dc.b 46,79,0,131
	dc.b 155,98,1,130
	dc.b 33,60,2,129
	dc.b 0,0,129,129
	dc.b 97,12,131,128
	dc.b 150,80,129,131
	dc.b 100,50,130,130
	dc.b 50,100,129,129
	dc.b 46,79,128,131
	dc.b 155,98,129,130
	dc.b 33,60,129,130
	dc.b 64,72,4,129
	dc.b 72,64,129,4
table_c	rept	2
	dc.w $0001,$0100,$770
	dc.w $0009,$0900,$770
	dc.w $0002,$0200,$770
	dc.w $000A,$0A00,$770
	dc.w $0003,$0300,$770
	dc.w $0003,$0300,$770
	dc.w $000B,$0B00,$770
	dc.w $000B,$0B00,$770
	dc.w $0004,$0400,$770
	dc.w $0004,$0400,$770
	dc.w $000C,$0C00,$770
	dc.w $000C,$0C00,$770
	dc.w $0005,$0500,$770
	dc.w $0005,$0500,$770
	dc.w $0005,$0500,$770
	dc.w $000D,$0D00,$770
	dc.w $000D,$0D00,$770
	dc.w $000D,$0D00,$770
	dc.w $0006,$0600,$770
	dc.w $0006,$0600,$770
	dc.w $0006,$0600,$770
	dc.w $000E,$0E00,$770
	dc.w $000E,$0E00,$770
	dc.w $000E,$0E00,$770
	dc.w $0007,$0700,$770
	dc.w $0007,$0700,$770
	dc.w $0007,$0700,$770
	dc.w $0007,$0700,$770
	dc.w $000E,$0E00,$770
	dc.w $000E,$0E00,$770
	dc.w $000E,$0E00,$770
	dc.w $0006,$0600,$770
	dc.w $0006,$0600,$770
	dc.w $0006,$0600,$770
	dc.w $000D,$0D00,$770
	dc.w $000D,$0D00,$770
	dc.w $000D,$0D00,$770
	dc.w $0005,$0500,$770
	dc.w $0005,$0500,$770
	dc.w $000C,$0C00,$770
	dc.w $000C,$0C00,$770
	dc.w $0004,$0400,$770
	dc.w $0004,$0400,$770
	dc.w $000B,$0B00,$770
	dc.w $000B,$0B00,$770
	dc.w $0003,$0300,$770
	dc.w $000A,$0A00,$770
	dc.w $0002,$0200,$770
	dc.w $0009,$0900,$770
	dc.w $0001,$0100,$770
	endr
	dc.w $0001,$0100,$010
	dc.w $0009,$0900,$090
	dc.w $0002,$0200,$020
	dc.w $000A,$0A00,$0A0
	dc.w $0003,$0300,$030
	dc.w $000B,$0B00,$0B0
	dc.w $0004,$0400,$040
	dc.w $0004,$0400,$040
	dc.w $000C,$0C00,$0C0
	dc.w $000C,$0C00,$0C0
	dc.w $0005,$0500,$050
	dc.w $0005,$0500,$050
	dc.w $000D,$0D00,$0D0
	dc.w $000D,$0D00,$0D0
	dc.w $000D,$0D00,$0D0
	dc.w $0006,$0600,$060
	dc.w $0006,$0600,$060
	dc.w $0006,$0600,$060
	dc.w $000E,$0E00,$0E0
	dc.w $000E,$0E00,$0E0
	dc.w $000E,$0E00,$0E0
	dc.w $0007,$0700,$070
	dc.w $0007,$0700,$070
	dc.w $0007,$0700,$070
	dc.w $0007,$0700,$070
	dc.w $0007,$0700,$070
	dc.w $0007,$0700,$070
	dc.w $0007,$0700,$070
	dc.w $000E,$0E00,$0E0
	dc.w $000E,$0E00,$0E0
	dc.w $000E,$0E00,$0E0
	dc.w $0006,$0600,$060
	dc.w $0006,$0600,$060
	dc.w $0006,$0600,$060
	dc.w $000D,$0D00,$0D0
	dc.w $000D,$0D00,$0D0
	dc.w $0005,$0500,$050
	dc.w $0005,$0500,$050
	dc.w $0005,$0500,$050
	dc.w $000C,$0C00,$0C0
	dc.w $000C,$0C00,$0C0
	dc.w $0004,$0400,$040
	dc.w $0004,$0400,$040
	dc.w $000B,$0B00,$0B0
	dc.w $000B,$0B00,$0B0
	dc.w $0003,$0300,$030
	dc.w $000A,$0A00,$0A0
	dc.w $0002,$0200,$020
	dc.w $0009,$0900,$090
	dc.w $0001,$0100,$010
l150:	dc.w $0000,$0000,$000
	dc.w $0001,$0100,$110
	dc.w $0009,$0200,$990
	dc.w $0002,$0200,$220
	dc.w $000A,$0300,$AA0
	dc.w $0003,$0300,$330
	dc.w $0003,$0300,$330
	dc.w $000B,$0400,$BB0
	dc.w $000B,$0400,$BB0
	dc.w $0004,$0400,$440
	dc.w $0004,$0400,$440
	dc.w $000C,$0500,$CC0
	dc.w $000C,$0500,$CC0
	dc.w $0005,$0500,$550
	dc.w $0005,$0500,$550
	dc.w $0005,$0500,$550
	dc.w $000D,$0600,$DD0
	dc.w $000D,$0600,$DD0
	dc.w $000D,$0600,$DD0
	dc.w $0006,$0600,$660
	dc.w $0006,$0600,$660
	dc.w $0006,$0600,$660
	dc.w $000E,$0700,$EE0
	dc.w $000E,$0700,$EE0
	dc.w $000E,$0700,$EE0
	dc.w $0007,$0700,$770
	dc.w $0007,$0700,$770
	dc.w $0007,$0700,$770
	dc.w $0007,$0700,$770
	dc.w $000E,$0600,$EE0
	dc.w $000E,$0600,$EE0
	dc.w $000E,$0600,$EE0
	dc.w $0006,$0600,$660
	dc.w $0006,$0600,$660
	dc.w $0006,$0600,$660
	dc.w $000D,$0500,$DD0
	dc.w $000D,$0500,$DD0
	dc.w $000D,$0500,$DD0
	dc.w $0005,$0500,$550
	dc.w $0005,$0500,$550
	dc.w $000C,$0400,$CC0
	dc.w $000C,$0400,$CC0
	dc.w $0004,$0400,$440
	dc.w $0004,$0400,$440
	dc.w $000B,$0300,$BB0
	dc.w $000B,$0300,$BB0
	dc.w $0003,$0300,$330
	dc.w $000A,$0200,$AA0
	dc.w $0000,$0200,$220
	dc.w $0000,$0100,$990
	dc.w $0000,$0000,$0
dessin1	
	ds.b	1000
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0011111000000000,%1000001011101110,%1000001111000000,%0100001111011110,%0111100000000000	   
	dc.w %0010001000000000,%1000001001000100,%1000001000000000,%0100001001010000,%0100100000000000	   
	dc.w %0011111000000000,%1000001001000100,%1000001110000000,%0100001001010111,%0100100000000000	   
	dc.w %0010001000000000,%1000001001000100,%1000001000000000,%0100001001010010,%0100100000000000	   
	dc.w %0010001000000000,%1111101001000100,%1111101111000000,%0111101111011110,%0111100000000000	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000111011,%1101110000011110,%1000100000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000100010,%0101001000010010,%1000100000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000110010,%0101110000011110,%1000100000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000100010,%0101001000010010,%1000100000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000100011,%1101001000010010,%1110111000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %1100000011001111,%0111111000111111,%0111111000110011,%1111111111111101,%1111011110011111	   
	dc.w %1110000111001111,%0111111100111111,%0111111100110011,%1111111111111101,%1111011111011111	   
	dc.w %1111001111001100,%0110000000110011,%0110000010110011,%1100000000110001,%1000011011011000	   
	dc.w %1101111011001110,%0110011110111111,%0111111110110011,%1111110000110001,%1110011110011111	   
	dc.w %1100110011001100,%0110000100111111,%0110000010110011,%0000110000110001,%1000011011000011	   
	dc.w %1100000011001111,%0111111100110011,%0111111110111111,%0000110000110001,%1111011011011111	   
	dc.w %1100000011001111,%0111111100110011,%0111111100111111,%1111110000110001,%1111011011011111	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000010010,%0100100000000000	   
	dc.w %0000000100000101,%1110100000101111,%1001111011110011,%1110000000010010,%0100100000000000	   
	dc.w %0000000110001101,%0000110001101000,%1001000010001010,%0000000000010010,%0100100000000000	   
	dc.w %0000000101010101,%0000101010101111,%0001000011110010,%0000000000010010,%0100100000000000	   
	dc.w %0000000100100101,%1100100100101000,%1101110010100011,%1110000000010010,%0100100000000000	   
	dc.w %0000000100000101,%0000100000101000,%0101000010010000,%0010000000000000,%0000000000000000	   
	dc.w %0000000100000101,%1110100000101111,%1101111010001011,%1110000000010010,%0100100000000000	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	incbin	n_logo.inc
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000001111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000	   
	dc.w %0000111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000	   
	dc.w %0000111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000	   
	dc.w %0000001111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0011111111111100,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000000,%0011111111111100,%0000000000001000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000000,%0101011010010010,%0000000000010000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000000,%0101011010010010,%0000001111100000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000011,%1101011010010011,%1111110000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000010,%0101011010010010,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000010,%0101011010010010,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000100,%0011111111111100,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000001111000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000110000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0001111000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0001111111111000,%1111111111110000,%0111111001100000,%0110011001111111	   
	dc.w %0000000000000000,%0001111111111000,%1111111111111000,%1111111101110000,%0110011011111110	   
	dc.w %0000000000000000,%0001111111111000,%1111111111111100,%1100001101111000,%0110000011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111100000011100,%1100001101101100,%0110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111100000011100,%1100001101100110,%0110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111111111111000,%1100001101100011,%0110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111111111110000,%1100001101100001,%1110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111101100000000,%1100001101100000,%1110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111100110000000,%1100001101100000,%0110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111100011000000,%1100001101100000,%0110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111100001100000,%1100001101100000,%0110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111100000110000,%1100001101100000,%0110011011000000	   
	dc.w %0000000000000000,%0001111111111000,%1111100000011000,%1111111101100000,%0110011011111110	   
	dc.w %0000000000000000,%0000111111110000,%0111000000001100,%0111111001100000,%0110011001111111	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   
	dc.w %0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000	   

	dc.w %1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111	   
	dc.w %1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001	   
	dc.w %1000011111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000001	   
	dc.w %1000111111111111,%1111111110000000,%0000000000000000,%0000000000111111,%1111111111110001	   
	dc.w %1000111111111111,%1111111100000000,%0000000000000000,%0000000000111111,%1111111111100001	   
	dc.w %1000111000000000,%0000000000000000,%0000000000000000,%0000000000110000,%0000011000000001	   
	dc.w %1000111000000000,%0000000000000000,%0000000000000000,%0000000000110000,%0000011000000001	   
	dc.w %1000111000000000,%0000000000000000,%0000000000000000,%0000000000110000,%0000011000000001	   
	dc.w %1000111000000000,%0000000000000000,%0000000000000000,%0000000000110000,%0000011000000001	   
	dc.w %1000111111111110,%0000000000110000,%0011011111111111,%1111111000110000,%0000011000000001	   
	dc.w %1000111111111111,%0000000000110000,%0011011111111110,%1111111100110000,%0000011000000001	   
	dc.w %1000111111111110,%0000000000011000,%0110011000000000,%1100001100110000,%0000011000000001	   
	dc.w %1000111000000000,%0000000000011000,%0110011000000000,%1100001100111111,%0000011000000001	   
	dc.w %1000111000000000,%0000000000001100,%1100011111110000,%1111111000111111,%0000011000000001	   
	dc.w %1000111000000000,%0000000000001100,%1100011111100000,%1111110000000011,%0000011000000001	   
	dc.w %1000111111111111,%1111111100000111,%1000011111110000,%1101100000000011,%0000011000000001	   
	dc.w %1000111111111111,%1111111110000111,%1000011000000000,%1100110000000011,%0000011000000001	   
	dc.w %1000111111111111,%1111111110000011,%0000011000000000,%1100110000000011,%0000011000000001	   
	dc.w %1000111111111111,%1111111110000011,%0000011111111110,%1100011000111111,%0000011000000001	   
	dc.w %1000011111111111,%1111111100000011,%0000011111111111,%1100011001111111,%0000011000000001	   
	dc.w %1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001	   
	dc.w %1000000000000000,%0000000000000000,%0010000000000000,%0000000000000000,%0000000000000001	   
	dc.w %1000000000000000,%0000000000000000,%0111000000000100,%0000000000001111,%1100111111111001	   
	dc.w %1000000000000000,%0000000000000000,%1111100000001010,%0000000000000000,%0000111111111001	   
	dc.w %1000000000000000,%0000000000000001,%1110010000010001,%0000000000000000,%1100011111111001	   
	dc.w %1000000000000000,%0000000000000010,%0100001000100000,%1000000000000011,%0000011111111001	   
	dc.w %1000000000000000,%0000000000000100,%0000000101000000,%0100000000000000,%0001001111111001	   
	dc.w %1000000000000000,%0000000000001000,%0000000010000000,%0010000000000000,%0010000111111001	   
	dc.w %1000000000000000,%0000000000010000,%0000000001000000,%0001000000000000,%0100010001111001	   
	dc.w %1000000000000000,%0000000000100000,%0000000000100000,%0000100000000000,%1000010000000001	   
	dc.w %1000000000000000,%0000000001000000,%0000000000000000,%0000000000000000,%0000100000000001	   
	dc.w %1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001	   
	dc.w %1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111	   

	dc.w %1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111	   
	dc.w %1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001	   
	dc.w %1010000000000010,%0111111111111110,%0111111111111110,%0111111111111110,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0100000000000000,%0100000000000010,%0000000100000001	   
	dc.w %1010000000000010,%0111111111111110,%0111111111111110,%0111111111111110,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000010000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000010000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000101000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000101000010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010001000100010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010001000100010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010010000010010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000000000001	   
	dc.w %1010010000010010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010100000001010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010100000001010,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1011000000000110,%0100000000000010,%0000000000000010,%0100000000000000,%0000000100000001	   
	dc.w %1010000000000010,%0100000000000010,%0111111111111110,%0100000000000000,%0000000100000001	   
	dc.w %1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001	   
	dc.w %1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111	   


	ds.b	1000
endessin1	
         
dessin2  
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$efff,$efff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffe,$fffe,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e3ff,$e3ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff8,$fff8,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e5ff,$e1ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffb,$fff0,$fff4,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e6ff,$e0ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffb,$ffc8,$ffc4,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e73f,$e03f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffb8,$ff80,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e3df,$e01f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff78,$ff00,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e3e7,$e007,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fcf0,$fc00,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e1fb,$e003,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fbf0,$f800,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e1fd,$e001,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e7e0,$e000,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e1fe,$e000,$ffff,$7fff,$7fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$dfe0,$c000,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e0ff,$e000,$ffff,$bfff,$3fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$3fc0,$0,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e0ff,$e000,$ffff,$cfff,$fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffe,$fffe,$ffff,$ffc0,$0,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e07f,$e000,$ffff,$f7ff,$7ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffd,$fffc,$fffe,$ffc1,$0,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$e07f,$e000,$ffff,$f9ff,$1ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff3,$fff0,$fffe,$ff81,$0,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$f7fe,$f83f,$f000,$ffff,$feff,$ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffef,$ffe0,$f7fd,$ff83,$1,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$f7fe,$f83f,$f000,$3fff,$ff7f,$7f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff9f,$ff80,$c7fd,$ff03,$1,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$f7ff,$f83f,$f000,$5fff,$bf9f,$401f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff7f,$ff00,$affd,$df03,$2001,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fbbf,$fc5f,$f800,$6fff,$9fef,$600f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fcff,$fc00,$6f7b,$9e87,$6003,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fbbf,$fc5f,$f800,$77ff,$8ff3,$7003,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffc,$fbff,$f800,$ef7b,$1e87,$e003,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fd9f,$fe6f,$fc00,$39ff,$c7fd,$3801,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffb,$e7fc,$e003,$df77,$3e8f,$c007,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fd9e,$fe6f,$fc00,$3eff,$c1fe,$3e00,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffe7,$dff8,$c007,$de77,$3d8f,$c007,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fd88,$fe77,$fc00,$1f7f,$e0ff,$1f00,$ffff,$3fff,$3fff,$ffff,$ffff,$ffff,$ffdf,$bfe0,$801f,$8e77,$7d8f,$8007,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fe88,$ff77,$fe00,$1f9f,$e07f,$1f80,$ffff,$dfff,$1fff,$ffff,$fffe,$fffe,$ffbf,$7fc0,$3f,$806f,$7f9f,$800f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fe88,$ff77,$fe00,$1fef,$e01f,$1fe0,$e7ff,$ffff,$7ff,$fffd,$fffb,$fff8,$fe7e,$ff81,$7f,$46f,$fb9f,$f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$7fff,$ffff,$ffff,$ffff,$ffff,$ff04,$fffb,$ff00,$7f7,$f80f,$ff0,$ffff,$fbff,$3ff,$fffb,$fff7,$fff0,$fdfd,$fe03,$1ff,$85f,$f7bf,$1f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff04,$fffb,$ff00,$1f9,$f607,$ff8,$ffff,$fdff,$1ff,$ffef,$ffff,$ffe0,$f3f3,$fc0f,$3ff,$85f,$f7bf,$1f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff02,$fffd,$ff00,$6fe,$ff01,$7fe,$ffff,$fe7f,$7f,$ff9f,$ffff,$ff80,$efee,$f01f,$ffe,$83f,$f7ff,$3f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff82,$fffd,$ff80,$77f,$ff80,$7ff,$7fff,$ffbf,$3f,$ff7f,$ffff,$ff00,$dfde,$e03f,$1ffe,$103f,$efff,$3f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff81,$fffe,$ff80,$39f,$ffe0,$3ff,$9fff,$7fcf,$800f,$ffff,$fcff,$fc00,$3f3c,$c0ff,$3ffc,$103f,$efff,$3f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffc1,$fffe,$ffc0,$3ef,$fff0,$3ff,$efff,$1ff7,$e007,$fffe,$f9ff,$f800,$fefc,$1ff,$fffc,$207f,$dfff,$7f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffc1,$fffe,$ffc0,$7f7,$fbf8,$3ff,$f7ff,$ffb,$f003,$fff9,$f7fe,$f001,$fdfa,$3fd,$fff8,$207f,$dfff,$7f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffc1,$ffff,$ffc0,$9df9,$63fe,$1ff,$f9ff,$7fc,$f800,$fff7,$cff8,$c007,$f3fb,$ffc,$fff8,$20ff,$dfff,$ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffe1,$ffff,$ffe0,$fdfe,$3ff,$1ff,$feff,$1ff,$fe00,$ffef,$3ff0,$f,$eff7,$1ff8,$fff0,$e0ff,$3fff,$ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffe1,$ffff,$ffe0,$feff,$81ff,$ff,$7f7f,$80ff,$ff00,$ff9f,$ffe0,$1f,$dff7,$3ff8,$fff0,$e1ff,$3fff,$1ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff1,$ffff,$fff0,$feff,$81ff,$ff,$9f80,$e040,$ffbf,$3f,$0,$ffff,$bff7,$7ff8,$fff0,$e1ff,$7fff,$1ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff1,$ffff,$fff0,$feff,$c1ff,$ff,$ef00,$f000,$ffff,$1e,$1,$ffff,$7fef,$fff0,$ffe0,$e1ff,$7fff,$1ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff1,$ffff,$fff0,$ff7f,$c0ff,$7f,$f400,$f800,$ffff,$5,$3,$ffff,$ffef,$fff0,$ffe0,$e3ff,$ffff,$3ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff9,$ffff,$fff8,$ff7f,$c0ff,$7f,$fa67,$fc78,$ff80,$fccb,$3c7,$3f,$ffdf,$ffe0,$ffc0,$e3ff,$ffff,$3ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff9,$ffff,$fff8,$ffbf,$e07f,$3f,$fa67,$fc78,$ff80,$fccb,$3c7,$3f,$ffdf,$ffe0,$ffc0,$e7ff,$ffff,$7ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffd,$ffff,$fffc,$fe3f,$e1ff,$3f,$fa67,$fc78,$ff80,$f8cb,$7c7,$3f,$ffbf,$ffc1,$ff80,$e7ff,$ffff,$7ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffd,$ffff,$fffc,$fa5f,$f5bf,$1f,$fa33,$fc3c,$ffc0,$f98b,$787,$7f,$ffbf,$ffc1,$ff80,$efff,$ffff,$fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffd,$ffff,$fffc,$fa1f,$f5ff,$1f,$fa3e,$fc00,$ffff,$f8f,$7,$ffff,$ff9f,$ffe3,$ff80,$efff,$ffff,$fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffe,$ffff,$fffe,$f81f,$f7ff,$1f,$fa3e,$fc00,$ffff,$f8f,$7,$ffff,$ff07,$fffb,$ff00,$efff,$ffff,$fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fffe,$ffff,$fffe,$fc0f,$fbff,$f,$fa3e,$fc00,$ffff,$f97,$f,$ffff,$ff0b,$fff7,$ff00,$dfff,$ffff,$1fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$7c0f,$fbff,$f,$fd3e,$fe00,$ffff,$f17,$f,$ffff,$fe0f,$fff7,$fe00,$dfff,$ffff,$1fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$7e07,$fdff,$7,$fd3e,$fe01,$ffff,$f17,$f00f,$ffff,$fe0f,$fff7,$fe00,$bfff,$ffff,$3fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$7e07,$fdff,$7,$fd18,$fe07,$ffff,$317,$fc0f,$ffff,$fc1f,$ffef,$fc00,$bfff,$ffff,$3fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$bf07,$feff,$8007,$fd10,$fe0f,$ffff,$117,$fe0f,$ffff,$fc1f,$ffef,$fc00,$bfff,$ffff,$3fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$bf33,$feff,$8003,$fd00,$fe1f,$ffff,$17,$ff0f,$ffff,$f83f,$ffdf,$f800,$7fff,$ffff,$7fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$df13,$feff,$c003,$fd01,$fe01,$fffe,$817,$f80f,$7ff,$f83f,$ffdf,$f800,$7fff,$ffff,$7fff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$dec5,$fe7f,$c101,$fd01,$fe01,$fffe,$817,$f80f,$7ff,$f85e,$ff9f,$f820,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$dedf,$fe7f,$c101,$fd01,$fe01,$fffe,$81f,$f80f,$7ff,$f05e,$ff9f,$f020,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ee7e,$fe7f,$e180,$fd1f,$fe00,$ffff,$1f1f,$f,$ffff,$f45d,$ff9f,$f021,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ee7e,$fe3f,$e180,$fd1f,$fe00,$ffff,$1f2f,$1f,$ffff,$ee9d,$ff1f,$e061,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$f63e,$fe3f,$f1c0,$fd1f,$fe00,$ffff,$1f2f,$1f,$ffff,$ef1d,$ff9f,$e061,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$f63f,$fe3f,$f1c0,$7d1f,$fe00,$7fff,$1f2f,$1f,$ffff,$df1b,$fe1f,$c0e3,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$f63f,$fe3f,$f1c0,$7d1f,$fe00,$7fff,$1f2f,$1f,$ffff,$df1b,$fe1f,$c0e3,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fa1f,$fe1f,$f9e0,$bd1f,$fe00,$3fff,$1f2f,$1f,$ffff,$de17,$fc1f,$c1e7,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fa1f,$fe1f,$f9e0,$bd0f,$fe00,$3fff,$1e2f,$e01f,$ffff,$be17,$fc1f,$81e7,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fe0f,$fe0f,$fdf0,$be8c,$ff03,$3fff,$62f,$f81f,$ffff,$be0f,$fc1f,$81ef,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fc0f,$fe0f,$fdf0,$de80,$ff0f,$1fff,$2f,$fe1f,$ffff,$7c0f,$f81f,$3ef,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fc07,$fe07,$fdf8,$de80,$ff0f,$1fff,$3f,$fe1f,$ffff,$7c0f,$f81f,$3ef,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fe07,$ff07,$fef8,$ee80,$ff0f,$fff,$3e,$fe1f,$fffe,$f81f,$f03f,$7df,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fe07,$ff07,$fef8,$de8c,$ff0f,$1ff0,$e65f,$1e3f,$1ff,$781f,$f03f,$7df,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ff03,$ffc3,$ff3c,$be86,$ff07,$3ff8,$4c5f,$bc3f,$3ff,$b83f,$f0ff,$873f,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffc3,$fffb,$ffc4,$7e86,$ff07,$7ff8,$4c5f,$bc3f,$3ff,$d0ff,$e7ff,$c8ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$fff8,$ffff,$fff8,$fe86,$ff07,$fff8,$4c5f,$bc3f,$3ff,$e7ff,$ffff,$e7ff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff
	dc.w $ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff,$ffff

caractere:	
;	   adresse des caracteres
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $12c
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $258
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $384
	dc.l $0
	dc.l $4b0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $0
	dc.l $5dc
	dc.l $708
	dc.l $834
	dc.l $960
	dc.l $a8c
	dc.l $bb8
	dc.l $ce4
	dc.l $e10
	dc.l $f3c
	dc.l $1068
	dc.l $1194
	dc.l $12c0
	dc.l $13ec
	dc.l $1518
	dc.l $1644
	dc.l $1770
	dc.l $189c
	dc.l $19c8
	dc.l $1af4
	dc.l $1c20
	dc.l $1d4c
	dc.l $1e78
	dc.l $1fa4
	dc.l $20d0
	dc.l $21fc
	dc.l $2328
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
;	   dessin des caracteres
chr_des:  
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$410,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$7fff,$0
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $0,$7fff,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$410,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$7fff,$0
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $0,$7fff,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$410,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$7fff,$0
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $0,$7fff,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$410,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1,$400,$0
	dc.w $7,$df00,$0
	dc.w $1f,$ffc0,$0
	dc.w $3f,$ffe0,$0
	dc.w $7f,$fff0,$0
	dc.w $7f,$fff0,$0
	dc.w $ff,$fff8,$0
	dc.w $7f,$fff0,$0
	dc.w $7f,$fff0,$0
	dc.w $3f,$ffe0,$0
	dc.w $7f,$fff0,$0
	dc.w $7f,$fff0,$0
	dc.w $ff,$fff8,$0
	dc.w $1ff,$fff0,$0
	dc.w $7ff,$fff0,$0
	dc.w $fff,$ffe0,$0
	dc.w $1fff,$ffc0,$0
	dc.w $1fff,$ff00,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$410,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$7fff,$0
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $0,$7fff,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$410,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$7fff,$0
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $7,$ffff,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $1ff,$ffff,$ffc0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $7ff,$f007,$fff0
	dc.w $1f7,$c001,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$4000
	dc.w $1f7,$df7d,$f000
	dc.w $7ff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ffff,$ffc0
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ffff,$ffc0
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $fff,$ffff,$fe00
	dc.w $7ff,$ffff,$fc00
	dc.w $1f7,$df7d,$f000
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1,$410,$4000
	dc.w $7,$df7d,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $1ff,$ffff,$ffc0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc07,$fff0
	dc.w $1fff,$fc01,$f7c0
	dc.w $3fff,$fe00,$4100
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$4100
	dc.w $1fff,$fc01,$f7c0
	dc.w $1fff,$fc07,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1ff,$ffff,$ffc0
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$df7d,$f000
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$0
	dc.w $1f7,$df7c,$0
	dc.w $7ff,$ffff,$0
	dc.w $fff,$ffff,$8000
	dc.w $1fff,$ffff,$c000
	dc.w $1fff,$ffff,$c000
	dc.w $3fff,$ffff,$e000
	dc.w $1fff,$ffff,$f000
	dc.w $1fff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$fdff,$fffc
	dc.w $1fff,$fc7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc7f,$fffc
	dc.w $1fff,$fdff,$fffc
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ffff,$ffc0
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$fc00
	dc.w $1fff,$ffff,$f000
	dc.w $3fff,$ffff,$e000
	dc.w $1fff,$ffff,$c000
	dc.w $1fff,$ffff,$c000
	dc.w $fff,$ffff,$8000
	dc.w $7ff,$ffff,$0
	dc.w $1f7,$df7c,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$4100
	dc.w $1f7,$df7d,$f7c0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ff7d,$f7c0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe10,$4000
	dc.w $1fff,$ff7d,$f000
	dc.w $1fff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$fc00
	dc.w $1fff,$ff7d,$f000
	dc.w $3fff,$fe10,$4000
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$ff7d,$f7c0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1f7,$df7d,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$4100
	dc.w $1f7,$df7d,$f7c0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ff7d,$f7c0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe10,$4000
	dc.w $1fff,$ff7d,$f000
	dc.w $1fff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$fc00
	dc.w $1fff,$ff7d,$f000
	dc.w $3fff,$fe10,$4000
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $7ff,$f000,$0
	dc.w $1f7,$c000,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1,$410,$4100
	dc.w $7,$df7d,$f7c0
	dc.w $1f,$ffff,$fff0
	dc.w $3f,$ffff,$fff8
	dc.w $7f,$ffff,$fffc
	dc.w $7f,$ffff,$fffc
	dc.w $ff,$ffff,$fffe
	dc.w $1ff,$ffff,$fffc
	dc.w $7ff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ff7d,$f7c0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$fc7d,$f7c0
	dc.w $1fff,$fdff,$fff0
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$fdff,$fffc
	dc.w $1fff,$fc7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fffc
	dc.w $1ff,$ffff,$fffc
	dc.w $ff,$ffff,$fffe
	dc.w $7f,$ffff,$fffc
	dc.w $7f,$ffff,$fffc
	dc.w $3f,$ffff,$fff8
	dc.w $1f,$ffff,$fff0
	dc.w $7,$df7d,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$4100
	dc.w $1f7,$c001,$f7c0
	dc.w $7ff,$f007,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $7ff,$f007,$fff0
	dc.w $1f7,$c001,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1,$410,$4000
	dc.w $7,$df7d,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$ffff,$f000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $7,$ffff,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$df7d,$f000
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$4100
	dc.w $0,$1,$f7c0
	dc.w $0,$7,$fff0
	dc.w $0,$f,$fff8
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$3f,$fffe
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$f,$fff8
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$3f,$fffe
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$f,$fff8
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$3f,$fffe
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$f,$fff8
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$3f,$fffe
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $0,$f,$fff8
	dc.w $0,$1f,$fffc
	dc.w $0,$1f,$fffc
	dc.w $41,$3f,$fffe
	dc.w $1f7,$c01f,$fffc
	dc.w $7ff,$f01f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1ff,$ffff,$ffc0
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$df7d,$f000
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$4100
	dc.w $1f7,$c001,$f7c0
	dc.w $7ff,$f007,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc7f,$fffc
	dc.w $1fff,$fdff,$fffc
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ffff,$ffc0
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$fc00
	dc.w $1fff,$ffff,$f000
	dc.w $3fff,$ffff,$e000
	dc.w $1fff,$ffff,$c000
	dc.w $1fff,$ffff,$c000
	dc.w $fff,$ffff,$8000
	dc.w $1fff,$ffff,$0
	dc.w $1fff,$fffc,$0
	dc.w $3fff,$fff8,$0
	dc.w $1fff,$fffc,$0
	dc.w $1fff,$ffff,$0
	dc.w $fff,$ffff,$8000
	dc.w $1fff,$ffff,$c000
	dc.w $1fff,$ffff,$c000
	dc.w $3fff,$ffff,$e000
	dc.w $1fff,$ffff,$f000
	dc.w $1fff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$fdff,$fffc
	dc.w $1fff,$fc7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $7ff,$f007,$fff0
	dc.w $1f7,$c001,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$0
	dc.w $1f7,$c000,$0
	dc.w $7ff,$f000,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$ff7d,$f7c0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1f7,$df7d,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1040,$0,$4100
	dc.w $7df0,$1,$f7c0
	dc.w $fffc,$7,$fff0
	dc.w $fffe,$f,$fff8
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$803f,$fffe
	dc.w $ffff,$c07f,$fffc
	dc.w $ffff,$f1ff,$fffc
	dc.w $ffff,$fbff,$fff8
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffe
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fff8
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffe
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fff8
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffe
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $fffe,$ffef,$fff8
	dc.w $ffff,$7fdf,$fffc
	dc.w $ffff,$1f1f,$fffc
	dc.w $ffff,$843f,$fffe
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $fffe,$f,$fff8
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$803f,$fffe
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $fffe,$f,$fff8
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$803f,$fffe
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $fffe,$f,$fff8
	dc.w $fffc,$7,$fff0
	dc.w $7df0,$1,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$4100
	dc.w $1f7,$c001,$f7c0
	dc.w $7ff,$f007,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff1f,$fffc
	dc.w $1fff,$ffdf,$fffc
	dc.w $fff,$ffef,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$fdff,$fffc
	dc.w $1fff,$fc7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $7ff,$f007,$fff0
	dc.w $1f7,$c001,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1,$410,$4000
	dc.w $7,$df7d,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $1ff,$ffff,$ffc0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1ff,$ffff,$ffc0
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$df7d,$f000
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$4000
	dc.w $1f7,$df7d,$f000
	dc.w $7ff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ffff,$ffc0
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$fc00
	dc.w $1fff,$ff7d,$f000
	dc.w $3fff,$fe10,$4000
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $3fff,$fe00,$0
	dc.w $1fff,$fc00,$0
	dc.w $1fff,$fc00,$0
	dc.w $fff,$f800,$0
	dc.w $7ff,$f000,$0
	dc.w $1f7,$c000,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1,$410,$4000
	dc.w $7,$df7d,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $1ff,$ffff,$ffc0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff1f,$fffc
	dc.w $1fff,$ffdf,$fffc
	dc.w $fff,$ffef,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ffff,$ffc0
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fffc
	dc.w $1ff,$ffff,$fffc
	dc.w $ff,$ffff,$fffe
	dc.w $7f,$ffff,$fffc
	dc.w $7f,$ffff,$fffc
	dc.w $3f,$ffef,$fff8
	dc.w $1f,$ffc7,$fff0
	dc.w $7,$df01,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$4000
	dc.w $1f7,$df7d,$f000
	dc.w $7ff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fff0
	dc.w $1fff,$ffff,$ffc0
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $fff,$ffff,$fe00
	dc.w $1fff,$ffff,$ff00
	dc.w $1fff,$ffff,$ff00
	dc.w $3fff,$ffff,$ff80
	dc.w $1fff,$ffff,$ffc0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$fbff,$fff8
	dc.w $1fff,$fdff,$fffc
	dc.w $1fff,$fc7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $7ff,$f007,$fff0
	dc.w $1f7,$c001,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1,$410,$4000
	dc.w $7,$df7d,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $1ff,$ffff,$ffc0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc07,$fff0
	dc.w $1fff,$fc01,$f7c0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$ff7d,$f000
	dc.w $1fff,$ffff,$fc00
	dc.w $fff,$ffff,$fe00
	dc.w $7ff,$ffff,$ff00
	dc.w $1ff,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ffc0
	dc.w $7f,$ffff,$fff0
	dc.w $3f,$ffff,$fff8
	dc.w $1f,$ffff,$fffc
	dc.w $7,$df7f,$fffc
	dc.w $41,$43f,$fffe
	dc.w $1f7,$c01f,$fffc
	dc.w $7ff,$f01f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1ff,$ffff,$ffc0
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$df7d,$f000
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$4100
	dc.w $1f7,$df7d,$f7c0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1f7,$ffff,$f7c0
	dc.w $43,$ffff,$e100
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $0,$7fff,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$4100
	dc.w $1f7,$c001,$f7c0
	dc.w $7ff,$f007,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fffc
	dc.w $1ff,$ffff,$fffc
	dc.w $ff,$ffff,$fffe
	dc.w $7f,$ffff,$fffc
	dc.w $7f,$ffff,$fffc
	dc.w $3f,$ffff,$fff8
	dc.w $1f,$ffff,$fff0
	dc.w $7,$df7d,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$4100
	dc.w $1f7,$c001,$f7c0
	dc.w $7ff,$f007,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1ff,$ffff,$ffc0
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$ffff,$f000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $0,$7fff,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $1040,$0,$4100
	dc.w $7df0,$1,$f7c0
	dc.w $fffc,$7,$fff0
	dc.w $fffe,$f,$fff8
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$803f,$fffe
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $fffe,$f,$fff8
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$803f,$fffe
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $fffe,$f,$fff8
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$843f,$fffe
	dc.w $ffff,$1f1f,$fffc
	dc.w $ffff,$7fdf,$fffc
	dc.w $fffe,$ffef,$fff8
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffe
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fff8
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffe
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fff8
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffe
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$ffff,$fffc
	dc.w $ffff,$fbff,$fff8
	dc.w $ffff,$f1ff,$fffc
	dc.w $ffff,$c07f,$fffc
	dc.w $ffff,$803f,$fffe
	dc.w $ffff,$1f,$fffc
	dc.w $ffff,$1f,$fffc
	dc.w $fffe,$f,$fff8
	dc.w $fffc,$7,$fff0
	dc.w $7df0,$1,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$4100
	dc.w $1f7,$c001,$f7c0
	dc.w $7ff,$f007,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1ff,$ffff,$ffc0
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$ffff,$f000
	dc.w $3,$ffff,$e000
	dc.w $7,$ffff,$f000
	dc.w $1f,$ffff,$fc00
	dc.w $3f,$ffff,$fe00
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $ff,$ffff,$ff80
	dc.w $1ff,$ffff,$ffc0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ff7f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $7ff,$f007,$fff0
	dc.w $1f7,$c001,$f7c0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$0,$4100
	dc.w $1f7,$c001,$f7c0
	dc.w $7ff,$f007,$fff0
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $fff,$f80f,$fff8
	dc.w $1fff,$fc1f,$fffc
	dc.w $1fff,$fc1f,$fffc
	dc.w $3fff,$fe3f,$fffe
	dc.w $1fff,$ff7f,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1ff,$ffff,$ffc0
	dc.w $ff,$ffff,$ff80
	dc.w $7f,$ffff,$ff00
	dc.w $7f,$ffff,$ff00
	dc.w $3f,$ffff,$fe00
	dc.w $1f,$ffff,$fc00
	dc.w $7,$ffff,$f000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $3,$ffff,$e000
	dc.w $1,$ffff,$c000
	dc.w $1,$ffff,$c000
	dc.w $0,$ffff,$8000
	dc.w $0,$7fff,$0
	dc.w $0,$1f7c,$0
	dc.w $0,$0,$0
	dc.w $0,$0,$0
	dc.w $41,$410,$4100
	dc.w $1f7,$df7d,$f7c0
	dc.w $7ff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fffc
	dc.w $1f7,$df7f,$fffc
	dc.w $41,$43f,$fffe
	dc.w $0,$7f,$fffc
	dc.w $0,$1ff,$fffc
	dc.w $0,$3ff,$fff8
	dc.w $0,$7ff,$fff0
	dc.w $0,$7ff,$ffc0
	dc.w $0,$fff,$ff80
	dc.w $0,$1fff,$ff00
	dc.w $0,$7fff,$ff00
	dc.w $0,$ffff,$fe00
	dc.w $1,$ffff,$fc00
	dc.w $1,$ffff,$f000
	dc.w $3,$ffff,$e000
	dc.w $7,$ffff,$c000
	dc.w $1f,$ffff,$c000
	dc.w $3f,$ffff,$8000
	dc.w $7f,$ffff,$0
	dc.w $7f,$fffc,$0
	dc.w $ff,$fff8,$0
	dc.w $1ff,$fff0,$0
	dc.w $7ff,$fff0,$0
	dc.w $fff,$ffe0,$0
	dc.w $1fff,$ffc0,$0
	dc.w $1fff,$ff00,$0
	dc.w $3fff,$fe10,$4100
	dc.w $1fff,$ff7d,$f7c0
	dc.w $1fff,$ffff,$fff0
	dc.w $fff,$ffff,$fff8
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $3fff,$ffff,$fffe
	dc.w $1fff,$ffff,$fffc
	dc.w $1fff,$ffff,$fffc
	dc.w $fff,$ffff,$fff8
	dc.w $7ff,$ffff,$fff0
	dc.w $1f7,$df7d,$f7c0
;         octets
text	dc.b "                      EH! GUYS   I'M VERY PROUD TO PRESENT YOU,MY FIRST DEMO SCREEN FOR"
	dc.b " THIS NEW DEMO,MADE BY A NEW CREW ... THE MEGABUSTERS!!! I WANT TO GIVE SPECIAL GREETINGS TO MY "
	dc.b " GREAT CODING FRIEND    TRONIC  ,CONGRATULATIONS FOR YOUR VERY NICE MAIN MENU AND FOR THIS MUSIC "
	dc.b " THAT YOU HAVE GIVE ME... AND OTHER GREETING COME TO WANTED AND ULTIMA ZOZOR MY BEST GRAPHIXX MEN"
	dc.b " AND AN LAST GREET TO DEJAYBEE AN NEW CODER OF MEGABUSTER... AND OF COURSE, GREETING TO ALL MEMBER "
	dc.b " OF CREW... I WANT TO EXPLICAT YOU THE CAUSE OF THIS SCREEN... I HAVE MAKE IT TO FORCE ALL MEMBERS TO MAKE A"
	dc.b " LITTLE CONTRIBUTION THIS CONTRIBUTION IS THE NAME LOGO THAT SLIDES ON THE CYLINDERS... SO AT THIS TIME THIS SCREEN"
	dc.b " ISN'T FINISHED AND I'M SORRY BUT I STOP WRITING TEXT...... BYE!...... MEGABUSTERS RULES....."
	dc.b "	NOW I'M IN THE OLD HOUSE OF THE MEGABUSTERS CODING PARTY! WHY ARE ELEVEN MEMBER OF THE GREET MEGABUSTERS"
	DC.B " ,TOM'S(THE COOKER),OXWALD (HOW WORK ON GEN ST ,THE FIRST SCREEN ,WHEN YOU LOAD),L'AVENTURIER(HE ISN'T A MEMBER OF THE CREW,AND HE'S THE ONLY GUEST CODER)"
	DC.B " DJAYBEE(THE GREET CODER OF THE MAIN MENU),WANTED AND GRIZZO WORK ON DELUXE PAINT TO MAKE SOME LOGO,IN THIS SCREEN, WANTED(MAKE THE GRAPHIXX OF DJAYBEE'S MEGAFULL) "
	DC.B " STORM AND EVERST PLAY GRAND PRIX II (OH!!! LAMERS!!!! STORM IS A REALY GREET LAMER!!!!).EVERST IS A LITTLE GFA CODER AND A BAD ASM CODER... I THINK I STOP THE SCROLL "
	DC.B " FOR INCLUDE SOME GRAPHIXS LOGO IN THIS DEMO... THIS C.P. HIS A GREET DELIROUS C.P. OF A WEEK!!! BYE I RESTART WRITING THE TEXT AFTER THE C.P."
	DC.B "      EH!!! NOW I AM AT SCHOOL THE END MAY 91 , I WORK A LITTLE IN THE 'CLUB INFORMATIQUE DU LYCEE' AND I'M WITH EVERST... TWO WEEK PAST,DJAYBEE HAVE WRITE ON THIS MINITEL:"
	DC.B " I WAN'T ABSOLUTLY NO LAMERS IN THE CREW!!!! SO, NOW WE ARE ONLY FOURTEN MEMBERS IN THE MEGABUSTERS, ISTERIC,JOUST,BST,BERST,STORM,CATLORD,TIGER STREET,AND EVERST WERE SUPPRIMED!!!"
	DC.B " THAT'S BAD,'CAUSE THEY ARE NOT GOOD, BUT THEY WERE MY FRIENDS... I HAVE SAVED OUTLAW,BECAUSE THEY MAKE GREAT NO TECHNICAL SOLUTION OF ALL EXTERNAL PROBLEM!"
	DC.B "     THE MEGA PARTY OF THE MEGABUSTERS WAS A TOTAL SUCCES!,VERY FUNY,VERY LONG,VERY GREAT AND VERY BUSTERS AND VERY ... , AND VERY ... AND VERY ... DARKMOON WANT SEE THAT SCROLL SO,I STOP HERE FOR TWO MINUTES..."
	DC.B "                 IN REALTY I STOP A VERY LONG TIME,BECAUSE, NOW I'AM AT THE END OF THE REALISATION OF SPACE DEMO. LAST NIGHT,TRONIC COME WITH JAILE , THEY HAVE SOME PACKING PROBLEM,US ROUTINE WAS BAD. NOW SHE RUN VERY WELL..."
	DC.B " I WANT MAKE A LITTLE FRENCH SPEACK, BECAUSE I'M A ENGLISH LAMER.  J'AI ECRIS LA TOTALITE DE SE SCROLL , EN PLUS DE DIX MOIS!!! MAIS JE VAIS UN PEU VOUS EXPLIQUER CE QUI C'EST PASSE:"
	DC.B " J'AI CONCU ET REALISE CETTE DEMO LA VEILLE DE LA TOUSSAINT DE L'AN DERNIER,EN QUARTE-VINGT-DIX, JUSTE AVANT D'ALLER A AGEN,POUR VOIR OXWALD,ET LES FLYING WALES. LES FLYING WALES ETAIT COMPOSE DE DJAYBEE,GRIZZO,WASP,MOBY DICK,BINOUIT"
	DC.B " J'ETAIS ALLER LA-BAS POUR APRENDRE LES RUDIMENTS DE L'ASSEMBLEUR A DJAYBEE,ET OXWALD, LE PREMIER CODANT EN STOS ET L'AUTRE EN GFA BASIC... A L'EPOUE, JE CODAIS DEPUIS MOIN DE QUATRE MOIS, EN ASSEMBLEUR, ET J'UTILISAIS ALORS NON PAS"
	DC.B " GEN ST MAIS LE GFA ASSEMBLEUR, D'AILLEUR LE SOURCE DE CETTE DEMO ETAIT A L'ORIGINE EN GFA ASM... J'AI DECOUVERT EN DJAYBEE, UNE VOLONTE A TOUTE EPREUVE,ET J'EN FU ENCHANTER CAR LES F.W. ALLER ETRE DES MB. LA TOUTE PREMIERE PARTI DU"
	DC.B " SCROLL FUT REDIGER A CE MOMENT LA... LE DEUSIEME POINT FORT, SE PRODUISI EN JANVIER QUARTE-VINGT-ONZE KAN,AVEC TRONIC,NOUS PARTIME LE JOUR DE L'AN CHER JAILE, A LILLE.CA FAISAIT QUAND MEME UNE TROTE,PRESQUE MILLE KILOMETRE, NOUS"
	DC.B " HABITONS DANS LES HAUTES ALPES, MOI ET TRONIC. ON AVAIT ETE INVITE A LA CODING PARTY DES FIREWAHKS,ELLE FUT D'AILLEUR BIEN ORGANISE... J'AI ECRIS ENSUITE, LORS DE LA REUNION DES MEGABUSTERS,PAS TRES LOIN DE CHEZ MOI."
	DC.B " MES HOTES ETAIENT :TRONIC,JAILE,OXWALD,DJAYBEE,EVERST,STORM,DARKMOON,GRIZZO,WANTED,ULTIMAZOZORE,TOM'S,JOUST... C ALORS QUE DJAYBEE,ET LES AUTRE BON CODERS, PURENT ENFIN CE CONNAITRE. GRACE A OUTLAW, CETTE REUNION D'UNE SEMAINE FUT"
	DC.B " PARFAITE. DE PLUS NOUS AVIONS UN CUISINER!!!! TOM'S, FAISAIT LA CUISINE, ET AS DE LA MAUVAISE!!!!!!!!!!. QUELQUES TEMPS APRES CELA,DJAYBEE, ME DIS QUE LE GROUPE COMPORTAIT BEAUCOUP DE LAMER,C'ETAIT MAFOIS VRAIS... ET QUE LUI REFUSAIT"
	DC.B " DE CREE DES DEMOS, POUR PARLER DE TOUT CES CRETINS KI NI COMPRENAIS RIEN!!! LE GROUPE QUI ETAIT ALORS COMPOSE DE VINGT ET UNE PERSONNES, DESCENDIS A QUATORZE. BIENTOT TOUTE FOIS EVERST,REINCORPORA THE MEGABUSTERS, CAR IL AVAIT"
	DC.B " DURMEMENT TRAVAILLER AVEC MOI, POUR SAVOIR FAIRE DU FULL, DU SYNC, DU SOUNDTRACK. IL DEVIENT BIENTOT LE MEILLEUR COMPAGNION DE CODE QUE JE CONNU... ENSEMBLE NOUS AVONS CODE LA 'ENJOY THE COKE SCREEN' QUI N'EST QUAND MEME PAS SI"
	DC.B " MAUVAISE.ET C'EST ENSEMBLE QUE NOUS NOUS EFFORCONS DE PERSE LES MYSTERES DES DEMOS TRIDIMENTIONNELLES.EN COMMENCANT PAR UNE ROUTINE DE LIGNE, QUE NOUS TRAVAILLONS ENSEMBLE DEPUIS LONGTEMPS..."
	DC.B " VOILA AUJOURD'HUI NOUS SOMME LE DIX JUILLET,ET JE REVIENS DE MON BOULOT.JE PENSE QUE D'ICI LA FIN DE LA SEMAINE LE DISQUE SERA PRES.TRONIC Y TRAVAILLE DUR!!! CETTE DEMO,QUI POURTANT REPRESENTE UN PASSE REVOLU, FIGURE DANS LA SPACE"
	DC.B " NON PAS PARCEQUE ELLE EST UNE PIECE DE MUSE (LE CODE EST EFFRAYANT,PAR CA NULITE!!!) MAIS PARCEQUE,ELLE RETRACE , PORTION DE SCROLL APRES PORTION DE SCROLL,LA NAISSANCE D'UN GROUPE, QUI JE L'ESPERE FERA ENCORE BEAUCOUP PARLER DE"
	DC.B " LUI :  T H E   M E G A B U S T E R S              REDIGE PAR LE BOSS: PRINST         SEE YOU SOON, AND LET'S WRAP....                      "   
endtext  
music	incbin	red_sect. 


