;	MEGA SCROLL SCREEN
;
;debut:05/05/91
;fin  :05/07/91
;dure du scroll text:	8'30''
;taille en RAM      :	241534 octets
;fichier a inclure  :	syncdat .inc
;		enchan6 .		
;		wave    .inc
;		wave3d1 .inc
;		wave3d2 .inc
;		wave3d3 .inc 
;		wave3d4 .inc
;		mbdec   .inc
;		2ddis   .inc
;		champet .inc
;		logdis3d.inc	
;
;		code de PrinST
;

;====================================
;	CONSTANTES...
;====================================

;====================================
;	macros
;====================================
INITMUS	macro
	lea.l	zic,a0
	lea.l	$1060(a0),a0
	moveq.l	#1,d0
	jsr	zic
	endm
PLAYMUS	macro
	movem.l	d0-a6,-(sp)
	jsr	zic+8
	movem.l	(sp)+,d0-a6
	endm
ENDMUS	macro
	lea.l	zic,a0
	lea	$1060(a0),a0
	moveq	#0,d0
	jsr 	zic
	endm
;====================================
	section	text
;====================================
	pea	prog
	move	#$26,-(sp)
	trap	#14
	addq	#6,sp
	
	clr	-(sp)
	trap	#1
		
prog	move 	#$2700,sr
	bra	progr
	
	DC.B "  IF YOU READ THIS TEXT,YOU ARE A RIPPER, FELICITATION BECAUSE US PROTECTION LOST!!!!"
	
;====================================
;	sauver la palette
;====================================
progr	lea	$ffff8240.w,a1
	lea 	savpal,a0
	rept 8
	move.l 	(a1)+,(a0)+
	endr
;====================================
;	installer le new ecran
;====================================
	move.b	$ffff8201,vff8201
	move.b	$ffff8203,vff8203
	clr.b 	vbig	
	move.l 	#datasync+1,possync
	move.l 	#fullscr,adrful
	move.l	#fullscr,d0
	move.l	d0,a0
;====================================
;	effacer l'ecran
;====================================
	move.l	#fullscr,a0
	move.l	#230*4*24,d0
eff	clr	(a0)+
	dbra	d0,eff
;====================================
;	init variables
;====================================
	INITMUS
	lea	stadre,a0
	move.l	#stwave,adrrte
	move.l	#stwave,adrwav
	move.l	#etoiles,adrget
	move.l	#stadre,adrpet
	move.l	#stadre+16,adrpet2
	move.l	#etoiles+10*32,adrget2
	move.l	#etoiles+5*32,adrget3
	move.l	#stadre+32,adrpet3
	move.l	#etoiles+13*32,adrget4
	move.l	#stadre+64,adrpet4
	move.l	#etoiles+8*32,adrget5
	move.l	#stadre+80,adrpet5
	move.l	#stcolor,adrcyl
	lea	stcolor,a0
	move	#319,d0
effstco	clr  	(a0)+
	dbra	d0,effstco
	move.b	#9,posonlet
	move.l	#fontes,adrlet
	move.l	#text,adrtxt
	move.l	#stdis2d,adrd2d
	lea	stdis2d,a0
	move	#999,d0
effstdi	move	#90,(a0)+
	clr	(a0)+
	dbra	d0,effstdi
	move.l	#fontes,d0
	lea	adrchr,a0
	move	#57,d1
bouc1	add.l	d0,(a0)+
	dbra	d1,bouc1
;====================================
;	boucle principale
;====================================
bigbcl
;====================================
;	synchro VBL
;====================================
	lea 	$ffff8209.w,a6
	move 	#161,d7
	move.b 	$ffff8203.w,d5
vsync1	cmp.b 	$ffff8207.w,d5
	bne.s 	vsync1
;====================================
;	init couleur a 0
;====================================
	clr.l	$ffff8240.w
	clr.l	$ffff8244.w
	clr.l	$ffff8248.w
	clr.l	$ffff824c.w
	clr.l	$ffff8250.w
	clr.l	$ffff8254.w
	clr.l	$ffff8258.w
	clr.l	$ffff825c.w
;====================================
;	affiche le distort 3D
;====================================
	move.l	adrwav,a4
	move.l	adrful,d0
	move.l	#graph3d,d1
	rept	40
	lea.l	0,a5
	moveq	#0,d2
	move	(a4)+,a5
	move	(a4)+,d2
	move.l	d2,d3
	lsl.l	#5,d2
	lsl.l	#2,d3
	sub.l	d3,d2
	add.l	d0,a5
	add.l	d1,d2
	move.l	d2,a3
	move.l	(a3)+,(a5)
	addq.l	#8,a5
	move.l	(a3)+,(a5)
	addq.l	#8,a5
	move.l	(a3)+,(a5)
	addq.l	#8,a5
	move.l	(a3)+,(a5)
	addq.l	#8,a5
	move.l	(a3)+,(a5)
	addq.l	#8,a5
	move.l	(a3)+,(a5)
	addq.l	#8,a5
	move.l	(a3)+,(a5)
	endr
;====================================
;	afficher le distort 2d
;====================================
	lea	graph2d,a2
	move.l	adrful,a1
	add.l	#230*110,a1
	addq.l	#4,adrd2d
	move.l	adrd2d,a4
	moveq	#0,d0
	rept	40
	lea	(a2),a0
	add.l	d0,a0
	lea	(a1),a3
	add	(a4)+,a3
	add	(a4)+,a0
	clr.l	(a3)
	addq.l	#8,a3  
	clr.l	(a3)
	addq.l	#8,a3
	move.l	(a0)+,(a3)
	addq.l	#8,a3
	move.l	(a0)+,(a3)
	addq.l	#8,a3
	move.l	(a0)+,(a3)
	addq.l	#8,a3
	move.l	(a0)+,(a3)
	addq.l	#8,a3
	move.l	(a0)+,(a3)
	addq.l	#8,a3
	move.l	(a0)+,(a3)
	lea	230(a1),a1
	add	#24,d0
	endr	
	cmp.l	#endis2d,a4
	bne.s	pasdis2d
	move.l	#dis2d,adrd2d
pasdis2d
;====================================
;	pression f1,...
;====================================
	move.b	wavsel,d0
	cmp.b	#1,d0
	bne.s	cla2
	move.l	#wave1,adrrte
cla2	cmp.b	#2,d0
	bne.s	cla3
	move.l	#wave2,adrrte
cla3	cmp.b	#3,d0
	bne.s	cla4
	move.l	#wave3,adrrte
cla4	cmp.b	#4,d0
	bne.s	cla5
	move.l	#wave4,adrrte
cla5	cmp.b	#5,d0
	bne.s	cla6
	move.l	#wave5,adrrte
cla6	
;====================================
;	routine de sync
;====================================
	moveq	#18,d6
vsync2	tst.b 	(a6)
	beq.s 	vsync2
	sub.b 	(a6),d6
	lsr.l 	d6,d6
	lea 	$ffff820a.w,a0
	lea 	$ffff8260.w,a1
	moveq 	#0,d0
	moveq 	#2,d1
	clr	$ffff8240.w 
	rept 47
	nop
	endr
	moveq 	#14,d6
	move.l 	possync,a2
sync	nop
	move.b 	(a2)+,(a0)
	move.b 	d1,(a0)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	move.b 	(a2),(a1)
	nop
	move.b 	d0,(a1)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
 	nop
	nop
	move.b 	(a2)+,(a1)
	move.b 	d0,(a1)
	rept 83
	nop
	endr
	dbra 	d6,sync
	nop
	move.b 	(a2)+,(a0)
	move.b 	d1,(a0)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	move	#$111,$ffff8240.w
	move.b 	d0,(a1)
	nop
	move.b 	d0,(a1)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	move.b 	d0,(a1)
	nop
	nop
	move.b 	d0,(a1)
	rept 36
	nop
	endr
	lea	raster,a4
;=====================================
;	init les vraies couleurs.
;=====================================
	move.l	#$01110111,$ffff8240.w
	move.l	#$01110111,$ffff8244.w
	move.l	#$01110111,$ffff8248.w
	move.l	#$01110111,$ffff824c.w
	move.l	#$00000557,$ffff8250.w
	move.l	#$00730073,$ffff8254.w
	move.l	#$00270027,$ffff8258.w
	move.l	#$00470047,$ffff825c.w
;====================================
;	routine  normal full
;====================================
full	move.b 	d0,(a0)
	nop
	move.b 	d1,(a0)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	move	(a4)+,$ffff8250.w
	move.b 	d1,(a1)
	nop
	move.b 	d0,(a1)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	move.b 	d1,(a1)
	nop
	move.b 	d0,(a1)
	rept	85
	nop
	endr
	dbra 	d7,full
	nop
	move.b	d0,(a0)
	nop
	move.b	d1,(a0)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	move.b	vbig,(a0)
	nop
	move.b	d1,(a1)
	nop
	move.b	d0,(a1)
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
	nop
;	move.b	d1,(a1)
	move.b	d1,(a0)
;	move.b	d0,(a1)
	clr	$ffff8240.w	
;====================================
;	fin du full... temps mort.
;====================================
	clr.l	$ffff8240.w
	clr.l	$ffff8244.w
	clr.l	$ffff8248.w
	clr.l	$ffff824c.w
	clr.l	$ffff8250.w
	clr.l	$ffff8254.w
	clr.l	$ffff8258.w
	clr.l	$ffff825c.w
	subq.b	#1,posonlet
	tst.b	posonlet
	bne.s	no9let
;====================================
;	calcul new lettre
;====================================
	move.b	#10,posonlet
	lea	adrchr,a0
	move.l	adrtxt,a1
	addq.l	#1,adrtxt
	clr.l	d0
	move.b	(a1)+,d0
	cmp.b	#0,d0
	bne.s	noendsy
	addq.l	#2,adrtxt
	move.b	(a1)+,wavsel
	move.b	(a1)+,d0
	move.b	#$fc,syncf
noendsy	cmp.l	#endtxt,a1
	bne.s	no9txt
	move.l	#text,adrtxt
no9txt	sub.l	#32,d0
	lsl.l	#2,d0
	add.l	d0,a0
	move.l	(a0),adrlet
no9let	
;====================================
;      affiche portion de lettre
;====================================
	move.l	adrful,a0
	lea	452(a0),a0
	move.l	adrlet,a1
	move.l	#226,d1
	rept	10
	moveq.l	#0,d0
	move.b	(a1)+,d0
	lsl.l	#5,d0
	lea	morceau,a2
	add.l	d0,a2
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	move	(a2)+,(a0)+
	clr	(a0)+
	clr.l	(a0)
	add.l	d1,a0
	endr	
	clr	230(a0)
	clr.l	232(a0)
	move.l	a1,adrlet
	not.b	guide
	tst.b	guide
	bne	le1
;====================================
;	cycle de couleur
;====================================
	move.l	adrcyl,a0
	lea	cycle+2,a1
	lea	-2(a1),a2
	rept	15
	move	(a1)+,(a2)+
	endr
	move	(a0),(a2)+
	addq.l	#2,adrcyl
	cmp.l	#endcolor,adrcyl
	bne.s	pas9col
	move.l	#color,adrcyl
pas9col	
	lea	raster+16,a1
	rept	9
	lea	cycle,a0
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	endr
;====================================
;	l'etoile 1
;====================================
le1	
	PLAYMUS
	move.l	adrful,a0
	move.l	adrpet,a1
	cmp.l	#endeto,adrget
	bne.s	pas9le1
	move.l	#etoiles,adrget
	addq.l	#4,adrpet
	cmp.l	#endadr,adrpet
	bne.s	pas9le1
	move.l	#adreto,adrpet
pas9le1	add.l	(a1),a0
	move.l	#etoiles,a1
	tst.b	guide
	bne.s	paseffet
	move.l	adrget,a1
paseffet
	rept	16
	clr	(a0)
	move	(a1)+,8(a0)
	lea	230(a0),a0
	endr
	tst.b	guide
	bne.s	le2
	move.l	a1,adrget
;====================================
;	l'etoile 2
;====================================
le2	move.l	adrful,a0
	move.l	adrpet2,a1
	cmp.l	#endeto,adrget2
	bne.s	pas9le2
	move.l	#etoiles,adrget2
	addq.l	#4,adrpet2
	cmp.l	#endadr,adrpet2
	bne.s	pas9le2
	move.l	#adreto,adrpet2
pas9le2	add.l	(a1),a0
	tst.b	guide
	move.l	#etoiles,a1
	bne.s	paseffet2
	move.l	adrget2,a1
paseffet2	
	rept	16
	clr	(a0)
	move	(a1)+,8(a0)
	lea	230(a0),a0
	endr
	tst.b	guide
	bne.s	le3
	move.l	a1,adrget2
;====================================
;	l'etoile 3
;====================================
le3	move.l	adrful,a0
	move.l	adrpet3,a1
	cmp.l	#endeto,adrget3
	bne.s	pas9le3
	move.l	#etoiles,adrget3
	addq.l	#4,adrpet3
	cmp.l	#endadr,adrpet3
	bne.s	pas9le3
	move.l	#adreto,adrpet3
pas9le3	add.l	(a1),a0
	tst.b	guide
	move.l	#etoiles,a1
	bne.s	paseffet3
	move.l	adrget3,a1
paseffet3	
	rept	16
	clr	(a0)
	move	(a1)+,8(a0)
	lea	230(a0),a0
	endr
	tst.b	guide
	bne.s	le4
	move.l	a1,adrget3
;====================================
;	l'etoile 4
;====================================
le4	move.l	adrful,a0
	move.l	adrpet4,a1
	cmp.l	#endeto,adrget4
	bne.s	pas9le4
	move.l	#etoiles,adrget4
	addq.l	#4,adrpet4
	cmp.l	#endadr,adrpet4
	bne.s	pas9le4
	move.l	#adreto,adrpet4
pas9le4	add.l	(a1),a0
	tst.b	guide
	move.l	#etoiles,a1
	bne.s	paseffet4
	move.l	adrget4,a1
paseffet4	
	rept	16
	clr	(a0)
	move	(a1)+,8(a0)
	lea	230(a0),a0
	endr
	tst.b	guide
	bne.s	le5
	move.l	a1,adrget4
;====================================
;	l'etoile 5
;====================================
le5	move.l	adrful,a0
	move.l	adrpet5,a1
	cmp.l	#endeto,adrget5
	bne.s	pas9le5
	move.l	#etoiles,adrget5
	addq.l	#4,adrpet5
	cmp.l	#endadr,adrpet5
	bne.s	pas9le5
	move.l	#adreto,adrpet5
pas9le5	add.l	(a1),a0
	tst.b	guide
	move.l	#etoiles,a1
	bne.s	paseffet5
	move.l	adrget5,a1
paseffet5	
	rept	16
	clr	(a0)
	move	(a1)+,8(a0)
	lea	230(a0),a0
	endr
	tst.b	guide
	bne.s	effdis
	move.l	a1,adrget5
;====================================
;	effacer le tridi dis
;====================================
effdis	move.l	adrful,d0
	move.l	adrwav,a1
	rept	40
	lea	0,a0
	move	(a1),a0
	addq.l	#4,a1
	add.l	d0,a0
	clr.l	(a0)
	addq.l	#8,a0
	clr.l	(a0)
	addq.l	#8,a0
	clr.l	(a0)
	addq.l	#8,a0
	clr.l	(a0)
	addq.l	#8,a0
	clr.l	(a0)
	addq.l	#8,a0
	clr.l	(a0)
	addq.l	#8,a0
	clr.l	(a0)
	addq.l	#8,a0
	clr.l	(a0)
	endr
	move.l	a1,adrwav
	cmp.l	#$ffffffff,(a1)
	bne.s	ste1
	move.l	adrrte,adrwav
;====================================
;	routine de calcul du sync
;====================================
ste1	move.l	adrful,a0
	clr.l	(a0)+
	clr.l	(a0)+
	cmp.b	#$fc,syncf
	bne.s	ste2
	clr.b	syncf
	move.l	#fullscr,a0
ste2	move.l 	a0,adrful
	move.l 	a0,d0
	sub.l	#2752,d0
	move.l 	d0,d1
	and.l 	#254,d1
	lsl 	#4,d1
	move.l 	#datasync,d2
	add.l 	d1,d2
	move.l 	d2,a0
	addq.l 	#1,d2
	move.l 	d2,possync
	moveq 	#0,d1
	move.b 	(a0),d1
	lsl 	#8,d1
	and.l 	#$ffff00,d0
	sub.l 	d1,d0
	lsr.l 	#8,d0
	move.b 	d0,$ffff8203.w
	lsr 	#8,d0
	move.b 	d0,$ffff8201.w
;====================================
;	sorti par mis a 2 de vbig 
;====================================
	move.b	-$3fe,d0
	cmp.b 	#2,vbig
	beq.s	sorti
	cmp.b 	#$39,d0
	beq 	bb
	jmp	bigbcl
bb	move.b 	#2,vbig
	jmp 	bigbcl
sorti
;====================================
;	Fin de la demo sortie...
;====================================
	ENDMUS
	move.b 	vff8201,$ffff8201.w
	move.b 	vff8203,$ffff8203.w
	move 	#$2000,sr
	lea 	$ffff8240.w,a0
	lea 	savpal,a1
	rept 8
	move.l 	(a1)+,(a0)+
	endr
	rts
;====================================
	section	data
;====================================

pal	dc.w 0,$444,$555,0,$666,0,0,0,$777,0,0,0,0,0,0,0,0
raster	
	dc.w	$700
	dc.w	$600
	dc.w	$500
	dc.w	$400
	dc.w	$300
	dc.w	$200
	dc.w	$100
	dc.w	$000
	rept	144
	dc.w	$0
	endr
	dc.b	$000
	dc.w	$100
	dc.w	$200
	dc.w	$300
	dc.w	$400
	dc.w	$500
	dc.w	$600
	dc.w	$700

stcolor	ds.w	320
color	rept	16
	dc.w	$000
	endr
	dc.w	$10
	dc.w	$11
	dc.w	$20
	dc.w	$22
	dc.w	$30
	dc.w	$33
	dc.w	$40
	dc.w	$44
	dc.w	$50
	dc.w	$55
	dc.w	$60
	dc.w	$66
	dc.w	$70
	dc.w	$77
	dc.w	$77
	dc.w	$70
	dc.w	$66
	dc.w	$60
	dc.w	$55
	dc.w	$50
	dc.w	$44
	dc.w	$40
	dc.w	$33
	dc.w	$30
	dc.w	$22
	dc.w	$20
	dc.w	$11
	dc.w	$10
	rept	16
	dc.w	$0
	endr
	dc.w	$100
	dc.w	$110
	dc.w	$200
	dc.w	$220
	dc.w	$300
	dc.w	$330
	dc.w	$400
	dc.w	$440
	dc.w	$500
	dc.w	$550
	dc.w	$600
	dc.w	$660
	dc.w	$700
	dc.w	$770
	dc.w	$700
	dc.w	$660
	dc.w	$600
	dc.w	$550
	dc.w	$500
	dc.w	$440
	dc.w	$400
	dc.w	$330
	dc.w	$300
	dc.w	$220
	dc.w	$200
	dc.w	$110
	dc.w	$100
	rept	16
	dc.w	0
	endr
	dc.w	$1
	dc.w	$101
	dc.w	$2
	dc.w	$202
	dc.w	$3
	dc.w	$303
	dc.w	$4
	dc.w	$404
	dc.w	$5
	dc.w	$505
	dc.w	$6
	dc.w	$606
	dc.w	$7
	dc.w	$707
	dc.w	$7
	dc.w	$606
	dc.w	$6
	dc.w	$505
	dc.w	$5
	dc.w	$404
	dc.w	$4
	dc.w	$303
	dc.w	$2
	dc.w	$202
	dc.w	$1
	dc.w	$101
	rept	4
	dc.w	0,1,2,3,4,5,6,7,7,6,5,4,3,2,1,0
	endr
	rept	4
	dc.w	$0,$100,$200,$300,$400,$500,$600,$700,$700,$600,$500,$400,$300,$200,$100,$0
	endr
	rept	4
	dc.w	$0,$10,$20,$30,$40,$50,$60,$70,$70,$60,$50,$40,$30,$20,$10,$0
	endr
	rept	16
	dc.w	$000
	endr
endcolor
datasync	incbin syncdata.bin
etoiles	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000001110000000
	dc.w %0000011111000000
	dc.w %0000001110000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000001110000000
	dc.w %0000111111100000
	dc.w %0000001110000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000010101000000
	dc.w %0000001110000000
	dc.w %0011111111110000
	dc.w %0000001110000000
	dc.w %0000010101000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000100100100000
	dc.w %0000010101000000
	dc.w %0000001110000000
	dc.w %0111111111111000
	dc.w %0000001110000000
	dc.w %0000010101000000
	dc.w %0000100100100000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0001000100010000
	dc.w %0000101110100000
	dc.w %0000011111000000
	dc.w %0000111111100000
	dc.w %0111111111111110
	dc.w %0000111111100000
	dc.w %0000011111000000
	dc.w %0000101110100000
	dc.w %0001000100010000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0010000100001000
	dc.w %0001000100010000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0111111111111110
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0001000100010000
	dc.w %0010000100001000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0010000100000100
	dc.w %0001001110001000
	dc.w %0000111111110000
	dc.w %0000111111100000
	dc.w %0001111111110000
	dc.w %1111111111111111
	dc.w %0001111111110000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000101110010000
	dc.w %0001000100001000
	dc.w %0010000100000100
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0100000100000010
	dc.w %0010000100000100
	dc.w %0001001110001000
	dc.w %0000111111110000
	dc.w %0000111111100000
	dc.w %0001111111110000
	dc.w %1111111111111111
	dc.w %0001111111110000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000101110010000
	dc.w %0001000100001000
	dc.w %0010000100000100
	dc.w %0100000100000010
	dc.w %0000000100000000
	dc.w %1000000100000001
	dc.w %0100000100000010
	dc.w %0010001110000100
	dc.w %0001001110001000
	dc.w %0000101111010000
	dc.w %0000011111110000
	dc.w %0011111111110000
	dc.w %1111111111111111
	dc.w %0011111111111000
	dc.w %0000111111110000
	dc.w %0000111111100000
	dc.w %0001001110010000
	dc.w %0010001110001000
	dc.w %0100000100000100
	dc.w %1000000100000010
	dc.w %0000000000000001
	dc.w %0000000100000000
	dc.w %0100000100000010
	dc.w %0010000100000100
	dc.w %0001001110001000
	dc.w %0000111111110000
	dc.w %0000111111100000
	dc.w %0001111111110000
	dc.w %1111111111111111
	dc.w %0001111111110000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000101110010000
	dc.w %0001000100001000
	dc.w %0010000100000100
	dc.w %0100000100000010
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0010000100000100
	dc.w %0001001110001000
	dc.w %0000111111110000
	dc.w %0000111111100000
	dc.w %0001111111110000
	dc.w %1111111111111111
	dc.w %0001111111110000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000101110010000
	dc.w %0001000100001000
	dc.w %0010000100000100
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0010000100001000
	dc.w %0001000100010000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0111111111111110
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0000111111100000
	dc.w %0001000100010000
	dc.w %0010000100001000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0001000100010000
	dc.w %0000101110100000
	dc.w %0000011111000000
	dc.w %0000111111100000
	dc.w %0111111111111110
	dc.w %0000111111100000
	dc.w %0000011111000000
	dc.w %0000101110100000
	dc.w %0001000100010000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000100100100000
	dc.w %0000010101000000
	dc.w %0000001110000000
	dc.w %0111111111111000
	dc.w %0000001110000000
	dc.w %0000010101000000
	dc.w %0000100100100000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000010101000000
	dc.w %0000001110000000
	dc.w %0011111111110000
	dc.w %0000001110000000
	dc.w %0000010101000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000001110000000
	dc.w %0000111111100000
	dc.w %0000001110000000
	dc.w %0000000100000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000100000000
	dc.w %0000001110000000
	dc.w %0000011111000000
	dc.w %0000001110000000
	dc.w %0000000100000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w %0000000000000000
	dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
endeto
stadre	dc.l 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
adreto	incbin	champet.inc
endadr
adrchr
 dc.l 0
 dc.l 100
 dc.l 200
 dc.l 300
 dc.l 400
 dc.l 500
 dc.l 600
 dc.l 700
 dc.l 800
 dc.l 900
 dc.l 1000
 dc.l 1100
 dc.l 1200
 dc.l 1300
 dc.l 1400
 dc.l 1500
 dc.l 1600
 dc.l 1700
 dc.l 1800
 dc.l 1900
 dc.l 2000
 dc.l 2100
 dc.l 2200
 dc.l 2300
 dc.l 2400
 dc.l 2500
 dc.l 2600
 dc.l 2700
 dc.l 2800
 dc.l 2900
 dc.l 3000
 dc.l 3100
 dc.l 3200
 dc.l 3300
 dc.l 3400
 dc.l 3500
 dc.l 3600
 dc.l 3700
 dc.l 3800
 dc.l 3900
 dc.l 4000
 dc.l 4100
 dc.l 4200
 dc.l 4300
 dc.l 4400
 dc.l 4500
 dc.l 4600
 dc.l 4700
 dc.l 4800
 dc.l 4900
 dc.l 5000
 dc.l 5100
 dc.l 5200
 dc.l 5300
 dc.l 5400
 dc.l 5500
 dc.l 5600
 dc.l 5700
 dc.l 5800
 dc.l 5900
 dc.l 6000
 dc.l 6100
fontes
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,6,1,4,2,6
 dc.b 2,2,2,2,2,2,1,2,2,2
 dc.b 2,2,2,2,2,2,1,2,2,2
 dc.b 3,2,2,2,2,5,1,3,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,1,2,2,2,2,2,2,1,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,8,1,1,1,1,1,1
 dc.b 1,1,8,2,1,1,1,1,1,1
 dc.b 1,8,2,2,1,1,1,1,1,1
 dc.b 1,2,2,10,1,1,1,1,1,1
 dc.b 1,2,10,1,1,1,1,1,1,1
 dc.b 1,10,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,1,1,1,1,1,1,2,2
 dc.b 3,5,1,1,1,1,1,1,3,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,6,1,1,1,1,1,1,4,6
 dc.b 2,2,1,1,1,1,1,1,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,9,1,1,1,1,8,1,1
 dc.b 1,1,2,9,1,1,8,2,1,1
 dc.b 1,1,2,2,9,8,2,2,1,1
 dc.b 1,8,2,2,2,2,2,2,9,1
 dc.b 8,2,2,2,2,2,2,2,2,9
 dc.b 7,2,2,2,2,2,2,2,2,10
 dc.b 1,7,2,2,2,2,2,2,10,1
 dc.b 1,1,2,2,10,7,2,2,1,1
 dc.b 1,1,2,10,1,1,7,2,1,1
 dc.b 1,1,10,1,1,1,1,7,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,4,2,2,6,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,4,2,2,2,2,2,2,6,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,3,2,2,2,2,2,2,5,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,3,2,2,5,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,8
 dc.b 1,1,1,1,1,1,1,1,8,2
 dc.b 1,1,1,1,1,1,1,8,2,2
 dc.b 1,1,1,1,1,1,8,2,2,10
 dc.b 1,1,1,1,1,1,2,2,10,1
 dc.b 1,1,1,1,1,1,3,10,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,4,2,2,6,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,3,2,2,5,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,4,2,2,6
 dc.b 1,1,1,1,1,1,2,2,2,2
 dc.b 1,1,1,1,1,1,2,2,2,2
 dc.b 1,1,1,1,1,1,3,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,8,2,6,1
 dc.b 1,1,1,1,1,8,2,2,2,1
 dc.b 1,1,1,1,8,2,2,2,10,1
 dc.b 1,1,1,8,2,2,2,10,1,1
 dc.b 1,1,8,2,2,2,10,1,1,1
 dc.b 1,8,2,2,2,10,1,1,1,1
 dc.b 1,2,2,2,10,1,1,1,1,1
 dc.b 1,3,2,10,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,2,2,2,2,2,2,6,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,1,1,8,2,2,2,1
 dc.b 1,2,2,1,8,2,10,2,2,1
 dc.b 1,2,2,8,2,10,1,2,2,1
 dc.b 1,2,2,2,10,1,1,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,3,2,2,2,2,2,2,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,8,2,6,1,1,4,6,1
 dc.b 1,8,2,2,10,1,1,2,2,1
 dc.b 1,2,2,10,1,1,1,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,3,2,2,2,2,2,2,2,1
 dc.b 1,1,1,1,1,1,1,2,2,1
 dc.b 1,1,1,1,1,1,1,3,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,2,2,6,1,8,2,6,1
 dc.b 1,2,2,2,5,8,2,2,2,1
 dc.b 1,2,2,1,8,2,2,2,2,1
 dc.b 1,2,2,8,2,2,10,2,2,1
 dc.b 1,2,2,2,2,10,1,2,2,1
 dc.b 1,2,2,2,10,1,1,2,2,1
 dc.b 1,3,2,10,1,1,1,2,2,1
 dc.b 1,1,1,1,1,1,1,3,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,6,1,1,1,1,4,6,1
 dc.b 1,2,2,1,1,1,1,2,2,1
 dc.b 1,2,2,1,1,1,1,2,2,1
 dc.b 1,2,2,1,4,6,1,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,3,2,2,2,2,2,2,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,8,2,6,1,1
 dc.b 1,1,1,1,8,2,2,2,1,1
 dc.b 1,1,1,8,2,2,2,2,1,1
 dc.b 1,1,8,2,2,10,2,2,1,1
 dc.b 1,8,2,2,10,1,2,2,1,1
 dc.b 1,2,2,2,2,2,2,2,6,1
 dc.b 1,3,2,2,2,2,2,2,5,1
 dc.b 1,1,1,1,1,1,3,5,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,2,2,2,6,1,4,6,1
 dc.b 1,2,2,2,2,2,1,2,2,1
 dc.b 1,2,2,2,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,2,2,2,1
 dc.b 1,2,2,1,2,2,2,2,2,1
 dc.b 1,3,5,1,3,2,2,2,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,2,2,2,2,2,2,6,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,2,2,2,1
 dc.b 1,2,2,1,2,2,2,2,2,1
 dc.b 1,3,5,1,3,2,2,2,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,6,1,1,1,1,8,6,1
 dc.b 1,2,2,1,1,1,8,2,2,1
 dc.b 1,2,2,1,1,8,2,2,10,1
 dc.b 1,2,2,1,8,2,2,10,1,1
 dc.b 1,2,2,8,2,2,10,1,1,1
 dc.b 1,2,2,2,2,10,1,1,1,1
 dc.b 1,2,2,2,10,1,1,1,1,1
 dc.b 1,3,2,10,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,2,2,6,4,2,2,6,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,3,2,2,5,3,2,2,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,2,2,2,6,1,4,6,1
 dc.b 1,2,2,2,2,2,1,2,2,1
 dc.b 1,2,2,2,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,1,2,2,1,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,2,2,2,2,2,2,2,2,1
 dc.b 1,3,2,2,2,2,2,2,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,4,2,6,1,1,4,2,6,1
 dc.b 1,2,2,2,1,1,2,2,2,1
 dc.b 1,3,2,5,1,1,3,2,5,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,8,9,1,1,1,1
 dc.b 1,1,1,8,10,7,9,1,1,1
 dc.b 1,1,8,10,8,9,7,9,1,1
 dc.b 1,8,10,8,10,7,9,7,9,1
 dc.b 8,10,8,10,1,1,7,9,7,9
 dc.b 10,8,10,1,1,1,1,7,9,7
 dc.b 8,10,1,1,1,1,1,1,7,9
 dc.b 10,1,1,1,1,1,1,1,1,7
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,2,2,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 9,1,1,1,1,1,1,1,1,8
 dc.b 7,9,1,1,1,1,1,1,8,10
 dc.b 9,7,9,1,1,1,1,8,10,8
 dc.b 7,9,7,9,1,1,8,10,8,10
 dc.b 1,7,9,7,9,8,10,8,10,1
 dc.b 1,1,7,9,7,10,8,10,1,1
 dc.b 1,1,1,7,9,8,10,1,1,1
 dc.b 1,1,1,1,7,10,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,6,1,1,1,1,1,1
 dc.b 2,2,2,5,1,1,1,1,1,1
 dc.b 2,2,1,1,1,1,1,1,1,1
 dc.b 2,2,1,1,8,2,6,1,4,6
 dc.b 2,2,1,8,2,2,5,1,3,5
 dc.b 2,2,8,2,2,10,1,1,1,1
 dc.b 2,2,2,2,10,1,1,1,1,1
 dc.b 3,2,2,10,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,2,2,2,2,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,5
 dc.b 2,2,2,1,1,2,2,1,1,1
 dc.b 2,2,2,1,1,2,2,1,1,1
 dc.b 2,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,1,1,2,2,1,1,2,2
 dc.b 2,2,1,1,2,2,1,1,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,2
 dc.b 1,1,1,1,3,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,1,1,1,1,2,2,2
 dc.b 2,2,2,1,1,1,1,2,2,2
 dc.b 2,2,2,1,1,1,1,2,2,2
 dc.b 2,2,2,1,1,1,1,2,2,2
 dc.b 3,2,5,1,1,1,1,3,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 7,2,2,2,9,1,1,2,2,2
 dc.b 1,7,2,2,2,9,1,2,2,2
 dc.b 1,1,7,2,2,2,9,2,2,2
 dc.b 1,1,1,7,2,2,2,2,2,2
 dc.b 1,1,1,1,7,2,2,2,2,2
 dc.b 1,1,1,1,1,7,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,1,2,2,1,2,2,2
 dc.b 2,2,2,1,2,2,1,2,2,2
 dc.b 2,2,2,1,3,5,1,2,2,2
 dc.b 2,2,2,1,1,1,1,2,2,2
 dc.b 3,2,5,1,1,1,1,3,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,5
 dc.b 2,2,2,1,1,2,2,1,1,1
 dc.b 2,2,2,1,1,2,2,1,1,1
 dc.b 2,2,2,1,1,3,5,1,1,1
 dc.b 2,2,2,1,1,1,1,1,1,1
 dc.b 3,2,5,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,1,1,1,1,1,2,2,2
 dc.b 2,2,1,1,4,6,1,2,2,2
 dc.b 2,2,1,1,2,2,1,2,2,2
 dc.b 2,2,6,1,2,2,2,2,2,2
 dc.b 3,2,5,1,3,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,2,2,2,1,1,1
 dc.b 1,1,1,1,2,2,2,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,6,1,1,1,1,1,1,4,6
 dc.b 2,2,1,1,1,1,1,1,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,1,1,1,1,1,1,2,2
 dc.b 3,5,1,1,1,1,1,1,3,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,4,2,9,1,1
 dc.b 1,1,1,1,1,3,2,2,9,1
 dc.b 1,1,1,1,1,1,7,2,2,9
 dc.b 2,9,1,1,1,1,1,2,2,2
 dc.b 2,2,9,1,1,1,1,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,8,2,2,9,1,1,1
 dc.b 1,1,8,2,2,2,2,9,1,1
 dc.b 1,8,2,2,10,7,2,2,9,1
 dc.b 8,2,2,10,1,1,7,2,2,9
 dc.b 3,2,10,1,1,1,1,7,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,2
 dc.b 1,1,1,1,1,1,1,2,2,2
 dc.b 1,1,1,1,1,1,1,2,2,2
 dc.b 1,1,1,1,1,1,1,2,2,2
 dc.b 1,1,1,1,1,1,1,2,2,2
 dc.b 1,1,1,1,1,1,1,3,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 7,2,2,2,2,2,2,2,2,2
 dc.b 1,7,2,2,2,2,2,2,2,5
 dc.b 1,1,7,2,2,9,1,1,1,1
 dc.b 1,1,8,2,2,10,1,1,1,1
 dc.b 1,8,2,2,2,2,2,2,2,6
 dc.b 8,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 7,2,2,2,2,2,2,2,2,2
 dc.b 1,7,2,2,2,2,2,2,2,5
 dc.b 1,1,7,2,2,2,9,1,1,1
 dc.b 1,1,1,7,2,2,2,9,1,1
 dc.b 1,1,1,1,7,2,2,2,9,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,1,1,1,1,2,2,2
 dc.b 2,2,2,1,1,1,1,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,5
 dc.b 2,2,1,1,2,2,1,1,1,1
 dc.b 2,2,1,1,2,2,1,1,1,1
 dc.b 2,2,2,2,2,2,1,1,1,1
 dc.b 3,2,2,2,2,5,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 2,2,2,2,2,2,2,2,1,1
 dc.b 2,2,2,2,2,2,2,2,1,1
 dc.b 2,2,1,1,1,1,2,2,1,1
 dc.b 2,2,1,1,7,9,2,2,1,1
 dc.b 2,2,1,1,1,7,2,2,1,1
 dc.b 2,2,1,1,1,1,2,2,1,1
 dc.b 2,2,2,2,2,2,2,2,9,1
 dc.b 2,2,2,2,2,2,2,2,7,9
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,5
 dc.b 2,2,2,1,2,2,2,9,1,1
 dc.b 2,2,2,1,2,2,2,2,9,1
 dc.b 2,2,2,1,2,2,7,2,2,9
 dc.b 2,2,2,2,2,2,1,7,2,2
 dc.b 3,2,2,2,2,5,1,1,7,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,6,1,4,2,6
 dc.b 2,2,2,2,2,2,1,2,2,2
 dc.b 2,2,2,2,2,2,1,2,2,2
 dc.b 2,2,2,7,2,2,1,2,2,2
 dc.b 2,2,2,1,2,2,9,2,2,2
 dc.b 2,2,2,1,2,2,2,2,2,2
 dc.b 2,2,2,1,2,2,2,2,2,2
 dc.b 3,2,5,1,3,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,6,1,1,1,1,1,1,1,1
 dc.b 2,2,1,1,1,1,1,1,1,1
 dc.b 2,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,5
 dc.b 2,2,1,1,1,1,1,1,1,1
 dc.b 3,5,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,2
 dc.b 1,1,1,1,1,1,1,2,2,2
 dc.b 1,1,1,1,1,1,1,2,2,2
 dc.b 4,2,2,2,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,2,2,2,2
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,9,1,1
 dc.b 2,2,2,2,2,2,2,2,9,1
 dc.b 3,2,2,2,2,2,2,2,2,9
 dc.b 1,1,1,1,1,1,7,2,2,2
 dc.b 1,1,1,1,1,1,8,2,2,2
 dc.b 4,2,2,2,2,2,2,2,2,10
 dc.b 2,2,2,2,2,2,2,2,10,1
 dc.b 3,2,2,2,2,2,2,10,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,2,2,2,2,2,2,6
 dc.b 2,2,2,2,2,2,2,2,2,10
 dc.b 3,2,2,2,2,2,2,2,10,1
 dc.b 1,1,1,1,8,2,2,10,1,1
 dc.b 1,1,1,1,7,2,2,9,1,1
 dc.b 4,2,2,2,2,2,2,2,9,1
 dc.b 2,2,2,2,2,2,2,2,2,9
 dc.b 3,2,2,2,2,2,2,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,2,9,1,1,8,2,2,6
 dc.b 7,2,2,2,9,8,2,2,2,10
 dc.b 1,7,2,2,2,2,2,2,10,1
 dc.b 1,1,7,2,2,2,2,10,1,1
 dc.b 1,1,8,2,2,2,2,9,1,1
 dc.b 1,8,2,2,2,2,2,2,9,1
 dc.b 8,2,2,2,10,7,2,2,2,9
 dc.b 3,2,2,10,1,1,7,2,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,9,1,1,1,1,8,2,6
 dc.b 7,2,2,9,1,1,8,2,2,10
 dc.b 1,7,2,2,9,8,2,2,10,1
 dc.b 1,1,7,2,2,2,2,10,1,1
 dc.b 1,1,1,2,2,2,10,1,1,1
 dc.b 1,1,8,2,2,10,1,1,1,1
 dc.b 1,8,2,2,10,1,1,1,1,1
 dc.b 1,3,2,10,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,6,1,1,1,8,2,2,6
 dc.b 2,2,2,1,1,8,2,2,2,2
 dc.b 2,2,2,1,8,2,2,2,2,2
 dc.b 2,2,2,8,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,10,2,2,2
 dc.b 2,2,2,2,2,10,1,2,2,2
 dc.b 2,2,2,2,10,1,1,2,2,2
 dc.b 3,2,2,10,1,1,1,3,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 1,1,1,1,1,1,1,1,1,1
 dc.b 4,2,6,1,1,1,8,2,2,6
 dc.b 2,2,2,1,1,8,2,2,2,2
 dc.b 2,2,2,1,8,2,2,2,2,2
 dc.b 2,2,2,8,2,2,2,2,2,2
 dc.b 2,2,2,2,2,2,10,2,2,2
 dc.b 2,2,2,2,2,10,1,2,2,2
 dc.b 2,2,2,2,10,1,1,2,2,2
 dc.b 3,2,2,10,1,1,1,3,2,5
 dc.b 1,1,1,1,1,1,1,1,1,1
morceau	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w	$ffff
	dc.w %1111110000000000
	dc.w %1111111110000000
	dc.w %1111111111100000
	dc.w %1111111111110000
	dc.w %1111111111111000
	dc.w %1111111111111100
	dc.w %1111111111111100
	dc.w %1111111111111110
	dc.w %1111111111111110
	dc.w %1111111111111110
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w %0000000000111111
	dc.w %0000000111111111
	dc.w %0000011111111111
	dc.w %0000111111111111
	dc.w %0001111111111111
	dc.w %0011111111111111
	dc.w %0011111111111111
	dc.w %0111111111111111
	dc.w %0111111111111111
	dc.w %0111111111111111
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w %1111111111111110
	dc.w %1111111111111110
	dc.w %1111111111111110
	dc.w %1111111111111100
	dc.w %1111111111111100
	dc.w %1111111111111000
	dc.w %1111111111110000
	dc.w %1111111111100000
	dc.w %1111111110000000
	dc.w %1111110000000000
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w $ffff
	dc.w %0111111111111111
	dc.w %0111111111111111
	dc.w %0111111111111111
	dc.w %0011111111111111
	dc.w %0011111111111111
	dc.w %0001111111111111
	dc.w %0000111111111111
	dc.w %0000011111111111
	dc.w %0000000111111111
	dc.w %0000000000111111
	dc.w %1000000000000000
	dc.w %1100000000000000
	dc.w %1110000000000000
	dc.w %1111000000000000
	dc.w %1111100000000000
	dc.w %1111110000000000
	dc.w %1111111000000000
	dc.w %1111111100000000
	dc.w %1111111110000000
	dc.w %1111111111000000
	dc.w %1111111111100000
	dc.w %1111111111110000
	dc.w %1111111111111000
	dc.w %1111111111111100
	dc.w %1111111111111110
	dc.w %1111111111111111
	dc.w %0000000000000001
	dc.w %0000000000000011
	dc.w %0000000000000111
	dc.w %0000000000001111
	dc.w %0000000000011111
	dc.w %0000000000111111
	dc.w %0000000001111111
	dc.w %0000000011111111
	dc.w %0000000111111111
	dc.w %0000001111111111
	dc.w %0000011111111111
	dc.w %0000111111111111
	dc.w %0001111111111111
	dc.w %0011111111111111
	dc.w %0111111111111111
	dc.w %1111111111111111
	dc.w %1111111111111111
	dc.w %111111111111111
	dc.w %11111111111111
	dc.w %1111111111111
	dc.w %111111111111
	dc.w %11111111111
	dc.w %1111111111
	dc.w %111111111
	dc.w %11111111
	dc.w %1111111
	dc.w %111111
	dc.w %11111
	dc.w %1111
	dc.w %111
	dc.w %11
	dc.w %1
	dc.w %1111111111111111
	dc.w %1111111111111110
	dc.w %1111111111111100
	dc.w %1111111111111000
	dc.w %1111111111110000
	dc.w %1111111111100000
	dc.w %1111111111000000
	dc.w %1111111110000000
	dc.w %1111111100000000
	dc.w %1111111000000000
	dc.w %1111110000000000
	dc.w %1111100000000000
	dc.w %1111000000000000
	dc.w %1110000000000000
	dc.w %1100000000000000
	dc.w %1000000000000000
;====================================
;	graph du distort 2D
;====================================
graph2d	incbin mbdec.inc
;====================================
;	wave du dessin 2D
;====================================
stdis2d	ds.w	2000
dis2d	rept	80
	dc.w	90,0
	endr
	incbin	2ddis.inc
	rept	80
	dc.w	90,0
	endr
endis2d
	rept	80
	dc.w	90,0
	endr
;====================================
;	text du scroll
;====================================
text
	dc.b "         WELCOME IN MY FIRST MEGA SCROLL SCREEN!!! WITH SOME STARS AND RASTERS AND A MB LOGO...   DISTORT?  !!! I HOPE YOU LIKE THIS 184*184 PIXELS HIGH FONTS... ALL CODING AND GRAPHS BY PRINST(THAT'S ME!!!) FOR THE MEGABUSTERS."
	DC.B " I HOPE YOU LIKE THE STARS, AND THE DISTORT LOGO!!! AND THE RASTERS,AND THE GREAT TUNE BY MAD MAX RIPPED FROM ENCHANED LAND AND THE ... AND WHAT?       ",0,1,"     AND THE PRINST LOGO !!!  YYYYEEEEAAAAAHHH!"
	DC.B " THAT'S GOOD NO?   FOR LAMER'S WHO SAY, THAT'S NOT GOOD, LET'S ME GIVE BETTER !!!    ",0,2,"     THAT'S NOT ONLY SOME PRECALCULED PICTURE LOGO, BECAUSE I CAN GIVE ALL TRIDI-WAVE-FORME I WANT!!!!!"
	DC.B " BUT IF YOU ARE A REALY GREAT LAMER YOU THINK PROBABLY THAT'S ONLY TWO PRECACULATED PICTURES ANIMATIONS.... HUMMMM BUT YOU'RE WRONG!!!!   ",0,5,"      NOW LET'S ME GIVE YOU A BETTER LOOK OF THE BACKGROUND"
	DC.B "   ################### BETTER NOW?  SOME GREETINGS TO ALL MEMBERS OF MB FOR YOUR COLABORATION IN THE SPACE DEMO, AND TO ALL OTHER CREW <FOR YOUR CREATIONS> BUT FOR ME THE GREATEST IS : < THE OVERLANDERS >"
	DC.B " NO?   LET'S ME CHANGED AGAIN THER TRIDI-WAVE-FORM    ",0,3,"      HUMMM I  PREFER IT, IT'S MORE <TRIDI> NO? LOOK BETTER : ################################## YES IT'S TOO MUCH !!! "
	DC.B " LET'S ME PRESENT YOU ALL MEMBERS. IN FIRST THE CODERS:DJAYBEE,EVERST,JAILE,OXWALD,PRINST(ME!!!!)"
	DC.B " AND TRONIC (THE BEST ELECTRONICMAN AND A GREAT CODER, SEE THE LOADING) THE GRAPHIXXMEN: BINOUIT,WASP,MOBYDICK,WANTED,& ULTIMA ...(THE GREATEST NAME!). THE MUSICMAN: IRONSIDE AND MORAL SUPPORT: OUTLAW .FOR MORE"
	DC.B " INFORMATIONS OF THE CREW READ THE RESET TEXT (ANOTHER PRINST CODE).    ",0,4,"        I APPLAUSE THE FATE OF ULM FOR THE ORGINAL CONCEPT ... NOW ,THE END OF THIS LITTLE SCROLL-TEXT WRITTEN BY PRINST "
	DC.B " OF THE MEGABUSTERS( OR MB ) THE 05/29/91 IN BRIANCON AT 22:44 IN MY SCHOOL!!! (JE SUIS INTERNE ET FRANCAIS) IN THE <CLUB INFORMATIQUE> AND WITH SOME LAMERS PLAYING LOTUS TURBO CHALLENGE..."
	DC.B " SEE YOU SOON ... IF YOU WANT CONTACT ME IN THE CLUB : 3615 RTEL *ECB    CODE: THE MEGABUSTERS....   AND PLEASE :****** ENJOY THE SPACE DEMO ******   !!!! A LAST SHOW OF BACKGROUND :      "
	DC.B 0,1,"    ###############################################################################   "
	DC.B 0,2,"    ###############################################################################   "
	DC.B 0,3,"    ###############################################################################   "
	DC.B 0,4,"    ###############################################################################   "
	DC.B 0,5,"    ###############################################################################   "
	DC.B "    NOW LET'S WRRRRRRAAAAAAAAAAAP .......  ",0,1,"      "  
endtxt	DC.B "           "
	even
;====================================
;	differente wave form...
;====================================
stwave	ds.b 16000
	dc.l $ffffffff,$ffffffff,$ffffffff,$ffffffff
wave1	incbin wave.inc
	dc.l $fffffffff,$ffffffff,$fffffff,$ffffffff
wave2	incbin wave3d1.inc
	dc.l $ffffffff,$ffffffff,$ffffffff,$ffffffff
wave3	incbin wave3d2.inc
	dc.l $ffffffff,$ffffffff,$ffffffff,$ffffffff
wave4	incbin wave3d3.inc
	dc.l $ffffffff,$ffffffff,$ffffffff,$ffffffff
wave5	incbin wave3d4.inc
	dc.l $ffffffff ,$ffffffff,$ffffffff,$ffffffff 
;====================================
;	graph 3d...
;====================================		 
graph3d	incbin logdis3d.inc
;====================================
;	musique...
;====================================
zic	incbin enchan6
;====================================
	section	bss
;====================================
adrful	ds.l	1
adrlet	ds.l	1
adrtxt	ds.l	1
adrcyl	ds.l	1
adrpet	ds.l	1
adrget	ds.l	1
adrget2	ds.l	1
adrpet2	ds.l	1
adrpet3	ds.l	1
adrget3	ds.l	1
adrpet4	ds.l	1
adrget4	ds.l	1
adrpet5	ds.l	1
adrget5	ds.l	1
adrwav	ds.l	1
adrrte	ds.l	1
adrd2d	ds.l	1
possync	ds.l	1
	ds.l	8
dis3d	ds.l	88

savpal	ds.w	16
cycle	ds.w	16

vff8201	ds.b	1
vff8203	ds.b	1
vbig	ds.b	1
posonlet	ds.b	1
guide	ds.b	1
syncf	ds.b	1
wavsel	ds.b	1

	even
	ds.b	230 
fullscr	ds.b	230*8*24
 
