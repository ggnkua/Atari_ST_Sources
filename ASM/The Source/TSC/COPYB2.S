		*76543210
	dc.l	$00000000		*1
	dc.l	$000000ff		*2
	dc.l	$0000ff00		*3
	dc.l	$0000ffff		*4
	dc.l	$00ff0000		*5
	dc.l	$00ff00ff		*6
	dc.l	$00ffff00		*7
	dc.l	$00ffffff		*8
	dc.l	$ff000000		*9
	dc.l	$ff0000ff		*10
	dc.l	$ff00ff00		*11
	dc.l	$ff00ffff		*12
	dc.l	$ffff0000		*13
	dc.l	$ffff00ff		*14
	dc.l	$ffffff00		*14
	dc.l	$ffffffff		*16
