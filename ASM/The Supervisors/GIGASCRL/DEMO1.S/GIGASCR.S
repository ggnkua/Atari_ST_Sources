;
;                                 *      *      *
;
;      SOURCE CODE OF THE "GIGASCROLL DEMO"   version 1.1,corrected.
;      ONLY FOR ADVANCED PROGRAMMERS (because it is not documented).
;      ALL PROGRAMMING,INCLUDING MUSIC COMPOSING BY RALPH RUDZKI.
;           ALL GRAPHICS AND COLOURS BY JACK STRZAœKOWSKI.
;
;             our address:
;                                THE SUPERVISORS
;                              UL.SUCHARSKIEGO 3/16
;                                01-390 WARSZAWA
;                                     POLAND
;
;                                 *      *      *
;

	PEA	STACK
	MOVE.W	#32,-(A7)
	TRAP	#1
	LEA	6(A7),A7
	MOVE.L	D0,BACK+2
	MOVE.W	SR,SYS+2
	MOVE.W	#4,-(A7)
	TRAP	#14
	MOVE.W	D0,RES+2
	MOVE.W	#3,-(A7)
	TRAP	#14
	MOVE.W	D0,LOG+2
	MOVE.W	#2,-(A7)
	TRAP	#14
	MOVE.W	D0,PHY+2
	LEA	6(A7),A7
	CLR.W	-(A7)
	PEA	$78000
	PEA	$78000
	MOVE.W	#5,-(A7)
	TRAP	#14
	LEA	12(A7),A7
	MOVE.W	#$2700,SR
	MOVE.L	$70,OLDVBL+2
	MOVE.L	$120,OLDHBL+2
	MOVE.B	$FFFA07,MFP07+3
	MOVE.B	$FFFA09,MFP09+3
	MOVE.B	$FFFA13,MFP13+3
	MOVE.B	$FFFA15,MFP15+3
	MOVE.B	$FF820A,SYNC+3
	MOVE.L	$FF8240,COL1+2
	MOVE.L	$FF8244,COL2+2
	MOVE.L	$FF8248,COL3+2
	MOVE.L	$FF824C,COL4+2
	MOVE.L	$FF8250,COL5+2
	MOVE.L	$FF8254,COL6+2
	MOVE.L	$FF8258,COL7+2
	MOVE.L	$FF825C,COL8+2

	CLR.L	$FFFF8240.W
	CLR.L	$FFFF8244.W
	CLR.L	$FFFF8248.W
	CLR.L	$FFFF824C.W
	CLR.L	$FFFF8250.W
	CLR.L	$FFFF8254.W
	CLR.L	$FFFF8258.W
	CLR.L	$FFFF825C.W
	PEA	TEX
	MOVE.W	#9,-(A7)
	TRAP	#1
	LEA	6(A7),A7
	LEA	$78000,A3
	LEA	STACK,A5
	MOVEQ	#7,D1
HEJ1:	MOVEQ	#4,D2
HEJ2:	MOVE.L	A3,A4
	MOVE.W	#4,D4
	SUB.W	D2,D4
	MULU	#1280,D4
	ADDA.L	D4,A4
	MOVE.W	#7,D4
	SUB.W	D1,D4
	MULU	#160,D4
	ADDA.L	D4,A4
	MOVEQ	#19,D3
HEJ3:	MOVE.W	(A4),(A5)+
	ADDQ.L	#8,A4	
	DBF	D3,HEJ3
	DBF	D2,HEJ2
	DBF	D1,HEJ1
	LEA	STACK,A4
	MOVEQ	#14,D4
JA:	LEA	1600(A4),A5
	MOVE.W	#799,D5
KJ:	MOVE.W	(A4)+,(A5)+
	DBF	D5,KJ
	MOVE.L	A4,A5
	MOVE.W	#799,D5
KAR:	ROXR.W	(A5)+
	DBF	D5,KAR
	DBF	D4,JA

	MOVE.L	#VC1+2,VECTOR
	MOVE.L	#VC2+2,VECTOR+4
	MOVE.L	#VC3+2,VECTOR+8
	MOVE.L	#VC4+2,VECTOR+12
	MOVE.L	#VC5+2,VECTOR+16
	MOVE.L	#VC6+2,VECTOR+20
	MOVE.L	#VC7+2,VECTOR+24
	MOVE.L	#VC8+2,VECTOR+28
	MOVE.L	#VC9+2,VECTOR+32
	MOVE.L	#VC10+2,VECTOR+36
	MOVE.L	#VC11+2,VECTOR+40
	MOVE.L	#VC12+2,VECTOR+44
	MOVE.L	#VC13+2,VECTOR+48
	MOVE.L	#VC14+2,VECTOR+52
	MOVE.L	#VC15+2,VECTOR+56
	MOVE.L	#VC16+2,VECTOR+60
	MOVE.L	#VC17+2,VECTOR+64
	MOVE.L	#VC18+2,VECTOR+68
	MOVE.L	#VC19+2,VECTOR+72
	MOVE.L	#VC20+2,VECTOR+76
	MOVE.L	#VC21+2,VECTOR+80
	MOVE.L	#VC22+2,VECTOR+84
	MOVE.L	#VC23+2,VECTOR+88
	MOVE.L	#VC24+2,VECTOR+92
	MOVE.L	#VC25+2,VECTOR+96

	LEA	GFX+34,A4
	LEA	$78002,A5
	MOVE.L	#$7999,D5
ZERO:	MOVE.L	(A4)+,(A5)+
	DBF	D5,ZERO

	MOVE.L	#$07270727,$FF8250
	MOVE.L	#$07270727,$FF8254
	MOVE.L	#$07270727,$FF8258
	MOVE.L	#$07270727,$FF825C

	MOVE.L	#VBL,$70
	MOVE.L	#HBL,$120
	MOVE.B	#1,$FFFFFA07.W
	CLR.B	$FFFFFA09.W
	MOVE.B	#1,$FFFFFA13.W
	MOVE.W	#$2300,SR
	MOVE.B	#$12,$FFFFFC02.W
	MOVE.B	#2,$FFFF820A.W

WAIT:	STOP	#$2300
	MOVE.B	$FFFFFC02.W,HANDLE
	CMP.B	#$39,HANDLE
	BNE	WAIT

	MOVE.W	#$2700,SR
	MOVE.B	#$8,$FFFFFC02.W

	MOVE.L	#$8000000,$FFFF8800.W
	MOVE.L	#$9000000,$FFFF8800.W
	MOVE.L	#$A000000,$FFFF8800.W
OLDVBL:	MOVE.L	#0,$70
OLDHBL:	MOVE.L	#0,$120
MFP07:	MOVE.B	#0,$FFFA07
MFP09:	MOVE.B	#0,$FFFA09
MFP13:	MOVE.B	#0,$FFFA13
MFP15:	MOVE.B	#0,$FFFA15
SYNC:	MOVE.B	#0,$FF820A
COL1:	MOVE.L	#0,$FF8240
COL2:	MOVE.L	#0,$FF8244
COL3:	MOVE.L	#0,$FF8248
COL4:	MOVE.L	#0,$FF824C
COL5:	MOVE.L	#0,$FF8250
COL6:	MOVE.L	#0,$FF8254
COL7:	MOVE.L	#0,$FF8258
COL8:	MOVE.L	#0,$FF825C
SYS:	MOVE.W	#0,SR
RES:	MOVE.W	#0,-(A7)
LOG:	PEA	0
PHY:	PEA	0
	MOVE.W	#5,-(A7)
	TRAP	#14
	LEA	12(A7),A7
BACK:	PEA	0
	MOVE.W	#32,-(A7)
	TRAP	#1
	LEA	6(A7),A7

	CLR.W	-(A7)
	TRAP	#1


LETTER:
	DC.W 0
PIXEL:
	DC.W 3
AV:
	MOVE.W LETTER,D0
	LEA TEKST,A5
	MOVEQ #0,D1
	MOVEQ #0,D2
	MOVE.B $00(A5,D0.W),D2
	TST.B D2
	BNE SPACE
	CLR.W LETTER
	BRA AV
SPACE:
	LEA ASCII,A5
	MOVE.B $00(A5,D2.W),D1
	LEA FONTS+34,A1
K:	CMP.W #10,D1
	BMI.S L
	ADDA.L #3200,A1
	SUB.W #10,D1
	BRA.S K
L:	MULU #16,D1
	ADDA.L D1,A1
	LEA $78142,A2
	MOVE.W	#19,D7
	MOVE.W PIXEL,D2
	LSL.W #3,D2
Z:	MOVE.W (A1),D1
	SWAP D1
	MOVE.W 8(A1),D1
	LSR.L D2,D1
	MOVE.W	2(A1),D3
	SWAP D3
	MOVE.W	10(A1),D3
	LSR.L	D2,D3
	MOVE.B 1(A2),(A2)
	MOVE.B 8(A2),1(A2)
	MOVE.B 9(A2),8(A2)
	MOVE.B 16(A2),9(A2)
	MOVE.B 17(A2),16(A2)
	MOVE.B 24(A2),17(A2)
	MOVE.B 25(A2),24(A2)
	MOVE.B 32(A2),25(A2)
	MOVE.B 33(A2),32(A2)
	MOVE.B 40(A2),33(A2)
	MOVE.B 41(A2),40(A2)
	MOVE.B 48(A2),41(A2)
	MOVE.B 49(A2),48(A2)
	MOVE.B 56(A2),49(A2)
	MOVE.B 57(A2),56(A2)
	MOVE.B 64(A2),57(A2)
	MOVE.B 65(A2),64(A2)
	MOVE.B 72(A2),65(A2)
	MOVE.B 73(A2),72(A2)
	MOVE.B 80(A2),73(A2)
	MOVE.B 81(A2),80(A2)
	MOVE.B 88(A2),81(A2)
	MOVE.B 89(A2),88(A2)
	MOVE.B 96(A2),89(A2)
	MOVE.B 97(A2),96(A2)
	MOVE.B 104(A2),97(A2)
	MOVE.B 105(A2),104(A2)
	MOVE.B 112(A2),105(A2)
	MOVE.B 113(A2),112(A2)
	MOVE.B 120(A2),113(A2)
	MOVE.B 121(A2),120(A2)
	MOVE.B 128(A2),121(A2)
	MOVE.B 129(A2),128(A2)
	MOVE.B 136(A2),129(A2)
	MOVE.B 137(A2),136(A2)
	MOVE.B 144(A2),137(A2)
	MOVE.B 145(A2),144(A2)
	MOVE.B 152(A2),145(A2)
	MOVE.B 153(A2),152(A2)
	MOVE.B D1,153(A2)
	LEA 2(A2),A2
	MOVE.B 1(A2),(A2)
	MOVE.B 8(A2),1(A2)
	MOVE.B 9(A2),8(A2)
	MOVE.B 16(A2),9(A2)
	MOVE.B 17(A2),16(A2)
	MOVE.B 24(A2),17(A2)
	MOVE.B 25(A2),24(A2)
	MOVE.B 32(A2),25(A2)
	MOVE.B 33(A2),32(A2)
	MOVE.B 40(A2),33(A2)
	MOVE.B 41(A2),40(A2)
	MOVE.B 48(A2),41(A2)
	MOVE.B 49(A2),48(A2)
	MOVE.B 56(A2),49(A2)
	MOVE.B 57(A2),56(A2)
	MOVE.B 64(A2),57(A2)
	MOVE.B 65(A2),64(A2)
	MOVE.B 72(A2),65(A2)
	MOVE.B 73(A2),72(A2)
	MOVE.B 80(A2),73(A2)
	MOVE.B 81(A2),80(A2)
	MOVE.B 88(A2),81(A2)
	MOVE.B 89(A2),88(A2)
	MOVE.B 96(A2),89(A2)
	MOVE.B 97(A2),96(A2)
	MOVE.B 104(A2),97(A2)
	MOVE.B 105(A2),104(A2)
	MOVE.B 112(A2),105(A2)
	MOVE.B 113(A2),112(A2)
	MOVE.B 120(A2),113(A2)
	MOVE.B 121(A2),120(A2)
	MOVE.B 128(A2),121(A2)
	MOVE.B 129(A2),128(A2)
	MOVE.B 136(A2),129(A2)
	MOVE.B 137(A2),136(A2)
	MOVE.B 144(A2),137(A2)
	MOVE.B 145(A2),144(A2)
	MOVE.B 152(A2),145(A2)
	MOVE.B 153(A2),152(A2)
	MOVE.B D3,153(A2)
	LEA 160(A1),A1
	LEA 158(A2),A2
	DBF D7,Z

	MOVE.W PIXEL,D7
	TST.W D7
	BNE Y
	MOVE.W #3,PIXEL
	ADD.W #1,LETTER
	RTS
Y:	SUB.W #1,D7
	MOVE.W D7,PIXEL
	RTS

TEKST:
	DC.B	'aaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaaa   lno -THE SUPERVISORS- PROUDLY PRESENT THEIR LAST DEMO CALLED: -GIGASCROLL-.'
	DC.B	'      HI THERE !!!     WE SUPPOSE THIS SCREEN TO BE VERY NICE AND HOPE THAT YOU LIKE IT.   WE HAVE WORKED FOR THAT NOT SO LONG AND NOT VERY '
	DC.B	'HARD, BUT BEFORE THAT, WE HAD HAD TO SPEND MANY MANY HOURS, LEARNING ABOUT THE ATARI ST.   A COUPLE OF PROJECTS, ROUTINES, TRIALS, '
	DC.B	'WRITING THE SOUNDCHIP MUSIC-EDITOR AND ROUTINE ETC. (I THINK ESPECIALLY ABOUT ME, TYPING THIS SCROLL IN THIS '
	DC.B	'MOMENT. MY NAME IS -RALPH-. I HAVE CODED THIS DEMO AND MADE THE MUSIC.  MY FRIEND: -JACK- JOINED ME A FEW MONTHS AGO, STARTING'
	DC.B	' TO LEARN PROGRAMMING FROM ME. HE IS A GRAPHICS MAN AND MY CODING ASSISTANT). WE ARE FOR SURE ONE OF THE '
	DC.B	'BEST OR EVEN THE BEST CODING GROUP IN OUR COUNTRY.  THERE IS ONLY ONE CREW EXCEPT OF US (ALSO DUET), WHICH COULD BE EVEN BETTER'
	DC.B	', BUT I AM AFRAID THEY ARE NOT ALIVE (IT IS A PITY, BECAUSE THEY ARE REALLY GOOD).'
	DC.B	'  SO THERE HAVE BEEN A FEW WORDS ABOUT US AND ABOUT CODING-CREWS IN OUR COUNTRY. NOW LET US TALK ABOUT THIS DEMO.   OUR SCREEN FEATURES VERY'
	DC.B	' NICE SOFTWARE SCROLLING, MANY MANY COLOURS AND A SOUNDCHIP MUSIC TUNE.  THE TUNE WAS COMPOSED AND PROGRAMMED BY '
	DC.B	'ME (-RALPH-). IT IS NOT MAYBE MY THE BEST TUNE BUT IN FACT IT IS THE NEWEST ONE. '
	DC.B	'THEREFORE WE INCLUDED IT IN OUR THE NEWEST DEMO. ALL GRAPHICS WAS DONE WITH DEGAS ELITE, OF COURSE BY -JACK- ('
	DC.B	'THE MAIN SCROLLINE FONTS ARE REALLY FANTASTIC, AREN`T THEY ?). THE BOUNCER, RASTERS AND MAIN SCROLLER USE NORMAL TECHNIQUES OF'
	DC.B	' SOFTWARE ANIMATION. THE MAIN FONTS ARE ON TWO BITPLANES. THEY ARE ALSO RASTERED VERY NICELY.  ALL CAN BE DONE '
	DC.B	'BY MOST OF CODERS ALL OVER THE WORLD.  BUT THESE LITTLE SCROLLERS, IN NUMBER OF TWENTY FIVE, MAY SURPRISE SOME OF YOU '
	DC.B	'(ONLY SOME OF YOU), BECAUSE THEY CANNOT BE DONE WITHIN USUAL METHODS. THIS TECHNIQUE WAS INVENTED BY ME (-RALPH-) '
	DC.B	'AND IT WASN`T HACKED FROM SOME OTHER DEMO (I DO NOT HAVE A HABIT OF HACKING). OF COURSE MANY, MANY CODERS ALL OVER THE '
	DC.B	'WORLD USE THE SAME OR SIMILAR ROUTINE, BECAUSE THERE CANNOT BE ANY OTHER POSSIBILITY TO MOVE TEXT IN MANY DIFFERENT '
	DC.B	'SPEEDS.             '
	DC.B	'OH !!!  I HAVE FORGOTTEN ABOUT SOMETHING VERY VERY INTERESTING.      YOU CAN CONTROL THE SPEED OF EACH LITTLE SCOLLINE ON YOUR OWN !!!     '
	DC.B	'     TO CHOOSE THE SCROLL, WHICH IS TO BE CONTROLED, PRESS A SUITABLE KEY:   `ESC` FOR THE FIRST ONE,`1` FOR THE SECOND ONE, ... ,`O` FOR THE TWENTY FOURTH ONE AND '
	DC.B	'`P` FOR THE TWENTY FIFTH ONE.    THEN DECREASE THE SPEED WITH -MINUS- AND INCREASE WITH -PLUS- ON THE NUMERIC PAD.     HAVE FUN !!!                    '
	DC.B	'     NOW LET`S TALK ABOUT NEW MODEL OF ATARI ST: ATARI STE.  WE HAVE READ IN -LOST BOYS DISK MAGGIE ISSUE 1.- THAT STE IS A GREAT '
	DC.B	'SHIT.  WE ARE NOT AGREE WITH THAT.  WE USE STS BUT MANY OF OUR FRIENDS OWN STE, AND THEY DO NOT COMPLAIN TO THAT. WE '
	DC.B	'HAVE FOUND ONLY ONE SHITTY THING IN STE: IT HAS PROBLEMS IN BOOTING WITH MEDIUM RESULATION.  BUT IT IS NOT TRUE THAT IT'
	DC.B	' DOES NOT READ AND WRITE SOME TRACKS ON THE DISK. WE ARE ALSO IMPRESSED WITH COLOURS, BLITTER SCROLLING AND ESPECIALLY '
	DC.B	'IMPROVED SOUND. PLEASE COMPARE, ON SOME TRACKER (TCB TRACKER FOR INSTANCE), THE ST AND STE PLAYING OPTION. YOU COULDN`T'
	DC.B	' TELL THAT YOU WILL PREFER YM-2491 SOUNDCHIP ANY LONGER.     O.K.   NOW, THERE IS TIME FOR GREETINGS (IN ORDER OF '
	DC.B	'IMPORTANCE)...                    TO -THE LOST BOYS- (WE HOPE YOU LIKE OUR DEMO AND YOU ARE NOT ANGRY FOR THE SIGNS aaaaaaaaaaaaaaaaaaaaa'
	DC.B	'aaaa   WE ALSO HOPE THAT WE WILL OFTEN CORRESPOND WITH YOU AND SOMETIMES MAYBE EVEN WORK WITH YOU.   O.K. WE DO NOT HOPE,  WE DREAM OF IT !!!!!)       TO -LIGHT-  (WE ARE NOT SURE THAT OUR FRIENDS FROM KIELCE CITY HAVE SENT YOU OUR FIR'
	DC.B	'ST DEMO. BUT WE ARE NOT GOING TO CODE ON STE (THE DEMO, YOU SHOULD OBTAIN USES SOME OF STE`S POWER, ANYWAY), SO WE CANNOT'
	DC.B	' WORK TOGETHER. WE HEARD YOU CODED ONLY ON STE.)         THAT IS THE END OF FOREIGN GREETINGS, NOW THE LOCAL ONES...  '
	DC.B	'       -QUANT- (HELLO CHARLIE AND PETER, ARE YOU STILL ALIVE ???),    -ROMAN- (`R` FROM R.M.D.,   THANKS FOR ALL SOFTWARE AND YOUR HELP),           '
	DC.B	'-ZYP- (HELLO, MAYBE YOU ARE ALREADY IN POLAND ???        PLACE IN  lno  IS WAITING FOR YOU),'
	DC.B	'     -ANDRZEJ- (VERY GOOD VECTORS LAST TIME !!!,BUT THEY WILL BE MUCH BETTER WHEN WE RUN THEM IN MACHINE CODE.),           '
	DC.B	'     -VENTYLSOFT-  (THAT IS THE WAY YOU CAN OBTAIN'
	DC.B	' MY PROGRAMS, GUYS !!!    WHAT ABOUT A SAMPLER, HA ????),  -GORSSOFT- (HAVE YOU STILL PROBLEMS WITH YOUR VERY SMOOTH '					
	DC.B	' SCROLLING ???),   -KIJOP- (IS THERE ANY OTHER DEMO TO COME AFTER THE -HALLO BABCIU DEMO- ???),    THE CODERS FROM POZNAN CITY  (SORRY,I CAN`T REMEMBER YOUR NAME...),       '
	DC.B	'-IMMORTALS- (HAVE YOU FORGOTTEN ABOUT US ???  DO YOU '
	DC.B	'WANT US TO TELL EVERYBODY ABOUT YOUR INTRO IN THE TRACKER DISK 1. ???     BY THE WAY, WHY ARE YOU SPREADING THE -LOST BOYS DISK MAGGIE- WITH SOME FILES CUT AWAY ???),'
	DC.B	'    -ROBERT- (WHAT ABOUT YOUR LEARNING C ???),   -RAKU- (WHEN WILL YOU GET ST ?),   -BARTEK- (FROM POLAND),  -DAREK R.- (FROM HUNGARY),   SLAWEK (I`M REALLY SORRY, BUT I CAN`T WRITE YOUR NAME CORRECTLY, `COS I HAVEN`T DONE POLISH FONTS)'
	DC.B	',   -SLAWEK 2- (HELLO SKINHEDZIAK !!!  DO YOU STILL PLAY `KICK OFF 2` EVERY DAY ???),    -MACA- (HI !)   -DAREK- (`D` FROM R.M.D.),   -MAREK- (`M` FROM R.M.D.)'       
	DC.B	'        AND TO THE AMIGA FRIENDS:    -KORSOFT-, -PRZYMUS-, -PREZES- AND -D.J.-.                                 AND THAT IS ALL'
	DC.B	' FOR TODAY.     THE BEST REGARDS FROM US TO YOU, READING THIS TEXT.     SEE YOU LATER, IN THE NEXT DEMO-SCREEN.           '
	DC.B	'BYE-BYE !!!                                                                                                                         AND NOW, -THE SUPERVISORS- STRIKE BACK AND AS USUAL START WITH:',0  
       
ASCII:
	DS.B 32;0
	DC.B 0,48,54,56,57,58,59,53,51,52,0,0,47,50,46,0,36,37,38,39,40,41
	DC.B 42,43,44,45,55,0,0,0,0,49,0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15
	DC.B 16,17,18,19,20,21,22,23,24,25,26,0,0,0,0,0,53,27,0,28,0,29,0,0
	DC.B 0,0,0,0,30,0,31,32,0,0,0,33,0,0,0,0,35,35,34,0,0,0,0,0
	DS.B 128;0

PIX1:	DC.W	0
PIX2:	DC.W	0
PIX3:	DC.W	0
PIX4:	DC.W	0
PIX5:	DC.W	0
PIX6:	DC.W	0
PIX7:	DC.W	0
PIX8:	DC.W	0
PIX9:	DC.W	0
PIX10:	DC.W	0
PIX11:	DC.W	0
PIX12:	DC.W	0
PIX13:	DC.W	0
PIX14:	DC.W	0
PIX15:	DC.W	0
PIX16:	DC.W	0
PIX17:	DC.W	0
PIX18:	DC.W	0
PIX19:	DC.W	0
PIX20:	DC.W	0
PIX21:	DC.W	0
PIX22:	DC.W	0
PIX23:	DC.W	0
PIX24:	DC.W	0
PIX25:	DC.W	0
HBL:	MOVE.W	(A6)+,$FFFF8240.W
	MOVE.W	(A0)+,$FFFF8242.W
	MOVE.L	(A0)+,$FFFF8244.W
	MOVE.L	(A0)+,$FFFF8248.W
	MOVE.L	(A0)+,$FFFF824C.W
	MOVE.B	#1,$FFFFFA21.W
	BCLR	#0,$FFFFFA0F.W
	RTE

VBL:	CLR.B	$FFFFFA1B.W
	MOVE.B	#1,$FFFFFA21.W
	MOVE.B	#8,$FFFFFA1B.W
	LEA	COPPER,A0
	MOVE.W	(A0)+,$FFFF8242.W
	MOVE.L	(A0)+,$FFFF8244.W
	MOVE.L	(A0)+,$FFFF8248.W
	MOVE.L	(A0)+,$FFFF824C.W
	JSR	HS

	LEA	STACK,A3
	LEA	$78000,A2
VC1:	ADD.W	#5,PIX1
	CMP.W	#1280,PIX1
	BMI	PX1
	SUB.W	#1280,PIX1
PX1:	MOVE.W	PIX1,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC2:	ADD.W	#4,PIX2
	CMP.W	#1280,PIX2
	BMI	PX2
	SUB.W	#1280,PIX2
PX2:	MOVE.W	PIX2,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC3:	ADD.W	#3,PIX3
	CMP.W	#1280,PIX3
	BMI	PX3
	SUB.W	#1280,PIX3
PX3:	MOVE.W	PIX3,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC4:	ADD.W	#2,PIX4
	CMP.W	#1280,PIX4
	BMI	PX4
	SUB.W	#1280,PIX4
PX4:	MOVE.W	PIX4,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC5:	ADD.W	#1,PIX5
	CMP.W	#1280,PIX5
	BMI	PX5
	SUB.W	#1280,PIX5
PX5:	MOVE.W	PIX5,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC6:	ADD.W	#2,PIX6
	CMP.W	#1280,PIX6
	BMI	PX6
	SUB.W	#1280,PIX6
PX6:	MOVE.W	PIX6,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC7:	ADD.W	#3,PIX7
	CMP.W	#1280,PIX7
	BMI	PX7
	SUB.W	#1280,PIX7
PX7:	MOVE.W	PIX7,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC8:	ADD.W	#4,PIX8
	CMP.W	#1280,PIX8
	BMI	PX8
	SUB.W	#1280,PIX8
PX8:	MOVE.W	PIX8,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC9:	ADD.W	#5,PIX9
	CMP.W	#1280,PIX9
	BMI	PX9
	SUB.W	#1280,PIX9
PX9:	MOVE.W	PIX9,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC10:	ADD.W	#6,PIX10
	CMP.W	#1280,PIX10
	BMI	PX10
	SUB.W	#1280,PIX10
PX10:	MOVE.W	PIX10,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC11:	ADD.W	#7,PIX11
	CMP.W	#1280,PIX11
	BMI	PX11
	SUB.W	#1280,PIX11
PX11:	MOVE.W	PIX11,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC12:	ADD.W	#8,PIX12
	CMP.W	#1280,PIX12
	BMI	PX12
	SUB.W	#1280,PIX12
PX12:	MOVE.W	PIX12,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC13:	ADD.W	#9,PIX13
	CMP.W	#1280,PIX13
	BMI	PX13
	SUB.W	#1280,PIX13
PX13:	MOVE.W	PIX13,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC14:	ADD.W	#8,PIX14
	CMP.W	#1280,PIX14
	BMI	PX14
	SUB.W	#1280,PIX14
PX14:	MOVE.W	PIX14,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC15:	ADD.W	#7,PIX15
	CMP.W	#1280,PIX15
	BMI	PX15
	SUB.W	#1280,PIX15
PX15:	MOVE.W	PIX15,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC16:	ADD.W	#6,PIX16
	CMP.W	#1280,PIX16
	BMI	PX16
	SUB.W	#1280,PIX16
PX16:	MOVE.W	PIX16,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC17:	ADD.W	#5,PIX17
	CMP.W	#1280,PIX17
	BMI	PX17
	SUB.W	#1280,PIX17
PX17:	MOVE.W	PIX17,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC18:	ADD.W	#4,PIX18
	CMP.W	#1280,PIX18
	BMI	PX18
	SUB.W	#1280,PIX18
PX18:	MOVE.W	PIX18,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC19:	ADD.W	#3,PIX19
	CMP.W	#1280,PIX19
	BMI	PX19
	SUB.W	#1280,PIX19
PX19:	MOVE.W	PIX19,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC20:	ADD.W	#2,PIX20
	CMP.W	#1280,PIX20
	BMI	PX20
	SUB.W	#1280,PIX20
PX20:	MOVE.W	PIX20,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC21:	ADD.W	#1,PIX21
	CMP.W	#1280,PIX21
	BMI	PX21
	SUB.W	#1280,PIX21
PX21:	MOVE.W	PIX21,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC22:	ADD.W	#2,PIX22
	CMP.W	#1280,PIX22
	BMI	PX22
	SUB.W	#1280,PIX22
PX22:	MOVE.W	PIX22,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC23:	ADD.W	#3,PIX23
	CMP.W	#1280,PIX23
	BMI	PX23
	SUB.W	#1280,PIX23
PX23:	MOVE.W	PIX23,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC24:	ADD.W	#4,PIX24
	CMP.W	#1280,PIX24
	BMI	PX24
	SUB.W	#1280,PIX24
PX24:	MOVE.W	PIX24,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA
VC25:	ADD.W	#5,PIX25
	CMP.W	#1280,PIX25
	BMI	PX25
	SUB.W	#1280,PIX25
PX25:	MOVE.W	PIX25,D1
	MOVE.W	D1,D2
	LSR.W	#4,D1
	NOT.W	D2
	AND.W	#$000F,D2
	LSL.W	#1,D1
	MULU	#1600,D2
	MOVE.L	A3,A1
	ADDA.W	D1,A1
	ADDA.W	D2,A1
	BSR	MEGA

	JSR	AV
	JSR	HOP
	JSR	MUZAK+$A8

	CMP.B	#1,HANDLE
	BMI	NONO
	CMP.B	#25,HANDLE
	BHI	NONO
	MOVE.B	HANDLE,NUMER+1
	SUB.W	#1,NUMER

NONO:	TST.B	AUTOR
	BNE	NONONO

	CMP.B	#74,HANDLE
	BNE	NO0
	LEA	VECTOR,A4
	MOVE.W	NUMER,D4
	LSL.W	#2,D4
	ADDA.W	D4,A4
	MOVE.L	(A4),D4
	MOVE.L	D4,A4
	TST.W	(A4)
	BEQ	NO2
	SUB.W	#1,(A4)
	MOVE.B	#1,AUTOR
NO0:
	CMP.B	#78,HANDLE
	BNE	NO2
	LEA	VECTOR,A4
	MOVE.W	NUMER,D4
	LSL.W	#2,D4
	ADDA.W	D4,A4
	MOVE.L	(A4),D4
	MOVE.L	D4,A4
	CMP.W	#20,(A4)
	BEQ	NO2
	ADD.W	#1,(A4)
	MOVE.B	#1,AUTOR
	

NONONO:	CMP.B	#202,HANDLE
	BNE	NO1
	CLR.B	AUTOR
NO1:	CMP.B	#206,HANDLE
	BNE	NO2
	CLR.B	AUTOR
NO2:
	RTE


MEGA:	MOVE.W	(A1)+,(A2)
	MOVE.W	(A1)+,8(A2)
	MOVE.W	(A1)+,16(A2)
	MOVE.W	(A1)+,24(A2)
	MOVE.W	(A1)+,32(A2)
	MOVE.W	(A1)+,40(A2)
	MOVE.W	(A1)+,48(A2)
	MOVE.W	(A1)+,56(A2)
	MOVE.W	(A1)+,64(A2)
	MOVE.W	(A1)+,72(A2)
	MOVE.W	(A1)+,80(A2)
	MOVE.W	(A1)+,88(A2)
	MOVE.W	(A1)+,96(A2)
	MOVE.W	(A1)+,104(A2)
	MOVE.W	(A1)+,112(A2)
	MOVE.W	(A1)+,120(A2)
	MOVE.W	(A1)+,128(A2)
	MOVE.W	(A1)+,136(A2)
	MOVE.W	(A1)+,144(A2)
	MOVE.W	(A1)+,152(A2)
	LEA	160(A1),A1
	LEA	160(A2),A2
	MOVE.W	(A1)+,(A2)
	MOVE.W	(A1)+,8(A2)
	MOVE.W	(A1)+,16(A2)
	MOVE.W	(A1)+,24(A2)
	MOVE.W	(A1)+,32(A2)
	MOVE.W	(A1)+,40(A2)
	MOVE.W	(A1)+,48(A2)
	MOVE.W	(A1)+,56(A2)
	MOVE.W	(A1)+,64(A2)
	MOVE.W	(A1)+,72(A2)
	MOVE.W	(A1)+,80(A2)
	MOVE.W	(A1)+,88(A2)
	MOVE.W	(A1)+,96(A2)
	MOVE.W	(A1)+,104(A2)
	MOVE.W	(A1)+,112(A2)
	MOVE.W	(A1)+,120(A2)
	MOVE.W	(A1)+,128(A2)
	MOVE.W	(A1)+,136(A2)
	MOVE.W	(A1)+,144(A2)
	MOVE.W	(A1)+,152(A2)
	LEA	160(A1),A1
	LEA	160(A2),A2
	MOVE.W	(A1)+,(A2)
	MOVE.W	(A1)+,8(A2)
	MOVE.W	(A1)+,16(A2)
	MOVE.W	(A1)+,24(A2)
	MOVE.W	(A1)+,32(A2)
	MOVE.W	(A1)+,40(A2)
	MOVE.W	(A1)+,48(A2)
	MOVE.W	(A1)+,56(A2)
	MOVE.W	(A1)+,64(A2)
	MOVE.W	(A1)+,72(A2)
	MOVE.W	(A1)+,80(A2)
	MOVE.W	(A1)+,88(A2)
	MOVE.W	(A1)+,96(A2)
	MOVE.W	(A1)+,104(A2)
	MOVE.W	(A1)+,112(A2)
	MOVE.W	(A1)+,120(A2)
	MOVE.W	(A1)+,128(A2)
	MOVE.W	(A1)+,136(A2)
	MOVE.W	(A1)+,144(A2)
	MOVE.W	(A1)+,152(A2)
	LEA	160(A1),A1
	LEA	160(A2),A2
	MOVE.W	(A1)+,(A2)
	MOVE.W	(A1)+,8(A2)
	MOVE.W	(A1)+,16(A2)
	MOVE.W	(A1)+,24(A2)
	MOVE.W	(A1)+,32(A2)
	MOVE.W	(A1)+,40(A2)
	MOVE.W	(A1)+,48(A2)
	MOVE.W	(A1)+,56(A2)
	MOVE.W	(A1)+,64(A2)
	MOVE.W	(A1)+,72(A2)
	MOVE.W	(A1)+,80(A2)
	MOVE.W	(A1)+,88(A2)
	MOVE.W	(A1)+,96(A2)
	MOVE.W	(A1)+,104(A2)
	MOVE.W	(A1)+,112(A2)
	MOVE.W	(A1)+,120(A2)
	MOVE.W	(A1)+,128(A2)
	MOVE.W	(A1)+,136(A2)
	MOVE.W	(A1)+,144(A2)
	MOVE.W	(A1)+,152(A2)
	LEA	160(A1),A1
	LEA	160(A2),A2
	MOVE.W	(A1)+,(A2)
	MOVE.W	(A1)+,8(A2)
	MOVE.W	(A1)+,16(A2)
	MOVE.W	(A1)+,24(A2)
	MOVE.W	(A1)+,32(A2)
	MOVE.W	(A1)+,40(A2)
	MOVE.W	(A1)+,48(A2)
	MOVE.W	(A1)+,56(A2)
	MOVE.W	(A1)+,64(A2)
	MOVE.W	(A1)+,72(A2)
	MOVE.W	(A1)+,80(A2)
	MOVE.W	(A1)+,88(A2)
	MOVE.W	(A1)+,96(A2)
	MOVE.W	(A1)+,104(A2)
	MOVE.W	(A1)+,112(A2)
	MOVE.W	(A1)+,120(A2)
	MOVE.W	(A1)+,128(A2)
	MOVE.W	(A1)+,136(A2)
	MOVE.W	(A1)+,144(A2)
	MOVE.W	(A1)+,152(A2)
	LEA	160(A1),A1
	LEA	160(A2),A2
	MOVE.W	(A1)+,(A2)
	MOVE.W	(A1)+,8(A2)
	MOVE.W	(A1)+,16(A2)
	MOVE.W	(A1)+,24(A2)
	MOVE.W	(A1)+,32(A2)
	MOVE.W	(A1)+,40(A2)
	MOVE.W	(A1)+,48(A2)
	MOVE.W	(A1)+,56(A2)
	MOVE.W	(A1)+,64(A2)
	MOVE.W	(A1)+,72(A2)
	MOVE.W	(A1)+,80(A2)
	MOVE.W	(A1)+,88(A2)
	MOVE.W	(A1)+,96(A2)
	MOVE.W	(A1)+,104(A2)
	MOVE.W	(A1)+,112(A2)
	MOVE.W	(A1)+,120(A2)
	MOVE.W	(A1)+,128(A2)
	MOVE.W	(A1)+,136(A2)
	MOVE.W	(A1)+,144(A2)
	MOVE.W	(A1)+,152(A2)
	LEA	160(A1),A1
	LEA	160(A2),A2
	MOVE.W	(A1)+,(A2)
	MOVE.W	(A1)+,8(A2)
	MOVE.W	(A1)+,16(A2)
	MOVE.W	(A1)+,24(A2)
	MOVE.W	(A1)+,32(A2)
	MOVE.W	(A1)+,40(A2)
	MOVE.W	(A1)+,48(A2)
	MOVE.W	(A1)+,56(A2)
	MOVE.W	(A1)+,64(A2)
	MOVE.W	(A1)+,72(A2)
	MOVE.W	(A1)+,80(A2)
	MOVE.W	(A1)+,88(A2)
	MOVE.W	(A1)+,96(A2)
	MOVE.W	(A1)+,104(A2)
	MOVE.W	(A1)+,112(A2)
	MOVE.W	(A1)+,120(A2)
	MOVE.W	(A1)+,128(A2)
	MOVE.W	(A1)+,136(A2)
	MOVE.W	(A1)+,144(A2)
	MOVE.W	(A1)+,152(A2)
	LEA	320(A1),A1
	LEA	320(A2),A2
	RTS

TEX:	DC.B	27,'E',27,'b',1,27,'f',27,'q',27,'v'
	DC.B	'CREDITS FOR THIS DEMO-SCREEN ARE:    ALL'
	DC.B	' CODING,MUSIC PROGRAMMING AND COMPOSING:'
	DC.B	' -RALPH-, ALL GRAPHICS,CHARACTERS AND CO'
	DC.B	'LOURS: -JACK-. BIG HELLO TO -TLB-.      '
	DC.B	'CREDITS FOR THIS DEMO-SCREEN ARE:       ',0
	EVEN

COPPER:
	DC.W	$700,$000,$000,$000,$000,$000,$000	
	DC.W	$700,$000,$000,$000,$000,$000,$000
	DC.W	$700,$036,$036,$267,$267,$014,$014	
	DC.W	$700,$377,$377,$036,$036,$025,$025		
	DC.W	$700,$005,$005,$036,$036,$025,$025	
	DC.W	$700,$006,$006,$025,$025,$036,$036
	DC.W	$700,$007,$007,$025,$025,$047,$047	
	DC.W	$700,$117,$117,$014,$014,$157,$157		
	DC.W	$600,$227,$227,$210,$210,$267,$267	
	DC.W	$600,$337,$337,$210,$210,$377,$377
	DC.W	$600,$447,$447,$210,$210,$477,$477	
	DC.W	$600,$557,$557,$210,$210,$540,$540		
	DC.W	$600,$667,$667,$210,$210,$650,$650	
	DC.W	$600,$777,$777,$320,$320,$760,$760
	DC.W	$600,$000,$000,$430,$430,$761,$761	
	DC.W	$600,$000,$000,$540,$540,$762,$762		
	DC.W	$500,$000,$000,$650,$650,$763,$763	
	DC.W	$500,$760,$760,$760,$760,$764,$764
	DC.W	$500,$650,$650,$761,$761,$765,$765	
	DC.W	$500,$540,$540,$762,$762,$766,$766		
	DC.W	$500,$540,$540,$760,$760,$765,$765	
	DC.W	$500,$430,$430,$650,$650,$764,$764
	DC.W	$500,$320,$320,$000,$000,$763,$763	
	DC.W	$500,$000,$000,$000,$000,$000,$000		
	DC.W	$400,$000,$000,$000,$000,$000,$000	
	DC.W	$400,$000,$400,$055,$400,$707,$400
	DC.W	$400,$000,$400,$044,$400,$707,$400	
	DC.W	$400,$000,$400,$033,$400,$707,$400	
	DC.W	$400,$000,$400,$022,$400,$707,$400	
	DC.W	$400,$000,$400,$011,$400,$707,$400
	DC.W	$400,$000,$400,$055,$400,$707,$400	
	DC.W	$400,$000,$400,$044,$400,$707,$400
	DC.W	$300,$000,$300,$033,$300,$707,$400	
	DC.W	$300,$000,$300,$022,$300,$707,$300
	DC.W	$300,$000,$300,$011,$300,$707,$300	
	DC.W	$300,$000,$300,$055,$300,$707,$300
	DC.W	$300,$000,$300,$044,$300,$707,$300	
	DC.W	$300,$000,$300,$033,$300,$707,$300
	DC.W	$300,$000,$300,$022,$300,$707,$300	
	DC.W	$300,$000,$300,$011,$300,$707,$300		
	DC.W	$400,$000,$400,$055,$400,$707,$400	
	DC.W	$400,$000,$400,$044,$400,$707,$400
	DC.W	$400,$000,$400,$033,$400,$707,$400	
	DC.W	$400,$000,$400,$001,$400,$707,$400		
	DC.W	$400,$000,$400,$002,$400,$707,$400	
	DC.W	$400,$001,$400,$002,$400,$707,$400
	DC.W	$400,$001,$400,$002,$400,$707,$400
	DC.W	$400,$001,$400,$002,$400,$707,$400		
	DC.W	$500,$001,$500,$002,$500,$707,$500	
	DC.W	$500,$001,$500,$002,$500,$707,$500
	DC.W	$500,$001,$500,$002,$500,$707,$500	
	DC.W	$500,$001,$500,$002,$500,$707,$500		
	DC.W	$500,$001,$500,$002,$500,$707,$500	
	DC.W	$500,$001,$500,$002,$500,$707,$500
	DC.W	$500,$002,$500,$003,$500,$707,$500	
	DC.W	$500,$001,$500,$002,$500,$707,$500		
	DC.W	$600,$002,$600,$003,$600,$707,$600	
	DC.W	$600,$001,$600,$002,$600,$707,$600
	DC.W	$600,$002,$600,$003,$600,$707,$600
	DC.W	$600,$002,$600,$003,$600,$707,$600
	DC.W	$600,$002,$600,$003,$600,$707,$600
	DC.W	$600,$002,$600,$003,$600,$707,$600
	DC.W	$600,$003,$600,$004,$600,$707,$600
	DC.W	$600,$002,$600,$003,$600,$707,$600
	DC.W	$700,$003,$700,$004,$700,$707,$700
	DC.W	$700,$002,$700,$003,$700,$707,$700
	DC.W	$700,$003,$700,$004,$700,$707,$700
	DC.W	$700,$003,$700,$004,$700,$707,$700
	DC.W	$700,$003,$700,$004,$700,$707,$700
	DC.W	$700,$003,$700,$004,$700,$707,$700
	DC.W	$700,$004,$700,$005,$700,$707,$700
	DC.W	$700,$003,$700,$004,$700,$707,$700	
	DC.W	$720,$004,$720,$005,$720,$707,$720	
	DC.W	$720,$003,$720,$004,$720,$707,$720
	DC.W	$720,$004,$720,$005,$720,$707,$720	
	DC.W	$720,$004,$720,$005,$720,$707,$720		
	DC.W	$720,$004,$720,$005,$720,$707,$720	
	DC.W	$720,$004,$720,$005,$720,$707,$720
	DC.W	$720,$005,$720,$006,$720,$707,$720	
	DC.W	$720,$004,$720,$005,$720,$707,$720		
	DC.W	$740,$005,$740,$006,$740,$707,$740	
	DC.W	$740,$004,$740,$005,$740,$707,$740
	DC.W	$740,$005,$740,$006,$740,$707,$740	
	DC.W	$740,$005,$740,$006,$740,$707,$740		
	DC.W	$740,$005,$740,$006,$740,$707,$740	
	DC.W	$740,$005,$740,$006,$740,$707,$740
	DC.W	$740,$006,$740,$007,$740,$707,$740	
	DC.W	$740,$005,$740,$006,$740,$707,$740		
	DC.W	$760,$006,$760,$007,$760,$707,$760	
	DC.W	$760,$005,$760,$006,$760,$707,$760
	DC.W	$760,$006,$760,$007,$760,$707,$760	
	DC.W	$760,$006,$760,$007,$760,$707,$760		
	DC.W	$760,$006,$760,$007,$760,$707,$760	
	DC.W	$760,$006,$760,$007,$760,$707,$760
	DC.W	$760,$007,$760,$117,$760,$707,$760	
	DC.W	$760,$006,$760,$007,$760,$707,$760		
	DC.W	$771,$007,$771,$117,$771,$707,$771	
	DC.W	$771,$006,$771,$007,$771,$707,$771
	DC.W	$771,$007,$771,$117,$771,$707,$771
	DC.W	$771,$007,$771,$117,$771,$707,$771		
	DC.W	$771,$007,$771,$117,$771,$707,$771
	DC.W	$771,$007,$771,$117,$771,$707,$771
	DC.W	$771,$006,$771,$007,$771,$606,$771
	DC.W	$771,$007,$771,$117,$771,$606,$771	
	DC.W	$760,$006,$760,$007,$760,$606,$760	
	DC.W	$760,$007,$760,$117,$760,$606,$760
	DC.W	$760,$006,$760,$007,$760,$606,$760	
	DC.W	$760,$006,$760,$007,$760,$606,$760		
	DC.W	$760,$006,$760,$007,$760,$505,$760	
	DC.W	$760,$006,$760,$007,$760,$505,$760
	DC.W	$760,$005,$760,$006,$760,$505,$760	
	DC.W	$760,$006,$760,$007,$760,$505,$760		
	DC.W	$740,$005,$740,$006,$740,$505,$740	
	DC.W	$740,$006,$740,$007,$740,$505,$740
	DC.W	$740,$005,$740,$006,$740,$404,$740	
	DC.W	$740,$005,$740,$006,$740,$404,$740		
	DC.W	$740,$005,$740,$006,$740,$404,$740	
	DC.W	$740,$005,$740,$006,$740,$404,$740
	DC.W	$740,$004,$740,$005,$740,$404,$740	
	DC.W	$740,$005,$740,$006,$740,$404,$740	
	DC.W	$720,$004,$720,$005,$720,$303,$720	
	DC.W	$720,$005,$720,$006,$720,$303,$720
	DC.W	$720,$004,$720,$005,$720,$303,$720	
	DC.W	$720,$004,$720,$005,$720,$303,$720		
	DC.W	$720,$004,$720,$005,$720,$303,$720	
	DC.W	$720,$004,$720,$005,$720,$303,$720
	DC.W	$720,$003,$720,$004,$720,$202,$720	
	DC.W	$720,$004,$720,$005,$720,$202,$720	
	DC.W	$700,$003,$700,$004,$700,$202,$700	
	DC.W	$700,$004,$700,$005,$700,$202,$700
	DC.W	$700,$003,$700,$004,$700,$202,$700	
	DC.W	$700,$003,$700,$004,$700,$202,$700		
	DC.W	$700,$003,$700,$004,$700,$101,$700	
	DC.W	$700,$003,$700,$004,$700,$101,$700
	DC.W	$700,$002,$700,$003,$700,$101,$700	
	DC.W	$700,$003,$700,$004,$700,$101,$700		
	DC.W	$600,$003,$600,$003,$600,$101,$600	
	DC.W	$600,$002,$600,$004,$600,$101,$600
	DC.W	$600,$002,$600,$003,$600,$101,$600	
	DC.W	$600,$002,$600,$002,$600,$101,$600		
	DC.W	$600,$002,$600,$002,$600,$101,$600	
	DC.W	$600,$002,$600,$002,$600,$101,$600
	DC.W	$600,$002,$600,$002,$600,$101,$600	
	DC.W	$600,$002,$600,$002,$600,$101,$600		
	DC.W	$500,$002,$500,$002,$500,$101,$500	
	DC.W	$500,$001,$500,$001,$500,$101,$500
	DC.W	$500,$000,$500,$000,$500,$101,$500	
	DC.W	$500,$100,$500,$033,$500,$101,$500		
	DC.W	$500,$100,$500,$022,$500,$101,$500	
	DC.W	$500,$100,$500,$011,$500,$101,$500
	DC.W	$500,$100,$500,$055,$500,$101,$500	
	DC.W	$500,$100,$500,$044,$500,$101,$500		
	DC.W	$400,$100,$400,$033,$400,$101,$400	
	DC.W	$400,$100,$400,$022,$400,$101,$400
	DC.W	$400,$100,$400,$011,$400,$101,$400	
	DC.W	$400,$100,$400,$055,$400,$101,$400		
	DC.W	$400,$100,$400,$044,$400,$101,$400	
	DC.W	$400,$100,$400,$033,$400,$101,$400
	DC.W	$400,$100,$400,$022,$400,$101,$400	
	DC.W	$400,$100,$400,$011,$400,$101,$400
	DC.W	$300,$100,$300,$055,$300,$101,$300	
	DC.W	$300,$100,$300,$044,$300,$101,$300
	DC.W	$300,$100,$300,$033,$300,$101,$300	
	DC.W	$300,$100,$300,$022,$300,$101,$300		
	DC.W	$300,$100,$300,$011,$300,$101,$300	
	DC.W	$300,$100,$300,$055,$300,$101,$300
	DC.W	$300,$100,$300,$044,$300,$101,$300	
	DC.W	$300,$100,$300,$033,$300,$101,$300	
	DC.W	$400,$100,$400,$022,$400,$101,$400	
	DC.W	$400,$100,$400,$011,$400,$101,$400
	DC.W	$400,$100,$400,$055,$400,$101,$400

	DC.W	$400,$777,$400,$044,$400,$002,$002
	DC.W	$400,$001,$001,$033,$400,$003,$003	
	DC.W	$400,$002,$002,$011,$400,$004,$004	
	DC.W	$400,$003,$003,$055,$500,$005,$005	
	DC.W	$400,$004,$004,$044,$500,$006,$006
	DC.W	$500,$005,$005,$033,$000,$007,$007	
	DC.W	$500,$006,$006,$000,$000,$017,$017		
	DC.W	$500,$117,$117,$267,$267,$027,$027	
	DC.W	$500,$227,$227,$036,$036,$037,$037
	DC.W	$500,$337,$337,$036,$036,$047,$047	
	DC.W	$500,$447,$447,$025,$025,$057,$057		
	DC.W	$500,$557,$557,$025,$025,$067,$067	
	DC.W	$500,$667,$667,$014,$014,$777,$777
	DC.W	$600,$667,$667,$210,$210,$430,$430	
	DC.W	$600,$777,$777,$210,$210,$430,$430		
	DC.W	$600,$777,$777,$210,$210,$430,$430	
	DC.W	$600,$777,$777,$320,$320,$540,$540
	DC.W	$600,$777,$777,$430,$430,$650,$650	
	DC.W	$600,$777,$777,$540,$540,$760,$760		
	DC.W	$600,$777,$777,$650,$650,$761,$761	
	DC.W	$600,$667,$667,$760,$760,$762,$762
	DC.W	$700,$667,$667,$761,$761,$763,$763	
	DC.W	$700,$557,$557,$762,$762,$764,$764		
	DC.W	$700,$447,$447,$763,$763,$765,$765	
	DC.W	$700,$337,$337,$764,$764,$766,$766
	DC.W	$700,$227,$227,$765,$765,$765,$765	
	DC.W	$700,$430,$430,$650,$650,$764,$764
	DC.W	$700,$227,$227,$765,$765,$765,$765	
	DC.W	$700,$430,$430,$650,$650,$764,$764



	DS.W	200
DLIST:	DC.W	$101,$303,$505,$707
	DC.W	$505,$303,$101,$102
	DC.W	$102,$102,$102,$102
	DC.W	$102,$102,$102,$102
	DC.W	$102,$102,$102,$102
	DC.W	$102,$102,$102,$102
	DC.W	$102,$102,$102,$102
	DC.W	$102,$102,$102,$102
	DC.W	$102,$102,$102,$102
	DC.W	$102,$101,$303,$505
	DC.W	$606,$505,$303,$101
	DS.W	200

FONTS:
	INCBIN	A:\DEMO1.S\GIGASCR1.PI1
	EVEN

CLS:	DC.W	0
BLITT:	DC.W	0
HANDLE:	DC.B	0
AUTOR:	DC.B	0
NUMER:	DC.W	0
VECTOR:	DS.L	25

GFX:
	INCBIN	A:\DEMO1.S\GIGASCR2.PI1
	EVEN

CNT:	DC.W	0

JUMP:	DC.W	0,1,2,3,4,6,8,10,12,15,18,21,24,28,32,36,40,45,50,55,60
	DC.W	66,72,78,84,91,98,105,112,120,128,136,144,153
	DC.W	144,136,128,120,112,105,98,91,84,78,72,66
	DC.W	60,55,50,45,40,36,32,28,24,21,18,15,12,10,8,6,4,3,2,1,0

	DC.W	$FFFF

HOP:	MOVE.W	CNT,D0
	LSL.W	#1,D0
	LEA	JUMP,A2
	MOVE.W	0(A2,D0.W),D0
	CMP.W	#$FFFF,D0
	BNE	NE
	MOVE.W	JUMP,D0
NE:	MOVE.W	D0,BLITT
	LEA	$78006,A2
	MOVE.W	CLS,D2
	ADD.W	#10,D2
	MULU	#160,D2
	ADDA.W	D2,A2
	MOVEQ	#23,D2
H1:	
	CLR.W	32(A2)
	CLR.W	40(A2)
	CLR.W	48(A2)
	CLR.W	56(A2)
	CLR.W	64(A2)
	CLR.W	72(A2)
	CLR.W	80(A2)
	CLR.W	88(A2)
	CLR.W	96(A2)
	CLR.W	104(A2)
	CLR.W	112(A2)
	CLR.W	120(A2)

	LEA	160(A2),A2
	DBF	D2,H1

	LEA	FONTS+34,A1
	ADDA.L	#32000,A1
	MOVE.W	#160,D1
	MULU	#24,D1
	SUBA.W	D1,A1
	LEA	$78006,A2
	MOVE.W	BLITT,D2
	ADD.W	#10,D2
	MOVE.W	BLITT,CLS
	MULU	#160,D2
	ADDA.W	D2,A2
	MOVEQ	#23,D2
H2:	
	MOVE.W	32(A1),32(A2)
	MOVE.W	40(A1),40(A2)
	MOVE.W	48(A1),48(A2)
	MOVE.W	56(A1),56(A2)
	MOVE.W	64(A1),64(A2)
	MOVE.W	72(A1),72(A2)
	MOVE.W	80(A1),80(A2)
	MOVE.W	88(A1),88(A2)
	MOVE.W	96(A1),96(A2)
	MOVE.W	104(A1),104(A2)
	MOVE.W	112(A1),112(A2)
	MOVE.W	120(A1),120(A2)

	LEA	160(A1),A1
	LEA	160(A2),A2
	DBF	D2,H2
	RTS

HS:	MOVE.W	CNT,D0
	LSL.W	#1,D0
	LEA	JUMP,A5
	MOVE.W	$0(A5,D0.W),D0
	CMP.W	#$FFFF,D0
	BNE	HHS
	CLR.W	CNT
	BRA.S	HS
HHS:	ADD.W	#1,CNT
	LEA	DLIST,A6
	LSL.W	#1,D0
	SUBA.W	D0,A6
	RTS

MUZAK:
	INCBIN	A:\DEMO1.S\GIGASCR.MUZ
	EVEN

	DS.L	100
STACK:

