;************************************
;     DIGITAL DRUMS MUZAX PLAYER 
;          by Ralph Rudzki
;        for own muzax files.
;************************************

	DC.W	$A00A
	PEA	0
	MOVE.W	#$20,-(A7)
	TRAP	#1
	LEA	6(A7),A7
	PEA	TEX
	MOVE.W	#9,-(A7)
	TRAP	#1
	LEA	6(A7),A7
	MOVE.L	$70.W,OLDVBL+2
	MOVE.L	$134.W,OLDSAM+2
	MOVE.B	$FFFFFA07.W,MFPA07+3
	MOVE.B	$FFFFFA09.W,MFPA09+3
	MOVE.B	$FFFFFA13.W,MFPA13+3
	MOVE.B	$FFFFFA17.W,MFPA17+3
	MOVE.B	$FFFFFA19.W,MFPA19+3
	MOVE.B	$FFFFFA1F.W,MFPA1F+3
	MOVE.B	#$20,$FFFFFA07.W
	MOVE.B	#$20,$FFFFFA13.W
	CLR.B	$FFFFFA09.W
	BCLR	#3,$FFFFFA17.W
	MOVE.B	#1,$FFFFFA19.W
	MOVE.B	#$3D,$FFFFFA1F.W
	MOVE.L	$70.W,MC+$2A
	MOVE.L	#MC,$70.W
	MOVE.L	#MC+$466,$134.W
LOOP:	STOP	#$2300
	CMP.B	#$39,$FFFFFC02.W
	BNE	LOOP
MFPA07:	MOVE.B	#0,$FFFFFA07.W
MFPA09:	MOVE.B	#0,$FFFFFA09.W
MFPA13:	MOVE.B	#0,$FFFFFA13.W
MFPA17:	MOVE.B	#0,$FFFFFA17.W
MFPA19:	MOVE.B	#0,$FFFFFA19.W
MFPA1F:	MOVE.B	#0,$FFFFFA1F.W
OLDVBL:	MOVE.L	#0,$70.W
OLDSAM:	MOVE.L	#0,$134.W
	MOVE.L	#$08000000,$FFFF8800.W
	MOVE.L	#$09000000,$FFFF8800.W
	MOVE.L	#$0A000000,$FFFF8800.W
	CLR.W	-(A7)
	TRAP	#1

MC:	INCBIN	A:\IMPROVED.MUX\RALPH_I2.MUX
TEX:	DC.B	27,'HPlaying a tune...',0
