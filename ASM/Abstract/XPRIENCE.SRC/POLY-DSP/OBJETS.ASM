; Description des objets
; Adresse des points, nombre de points
; Adresse des faces, nombre de faces
; Coefficient pour le Gouraud Shading [rapport Intensit‚ / Profondeur (Z)]

OBJETS		DC		CUBE_POINTS,8,CUBE_FACES,6,$800000*495/1600
			DC		GATO_POINTS,16,GATO_FACES,10,$800000*495/1600
			DC		BOUZOU_POINTS,12,BOUZOU_FACES,20,$800000*495/900
			DC		SPACE_POINTS,28,SPACE_FACES,17,$800000*495/1200
			DC		DIAMOND_POINTS,17,DIAMOND_FACES,18,$800000*495/1800
			DC		ROND_POINTS,32,ROND_FACES,20,$800000*495/1200
			DC		OBJ_POINTS,24,OBJ_FACES,26,$800000*495/500

; Description des Faces
; Nombre de Points
; Liste des num‚ros de Point
; Type de polygone :	1 = Normal	Couleur
;					2 = Gouraud	Infos Adresse Couleurs
;					3 = Mapping	Infos Adresse Image + Coordonn‚es

CUBE_FACES	DC		4,0,1,2,3,2,GOURAUD1
			DC		4,7,6,5,4,2,GOURAUD2
			DC		4,1,5,6,2,2,GOURAUD3
			DC		4,0,3,7,4,2,GOURAUD4
			DC		4,0,4,5,1,2,GOURAUD10
			DC		4,3,2,6,7,2,GOURAUD11

CUBE_POINTS	DC		-50*512,-50*512,+50*512
			DC		+50*512,-50*512,+50*512
			DC		+50*512,+50*512,+50*512
			DC		-50*512,+50*512,+50*512
			
			DC		-50*512,-50*512,-50*512
			DC		+50*512,-50*512,-50*512
			DC		+50*512,+50*512,-50*512
			DC		-50*512,+50*512,-50*512


GATO_FACES	DC		8,0,1,2,3,4,5,6,7,2,GOURAUD8
			DC		8,15,14,13,12,11,10,9,8,2,GOURAUD8
			DC		4,1,0,8,9,2,GOURAUD8
			DC		4,2,1,9,10,2,GOURAUD8
			DC		4,3,2,10,11,2,GOURAUD8
			DC		4,4,3,11,12,2,GOURAUD8
			DC		4,5,4,12,13,2,GOURAUD8
			DC		4,6,5,13,14,2,GOURAUD8
			DC		4,7,6,14,15,2,GOURAUD8
			DC		4,0,7,15,8,2,GOURAUD8

GATO_POINTS	DC		+80*512,+00*512,-13*512
			DC		+56*512,-56*512,-13*512
			DC		+00*512,-80*512,-13*512
			DC		-56*512,-56*512,-13*512
			DC		-80*512,+00*512,-13*512
			DC		-56*512,+56*512,-13*512
			DC		+00*512,+80*512,-13*512
			DC		+56*512,+56*512,-13*512

			DC		+54*512,+00*512,+13*512
			DC		+39*512,-39*512,+13*512
			DC		+00*512,-54*512,+13*512
			DC		-39*512,-39*512,+13*512
			DC		-54*512,+00*512,+13*512
			DC		-39*512,+39*512,+13*512
			DC		+00*512,+54*512,+13*512
			DC		+39*512,+39*512,+13*512


BOUZOU_POINTS	DC		40*512,0*512,55*512
			DC		-20*512,35*512,55*512
			DC		-20*512,-35*512,55*512

			DC		40*512,0*512,-55*512
			DC		-20*512,35*512,-55*512
			DC		-20*512,-35*512,-55*512

			DC		70*512,0*512,0*512
			DC		35*512,61*512,0*512
			DC		-35*512,61*512,0*512
			DC		-70*512,0*512,0*512
			DC		-35*512,-61*512,0*512
			DC		35*512,-61*512,0*512

BOUZOU_FACES	DC		3,0,1,2,2,GOURAUD7
			DC		3,5,4,3,2,GOURAUD7

			DC		3,0,2,11,2,GOURAUD7
			DC		3,0,11,6,2,GOURAUD7
			DC		3,0,6,7,2,GOURAUD7
			DC		3,1,0,7,2,GOURAUD7
			DC		3,1,7,8,2,GOURAUD7
			DC		3,1,8,9,2,GOURAUD7
			DC		3,2,1,9,2,GOURAUD7
			DC		3,2,9,10,2,GOURAUD7
			DC		3,2,10,11,2,GOURAUD7

			DC		3,3,11,5,2,GOURAUD7
			DC		3,3,6,11,2,GOURAUD7
			DC		3,3,7,6,2,GOURAUD7
			DC		3,4,7,3,2,GOURAUD7
			DC		3,4,8,7,2,GOURAUD7
			DC		3,4,9,8,2,GOURAUD7
			DC		3,5,9,4,2,GOURAUD7
			DC		3,5,10,9,2,GOURAUD7
			DC		3,5,11,10,2,GOURAUD7

ROND_POINTS	DC		0*512,-60*512,40*512
			DC		22*512,-55*512,40*512
			DC		41*512,-41*512,40*512
			DC		55*512,-22*512,40*512
			DC		60*512,0*512,40*512
			DC		55*512,22*512,40*512
			DC		41*512,41*512,40*512
			DC		22*512,55*512,40*512
			DC		0*512,60*512,40*512
			DC		-22*512,55*512,40*512
			DC		-41*512,41*512,40*512
			DC		-55*512,22*512,40*512
			DC		-60*512,0*512,40*512
			DC		-55*512,-22*512,40*512
			DC		-41*512,-41*512,40*512
			DC		-22*512,-55*512,40*512

			DC		0*512,-60*512,-40*512
			DC		22*512,-55*512,-40*512
			DC		41*512,-41*512,-40*512
			DC		55*512,-22*512,-40*512
			DC		60*512,0*512,-40*512
			DC		55*512,22*512,-40*512
			DC		41*512,41*512,-40*512
			DC		22*512,55*512,-40*512
			DC		0*512,60*512,-40*512
			DC		-22*512,55*512,-40*512
			DC		-41*512,41*512,-40*512
			DC		-55*512,22*512,-40*512
			DC		-60*512,0*512,-40*512
			DC		-55*512,-22*512,-40*512
			DC		-41*512,-41*512,-40*512
			DC		-22*512,-55*512,-40*512

ROND_FACES	DC		9
			DC		8,0,1,2,3,4,5,6,7
			DC		2,GOURAUD2
			DC		9
			DC		0,8,9,10,11,12,13,14,15
			DC		2,GOURAUD2
			DC		9
			DC		24,16,31,30,29,28,27,26,25
			DC		2,GOURAUD2
			DC		9
			DC		16,24,23,22,21,20,19,18,17
			DC		2,GOURAUD2
			DC		4
			DC		0,16,17,1
			DC		2,GOURAUD3
			DC		4
			DC		1,17,18,2
			DC		2,GOURAUD3
			DC		4
			DC		2,18,19,3
			DC		2,GOURAUD3
			DC		4
			DC		3,19,20,4
			DC		2,GOURAUD3
			DC		4
			DC		4,20,21,5
			DC		2,GOURAUD3
			DC		4
			DC		5,21,22,6
			DC		2,GOURAUD3
			DC		4
			DC		6,22,23,7
			DC		2,GOURAUD3
			DC		4
			DC		7,23,24,8
			DC		2,GOURAUD3
			DC		4
			DC		8,24,25,9
			DC		2,GOURAUD3
			DC		4
			DC		9,25,26,10
			DC		2,GOURAUD3
			DC		4
			DC		10,26,27,11
			DC		2,GOURAUD3
			DC		4
			DC		11,27,28,12
			DC		2,GOURAUD3
			DC		4
			DC		12,28,29,13
			DC		2,GOURAUD3
			DC		4
			DC		13,29,30,14
			DC		2,GOURAUD3
			DC		4
			DC		14,30,31,15
			DC		2,GOURAUD3
			DC		4
			DC		15,31,16,0
			DC		2,GOURAUD3


DIAMOND_POINTS	DC		-26*512,-60*512,-80*512
			DC		26*512,-60*512,-80*512
			DC		60*512,-26*512,-80*512
			DC		60*512,26*512,-80*512
			DC		26*512,60*512,-80*512
			DC		-26*512,60*512,-80*512
			DC		-60*512,26*512,-80*512
			DC		-60*512,-26*512,-80*512

			DC		-16*512,-44*512,-108*512
			DC		16*512,-44*512,-108*512
			DC		44*512,-16*512,-108*512
			DC		44*512,16*512,-108*512
			DC		16*512,44*512,-108*512
			DC		-16*512,44*512,-108*512
			DC		-44*512,16*512,-108*512
			DC		-44*512,-16*512,-108*512

			DC		0*512,0*512,0*512

DIAMOND_FACES	DC		3
			DC		0,1,16
			DC		2,GOURAUD4
			DC		3
			DC		1,2,16
			DC		2,GOURAUD4
			DC		3
			DC		2,3,16
			DC		2,GOURAUD4
			DC		3
			DC		3,4,16
			DC		2,GOURAUD4
			DC		3
			DC		4,5,16
			DC		2,GOURAUD4
			DC		3
			DC		5,6,16
			DC		2,GOURAUD4
			DC		3
			DC		6,7,16
			DC		2,GOURAUD4
			DC		3
			DC		7,0,16
			DC		2,GOURAUD4
			DC		4
			DC		1,0,8,9
			DC		2,GOURAUD4
			DC		4
			DC		0,7,15,8
			DC		2,GOURAUD4
			DC		4
			DC		7,6,14,15
			DC		2,GOURAUD4
			DC		4
			DC		6,5,13,14
			DC		2,GOURAUD4
			DC		4
			DC		5,4,12,13
			DC		2,GOURAUD4
			DC		4
			DC		4,3,11,12
			DC		2,GOURAUD4
			DC		4
			DC		3,2,10,11
			DC		2,GOURAUD4
			DC		4
			DC		2,1,9,10
			DC		2,GOURAUD4

			DC		5
			DC		13,9,8,15,14
			DC		2,GOURAUD4
			DC		5
			DC		9,13,12,11,10
			DC		2,GOURAUD4


SPACE_POINTS	DC		-20*512,-75*512,+0*512
			DC		+20*512,-75*512,+0*512
			DC		+60*512,+25*512,+0*512
			DC		+40*512,+55*512,10*512
			DC		-40*512,+55*512,10*512
			DC		-60*512,+25*512,+0*512
			DC		-26*512,+25*512,+30*512
			DC		+26*512,+25*512,+30*512
			DC		+40*512,+55*512,-10*512
			DC		-40*512,+55*512,-10*512
			DC		-20*512,+25*512,-20*512
			DC		+20*512,+25*512,-20*512

			DC		30*512,55*512,-10*512
			DC		20*512,55*512,-10*512
			DC		15*512,55*512,-5*512
			DC		15*512,55*512,5*512
			DC		20*512,55*512,10*512
			DC		30*512,55*512,10*512
			DC		35*512,55*512,5*512
			DC		35*512,55*512,-5*512
				
			DC		-30*512,55*512,-10*512
			DC		-20*512,55*512,-10*512
			DC		-15*512,55*512,-5*512
			DC		-15*512,55*512,5*512
			DC		-20*512,55*512,10*512
			DC		-30*512,55*512,10*512
			DC		-35*512,55*512,5*512
			DC		-35*512,55*512,-5*512

SPACE_FACES	DC		4
			DC		0,1,7,6,2,GOURAUD4
			DC		3
			DC		7,1,2,2,GOURAUD4
			DC		3
			DC		0,6,5,2,GOURAUD4
			DC		3
			DC		7,2,3,2,GOURAUD4
			DC		3
			DC		4,5,6,2,GOURAUD4
			DC		4
			DC		3,4,6,7,2,GOURAUD4
			DC		4
			DC		4,3,8,9,2,GOURAUD3
			DC		3
			DC		3,2,8,2,GOURAUD3
			DC		3
			DC		9,5,4,2,GOURAUD3
			DC		4
			DC		1,0,10,11,2,GOURAUD3
			DC		3
			DC		2,1,11,2,GOURAUD3
			DC		3
			DC		0,5,10,2,GOURAUD3
			DC		3
			DC		11,8,2,2,GOURAUD3
			DC		3
			DC		9,10,5,2,GOURAUD3
			DC		4
			DC		11,10,9,8,2,GOURAUD3

			DC		8,12,13,14,15,16,17,18,19,2,GOURAUD5
			DC		8
			DC		27,26,25,24,23,22,21,20,2,GOURAUD5


OBJ_FACES		DC		4,0,1,9,8,2,GOURAUD6
			DC		4,9,2,3,10,2,GOURAUD6
			DC		4,11,10,4,5,2,GOURAUD6
			DC		4,7,8,11,6,2,GOURAUD6
			DC		4,0,12,13,1,2,GOURAUD6
			DC		4,2,14,15,3,2,GOURAUD6
			DC		4,5,4,16,17,2,GOURAUD6
			DC		4,7,6,18,19,2,GOURAUD6
			DC		4,13,12,20,21,2,GOURAUD6
			DC		4,14,21,22,15,2,GOURAUD6
			DC		4,22,23,17,16,2,GOURAUD6
			DC		4,20,19,18,23,2,GOURAUD6
			DC		4,8,9,10,11,2,GOURAUD6
			DC		4,21,20,23,22,2,GOURAUD6
			DC		4,1,13,14,2,2,GOURAUD6
			DC		4,3,15,16,4,2,GOURAUD6
			DC		4,6,5,17,18,2,GOURAUD6
			DC		4,0,7,19,12,2,GOURAUD6
			DC		3,1,2,9,2,GOURAUD6
			DC		3,10,3,4,2,GOURAUD6
			DC		3,21,14,13,2,GOURAUD6
			DC		3,16,15,22,2,GOURAUD6
			DC		3,0,8,7,2,GOURAUD6
			DC		3,11,5,6,2,GOURAUD6
			DC		3,19,20,12,2,GOURAUD6
			DC		3,18,17,23,2,GOURAUD6

OBJ_POINTS	DC		-20*512,-60*512,20*512
			DC		20*512,-60*512,20*512
			DC		60*512,-20*512,20*512
			DC		60*512,20*512,20*512
			DC		20*512,60*512,20*512
			DC		-20*512,60*512,20*512
			DC		-60*512,20*512,20*512
			DC		-60*512,-20*512,20*512
			DC		-20*512,-20*512,60*512
			DC		20*512,-20*512,60*512
			DC		20*512,20*512,60*512
			DC		-20*512,20*512,60*512

			DC		-20*512,-60*512,-20*512
			DC		20*512,-60*512,-20*512
			DC		60*512,-20*512,-20*512
			DC		60*512,20*512,-20*512
			DC		20*512,60*512,-20*512
			DC		-20*512,60*512,-20*512
			DC		-60*512,20*512,-20*512
			DC		-60*512,-20*512,-20*512
			DC		-20*512,-20*512,-60*512
			DC		20*512,-20*512,-60*512
			DC		20*512,20*512,-60*512
			DC		-20*512,20*512,-60*512
