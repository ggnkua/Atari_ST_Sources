; Table de Couleurs pour le Gouraud

			DC		0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
			DC		0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
GOURAUD6		DC		0,0,0,0,0,0,0,0,0,0,0,0
			DC		0*2049,1*2049,2*2049,3*2049,4*2049,5*2049
			DC		6*2049,7*2049,8*2049,9*2049,10*2049,11*2049
			DC		12*2049,13*2049,14*2049,15*2049,16*2049
			DC		17*2049,18*2049,19*2049,20*2049,21*2049,22*2049
GOURAUD1		DC		23*2049+01*65,24*2049+02*64,25*2049+03*64
			DC		26*2049+04*64,27*2049+05*64,28*2049+06*64
			DC		29*2049+07*64,30*2049+08*64,31*2049+09*64
			DC		63519+10*64,63519+11*64,63519+12*64
			DC		63519+13*64,63519+14*64,63519+15*64
			DC		63519+16*64,63519+17*64,63519+18*64
			DC		63519+19*64,63519+20*64,63519+21*64
			DC		63519+22*64,63519+23*64,63519+24*64
			DC		63519+25*64,63519+26*64,63519+27*64
			DC		63519+28*64,63519+29*64,63519+30*64
			DC		-1,-1,-1,-1,-1,-1,-1,-1

			DC		0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
			DC		0*2048,1*2048,2*2048,3*2048,4*2048,5*2048
			DC		6*2048,7*2048,8*2048,9*2048,10*2048,11*2048
GOURAUD5		DC		12*2048,13*2048,14*2048,15*2048,16*2048
			DC		17*2048,18*2048,19*2048,20*2048,21*2048,22*2048
GOURAUD2		DC		23*2048+01*65,24*2048+02*65,25*2048+03*65
			DC		26*2048+04*65,27*2048+05*65,28*2048+06*65
			DC		29*2048+07*65,30*2048+08*65,31*2048+09*65
			DC		63518+10*65,63518+11*65,63518+12*65
			DC		63518+13*65,63518+14*65,63518+15*65
			DC		63518+16*65,63518+17*65,63518+18*65
			DC		63518+19*65,63518+20*65,63518+21*65
			DC		63518+22*65,63518+23*65,63518+24*65
			DC		63518+25*65,63518+26*65,63518+27*65
			DC		63518+28*65,63518+29*65,63518+30*65
			DC		-1,-1,-1,-1,-1,-1,-1,-1

			DC		0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
			DC		0*1,1*1,2*1,3*1,4*1,5*1
			DC		6*1,7*1,8*1,9*1,10*1,11*1
			DC		12*1,13*1,14*1,15*1,16*1
GOURAUD3		DC		17*1,18*1,19*1,20*1,21*1,22*1
			DC		23*1+01*2112,24*1+02*2112,25*1+03*2112
GOURAUD8		DC		26*1+04*2112,27*1+05*2112,28*1+06*2112
			DC		29*1+07*2112,30*1+08*2112,31*1+09*2112
			DC		31+10*2112,31+11*2112,31+12*2112
			DC		31+13*2112,31+14*2112,31+15*2112
			DC		31+16*2112,31+17*2112,31+18*2112
			DC		31+19*2112,31+20*2112,31+21*2112
			DC		31+22*2112,31+23*2112,31+24*2112
			DC		31+25*2112,31+26*2112,31+27*2112
			DC		31+28*2112,31+29*2112,31+30*2112
			DC		-1,-1,-1,-1,-1,-1,-1,-1

			DC		0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
			DC		0*1+1*64,1*1+1*64,2*1+2*64,3*1+2*64,4*1+3*64,5*1+3*64
			DC		6*1+4*64,7*1+4*64,8*1+5*64,9*1+5*64,10*1+6*64,11*1+6*64
			DC		12*1+7*64,13*1+7*64,14*1+8*64,15*1+8*64,16*1+9*64
GOURAUD4		DC		17*1+9*64,18*1+10*64,19*1+10*64,20*1+11*64,21*1+11*64,22*1+12*64
			DC		23*1+12*64+01*2048,24*1+13*64+02*2048,25*1+13*64+03*2048
			DC		26*1+14*64+04*2048,27*1+14*64+05*2048,28*1+15*64+06*2048
			DC		29*1+15*64+07*2048,30*1+16*64+08*2048,31*1+16*64+09*2048
			DC		31+10*2048+17*64,31+11*2048+17*64,31+12*2048+18*64
			DC		31+13*2048+18*64,31+14*2048+19*64,31+15*2048+19*64
			DC		31+16*2048+20*64,31+17*2048+20*64,31+18*2048+21*64
			DC		31+19*2048+21*64,31+20*2048+22*64,31+21*2048+22*64
			DC		31+22*2048+23*64,31+23*2048+23*64,31+24*2048+24*64
			DC		31+25*2048+24*64,31+26*2048+25*64,31+27*2048+25*64
			DC		31+28*2048+26*64,31+29*2048+26*64,31+30*2048+27*64
			DC		63519+28*64,63519+28*64,63519+29*64,63519+29*64,63519+30*64
			DC		63519+30*64,63519+31*64,63519+31*64

			DC		0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
			DC		0*64+1*2048,1*64+1*2048,2*64+2*2048,3*64+2*2048,4*64+3*2048,5*64+3*2048
			DC		6*64+4*2048,7*64+4*2048,8*64+5*2048,9*64+5*2048,10*64+6*2048,11*64+6*2048
			DC		12*64+7*2048,13*64+7*2048,14*64+8*2048,15*64+8*2048,16*64+9*2048
			DC		17*64+9*2048,18*64+10*2048,19*64+10*2048,20*64+11*2048,21*64+11*2048,22*64+12*2048
GOURAUD10		DC		23*64+12*2048+01*1,24*64+13*2048+02*1,25*64+13*2048+03*1
			DC		26*64+14*2048+04*1,27*64+14*2048+05*1,28*64+15*2048+06*1
			DC		29*64+15*2048+07*1,30*64+16*2048+08*1,31*64+16*2048+09*1
			DC		1984+10*1+17*2048,1984+11*1+17*2048,1984+12*1+18*2048
			DC		1984+13*1+18*2048,1984+14*1+19*2048,1984+15*1+19*2048
			DC		1984+16*1+20*2048,1984+17*1+20*2048,1984+18*1+21*2048
			DC		1984+19*1+21*2048,1984+20*1+22*2048,1984+21*1+22*2048
			DC		1984+22*1+23*2048,1984+23*1+23*2048,1984+24*1+24*2048
			DC		1984+25*1+24*2048,1984+26*1+25*2048,1984+27*1+25*2048
			DC		1984+28*1+26*2048,1984+29*1+26*2048,1984+30*1+27*2048
			DC		2015+28*2048,2015+28*2048,2015+29*2048,2015+29*2048,2015+30*2048
			DC		2015+30*2048,2015+31*2048,2015+31*2048

			DC		0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
			DC		0*2048+1*64,1*2048+1*64,2*2048+2*64,3*2048+2*64,4*2048+3*64,5*2048+3*64
			DC		6*2048+4*64,7*2048+4*64,8*2048+5*64,9*2048+5*64,10*2048+6*64,11*2048+6*64
GOURAUD7		DC		12*2048+7*64,13*2048+7*64,14*2048+8*64,15*2048+8*64,16*2048+9*64
			DC		17*2048+9*64,18*2048+10*64,19*2048+10*64,20*2048+11*64,21*2048+11*64,22*2048+12*64
GOURAUD11		DC		23*2048+12*64+01*1,24*2048+13*64+02*1,25*2048+13*64+03*1
			DC		26*2048+14*64+04*1,27*2048+14*64+05*1,28*2048+15*64+06*1
			DC		29*2048+15*64+07*1,30*2048+16*64+08*1,31*2048+16*64+09*1
			DC		63488+10*1+17*64,63488+11*1+17*64,63488+12*1+18*64
			DC		63488+13*1+18*64,63488+14*1+19*64,63488+15*1+19*64
			DC		63488+16*1+20*64,63488+17*1+20*64,63488+18*1+21*64
			DC		63488+19*1+21*64,63488+20*1+22*64,63488+21*1+22*64
			DC		63488+22*1+23*64,63488+23*1+23*64,63488+24*1+24*64
			DC		63488+25*1+24*64,63488+26*1+25*64,63488+27*1+25*64
			DC		63488+28*1+26*64,63488+29*1+26*64,63488+30*1+27*64
			DC		63519+28*64,63519+28*64,63519+29*64,63519+29*64,63519+30*64
			DC		63519+30*64,63519+31*64,63519+31*64
