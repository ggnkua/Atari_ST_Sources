alien_numcoord = 12 
alien_numface  = 20 
RSIZE          = 4
alien_coords:
 dc.w 56*RSIZE,-63*RSIZE,0*RSIZE
 dc.w 56*RSIZE,63*RSIZE,0*RSIZE
 dc.w -56*RSIZE,-63*RSIZE,0*RSIZE
 dc.w -56*RSIZE,63*RSIZE,0*RSIZE
 dc.w 56*RSIZE,-63*RSIZE,-45*RSIZE
 dc.w 56*RSIZE,63*RSIZE,-45*RSIZE
 dc.w -56*RSIZE,-63*RSIZE,-45*RSIZE
 dc.w -56*RSIZE,63*RSIZE,-45*RSIZE
 dc.w 256*RSIZE,0*RSIZE,132*RSIZE
 dc.w -256*RSIZE,0*RSIZE,132*RSIZE
 dc.w 0*RSIZE,256*RSIZE,132*RSIZE
 dc.w 0*RSIZE,-256*RSIZE,132*RSIZE
alien_ecoords:
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
 dc.w 0,0,0
alien_faces:
 dc.w 8*4,0*4,4*4,0
 dc.w 1*4,8*4,5*4,0
 dc.w 2*4,9*4,6*4,0
 dc.w 9*4,3*4,7*4,0
 dc.w 0*4,11*4,4*4,0
 dc.w 11*4,2*4,6*4,0
 dc.w 3*4,10*4,7*4,0
 dc.w 10*4,1*4,5*4,0
 dc.w 1*4,0*4,8*4,0
 dc.w 5*4,8*4,4*4,0
 dc.w 3*4,9*4,2*4,0
 dc.w 9*4,7*4,6*4,0
 dc.w 0*4,2*4,11*4,0
 dc.w 6*4,4*4,11*4,0
 dc.w 2*4,0*4,1*4,0
 dc.w 6*4,5*4,4*4,0
 dc.w 1*4,3*4,2*4,0
 dc.w 7*4,5*4,6*4,0
 dc.w 1*4,10*4,3*4,0
 dc.w 10*4,5*4,7*4,0
