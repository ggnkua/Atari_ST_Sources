 dc.w 14  ; NUMCAM    
 dc.w 524  ; NUMVERTS  
 dc.w 2925  ; TNUMVERTS 
 dc.w 975  ; NUMFACES  
 dc.s 0.789582  ; camera_fov 
 dc.l camera_land  ; camera     
 dc.l coords_land  ; coords     
 dc.l faces_land   ; faces      
 dc.l tcoords_land ; tcoords    
 dc.l tex_land+20 ; palette    
 dc.l textures_land ; textures    

 textures_land: 
TH	= 20+768
 dc.l tex_land+TH+256*256*0
 dc.l tex_land+TH+256*256*1
 dc.l tex_land+TH+256*256*2
 dc.l tex_land+TH+256*256*3
 dc.l tex_land+TH+256*256*4
 dc.l tex_land+TH+256*256*5
 dc.l tex_land+TH+256*256*6
 dc.l tex_land+TH+256*256*7
 dc.l tex_land+TH+256*256*8
 dc.l tex_land+TH+256*256*9
 dc.l tex_land+TH+256*256*10
 dc.l tex_land+TH+256*256*11
 dc.l tex_land+TH+256*256*12
 dc.l tex_land+TH+256*256*13
 dc.l tex_land+TH+256*256*14
 dc.l tex_land+TH+256*256*15


	ds.b	1024
tex_land: 
;	incbin "land\snow.raw"
	incbin	"land\bfp_sno7.apx"
	ds.b	1024
	even

CAMDEBUG	=	1
	
camera_land:				;x,y,z , rx,ry,rz,rw , time
	ifne	CAMDEBUG
	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
;	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
;	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
;	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
;	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
;	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
;	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
;;	dc.s 4000,10000,-4000,1.00000,0.000000,0.0000,-1.570000,0.000000
	endc
	dc.s -1353.802979,705.130676,-829.739075,0.022500,-0.999600,0.014000,1.110300,0.000000
	dc.s 681.429382,705.130676,-1317.928955,-0.127400,-0.990600,-0.050200,0.757000,0.076900
	dc.s 2207.395020,705.130676,-2456.537842,0.009700,-0.999900,0.003500,0.691200,0.153800
	dc.s 4174.301270,705.130676,-3814.392578,0.006100,-1.000000,0.001700,0.555000,0.230800
	dc.s 5999.323242,705.130676,-4519.962402,0.805200,0.590900,-0.050700,0.212200,0.307700
	dc.s 7126.492188,705.130676,-5941.118652,-0.110900,0.975200,0.191300,2.112500,0.384600
	dc.s 6503.679688,705.130676,-4327.016602,-0.034800,0.997600,0.059300,2.082500,0.461500
	dc.s 4403.515137,555.130676,-4657.710938,-0.004200,0.999200,-0.040100,3.350900,0.538500
	dc.s 3358.017578,555.130676,-3998.507324,-0.024000,0.998300,-0.052300,3.999000,0.615400
	dc.s 2646.069580,1155.130615,-1481.079712,0.152000,0.982600,0.106900,4.844600,0.692300
	dc.s 2896.717041,1155.130615,-810.500671,-0.167900,0.985500,0.023400,4.794800,0.769200
	dc.s 3985.169434,1055.130615,-1155.067505,-0.456800,0.889200,-0.024900,4.724000,0.846200
	dc.s 4338.626465,1655.130615,-909.979614,-0.456800,0.889200,-0.024900,4.724000,0.923100
	dc.s 5394.808105,2105.130615,-474.686615,-0.456800,0.889200,-0.024900,4.724000,1.000000
coords_land:				;x,y,z
	dc.s	5545.918457,607.228149,-573.701233
	dc.s	4627.605469,447.264740,-530.281921
	dc.s	7154.472168,701.060242,-802.638184
	dc.s	4790.021973,98.268257,-960.213989
	dc.s	7551.938965,639.695312,-622.666504
	dc.s	4041.444824,57.152519,-551.080383
	dc.s	6798.056152,1101.323853,-926.954712
	dc.s	7456.331055,679.190491,-485.548981
	dc.s	6431.243652,1723.756348,-896.972351
	dc.s	8000.000000,290.000000,-645.000000
	dc.s	5739.459961,1168.801636,-834.082886
	dc.s	941.897278,141.696426,-677.515381
	dc.s	5502.013672,754.310669,-1045.692871
	dc.s	6116.796387,2125.026611,-771.193420
	dc.s	4161.912109,56.217731,-979.513916
	dc.s	5110.565430,390.546997,-771.193420
	dc.s	6000.000000,120.806053,-5454.061523
	dc.s	6000.000000,134.922348,-5534.630371
	dc.s	6000.000000,193.791901,-5697.132812
	dc.s	6000.000000,237.319962,-5889.799316
	dc.s	6000.000000,619.051086,-6267.989746
	dc.s	6000.000000,696.836548,-6483.803711
	dc.s	6000.000000,615.518616,-7029.976074
	dc.s	6000.000000,725.788025,-7088.729492
	dc.s	6000.000000,767.102478,-7137.433105
	dc.s	6000.000000,1673.907715,-7769.834961
	dc.s	2268.846436,73.542725,-2000.000000
	dc.s	2078.263184,72.626595,-2000.000000
	dc.s	1359.263062,61.925323,-2000.000000
	dc.s	1472.636353,91.719513,-2000.000000
	dc.s	142.674255,137.618835,-2000.000000
	dc.s	547.594604,82.923645,-2000.000000
	dc.s	1315.267456,70.434311,-2000.000000
	dc.s	5083.778809,194.487610,-2000.000000
	dc.s	5522.882324,683.672302,-2000.000000
	dc.s	0.000000,124.000000,-2000.000000
	dc.s	3104.509277,34.068909,-2000.000000
	dc.s	5736.091797,1219.588623,-2000.000000
	dc.s	6372.943848,1744.866699,-2000.000000
	dc.s	6751.486328,1346.207886,-2000.000000
	dc.s	7129.517090,859.070984,-2000.000000
	dc.s	7440.760254,397.776611,-2000.000000
	dc.s	4792.782227,95.294930,-2000.000000
	dc.s	3527.177246,36.338043,-2000.000000
	dc.s	3775.827148,42.017021,-2000.000000
	dc.s	4432.651855,66.265549,-2000.000000
	dc.s	4574.740234,29.703056,-2000.000000
	dc.s	1863.679321,117.847504,-2000.000000
	dc.s	2000.000000,89.119576,-2000.000000
	dc.s	6000.000000,1753.281982,-2000.000000
	dc.s	4867.571777,135.236069,-4000.000000
	dc.s	5001.250977,100.652451,-4000.000000
	dc.s	0.000000,122.000000,-4000.000000
	dc.s	4681.899902,100.809090,-4000.000000
	dc.s	1880.542603,56.144596,-4000.000000
	dc.s	2892.585205,52.940022,-4000.000000
	dc.s	3536.592285,53.900723,-4000.000000
	dc.s	7394.003418,175.302002,-4000.000000
	dc.s	7555.987305,186.920303,-4000.000000
	dc.s	7051.148926,132.683823,-4000.000000
	dc.s	2588.883789,40.744099,-4000.000000
	dc.s	6626.734375,52.097256,-4000.000000
	dc.s	6943.532715,134.852112,-4000.000000
	dc.s	7653.367676,204.945862,-4000.000000
	dc.s	7857.053711,160.671875,-4000.000000
	dc.s	3648.770020,59.763874,-4000.000000
	dc.s	4505.170898,117.007576,-4000.000000
	dc.s	4199.727539,146.553696,-4000.000000
	dc.s	4099.300781,173.422150,-4000.000000
	dc.s	7859.641602,164.056442,-4000.000000
	dc.s	7891.615723,172.456085,-4000.000000
	dc.s	8000.000000,182.000000,-4000.000000
	dc.s	2402.777344,30.523211,-4000.000000
	dc.s	4000.000000,153.052963,-4000.000000
	dc.s	3759.472168,103.714539,-4000.000000
	dc.s	5989.980469,26.423141,-4000.000000
	dc.s	6294.031250,52.385517,-4000.000000
	dc.s	6000.000000,27.278681,-4000.000000
	dc.s	576.866699,52.707462,-6000.000000
	dc.s	839.214172,71.100822,-6000.000000
	dc.s	477.135101,95.607948,-6000.000000
	dc.s	1632.230347,42.909630,-6000.000000
	dc.s	1089.760864,68.589043,-6000.000000
	dc.s	5165.512207,1470.872559,-6000.000000
	dc.s	5077.121094,1606.184448,-6000.000000
	dc.s	0.000000,73.000000,-6000.000000
	dc.s	150.954163,76.345116,-6000.000000
	dc.s	5249.324219,1277.375000,-6000.000000
	dc.s	5506.869141,731.134155,-6000.000000
	dc.s	4369.717773,1866.690796,-6000.000000
	dc.s	4841.939941,1638.423584,-6000.000000
	dc.s	4758.717773,1789.442627,-6000.000000
	dc.s	5672.129395,572.023010,-6000.000000
	dc.s	4913.920410,1691.526489,-6000.000000
	dc.s	3772.423340,1538.613770,-6000.000000
	dc.s	6235.323242,272.731140,-6000.000000
	dc.s	2505.629883,72.754440,-6000.000000
	dc.s	8000.000000,113.000000,-6000.000000
	dc.s	2233.206055,46.638321,-6000.000000
	dc.s	2000.000000,45.191418,-6000.000000
	dc.s	4000.000000,1826.883179,-6000.000000
	dc.s	6000.000000,336.650848,-6000.000000
	dc.s	6135.907227,324.341125,-6000.000000
	dc.s	2000.000000,79.875938,-2304.535645
	dc.s	2000.000000,40.928368,-3555.591553
	dc.s	892.348938,101.617210,-4000.000000
	dc.s	466.606049,162.426010,-4000.000000
	dc.s	1380.086182,48.518936,-4000.000000
	dc.s	2000.000000,55.580055,-4000.000000
	dc.s	2000.000000,49.961426,-6229.941895
	dc.s	2752.116943,345.282867,-6000.000000
	dc.s	3255.226807,824.224121,-6000.000000
	dc.s	4000.000000,849.352173,-6842.091797
	dc.s	3546.774902,1006.895752,-6000.000000
	dc.s	4000.000000,429.200592,-7419.041016
	dc.s	6000.000000,442.589691,-6117.531738
	dc.s	6000.000000,611.230042,-6675.412109
	dc.s	5614.000000,1787.000000,-8000.000000
	dc.s	6000.000000,1930.000000,-8000.000000
	dc.s	6000.000000,1795.022339,-7833.483887
	dc.s	5884.539062,384.802673,-6000.000000
	dc.s	6679.519043,289.507416,-6000.000000
	dc.s	7222.472656,182.585403,-6000.000000
	dc.s	4086.905029,1921.969238,-6000.000000
	dc.s	5809.729492,31.750902,-4000.000000
	dc.s	7909.348633,128.373383,-6000.000000
	dc.s	7663.621094,199.895172,-2000.000000
	dc.s	6858.433105,1259.155273,-2000.000000
	dc.s	6088.624512,1946.576416,-2000.000000
	dc.s	5659.928223,1024.656860,-2000.000000
	dc.s	5016.856934,99.914940,-2000.000000
	dc.s	4218.603027,83.252495,-2000.000000
	dc.s	4000.000000,62.324032,-2000.000000
	dc.s	2571.891113,119.164459,-2000.000000
	dc.s	2000.000000,43.783894,-1091.174072
	dc.s	8000.000000,121.000000,-2000.000000
	dc.s	4000.000000,1363.243530,-5494.384277
	dc.s	4000.000000,1716.970947,-5747.390137
	dc.s	4000.000000,1867.458862,-5963.158203
	dc.s	4000.000000,1766.648438,-6054.691895
	dc.s	4000.000000,1626.389282,-6204.083008
	dc.s	4000.000000,1449.805664,-6334.195801
	dc.s	4000.000000,1318.111206,-6452.033691
	dc.s	4000.000000,598.704834,-7088.572754
	dc.s	4000.000000,575.215332,-7130.228516
	dc.s	4000.000000,255.716614,-7689.698242
	dc.s	4000.000000,254.384933,-7837.889648
	dc.s	4000.000000,205.321716,-7901.740723
	dc.s	4000.000000,167.000000,-8000.000000
	dc.s	6000.000000,1962.000000,0.000000
	dc.s	6000.000000,2009.564819,-249.813934
	dc.s	6000.000000,1946.336182,-328.610657
	dc.s	6000.000000,1914.044312,-420.468475
	dc.s	6000.000000,2012.927856,-678.588074
	dc.s	6000.000000,2037.178833,-928.204041
	dc.s	6000.000000,2070.751709,-954.693237
	dc.s	6000.000000,2075.749268,-966.683105
	dc.s	6000.000000,2115.108887,-1013.239014
	dc.s	6000.000000,2014.967773,-1166.481812
	dc.s	6000.000000,1992.832153,-1384.401245
	dc.s	6000.000000,2024.908691,-1556.572266
	dc.s	6000.000000,1969.332642,-1800.833252
	dc.s	6000.000000,1898.276123,-1926.365356
	dc.s	6000.000000,1702.148560,-2025.967896
	dc.s	6000.000000,1582.949097,-2202.127930
	dc.s	6000.000000,1294.525513,-2463.593018
	dc.s	6000.000000,1131.587891,-2693.482666
	dc.s	6000.000000,885.179382,-2800.026855
	dc.s	6000.000000,691.825684,-2929.016846
	dc.s	6000.000000,457.702057,-3015.527344
	dc.s	6000.000000,319.628296,-3159.838623
	dc.s	6000.000000,345.690918,-3083.691406
	dc.s	6000.000000,236.408707,-3448.417480
	dc.s	6000.000000,26.865158,-3994.288818
	dc.s	6000.000000,61.505413,-4472.708008
	dc.s	6000.000000,64.979576,-4657.958008
	dc.s	6000.000000,67.976578,-4797.720703
	dc.s	6000.000000,106.435493,-5200.900391
	dc.s	7395.619629,609.018982,-7463.822754
	dc.s	4544.560547,484.235168,-7343.140625
	dc.s	5027.384766,839.764282,-7537.242676
	dc.s	6179.686035,1312.663574,-7500.364258
	dc.s	747.173767,37.695648,-7406.793945
	dc.s	3669.770508,156.306198,-7610.402832
	dc.s	4230.113281,304.620178,-7563.253906
	dc.s	5330.678223,913.664673,-7563.253906
	dc.s	5550.791504,770.987915,-7500.364258
	dc.s	276.053772,49.367939,-7545.159668
	dc.s	4518.424805,323.316010,-7775.733398
	dc.s	6305.464844,1439.625854,-7814.811523
	dc.s	1290.616211,72.881836,-7434.776855
	dc.s	6060.869141,1796.256104,-7806.349121
	dc.s	6473.000000,1855.000000,-8000.000000
	dc.s	7573.653809,308.227997,-7664.867188
	dc.s	1166.831909,29.116201,-7814.134277
	dc.s	2909.434570,41.100624,-7846.256348
	dc.s	6725.429199,1051.768188,-7697.585449
	dc.s	4292.740723,343.841614,-7759.992188
	dc.s	8000.000000,235.000000,-8000.000000
	dc.s	4262.000000,242.000000,-8000.000000
	dc.s	6996.000000,1221.000000,-8000.000000
	dc.s	2685.000000,67.000000,-8000.000000
	dc.s	7660.000000,421.000000,-8000.000000
	dc.s	3374.000000,63.000000,-8000.000000
	dc.s	6368.000000,1833.000000,-8000.000000
	dc.s	726.000000,92.000000,-8000.000000
	dc.s	1829.000000,45.000000,-8000.000000
	dc.s	3790.000000,106.000000,-8000.000000
	dc.s	4482.000000,387.000000,-8000.000000
	dc.s	4639.000000,547.000000,-8000.000000
	dc.s	4828.000000,999.000000,-8000.000000
	dc.s	5111.000000,1429.000000,-8000.000000
	dc.s	5394.000000,1748.000000,-8000.000000
	dc.s	6180.000000,1983.000000,-8000.000000
	dc.s	1448.106812,53.084381,-4774.838379
	dc.s	5330.678223,25.343716,-4796.118164
	dc.s	4269.158203,761.700378,-4815.904785
	dc.s	4796.736328,202.588226,-4796.328613
	dc.s	5835.339844,66.612640,-4737.429199
	dc.s	4041.444824,880.507263,-4953.341797
	dc.s	6618.837402,73.102623,-5024.312012
	dc.s	2734.001465,24.302683,-4933.074219
	dc.s	2286.659424,26.665691,-5426.694336
	dc.s	5355.268066,139.121719,-5066.661621
	dc.s	3321.075439,237.049545,-5039.299316
	dc.s	3474.829346,544.821838,-5228.140625
	dc.s	4594.631836,526.627502,-5026.011230
	dc.s	5015.496094,207.676514,-5106.794434
	dc.s	6109.220215,132.850266,-5508.323730
	dc.s	1680.492676,9.219558,-4982.918457
	dc.s	5802.349121,138.672089,-5582.236328
	dc.s	959.861755,55.774956,-5173.454590
	dc.s	3098.103027,300.733032,-5173.454590
	dc.s	2752.210938,106.110504,-5582.236328
	dc.s	3318.216064,693.561462,-5362.123047
	dc.s	4956.673340,747.172607,-5467.093262
	dc.s	646.584106,28.034945,-5628.700195
	dc.s	3023.485596,142.957611,-5320.871094
	dc.s	5616.197754,78.482437,-5263.383789
	dc.s	1174.539062,63.844364,-5613.553711
	dc.s	7293.349121,55.037331,-5160.259766
	dc.s	7814.811523,196.583557,-5519.346680
	dc.s	3828.649414,1748.516479,-5874.080078
	dc.s	4203.000977,1679.598633,-5597.298828
	dc.s	8000.000000,122.000000,-5069.000000
	dc.s	4984.786621,870.779419,-5613.681152
	dc.s	5583.610840,101.466660,-5442.919922
	dc.s	446.334656,115.094116,-5564.455566
	dc.s	6931.008789,104.034210,-5798.889160
	dc.s	6609.751953,95.299286,-5493.980957
	dc.s	3130.000000,61.000000,0.000000
	dc.s	1181.801025,34.955204,-467.466614
	dc.s	3635.000000,60.000000,0.000000
	dc.s	7311.695801,947.193359,-299.522583
	dc.s	8000.000000,313.000000,-251.000000
	dc.s	4922.980957,423.449066,-402.913208
	dc.s	6620.000000,1785.000000,0.000000
	dc.s	4283.000000,229.000000,0.000000
	dc.s	5775.000000,1940.000000,0.000000
	dc.s	6088.611328,2036.775879,-340.952393
	dc.s	6651.356934,1589.723022,-268.077850
	dc.s	676.859253,184.849625,-299.522583
	dc.s	4859.000000,1024.000000,0.000000
	dc.s	5357.000000,1754.000000,0.000000
	dc.s	5519.000000,1815.000000,0.000000
	dc.s	7154.000000,1090.000000,0.000000
	dc.s	0.000000,191.000000,0.000000
	dc.s	4667.000000,653.000000,0.000000
	dc.s	7437.475098,424.873993,-1903.203491
	dc.s	7814.811523,320.519867,-1808.869385
	dc.s	8000.000000,213.000000,-1840.000000
	dc.s	5865.238770,1795.196655,-1840.314087
	dc.s	3797.982910,36.651623,-1779.791626
	dc.s	5582.236328,733.074524,-2060.427246
	dc.s	4167.223633,84.591866,-2217.650879
	dc.s	6368.354492,1640.720093,-2154.761230
	dc.s	5012.059570,100.677925,-2050.270996
	dc.s	7442.705078,381.735199,-2057.302734
	dc.s	4764.673340,109.796013,-2091.871826
	dc.s	5046.142578,608.661438,-2496.161377
	dc.s	5570.704590,482.458405,-2204.495605
	dc.s	6808.580566,1275.333862,-2217.650879
	dc.s	8000.000000,66.000000,-2281.000000
	dc.s	5229.507812,548.641907,-2533.579590
	dc.s	0.000000,107.000000,-3482.000000
	dc.s	272.296021,50.377270,-2393.942383
	dc.s	2899.848633,35.611622,-2510.118652
	dc.s	5301.964844,712.992737,-2290.293213
	dc.s	5896.683594,1159.040894,-2437.763916
	dc.s	6840.025391,926.072815,-2563.542725
	dc.s	5550.791504,305.049622,-2563.542725
	dc.s	3743.132812,49.934479,-2324.950684
	dc.s	4535.267090,45.878819,-2514.465332
	dc.s	6148.241211,1488.922607,-2500.653320
	dc.s	6368.354492,1139.154663,-2594.987305
	dc.s	7140.127441,1000.763184,-2506.291504
	dc.s	7652.879883,409.573547,-2499.342041
	dc.s	4198.668457,25.960686,-2437.763916
	dc.s	6593.929199,787.628845,-2669.866211
	dc.s	1361.991089,46.952766,-2241.751953
	dc.s	7248.806641,791.340820,-2846.545166
	dc.s	4697.020020,252.953079,-2683.889160
	dc.s	2000.000000,41.000000,0.000000
	dc.s	2000.000000,41.000000,0.000000
	dc.s	2000.000000,47.540287,-3048.351807
	dc.s	2000.000000,18.643368,-4548.118164
	dc.s	2000.000000,24.030386,-4836.455566
	dc.s	2000.000000,18.415323,-5216.830566
	dc.s	2000.000000,36.248840,-5474.858887
	dc.s	2000.000000,59.946552,-5760.159668
	dc.s	2000.000000,81.256447,-6555.013184
	dc.s	2000.000000,35.748997,-7029.670898
	dc.s	2000.000000,94.846909,-6788.412598
	dc.s	2000.000000,73.532143,-7250.614258
	dc.s	2000.000000,51.343391,-7427.109863
	dc.s	2000.000000,50.165985,-7841.755859
	dc.s	2000.000000,50.000000,-8000.000000
	dc.s	4000.000000,155.000000,0.000000
	dc.s	4000.000000,144.673874,-330.510956
	dc.s	4000.000000,63.056763,-548.287964
	dc.s	4000.000000,71.721748,-772.730774
	dc.s	4000.000000,52.906910,-1031.949829
	dc.s	4000.000000,47.512768,-1335.557495
	dc.s	4000.000000,49.622387,-1558.261841
	dc.s	4000.000000,70.926079,-2259.960449
	dc.s	4000.000000,67.754570,-2492.636230
	dc.s	4000.000000,31.282635,-2653.061523
	dc.s	4000.000000,71.679108,-2923.780273
	dc.s	4000.000000,62.710258,-3124.050537
	dc.s	4000.000000,93.049721,-3576.627197
	dc.s	4000.000000,107.502007,-3795.023193
	dc.s	4000.000000,98.504730,-3870.058105
	dc.s	4000.000000,257.973694,-4249.936523
	dc.s	4000.000000,271.911621,-4309.216309
	dc.s	4000.000000,517.597839,-4637.455078
	dc.s	4000.000000,518.888123,-4640.420410
	dc.s	4000.000000,843.487366,-4958.287109
	dc.s	4000.000000,855.953735,-4973.441895
	dc.s	4859.007324,1048.767334,-6588.467285
	dc.s	5431.109375,1101.632935,-6532.870605
	dc.s	6934.359375,364.183594,-6619.912109
	dc.s	5299.233887,678.887207,-6682.801758
	dc.s	5550.791504,868.547913,-6808.580566
	dc.s	7739.018066,255.075348,-6840.433105
	dc.s	1278.292725,38.234039,-6857.526367
	dc.s	952.603943,76.265129,-6625.205078
	dc.s	3383.660156,295.620026,-6925.014648
	dc.s	4530.922363,1508.069580,-6547.187500
	dc.s	4708.684082,517.787170,-7087.961914
	dc.s	7563.253906,279.404938,-7123.027832
	dc.s	2322.433838,18.871132,-6845.539551
	dc.s	5110.565430,513.759521,-6808.580566
	dc.s	6242.575195,665.657227,-6934.359375
	dc.s	6665.629883,671.392029,-7028.011230
	dc.s	0.000000,194.000000,-8000.000000
	dc.s	3559.077637,263.564453,-7181.386719
	dc.s	5297.088867,331.777344,-7018.051270
	dc.s	6494.133301,924.098633,-7343.140625
	dc.s	7123.027832,574.742981,-7028.693359
	dc.s	802.638184,111.208694,-7123.027832
	dc.s	4109.219727,652.413574,-7117.556152
	dc.s	1103.589478,50.283463,-7247.804688
	dc.s	5538.314453,445.447784,-7063.303223
	dc.s	5079.120605,540.634216,-7280.251465
	dc.s	5554.496582,523.436096,-7205.581543
	dc.s	0.000000,82.000000,-6958.000000
	dc.s	2861.324707,74.321739,-7027.006348
	dc.s	6089.259277,766.330444,-7065.317383
	dc.s	7091.871094,781.086670,-7189.912109
	dc.s	7060.138184,1053.162598,-7563.253906
	dc.s	8000.000000,118.000000,-7113.000000
	dc.s	4817.678711,734.443542,-7371.332031
	dc.s	3347.542969,204.931366,-7336.726562
	dc.s	8000.000000,191.000000,-7271.000000
	dc.s	2518.588867,57.497787,-5852.263672
	dc.s	3066.658203,543.464172,-5770.904297
	dc.s	5299.233887,1042.863037,-5802.349121
	dc.s	3412.550293,940.049255,-5676.570312
	dc.s	4576.004883,1695.344116,-5613.681152
	dc.s	4545.733887,1804.163818,-5850.886230
	dc.s	0.000000,59.000000,-6198.000000
	dc.s	5550.791504,462.091980,-5802.349121
	dc.s	4813.894531,1152.373413,-5784.636719
	dc.s	5047.675781,1499.009155,-5865.238770
	dc.s	7737.999023,130.824402,-6161.313965
	dc.s	5880.697266,260.359283,-5903.371582
	dc.s	6303.227051,178.761841,-5855.303223
	dc.s	4850.288574,1783.113281,-6064.110352
	dc.s	4274.733887,1900.432495,-6080.466797
	dc.s	5487.901855,847.314575,-6085.351562
	dc.s	5286.856934,1545.704712,-6311.870117
	dc.s	5629.373047,1151.679443,-6530.127441
	dc.s	3664.108154,1134.252197,-6242.575195
	dc.s	6132.035156,415.667419,-6220.097656
	dc.s	6687.549805,229.138153,-6395.100098
	dc.s	6464.772949,356.727173,-6652.419922
	dc.s	7664.694336,169.887787,-6356.053223
	dc.s	7094.022461,367.728943,-6378.281250
	dc.s	2474.388184,109.535667,-6356.167480
	dc.s	5896.683594,778.197144,-6305.464844
	dc.s	4589.794434,1683.576904,-6383.406250
	dc.s	504.420197,78.345795,-6385.834473
	dc.s	2791.541260,215.545502,-6475.581055
	dc.s	3318.216064,325.370636,-6714.246094
	dc.s	3906.875732,1297.060425,-6420.200195
	dc.s	4301.667969,1386.303589,-6555.155762
	dc.s	5098.699219,1684.723511,-6098.754395
	dc.s	5047.675781,708.264893,-6588.467285
	dc.s	3191.839355,641.837769,-6304.984863
	dc.s	8000.000000,112.000000,-5861.000000
	dc.s	5079.120605,879.180176,-2689.321533
	dc.s	4261.557617,211.425125,-2720.766357
	dc.s	613.969849,76.713539,-2689.321533
	dc.s	8000.000000,115.000000,-2577.000000
	dc.s	5856.823242,786.460999,-2879.724365
	dc.s	7026.290527,901.581848,-2969.557129
	dc.s	7640.644531,196.585709,-2977.460449
	dc.s	4104.333984,83.615356,-2909.434570
	dc.s	5085.123047,1024.479858,-3035.885254
	dc.s	8000.000000,127.000000,-2941.000000
	dc.s	5550.791504,494.099060,-2940.879395
	dc.s	6745.690918,598.693054,-3066.658203
	dc.s	4450.917480,312.618774,-3052.847412
	dc.s	6053.907227,333.921631,-3066.658203
	dc.s	7563.253906,335.796753,-3318.216064
	dc.s	2245.583740,45.209896,-2984.765869
	dc.s	3713.890381,38.946964,-2963.119629
	dc.s	4350.653320,91.834335,-3321.285889
	dc.s	5425.012695,619.024109,-3066.658203
	dc.s	6399.798828,427.571381,-3066.658203
	dc.s	581.913208,32.611893,-3284.299805
	dc.s	4834.879883,656.047058,-3316.195068
	dc.s	5696.461914,411.960907,-3179.600342
	dc.s	1447.855225,52.779690,-3191.311523
	dc.s	6571.453613,92.072464,-3589.278564
	dc.s	6871.469727,425.764832,-3255.326660
	dc.s	8000.000000,78.000000,-3287.000000
	dc.s	4581.256836,233.422928,-3365.406006
	dc.s	7349.535645,659.036865,-3290.359619
	dc.s	851.155029,84.642647,-3736.367432
	dc.s	3104.707764,114.764778,-3077.482666
	dc.s	3333.437988,56.427784,-3498.637939
	dc.s	5876.806641,286.963959,-3372.782471
	dc.s	4481.670898,39.761318,-3695.552734
	dc.s	5330.678223,240.783264,-3443.994873
	dc.s	7311.695801,370.150024,-3506.884521
	dc.s	8000.000000,177.000000,-3507.000000
	dc.s	5002.646484,293.973633,-3568.592285
	dc.s	6970.423828,301.519196,-3531.110596
	dc.s	7606.808105,367.867493,-3546.724854
	dc.s	0.000000,136.000000,-4513.000000
	dc.s	2695.537842,39.158127,-3601.597900
	dc.s	5666.630859,79.426254,-3663.859863
	dc.s	4128.493652,117.347618,-3852.157471
	dc.s	3677.639404,51.232307,-3914.966309
	dc.s	7657.593750,237.139236,-3890.245850
	dc.s	4513.115723,95.648315,-3915.665771
	dc.s	6999.589355,164.347626,-3896.110107
	dc.s	6461.052734,47.205044,-3731.482666
	dc.s	1180.098145,26.608498,-4447.421875
	dc.s	4842.454102,105.718216,-4080.221924
	dc.s	1886.053833,63.843269,-4234.302734
	dc.s	4041.444824,284.553741,-4293.002441
	dc.s	6795.739746,57.087616,-4273.904297
	dc.s	7641.025879,110.929108,-4320.523438
	dc.s	496.881042,36.930817,-4705.302734
	dc.s	4455.215820,251.304657,-4530.254395
	dc.s	7227.334473,24.484186,-4355.006348
	dc.s	5047.675781,100.570381,-4355.892090
	dc.s	5393.567871,84.133362,-4326.447266
	dc.s	7480.379395,84.045860,-4572.791992
	dc.s	3040.506836,63.285973,-4299.077148
	dc.s	4733.228516,270.361267,-4670.339355
	dc.s	3473.915771,111.437386,-4515.027344
	dc.s	4003.614990,520.388794,-4638.296387
	dc.s	0.000000,109.000000,-5519.000000
	dc.s	8000.000000,195.000000,-3782.000000
	dc.s	2416.012695,43.314739,-4645.753906
	dc.s	7458.492676,500.627777,-988.327637
	dc.s	8000.000000,242.000000,-1059.000000
	dc.s	6441.175293,1814.626343,-1190.794067
	dc.s	0.000000,222.000000,-1617.000000
	dc.s	1148.953491,154.017548,-1139.477051
	dc.s	6588.467285,1804.507324,-1462.977417
	dc.s	7068.471680,594.028748,-1220.425293
	dc.s	4435.656738,77.594276,-1080.525391
	dc.s	6085.351562,2106.958008,-1368.643188
	dc.s	2689.321533,48.412266,-1274.308960
	dc.s	6385.276367,2024.715088,-1584.146973
	dc.s	1625.322388,153.495834,-1666.391968
	dc.s	5690.806641,1579.401733,-1441.486328
	dc.s	7594.698730,465.863495,-1462.977417
	dc.s	7343.140625,481.089630,-1588.756226
	dc.s	5068.248047,91.741974,-1461.504639
	dc.s	7146.531738,584.616333,-1497.197144
	dc.s	8000.000000,246.000000,-1526.000000
	dc.s	1349.882324,113.410805,-1168.697998
	dc.s	5941.414062,1968.589355,-1685.568237
	dc.s	0.000000,71.000000,-2208.000000
	dc.s	3319.108398,32.451279,-1465.109985
	dc.s	7721.789062,303.994232,-1609.437378
	dc.s	5343.834961,534.645569,-1817.715210
	dc.s	4913.393555,33.073071,-1605.792480
	dc.s	7060.138184,870.359131,-1903.203491
	dc.s	2673.775146,81.194115,-913.103149
	dc.s	6048.694336,2199.476562,-945.795044
	dc.s	2940.444336,123.224007,-1171.465210
	dc.s	3814.472412,89.487076,-535.787598
	dc.s	3737.118652,47.531441,-1117.085205
	dc.s	5332.041016,378.535675,-1253.212769
	dc.s	6129.269531,2197.072021,-1051.506104
	dc.s	5047.675781,189.571701,-959.861755
	dc.s	5959.572754,1858.050415,-456.746185
	dc.s	6965.804199,1134.355225,-425.301453
	dc.s	5273.724609,465.215027,-541.496948
	dc.s	0.000000,251.000000,-723.000000
	dc.s	6427.386719,1659.941895,-448.521545
	dc.s	2001.000000,41.000000,0.000000
	dc.s	7846.000000,362.000000,0.000000
	dc.s	803.000000,47.000000,0.000000
	dc.s	6232.000000,1984.000000,0.000000
	dc.s	4481.670898,366.344543,-79.409508
	dc.s	5047.675781,1372.135742,-47.964783
	dc.s	5445.241699,1380.130981,-251.344147
faces_land:				;f1,f2,f3 , tf1,tf2,tf3 , texnum , flag
	dc.w 267,522,262,  0,1,2,  0,0
	dc.w 262,522,263,  3,4,5,  0,0
	dc.w 522,523,263,  6,7,8,  0,0
	dc.w 523,264,263,  9,10,11,  0,0
	dc.w 523,258,264,  12,13,14,  0,0
	dc.w 518,265,253,  15,16,17,  0,0
	dc.w 254,518,253,  18,19,20,  0,0
	dc.w 517,134,250,  21,22,23,  0,0
	dc.w 257,521,267,  24,25,26,  0,0
	dc.w 519,266,261,  27,28,29,  0,0
	dc.w 255,522,267,  30,31,32,  0,0
	dc.w 265,256,260,  33,34,35,  0,0
	dc.w 521,255,267,  36,37,38,  0,0
	dc.w 254,253,7,  39,40,41,  0,0
	dc.w 521,1,255,  42,43,44,  0,0
	dc.w 260,256,520,  45,46,47,  0,0
	dc.w 265,260,513,  48,49,50,  0,0
	dc.w 251,519,11,  51,52,53,  0,0
	dc.w 255,523,522,  54,55,56,  0,0
	dc.w 519,261,11,  57,58,59,  0,0
	dc.w 252,250,506,  60,61,62,  0,0
	dc.w 0,512,523,  63,64,65,  0,0
	dc.w 260,520,259,  66,67,68,  0,0
	dc.w 5,1,257,  69,70,71,  0,0
	dc.w 257,1,521,  72,73,74,  0,0
	dc.w 253,265,513,  75,76,77,  0,0
	dc.w 14,1,5,  78,79,80,  0,0
	dc.w 514,0,523,  81,82,83,  0,0
	dc.w 513,260,516,  84,85,86,  0,0
	dc.w 134,504,250,  87,88,89,  0,0
	dc.w 260,259,516,  90,91,92,  0,0
	dc.w 11,261,266,  93,94,95,  0,0
	dc.w 252,506,507,  96,97,98,  0,0
	dc.w 255,514,523,  99,100,101,  0,0
	dc.w 516,259,13,  102,103,104,  0,0
	dc.w 250,504,506,  105,106,107,  0,0
	dc.w 254,7,4,  108,109,110,  0,0
	dc.w 11,266,515,  111,112,113,  0,0
	dc.w 3,514,255,  114,115,116,  0,0
	dc.w 3,255,1,  117,118,119,  0,0
	dc.w 3,15,514,  120,121,122,  0,0
	dc.w 259,505,13,  123,124,125,  0,0
	dc.w 6,513,516,  126,127,128,  0,0
	dc.w 9,254,4,  129,130,131,  0,0
	dc.w 6,516,13,  132,133,134,  0,0
	dc.w 2,513,6,  135,136,137,  0,0
	dc.w 2,253,513,  138,139,140,  0,0
	dc.w 7,253,2,  141,142,143,  0,0
	dc.w 0,10,512,  144,145,146,  0,0
	dc.w 6,13,8,  147,148,149,  0,0
	dc.w 478,4,7,  150,151,152,  0,0
	dc.w 251,11,482,  153,154,155,  0,0
	dc.w 14,485,1,  156,157,158,  0,0
	dc.w 478,7,2,  159,160,161,  0,0
	dc.w 251,482,496,  162,163,164,  0,0
	dc.w 3,511,15,  165,166,167,  0,0
	dc.w 479,9,4,  168,169,170,  0,0
	dc.w 485,3,1,  171,172,173,  0,0
	dc.w 15,12,514,  174,175,176,  0,0
	dc.w 514,12,0,  177,178,179,  0,0
	dc.w 8,13,510,  180,181,182,  0,0
	dc.w 479,4,478,  183,184,185,  0,0
	dc.w 0,12,10,  186,187,188,  0,0
	dc.w 509,12,15,  189,190,191,  0,0
	dc.w 13,505,510,  192,193,194,  0,0
	dc.w 484,2,6,  195,196,197,  0,0
	dc.w 478,2,484,  198,199,200,  0,0
	dc.w 8,510,480,  201,202,203,  0,0
	dc.w 11,515,481,  204,205,206,  0,0
	dc.w 487,506,504,  207,208,209,  0,0
	dc.w 6,8,480,  210,211,212,  0,0
	dc.w 479,478,491,  213,214,215,  0,0
	dc.w 511,509,15,  216,217,218,  0,0
	dc.w 134,487,504,  219,220,221,  0,0
	dc.w 493,509,511,  222,223,224,  0,0
	dc.w 479,491,495,  225,226,227,  0,0
	dc.w 499,507,506,  228,229,230,  0,0
	dc.w 11,481,482,  231,232,233,  0,0
	dc.w 499,508,507,  234,235,236,  0,0
	dc.w 484,6,480,  237,238,239,  0,0
	dc.w 493,511,3,  240,241,242,  0,0
	dc.w 484,480,483,  243,244,245,  0,0
	dc.w 478,484,494,  246,247,248,  0,0
	dc.w 480,510,486,  249,250,251,  0,0
	dc.w 480,486,488,  252,253,254,  0,0
	dc.w 502,493,3,  255,256,257,  0,0
	dc.w 483,480,488,  258,259,260,  0,0
	dc.w 487,133,506,  261,262,263,  0,0
	dc.w 493,490,509,  264,265,266,  0,0
	dc.w 494,484,483,  267,268,269,  0,0
	dc.w 502,3,485,  270,271,272,  0,0
	dc.w 128,488,486,  273,274,275,  0,0
	dc.w 499,506,133,  276,277,278,  0,0
	dc.w 502,485,131,  279,280,281,  0,0
	dc.w 495,491,500,  282,283,284,  0,0
	dc.w 492,478,494,  285,286,287,  0,0
	dc.w 493,501,490,  288,289,290,  0,0
	dc.w 501,497,490,  291,292,293,  0,0
	dc.w 491,478,492,  294,295,296,  0,0
	dc.w 494,483,488,  297,298,299,  0,0
	dc.w 499,272,508,  300,301,302,  0,0
	dc.w 494,488,127,  303,304,305,  0,0
	dc.w 492,494,503,  306,307,308,  0,0
	dc.w 500,491,492,  309,310,311,  0,0
	dc.w 494,127,503,  312,313,314,  0,0
	dc.w 495,500,269,  315,316,317,  0,0
	dc.w 270,495,269,  318,319,320,  0,0
	dc.w 500,492,268,  321,322,323,  0,0
	dc.w 268,492,503,  324,325,326,  0,0
	dc.w 126,500,268,  327,328,329,  0,0
	dc.w 268,503,127,  330,331,332,  0,0
	dc.w 126,269,500,  333,334,335,  0,0
	dc.w 135,270,269,  336,337,338,  0,0
	dc.w 135,269,126,  339,340,341,  0,0
	dc.w 276,287,273,  342,343,344,  0,0
	dc.w 280,273,287,  345,346,347,  0,0
	dc.w 276,278,279,  348,349,350,  0,0
	dc.w 276,283,287,  351,352,353,  0,0
	dc.w 297,292,278,  354,355,356,  0,0
	dc.w 292,279,278,  357,358,359,  0,0
	dc.w 276,279,283,  360,361,362,  0,0
	dc.w 298,281,294,  363,364,365,  0,0
	dc.w 289,295,281,  366,367,368,  0,0
	dc.w 299,285,412,  369,370,371,  0,0
	dc.w 277,295,296,  372,373,374,  0,0
	dc.w 292,301,279,  375,376,377,  0,0
	dc.w 290,280,287,  378,379,380,  0,0
	dc.w 285,498,284,  381,382,383,  0,0
	dc.w 286,103,425,  384,385,386,  0,0
	dc.w 298,289,281,  387,388,389,  0,0
	dc.w 282,296,413,  390,391,392,  0,0
	dc.w 290,287,283,  393,394,395,  0,0
	dc.w 290,288,280,  396,397,398,  0,0
	dc.w 290,414,288,  399,400,401,  0,0
	dc.w 286,440,291,  402,403,404,  0,0
	dc.w 283,279,410,  405,406,407,  0,0
	dc.w 297,411,292,  408,409,410,  0,0
	dc.w 301,410,279,  411,412,413,  0,0
	dc.w 421,289,298,  414,415,416,  0,0
	dc.w 430,299,412,  417,418,419,  0,0
	dc.w 426,291,440,  420,421,422,  0,0
	dc.w 297,417,411,  423,424,425,  0,0
	dc.w 415,295,289,  426,427,428,  0,0
	dc.w 296,295,300,  429,430,431,  0,0
	dc.w 286,425,440,  432,433,434,  0,0
	dc.w 413,296,416,  435,436,437,  0,0
	dc.w 292,422,301,  438,439,440,  0,0
	dc.w 290,283,420,  441,442,443,  0,0
	dc.w 290,420,414,  444,445,446,  0,0
	dc.w 292,411,422,  447,448,449,  0,0
	dc.w 283,410,418,  450,451,452,  0,0
	dc.w 420,283,428,  453,454,455,  0,0
	dc.w 421,415,289,  456,457,458,  0,0
	dc.w 413,416,419,  459,460,461,  0,0
	dc.w 301,418,410,  462,463,464,  0,0
	dc.w 416,296,300,  465,466,467,  0,0
	dc.w 283,418,428,  468,469,470,  0,0
	dc.w 300,295,415,  471,472,473,  0,0
	dc.w 430,412,285,  474,475,476,  0,0
	dc.w 430,433,299,  477,478,479,  0,0
	dc.w 429,298,294,  480,481,482,  0,0
	dc.w 417,422,411,  483,484,485,  0,0
	dc.w 432,414,420,  486,487,488,  0,0
	dc.w 416,300,438,  489,490,491,  0,0
	dc.w 429,421,298,  492,493,494,  0,0
	dc.w 301,422,418,  495,496,497,  0,0
	dc.w 432,420,428,  498,499,500,  0,0
	dc.w 416,438,424,  501,502,503,  0,0
	dc.w 426,440,441,  504,505,506,  0,0
	dc.w 417,427,422,  507,508,509,  0,0
	dc.w 438,300,415,  510,511,512,  0,0
	dc.w 422,431,418,  513,514,515,  0,0
	dc.w 436,419,416,  516,517,518,  0,0
	dc.w 430,285,284,  519,520,521,  0,0
	dc.w 437,431,422,  522,523,524,  0,0
	dc.w 447,428,418,  525,526,527,  0,0
	dc.w 435,415,421,  528,529,530,  0,0
	dc.w 427,437,422,  531,532,533,  0,0
	dc.w 434,421,429,  534,535,536,  0,0
	dc.w 434,435,421,  537,538,539,  0,0
	dc.w 458,434,429,  540,541,542,  0,0
	dc.w 448,415,435,  543,544,545,  0,0
	dc.w 436,416,424,  546,547,548,  0,0
	dc.w 451,441,440,  549,550,551,  0,0
	dc.w 444,428,447,  552,553,554,  0,0
	dc.w 444,432,428,  555,556,557,  0,0
	dc.w 104,433,439,  558,559,560,  0,0
	dc.w 452,432,444,  561,562,563,  0,0
	dc.w 458,429,423,  564,565,566,  0,0
	dc.w 430,439,433,  567,568,569,  0,0
	dc.w 434,448,435,  570,571,572,  0,0
	dc.w 448,438,415,  573,574,575,  0,0
	dc.w 436,424,449,  576,577,578,  0,0
	dc.w 424,438,445,  579,580,581,  0,0
	dc.w 447,418,431,  582,583,584,  0,0
	dc.w 448,445,438,  585,586,587,  0,0
	dc.w 104,439,105,  588,589,590,  0,0
	dc.w 451,440,425,  591,592,593,  0,0
	dc.w 443,437,427,  594,595,596,  0,0
	dc.w 437,447,431,  597,598,599,  0,0
	dc.w 452,442,432,  600,601,602,  0,0
	dc.w 436,449,446,  603,604,605,  0,0
	dc.w 424,445,449,  606,607,608,  0,0
	dc.w 443,447,437,  609,610,611,  0,0
	dc.w 443,427,453,  612,613,614,  0,0
	dc.w 452,444,447,  615,616,617,  0,0
	dc.w 457,445,448,  618,619,620,  0,0
	dc.w 446,449,455,  621,622,623,  0,0
	dc.w 458,448,434,  624,625,626,  0,0
	dc.w 443,456,447,  627,628,629,  0,0
	dc.w 446,455,476,  630,631,632,  0,0
	dc.w 451,454,441,  633,634,635,  0,0
	dc.w 457,449,445,  636,637,638,  0,0
	dc.w 458,457,448,  639,640,641,  0,0
	dc.w 443,453,456,  642,643,644,  0,0
	dc.w 124,460,468,  645,646,647,  0,0
	dc.w 459,461,107,  648,649,650,  0,0
	dc.w 468,460,466,  651,652,653,  0,0
	dc.w 229,461,214,  654,655,656,  0,0
	dc.w 465,106,450,  657,658,659,  0,0
	dc.w 468,466,472,  660,661,662,  0,0
	dc.w 467,470,464,  663,664,665,  0,0
	dc.w 459,214,461,  666,667,668,  0,0
	dc.w 221,473,471,  669,670,671,  0,0
	dc.w 466,462,474,  672,673,674,  0,0
	dc.w 124,469,218,  675,676,677,  0,0
	dc.w 467,463,220,  678,679,680,  0,0
	dc.w 221,471,477,  681,682,683,  0,0
	dc.w 468,472,217,  684,685,686,  0,0
	dc.w 466,216,472,  687,688,689,  0,0
	dc.w 459,465,214,  690,691,692,  0,0
	dc.w 215,469,217,  693,694,695,  0,0
	dc.w 215,218,469,  696,697,698,  0,0
	dc.w 465,450,475,  699,700,701,  0,0
	dc.w 217,472,226,  702,703,704,  0,0
	dc.w 465,475,247,  705,706,707,  0,0
	dc.w 465,231,214,  708,709,710,  0,0
	dc.w 472,216,226,  711,712,713,  0,0
	dc.w 467,240,470,  714,715,716,  0,0
	dc.w 466,474,216,  717,718,719,  0,0
	dc.w 221,237,473,  720,721,722,  0,0
	dc.w 217,226,227,  723,724,725,  0,0
	dc.w 215,217,227,  726,727,728,  0,0
	dc.w 215,223,218,  729,730,731,  0,0
	dc.w 229,214,231,  732,733,734,  0,0
	dc.w 474,219,216,  735,736,737,  0,0
	dc.w 473,237,224,  738,739,740,  0,0
	dc.w 215,227,223,  741,742,743,  0,0
	dc.w 218,223,238,  744,745,746,  0,0
	dc.w 221,477,222,  747,748,749,  0,0
	dc.w 467,220,240,  750,751,752,  0,0
	dc.w 465,247,231,  753,754,755,  0,0
	dc.w 229,231,239,  756,757,758,  0,0
	dc.w 237,232,224,  759,760,761,  0,0
	dc.w 226,216,243,  762,763,764,  0,0
	dc.w 236,231,247,  765,766,767,  0,0
	dc.w 240,241,244,  768,769,770,  0,0
	dc.w 224,232,234,  771,772,773,  0,0
	dc.w 227,226,235,  774,775,776,  0,0
	dc.w 237,234,232,  777,778,779,  0,0
	dc.w 224,234,225,  780,781,782,  0,0
	dc.w 238,223,235,  783,784,785,  0,0
	dc.w 220,228,249,  786,787,788,  0,0
	dc.w 223,227,235,  789,790,791,  0,0
	dc.w 240,220,249,  792,793,794,  0,0
	dc.w 236,239,231,  795,796,797,  0,0
	dc.w 221,233,237,  798,799,800,  0,0
	dc.w 216,219,243,  801,802,803,  0,0
	dc.w 238,235,246,  804,805,806,  0,0
	dc.w 221,222,233,  807,808,809,  0,0
	dc.w 226,243,378,  810,811,812,  0,0
	dc.w 238,246,230,  813,814,815,  0,0
	dc.w 249,228,386,  816,817,818,  0,0
	dc.w 226,378,235,  819,820,821,  0,0
	dc.w 237,377,234,  822,823,824,  0,0
	dc.w 225,377,242,  825,826,827,  0,0
	dc.w 246,235,245,  828,829,830,  0,0
	dc.w 240,248,241,  831,832,833,  0,0
	dc.w 409,244,241,  834,835,836,  0,0
	dc.w 235,378,245,  837,838,839,  0,0
	dc.w 240,249,248,  840,841,842,  0,0
	dc.w 225,234,377,  843,844,845,  0,0
	dc.w 246,245,376,  846,847,848,  0,0
	dc.w 222,374,233,  849,850,851,  0,0
	dc.w 245,379,382,  852,853,854,  0,0
	dc.w 233,375,237,  855,856,857,  0,0
	dc.w 243,379,378,  858,859,860,  0,0
	dc.w 245,378,379,  861,862,863,  0,0
	dc.w 246,376,381,  864,865,866,  0,0
	dc.w 237,375,377,  867,868,869,  0,0
	dc.w 245,382,376,  870,871,872,  0,0
	dc.w 246,381,230,  873,874,875,  0,0
	dc.w 377,113,242,  876,877,878,  0,0
	dc.w 376,382,383,  879,880,881,  0,0
	dc.w 249,121,248,  882,883,884,  0,0
	dc.w 375,111,377,  885,886,887,  0,0
	dc.w 230,381,385,  888,889,890,  0,0
	dc.w 111,113,377,  891,892,893,  0,0
	dc.w 249,386,121,  894,895,896,  0,0
	dc.w 389,406,390,  897,898,899,  0,0
	dc.w 398,402,110,  900,901,902,  0,0
	dc.w 384,122,397,  903,904,905,  0,0
	dc.w 400,406,387,  906,907,908,  0,0
	dc.w 389,390,339,  909,910,911,  0,0
	dc.w 389,339,391,  912,913,914,  0,0
	dc.w 400,387,388,  915,916,917,  0,0
	dc.w 384,397,396,  918,919,920,  0,0
	dc.w 380,365,401,  921,922,923,  0,0
	dc.w 394,393,395,  924,925,926,  0,0
	dc.w 122,394,397,  927,928,929,  0,0
	dc.w 403,404,392,  930,931,932,  0,0
	dc.w 405,400,388,  933,934,935,  0,0
	dc.w 344,109,345,  936,937,938,  0,0
	dc.w 395,393,116,  939,940,941,  0,0
	dc.w 338,400,347,  942,943,944,  0,0
	dc.w 407,390,406,  945,946,947,  0,0
	dc.w 394,340,397,  948,949,950,  0,0
	dc.w 346,112,404,  951,952,953,  0,0
	dc.w 405,347,400,  954,955,956,  0,0
	dc.w 396,397,340,  957,958,959,  0,0
	dc.w 350,402,398,  960,961,962,  0,0
	dc.w 402,403,408,  963,964,965,  0,0
	dc.w 346,404,403,  966,967,968,  0,0
	dc.w 338,406,400,  969,970,971,  0,0
	dc.w 407,406,338,  972,973,974,  0,0
	dc.w 366,403,402,  975,976,977,  0,0
	dc.w 341,390,407,  978,979,980,  0,0
	dc.w 341,339,390,  981,982,983,  0,0
	dc.w 342,391,339,  984,985,986,  0,0
	dc.w 395,116,352,  987,988,989,  0,0
	dc.w 370,396,343,  990,991,992,  0,0
	dc.w 345,401,365,  993,994,995,  0,0
	dc.w 351,407,338,  996,997,998,  0,0
	dc.w 351,341,407,  999,1000,1001,  0,0
	dc.w 350,366,402,  1002,1003,1004,  0,0
	dc.w 351,338,347,  1005,1006,1007,  0,0
	dc.w 341,342,339,  1008,1009,1010,  0,0
	dc.w 395,352,353,  1011,1012,1013,  0,0
	dc.w 394,395,353,  1014,1015,1016,  0,0
	dc.w 366,346,403,  1017,1018,1019,  0,0
	dc.w 396,340,353,  1020,1021,1022,  0,0
	dc.w 396,358,343,  1023,1024,1025,  0,0
	dc.w 356,341,351,  1026,1027,1028,  0,0
	dc.w 356,342,341,  1029,1030,1031,  0,0
	dc.w 396,353,358,  1032,1033,1034,  0,0
	dc.w 362,391,342,  1035,1036,1037,  0,0
	dc.w 394,353,340,  1038,1039,1040,  0,0
	dc.w 344,345,359,  1041,1042,1043,  0,0
	dc.w 351,347,348,  1044,1045,1046,  0,0
	dc.w 187,345,365,  1047,1048,1049,  0,0
	dc.w 356,351,348,  1050,1051,1052,  0,0
	dc.w 343,358,349,  1053,1054,1055,  0,0
	dc.w 370,343,373,  1056,1057,1058,  0,0
	dc.w 187,359,345,  1059,1060,1061,  0,0
	dc.w 344,359,361,  1062,1063,1064,  0,0
	dc.w 344,361,190,  1065,1066,1067,  0,0
	dc.w 372,355,346,  1068,1069,1070,  0,0
	dc.w 348,347,360,  1071,1072,1073,  0,0
	dc.w 349,358,368,  1074,1075,1076,  0,0
	dc.w 366,372,346,  1077,1078,1079,  0,0
	dc.w 358,353,368,  1080,1081,1082,  0,0
	dc.w 356,362,342,  1083,1084,1085,  0,0
	dc.w 352,367,357,  1086,1087,1088,  0,0
	dc.w 352,357,353,  1089,1090,1091,  0,0
	dc.w 373,343,349,  1092,1093,1094,  0,0
	dc.w 348,371,363,  1095,1096,1097,  0,0
	dc.w 356,348,363,  1098,1099,1100,  0,0
	dc.w 356,363,362,  1101,1102,1103,  0,0
	dc.w 182,361,359,  1104,1105,1106,  0,0
	dc.w 179,371,348,  1107,1108,1109,  0,0
	dc.w 349,368,178,  1110,1111,1112,  0,0
	dc.w 349,178,193,  1113,1114,1115,  0,0
	dc.w 373,349,193,  1116,1117,1118,  0,0
	dc.w 182,359,187,  1119,1120,1121,  0,0
	dc.w 182,205,361,  1122,1123,1124,  0,0
	dc.w 179,348,360,  1125,1126,1127,  0,0
	dc.w 353,357,196,  1128,1129,1130,  0,0
	dc.w 362,363,364,  1131,1132,1133,  0,0
	dc.w 367,181,357,  1134,1135,1136,  0,0
	dc.w 187,365,354,  1137,1138,1139,  0,0
	dc.w 195,372,366,  1140,1141,1142,  0,0
	dc.w 114,179,360,  1143,1144,1145,  0,0
	dc.w 364,363,185,  1146,1147,1148,  0,0
	dc.w 353,196,368,  1149,1150,1151,  0,0
	dc.w 184,179,114,  1152,1153,1154,  0,0
	dc.w 184,188,179,  1155,1156,1157,  0,0
	dc.w 364,185,186,  1158,1159,1160,  0,0
	dc.w 367,191,181,  1161,1162,1163,  0,0
	dc.w 183,355,372,  1164,1165,1166,  0,0
	dc.w 188,371,179,  1167,1168,1169,  0,0
	dc.w 363,371,180,  1170,1171,1172,  0,0
	dc.w 363,180,185,  1173,1174,1175,  0,0
	dc.w 357,181,189,  1176,1177,1178,  0,0
	dc.w 357,189,196,  1179,1180,1181,  0,0
	dc.w 194,361,205,  1182,1183,1184,  0,0
	dc.w 194,190,361,  1185,1186,1187,  0,0
	dc.w 195,366,201,  1188,1189,1190,  0,0
	dc.w 188,180,371,  1191,1192,1193,  0,0
	dc.w 178,368,369,  1194,1195,1196,  0,0
	dc.w 182,187,354,  1197,1198,1199,  0,0
	dc.w 195,183,372,  1200,1201,1202,  0,0
	dc.w 181,191,189,  1203,1204,1205,  0,0
	dc.w 368,196,369,  1206,1207,1208,  0,0
	dc.w 195,203,183,  1209,1210,1211,  0,0
	dc.w 184,114,197,  1212,1213,1214,  0,0
	dc.w 184,197,188,  1215,1216,1217,  0,0
	dc.w 180,211,185,  1218,1219,1220,  0,0
	dc.w 373,193,198,  1221,1222,1223,  0,0
	dc.w 196,189,192,  1224,1225,1226,  0,0
	dc.w 196,200,369,  1227,1228,1229,  0,0
	dc.w 178,369,200,  1230,1231,1232,  0,0
	dc.w 182,354,205,  1233,1234,1235,  0,0
	dc.w 186,185,117,  1236,1237,1238,  0,0
	dc.w 198,193,202,  1239,1240,1241,  0,0
	dc.w 193,178,202,  1242,1243,1244,  0,0
	dc.w 195,201,203,  1245,1246,1247,  0,0
	dc.w 180,210,211,  1248,1249,1250,  0,0
	dc.w 185,211,212,  1251,1252,1253,  0,0
	dc.w 185,212,117,  1254,1255,1256,  0,0
	dc.w 188,208,209,  1257,1258,1259,  0,0
	dc.w 188,209,180,  1260,1261,1262,  0,0
	dc.w 189,213,204,  1263,1264,1265,  0,0
	dc.w 189,204,192,  1266,1267,1268,  0,0
	dc.w 188,197,208,  1269,1270,1271,  0,0
	dc.w 209,210,180,  1272,1273,1274,  0,0
	dc.w 202,178,200,  1275,1276,1277,  0,0
	dc.w 194,205,206,  1278,1279,1280,  0,0
	dc.w 199,208,197,  1281,1282,1283,  0,0
	dc.w 196,192,200,  1284,1285,1286,  0,0
	dc.w 251,303,519,  1287,1288,1289,  0,0
	dc.w 251,134,302,  1290,1291,1292,  0,0
	dc.w 302,134,517,  1293,1294,1295,  0,0
	dc.w 251,496,134,  1296,1297,1298,  0,0
	dc.w 134,496,489,  1299,1300,1301,  0,0
	dc.w 299,433,103,  1302,1303,1304,  0,0
	dc.w 425,103,304,  1305,1306,1307,  0,0
	dc.w 304,103,433,  1308,1309,1310,  0,0
	dc.w 104,304,433,  1311,1312,1313,  0,0
	dc.w 104,425,304,  1314,1315,1316,  0,0
	dc.w 451,425,104,  1317,1318,1319,  0,0
	dc.w 229,305,461,  1320,1321,1322,  0,0
	dc.w 305,108,461,  1323,1324,1325,  0,0
	dc.w 229,306,305,  1326,1327,1328,  0,0
	dc.w 307,477,306,  1329,1330,1331,  0,0
	dc.w 307,222,477,  1332,1333,1334,  0,0
	dc.w 229,307,306,  1335,1336,1337,  0,0
	dc.w 229,239,308,  1338,1339,1340,  0,0
	dc.w 229,308,307,  1341,1342,1343,  0,0
	dc.w 307,308,222,  1344,1345,1346,  0,0
	dc.w 308,239,309,  1347,1348,1349,  0,0
	dc.w 222,309,374,  1350,1351,1352,  0,0
	dc.w 222,308,309,  1353,1354,1355,  0,0
	dc.w 109,310,398,  1356,1357,1358,  0,0
	dc.w 344,310,109,  1359,1360,1361,  0,0
	dc.w 350,398,312,  1362,1363,1364,  0,0
	dc.w 350,312,311,  1365,1366,1367,  0,0
	dc.w 311,312,190,  1368,1369,1370,  0,0
	dc.w 344,190,312,  1371,1372,1373,  0,0
	dc.w 344,312,310,  1374,1375,1376,  0,0
	dc.w 310,312,398,  1377,1378,1379,  0,0
	dc.w 311,190,313,  1380,1381,1382,  0,0
	dc.w 350,313,366,  1383,1384,1385,  0,0
	dc.w 350,311,313,  1386,1387,1388,  0,0
	dc.w 314,366,313,  1389,1390,1391,  0,0
	dc.w 194,314,190,  1392,1393,1394,  0,0
	dc.w 314,313,190,  1395,1396,1397,  0,0
	dc.w 315,201,366,  1398,1399,1400,  0,0
	dc.w 316,201,315,  1401,1402,1403,  0,0
	dc.w 206,316,315,  1404,1405,1406,  0,0
	dc.w 194,206,314,  1407,1408,1409,  0,0
	dc.w 206,315,314,  1410,1411,1412,  0,0
	dc.w 315,366,314,  1413,1414,1415,  0,0
	dc.w 252,507,318,  1416,1417,1418,  0,0
	dc.w 252,318,317,  1419,1420,1421,  0,0
	dc.w 318,257,317,  1422,1423,1424,  0,0
	dc.w 5,257,318,  1425,1426,1427,  0,0
	dc.w 5,318,319,  1428,1429,1430,  0,0
	dc.w 319,318,507,  1431,1432,1433,  0,0
	dc.w 14,5,320,  1434,1435,1436,  0,0
	dc.w 5,319,320,  1437,1438,1439,  0,0
	dc.w 319,507,320,  1440,1441,1442,  0,0
	dc.w 321,14,320,  1443,1444,1445,  0,0
	dc.w 508,321,320,  1446,1447,1448,  0,0
	dc.w 508,320,507,  1449,1450,1451,  0,0
	dc.w 322,14,321,  1452,1453,1454,  0,0
	dc.w 272,322,508,  1455,1456,1457,  0,0
	dc.w 322,321,508,  1458,1459,1460,  0,0
	dc.w 322,485,14,  1461,1462,1463,  0,0
	dc.w 322,323,485,  1464,1465,1466,  0,0
	dc.w 272,323,322,  1467,1468,1469,  0,0
	dc.w 132,324,274,  1470,1471,1472,  0,0
	dc.w 426,325,291,  1473,1474,1475,  0,0
	dc.w 291,325,324,  1476,1477,1478,  0,0
	dc.w 325,274,324,  1479,1480,1481,  0,0
	dc.w 297,274,325,  1482,1483,1484,  0,0
	dc.w 297,325,326,  1485,1486,1487,  0,0
	dc.w 326,325,426,  1488,1489,1490,  0,0
	dc.w 297,326,417,  1491,1492,1493,  0,0
	dc.w 326,327,417,  1494,1495,1496,  0,0
	dc.w 326,426,327,  1497,1498,1499,  0,0
	dc.w 328,427,417,  1500,1501,1502,  0,0
	dc.w 328,417,327,  1503,1504,1505,  0,0
	dc.w 426,328,327,  1506,1507,1508,  0,0
	dc.w 328,329,427,  1509,1510,1511,  0,0
	dc.w 427,329,453,  1512,1513,1514,  0,0
	dc.w 426,329,328,  1515,1516,1517,  0,0
	dc.w 329,330,453,  1518,1519,1520,  0,0
	dc.w 441,330,329,  1521,1522,1523,  0,0
	dc.w 426,441,329,  1524,1525,1526,  0,0
	dc.w 331,453,330,  1527,1528,1529,  0,0
	dc.w 454,330,441,  1530,1531,1532,  0,0
	dc.w 454,331,330,  1533,1534,1535,  0,0
	dc.w 332,333,462,  1536,1537,1538,  0,0
	dc.w 333,474,462,  1539,1540,1541,  0,0
	dc.w 333,334,474,  1542,1543,1544,  0,0
	dc.w 473,334,333,  1545,1546,1547,  0,0
	dc.w 473,224,335,  1548,1549,1550,  0,0
	dc.w 473,335,334,  1551,1552,1553,  0,0
	dc.w 334,335,474,  1554,1555,1556,  0,0
	dc.w 474,336,219,  1557,1558,1559,  0,0
	dc.w 335,336,474,  1560,1561,1562,  0,0
	dc.w 224,336,335,  1563,1564,1565,  0,0
	dc.w 224,225,336,  1566,1567,1568,  0,0
	dc.w 225,337,336,  1569,1570,1571,  0,0
	dc.w 336,337,219,  1572,1573,1574,  0,0
	dc.w 225,136,337,  1575,1576,1577,  0,0
	dc.w 219,136,243,  1578,1579,1580,  0,0
	dc.w 337,136,219,  1581,1582,1583,  0,0
	dc.w 225,242,136,  1584,1585,1586,  0,0
	dc.w 136,242,137,  1587,1588,1589,  0,0
	dc.w 136,137,243,  1590,1591,1592,  0,0
	dc.w 137,242,138,  1593,1594,1595,  0,0
	dc.w 392,404,140,  1596,1597,1598,  0,0
	dc.w 392,140,139,  1599,1600,1601,  0,0
	dc.w 140,123,139,  1602,1603,1604,  0,0
	dc.w 140,388,123,  1605,1606,1607,  0,0
	dc.w 141,388,140,  1608,1609,1610,  0,0
	dc.w 404,141,140,  1611,1612,1613,  0,0
	dc.w 405,388,141,  1614,1615,1616,  0,0
	dc.w 142,405,141,  1617,1618,1619,  0,0
	dc.w 404,142,141,  1620,1621,1622,  0,0
	dc.w 112,405,142,  1623,1624,1625,  0,0
	dc.w 112,142,404,  1626,1627,1628,  0,0
	dc.w 143,360,112,  1629,1630,1631,  0,0
	dc.w 346,143,112,  1632,1633,1634,  0,0
	dc.w 112,347,405,  1635,1636,1637,  0,0
	dc.w 144,360,143,  1638,1639,1640,  0,0
	dc.w 355,143,346,  1641,1642,1643,  0,0
	dc.w 355,144,143,  1644,1645,1646,  0,0
	dc.w 360,347,112,  1647,1648,1649,  0,0
	dc.w 114,360,144,  1650,1651,1652,  0,0
	dc.w 355,114,144,  1653,1654,1655,  0,0
	dc.w 183,114,355,  1656,1657,1658,  0,0
	dc.w 145,197,114,  1659,1660,1661,  0,0
	dc.w 183,145,114,  1662,1663,1664,  0,0
	dc.w 146,197,145,  1665,1666,1667,  0,0
	dc.w 203,146,183,  1668,1669,1670,  0,0
	dc.w 183,146,145,  1671,1672,1673,  0,0
	dc.w 203,207,146,  1674,1675,1676,  0,0
	dc.w 207,147,146,  1677,1678,1679,  0,0
	dc.w 147,197,146,  1680,1681,1682,  0,0
	dc.w 147,199,197,  1683,1684,1685,  0,0
	dc.w 148,199,147,  1686,1687,1688,  0,0
	dc.w 207,148,147,  1689,1690,1691,  0,0
	dc.w 149,150,520,  1692,1693,1694,  0,0
	dc.w 520,150,259,  1695,1696,1697,  0,0
	dc.w 258,150,149,  1698,1699,1700,  0,0
	dc.w 151,259,150,  1701,1702,1703,  0,0
	dc.w 523,151,258,  1704,1705,1706,  0,0
	dc.w 258,151,150,  1707,1708,1709,  0,0
	dc.w 523,512,151,  1710,1711,1712,  0,0
	dc.w 512,152,151,  1713,1714,1715,  0,0
	dc.w 152,259,151,  1716,1717,1718,  0,0
	dc.w 152,153,259,  1719,1720,1721,  0,0
	dc.w 153,505,259,  1722,1723,1724,  0,0
	dc.w 512,153,152,  1725,1726,1727,  0,0
	dc.w 153,154,505,  1728,1729,1730,  0,0
	dc.w 10,154,153,  1731,1732,1733,  0,0
	dc.w 10,153,512,  1734,1735,1736,  0,0
	dc.w 154,155,505,  1737,1738,1739,  0,0
	dc.w 12,155,10,  1740,1741,1742,  0,0
	dc.w 10,155,154,  1743,1744,1745,  0,0
	dc.w 155,156,505,  1746,1747,1748,  0,0
	dc.w 509,156,12,  1749,1750,1751,  0,0
	dc.w 12,156,155,  1752,1753,1754,  0,0
	dc.w 157,510,505,  1755,1756,1757,  0,0
	dc.w 158,510,157,  1758,1759,1760,  0,0
	dc.w 490,158,157,  1761,1762,1763,  0,0
	dc.w 509,490,156,  1764,1765,1766,  0,0
	dc.w 490,157,156,  1767,1768,1769,  0,0
	dc.w 156,157,505,  1770,1771,1772,  0,0
	dc.w 158,486,510,  1773,1774,1775,  0,0
	dc.w 159,486,158,  1776,1777,1778,  0,0
	dc.w 490,159,158,  1779,1780,1781,  0,0
	dc.w 490,497,160,  1782,1783,1784,  0,0
	dc.w 490,160,159,  1785,1786,1787,  0,0
	dc.w 159,160,486,  1788,1789,1790,  0,0
	dc.w 128,486,161,  1791,1792,1793,  0,0
	dc.w 161,486,160,  1794,1795,1796,  0,0
	dc.w 497,161,160,  1797,1798,1799,  0,0
	dc.w 162,128,161,  1800,1801,1802,  0,0
	dc.w 271,162,161,  1803,1804,1805,  0,0
	dc.w 271,161,497,  1806,1807,1808,  0,0
	dc.w 280,288,164,  1809,1810,1811,  0,0
	dc.w 280,164,163,  1812,1813,1814,  0,0
	dc.w 288,165,164,  1815,1816,1817,  0,0
	dc.w 166,293,165,  1818,1819,1820,  0,0
	dc.w 414,166,288,  1821,1822,1823,  0,0
	dc.w 166,165,288,  1824,1825,1826,  0,0
	dc.w 166,294,293,  1827,1828,1829,  0,0
	dc.w 167,294,166,  1830,1831,1832,  0,0
	dc.w 414,167,166,  1833,1834,1835,  0,0
	dc.w 429,294,168,  1836,1837,1838,  0,0
	dc.w 168,294,167,  1839,1840,1841,  0,0
	dc.w 168,167,414,  1842,1843,1844,  0,0
	dc.w 429,168,169,  1845,1846,1847,  0,0
	dc.w 423,429,169,  1848,1849,1850,  0,0
	dc.w 169,168,414,  1851,1852,1853,  0,0
	dc.w 442,170,432,  1854,1855,1856,  0,0
	dc.w 170,171,432,  1857,1858,1859,  0,0
	dc.w 170,423,171,  1860,1861,1862,  0,0
	dc.w 171,169,432,  1863,1864,1865,  0,0
	dc.w 432,169,414,  1866,1867,1868,  0,0
	dc.w 423,169,171,  1869,1870,1871,  0,0
	dc.w 458,423,172,  1872,1873,1874,  0,0
	dc.w 172,423,170,  1875,1876,1877,  0,0
	dc.w 172,170,442,  1878,1879,1880,  0,0
	dc.w 173,458,172,  1881,1882,1883,  0,0
	dc.w 174,218,175,  1884,1885,1886,  0,0
	dc.w 463,175,220,  1887,1888,1889,  0,0
	dc.w 175,176,220,  1890,1891,1892,  0,0
	dc.w 175,218,176,  1893,1894,1895,  0,0
	dc.w 238,16,177,  1896,1897,1898,  0,0
	dc.w 218,238,177,  1899,1900,1901,  0,0
	dc.w 177,16,228,  1902,1903,1904,  0,0
	dc.w 218,177,176,  1905,1906,1907,  0,0
	dc.w 176,177,220,  1908,1909,1910,  0,0
	dc.w 220,177,228,  1911,1912,1913,  0,0
	dc.w 238,230,16,  1914,1915,1916,  0,0
	dc.w 16,230,17,  1917,1918,1919,  0,0
	dc.w 16,17,228,  1920,1921,1922,  0,0
	dc.w 230,385,18,  1923,1924,1925,  0,0
	dc.w 17,230,18,  1926,1927,1928,  0,0
	dc.w 228,17,18,  1929,1930,1931,  0,0
	dc.w 18,385,19,  1932,1933,1934,  0,0
	dc.w 228,18,386,  1935,1936,1937,  0,0
	dc.w 386,18,19,  1938,1939,1940,  0,0
	dc.w 115,399,20,  1941,1942,1943,  0,0
	dc.w 393,115,20,  1944,1945,1946,  0,0
	dc.w 20,399,21,  1947,1948,1949,  0,0
	dc.w 393,20,21,  1950,1951,1952,  0,0
	dc.w 393,21,116,  1953,1954,1955,  0,0
	dc.w 116,21,391,  1956,1957,1958,  0,0
	dc.w 21,399,391,  1959,1960,1961,  0,0
	dc.w 362,116,391,  1962,1963,1964,  0,0
	dc.w 116,22,352,  1965,1966,1967,  0,0
	dc.w 364,22,116,  1968,1969,1970,  0,0
	dc.w 22,367,352,  1971,1972,1973,  0,0
	dc.w 22,23,367,  1974,1975,1976,  0,0
	dc.w 364,23,22,  1977,1978,1979,  0,0
	dc.w 362,364,116,  1980,1981,1982,  0,0
	dc.w 364,186,24,  1983,1984,1985,  0,0
	dc.w 364,24,23,  1986,1987,1988,  0,0
	dc.w 23,24,367,  1989,1990,1991,  0,0
	dc.w 24,186,25,  1992,1993,1994,  0,0
	dc.w 367,24,25,  1995,1996,1997,  0,0
	dc.w 367,25,191,  1998,1999,2000,  0,0
	dc.w 186,117,25,  2001,2002,2003,  0,0
	dc.w 25,117,119,  2004,2005,2006,  0,0
	dc.w 25,119,191,  2007,2008,2009,  0,0
	dc.w 189,191,118,  2010,2011,2012,  0,0
	dc.w 189,118,213,  2013,2014,2015,  0,0
	dc.w 117,118,119,  2016,2017,2018,  0,0
	dc.w 119,118,191,  2019,2020,2021,  0,0
	dc.w 134,27,26,  2022,2023,2024,  0,0
	dc.w 134,26,487,  2025,2026,2027,  0,0
	dc.w 27,103,26,  2028,2029,2030,  0,0
	dc.w 26,103,133,  2031,2032,2033,  0,0
	dc.w 487,26,133,  2034,2035,2036,  0,0
	dc.w 28,489,496,  2037,2038,2039,  0,0
	dc.w 28,29,489,  2040,2041,2042,  0,0
	dc.w 299,29,28,  2043,2044,2045,  0,0
	dc.w 31,482,481,  2046,2047,2048,  0,0
	dc.w 31,481,30,  2049,2050,2051,  0,0
	dc.w 285,31,30,  2052,2053,2054,  0,0
	dc.w 502,130,493,  2055,2056,2057,  0,0
	dc.w 32,496,482,  2058,2059,2060,  0,0
	dc.w 28,496,32,  2061,2062,2063,  0,0
	dc.w 299,28,32,  2064,2065,2066,  0,0
	dc.w 493,130,33,  2067,2068,2069,  0,0
	dc.w 493,33,501,  2070,2071,2072,  0,0
	dc.w 130,276,33,  2073,2074,2075,  0,0
	dc.w 34,273,129,  2076,2077,2078,  0,0
	dc.w 501,129,497,  2079,2080,2081,  0,0
	dc.w 501,34,129,  2082,2083,2084,  0,0
	dc.w 35,30,481,  2085,2086,2087,  0,0
	dc.w 285,30,498,  2088,2089,2090,  0,0
	dc.w 498,30,35,  2091,2092,2093,  0,0
	dc.w 129,271,497,  2094,2095,2096,  0,0
	dc.w 299,31,285,  2097,2098,2099,  0,0
	dc.w 299,32,31,  2100,2101,2102,  0,0
	dc.w 32,482,31,  2103,2104,2105,  0,0
	dc.w 499,133,36,  2106,2107,2108,  0,0
	dc.w 36,133,286,  2109,2110,2111,  0,0
	dc.w 280,37,129,  2112,2113,2114,  0,0
	dc.w 280,129,273,  2115,2116,2117,  0,0
	dc.w 129,37,271,  2118,2119,2120,  0,0
	dc.w 38,488,128,  2121,2122,2123,  0,0
	dc.w 275,38,128,  2124,2125,2126,  0,0
	dc.w 39,488,38,  2127,2128,2129,  0,0
	dc.w 127,488,39,  2130,2131,2132,  0,0
	dc.w 39,38,275,  2133,2134,2135,  0,0
	dc.w 268,127,40,  2136,2137,2138,  0,0
	dc.w 41,268,40,  2139,2140,2141,  0,0
	dc.w 277,41,40,  2142,2143,2144,  0,0
	dc.w 42,278,276,  2145,2146,2147,  0,0
	dc.w 42,276,130,  2148,2149,2150,  0,0
	dc.w 502,42,130,  2151,2152,2153,  0,0
	dc.w 33,273,34,  2154,2155,2156,  0,0
	dc.w 276,273,33,  2157,2158,2159,  0,0
	dc.w 33,34,501,  2160,2161,2162,  0,0
	dc.w 126,268,41,  2163,2164,2165,  0,0
	dc.w 126,41,277,  2166,2167,2168,  0,0
	dc.w 36,286,43,  2169,2170,2171,  0,0
	dc.w 499,36,43,  2172,2173,2174,  0,0
	dc.w 499,43,272,  2175,2176,2177,  0,0
	dc.w 127,39,281,  2178,2179,2180,  0,0
	dc.w 281,39,275,  2181,2182,2183,  0,0
	dc.w 286,291,43,  2184,2185,2186,  0,0
	dc.w 43,291,44,  2187,2188,2189,  0,0
	dc.w 43,44,272,  2190,2191,2192,  0,0
	dc.w 45,131,274,  2193,2194,2195,  0,0
	dc.w 502,131,45,  2196,2197,2198,  0,0
	dc.w 126,277,296,  2199,2200,2201,  0,0
	dc.w 46,502,45,  2202,2203,2204,  0,0
	dc.w 297,46,45,  2205,2206,2207,  0,0
	dc.w 297,45,274,  2208,2209,2210,  0,0
	dc.w 277,40,295,  2211,2212,2213,  0,0
	dc.w 40,127,295,  2214,2215,2216,  0,0
	dc.w 282,135,126,  2217,2218,2219,  0,0
	dc.w 297,278,46,  2220,2221,2222,  0,0
	dc.w 46,278,42,  2223,2224,2225,  0,0
	dc.w 46,42,502,  2226,2227,2228,  0,0
	dc.w 281,275,128,  2229,2230,2231,  0,0
	dc.w 295,127,281,  2232,2233,2234,  0,0
	dc.w 282,126,296,  2235,2236,2237,  0,0
	dc.w 286,133,103,  2238,2239,2240,  0,0
	dc.w 294,281,128,  2241,2242,2243,  0,0
	dc.w 294,128,293,  2244,2245,2246,  0,0
	dc.w 103,48,47,  2247,2248,2249,  0,0
	dc.w 134,489,48,  2250,2251,2252,  0,0
	dc.w 48,489,47,  2253,2254,2255,  0,0
	dc.w 134,48,27,  2256,2257,2258,  0,0
	dc.w 27,48,103,  2259,2260,2261,  0,0
	dc.w 299,103,29,  2262,2263,2264,  0,0
	dc.w 103,47,29,  2265,2266,2267,  0,0
	dc.w 29,47,489,  2268,2269,2270,  0,0
	dc.w 132,274,131,  2271,2272,2273,  0,0
	dc.w 323,131,485,  2274,2275,2276,  0,0
	dc.w 323,132,131,  2277,2278,2279,  0,0
	dc.w 272,132,323,  2280,2281,2282,  0,0
	dc.w 44,291,324,  2283,2284,2285,  0,0
	dc.w 44,324,132,  2286,2287,2288,  0,0
	dc.w 272,44,132,  2289,2290,2291,  0,0
	dc.w 49,128,162,  2292,2293,2294,  0,0
	dc.w 163,128,49,  2295,2296,2297,  0,0
	dc.w 37,49,271,  2298,2299,2300,  0,0
	dc.w 49,162,271,  2301,2302,2303,  0,0
	dc.w 280,163,37,  2304,2305,2306,  0,0
	dc.w 37,163,49,  2307,2308,2309,  0,0
	dc.w 164,128,163,  2310,2311,2312,  0,0
	dc.w 293,128,164,  2313,2314,2315,  0,0
	dc.w 165,293,164,  2316,2317,2318,  0,0
	dc.w 430,106,439,  2319,2320,2321,  0,0
	dc.w 430,284,106,  2322,2323,2324,  0,0
	dc.w 124,442,452,  2325,2326,2327,  0,0
	dc.w 104,105,107,  2328,2329,2330,  0,0
	dc.w 51,447,50,  2331,2332,2333,  0,0
	dc.w 452,447,51,  2334,2335,2336,  0,0
	dc.w 51,50,460,  2337,2338,2339,  0,0
	dc.w 52,450,106,  2340,2341,2342,  0,0
	dc.w 284,52,106,  2343,2344,2345,  0,0
	dc.w 53,460,50,  2346,2347,2348,  0,0
	dc.w 456,53,447,  2349,2350,2351,  0,0
	dc.w 53,50,447,  2352,2353,2354,  0,0
	dc.w 439,106,105,  2355,2356,2357,  0,0
	dc.w 107,461,54,  2358,2359,2360,  0,0
	dc.w 104,107,54,  2361,2362,2363,  0,0
	dc.w 55,471,56,  2364,2365,2366,  0,0
	dc.w 451,55,56,  2367,2368,2369,  0,0
	dc.w 451,56,454,  2370,2371,2372,  0,0
	dc.w 57,455,449,  2373,2374,2375,  0,0
	dc.w 57,58,455,  2376,2377,2378,  0,0
	dc.w 467,58,57,  2379,2380,2381,  0,0
	dc.w 457,57,449,  2382,2383,2384,  0,0
	dc.w 59,57,457,  2385,2386,2387,  0,0
	dc.w 467,57,59,  2388,2389,2390,  0,0
	dc.w 124,452,51,  2391,2392,2393,  0,0
	dc.w 124,51,460,  2394,2395,2396,  0,0
	dc.w 465,105,106,  2397,2398,2399,  0,0
	dc.w 60,477,471,  2400,2401,2402,  0,0
	dc.w 60,471,55,  2403,2404,2405,  0,0
	dc.w 451,60,55,  2406,2407,2408,  0,0
	dc.w 61,463,62,  2409,2410,2411,  0,0
	dc.w 458,61,457,  2412,2413,2414,  0,0
	dc.w 61,62,457,  2415,2416,2417,  0,0
	dc.w 467,464,58,  2418,2419,2420,  0,0
	dc.w 464,63,58,  2421,2422,2423,  0,0
	dc.w 58,63,455,  2424,2425,2426,  0,0
	dc.w 459,105,465,  2427,2428,2429,  0,0
	dc.w 459,107,105,  2430,2431,2432,  0,0
	dc.w 64,476,455,  2433,2434,2435,  0,0
	dc.w 64,455,63,  2436,2437,2438,  0,0
	dc.w 464,64,63,  2439,2440,2441,  0,0
	dc.w 56,473,65,  2442,2443,2444,  0,0
	dc.w 56,471,473,  2445,2446,2447,  0,0
	dc.w 454,56,65,  2448,2449,2450,  0,0
	dc.w 456,453,67,  2451,2452,2453,  0,0
	dc.w 456,67,66,  2454,2455,2456,  0,0
	dc.w 66,67,466,  2457,2458,2459,  0,0
	dc.w 67,462,466,  2460,2461,2462,  0,0
	dc.w 67,68,462,  2463,2464,2465,  0,0
	dc.w 453,68,67,  2466,2467,2468,  0,0
	dc.w 53,466,460,  2469,2470,2471,  0,0
	dc.w 53,66,466,  2472,2473,2474,  0,0
	dc.w 456,66,53,  2475,2476,2477,  0,0
	dc.w 59,457,62,  2478,2479,2480,  0,0
	dc.w 467,59,463,  2481,2482,2483,  0,0
	dc.w 463,59,62,  2484,2485,2486,  0,0
	dc.w 64,69,476,  2487,2488,2489,  0,0
	dc.w 470,69,464,  2490,2491,2492,  0,0
	dc.w 464,69,64,  2493,2494,2495,  0,0
	dc.w 69,70,476,  2496,2497,2498,  0,0
	dc.w 240,70,470,  2499,2500,2501,  0,0
	dc.w 470,70,69,  2502,2503,2504,  0,0
	dc.w 240,244,70,  2505,2506,2507,  0,0
	dc.w 244,71,70,  2508,2509,2510,  0,0
	dc.w 70,71,476,  2511,2512,2513,  0,0
	dc.w 108,54,461,  2514,2515,2516,  0,0
	dc.w 104,54,108,  2517,2518,2519,  0,0
	dc.w 451,104,108,  2520,2521,2522,  0,0
	dc.w 305,72,108,  2523,2524,2525,  0,0
	dc.w 72,451,108,  2526,2527,2528,  0,0
	dc.w 305,306,477,  2529,2530,2531,  0,0
	dc.w 72,477,60,  2532,2533,2534,  0,0
	dc.w 305,477,72,  2535,2536,2537,  0,0
	dc.w 72,60,451,  2538,2539,2540,  0,0
	dc.w 73,332,68,  2541,2542,2543,  0,0
	dc.w 68,332,462,  2544,2545,2546,  0,0
	dc.w 331,68,453,  2547,2548,2549,  0,0
	dc.w 331,73,68,  2550,2551,2552,  0,0
	dc.w 74,332,73,  2553,2554,2555,  0,0
	dc.w 454,74,331,  2556,2557,2558,  0,0
	dc.w 331,74,73,  2559,2560,2561,  0,0
	dc.w 65,473,333,  2562,2563,2564,  0,0
	dc.w 74,333,332,  2565,2566,2567,  0,0
	dc.w 65,333,74,  2568,2569,2570,  0,0
	dc.w 454,65,74,  2571,2572,2573,  0,0
	dc.w 124,172,442,  2574,2575,2576,  0,0
	dc.w 75,173,124,  2577,2578,2579,  0,0
	dc.w 173,172,124,  2580,2581,2582,  0,0
	dc.w 61,76,463,  2583,2584,2585,  0,0
	dc.w 76,174,463,  2586,2587,2588,  0,0
	dc.w 463,174,175,  2589,2590,2591,  0,0
	dc.w 458,76,61,  2592,2593,2594,  0,0
	dc.w 75,77,173,  2595,2596,2597,  0,0
	dc.w 124,218,174,  2598,2599,2600,  0,0
	dc.w 75,174,77,  2601,2602,2603,  0,0
	dc.w 75,124,174,  2604,2605,2606,  0,0
	dc.w 173,76,458,  2607,2608,2609,  0,0
	dc.w 173,77,76,  2610,2611,2612,  0,0
	dc.w 77,174,76,  2613,2614,2615,  0,0
	dc.w 248,122,241,  2616,2617,2618,  0,0
	dc.w 409,241,122,  2619,2620,2621,  0,0
	dc.w 78,401,79,  2622,2623,2624,  0,0
	dc.w 236,79,239,  2625,2626,2627,  0,0
	dc.w 236,78,79,  2628,2629,2630,  0,0
	dc.w 233,110,375,  2631,2632,2633,  0,0
	dc.w 236,247,80,  2634,2635,2636,  0,0
	dc.w 236,80,78,  2637,2638,2639,  0,0
	dc.w 78,80,401,  2640,2641,2642,  0,0
	dc.w 374,110,233,  2643,2644,2645,  0,0
	dc.w 243,123,379,  2646,2647,2648,  0,0
	dc.w 81,239,82,  2649,2650,2651,  0,0
	dc.w 81,345,109,  2652,2653,2654,  0,0
	dc.w 81,82,345,  2655,2656,2657,  0,0
	dc.w 376,383,83,  2658,2659,2660,  0,0
	dc.w 83,383,84,  2661,2662,2663,  0,0
	dc.w 83,84,406,  2664,2665,2666,  0,0
	dc.w 125,122,384,  2667,2668,2669,  0,0
	dc.w 409,122,125,  2670,2671,2672,  0,0
	dc.w 85,86,475,  2673,2674,2675,  0,0
	dc.w 86,247,475,  2676,2677,2678,  0,0
	dc.w 380,86,85,  2679,2680,2681,  0,0
	dc.w 86,401,80,  2682,2683,2684,  0,0
	dc.w 380,401,86,  2685,2686,2687,  0,0
	dc.w 86,80,247,  2688,2689,2690,  0,0
	dc.w 110,111,375,  2691,2692,2693,  0,0
	dc.w 376,83,87,  2694,2695,2696,  0,0
	dc.w 381,376,87,  2697,2698,2699,  0,0
	dc.w 87,83,406,  2700,2701,2702,  0,0
	dc.w 389,87,406,  2703,2704,2705,  0,0
	dc.w 88,87,389,  2706,2707,2708,  0,0
	dc.w 381,87,88,  2709,2710,2711,  0,0
	dc.w 82,79,345,  2712,2713,2714,  0,0
	dc.w 79,401,345,  2715,2716,2717,  0,0
	dc.w 239,79,82,  2718,2719,2720,  0,0
	dc.w 89,123,388,  2721,2722,2723,  0,0
	dc.w 379,123,89,  2724,2725,2726,  0,0
	dc.w 382,379,90,  2727,2728,2729,  0,0
	dc.w 90,379,91,  2730,2731,2732,  0,0
	dc.w 90,91,387,  2733,2734,2735,  0,0
	dc.w 381,88,92,  2736,2737,2738,  0,0
	dc.w 385,381,92,  2739,2740,2741,  0,0
	dc.w 92,88,389,  2742,2743,2744,  0,0
	dc.w 90,387,93,  2745,2746,2747,  0,0
	dc.w 382,90,383,  2748,2749,2750,  0,0
	dc.w 383,90,93,  2751,2752,2753,  0,0
	dc.w 84,93,406,  2754,2755,2756,  0,0
	dc.w 406,93,387,  2757,2758,2759,  0,0
	dc.w 383,93,84,  2760,2761,2762,  0,0
	dc.w 91,379,89,  2763,2764,2765,  0,0
	dc.w 387,91,388,  2766,2767,2768,  0,0
	dc.w 91,89,388,  2769,2770,2771,  0,0
	dc.w 113,392,94,  2772,2773,2774,  0,0
	dc.w 113,94,242,  2775,2776,2777,  0,0
	dc.w 95,393,121,  2778,2779,2780,  0,0
	dc.w 386,95,121,  2781,2782,2783,  0,0
	dc.w 248,121,122,  2784,2785,2786,  0,0
	dc.w 96,398,110,  2787,2788,2789,  0,0
	dc.w 374,96,110,  2790,2791,2792,  0,0
	dc.w 402,111,110,  2793,2794,2795,  0,0
	dc.w 402,408,111,  2796,2797,2798,  0,0
	dc.w 120,92,391,  2799,2800,2801,  0,0
	dc.w 92,389,391,  2802,2803,2804,  0,0
	dc.w 385,92,120,  2805,2806,2807,  0,0
	dc.w 394,121,393,  2808,2809,2810,  0,0
	dc.w 122,121,394,  2811,2812,2813,  0,0
	dc.w 120,391,399,  2814,2815,2816,  0,0
	dc.w 120,399,115,  2817,2818,2819,  0,0
	dc.w 408,113,111,  2820,2821,2822,  0,0
	dc.w 125,384,396,  2823,2824,2825,  0,0
	dc.w 403,392,113,  2826,2827,2828,  0,0
	dc.w 403,113,408,  2829,2830,2831,  0,0
	dc.w 97,396,370,  2832,2833,2834,  0,0
	dc.w 97,125,396,  2835,2836,2837,  0,0
	dc.w 409,125,97,  2838,2839,2840,  0,0
	dc.w 99,98,309,  2841,2842,2843,  0,0
	dc.w 98,374,309,  2844,2845,2846,  0,0
	dc.w 99,109,98,  2847,2848,2849,  0,0
	dc.w 81,109,99,  2850,2851,2852,  0,0
	dc.w 81,309,239,  2853,2854,2855,  0,0
	dc.w 81,99,309,  2856,2857,2858,  0,0
	dc.w 98,398,96,  2859,2860,2861,  0,0
	dc.w 98,109,398,  2862,2863,2864,  0,0
	dc.w 98,96,374,  2865,2866,2867,  0,0
	dc.w 243,137,123,  2868,2869,2870,  0,0
	dc.w 137,138,123,  2871,2872,2873,  0,0
	dc.w 100,123,138,  2874,2875,2876,  0,0
	dc.w 139,123,100,  2877,2878,2879,  0,0
	dc.w 94,100,242,  2880,2881,2882,  0,0
	dc.w 242,100,138,  2883,2884,2885,  0,0
	dc.w 392,139,94,  2886,2887,2888,  0,0
	dc.w 94,139,100,  2889,2890,2891,  0,0
	dc.w 101,120,115,  2892,2893,2894,  0,0
	dc.w 19,385,101,  2895,2896,2897,  0,0
	dc.w 385,120,101,  2898,2899,2900,  0,0
	dc.w 386,19,102,  2901,2902,2903,  0,0
	dc.w 19,101,102,  2904,2905,2906,  0,0
	dc.w 102,101,115,  2907,2908,2909,  0,0
	dc.w 95,102,393,  2910,2911,2912,  0,0
	dc.w 102,115,393,  2913,2914,2915,  0,0
	dc.w 386,102,95,  2916,2917,2918,  0,0
	dc.w 217,469,468,  2919,2920,2921,  0,0
	dc.w 469,124,468,  2922,2923,2924,  0,0
tcoords_land:				;u,v
	dc.s	0.583375,-0.000000
	dc.s	0.630959,0.005996
	dc.s	0.607375,-0.000000
	dc.s	0.607375,-0.000000
	dc.s	0.630959,0.005996
	dc.s	0.669625,-0.000000
	dc.s	0.630959,0.005996
	dc.s	0.680655,0.031418
	dc.s	0.669625,-0.000000
	dc.s	0.680655,0.031418
	dc.s	0.689875,-0.000000
	dc.s	0.669625,-0.000000
	dc.s	0.680655,0.031418
	dc.s	0.721875,-0.000000
	dc.s	0.689875,-0.000000
	dc.s	0.980750,-0.000000
	dc.s	0.894250,-0.000000
	dc.s	0.913962,0.037440
	dc.s	1.000000,0.031375
	dc.s	0.980750,-0.000000
	dc.s	0.913962,0.037440
	dc.s	0.250125,-0.000000
	dc.s	0.250000,0.136397
	dc.s	0.391250,-0.000000
	dc.s	0.535375,-0.000000
	dc.s	0.560209,0.009926
	dc.s	0.583375,-0.000000
	dc.s	0.100375,-0.000000
	dc.s	-0.000000,-0.000000
	dc.s	0.084607,0.037440
	dc.s	0.615373,0.050364
	dc.s	0.630959,0.005996
	dc.s	0.583375,-0.000000
	dc.s	0.894250,-0.000000
	dc.s	0.827500,-0.000000
	dc.s	0.831420,0.033510
	dc.s	0.560209,0.009926
	dc.s	0.615373,0.050364
	dc.s	0.583375,-0.000000
	dc.s	1.000000,0.031375
	dc.s	0.913962,0.037440
	dc.s	0.932041,0.060694
	dc.s	0.560209,0.009926
	dc.s	0.578451,0.066285
	dc.s	0.615373,0.050364
	dc.s	0.831420,0.033510
	dc.s	0.827500,-0.000000
	dc.s	0.779000,-0.000000
	dc.s	0.894250,-0.000000
	dc.s	0.831420,0.033510
	dc.s	0.870726,0.053163
	dc.s	0.147725,0.058433
	dc.s	0.100375,-0.000000
	dc.s	0.117737,0.084689
	dc.s	0.615373,0.050364
	dc.s	0.680655,0.031418
	dc.s	0.630959,0.005996
	dc.s	0.100375,-0.000000
	dc.s	0.084607,0.037440
	dc.s	0.117737,0.084689
	dc.s	0.454375,-0.000000
	dc.s	0.391250,-0.000000
	dc.s	0.367556,0.146433
	dc.s	0.693240,0.071713
	dc.s	0.744947,0.057093
	dc.s	0.680655,0.031418
	dc.s	0.831420,0.033510
	dc.s	0.779000,-0.000000
	dc.s	0.761076,0.042619
	dc.s	0.505181,0.068885
	dc.s	0.578451,0.066285
	dc.s	0.535375,-0.000000
	dc.s	0.535375,-0.000000
	dc.s	0.578451,0.066285
	dc.s	0.560209,0.009926
	dc.s	0.913962,0.037440
	dc.s	0.894250,-0.000000
	dc.s	0.870726,0.053163
	dc.s	0.520239,0.122439
	dc.s	0.578451,0.066285
	dc.s	0.505181,0.068885
	dc.s	0.659216,0.067687
	dc.s	0.693240,0.071713
	dc.s	0.680655,0.031418
	dc.s	0.870726,0.053163
	dc.s	0.831420,0.033510
	dc.s	0.803423,0.056065
	dc.s	0.250000,0.136397
	dc.s	0.334222,0.114138
	dc.s	0.391250,-0.000000
	dc.s	0.831420,0.033510
	dc.s	0.761076,0.042619
	dc.s	0.803423,0.056065
	dc.s	0.117737,0.084689
	dc.s	0.084607,0.037440
	dc.s	-0.000000,-0.000000
	dc.s	0.454375,-0.000000
	dc.s	0.367556,0.146433
	dc.s	0.476809,0.066973
	dc.s	0.615373,0.050364
	dc.s	0.659216,0.067687
	dc.s	0.680655,0.031418
	dc.s	0.803423,0.056065
	dc.s	0.761076,0.042619
	dc.s	0.764600,0.096399
	dc.s	0.391250,-0.000000
	dc.s	0.334222,0.114138
	dc.s	0.367556,0.146433
	dc.s	1.000000,0.031375
	dc.s	0.932041,0.060694
	dc.s	0.943992,0.077833
	dc.s	0.117737,0.084689
	dc.s	-0.000000,-0.000000
	dc.s	-0.000000,0.090375
	dc.s	0.598753,0.120027
	dc.s	0.659216,0.067687
	dc.s	0.615373,0.050364
	dc.s	0.598753,0.120027
	dc.s	0.615373,0.050364
	dc.s	0.578451,0.066285
	dc.s	0.598753,0.120027
	dc.s	0.638821,0.096399
	dc.s	0.659216,0.067687
	dc.s	0.761076,0.042619
	dc.s	0.756087,0.118224
	dc.s	0.764600,0.096399
	dc.s	0.849757,0.115869
	dc.s	0.870726,0.053163
	dc.s	0.803423,0.056065
	dc.s	1.000000,0.080625
	dc.s	1.000000,0.031375
	dc.s	0.943992,0.077833
	dc.s	0.849757,0.115869
	dc.s	0.803423,0.056065
	dc.s	0.764600,0.096399
	dc.s	0.894309,0.100330
	dc.s	0.870726,0.053163
	dc.s	0.849757,0.115869
	dc.s	0.894309,0.100330
	dc.s	0.913962,0.037440
	dc.s	0.870726,0.053163
	dc.s	0.932041,0.060694
	dc.s	0.913962,0.037440
	dc.s	0.894309,0.100330
	dc.s	0.693240,0.071713
	dc.s	0.717432,0.104260
	dc.s	0.744947,0.057093
	dc.s	0.849757,0.115869
	dc.s	0.764600,0.096399
	dc.s	0.803905,0.112122
	dc.s	0.932312,0.123541
	dc.s	0.943992,0.077833
	dc.s	0.932041,0.060694
	dc.s	0.147725,0.058433
	dc.s	0.117737,0.084689
	dc.s	0.143619,0.142435
	dc.s	0.520239,0.122439
	dc.s	0.554457,0.135066
	dc.s	0.578451,0.066285
	dc.s	0.932312,0.123541
	dc.s	0.932041,0.060694
	dc.s	0.894309,0.100330
	dc.s	0.147725,0.058433
	dc.s	0.143619,0.142435
	dc.s	0.168735,0.146087
	dc.s	0.598753,0.120027
	dc.s	0.630959,0.119983
	dc.s	0.638821,0.096399
	dc.s	1.000000,0.132375
	dc.s	1.000000,0.080625
	dc.s	0.943992,0.077833
	dc.s	0.554457,0.135066
	dc.s	0.598753,0.120027
	dc.s	0.578451,0.066285
	dc.s	0.638821,0.096399
	dc.s	0.687752,0.130712
	dc.s	0.659216,0.067687
	dc.s	0.659216,0.067687
	dc.s	0.687752,0.130712
	dc.s	0.693240,0.071713
	dc.s	0.803905,0.112122
	dc.s	0.764600,0.096399
	dc.s	0.766159,0.131438
	dc.s	1.000000,0.132375
	dc.s	0.943992,0.077833
	dc.s	0.932312,0.123541
	dc.s	0.693240,0.071713
	dc.s	0.687752,0.130712
	dc.s	0.717432,0.104260
	dc.s	0.666505,0.156652
	dc.s	0.687752,0.130712
	dc.s	0.638821,0.096399
	dc.s	0.764600,0.096399
	dc.s	0.756087,0.118224
	dc.s	0.766159,0.131438
	dc.s	0.883559,0.152553
	dc.s	0.894309,0.100330
	dc.s	0.849757,0.115869
	dc.s	0.932312,0.123541
	dc.s	0.894309,0.100330
	dc.s	0.883559,0.152553
	dc.s	0.803905,0.112122
	dc.s	0.766159,0.131438
	dc.s	0.805147,0.148849
	dc.s	0.117737,0.084689
	dc.s	-0.000000,0.090375
	dc.s	-0.000000,0.202125
	dc.s	0.336165,0.159289
	dc.s	0.367556,0.146433
	dc.s	0.334222,0.114138
	dc.s	0.849757,0.115869
	dc.s	0.803905,0.112122
	dc.s	0.805147,0.148849
	dc.s	1.000000,0.132375
	dc.s	0.932312,0.123541
	dc.s	0.949337,0.182872
	dc.s	0.630959,0.119983
	dc.s	0.666505,0.156652
	dc.s	0.638821,0.096399
	dc.s	0.250000,0.136397
	dc.s	0.336165,0.159289
	dc.s	0.334222,0.114138
	dc.s	0.633531,0.182688
	dc.s	0.666505,0.156652
	dc.s	0.630959,0.119983
	dc.s	1.000000,0.132375
	dc.s	0.949337,0.182872
	dc.s	1.000000,0.190750
	dc.s	0.414889,0.183139
	dc.s	0.476809,0.066973
	dc.s	0.367556,0.146433
	dc.s	0.117737,0.084689
	dc.s	-0.000000,0.202125
	dc.s	0.143619,0.142435
	dc.s	0.414889,0.183139
	dc.s	0.467140,0.139636
	dc.s	0.476809,0.066973
	dc.s	0.883559,0.152553
	dc.s	0.849757,0.115869
	dc.s	0.805147,0.148849
	dc.s	0.633531,0.182688
	dc.s	0.630959,0.119983
	dc.s	0.598753,0.120027
	dc.s	0.883559,0.152553
	dc.s	0.805147,0.148849
	dc.s	0.823558,0.182872
	dc.s	0.932312,0.123541
	dc.s	0.883559,0.152553
	dc.s	0.893316,0.187150
	dc.s	0.805147,0.148849
	dc.s	0.766159,0.131438
	dc.s	0.760669,0.171080
	dc.s	0.805147,0.148849
	dc.s	0.760669,0.171080
	dc.s	0.798160,0.198018
	dc.s	0.614174,0.200724
	dc.s	0.633531,0.182688
	dc.s	0.598753,0.120027
	dc.s	0.823558,0.182872
	dc.s	0.805147,0.148849
	dc.s	0.798160,0.198018
	dc.s	0.336165,0.159289
	dc.s	0.321486,0.250000
	dc.s	0.367556,0.146433
	dc.s	0.633531,0.182688
	dc.s	0.711351,0.180186
	dc.s	0.666505,0.156652
	dc.s	0.893316,0.187150
	dc.s	0.883559,0.152553
	dc.s	0.823558,0.182872
	dc.s	0.614174,0.200724
	dc.s	0.598753,0.120027
	dc.s	0.554457,0.135066
	dc.s	0.761078,0.250000
	dc.s	0.798160,0.198018
	dc.s	0.760669,0.171080
	dc.s	0.414889,0.183139
	dc.s	0.367556,0.146433
	dc.s	0.321486,0.250000
	dc.s	0.614174,0.200724
	dc.s	0.554457,0.135066
	dc.s	0.527325,0.250000
	dc.s	1.000000,0.190750
	dc.s	0.949337,0.182872
	dc.s	0.965224,0.201180
	dc.s	0.917893,0.198595
	dc.s	0.932312,0.123541
	dc.s	0.893316,0.187150
	dc.s	0.633531,0.182688
	dc.s	0.667979,0.227214
	dc.s	0.711351,0.180186
	dc.s	0.667979,0.227214
	dc.s	0.742677,0.210696
	dc.s	0.711351,0.180186
	dc.s	0.949337,0.182872
	dc.s	0.932312,0.123541
	dc.s	0.917893,0.198595
	dc.s	0.893316,0.187150
	dc.s	0.823558,0.182872
	dc.s	0.798160,0.198018
	dc.s	0.414889,0.183139
	dc.s	0.474748,0.222474
	dc.s	0.467140,0.139636
	dc.s	0.893316,0.187150
	dc.s	0.798160,0.198018
	dc.s	0.857304,0.250000
	dc.s	0.917893,0.198595
	dc.s	0.893316,0.187150
	dc.s	0.882517,0.237900
	dc.s	0.965224,0.201180
	dc.s	0.949337,0.182872
	dc.s	0.917893,0.198595
	dc.s	0.893316,0.187150
	dc.s	0.857304,0.250000
	dc.s	0.882517,0.237900
	dc.s	1.000000,0.190750
	dc.s	0.965224,0.201180
	dc.s	0.976851,0.226109
	dc.s	1.000000,0.230000
	dc.s	1.000000,0.190750
	dc.s	0.976851,0.226109
	dc.s	0.965224,0.201180
	dc.s	0.917893,0.198595
	dc.s	0.929684,0.237900
	dc.s	0.929684,0.237900
	dc.s	0.917893,0.198595
	dc.s	0.882517,0.237900
	dc.s	0.957953,0.250000
	dc.s	0.965224,0.201180
	dc.s	0.929684,0.237900
	dc.s	0.929684,0.237900
	dc.s	0.882517,0.237900
	dc.s	0.857304,0.250000
	dc.s	0.957953,0.250000
	dc.s	0.976851,0.226109
	dc.s	0.965224,0.201180
	dc.s	1.000000,0.250000
	dc.s	1.000000,0.230000
	dc.s	0.976851,0.226109
	dc.s	1.000000,0.250000
	dc.s	0.976851,0.226109
	dc.s	0.957953,0.250000
	dc.s	0.626507,0.256284
	dc.s	0.662746,0.286287
	dc.s	0.697780,0.257553
	dc.s	0.696338,0.275562
	dc.s	0.697780,0.257553
	dc.s	0.662746,0.286287
	dc.s	0.626507,0.256284
	dc.s	0.595584,0.261484
	dc.s	0.630768,0.312020
	dc.s	0.626507,0.256284
	dc.s	0.653688,0.316697
	dc.s	0.662746,0.286287
	dc.s	0.524834,0.304720
	dc.s	0.566908,0.314308
	dc.s	0.595584,0.261484
	dc.s	0.566908,0.314308
	dc.s	0.630768,0.312020
	dc.s	0.595584,0.261484
	dc.s	0.626507,0.256284
	dc.s	0.630768,0.312020
	dc.s	0.653688,0.316697
	dc.s	0.824241,0.333733
	dc.s	0.851073,0.277206
	dc.s	0.796044,0.324373
	dc.s	0.855003,0.320443
	dc.s	0.892516,0.313286
	dc.s	0.851073,0.277206
	dc.s	0.170249,0.280219
	dc.s	0.034037,0.299243
	dc.s	0.076746,0.336165
	dc.s	0.930338,0.257163
	dc.s	0.892516,0.313286
	dc.s	0.956610,0.312418
	dc.s	0.566908,0.314308
	dc.s	0.587128,0.335486
	dc.s	0.630768,0.312020
	dc.s	0.693849,0.320443
	dc.s	0.696338,0.275562
	dc.s	0.662746,0.286287
	dc.s	0.034037,0.299243
	dc.s	-0.000000,0.276000
	dc.s	-0.000000,0.435250
	dc.s	0.362481,0.313765
	dc.s	0.250000,0.288067
	dc.s	0.280698,0.373096
	dc.s	0.824241,0.333733
	dc.s	0.855003,0.320443
	dc.s	0.851073,0.277206
	dc.s	1.000000,0.285125
	dc.s	0.956610,0.312418
	dc.s	1.000000,0.322125
	dc.s	0.693849,0.320443
	dc.s	0.662746,0.286287
	dc.s	0.653688,0.316697
	dc.s	0.693849,0.320443
	dc.s	0.737085,0.304720
	dc.s	0.696338,0.275562
	dc.s	0.693849,0.320443
	dc.s	0.732103,0.359966
	dc.s	0.737085,0.304720
	dc.s	0.362481,0.313765
	dc.s	0.388088,0.384685
	dc.s	0.467892,0.290619
	dc.s	0.653688,0.316697
	dc.s	0.630768,0.312020
	dc.s	0.634890,0.336165
	dc.s	0.524834,0.304720
	dc.s	0.532695,0.340096
	dc.s	0.566908,0.314308
	dc.s	0.587128,0.335486
	dc.s	0.634890,0.336165
	dc.s	0.630768,0.312020
	dc.s	0.843211,0.383332
	dc.s	0.855003,0.320443
	dc.s	0.824241,0.333733
	dc.s	0.072739,0.410537
	dc.s	0.170249,0.280219
	dc.s	0.076746,0.336165
	dc.s	0.464236,0.370390
	dc.s	0.467892,0.290619
	dc.s	0.388088,0.384685
	dc.s	0.524834,0.304720
	dc.s	0.513042,0.363679
	dc.s	0.532695,0.340096
	dc.s	0.878286,0.371195
	dc.s	0.892516,0.313286
	dc.s	0.855003,0.320443
	dc.s	0.956610,0.312418
	dc.s	0.892516,0.313286
	dc.s	0.906101,0.355818
	dc.s	0.362481,0.313765
	dc.s	0.280698,0.373096
	dc.s	0.388088,0.384685
	dc.s	1.000000,0.322125
	dc.s	0.956610,0.312418
	dc.s	0.955081,0.372183
	dc.s	0.566908,0.314308
	dc.s	0.556365,0.381606
	dc.s	0.587128,0.335486
	dc.s	0.693849,0.320443
	dc.s	0.653688,0.316697
	dc.s	0.693849,0.367610
	dc.s	0.693849,0.320443
	dc.s	0.693849,0.367610
	dc.s	0.732103,0.359966
	dc.s	0.566908,0.314308
	dc.s	0.532695,0.340096
	dc.s	0.556365,0.381606
	dc.s	0.653688,0.316697
	dc.s	0.634890,0.336165
	dc.s	0.635640,0.379486
	dc.s	0.693849,0.367610
	dc.s	0.653688,0.316697
	dc.s	0.678127,0.383332
	dc.s	0.843211,0.383332
	dc.s	0.878286,0.371195
	dc.s	0.855003,0.320443
	dc.s	1.000000,0.322125
	dc.s	0.955081,0.372183
	dc.s	1.000000,0.367625
	dc.s	0.587128,0.335486
	dc.s	0.635640,0.379486
	dc.s	0.634890,0.336165
	dc.s	0.955081,0.372183
	dc.s	0.956610,0.312418
	dc.s	0.906101,0.355818
	dc.s	0.653688,0.316697
	dc.s	0.635640,0.379486
	dc.s	0.678127,0.383332
	dc.s	0.906101,0.355818
	dc.s	0.892516,0.313286
	dc.s	0.878286,0.371195
	dc.s	0.072739,0.410537
	dc.s	0.076746,0.336165
	dc.s	0.034037,0.299243
	dc.s	0.072739,0.410537
	dc.s	0.180982,0.398914
	dc.s	0.170249,0.280219
	dc.s	0.799975,0.383332
	dc.s	0.824241,0.333733
	dc.s	0.796044,0.324373
	dc.s	0.513042,0.363679
	dc.s	0.556365,0.381606
	dc.s	0.532695,0.340096
	dc.s	0.712058,0.397450
	dc.s	0.732103,0.359966
	dc.s	0.693849,0.367610
	dc.s	0.955081,0.372183
	dc.s	0.906101,0.355818
	dc.s	0.918692,0.411295
	dc.s	0.799975,0.383332
	dc.s	0.843211,0.383332
	dc.s	0.824241,0.333733
	dc.s	0.587128,0.335486
	dc.s	0.556365,0.381606
	dc.s	0.635640,0.379486
	dc.s	0.712058,0.397450
	dc.s	0.693849,0.367610
	dc.s	0.678127,0.383332
	dc.s	0.955081,0.372183
	dc.s	0.918692,0.411295
	dc.s	0.945407,0.414777
	dc.s	0.464236,0.370390
	dc.s	0.388088,0.384685
	dc.s	0.416680,0.437330
	dc.s	0.513042,0.363679
	dc.s	0.543832,0.415161
	dc.s	0.556365,0.381606
	dc.s	0.918692,0.411295
	dc.s	0.906101,0.355818
	dc.s	0.878286,0.371195
	dc.s	0.556365,0.381606
	dc.s	0.604360,0.414524
	dc.s	0.635640,0.379486
	dc.s	1.000000,0.410875
	dc.s	1.000000,0.367625
	dc.s	0.955081,0.372183
	dc.s	0.072739,0.410537
	dc.s	0.034037,0.299243
	dc.s	-0.000000,0.435250
	dc.s	0.572657,0.420676
	dc.s	0.604360,0.414524
	dc.s	0.556365,0.381606
	dc.s	0.625331,0.446074
	dc.s	0.678127,0.383332
	dc.s	0.635640,0.379486
	dc.s	0.858934,0.406916
	dc.s	0.878286,0.371195
	dc.s	0.843211,0.383332
	dc.s	0.543832,0.415161
	dc.s	0.572657,0.420676
	dc.s	0.556365,0.381606
	dc.s	0.821432,0.448660
	dc.s	0.843211,0.383332
	dc.s	0.799975,0.383332
	dc.s	0.821432,0.448660
	dc.s	0.858934,0.406916
	dc.s	0.843211,0.383332
	dc.s	0.807632,0.466435
	dc.s	0.821432,0.448660
	dc.s	0.799975,0.383332
	dc.s	0.871303,0.441389
	dc.s	0.878286,0.371195
	dc.s	0.858934,0.406916
	dc.s	1.000000,0.410875
	dc.s	0.955081,0.372183
	dc.s	0.945407,0.414777
	dc.s	0.336942,0.450200
	dc.s	0.416680,0.437330
	dc.s	0.388088,0.384685
	dc.s	0.666335,0.430499
	dc.s	0.678127,0.383332
	dc.s	0.625331,0.446074
	dc.s	0.666335,0.430499
	dc.s	0.712058,0.397450
	dc.s	0.678127,0.383332
	dc.s	0.250000,0.444449
	dc.s	0.180982,0.398914
	dc.s	0.106394,0.467046
	dc.s	0.708329,0.457982
	dc.s	0.712058,0.397450
	dc.s	0.666335,0.430499
	dc.s	0.807632,0.466435
	dc.s	0.799975,0.383332
	dc.s	0.756738,0.383332
	dc.s	0.072739,0.410537
	dc.s	0.106394,0.467046
	dc.s	0.180982,0.398914
	dc.s	0.821432,0.448660
	dc.s	0.871303,0.441389
	dc.s	0.858934,0.406916
	dc.s	0.871303,0.441389
	dc.s	0.918692,0.411295
	dc.s	0.878286,0.371195
	dc.s	1.000000,0.410875
	dc.s	0.945407,0.414777
	dc.s	0.950851,0.443341
	dc.s	0.945407,0.414777
	dc.s	0.918692,0.411295
	dc.s	0.913962,0.438361
	dc.s	0.625331,0.446074
	dc.s	0.635640,0.379486
	dc.s	0.604360,0.414524
	dc.s	0.871303,0.441389
	dc.s	0.913962,0.438361
	dc.s	0.918692,0.411295
	dc.s	0.250000,0.444449
	dc.s	0.106394,0.467046
	dc.s	0.111544,0.500000
	dc.s	0.336942,0.450200
	dc.s	0.388088,0.384685
	dc.s	0.280698,0.373096
	dc.s	0.560209,0.461944
	dc.s	0.572657,0.420676
	dc.s	0.543832,0.415161
	dc.s	0.572657,0.420676
	dc.s	0.625331,0.446074
	dc.s	0.604360,0.414524
	dc.s	0.708329,0.457982
	dc.s	0.734601,0.421598
	dc.s	0.712058,0.397450
	dc.s	1.000000,0.410875
	dc.s	0.950851,0.443341
	dc.s	1.000000,0.438375
	dc.s	0.945407,0.414777
	dc.s	0.913962,0.438361
	dc.s	0.950851,0.443341
	dc.s	0.560209,0.461944
	dc.s	0.625331,0.446074
	dc.s	0.572657,0.420676
	dc.s	0.560209,0.461944
	dc.s	0.543832,0.415161
	dc.s	0.516062,0.481520
	dc.s	0.708329,0.457982
	dc.s	0.666335,0.430499
	dc.s	0.625331,0.446074
	dc.s	0.874949,0.487014
	dc.s	0.913962,0.438361
	dc.s	0.871303,0.441389
	dc.s	1.000000,0.438375
	dc.s	0.950851,0.443341
	dc.s	0.957199,0.486281
	dc.s	0.807632,0.466435
	dc.s	0.871303,0.441389
	dc.s	0.821432,0.448660
	dc.s	0.560209,0.461944
	dc.s	0.564139,0.489458
	dc.s	0.625331,0.446074
	dc.s	1.000000,0.438375
	dc.s	0.957199,0.486281
	dc.s	1.000000,0.472750
	dc.s	0.336942,0.450200
	dc.s	0.459705,0.489371
	dc.s	0.416680,0.437330
	dc.s	0.874949,0.487014
	dc.s	0.950851,0.443341
	dc.s	0.913962,0.438361
	dc.s	0.807632,0.466435
	dc.s	0.874949,0.487014
	dc.s	0.871303,0.441389
	dc.s	0.560209,0.461944
	dc.s	0.516062,0.481520
	dc.s	0.564139,0.489458
	dc.s	0.726216,0.500000
	dc.s	0.605307,0.510028
	dc.s	0.630959,0.544487
	dc.s	0.147512,0.555928
	dc.s	0.235757,0.529288
	dc.s	0.172511,0.500000
	dc.s	0.630959,0.544487
	dc.s	0.605307,0.510028
	dc.s	0.556902,0.566282
	dc.s	0.210062,0.622865
	dc.s	0.235757,0.529288
	dc.s	0.181013,0.596855
	dc.s	0.062110,0.588163
	dc.s	0.058326,0.500000
	dc.s	-0.000000,0.564125
	dc.s	0.630959,0.544487
	dc.s	0.556902,0.566282
	dc.s	0.591654,0.583792
	dc.s	0.903417,0.544376
	dc.s	0.935047,0.571599
	dc.s	0.955128,0.540065
	dc.s	0.147512,0.555928
	dc.s	0.181013,0.596855
	dc.s	0.235757,0.529288
	dc.s	0.341750,0.616634
	dc.s	0.434239,0.564378
	dc.s	0.380063,0.537385
	dc.s	0.556902,0.566282
	dc.s	0.505181,0.536625
	dc.s	0.500452,0.579787
	dc.s	0.726216,0.500000
	dc.s	0.674196,0.540806
	dc.s	0.729417,0.592179
	dc.s	0.903417,0.544376
	dc.s	0.849467,0.534238
	dc.s	0.827355,0.628039
	dc.s	0.341750,0.616634
	dc.s	0.380063,0.537385
	dc.s	0.302002,0.580719
	dc.s	0.630959,0.544487
	dc.s	0.591654,0.583792
	dc.s	0.599592,0.599541
	dc.s	0.556902,0.566282
	dc.s	0.533645,0.601988
	dc.s	0.591654,0.583792
	dc.s	0.147512,0.555928
	dc.s	0.062110,0.588163
	dc.s	0.181013,0.596855
	dc.s	0.666335,0.599515
	dc.s	0.674196,0.540806
	dc.s	0.599592,0.599541
	dc.s	0.666335,0.599515
	dc.s	0.729417,0.592179
	dc.s	0.674196,0.540806
	dc.s	0.062110,0.588163
	dc.s	-0.000000,0.564125
	dc.s	-0.000000,0.689875
	dc.s	0.599592,0.599541
	dc.s	0.591654,0.583792
	dc.s	0.574329,0.628251
	dc.s	0.062110,0.588163
	dc.s	-0.000000,0.689875
	dc.s	0.055792,0.695557
	dc.s	0.062110,0.588163
	dc.s	0.119983,0.646682
	dc.s	0.181013,0.596855
	dc.s	0.591654,0.583792
	dc.s	0.533645,0.601988
	dc.s	0.574329,0.628251
	dc.s	0.903417,0.544376
	dc.s	0.911669,0.645032
	dc.s	0.935047,0.571599
	dc.s	0.556902,0.566282
	dc.s	0.500452,0.579787
	dc.s	0.533645,0.601988
	dc.s	0.341750,0.616634
	dc.s	0.377936,0.665109
	dc.s	0.434239,0.564378
	dc.s	0.599592,0.599541
	dc.s	0.574329,0.628251
	dc.s	0.626937,0.638349
	dc.s	0.666335,0.599515
	dc.s	0.599592,0.599541
	dc.s	0.626937,0.638349
	dc.s	0.666335,0.599515
	dc.s	0.669409,0.633333
	dc.s	0.729417,0.592179
	dc.s	0.210062,0.622865
	dc.s	0.181013,0.596855
	dc.s	0.119983,0.646682
	dc.s	0.500452,0.579787
	dc.s	0.505181,0.619168
	dc.s	0.533645,0.601988
	dc.s	0.434239,0.564378
	dc.s	0.377936,0.665109
	dc.s	0.415134,0.629912
	dc.s	0.666335,0.599515
	dc.s	0.626937,0.638349
	dc.s	0.669409,0.633333
	dc.s	0.729417,0.592179
	dc.s	0.669409,0.633333
	dc.s	0.702025,0.657923
	dc.s	0.341750,0.616634
	dc.s	0.302002,0.580719
	dc.s	0.285832,0.678337
	dc.s	0.903417,0.544376
	dc.s	0.827355,0.628039
	dc.s	0.911669,0.645032
	dc.s	0.062110,0.588163
	dc.s	0.055792,0.695557
	dc.s	0.119983,0.646682
	dc.s	0.210062,0.622865
	dc.s	0.119983,0.646682
	dc.s	0.146817,0.701694
	dc.s	0.377936,0.665109
	dc.s	0.387263,0.646682
	dc.s	0.415134,0.629912
	dc.s	0.574329,0.628251
	dc.s	0.533645,0.601988
	dc.s	0.525375,0.699662
	dc.s	0.080823,0.703588
	dc.s	0.119983,0.646682
	dc.s	0.055792,0.695557
	dc.s	0.911669,0.645032
	dc.s	0.976851,0.689918
	dc.s	1.000000,0.633625
	dc.s	0.415134,0.629912
	dc.s	0.387263,0.646682
	dc.s	0.414777,0.670265
	dc.s	0.626937,0.638349
	dc.s	0.574329,0.628251
	dc.s	0.619584,0.683387
	dc.s	0.377936,0.665109
	dc.s	0.414777,0.670265
	dc.s	0.387263,0.646682
	dc.s	0.415134,0.629912
	dc.s	0.414777,0.670265
	dc.s	0.434354,0.653518
	dc.s	0.702025,0.657923
	dc.s	0.669409,0.633333
	dc.s	0.619584,0.683387
	dc.s	0.827355,0.628039
	dc.s	0.763653,0.688540
	dc.s	0.826219,0.686748
	dc.s	0.669409,0.633333
	dc.s	0.626937,0.638349
	dc.s	0.619584,0.683387
	dc.s	0.911669,0.645032
	dc.s	0.827355,0.628039
	dc.s	0.826219,0.686748
	dc.s	0.080823,0.703588
	dc.s	0.146817,0.701694
	dc.s	0.119983,0.646682
	dc.s	0.341750,0.616634
	dc.s	0.344026,0.697780
	dc.s	0.377936,0.665109
	dc.s	0.533645,0.601988
	dc.s	0.505181,0.619168
	dc.s	0.525375,0.699662
	dc.s	0.702025,0.657923
	dc.s	0.619584,0.683387
	dc.s	0.697951,0.680365
	dc.s	0.341750,0.616634
	dc.s	0.285832,0.678337
	dc.s	0.344026,0.697780
	dc.s	0.574329,0.628251
	dc.s	0.525375,0.699662
	dc.s	0.572001,0.701710
	dc.s	0.702025,0.657923
	dc.s	0.697951,0.680365
	dc.s	0.725294,0.697780
	dc.s	0.826219,0.686748
	dc.s	0.763653,0.688540
	dc.s	0.787903,0.731913
	dc.s	0.574329,0.628251
	dc.s	0.572001,0.701710
	dc.s	0.619584,0.683387
	dc.s	0.377936,0.665109
	dc.s	0.426569,0.709571
	dc.s	0.414777,0.670265
	dc.s	0.434354,0.653518
	dc.s	0.426569,0.709571
	dc.s	0.478581,0.734260
	dc.s	0.697951,0.680365
	dc.s	0.619584,0.683387
	dc.s	0.623098,0.701710
	dc.s	0.911669,0.645032
	dc.s	0.866376,0.724861
	dc.s	0.976851,0.689918
	dc.s	1.000000,0.732625
	dc.s	1.000000,0.633625
	dc.s	0.976851,0.689918
	dc.s	0.619584,0.683387
	dc.s	0.572001,0.701710
	dc.s	0.623098,0.701710
	dc.s	0.911669,0.645032
	dc.s	0.826219,0.686748
	dc.s	0.866376,0.724861
	dc.s	0.434354,0.653518
	dc.s	0.414777,0.670265
	dc.s	0.426569,0.709571
	dc.s	0.697951,0.680365
	dc.s	0.623098,0.701710
	dc.s	0.662404,0.725294
	dc.s	0.285832,0.678337
	dc.s	0.314824,0.731533
	dc.s	0.344026,0.697780
	dc.s	0.623098,0.701710
	dc.s	0.568217,0.731361
	dc.s	0.601737,0.723080
	dc.s	0.344026,0.697780
	dc.s	0.383332,0.721363
	dc.s	0.377936,0.665109
	dc.s	0.525375,0.699662
	dc.s	0.568217,0.731361
	dc.s	0.572001,0.701710
	dc.s	0.623098,0.701710
	dc.s	0.572001,0.701710
	dc.s	0.568217,0.731361
	dc.s	0.697951,0.680365
	dc.s	0.662404,0.725294
	dc.s	0.693849,0.725294
	dc.s	0.377936,0.665109
	dc.s	0.383332,0.721363
	dc.s	0.426569,0.709571
	dc.s	0.623098,0.701710
	dc.s	0.601737,0.723080
	dc.s	0.662404,0.725294
	dc.s	0.697951,0.680365
	dc.s	0.693849,0.725294
	dc.s	0.725294,0.697780
	dc.s	0.426569,0.709571
	dc.s	0.443347,0.750000
	dc.s	0.478581,0.734260
	dc.s	0.662404,0.725294
	dc.s	0.601737,0.723080
	dc.s	0.630959,0.733155
	dc.s	0.826219,0.686748
	dc.s	0.834940,0.750000
	dc.s	0.866376,0.724861
	dc.s	0.383332,0.721363
	dc.s	0.406903,0.750000
	dc.s	0.426569,0.709571
	dc.s	0.725294,0.697780
	dc.s	0.693849,0.725294
	dc.s	0.735087,0.737921
	dc.s	0.406903,0.750000
	dc.s	0.443347,0.750000
	dc.s	0.426569,0.709571
	dc.s	0.826219,0.686748
	dc.s	0.787903,0.731913
	dc.s	0.834940,0.750000
	dc.s	0.685988,0.760669
	dc.s	0.637337,0.762344
	dc.s	0.660857,0.788984
	dc.s	0.309299,0.794521
	dc.s	0.348943,0.809448
	dc.s	0.344015,0.750000
	dc.s	0.967250,0.770164
	dc.s	0.902809,0.750000
	dc.s	0.886753,0.797285
	dc.s	0.573724,0.797926
	dc.s	0.637337,0.762344
	dc.s	0.606286,0.758014
	dc.s	0.685988,0.760669
	dc.s	0.660857,0.788984
	dc.s	0.678889,0.816609
	dc.s	0.685988,0.760669
	dc.s	0.678889,0.816609
	dc.s	0.703672,0.816266
	dc.s	0.573724,0.797926
	dc.s	0.606286,0.758014
	dc.s	0.534342,0.760058
	dc.s	0.967250,0.770164
	dc.s	0.886753,0.797285
	dc.s	0.958087,0.794507
	dc.s	-0.000000,0.774750
	dc.s	-0.000000,0.869750
	dc.s	0.063053,0.798229
	dc.s	0.835944,0.799388
	dc.s	0.766504,0.777512
	dc.s	0.808097,0.831552
	dc.s	0.902809,0.750000
	dc.s	0.835944,0.799388
	dc.s	0.886753,0.797285
	dc.s	0.414777,0.839281
	dc.s	0.488359,0.802525
	dc.s	0.458014,0.780322
	dc.s	0.537708,0.819394
	dc.s	0.573724,0.797926
	dc.s	0.534342,0.760058
	dc.s	0.159787,0.857191
	dc.s	0.250000,0.778743
	dc.s	0.119075,0.828151
	dc.s	0.808097,0.831552
	dc.s	0.766504,0.777512
	dc.s	0.750000,0.834427
	dc.s	0.607376,0.823558
	dc.s	0.573724,0.797926
	dc.s	0.566365,0.818398
	dc.s	0.630959,0.823558
	dc.s	0.660857,0.788984
	dc.s	0.637337,0.762344
	dc.s	0.835944,0.799388
	dc.s	0.866795,0.827489
	dc.s	0.886753,0.797285
	dc.s	0.422958,0.865627
	dc.s	0.500000,0.855261
	dc.s	0.488359,0.802525
	dc.s	0.537708,0.819394
	dc.s	0.566365,0.818398
	dc.s	0.573724,0.797926
	dc.s	0.958087,0.794507
	dc.s	0.886753,0.797285
	dc.s	0.866795,0.827489
	dc.s	0.290304,0.855692
	dc.s	0.348943,0.809448
	dc.s	0.309299,0.794521
	dc.s	0.348943,0.809448
	dc.s	0.414777,0.839281
	dc.s	0.398980,0.788123
	dc.s	0.422958,0.865627
	dc.s	0.488359,0.802525
	dc.s	0.414777,0.839281
	dc.s	0.607376,0.823558
	dc.s	0.637337,0.762344
	dc.s	0.573724,0.797926
	dc.s	0.630959,0.823558
	dc.s	0.637337,0.762344
	dc.s	0.607376,0.823558
	dc.s	0.357666,0.878376
	dc.s	0.414777,0.839281
	dc.s	0.348943,0.809448
	dc.s	0.662404,0.835350
	dc.s	0.660857,0.788984
	dc.s	0.630959,0.823558
	dc.s	0.662404,0.835350
	dc.s	0.678889,0.816609
	dc.s	0.660857,0.788984
	dc.s	0.693849,0.851073
	dc.s	0.703672,0.816266
	dc.s	0.678889,0.816609
	dc.s	0.808097,0.831552
	dc.s	0.750000,0.834427
	dc.s	0.780322,0.866795
	dc.s	1.000000,0.889125
	dc.s	0.958087,0.794507
	dc.s	0.967377,0.855054
	dc.s	0.119075,0.828151
	dc.s	0.063053,0.798229
	dc.s	-0.000000,0.869750
	dc.s	0.638821,0.851073
	dc.s	0.630959,0.823558
	dc.s	0.607376,0.823558
	dc.s	0.638821,0.851073
	dc.s	0.662404,0.835350
	dc.s	0.630959,0.823558
	dc.s	0.290304,0.855692
	dc.s	0.357666,0.878376
	dc.s	0.348943,0.809448
	dc.s	0.638821,0.851073
	dc.s	0.607376,0.823558
	dc.s	0.566365,0.818398
	dc.s	0.662404,0.835350
	dc.s	0.693849,0.851073
	dc.s	0.678889,0.816609
	dc.s	0.808097,0.831552
	dc.s	0.780322,0.866795
	dc.s	0.833204,0.878501
	dc.s	0.835944,0.799388
	dc.s	0.808097,0.831552
	dc.s	0.833204,0.878501
	dc.s	0.357666,0.878376
	dc.s	0.422958,0.865627
	dc.s	0.414777,0.839281
	dc.s	0.958087,0.794507
	dc.s	0.866795,0.827489
	dc.s	0.833204,0.878501
	dc.s	0.958087,0.794507
	dc.s	0.890378,0.878587
	dc.s	0.967377,0.855054
	dc.s	0.662136,0.877256
	dc.s	0.662404,0.835350
	dc.s	0.638821,0.851073
	dc.s	0.662136,0.877256
	dc.s	0.693849,0.851073
	dc.s	0.662404,0.835350
	dc.s	0.958087,0.794507
	dc.s	0.833204,0.878501
	dc.s	0.890378,0.878587
	dc.s	0.692289,0.882913
	dc.s	0.703672,0.816266
	dc.s	0.693849,0.851073
	dc.s	0.835944,0.799388
	dc.s	0.833204,0.878501
	dc.s	0.866795,0.827489
	dc.s	0.159787,0.857191
	dc.s	0.119075,0.828151
	dc.s	0.100330,0.890378
	dc.s	0.638821,0.851073
	dc.s	0.566365,0.818398
	dc.s	0.588586,0.885995
	dc.s	0.034507,0.943145
	dc.s	0.119075,0.828151
	dc.s	-0.000000,0.869750
	dc.s	0.662136,0.877256
	dc.s	0.638821,0.851073
	dc.s	0.588586,0.885995
	dc.s	0.967377,0.855054
	dc.s	0.890378,0.878587
	dc.s	0.945407,0.890378
	dc.s	1.000000,0.889125
	dc.s	0.967377,0.855054
	dc.s	1.000000,0.908875
	dc.s	0.034507,0.943145
	dc.s	0.100330,0.890378
	dc.s	0.119075,0.828151
	dc.s	0.159787,0.857191
	dc.s	0.100330,0.890378
	dc.s	0.137949,0.905976
	dc.s	0.159787,0.857191
	dc.s	0.137949,0.905976
	dc.s	0.161327,0.929347
	dc.s	0.418443,0.917091
	dc.s	0.444885,0.897673
	dc.s	0.422958,0.865627
	dc.s	0.588586,0.885995
	dc.s	0.566365,0.818398
	dc.s	0.513652,0.889695
	dc.s	0.945407,0.890378
	dc.s	0.890378,0.878587
	dc.s	0.886484,0.898739
	dc.s	0.357666,0.878376
	dc.s	0.418443,0.917091
	dc.s	0.422958,0.865627
	dc.s	0.890378,0.878587
	dc.s	0.833204,0.878501
	dc.s	0.886484,0.898739
	dc.s	0.662136,0.877256
	dc.s	0.692289,0.882913
	dc.s	0.693849,0.851073
	dc.s	0.780322,0.866795
	dc.s	0.761157,0.883165
	dc.s	0.811767,0.917893
	dc.s	0.780322,0.866795
	dc.s	0.811767,0.917893
	dc.s	0.833204,0.878501
	dc.s	1.000000,0.908875
	dc.s	0.967377,0.855054
	dc.s	0.945407,0.890378
	dc.s	0.588586,0.885995
	dc.s	0.602210,0.921417
	dc.s	0.634890,0.910031
	dc.s	0.662136,0.877256
	dc.s	0.588586,0.885995
	dc.s	0.634890,0.910031
	dc.s	0.662136,0.877256
	dc.s	0.634890,0.910031
	dc.s	0.692289,0.882913
	dc.s	0.093397,0.925849
	dc.s	0.137949,0.905976
	dc.s	0.100330,0.890378
	dc.s	0.568070,0.917893
	dc.s	0.602210,0.921417
	dc.s	0.588586,0.885995
	dc.s	0.945407,0.890378
	dc.s	0.886484,0.898739
	dc.s	0.924452,0.932978
	dc.s	0.945407,0.890378
	dc.s	0.924452,0.932978
	dc.s	0.946707,0.958108
	dc.s	1.000000,0.908875
	dc.s	0.945407,0.890378
	dc.s	0.946707,0.958108
	dc.s	0.093397,0.925849
	dc.s	0.100330,0.890378
	dc.s	0.034507,0.943145
	dc.s	0.093397,0.925849
	dc.s	0.090750,1.000000
	dc.s	0.137949,0.905976
	dc.s	0.568070,0.917893
	dc.s	0.588586,0.885995
	dc.s	0.513652,0.889695
	dc.s	0.833204,0.878501
	dc.s	0.811767,0.917893
	dc.s	0.840679,0.962198
	dc.s	0.692289,0.882913
	dc.s	0.634890,0.910031
	dc.s	0.694312,0.900698
	dc.s	0.761157,0.883165
	dc.s	0.772461,0.937546
	dc.s	0.811767,0.917893
	dc.s	0.034507,0.943145
	dc.s	-0.000000,0.869750
	dc.s	-0.000000,1.000000
	dc.s	0.363679,0.980782
	dc.s	0.418443,0.917091
	dc.s	0.357666,0.878376
	dc.s	0.500000,0.927380
	dc.s	0.568070,0.917893
	dc.s	0.513652,0.889695
	dc.s	0.694312,0.900698
	dc.s	0.634890,0.910031
	dc.s	0.666335,0.945407
	dc.s	0.833204,0.878501
	dc.s	0.840679,0.962198
	dc.s	0.886484,0.898739
	dc.s	0.528764,0.945407
	dc.s	0.568070,0.917893
	dc.s	0.500000,0.927380
	dc.s	0.528764,0.945407
	dc.s	0.564803,0.971967
	dc.s	0.568070,0.917893
	dc.s	0.694312,0.900698
	dc.s	0.666335,0.945407
	dc.s	0.693849,0.937546
	dc.s	0.761157,0.883165
	dc.s	0.757609,0.975794
	dc.s	0.772461,0.937546
	dc.s	0.458721,0.951300
	dc.s	0.444885,0.897673
	dc.s	0.418443,0.917091
	dc.s	0.564803,0.971967
	dc.s	0.602210,0.921417
	dc.s	0.568070,0.917893
	dc.s	0.634890,0.910031
	dc.s	0.602210,0.921417
	dc.s	0.628423,0.942155
	dc.s	0.634890,0.910031
	dc.s	0.628423,0.942155
	dc.s	0.666335,0.945407
	dc.s	0.811767,0.917893
	dc.s	0.772461,0.937546
	dc.s	0.788183,0.976851
	dc.s	0.811767,0.917893
	dc.s	0.788183,0.976851
	dc.s	0.840679,0.962198
	dc.s	0.145854,0.976767
	dc.s	0.137949,0.905976
	dc.s	0.090750,1.000000
	dc.s	0.145854,0.976767
	dc.s	0.161327,0.929347
	dc.s	0.137949,0.905976
	dc.s	0.363679,0.980782
	dc.s	0.357666,0.878376
	dc.s	0.335625,1.000000
	dc.s	0.564803,0.971967
	dc.s	0.628423,0.942155
	dc.s	0.602210,0.921417
	dc.s	0.924452,0.932978
	dc.s	0.886484,0.898739
	dc.s	0.882517,0.945407
	dc.s	0.093397,0.925849
	dc.s	0.034507,0.943145
	dc.s	-0.000000,1.000000
	dc.s	0.363679,0.980782
	dc.s	0.458721,0.951300
	dc.s	0.418443,0.917091
	dc.s	0.772461,0.937546
	dc.s	0.757609,0.975794
	dc.s	0.788183,0.976851
	dc.s	0.886484,0.898739
	dc.s	0.840679,0.962198
	dc.s	0.882517,0.945407
	dc.s	0.363679,0.980782
	dc.s	0.421750,1.000000
	dc.s	0.458721,0.951300
	dc.s	0.528764,0.945407
	dc.s	0.500000,0.927380
	dc.s	0.536593,0.969999
	dc.s	0.528764,0.945407
	dc.s	0.536593,0.969999
	dc.s	0.564803,0.971967
	dc.s	0.628423,0.942155
	dc.s	0.638875,1.000000
	dc.s	0.666335,0.945407
	dc.s	1.000000,0.908875
	dc.s	0.946707,0.958108
	dc.s	1.000000,1.000000
	dc.s	0.840679,0.962198
	dc.s	0.788183,0.976851
	dc.s	0.809125,1.000000
	dc.s	0.840679,0.962198
	dc.s	0.874500,1.000000
	dc.s	0.882517,0.945407
	dc.s	0.924452,0.932978
	dc.s	0.882517,0.945407
	dc.s	0.874500,1.000000
	dc.s	0.093397,0.925849
	dc.s	-0.000000,1.000000
	dc.s	0.090750,1.000000
	dc.s	0.693849,0.937546
	dc.s	0.666335,0.945407
	dc.s	0.701750,1.000000
	dc.s	1.000000,1.000000
	dc.s	0.946707,0.958108
	dc.s	0.957500,1.000000
	dc.s	0.946707,0.958108
	dc.s	0.924452,0.932978
	dc.s	0.957500,1.000000
	dc.s	0.363679,0.980782
	dc.s	0.335625,1.000000
	dc.s	0.421750,1.000000
	dc.s	0.628423,0.942155
	dc.s	0.603500,1.000000
	dc.s	0.638875,1.000000
	dc.s	0.666335,0.945407
	dc.s	0.638875,1.000000
	dc.s	0.674250,1.000000
	dc.s	0.666335,0.945407
	dc.s	0.674250,1.000000
	dc.s	0.701750,1.000000
	dc.s	0.564803,0.971967
	dc.s	0.560250,1.000000
	dc.s	0.579875,1.000000
	dc.s	0.564803,0.971967
	dc.s	0.579875,1.000000
	dc.s	0.628423,0.942155
	dc.s	0.788183,0.976851
	dc.s	0.772500,1.000000
	dc.s	0.796000,1.000000
	dc.s	0.788183,0.976851
	dc.s	0.796000,1.000000
	dc.s	0.809125,1.000000
	dc.s	0.564803,0.971967
	dc.s	0.536593,0.969999
	dc.s	0.560250,1.000000
	dc.s	0.579875,1.000000
	dc.s	0.603500,1.000000
	dc.s	0.628423,0.942155
	dc.s	0.957500,1.000000
	dc.s	0.924452,0.932978
	dc.s	0.874500,1.000000
	dc.s	0.145854,0.976767
	dc.s	0.090750,1.000000
	dc.s	0.228625,1.000000
	dc.s	0.532750,1.000000
	dc.s	0.560250,1.000000
	dc.s	0.536593,0.969999
	dc.s	0.840679,0.962198
	dc.s	0.809125,1.000000
	dc.s	0.874500,1.000000
	dc.s	0.147725,0.058433
	dc.s	0.250000,-0.000000
	dc.s	0.100375,-0.000000
	dc.s	0.147725,0.058433
	dc.s	0.250000,0.136397
	dc.s	0.250000,-0.000000
	dc.s	0.250000,-0.000000
	dc.s	0.250000,0.136397
	dc.s	0.250125,-0.000000
	dc.s	0.147725,0.058433
	dc.s	0.168735,0.146087
	dc.s	0.250000,0.136397
	dc.s	0.250000,0.136397
	dc.s	0.168735,0.146087
	dc.s	0.203165,0.208299
	dc.s	0.170249,0.280219
	dc.s	0.180982,0.398914
	dc.s	0.250000,0.288067
	dc.s	0.280698,0.373096
	dc.s	0.250000,0.288067
	dc.s	0.250000,0.381044
	dc.s	0.250000,0.381044
	dc.s	0.250000,0.288067
	dc.s	0.180982,0.398914
	dc.s	0.250000,0.444449
	dc.s	0.250000,0.381044
	dc.s	0.180982,0.398914
	dc.s	0.250000,0.444449
	dc.s	0.280698,0.373096
	dc.s	0.250000,0.381044
	dc.s	0.336942,0.450200
	dc.s	0.280698,0.373096
	dc.s	0.250000,0.444449
	dc.s	0.210062,0.622865
	dc.s	0.250000,0.568515
	dc.s	0.235757,0.529288
	dc.s	0.250000,0.568515
	dc.s	0.250000,0.500000
	dc.s	0.235757,0.529288
	dc.s	0.210062,0.622865
	dc.s	0.250000,0.604557
	dc.s	0.250000,0.568515
	dc.s	0.250000,0.652104
	dc.s	0.302002,0.580719
	dc.s	0.250000,0.604557
	dc.s	0.250000,0.652104
	dc.s	0.285832,0.678337
	dc.s	0.302002,0.580719
	dc.s	0.210062,0.622865
	dc.s	0.250000,0.652104
	dc.s	0.250000,0.604557
	dc.s	0.210062,0.622865
	dc.s	0.146817,0.701694
	dc.s	0.250000,0.684357
	dc.s	0.210062,0.622865
	dc.s	0.250000,0.684357
	dc.s	0.250000,0.652104
	dc.s	0.250000,0.652104
	dc.s	0.250000,0.684357
	dc.s	0.285832,0.678337
	dc.s	0.250000,0.684357
	dc.s	0.146817,0.701694
	dc.s	0.250000,0.720020
	dc.s	0.285832,0.678337
	dc.s	0.250000,0.720020
	dc.s	0.314824,0.731533
	dc.s	0.285832,0.678337
	dc.s	0.250000,0.684357
	dc.s	0.250000,0.720020
	dc.s	0.250000,0.778743
	dc.s	0.250000,0.819377
	dc.s	0.309299,0.794521
	dc.s	0.159787,0.857191
	dc.s	0.250000,0.819377
	dc.s	0.250000,0.778743
	dc.s	0.290304,0.855692
	dc.s	0.309299,0.794521
	dc.s	0.250000,0.848552
	dc.s	0.290304,0.855692
	dc.s	0.250000,0.848552
	dc.s	0.250000,0.878709
	dc.s	0.250000,0.878709
	dc.s	0.250000,0.848552
	dc.s	0.161327,0.929347
	dc.s	0.159787,0.857191
	dc.s	0.161327,0.929347
	dc.s	0.250000,0.848552
	dc.s	0.159787,0.857191
	dc.s	0.250000,0.848552
	dc.s	0.250000,0.819377
	dc.s	0.250000,0.819377
	dc.s	0.250000,0.848552
	dc.s	0.309299,0.794521
	dc.s	0.250000,0.878709
	dc.s	0.161327,0.929347
	dc.s	0.250000,0.906327
	dc.s	0.290304,0.855692
	dc.s	0.250000,0.906327
	dc.s	0.357666,0.878376
	dc.s	0.290304,0.855692
	dc.s	0.250000,0.878709
	dc.s	0.250000,0.906327
	dc.s	0.250000,0.928389
	dc.s	0.357666,0.878376
	dc.s	0.250000,0.906327
	dc.s	0.145854,0.976767
	dc.s	0.250000,0.928389
	dc.s	0.161327,0.929347
	dc.s	0.250000,0.928389
	dc.s	0.250000,0.906327
	dc.s	0.161327,0.929347
	dc.s	0.250000,0.980219
	dc.s	0.335625,1.000000
	dc.s	0.357666,0.878376
	dc.s	0.250000,1.000000
	dc.s	0.335625,1.000000
	dc.s	0.250000,0.980219
	dc.s	0.228625,1.000000
	dc.s	0.250000,1.000000
	dc.s	0.250000,0.980219
	dc.s	0.145854,0.976767
	dc.s	0.228625,1.000000
	dc.s	0.250000,0.928389
	dc.s	0.228625,1.000000
	dc.s	0.250000,0.980219
	dc.s	0.250000,0.928389
	dc.s	0.250000,0.980219
	dc.s	0.357666,0.878376
	dc.s	0.250000,0.928389
	dc.s	0.454375,-0.000000
	dc.s	0.476809,0.066973
	dc.s	0.500000,0.041314
	dc.s	0.454375,-0.000000
	dc.s	0.500000,0.041314
	dc.s	0.500000,-0.000000
	dc.s	0.500000,0.041314
	dc.s	0.535375,-0.000000
	dc.s	0.500000,-0.000000
	dc.s	0.505181,0.068885
	dc.s	0.535375,-0.000000
	dc.s	0.500000,0.041314
	dc.s	0.505181,0.068885
	dc.s	0.500000,0.041314
	dc.s	0.500000,0.068536
	dc.s	0.500000,0.068536
	dc.s	0.500000,0.041314
	dc.s	0.476809,0.066973
	dc.s	0.520239,0.122439
	dc.s	0.505181,0.068885
	dc.s	0.500000,0.096591
	dc.s	0.505181,0.068885
	dc.s	0.500000,0.068536
	dc.s	0.500000,0.096591
	dc.s	0.500000,0.068536
	dc.s	0.476809,0.066973
	dc.s	0.500000,0.096591
	dc.s	0.500000,0.128994
	dc.s	0.520239,0.122439
	dc.s	0.500000,0.096591
	dc.s	0.467140,0.139636
	dc.s	0.500000,0.128994
	dc.s	0.500000,0.096591
	dc.s	0.467140,0.139636
	dc.s	0.500000,0.096591
	dc.s	0.476809,0.066973
	dc.s	0.500000,0.166945
	dc.s	0.520239,0.122439
	dc.s	0.500000,0.128994
	dc.s	0.474748,0.222474
	dc.s	0.500000,0.166945
	dc.s	0.467140,0.139636
	dc.s	0.500000,0.166945
	dc.s	0.500000,0.128994
	dc.s	0.467140,0.139636
	dc.s	0.500000,0.166945
	dc.s	0.554457,0.135066
	dc.s	0.520239,0.122439
	dc.s	0.500000,0.166945
	dc.s	0.500000,0.194783
	dc.s	0.554457,0.135066
	dc.s	0.474748,0.222474
	dc.s	0.500000,0.194783
	dc.s	0.500000,0.166945
	dc.s	0.500000,0.250000
	dc.s	0.500000,0.282495
	dc.s	0.520903,0.277206
	dc.s	0.464236,0.370390
	dc.s	0.500000,0.311580
	dc.s	0.467892,0.290619
	dc.s	0.467892,0.290619
	dc.s	0.500000,0.311580
	dc.s	0.500000,0.282495
	dc.s	0.500000,0.311580
	dc.s	0.520903,0.277206
	dc.s	0.500000,0.282495
	dc.s	0.524834,0.304720
	dc.s	0.520903,0.277206
	dc.s	0.500000,0.311580
	dc.s	0.524834,0.304720
	dc.s	0.500000,0.311580
	dc.s	0.500000,0.331633
	dc.s	0.500000,0.331633
	dc.s	0.500000,0.311580
	dc.s	0.464236,0.370390
	dc.s	0.524834,0.304720
	dc.s	0.500000,0.331633
	dc.s	0.513042,0.363679
	dc.s	0.500000,0.331633
	dc.s	0.500000,0.365473
	dc.s	0.513042,0.363679
	dc.s	0.500000,0.331633
	dc.s	0.464236,0.370390
	dc.s	0.500000,0.365473
	dc.s	0.500000,0.390506
	dc.s	0.543832,0.415161
	dc.s	0.513042,0.363679
	dc.s	0.500000,0.390506
	dc.s	0.513042,0.363679
	dc.s	0.500000,0.365473
	dc.s	0.464236,0.370390
	dc.s	0.500000,0.390506
	dc.s	0.500000,0.365473
	dc.s	0.500000,0.390506
	dc.s	0.500000,0.447078
	dc.s	0.543832,0.415161
	dc.s	0.543832,0.415161
	dc.s	0.500000,0.447078
	dc.s	0.516062,0.481520
	dc.s	0.464236,0.370390
	dc.s	0.500000,0.447078
	dc.s	0.500000,0.390506
	dc.s	0.500000,0.447078
	dc.s	0.500000,0.474378
	dc.s	0.516062,0.481520
	dc.s	0.416680,0.437330
	dc.s	0.500000,0.474378
	dc.s	0.500000,0.447078
	dc.s	0.464236,0.370390
	dc.s	0.416680,0.437330
	dc.s	0.500000,0.447078
	dc.s	0.500000,0.483757
	dc.s	0.516062,0.481520
	dc.s	0.500000,0.474378
	dc.s	0.459705,0.489371
	dc.s	0.500000,0.474378
	dc.s	0.416680,0.437330
	dc.s	0.459705,0.489371
	dc.s	0.500000,0.483757
	dc.s	0.500000,0.474378
	dc.s	0.500000,0.531242
	dc.s	0.500000,0.538652
	dc.s	0.505181,0.536625
	dc.s	0.500000,0.538652
	dc.s	0.500452,0.579787
	dc.s	0.505181,0.536625
	dc.s	0.500000,0.538652
	dc.s	0.500000,0.579682
	dc.s	0.500452,0.579787
	dc.s	0.434239,0.564378
	dc.s	0.500000,0.579682
	dc.s	0.500000,0.538652
	dc.s	0.434239,0.564378
	dc.s	0.415134,0.629912
	dc.s	0.500000,0.580053
	dc.s	0.434239,0.564378
	dc.s	0.500000,0.580053
	dc.s	0.500000,0.579682
	dc.s	0.500000,0.579682
	dc.s	0.500000,0.580053
	dc.s	0.500452,0.579787
	dc.s	0.500452,0.579787
	dc.s	0.500000,0.619786
	dc.s	0.505181,0.619168
	dc.s	0.500000,0.580053
	dc.s	0.500000,0.619786
	dc.s	0.500452,0.579787
	dc.s	0.415134,0.629912
	dc.s	0.500000,0.619786
	dc.s	0.500000,0.580053
	dc.s	0.415134,0.629912
	dc.s	0.434354,0.653518
	dc.s	0.500000,0.619786
	dc.s	0.434354,0.653518
	dc.s	0.500000,0.621680
	dc.s	0.500000,0.619786
	dc.s	0.500000,0.619786
	dc.s	0.500000,0.621680
	dc.s	0.505181,0.619168
	dc.s	0.434354,0.653518
	dc.s	0.500000,0.686798
	dc.s	0.500000,0.621680
	dc.s	0.505181,0.619168
	dc.s	0.500000,0.686798
	dc.s	0.525375,0.699662
	dc.s	0.500000,0.621680
	dc.s	0.500000,0.686798
	dc.s	0.505181,0.619168
	dc.s	0.434354,0.653518
	dc.s	0.478581,0.734260
	dc.s	0.500000,0.686798
	dc.s	0.500000,0.686798
	dc.s	0.478581,0.734260
	dc.s	0.500000,0.718424
	dc.s	0.500000,0.686798
	dc.s	0.500000,0.718424
	dc.s	0.525375,0.699662
	dc.s	0.500000,0.718424
	dc.s	0.478581,0.734260
	dc.s	0.500000,0.745395
	dc.s	0.458014,0.780322
	dc.s	0.488359,0.802525
	dc.s	0.500000,0.775510
	dc.s	0.458014,0.780322
	dc.s	0.500000,0.775510
	dc.s	0.500000,0.756836
	dc.s	0.500000,0.775510
	dc.s	0.510863,0.750000
	dc.s	0.500000,0.756836
	dc.s	0.500000,0.775510
	dc.s	0.534342,0.760058
	dc.s	0.510863,0.750000
	dc.s	0.500000,0.791774
	dc.s	0.534342,0.760058
	dc.s	0.500000,0.775510
	dc.s	0.488359,0.802525
	dc.s	0.500000,0.791774
	dc.s	0.500000,0.775510
	dc.s	0.537708,0.819394
	dc.s	0.534342,0.760058
	dc.s	0.500000,0.791774
	dc.s	0.500000,0.806504
	dc.s	0.537708,0.819394
	dc.s	0.500000,0.791774
	dc.s	0.488359,0.802525
	dc.s	0.500000,0.806504
	dc.s	0.500000,0.791774
	dc.s	0.500000,0.855261
	dc.s	0.537708,0.819394
	dc.s	0.500000,0.806504
	dc.s	0.500000,0.855261
	dc.s	0.500000,0.806504
	dc.s	0.488359,0.802525
	dc.s	0.500000,0.886072
	dc.s	0.513652,0.889695
	dc.s	0.500000,0.855261
	dc.s	0.422958,0.865627
	dc.s	0.500000,0.886072
	dc.s	0.500000,0.855261
	dc.s	0.500000,0.855261
	dc.s	0.566365,0.818398
	dc.s	0.537708,0.819394
	dc.s	0.500000,0.891279
	dc.s	0.513652,0.889695
	dc.s	0.500000,0.886072
	dc.s	0.444885,0.897673
	dc.s	0.500000,0.886072
	dc.s	0.422958,0.865627
	dc.s	0.444885,0.897673
	dc.s	0.500000,0.891279
	dc.s	0.500000,0.886072
	dc.s	0.513652,0.889695
	dc.s	0.566365,0.818398
	dc.s	0.500000,0.855261
	dc.s	0.500000,0.927380
	dc.s	0.513652,0.889695
	dc.s	0.500000,0.891279
	dc.s	0.444885,0.897673
	dc.s	0.500000,0.927380
	dc.s	0.500000,0.891279
	dc.s	0.458721,0.951300
	dc.s	0.500000,0.927380
	dc.s	0.444885,0.897673
	dc.s	0.500000,0.961212
	dc.s	0.536593,0.969999
	dc.s	0.500000,0.927380
	dc.s	0.458721,0.951300
	dc.s	0.500000,0.961212
	dc.s	0.500000,0.927380
	dc.s	0.500000,0.979736
	dc.s	0.536593,0.969999
	dc.s	0.500000,0.961212
	dc.s	0.421750,1.000000
	dc.s	0.500000,0.979736
	dc.s	0.458721,0.951300
	dc.s	0.458721,0.951300
	dc.s	0.500000,0.979736
	dc.s	0.500000,0.961212
	dc.s	0.421750,1.000000
	dc.s	0.473750,1.000000
	dc.s	0.500000,0.979736
	dc.s	0.473750,1.000000
	dc.s	0.500000,0.987718
	dc.s	0.500000,0.979736
	dc.s	0.500000,0.987718
	dc.s	0.536593,0.969999
	dc.s	0.500000,0.979736
	dc.s	0.500000,0.987718
	dc.s	0.532750,1.000000
	dc.s	0.536593,0.969999
	dc.s	0.500000,1.000000
	dc.s	0.532750,1.000000
	dc.s	0.500000,0.987718
	dc.s	0.473750,1.000000
	dc.s	0.500000,1.000000
	dc.s	0.500000,0.987718
	dc.s	0.750000,-0.000000
	dc.s	0.750000,0.031227
	dc.s	0.779000,-0.000000
	dc.s	0.779000,-0.000000
	dc.s	0.750000,0.031227
	dc.s	0.761076,0.042619
	dc.s	0.721875,-0.000000
	dc.s	0.750000,0.031227
	dc.s	0.750000,-0.000000
	dc.s	0.750000,0.041076
	dc.s	0.761076,0.042619
	dc.s	0.750000,0.031227
	dc.s	0.680655,0.031418
	dc.s	0.750000,0.041076
	dc.s	0.721875,-0.000000
	dc.s	0.721875,-0.000000
	dc.s	0.750000,0.041076
	dc.s	0.750000,0.031227
	dc.s	0.680655,0.031418
	dc.s	0.744947,0.057093
	dc.s	0.750000,0.041076
	dc.s	0.744947,0.057093
	dc.s	0.750000,0.052559
	dc.s	0.750000,0.041076
	dc.s	0.750000,0.052559
	dc.s	0.761076,0.042619
	dc.s	0.750000,0.041076
	dc.s	0.750000,0.052559
	dc.s	0.750000,0.084824
	dc.s	0.761076,0.042619
	dc.s	0.750000,0.084824
	dc.s	0.756087,0.118224
	dc.s	0.761076,0.042619
	dc.s	0.744947,0.057093
	dc.s	0.750000,0.084824
	dc.s	0.750000,0.052559
	dc.s	0.750000,0.084824
	dc.s	0.750000,0.116026
	dc.s	0.756087,0.118224
	dc.s	0.717432,0.104260
	dc.s	0.750000,0.116026
	dc.s	0.750000,0.084824
	dc.s	0.717432,0.104260
	dc.s	0.750000,0.084824
	dc.s	0.744947,0.057093
	dc.s	0.750000,0.116026
	dc.s	0.750000,0.119337
	dc.s	0.756087,0.118224
	dc.s	0.687752,0.130712
	dc.s	0.750000,0.119337
	dc.s	0.717432,0.104260
	dc.s	0.717432,0.104260
	dc.s	0.750000,0.119337
	dc.s	0.750000,0.116026
	dc.s	0.750000,0.119337
	dc.s	0.750000,0.120835
	dc.s	0.756087,0.118224
	dc.s	0.666505,0.156652
	dc.s	0.750000,0.120835
	dc.s	0.687752,0.130712
	dc.s	0.687752,0.130712
	dc.s	0.750000,0.120835
	dc.s	0.750000,0.119337
	dc.s	0.750000,0.126655
	dc.s	0.766159,0.131438
	dc.s	0.756087,0.118224
	dc.s	0.750000,0.145810
	dc.s	0.766159,0.131438
	dc.s	0.750000,0.126655
	dc.s	0.711351,0.180186
	dc.s	0.750000,0.145810
	dc.s	0.750000,0.126655
	dc.s	0.666505,0.156652
	dc.s	0.711351,0.180186
	dc.s	0.750000,0.120835
	dc.s	0.711351,0.180186
	dc.s	0.750000,0.126655
	dc.s	0.750000,0.120835
	dc.s	0.750000,0.120835
	dc.s	0.750000,0.126655
	dc.s	0.756087,0.118224
	dc.s	0.750000,0.145810
	dc.s	0.760669,0.171080
	dc.s	0.766159,0.131438
	dc.s	0.750000,0.173050
	dc.s	0.760669,0.171080
	dc.s	0.750000,0.145810
	dc.s	0.711351,0.180186
	dc.s	0.750000,0.173050
	dc.s	0.750000,0.145810
	dc.s	0.711351,0.180186
	dc.s	0.742677,0.210696
	dc.s	0.750000,0.194572
	dc.s	0.711351,0.180186
	dc.s	0.750000,0.194572
	dc.s	0.750000,0.173050
	dc.s	0.750000,0.173050
	dc.s	0.750000,0.194572
	dc.s	0.760669,0.171080
	dc.s	0.761078,0.250000
	dc.s	0.760669,0.171080
	dc.s	0.750000,0.225104
	dc.s	0.750000,0.225104
	dc.s	0.760669,0.171080
	dc.s	0.750000,0.194572
	dc.s	0.742677,0.210696
	dc.s	0.750000,0.225104
	dc.s	0.750000,0.194572
	dc.s	0.750000,0.240796
	dc.s	0.761078,0.250000
	dc.s	0.750000,0.225104
	dc.s	0.733155,0.230039
	dc.s	0.750000,0.240796
	dc.s	0.750000,0.225104
	dc.s	0.733155,0.230039
	dc.s	0.750000,0.225104
	dc.s	0.742677,0.210696
	dc.s	0.696338,0.275562
	dc.s	0.737085,0.304720
	dc.s	0.750000,0.275266
	dc.s	0.696338,0.275562
	dc.s	0.750000,0.275266
	dc.s	0.750000,0.253246
	dc.s	0.737085,0.304720
	dc.s	0.750000,0.307949
	dc.s	0.750000,0.275266
	dc.s	0.750000,0.336685
	dc.s	0.768530,0.312582
	dc.s	0.750000,0.307949
	dc.s	0.732103,0.359966
	dc.s	0.750000,0.336685
	dc.s	0.737085,0.304720
	dc.s	0.750000,0.336685
	dc.s	0.750000,0.307949
	dc.s	0.737085,0.304720
	dc.s	0.750000,0.336685
	dc.s	0.796044,0.324373
	dc.s	0.768530,0.312582
	dc.s	0.750000,0.350003
	dc.s	0.796044,0.324373
	dc.s	0.750000,0.336685
	dc.s	0.732103,0.359966
	dc.s	0.750000,0.350003
	dc.s	0.750000,0.336685
	dc.s	0.799975,0.383332
	dc.s	0.796044,0.324373
	dc.s	0.750000,0.366127
	dc.s	0.750000,0.366127
	dc.s	0.796044,0.324373
	dc.s	0.750000,0.350003
	dc.s	0.750000,0.366127
	dc.s	0.750000,0.350003
	dc.s	0.732103,0.359966
	dc.s	0.799975,0.383332
	dc.s	0.750000,0.366127
	dc.s	0.750000,0.376941
	dc.s	0.756738,0.383332
	dc.s	0.799975,0.383332
	dc.s	0.750000,0.376941
	dc.s	0.750000,0.376941
	dc.s	0.750000,0.366127
	dc.s	0.732103,0.359966
	dc.s	0.734601,0.421598
	dc.s	0.750000,0.394980
	dc.s	0.712058,0.397450
	dc.s	0.750000,0.394980
	dc.s	0.750000,0.385461
	dc.s	0.712058,0.397450
	dc.s	0.750000,0.394980
	dc.s	0.756738,0.383332
	dc.s	0.750000,0.385461
	dc.s	0.750000,0.385461
	dc.s	0.750000,0.376941
	dc.s	0.712058,0.397450
	dc.s	0.712058,0.397450
	dc.s	0.750000,0.376941
	dc.s	0.732103,0.359966
	dc.s	0.756738,0.383332
	dc.s	0.750000,0.376941
	dc.s	0.750000,0.385461
	dc.s	0.807632,0.466435
	dc.s	0.756738,0.383332
	dc.s	0.750000,0.431052
	dc.s	0.750000,0.431052
	dc.s	0.756738,0.383332
	dc.s	0.750000,0.394980
	dc.s	0.750000,0.431052
	dc.s	0.750000,0.394980
	dc.s	0.734601,0.421598
	dc.s	0.750000,0.499286
	dc.s	0.807632,0.466435
	dc.s	0.750000,0.431052
	dc.s	0.750000,0.559089
	dc.s	0.729417,0.592179
	dc.s	0.750000,0.582245
	dc.s	0.849467,0.534238
	dc.s	0.750000,0.582245
	dc.s	0.827355,0.628039
	dc.s	0.750000,0.582245
	dc.s	0.750000,0.599715
	dc.s	0.827355,0.628039
	dc.s	0.750000,0.582245
	dc.s	0.729417,0.592179
	dc.s	0.750000,0.599715
	dc.s	0.702025,0.657923
	dc.s	0.750000,0.681758
	dc.s	0.750000,0.650113
	dc.s	0.729417,0.592179
	dc.s	0.702025,0.657923
	dc.s	0.750000,0.650113
	dc.s	0.750000,0.650113
	dc.s	0.750000,0.681758
	dc.s	0.763653,0.688540
	dc.s	0.729417,0.592179
	dc.s	0.750000,0.650113
	dc.s	0.750000,0.599715
	dc.s	0.750000,0.599715
	dc.s	0.750000,0.650113
	dc.s	0.827355,0.628039
	dc.s	0.827355,0.628039
	dc.s	0.750000,0.650113
	dc.s	0.763653,0.688540
	dc.s	0.702025,0.657923
	dc.s	0.725294,0.697780
	dc.s	0.750000,0.681758
	dc.s	0.750000,0.681758
	dc.s	0.725294,0.697780
	dc.s	0.750000,0.691829
	dc.s	0.750000,0.681758
	dc.s	0.750000,0.691829
	dc.s	0.763653,0.688540
	dc.s	0.725294,0.697780
	dc.s	0.735087,0.737921
	dc.s	0.750000,0.712142
	dc.s	0.750000,0.691829
	dc.s	0.725294,0.697780
	dc.s	0.750000,0.712142
	dc.s	0.763653,0.688540
	dc.s	0.750000,0.691829
	dc.s	0.750000,0.712142
	dc.s	0.750000,0.712142
	dc.s	0.735087,0.737921
	dc.s	0.750000,0.736225
	dc.s	0.763653,0.688540
	dc.s	0.750000,0.712142
	dc.s	0.787903,0.731913
	dc.s	0.787903,0.731913
	dc.s	0.750000,0.712142
	dc.s	0.750000,0.736225
	dc.s	0.750000,0.764691
	dc.s	0.737085,0.788183
	dc.s	0.750000,0.783499
	dc.s	0.766504,0.777512
	dc.s	0.750000,0.764691
	dc.s	0.750000,0.783499
	dc.s	0.750000,0.783499
	dc.s	0.737085,0.788183
	dc.s	0.750000,0.810475
	dc.s	0.766504,0.777512
	dc.s	0.750000,0.783499
	dc.s	0.750000,0.810475
	dc.s	0.766504,0.777512
	dc.s	0.750000,0.810475
	dc.s	0.750000,0.834427
	dc.s	0.750000,0.834427
	dc.s	0.750000,0.810475
	dc.s	0.703672,0.816266
	dc.s	0.750000,0.810475
	dc.s	0.737085,0.788183
	dc.s	0.703672,0.816266
	dc.s	0.692289,0.882913
	dc.s	0.750000,0.834427
	dc.s	0.703672,0.816266
	dc.s	0.750000,0.834427
	dc.s	0.750000,0.878747
	dc.s	0.780322,0.866795
	dc.s	0.694312,0.900698
	dc.s	0.750000,0.878747
	dc.s	0.750000,0.834427
	dc.s	0.750000,0.878747
	dc.s	0.761157,0.883165
	dc.s	0.780322,0.866795
	dc.s	0.750000,0.878747
	dc.s	0.750000,0.886091
	dc.s	0.761157,0.883165
	dc.s	0.694312,0.900698
	dc.s	0.750000,0.886091
	dc.s	0.750000,0.878747
	dc.s	0.692289,0.882913
	dc.s	0.694312,0.900698
	dc.s	0.750000,0.834427
	dc.s	0.694312,0.900698
	dc.s	0.693849,0.937546
	dc.s	0.750000,0.892179
	dc.s	0.694312,0.900698
	dc.s	0.750000,0.892179
	dc.s	0.750000,0.886091
	dc.s	0.750000,0.886091
	dc.s	0.750000,0.892179
	dc.s	0.761157,0.883165
	dc.s	0.750000,0.892179
	dc.s	0.693849,0.937546
	dc.s	0.750000,0.971229
	dc.s	0.761157,0.883165
	dc.s	0.750000,0.892179
	dc.s	0.750000,0.971229
	dc.s	0.761157,0.883165
	dc.s	0.750000,0.971229
	dc.s	0.757609,0.975794
	dc.s	0.693849,0.937546
	dc.s	0.701750,1.000000
	dc.s	0.750000,0.971229
	dc.s	0.750000,0.971229
	dc.s	0.701750,1.000000
	dc.s	0.750000,0.979185
	dc.s	0.750000,0.971229
	dc.s	0.750000,0.979185
	dc.s	0.757609,0.975794
	dc.s	0.788183,0.976851
	dc.s	0.757609,0.975794
	dc.s	0.750000,1.000000
	dc.s	0.788183,0.976851
	dc.s	0.750000,1.000000
	dc.s	0.772500,1.000000
	dc.s	0.701750,1.000000
	dc.s	0.750000,1.000000
	dc.s	0.750000,0.979185
	dc.s	0.750000,0.979185
	dc.s	0.750000,1.000000
	dc.s	0.757609,0.975794
	dc.s	0.250000,0.136397
	dc.s	0.259783,0.250000
	dc.s	0.283606,0.250000
	dc.s	0.250000,0.136397
	dc.s	0.283606,0.250000
	dc.s	0.336165,0.159289
	dc.s	0.259783,0.250000
	dc.s	0.250000,0.288067
	dc.s	0.283606,0.250000
	dc.s	0.283606,0.250000
	dc.s	0.250000,0.288067
	dc.s	0.321486,0.250000
	dc.s	0.336165,0.159289
	dc.s	0.283606,0.250000
	dc.s	0.321486,0.250000
	dc.s	0.169908,0.250000
	dc.s	0.203165,0.208299
	dc.s	0.168735,0.146087
	dc.s	0.169908,0.250000
	dc.s	0.184080,0.250000
	dc.s	0.203165,0.208299
	dc.s	0.170249,0.280219
	dc.s	0.184080,0.250000
	dc.s	0.169908,0.250000
	dc.s	0.068449,0.250000
	dc.s	0.143619,0.142435
	dc.s	-0.000000,0.202125
	dc.s	0.068449,0.250000
	dc.s	-0.000000,0.202125
	dc.s	0.017834,0.250000
	dc.s	0.034037,0.299243
	dc.s	0.068449,0.250000
	dc.s	0.017834,0.250000
	dc.s	0.614174,0.200724
	dc.s	0.627107,0.250000
	dc.s	0.633531,0.182688
	dc.s	0.164408,0.250000
	dc.s	0.168735,0.146087
	dc.s	0.143619,0.142435
	dc.s	0.169908,0.250000
	dc.s	0.168735,0.146087
	dc.s	0.164408,0.250000
	dc.s	0.170249,0.280219
	dc.s	0.169908,0.250000
	dc.s	0.164408,0.250000
	dc.s	0.633531,0.182688
	dc.s	0.627107,0.250000
	dc.s	0.635472,0.250000
	dc.s	0.633531,0.182688
	dc.s	0.635472,0.250000
	dc.s	0.667979,0.227214
	dc.s	0.627107,0.250000
	dc.s	0.626507,0.256284
	dc.s	0.635472,0.250000
	dc.s	0.690360,0.250000
	dc.s	0.697780,0.257553
	dc.s	0.707491,0.250000
	dc.s	0.667979,0.227214
	dc.s	0.707491,0.250000
	dc.s	0.742677,0.210696
	dc.s	0.667979,0.227214
	dc.s	0.690360,0.250000
	dc.s	0.707491,0.250000
	dc.s	-0.000000,0.250000
	dc.s	0.017834,0.250000
	dc.s	-0.000000,0.202125
	dc.s	0.034037,0.299243
	dc.s	0.017834,0.250000
	dc.s	-0.000000,0.276000
	dc.s	-0.000000,0.276000
	dc.s	0.017834,0.250000
	dc.s	-0.000000,0.250000
	dc.s	0.707491,0.250000
	dc.s	0.733155,0.230039
	dc.s	0.742677,0.210696
	dc.s	0.170249,0.280219
	dc.s	0.068449,0.250000
	dc.s	0.034037,0.299243
	dc.s	0.170249,0.280219
	dc.s	0.164408,0.250000
	dc.s	0.068449,0.250000
	dc.s	0.164408,0.250000
	dc.s	0.143619,0.142435
	dc.s	0.068449,0.250000
	dc.s	0.414889,0.183139
	dc.s	0.321486,0.250000
	dc.s	0.388064,0.250000
	dc.s	0.388064,0.250000
	dc.s	0.321486,0.250000
	dc.s	0.362481,0.313765
	dc.s	0.696338,0.275562
	dc.s	0.717011,0.250000
	dc.s	0.707491,0.250000
	dc.s	0.696338,0.275562
	dc.s	0.707491,0.250000
	dc.s	0.697780,0.257553
	dc.s	0.707491,0.250000
	dc.s	0.717011,0.250000
	dc.s	0.733155,0.230039
	dc.s	0.796618,0.250000
	dc.s	0.798160,0.198018
	dc.s	0.761078,0.250000
	dc.s	0.796044,0.269345
	dc.s	0.796618,0.250000
	dc.s	0.761078,0.250000
	dc.s	0.843936,0.250000
	dc.s	0.798160,0.198018
	dc.s	0.796618,0.250000
	dc.s	0.857304,0.250000
	dc.s	0.798160,0.198018
	dc.s	0.843936,0.250000
	dc.s	0.843936,0.250000
	dc.s	0.796618,0.250000
	dc.s	0.796044,0.269345
	dc.s	0.929684,0.237900
	dc.s	0.857304,0.250000
	dc.s	0.891190,0.250000
	dc.s	0.930095,0.250000
	dc.s	0.929684,0.237900
	dc.s	0.891190,0.250000
	dc.s	0.930338,0.257163
	dc.s	0.930095,0.250000
	dc.s	0.891190,0.250000
	dc.s	0.599098,0.250000
	dc.s	0.595584,0.261484
	dc.s	0.626507,0.256284
	dc.s	0.599098,0.250000
	dc.s	0.626507,0.256284
	dc.s	0.627107,0.250000
	dc.s	0.614174,0.200724
	dc.s	0.599098,0.250000
	dc.s	0.627107,0.250000
	dc.s	0.635472,0.250000
	dc.s	0.697780,0.257553
	dc.s	0.690360,0.250000
	dc.s	0.626507,0.256284
	dc.s	0.697780,0.257553
	dc.s	0.635472,0.250000
	dc.s	0.635472,0.250000
	dc.s	0.690360,0.250000
	dc.s	0.667979,0.227214
	dc.s	0.957953,0.250000
	dc.s	0.929684,0.237900
	dc.s	0.930095,0.250000
	dc.s	0.957953,0.250000
	dc.s	0.930095,0.250000
	dc.s	0.930338,0.257163
	dc.s	0.388064,0.250000
	dc.s	0.362481,0.313765
	dc.s	0.440897,0.250000
	dc.s	0.414889,0.183139
	dc.s	0.388064,0.250000
	dc.s	0.440897,0.250000
	dc.s	0.414889,0.183139
	dc.s	0.440897,0.250000
	dc.s	0.474748,0.222474
	dc.s	0.857304,0.250000
	dc.s	0.843936,0.250000
	dc.s	0.851073,0.277206
	dc.s	0.851073,0.277206
	dc.s	0.843936,0.250000
	dc.s	0.796044,0.269345
	dc.s	0.362481,0.313765
	dc.s	0.467892,0.290619
	dc.s	0.440897,0.250000
	dc.s	0.440897,0.250000
	dc.s	0.467892,0.290619
	dc.s	0.471978,0.250000
	dc.s	0.440897,0.250000
	dc.s	0.471978,0.250000
	dc.s	0.474748,0.222474
	dc.s	0.554081,0.250000
	dc.s	0.527325,0.250000
	dc.s	0.520903,0.277206
	dc.s	0.614174,0.200724
	dc.s	0.527325,0.250000
	dc.s	0.554081,0.250000
	dc.s	0.957953,0.250000
	dc.s	0.930338,0.257163
	dc.s	0.956610,0.312418
	dc.s	0.571843,0.250000
	dc.s	0.614174,0.200724
	dc.s	0.554081,0.250000
	dc.s	0.524834,0.304720
	dc.s	0.571843,0.250000
	dc.s	0.554081,0.250000
	dc.s	0.524834,0.304720
	dc.s	0.554081,0.250000
	dc.s	0.520903,0.277206
	dc.s	0.930338,0.257163
	dc.s	0.891190,0.250000
	dc.s	0.892516,0.313286
	dc.s	0.891190,0.250000
	dc.s	0.857304,0.250000
	dc.s	0.892516,0.313286
	dc.s	1.000000,0.285125
	dc.s	1.000000,0.250000
	dc.s	0.957953,0.250000
	dc.s	0.524834,0.304720
	dc.s	0.595584,0.261484
	dc.s	0.571843,0.250000
	dc.s	0.571843,0.250000
	dc.s	0.595584,0.261484
	dc.s	0.599098,0.250000
	dc.s	0.571843,0.250000
	dc.s	0.599098,0.250000
	dc.s	0.614174,0.200724
	dc.s	0.851073,0.277206
	dc.s	0.796044,0.269345
	dc.s	0.761078,0.250000
	dc.s	0.892516,0.313286
	dc.s	0.857304,0.250000
	dc.s	0.851073,0.277206
	dc.s	1.000000,0.285125
	dc.s	0.957953,0.250000
	dc.s	0.956610,0.312418
	dc.s	0.362481,0.313765
	dc.s	0.321486,0.250000
	dc.s	0.250000,0.288067
	dc.s	0.796044,0.324373
	dc.s	0.851073,0.277206
	dc.s	0.761078,0.250000
	dc.s	0.796044,0.324373
	dc.s	0.761078,0.250000
	dc.s	0.768530,0.312582
	dc.s	0.250000,0.288067
	dc.s	0.250000,0.250000
	dc.s	0.232960,0.250000
	dc.s	0.250000,0.136397
	dc.s	0.203165,0.208299
	dc.s	0.250000,0.250000
	dc.s	0.250000,0.250000
	dc.s	0.203165,0.208299
	dc.s	0.232960,0.250000
	dc.s	0.250000,0.136397
	dc.s	0.250000,0.250000
	dc.s	0.259783,0.250000
	dc.s	0.259783,0.250000
	dc.s	0.250000,0.250000
	dc.s	0.250000,0.288067
	dc.s	0.170249,0.280219
	dc.s	0.250000,0.288067
	dc.s	0.184080,0.250000
	dc.s	0.250000,0.288067
	dc.s	0.232960,0.250000
	dc.s	0.184080,0.250000
	dc.s	0.184080,0.250000
	dc.s	0.232960,0.250000
	dc.s	0.203165,0.208299
	dc.s	0.500000,0.250000
	dc.s	0.520903,0.277206
	dc.s	0.527325,0.250000
	dc.s	0.500000,0.194783
	dc.s	0.527325,0.250000
	dc.s	0.554457,0.135066
	dc.s	0.500000,0.194783
	dc.s	0.500000,0.250000
	dc.s	0.527325,0.250000
	dc.s	0.474748,0.222474
	dc.s	0.500000,0.250000
	dc.s	0.500000,0.194783
	dc.s	0.471978,0.250000
	dc.s	0.467892,0.290619
	dc.s	0.500000,0.282495
	dc.s	0.471978,0.250000
	dc.s	0.500000,0.282495
	dc.s	0.500000,0.250000
	dc.s	0.474748,0.222474
	dc.s	0.471978,0.250000
	dc.s	0.500000,0.250000
	dc.s	0.750000,0.250000
	dc.s	0.761078,0.250000
	dc.s	0.750000,0.240796
	dc.s	0.750000,0.253246
	dc.s	0.761078,0.250000
	dc.s	0.750000,0.250000
	dc.s	0.717011,0.250000
	dc.s	0.750000,0.250000
	dc.s	0.733155,0.230039
	dc.s	0.750000,0.250000
	dc.s	0.750000,0.240796
	dc.s	0.733155,0.230039
	dc.s	0.696338,0.275562
	dc.s	0.750000,0.253246
	dc.s	0.717011,0.250000
	dc.s	0.717011,0.250000
	dc.s	0.750000,0.253246
	dc.s	0.750000,0.250000
	dc.s	0.750000,0.275266
	dc.s	0.761078,0.250000
	dc.s	0.750000,0.253246
	dc.s	0.768530,0.312582
	dc.s	0.761078,0.250000
	dc.s	0.750000,0.275266
	dc.s	0.750000,0.307949
	dc.s	0.768530,0.312582
	dc.s	0.750000,0.275266
	dc.s	0.072739,0.410537
	dc.s	0.058326,0.500000
	dc.s	0.106394,0.467046
	dc.s	0.072739,0.410537
	dc.s	-0.000000,0.435250
	dc.s	0.058326,0.500000
	dc.s	0.726216,0.500000
	dc.s	0.734601,0.421598
	dc.s	0.708329,0.457982
	dc.s	0.250000,0.444449
	dc.s	0.111544,0.500000
	dc.s	0.172511,0.500000
	dc.s	0.625156,0.500000
	dc.s	0.625331,0.446074
	dc.s	0.608446,0.500000
	dc.s	0.708329,0.457982
	dc.s	0.625331,0.446074
	dc.s	0.625156,0.500000
	dc.s	0.625156,0.500000
	dc.s	0.608446,0.500000
	dc.s	0.605307,0.510028
	dc.s	-0.000000,0.500000
	dc.s	-0.000000,0.564125
	dc.s	0.058326,0.500000
	dc.s	-0.000000,0.435250
	dc.s	-0.000000,0.500000
	dc.s	0.058326,0.500000
	dc.s	0.585237,0.500000
	dc.s	0.605307,0.510028
	dc.s	0.608446,0.500000
	dc.s	0.564139,0.489458
	dc.s	0.585237,0.500000
	dc.s	0.625331,0.446074
	dc.s	0.585237,0.500000
	dc.s	0.608446,0.500000
	dc.s	0.625331,0.446074
	dc.s	0.106394,0.467046
	dc.s	0.058326,0.500000
	dc.s	0.111544,0.500000
	dc.s	0.172511,0.500000
	dc.s	0.235757,0.529288
	dc.s	0.235068,0.500000
	dc.s	0.250000,0.444449
	dc.s	0.172511,0.500000
	dc.s	0.235068,0.500000
	dc.s	0.361573,0.500000
	dc.s	0.380063,0.537385
	dc.s	0.442074,0.500000
	dc.s	0.336942,0.450200
	dc.s	0.361573,0.500000
	dc.s	0.442074,0.500000
	dc.s	0.336942,0.450200
	dc.s	0.442074,0.500000
	dc.s	0.459705,0.489371
	dc.s	0.924250,0.500000
	dc.s	0.957199,0.486281
	dc.s	0.950851,0.443341
	dc.s	0.924250,0.500000
	dc.s	0.944498,0.500000
	dc.s	0.957199,0.486281
	dc.s	0.903417,0.544376
	dc.s	0.944498,0.500000
	dc.s	0.924250,0.500000
	dc.s	0.874949,0.487014
	dc.s	0.924250,0.500000
	dc.s	0.950851,0.443341
	dc.s	0.881394,0.500000
	dc.s	0.924250,0.500000
	dc.s	0.874949,0.487014
	dc.s	0.903417,0.544376
	dc.s	0.924250,0.500000
	dc.s	0.881394,0.500000
	dc.s	0.726216,0.500000
	dc.s	0.708329,0.457982
	dc.s	0.625156,0.500000
	dc.s	0.726216,0.500000
	dc.s	0.625156,0.500000
	dc.s	0.605307,0.510028
	dc.s	0.062110,0.588163
	dc.s	0.111544,0.500000
	dc.s	0.058326,0.500000
	dc.s	0.323610,0.500000
	dc.s	0.302002,0.580719
	dc.s	0.380063,0.537385
	dc.s	0.323610,0.500000
	dc.s	0.380063,0.537385
	dc.s	0.361573,0.500000
	dc.s	0.336942,0.450200
	dc.s	0.323610,0.500000
	dc.s	0.361573,0.500000
	dc.s	0.828342,0.500000
	dc.s	0.849467,0.534238
	dc.s	0.867942,0.500000
	dc.s	0.807632,0.466435
	dc.s	0.828342,0.500000
	dc.s	0.874949,0.487014
	dc.s	0.828342,0.500000
	dc.s	0.867942,0.500000
	dc.s	0.874949,0.487014
	dc.s	0.903417,0.544376
	dc.s	0.955128,0.540065
	dc.s	0.944498,0.500000
	dc.s	0.955128,0.540065
	dc.s	0.956671,0.500000
	dc.s	0.944498,0.500000
	dc.s	0.944498,0.500000
	dc.s	0.956671,0.500000
	dc.s	0.957199,0.486281
	dc.s	0.147512,0.555928
	dc.s	0.111544,0.500000
	dc.s	0.062110,0.588163
	dc.s	0.147512,0.555928
	dc.s	0.172511,0.500000
	dc.s	0.111544,0.500000
	dc.s	0.982132,0.500000
	dc.s	1.000000,0.472750
	dc.s	0.957199,0.486281
	dc.s	0.982132,0.500000
	dc.s	0.957199,0.486281
	dc.s	0.956671,0.500000
	dc.s	0.955128,0.540065
	dc.s	0.982132,0.500000
	dc.s	0.956671,0.500000
	dc.s	0.442074,0.500000
	dc.s	0.434239,0.564378
	dc.s	0.456096,0.500000
	dc.s	0.442074,0.500000
	dc.s	0.380063,0.537385
	dc.s	0.434239,0.564378
	dc.s	0.459705,0.489371
	dc.s	0.442074,0.500000
	dc.s	0.456096,0.500000
	dc.s	0.564139,0.489458
	dc.s	0.516062,0.481520
	dc.s	0.524966,0.500000
	dc.s	0.564139,0.489458
	dc.s	0.524966,0.500000
	dc.s	0.563146,0.500000
	dc.s	0.563146,0.500000
	dc.s	0.524966,0.500000
	dc.s	0.556902,0.566282
	dc.s	0.524966,0.500000
	dc.s	0.505181,0.536625
	dc.s	0.556902,0.566282
	dc.s	0.524966,0.500000
	dc.s	0.512413,0.500000
	dc.s	0.505181,0.536625
	dc.s	0.516062,0.481520
	dc.s	0.512413,0.500000
	dc.s	0.524966,0.500000
	dc.s	0.585237,0.500000
	dc.s	0.556902,0.566282
	dc.s	0.605307,0.510028
	dc.s	0.585237,0.500000
	dc.s	0.563146,0.500000
	dc.s	0.556902,0.566282
	dc.s	0.564139,0.489458
	dc.s	0.563146,0.500000
	dc.s	0.585237,0.500000
	dc.s	0.881394,0.500000
	dc.s	0.874949,0.487014
	dc.s	0.867942,0.500000
	dc.s	0.903417,0.544376
	dc.s	0.881394,0.500000
	dc.s	0.849467,0.534238
	dc.s	0.849467,0.534238
	dc.s	0.881394,0.500000
	dc.s	0.867942,0.500000
	dc.s	0.982132,0.500000
	dc.s	0.982455,0.500000
	dc.s	1.000000,0.472750
	dc.s	0.935047,0.571599
	dc.s	0.982455,0.500000
	dc.s	0.955128,0.540065
	dc.s	0.955128,0.540065
	dc.s	0.982455,0.500000
	dc.s	0.982132,0.500000
	dc.s	0.982455,0.500000
	dc.s	0.986452,0.500000
	dc.s	1.000000,0.472750
	dc.s	0.911669,0.645032
	dc.s	0.986452,0.500000
	dc.s	0.935047,0.571599
	dc.s	0.935047,0.571599
	dc.s	0.986452,0.500000
	dc.s	0.982455,0.500000
	dc.s	0.911669,0.645032
	dc.s	1.000000,0.633625
	dc.s	0.986452,0.500000
	dc.s	1.000000,0.633625
	dc.s	1.000000,0.500000
	dc.s	0.986452,0.500000
	dc.s	0.986452,0.500000
	dc.s	1.000000,0.500000
	dc.s	1.000000,0.472750
	dc.s	0.250000,0.500000
	dc.s	0.235068,0.500000
	dc.s	0.235757,0.529288
	dc.s	0.250000,0.444449
	dc.s	0.235068,0.500000
	dc.s	0.250000,0.500000
	dc.s	0.336942,0.450200
	dc.s	0.250000,0.444449
	dc.s	0.250000,0.500000
	dc.s	0.250000,0.568515
	dc.s	0.300347,0.500000
	dc.s	0.250000,0.500000
	dc.s	0.300347,0.500000
	dc.s	0.336942,0.450200
	dc.s	0.250000,0.500000
	dc.s	0.250000,0.568515
	dc.s	0.250000,0.604557
	dc.s	0.302002,0.580719
	dc.s	0.300347,0.500000
	dc.s	0.302002,0.580719
	dc.s	0.323610,0.500000
	dc.s	0.250000,0.568515
	dc.s	0.302002,0.580719
	dc.s	0.300347,0.500000
	dc.s	0.300347,0.500000
	dc.s	0.323610,0.500000
	dc.s	0.336942,0.450200
	dc.s	0.500000,0.500000
	dc.s	0.500000,0.531242
	dc.s	0.512413,0.500000
	dc.s	0.512413,0.500000
	dc.s	0.500000,0.531242
	dc.s	0.505181,0.536625
	dc.s	0.500000,0.483757
	dc.s	0.512413,0.500000
	dc.s	0.516062,0.481520
	dc.s	0.500000,0.483757
	dc.s	0.500000,0.500000
	dc.s	0.512413,0.500000
	dc.s	0.469934,0.500000
	dc.s	0.500000,0.531242
	dc.s	0.500000,0.500000
	dc.s	0.459705,0.489371
	dc.s	0.469934,0.500000
	dc.s	0.500000,0.483757
	dc.s	0.500000,0.483757
	dc.s	0.469934,0.500000
	dc.s	0.500000,0.500000
	dc.s	0.456096,0.500000
	dc.s	0.434239,0.564378
	dc.s	0.500000,0.538652
	dc.s	0.469934,0.500000
	dc.s	0.500000,0.538652
	dc.s	0.500000,0.531242
	dc.s	0.456096,0.500000
	dc.s	0.500000,0.538652
	dc.s	0.469934,0.500000
	dc.s	0.459705,0.489371
	dc.s	0.456096,0.500000
	dc.s	0.469934,0.500000
	dc.s	0.726216,0.500000
	dc.s	0.750000,0.431052
	dc.s	0.734601,0.421598
	dc.s	0.748748,0.500000
	dc.s	0.750000,0.499286
	dc.s	0.726216,0.500000
	dc.s	0.750000,0.499286
	dc.s	0.750000,0.431052
	dc.s	0.726216,0.500000
	dc.s	0.828342,0.500000
	dc.s	0.786754,0.500000
	dc.s	0.849467,0.534238
	dc.s	0.786754,0.500000
	dc.s	0.750000,0.559089
	dc.s	0.849467,0.534238
	dc.s	0.849467,0.534238
	dc.s	0.750000,0.559089
	dc.s	0.750000,0.582245
	dc.s	0.807632,0.466435
	dc.s	0.786754,0.500000
	dc.s	0.828342,0.500000
	dc.s	0.748748,0.500000
	dc.s	0.750000,0.500000
	dc.s	0.750000,0.499286
	dc.s	0.726216,0.500000
	dc.s	0.729417,0.592179
	dc.s	0.750000,0.559089
	dc.s	0.748748,0.500000
	dc.s	0.750000,0.559089
	dc.s	0.750000,0.500000
	dc.s	0.748748,0.500000
	dc.s	0.726216,0.500000
	dc.s	0.750000,0.559089
	dc.s	0.750000,0.499286
	dc.s	0.786754,0.500000
	dc.s	0.807632,0.466435
	dc.s	0.750000,0.499286
	dc.s	0.750000,0.500000
	dc.s	0.786754,0.500000
	dc.s	0.750000,0.500000
	dc.s	0.750000,0.559089
	dc.s	0.786754,0.500000
	dc.s	0.866376,0.724861
	dc.s	0.902809,0.750000
	dc.s	0.976851,0.689918
	dc.s	1.000000,0.732625
	dc.s	0.976851,0.689918
	dc.s	0.902809,0.750000
	dc.s	0.072108,0.750000
	dc.s	0.063053,0.798229
	dc.s	0.104902,0.750000
	dc.s	0.080823,0.703588
	dc.s	0.104902,0.750000
	dc.s	0.146817,0.701694
	dc.s	0.080823,0.703588
	dc.s	0.072108,0.750000
	dc.s	0.104902,0.750000
	dc.s	0.344026,0.697780
	dc.s	0.344015,0.750000
	dc.s	0.383332,0.721363
	dc.s	0.080823,0.703588
	dc.s	0.055792,0.695557
	dc.s	0.059642,0.750000
	dc.s	0.080823,0.703588
	dc.s	0.059642,0.750000
	dc.s	0.072108,0.750000
	dc.s	0.072108,0.750000
	dc.s	0.059642,0.750000
	dc.s	0.063053,0.798229
	dc.s	0.314824,0.731533
	dc.s	0.344015,0.750000
	dc.s	0.344026,0.697780
	dc.s	0.525375,0.699662
	dc.s	0.510863,0.750000
	dc.s	0.568217,0.731361
	dc.s	0.204029,0.750000
	dc.s	0.146817,0.701694
	dc.s	0.136220,0.750000
	dc.s	0.204029,0.750000
	dc.s	0.119075,0.828151
	dc.s	0.250000,0.778743
	dc.s	0.204029,0.750000
	dc.s	0.136220,0.750000
	dc.s	0.119075,0.828151
	dc.s	0.662404,0.725294
	dc.s	0.630959,0.733155
	dc.s	0.645689,0.750000
	dc.s	0.645689,0.750000
	dc.s	0.630959,0.733155
	dc.s	0.634640,0.750000
	dc.s	0.645689,0.750000
	dc.s	0.634640,0.750000
	dc.s	0.637337,0.762344
	dc.s	0.988669,0.750000
	dc.s	0.902809,0.750000
	dc.s	0.967250,0.770164
	dc.s	1.000000,0.732625
	dc.s	0.902809,0.750000
	dc.s	0.988669,0.750000
	dc.s	-0.000000,0.750000
	dc.s	0.018869,0.750000
	dc.s	-0.000000,0.689875
	dc.s	0.018869,0.750000
	dc.s	0.055792,0.695557
	dc.s	-0.000000,0.689875
	dc.s	-0.000000,0.774750
	dc.s	0.018869,0.750000
	dc.s	-0.000000,0.750000
	dc.s	0.018869,0.750000
	dc.s	0.063053,0.798229
	dc.s	0.059642,0.750000
	dc.s	-0.000000,0.774750
	dc.s	0.063053,0.798229
	dc.s	0.018869,0.750000
	dc.s	0.018869,0.750000
	dc.s	0.059642,0.750000
	dc.s	0.055792,0.695557
	dc.s	0.344015,0.750000
	dc.s	0.406903,0.750000
	dc.s	0.383332,0.721363
	dc.s	0.662404,0.725294
	dc.s	0.645689,0.750000
	dc.s	0.656166,0.750000
	dc.s	0.693849,0.725294
	dc.s	0.662404,0.725294
	dc.s	0.656166,0.750000
	dc.s	0.656166,0.750000
	dc.s	0.645689,0.750000
	dc.s	0.637337,0.762344
	dc.s	0.685988,0.760669
	dc.s	0.656166,0.750000
	dc.s	0.637337,0.762344
	dc.s	0.688359,0.750000
	dc.s	0.656166,0.750000
	dc.s	0.685988,0.760669
	dc.s	0.693849,0.725294
	dc.s	0.656166,0.750000
	dc.s	0.688359,0.750000
	dc.s	0.136220,0.750000
	dc.s	0.104902,0.750000
	dc.s	0.119075,0.828151
	dc.s	0.104902,0.750000
	dc.s	0.063053,0.798229
	dc.s	0.119075,0.828151
	dc.s	0.146817,0.701694
	dc.s	0.104902,0.750000
	dc.s	0.136220,0.750000
	dc.s	0.546215,0.750000
	dc.s	0.510863,0.750000
	dc.s	0.534342,0.760058
	dc.s	0.568217,0.731361
	dc.s	0.510863,0.750000
	dc.s	0.546215,0.750000
	dc.s	0.601737,0.723080
	dc.s	0.568217,0.731361
	dc.s	0.605242,0.750000
	dc.s	0.605242,0.750000
	dc.s	0.568217,0.731361
	dc.s	0.594840,0.750000
	dc.s	0.605242,0.750000
	dc.s	0.594840,0.750000
	dc.s	0.606286,0.758014
	dc.s	0.693849,0.725294
	dc.s	0.688359,0.750000
	dc.s	0.709016,0.750000
	dc.s	0.735087,0.737921
	dc.s	0.693849,0.725294
	dc.s	0.709016,0.750000
	dc.s	0.709016,0.750000
	dc.s	0.688359,0.750000
	dc.s	0.685988,0.760669
	dc.s	0.605242,0.750000
	dc.s	0.606286,0.758014
	dc.s	0.614240,0.750000
	dc.s	0.601737,0.723080
	dc.s	0.605242,0.750000
	dc.s	0.630959,0.733155
	dc.s	0.630959,0.733155
	dc.s	0.605242,0.750000
	dc.s	0.614240,0.750000
	dc.s	0.634640,0.750000
	dc.s	0.614240,0.750000
	dc.s	0.637337,0.762344
	dc.s	0.637337,0.762344
	dc.s	0.614240,0.750000
	dc.s	0.606286,0.758014
	dc.s	0.630959,0.733155
	dc.s	0.614240,0.750000
	dc.s	0.634640,0.750000
	dc.s	0.594840,0.750000
	dc.s	0.568217,0.731361
	dc.s	0.546215,0.750000
	dc.s	0.606286,0.758014
	dc.s	0.594840,0.750000
	dc.s	0.534342,0.760058
	dc.s	0.594840,0.750000
	dc.s	0.546215,0.750000
	dc.s	0.534342,0.760058
	dc.s	0.443347,0.750000
	dc.s	0.458014,0.780322
	dc.s	0.471553,0.750000
	dc.s	0.443347,0.750000
	dc.s	0.471553,0.750000
	dc.s	0.478581,0.734260
	dc.s	0.779415,0.750000
	dc.s	0.766504,0.777512
	dc.s	0.834940,0.750000
	dc.s	0.787903,0.731913
	dc.s	0.779415,0.750000
	dc.s	0.834940,0.750000
	dc.s	0.866376,0.724861
	dc.s	0.834940,0.750000
	dc.s	0.902809,0.750000
	dc.s	0.313204,0.750000
	dc.s	0.309299,0.794521
	dc.s	0.344015,0.750000
	dc.s	0.314824,0.731533
	dc.s	0.313204,0.750000
	dc.s	0.344015,0.750000
	dc.s	0.348943,0.809448
	dc.s	0.406903,0.750000
	dc.s	0.344015,0.750000
	dc.s	0.348943,0.809448
	dc.s	0.398980,0.788123
	dc.s	0.406903,0.750000
	dc.s	0.735567,0.750000
	dc.s	0.709016,0.750000
	dc.s	0.703672,0.816266
	dc.s	0.709016,0.750000
	dc.s	0.685988,0.760669
	dc.s	0.703672,0.816266
	dc.s	0.735087,0.737921
	dc.s	0.709016,0.750000
	dc.s	0.735567,0.750000
	dc.s	0.835944,0.799388
	dc.s	0.834940,0.750000
	dc.s	0.766504,0.777512
	dc.s	0.902809,0.750000
	dc.s	0.834940,0.750000
	dc.s	0.835944,0.799388
	dc.s	0.735567,0.750000
	dc.s	0.703672,0.816266
	dc.s	0.737085,0.788183
	dc.s	0.735567,0.750000
	dc.s	0.737085,0.788183
	dc.s	0.750000,0.764691
	dc.s	0.398980,0.788123
	dc.s	0.443347,0.750000
	dc.s	0.406903,0.750000
	dc.s	0.988669,0.750000
	dc.s	0.967250,0.770164
	dc.s	0.958087,0.794507
	dc.s	0.414777,0.839281
	dc.s	0.458014,0.780322
	dc.s	0.443347,0.750000
	dc.s	0.414777,0.839281
	dc.s	0.443347,0.750000
	dc.s	0.398980,0.788123
	dc.s	1.000000,0.750000
	dc.s	0.958087,0.794507
	dc.s	1.000000,0.889125
	dc.s	1.000000,0.750000
	dc.s	0.988669,0.750000
	dc.s	0.958087,0.794507
	dc.s	1.000000,0.732625
	dc.s	0.988669,0.750000
	dc.s	1.000000,0.750000
	dc.s	0.250000,0.750000
	dc.s	0.279151,0.750000
	dc.s	0.250000,0.720020
	dc.s	0.279151,0.750000
	dc.s	0.314824,0.731533
	dc.s	0.250000,0.720020
	dc.s	0.250000,0.750000
	dc.s	0.250000,0.778743
	dc.s	0.279151,0.750000
	dc.s	0.204029,0.750000
	dc.s	0.250000,0.778743
	dc.s	0.250000,0.750000
	dc.s	0.204029,0.750000
	dc.s	0.250000,0.720020
	dc.s	0.146817,0.701694
	dc.s	0.204029,0.750000
	dc.s	0.250000,0.750000
	dc.s	0.250000,0.720020
	dc.s	0.279151,0.750000
	dc.s	0.309299,0.794521
	dc.s	0.313204,0.750000
	dc.s	0.279151,0.750000
	dc.s	0.250000,0.778743
	dc.s	0.309299,0.794521
	dc.s	0.279151,0.750000
	dc.s	0.313204,0.750000
	dc.s	0.314824,0.731533
	dc.s	0.525375,0.699662
	dc.s	0.500000,0.718424
	dc.s	0.510863,0.750000
	dc.s	0.500000,0.718424
	dc.s	0.500000,0.745395
	dc.s	0.510863,0.750000
	dc.s	0.500000,0.750000
	dc.s	0.510863,0.750000
	dc.s	0.500000,0.745395
	dc.s	0.500000,0.756836
	dc.s	0.510863,0.750000
	dc.s	0.500000,0.750000
	dc.s	0.471553,0.750000
	dc.s	0.500000,0.750000
	dc.s	0.478581,0.734260
	dc.s	0.478581,0.734260
	dc.s	0.500000,0.750000
	dc.s	0.500000,0.745395
	dc.s	0.458014,0.780322
	dc.s	0.500000,0.756836
	dc.s	0.471553,0.750000
	dc.s	0.471553,0.750000
	dc.s	0.500000,0.756836
	dc.s	0.500000,0.750000
	dc.s	0.750000,0.750000
	dc.s	0.735567,0.750000
	dc.s	0.750000,0.764691
	dc.s	0.750000,0.736225
	dc.s	0.735087,0.737921
	dc.s	0.750000,0.750000
	dc.s	0.735087,0.737921
	dc.s	0.735567,0.750000
	dc.s	0.750000,0.750000
	dc.s	0.787903,0.731913
	dc.s	0.750000,0.736225
	dc.s	0.766988,0.750000
	dc.s	0.750000,0.736225
	dc.s	0.750000,0.750000
	dc.s	0.766988,0.750000
	dc.s	0.766988,0.750000
	dc.s	0.750000,0.750000
	dc.s	0.750000,0.764691
	dc.s	0.779415,0.750000
	dc.s	0.766988,0.750000
	dc.s	0.766504,0.777512
	dc.s	0.766988,0.750000
	dc.s	0.750000,0.764691
	dc.s	0.766504,0.777512
	dc.s	0.787903,0.731913
	dc.s	0.766988,0.750000
	dc.s	0.779415,0.750000
	dc.s	0.599592,0.599541
	dc.s	0.674196,0.540806
	dc.s	0.630959,0.544487
	dc.s	0.674196,0.540806
	dc.s	0.726216,0.500000
	dc.s	0.630959,0.544487
