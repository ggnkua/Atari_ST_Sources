 dc.w 14  ; NUMCAM    
 dc.w 61  ; NUMVERTS  
 dc.w 315  ; TNUMVERTS 
 dc.w 105  ; NUMFACES  
 dc.s 0.789582  ; camera_fov 
 dc.l camera_land  ; camera     
 dc.l coords_land_sky  ; coords     
 dc.l faces_land_sky   ; faces      
 dc.l tcoords_land_sky ; tcoords    
 dc.l tex_land_sky+20 ; palette    
 dc.l textures_land_sky ; textures    

textures_land_sky: 
 dc.l tex_land_sky+20+768+256*256*0 

tex_land_sky: incbin "land\snow_sk6.apx"

;camera_land:				;x,y,z , rx,ry,rz,rw , time
	dc.s -1353.802979,705.130676,-829.739075,0.022500,-0.999600,0.014000,1.110300,0.000000
	dc.s 681.429382,705.130676,-1317.928955,-0.127400,-0.990600,-0.050200,0.757000,0.076900
	dc.s 2207.395020,705.130676,-2456.537842,0.009700,-0.999900,0.003500,0.691200,0.153800
	dc.s 4174.301270,705.130676,-3814.392578,0.006100,-1.000000,0.001700,0.555000,0.230800
	dc.s 5999.323242,705.130676,-4519.962402,0.805200,0.590900,-0.050700,0.212200,0.307700
	dc.s 7126.492188,705.130676,-5941.118652,-0.110900,0.975200,0.191300,2.112500,0.384600
	dc.s 6503.679688,705.130676,-4327.016602,-0.034800,0.997600,0.059300,2.082500,0.461500
	dc.s 4403.515137,555.130676,-4657.710938,-0.004200,0.999200,-0.040100,3.350900,0.538500
	dc.s 3358.017578,555.130676,-3998.507324,-0.024000,0.998300,-0.052300,3.999000,0.615400
	dc.s 2646.069580,1155.130615,-1481.079712,0.152000,0.982600,0.106900,4.844600,0.692300
	dc.s 2896.717041,1155.130615,-810.500671,-0.167900,0.985500,0.023400,4.794800,0.769200
	dc.s 3985.169434,1055.130615,-1155.067505,-0.456800,0.889200,-0.024900,4.724000,0.846200
	dc.s 4338.626465,1655.130615,-909.979614,-0.456800,0.889200,-0.024900,4.724000,0.923100
	dc.s 5394.808105,2105.130615,-474.686615,-0.456800,0.889200,-0.024900,4.724000,1.000000

coords_land_sky:				;x,y,z
	dc.s	4000.000000,1500.739868,3857.975586
	dc.s	5696.252441,-1248.611816,3717.751953
	dc.s	835.916260,1248.611816,3240.824707
	dc.s	2303.747559,-1248.611816,3717.751953
	dc.s	-1908.678223,1248.611816,1246.760254
	dc.s	-3473.378418,1500.739868,-1571.751953
	dc.s	-2815.847168,-1248.611816,-1.851562
	dc.s	-3864.188965,1248.611816,-4771.684570
	dc.s	-3864.188965,-1248.611816,-3228.315430
	dc.s	-2815.847168,1248.611816,-7998.148438
	dc.s	-618.802246,1500.739868,-10357.236328
	dc.s	-1908.678223,-1248.611816,-9246.759766
	dc.s	2303.747559,1248.611816,-11717.751953
	dc.s	835.916260,-1248.611816,-11240.824219
	dc.s	11473.378906,-1500.739868,-6428.248047
	dc.s	8618.802734,-1500.739868,2357.235840
	dc.s	-618.802246,-1500.739868,2357.235840
	dc.s	-3473.378418,-1500.739868,-6428.248047
	dc.s	4000.000000,-1500.739868,-11857.975586
	dc.s	4000.000000,8000.000000,-4000.000000
	dc.s	6744.593750,7461.363281,-4891.772461
	dc.s	4000.000000,7461.363281,-6885.836914
	dc.s	9119.595703,5917.994629,-5663.457031
	dc.s	6854.577148,6357.235840,-7928.987793
	dc.s	4000.000000,5917.994629,-9383.060547
	dc.s	10805.206055,3577.708740,-6211.145508
	dc.s	9119.595703,4134.449219,-8549.294922
	dc.s	6744.593750,4134.449219,-10274.833984
	dc.s	4000.000000,3577.708740,-11155.417969
	dc.s	5696.252441,7461.363281,-1665.308594
	dc.s	7164.083984,5917.994629,354.987793
	dc.s	8618.802734,6357.235840,-2499.260254
	dc.s	8205.848633,3577.708740,1788.854492
	dc.s	9908.677734,4134.449219,-536.785156
	dc.s	10815.847656,4134.449219,-3328.766113
	dc.s	2303.747559,7461.363281,-1665.308594
	dc.s	835.916260,5917.994629,354.987793
	dc.s	4000.000000,6357.235840,856.496094
	dc.s	-205.848633,3577.708740,1788.854492
	dc.s	2532.168701,4134.449219,2689.678711
	dc.s	5467.831055,4134.449219,2689.678711
	dc.s	1255.406006,7461.363281,-4891.772461
	dc.s	-1119.595215,5917.994629,-5663.457031
	dc.s	-618.802246,6357.235840,-2499.260254
	dc.s	-2805.206055,3577.708740,-6211.145508
	dc.s	-2815.847168,4134.449219,-3328.766113
	dc.s	-1908.678223,4134.449219,-536.785156
	dc.s	1145.423096,6357.235840,-7928.987793
	dc.s	1255.406006,4134.449219,-10274.833984
	dc.s	-1119.595215,4134.449219,-8549.294922
	dc.s	5696.252441,1248.611816,-11717.751953
	dc.s	8618.802734,1500.739868,-10357.236328
	dc.s	7164.083984,-1248.611816,-11240.824219
	dc.s	10815.847656,1248.611816,-7998.148438
	dc.s	9908.677734,-1248.611816,-9246.759766
	dc.s	11864.189453,1248.611816,-4771.684570
	dc.s	11473.378906,1500.739868,-1571.751953
	dc.s	11864.189453,-1248.611816,-3228.315430
	dc.s	9908.677734,1248.611816,1246.760254
	dc.s	10815.847656,-1248.611816,-1.851562
	dc.s	7164.083984,1248.611816,3240.824707
faces_land_sky:				;f1,f2,f3 , tf1,tf2,tf3 , texnum , flag
	dc.w 20,21,19,  0,1,2,  0,0
	dc.w 22,23,20,  3,4,5,  0,0
	dc.w 24,21,23,  6,7,8,  0,0
	dc.w 23,21,20,  9,10,11,  0,0
	dc.w 25,26,22,  12,13,14,  0,0
	dc.w 26,27,23,  15,16,17,  0,0
	dc.w 28,24,27,  18,19,20,  0,0
	dc.w 26,23,22,  21,22,23,  0,0
	dc.w 27,24,23,  24,25,26,  0,0
	dc.w 29,20,19,  27,28,29,  0,0
	dc.w 30,31,29,  30,31,32,  0,0
	dc.w 22,20,31,  33,34,35,  0,0
	dc.w 31,20,29,  36,37,38,  0,0
	dc.w 32,33,30,  39,40,41,  0,0
	dc.w 33,34,31,  42,43,44,  0,0
	dc.w 25,22,34,  45,46,47,  0,0
	dc.w 33,31,30,  48,49,50,  0,0
	dc.w 34,22,31,  51,52,53,  0,0
	dc.w 35,29,19,  54,55,56,  0,0
	dc.w 36,37,35,  57,58,59,  0,0
	dc.w 30,29,37,  60,61,62,  0,0
	dc.w 37,29,35,  63,64,65,  0,0
	dc.w 38,39,36,  66,67,68,  0,0
	dc.w 39,40,37,  69,70,71,  0,0
	dc.w 32,30,40,  72,73,74,  0,0
	dc.w 39,37,36,  75,76,77,  0,0
	dc.w 40,30,37,  78,79,80,  0,0
	dc.w 35,19,41,  81,82,83,  0,0
	dc.w 42,43,41,  84,85,86,  0,0
	dc.w 36,35,43,  87,88,89,  0,0
	dc.w 43,35,41,  90,91,92,  0,0
	dc.w 44,45,42,  93,94,95,  0,0
	dc.w 46,43,45,  96,97,98,  0,0
	dc.w 38,36,46,  99,100,101,  0,0
	dc.w 45,43,42,  102,103,104,  0,0
	dc.w 46,36,43,  105,106,107,  0,0
	dc.w 41,19,21,  108,109,110,  0,0
	dc.w 24,47,21,  111,112,113,  0,0
	dc.w 42,41,47,  114,115,116,  0,0
	dc.w 47,41,21,  117,118,119,  0,0
	dc.w 28,48,24,  120,121,122,  0,0
	dc.w 49,47,48,  123,124,125,  0,0
	dc.w 44,42,49,  126,127,128,  0,0
	dc.w 48,47,24,  129,130,131,  0,0
	dc.w 49,42,47,  132,133,134,  0,0
	dc.w 50,28,27,  135,136,137,  0,0
	dc.w 51,27,26,  138,139,140,  0,0
	dc.w 52,50,51,  141,142,143,  0,0
	dc.w 50,27,51,  144,145,146,  0,0
	dc.w 53,26,25,  147,148,149,  0,0
	dc.w 54,51,53,  150,151,152,  0,0
	dc.w 53,51,26,  153,154,155,  0,0
	dc.w 54,52,51,  156,157,158,  0,0
	dc.w 55,25,34,  159,160,161,  0,0
	dc.w 56,34,33,  162,163,164,  0,0
	dc.w 57,55,56,  165,166,167,  0,0
	dc.w 55,34,56,  168,169,170,  0,0
	dc.w 58,33,32,  171,172,173,  0,0
	dc.w 59,56,58,  174,175,176,  0,0
	dc.w 58,56,33,  177,178,179,  0,0
	dc.w 59,57,56,  180,181,182,  0,0
	dc.w 60,32,40,  183,184,185,  0,0
	dc.w 0,40,39,  186,187,188,  0,0
	dc.w 1,60,0,  189,190,191,  0,0
	dc.w 60,40,0,  192,193,194,  0,0
	dc.w 2,39,38,  195,196,197,  0,0
	dc.w 3,0,2,  198,199,200,  0,0
	dc.w 2,0,39,  201,202,203,  0,0
	dc.w 1,0,3,  204,205,206,  0,0
	dc.w 4,38,46,  207,208,209,  0,0
	dc.w 5,46,45,  210,211,212,  0,0
	dc.w 6,4,5,  213,214,215,  0,0
	dc.w 4,46,5,  216,217,218,  0,0
	dc.w 7,45,44,  219,220,221,  0,0
	dc.w 8,5,7,  222,223,224,  0,0
	dc.w 7,5,45,  225,226,227,  0,0
	dc.w 6,5,8,  228,229,230,  0,0
	dc.w 9,44,49,  231,232,233,  0,0
	dc.w 10,49,48,  234,235,236,  0,0
	dc.w 11,9,10,  237,238,239,  0,0
	dc.w 9,49,10,  240,241,242,  0,0
	dc.w 12,48,28,  243,244,245,  0,0
	dc.w 13,10,12,  246,247,248,  0,0
	dc.w 12,10,48,  249,250,251,  0,0
	dc.w 11,10,13,  252,253,254,  0,0
	dc.w 14,55,57,  255,256,257,  0,0
	dc.w 14,54,53,  258,259,260,  0,0
	dc.w 55,53,25,  261,262,263,  0,0
	dc.w 14,53,55,  264,265,266,  0,0
	dc.w 15,60,1,  267,268,269,  0,0
	dc.w 15,59,58,  270,271,272,  0,0
	dc.w 60,58,32,  273,274,275,  0,0
	dc.w 15,58,60,  276,277,278,  0,0
	dc.w 16,4,6,  279,280,281,  0,0
	dc.w 16,3,2,  282,283,284,  0,0
	dc.w 2,38,4,  285,286,287,  0,0
	dc.w 16,2,4,  288,289,290,  0,0
	dc.w 17,9,11,  291,292,293,  0,0
	dc.w 17,8,7,  294,295,296,  0,0
	dc.w 7,44,9,  297,298,299,  0,0
	dc.w 17,7,9,  300,301,302,  0,0
	dc.w 18,50,52,  303,304,305,  0,0
	dc.w 18,13,12,  306,307,308,  0,0
	dc.w 12,28,50,  309,310,311,  0,0
	dc.w 18,12,50,  312,313,314,  0,0
tcoords_land_sky:				;u,v
	dc.s	0.550000,0.787224
	dc.s	0.750000,0.787224
	dc.s	0.650000,0.996851
	dc.s	0.550000,0.577599
	dc.s	0.650000,0.626301
	dc.s	0.550000,0.787224
	dc.s	0.750000,0.577599
	dc.s	0.750000,0.787224
	dc.s	0.650000,0.626301
	dc.s	0.650000,0.626301
	dc.s	0.750000,0.787224
	dc.s	0.550000,0.787224
	dc.s	0.550000,0.367973
	dc.s	0.615623,0.413112
	dc.s	0.550000,0.577599
	dc.s	0.615623,0.413112
	dc.s	0.684377,0.413112
	dc.s	0.650000,0.626301
	dc.s	0.750000,0.367973
	dc.s	0.750000,0.577599
	dc.s	0.684377,0.413112
	dc.s	0.615623,0.413112
	dc.s	0.650000,0.626301
	dc.s	0.550000,0.577599
	dc.s	0.684377,0.413112
	dc.s	0.750000,0.577599
	dc.s	0.650000,0.626301
	dc.s	0.350000,0.787224
	dc.s	0.550000,0.787224
	dc.s	0.450000,0.996851
	dc.s	0.350000,0.577599
	dc.s	0.450000,0.626301
	dc.s	0.350000,0.787224
	dc.s	0.550000,0.577599
	dc.s	0.550000,0.787224
	dc.s	0.450000,0.626301
	dc.s	0.450000,0.626301
	dc.s	0.550000,0.787224
	dc.s	0.350000,0.787224
	dc.s	0.350000,0.367973
	dc.s	0.415623,0.413112
	dc.s	0.350000,0.577599
	dc.s	0.415623,0.413112
	dc.s	0.484377,0.413112
	dc.s	0.450000,0.626301
	dc.s	0.550000,0.367973
	dc.s	0.550000,0.577599
	dc.s	0.484377,0.413112
	dc.s	0.415623,0.413112
	dc.s	0.450000,0.626301
	dc.s	0.350000,0.577599
	dc.s	0.484377,0.413112
	dc.s	0.550000,0.577599
	dc.s	0.450000,0.626301
	dc.s	0.150000,0.787224
	dc.s	0.350000,0.787224
	dc.s	0.250000,0.996851
	dc.s	0.150000,0.577599
	dc.s	0.250000,0.626301
	dc.s	0.150000,0.787224
	dc.s	0.350000,0.577599
	dc.s	0.350000,0.787224
	dc.s	0.250000,0.626301
	dc.s	0.250000,0.626301
	dc.s	0.350000,0.787224
	dc.s	0.150000,0.787224
	dc.s	0.150000,0.367973
	dc.s	0.215623,0.413112
	dc.s	0.150000,0.577599
	dc.s	0.215623,0.413112
	dc.s	0.284377,0.413112
	dc.s	0.250000,0.626301
	dc.s	0.350000,0.367973
	dc.s	0.350000,0.577599
	dc.s	0.284377,0.413112
	dc.s	0.215623,0.413112
	dc.s	0.250000,0.626301
	dc.s	0.150000,0.577599
	dc.s	0.284377,0.413112
	dc.s	0.350000,0.577599
	dc.s	0.250000,0.626301
	dc.s	0.150000,0.787224
	dc.s	0.050000,0.996851
	dc.s	-0.050000,0.787224
	dc.s	0.950000,0.577599
	dc.s	1.050000,0.626301
	dc.s	0.950000,0.787224
	dc.s	0.150000,0.577599
	dc.s	0.150000,0.787224
	dc.s	0.050000,0.626301
	dc.s	0.050000,0.626301
	dc.s	0.150000,0.787224
	dc.s	-0.050000,0.787224
	dc.s	0.950000,0.367973
	dc.s	1.015623,0.413112
	dc.s	0.950000,0.577599
	dc.s	0.084377,0.413112
	dc.s	0.050000,0.626301
	dc.s	0.015623,0.413112
	dc.s	0.150000,0.367973
	dc.s	0.150000,0.577599
	dc.s	0.084377,0.413112
	dc.s	1.015623,0.413112
	dc.s	1.050000,0.626301
	dc.s	0.950000,0.577599
	dc.s	0.084377,0.413112
	dc.s	0.150000,0.577599
	dc.s	0.050000,0.626301
	dc.s	0.950000,0.787224
	dc.s	0.850000,0.996851
	dc.s	0.750000,0.787224
	dc.s	0.750000,0.577599
	dc.s	0.850000,0.626301
	dc.s	0.750000,0.787224
	dc.s	0.950000,0.577599
	dc.s	0.950000,0.787224
	dc.s	0.850000,0.626301
	dc.s	0.850000,0.626301
	dc.s	0.950000,0.787224
	dc.s	0.750000,0.787224
	dc.s	0.750000,0.367973
	dc.s	0.815623,0.413112
	dc.s	0.750000,0.577599
	dc.s	0.884377,0.413112
	dc.s	0.850000,0.626301
	dc.s	0.815623,0.413112
	dc.s	0.950000,0.367973
	dc.s	0.950000,0.577599
	dc.s	0.884377,0.413112
	dc.s	0.815623,0.413112
	dc.s	0.850000,0.626301
	dc.s	0.750000,0.577599
	dc.s	0.884377,0.413112
	dc.s	0.950000,0.577599
	dc.s	0.850000,0.626301
	dc.s	0.715567,0.193631
	dc.s	0.750000,0.367973
	dc.s	0.684377,0.413112
	dc.s	0.650000,0.211804
	dc.s	0.684377,0.413112
	dc.s	0.615623,0.413112
	dc.s	0.684433,0.015595
	dc.s	0.715567,0.193631
	dc.s	0.650000,0.211804
	dc.s	0.715567,0.193631
	dc.s	0.684377,0.413112
	dc.s	0.650000,0.211804
	dc.s	0.584433,0.193631
	dc.s	0.615623,0.413112
	dc.s	0.550000,0.367973
	dc.s	0.615567,0.015595
	dc.s	0.650000,0.211804
	dc.s	0.584433,0.193631
	dc.s	0.584433,0.193631
	dc.s	0.650000,0.211804
	dc.s	0.615623,0.413112
	dc.s	0.615567,0.015595
	dc.s	0.684433,0.015595
	dc.s	0.650000,0.211804
	dc.s	0.515567,0.193631
	dc.s	0.550000,0.367973
	dc.s	0.484377,0.413112
	dc.s	0.450000,0.211804
	dc.s	0.484377,0.413112
	dc.s	0.415623,0.413112
	dc.s	0.484433,0.015595
	dc.s	0.515567,0.193631
	dc.s	0.450000,0.211804
	dc.s	0.515567,0.193631
	dc.s	0.484377,0.413112
	dc.s	0.450000,0.211804
	dc.s	0.384433,0.193631
	dc.s	0.415623,0.413112
	dc.s	0.350000,0.367973
	dc.s	0.415567,0.015595
	dc.s	0.450000,0.211804
	dc.s	0.384433,0.193631
	dc.s	0.384433,0.193631
	dc.s	0.450000,0.211804
	dc.s	0.415623,0.413112
	dc.s	0.415567,0.015595
	dc.s	0.484433,0.015595
	dc.s	0.450000,0.211804
	dc.s	0.315567,0.193631
	dc.s	0.350000,0.367973
	dc.s	0.284377,0.413112
	dc.s	0.250000,0.211804
	dc.s	0.284377,0.413112
	dc.s	0.215623,0.413112
	dc.s	0.284433,0.015595
	dc.s	0.315567,0.193631
	dc.s	0.250000,0.211804
	dc.s	0.315567,0.193631
	dc.s	0.284377,0.413112
	dc.s	0.250000,0.211804
	dc.s	0.184433,0.193631
	dc.s	0.215623,0.413112
	dc.s	0.150000,0.367973
	dc.s	0.215567,0.015595
	dc.s	0.250000,0.211804
	dc.s	0.184433,0.193631
	dc.s	0.184433,0.193631
	dc.s	0.250000,0.211804
	dc.s	0.215623,0.413112
	dc.s	0.284433,0.015595
	dc.s	0.250000,0.211804
	dc.s	0.215567,0.015595
	dc.s	0.115567,0.193631
	dc.s	0.150000,0.367973
	dc.s	0.084377,0.413112
	dc.s	0.050000,0.211804
	dc.s	0.084377,0.413112
	dc.s	0.015623,0.413112
	dc.s	0.084433,0.015595
	dc.s	0.115567,0.193631
	dc.s	0.050000,0.211804
	dc.s	0.115567,0.193631
	dc.s	0.084377,0.413112
	dc.s	0.050000,0.211804
	dc.s	0.984433,0.193631
	dc.s	1.015623,0.413112
	dc.s	0.950000,0.367973
	dc.s	0.015567,0.015595
	dc.s	0.050000,0.211804
	dc.s	-0.015567,0.193631
	dc.s	-0.015567,0.193631
	dc.s	0.050000,0.211804
	dc.s	0.015623,0.413112
	dc.s	0.084433,0.015595
	dc.s	0.050000,0.211804
	dc.s	0.015567,0.015595
	dc.s	0.915567,0.193631
	dc.s	0.950000,0.367973
	dc.s	0.884377,0.413112
	dc.s	0.850000,0.211804
	dc.s	0.884377,0.413112
	dc.s	0.815623,0.413112
	dc.s	0.884433,0.015595
	dc.s	0.915567,0.193631
	dc.s	0.850000,0.211804
	dc.s	0.915567,0.193631
	dc.s	0.884377,0.413112
	dc.s	0.850000,0.211804
	dc.s	0.784433,0.193631
	dc.s	0.815623,0.413112
	dc.s	0.750000,0.367973
	dc.s	0.815567,0.015595
	dc.s	0.850000,0.211804
	dc.s	0.784433,0.193631
	dc.s	0.784433,0.193631
	dc.s	0.850000,0.211804
	dc.s	0.815623,0.413112
	dc.s	0.884433,0.015595
	dc.s	0.850000,0.211804
	dc.s	0.815567,0.015595
	dc.s	0.550000,-0.002577
	dc.s	0.515567,0.193631
	dc.s	0.484433,0.015595
	dc.s	0.550000,-0.002577
	dc.s	0.615567,0.015595
	dc.s	0.584433,0.193631
	dc.s	0.515567,0.193631
	dc.s	0.584433,0.193631
	dc.s	0.550000,0.367973
	dc.s	0.550000,-0.002577
	dc.s	0.584433,0.193631
	dc.s	0.515567,0.193631
	dc.s	0.350000,-0.002577
	dc.s	0.315567,0.193631
	dc.s	0.284433,0.015595
	dc.s	0.350000,-0.002577
	dc.s	0.415567,0.015595
	dc.s	0.384433,0.193631
	dc.s	0.315567,0.193631
	dc.s	0.384433,0.193631
	dc.s	0.350000,0.367973
	dc.s	0.350000,-0.002577
	dc.s	0.384433,0.193631
	dc.s	0.315567,0.193631
	dc.s	0.150000,-0.002577
	dc.s	0.115567,0.193631
	dc.s	0.084433,0.015595
	dc.s	0.150000,-0.002577
	dc.s	0.215567,0.015595
	dc.s	0.184433,0.193631
	dc.s	0.184433,0.193631
	dc.s	0.150000,0.367973
	dc.s	0.115567,0.193631
	dc.s	0.150000,-0.002577
	dc.s	0.184433,0.193631
	dc.s	0.115567,0.193631
	dc.s	0.950000,-0.002577
	dc.s	0.915567,0.193631
	dc.s	0.884433,0.015595
	dc.s	0.950000,-0.002577
	dc.s	1.015567,0.015595
	dc.s	0.984433,0.193631
	dc.s	0.984433,0.193631
	dc.s	0.950000,0.367973
	dc.s	0.915567,0.193631
	dc.s	0.950000,-0.002577
	dc.s	0.984433,0.193631
	dc.s	0.915567,0.193631
	dc.s	0.750000,-0.002577
	dc.s	0.715567,0.193631
	dc.s	0.684433,0.015595
	dc.s	0.750000,-0.002577
	dc.s	0.815567,0.015595
	dc.s	0.784433,0.193631
	dc.s	0.784433,0.193631
	dc.s	0.750000,0.367973
	dc.s	0.715567,0.193631
	dc.s	0.750000,-0.002577
	dc.s	0.784433,0.193631
	dc.s	0.715567,0.193631
