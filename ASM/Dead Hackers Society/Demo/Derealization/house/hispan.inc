 dc.w 12  ; NUMCAM    
 dc.w 229  ; NUMVERTS  
 dc.w 951  ; TNUMVERTS 
 dc.w 317  ; NUMFACES  
 dc.s 0.789582  ; camera_fov 
 dc.l camera_hisp  ; camera     
 dc.l coords_hisp  ; coords     
 dc.l faces_hisp   ; faces      
 dc.l tcoords_hisp ; tcoords    
 dc.l tex_hisp+20 ; palette    
 dc.l textures_hisp ; textures    
textures_hisp: 
 dc.l tex_hisp+20+768+256*256*4 
 dc.l tex_hisp+20+768+256*256*3 
 dc.l tex_hisp+20+768+256*256*2 
 dc.l tex_hisp+20+768+256*256*1 
 dc.l tex_hisp+20+768+256*256*0 
tex_hisp: incbin "house\house.apx"
camera_hisp:				;x,y,z , rx,ry,rz,rw , time
	dc.s -1.191600,0.325000,9.545800,0.816200,-0.575400,0.051400,0.217800,0.000000
	dc.s -1.191600,0.325000,9.545800,0.816200,-0.575400,0.051400,0.217800,0.000000
	dc.s -3.749900,0.325000,2.025700,0.238200,-0.967700,0.083000,0.690900,0.125000
	dc.s -2.560000,0.325000,1.973500,0.238200,-0.967700,0.083000,0.690900,0.250000
	dc.s -1.254600,0.325000,1.936300,0.238200,-0.967700,0.083000,0.690900,0.375000
	dc.s 1.992000,1.105000,1.493300,-0.503100,0.853400,0.136700,0.616500,0.500000
	dc.s 2.522200,1.358800,1.469000,-0.423800,0.897300,0.123600,0.628500,0.525000
	dc.s 2.522200,1.358800,1.469000,-0.423800,0.897300,0.123600,0.628500,0.625000
	dc.s 1.992000,1.885000,1.493300,-0.384300,0.905000,0.182500,0.966400,0.750000
	dc.s -0.309700,0.825000,1.451900,-0.965000,-0.262000,-0.014600,0.420200,0.875000
	dc.s -0.235500,0.485000,1.158500,-0.836200,-0.546300,0.048600,0.188800,1.000000
	dc.s -0.235500,0.485000,1.158500,-0.836200,-0.546300,0.048600,0.188800,1.000000
coords_hisp:				;x,y,z
	dc.s	0.000000,2.046926,0.483962
	dc.s	0.000000,2.102372,0.479500
	dc.s	-1.350000,1.387500,0.500000
	dc.s	-1.350000,1.850000,0.500000
	dc.s	0.000000,1.387500,0.500000
	dc.s	-2.700000,0.925000,0.500000
	dc.s	-1.350000,0.462500,0.500000
	dc.s	0.000000,0.462500,0.500000
	dc.s	-1.350000,0.000000,0.500000
	dc.s	-0.870547,1.975000,0.489750
	dc.s	-0.228594,2.074649,0.481731
	dc.s	-2.025000,0.000000,0.500000
	dc.s	-1.350000,0.231250,0.500000
	dc.s	-0.675000,0.462500,0.500000
	dc.s	-2.700000,0.000000,0.500000
	dc.s	-2.700000,1.850000,0.500000
	dc.s	0.000000,0.925000,0.500000
	dc.s	0.000000,1.850000,0.500000
	dc.s	0.000000,0.000000,0.500000
	dc.s	-1.283905,1.847629,0.500000
	dc.s	-0.457189,2.102372,0.479500
	dc.s	0.000000,1.847629,0.500000
	dc.s	-0.641952,1.947277,0.491981
	dc.s	0.000000,1.947277,0.491981
	dc.s	-0.641952,1.847629,0.500000
	dc.s	-0.675000,1.156250,0.500000
	dc.s	-0.675000,1.387500,0.500000
	dc.s	0.000000,1.156250,0.500000
	dc.s	-2.025000,1.618750,0.500000
	dc.s	-2.025000,1.850000,0.500000
	dc.s	-1.350000,1.618750,0.500000
	dc.s	-0.675000,1.618750,0.500000
	dc.s	-0.675000,1.850000,0.500000
	dc.s	0.000000,1.618750,0.500000
	dc.s	-2.700000,0.462500,0.500000
	dc.s	-2.025000,0.693750,0.500000
	dc.s	-2.025000,0.231250,0.500000
	dc.s	-2.700000,1.387500,0.500000
	dc.s	-2.025000,1.156250,0.500000
	dc.s	-1.350000,0.925000,0.500000
	dc.s	-0.675000,0.693750,0.500000
	dc.s	0.000000,0.231250,0.500000
	dc.s	0.000000,0.693750,0.500000
	dc.s	-0.675000,0.000000,0.500000
	dc.s	-0.675000,0.231250,0.500000
	dc.s	2.700000,0.000000,0.500000
	dc.s	2.700000,1.850000,0.500000
	dc.s	0.000000,0.925000,0.500000
	dc.s	0.000000,1.850000,0.500000
	dc.s	0.000000,0.000000,0.500000
	dc.s	1.183905,1.847629,0.500000
	dc.s	0.357188,2.102372,0.479500
	dc.s	0.000000,1.847629,0.500000
	dc.s	0.675000,0.000000,0.500000
	dc.s	0.000000,0.693750,0.500000
	dc.s	0.675000,0.462500,0.500000
	dc.s	1.350000,0.231250,0.500000
	dc.s	2.025000,0.000000,0.500000
	dc.s	0.357188,2.102372,0.479500
	dc.s	0.178594,1.975000,0.489750
	dc.s	0.178594,2.074649,0.481731
	dc.s	0.000000,2.046926,0.483962
	dc.s	0.000000,2.102372,0.479500
	dc.s	0.000000,1.387500,0.500000
	dc.s	1.350000,1.850000,0.500000
	dc.s	1.350000,1.387500,0.500000
	dc.s	1.350000,0.462500,0.500000
	dc.s	2.700000,0.925000,0.500000
	dc.s	0.000000,0.462500,0.500000
	dc.s	1.350000,0.000000,0.500000
	dc.s	0.178594,1.975000,0.489750
	dc.s	0.770546,1.975000,0.489750
	dc.s	0.591952,1.847629,0.500000
	dc.s	0.000000,1.947277,0.491981
	dc.s	0.178594,2.074649,0.481731
	dc.s	0.000000,1.156250,0.500000
	dc.s	0.000000,1.618750,0.500000
	dc.s	0.675000,1.387500,0.500000
	dc.s	0.675000,1.156250,0.500000
	dc.s	0.675000,1.850000,0.500000
	dc.s	0.675000,1.618750,0.500000
	dc.s	1.350000,1.618750,0.500000
	dc.s	2.025000,1.850000,0.500000
	dc.s	2.025000,1.618750,0.500000
	dc.s	2.025000,0.231250,0.500000
	dc.s	2.025000,0.693750,0.500000
	dc.s	2.700000,0.462500,0.500000
	dc.s	0.675000,0.693750,0.500000
	dc.s	1.350000,0.925000,0.500000
	dc.s	2.025000,1.156250,0.500000
	dc.s	2.700000,1.387500,0.500000
	dc.s	0.000000,0.231250,0.500000
	dc.s	0.675000,0.231250,0.500000
	dc.s	-2.700000,1.387500,-1.037500
	dc.s	-2.700000,0.925000,-0.012500
	dc.s	-2.700000,0.462500,0.500000
	dc.s	-2.700000,1.850000,-1.037500
	dc.s	-2.700000,1.387500,-0.525000
	dc.s	-2.700000,1.387500,-0.012500
	dc.s	-2.700000,1.850000,-0.012500
	dc.s	-2.700000,1.387500,0.500000
	dc.s	-2.700000,0.000000,0.500000
	dc.s	-2.700000,0.000000,-1.550000
	dc.s	-2.700000,1.850000,0.500000
	dc.s	-2.700000,1.850000,-1.550000
	dc.s	-2.700000,0.000000,-0.525000
	dc.s	-2.700000,0.925000,-1.550000
	dc.s	-2.700000,0.925000,-0.525000
	dc.s	-2.700000,1.850000,-0.525000
	dc.s	-2.700000,0.925000,0.500000
	dc.s	-2.700000,0.000000,-0.012500
	dc.s	-2.700000,0.462500,-0.525000
	dc.s	-2.700000,0.462500,-0.012500
	dc.s	-2.700000,0.000000,-1.037500
	dc.s	-2.700000,0.462500,-1.550000
	dc.s	-2.700000,0.462500,-1.037500
	dc.s	-2.700000,0.925000,-1.037500
	dc.s	-2.700000,1.387500,-1.550000
	dc.s	0.150000,0.000000,1.175000
	dc.s	0.150000,0.000000,0.837500
	dc.s	1.100000,0.000000,0.837500
	dc.s	-2.700000,0.000000,1.512500
	dc.s	-1.750000,0.000000,1.175000
	dc.s	-2.700000,0.000000,0.837500
	dc.s	-1.750000,0.000000,0.500000
	dc.s	-1.750000,0.000000,0.837500
	dc.s	-0.800000,0.000000,0.837500
	dc.s	0.150000,0.000000,0.500000
	dc.s	2.200000,0.000000,1.512500
	dc.s	2.200000,0.000000,1.850000
	dc.s	2.200000,0.000000,0.837500
	dc.s	2.200000,0.000000,1.175000
	dc.s	3.300000,0.000000,1.512500
	dc.s	2.200000,0.000000,0.500000
	dc.s	3.300000,0.000000,0.837500
	dc.s	2.200000,0.000000,2.862500
	dc.s	2.200000,0.000000,3.200000
	dc.s	2.200000,0.000000,2.187500
	dc.s	2.200000,0.000000,2.525000
	dc.s	3.300000,0.000000,2.862500
	dc.s	3.300000,0.000000,2.187500
	dc.s	0.150000,0.000000,2.862500
	dc.s	1.100000,0.000000,2.862500
	dc.s	-1.750000,0.000000,3.200000
	dc.s	-1.750000,0.000000,2.862500
	dc.s	-0.800000,0.000000,2.862500
	dc.s	0.150000,0.000000,2.525000
	dc.s	0.150000,0.000000,2.187500
	dc.s	1.100000,0.000000,2.187500
	dc.s	-2.700000,0.000000,2.862500
	dc.s	-1.750000,0.000000,2.525000
	dc.s	-2.700000,0.000000,2.187500
	dc.s	-1.750000,0.000000,1.850000
	dc.s	-1.750000,0.000000,2.187500
	dc.s	-0.800000,0.000000,2.187500
	dc.s	0.150000,0.000000,1.850000
	dc.s	0.150000,0.000000,1.512500
	dc.s	1.100000,0.000000,1.512500
	dc.s	-1.750000,0.000000,1.512500
	dc.s	-0.800000,0.000000,1.512500
	dc.s	-2.700000,0.000000,3.200000
	dc.s	-2.700000,0.000000,0.500000
	dc.s	-2.700000,0.000000,1.850000
	dc.s	1.100000,0.000000,0.500000
	dc.s	1.100000,0.000000,3.200000
	dc.s	1.100000,0.000000,1.850000
	dc.s	-0.800000,0.000000,3.200000
	dc.s	-0.800000,0.000000,2.525000
	dc.s	1.100000,0.000000,2.525000
	dc.s	-2.700000,0.000000,2.525000
	dc.s	-0.800000,0.000000,1.850000
	dc.s	-0.800000,0.000000,1.175000
	dc.s	1.100000,0.000000,1.175000
	dc.s	-2.700000,0.000000,1.175000
	dc.s	-0.800000,0.000000,0.500000
	dc.s	3.300000,0.000000,1.175000
	dc.s	3.300000,0.000000,1.850000
	dc.s	3.300000,0.000000,0.500000
	dc.s	3.300000,0.000000,2.525000
	dc.s	3.300000,0.000000,3.200000
	dc.s	0.150000,0.000000,3.200000
	dc.s	-4.543750,0.000000,3.200000
	dc.s	-4.543750,0.000000,2.575000
	dc.s	-4.175000,0.000000,2.575000
	dc.s	-4.543750,0.000000,1.950000
	dc.s	-4.543750,0.000000,1.325000
	dc.s	-4.175000,0.000000,1.325000
	dc.s	-4.912500,0.000000,2.575000
	dc.s	-4.912500,0.000000,1.325000
	dc.s	-4.543750,0.000000,0.700000
	dc.s	-3.068750,0.000000,3.200000
	dc.s	-3.068750,0.000000,2.575000
	dc.s	-2.700000,0.000000,2.575000
	dc.s	-3.806250,0.000000,3.200000
	dc.s	-3.806250,0.000000,2.575000
	dc.s	-3.437500,0.000000,2.575000
	dc.s	-3.068750,0.000000,1.950000
	dc.s	-3.068750,0.000000,1.325000
	dc.s	-2.700000,0.000000,1.325000
	dc.s	-3.806250,0.000000,1.950000
	dc.s	-3.806250,0.000000,0.700000
	dc.s	-3.806250,0.000000,1.325000
	dc.s	-3.437500,0.000000,1.325000
	dc.s	-3.068750,0.000000,0.700000
	dc.s	-2.700000,0.000000,0.700000
	dc.s	-4.175000,0.000000,3.200000
	dc.s	-4.175000,0.000000,0.700000
	dc.s	-4.912500,0.000000,3.200000
	dc.s	-4.912500,0.000000,1.950000
	dc.s	-4.175000,0.000000,1.950000
	dc.s	-5.650000,0.000000,1.950000
	dc.s	-4.912500,0.000000,0.700000
	dc.s	-4.912500,0.000000,-0.550000
	dc.s	-4.175000,0.000000,-0.550000
	dc.s	-5.650000,0.000000,-0.550000
	dc.s	-4.912500,0.000000,-1.800000
	dc.s	-3.437500,0.000000,0.700000
	dc.s	-3.437500,0.000000,-0.550000
	dc.s	-2.700000,0.000000,-0.550000
	dc.s	-3.437500,0.000000,-1.800000
	dc.s	-3.437500,0.000000,3.200000
	dc.s	-3.437500,0.000000,1.950000
	dc.s	-2.700000,0.000000,1.950000
	dc.s	-5.650000,0.000000,3.200000
	dc.s	-2.700000,0.000000,3.200000
	dc.s	-2.700000,0.000000,-1.800000
	dc.s	-5.650000,0.000000,-1.800000
	dc.s	-5.650000,0.000000,0.700000
	dc.s	-4.175000,0.000000,-1.800000
faces_hisp:				;f1,f2,f3 , tf1,tf2,tf3 , texnum , flag
	dc.w 0,10,1,  0,1,2,  0,0
	dc.w 10,20,1,  3,4,5,  0,0
	dc.w 19,9,22,  6,7,8,  0,0
	dc.w 9,20,10,  9,10,11,  0,0
	dc.w 22,10,0,  12,13,14,  0,0
	dc.w 22,9,10,  15,16,17,  0,0
	dc.w 21,24,23,  18,19,20,  0,0
	dc.w 24,19,22,  21,22,23,  0,0
	dc.w 23,22,0,  24,25,26,  0,0
	dc.w 24,22,23,  27,28,29,  0,0
	dc.w 16,25,27,  30,31,32,  0,0
	dc.w 25,2,26,  33,34,35,  0,0
	dc.w 27,26,4,  36,37,38,  0,0
	dc.w 27,25,26,  39,40,41,  0,0
	dc.w 2,28,30,  42,43,44,  0,0
	dc.w 28,15,29,  45,46,47,  0,0
	dc.w 30,29,3,  48,49,50,  0,0
	dc.w 30,28,29,  51,52,53,  0,0
	dc.w 4,31,33,  54,55,56,  0,0
	dc.w 31,3,32,  57,58,59,  0,0
	dc.w 33,32,17,  60,61,62,  0,0
	dc.w 33,31,32,  63,64,65,  0,0
	dc.w 4,26,31,  66,67,68,  0,0
	dc.w 26,2,30,  69,70,71,  0,0
	dc.w 31,30,3,  72,73,74,  0,0
	dc.w 26,30,31,  75,76,77,  0,0
	dc.w 14,34,36,  78,79,80,  0,0
	dc.w 34,5,35,  81,82,83,  0,0
	dc.w 36,35,6,  84,85,86,  0,0
	dc.w 36,34,35,  87,88,89,  0,0
	dc.w 5,37,38,  90,91,92,  0,0
	dc.w 37,15,28,  93,94,95,  0,0
	dc.w 38,28,2,  96,97,98,  0,0
	dc.w 38,37,28,  99,100,101,  0,0
	dc.w 6,39,40,  102,103,104,  0,0
	dc.w 39,2,25,  105,106,107,  0,0
	dc.w 40,25,16,  108,109,110,  0,0
	dc.w 40,39,25,  111,112,113,  0,0
	dc.w 6,35,39,  114,115,116,  0,0
	dc.w 35,5,38,  117,118,119,  0,0
	dc.w 39,38,2,  120,121,122,  0,0
	dc.w 35,38,39,  123,124,125,  0,0
	dc.w 18,43,41,  126,127,128,  0,0
	dc.w 43,8,44,  129,130,131,  0,0
	dc.w 41,44,7,  132,133,134,  0,0
	dc.w 43,44,41,  135,136,137,  0,0
	dc.w 8,11,12,  138,139,140,  0,0
	dc.w 11,14,36,  141,142,143,  0,0
	dc.w 12,36,6,  144,145,146,  0,0
	dc.w 11,36,12,  147,148,149,  0,0
	dc.w 7,13,42,  150,151,152,  0,0
	dc.w 13,6,40,  153,154,155,  0,0
	dc.w 42,40,16,  156,157,158,  0,0
	dc.w 13,40,42,  159,160,161,  0,0
	dc.w 8,12,44,  162,163,164,  0,0
	dc.w 12,6,13,  165,166,167,  0,0
	dc.w 44,13,7,  168,169,170,  0,0
	dc.w 44,12,13,  171,172,173,  0,0
	dc.w 61,62,74,  174,175,176,  1,0
	dc.w 74,62,51,  177,178,179,  1,0
	dc.w 52,70,72,  180,181,182,  1,0
	dc.w 70,51,71,  183,184,185,  1,0
	dc.w 72,71,50,  186,187,188,  1,0
	dc.w 72,70,71,  189,190,191,  1,0
	dc.w 52,73,70,  192,193,194,  1,0
	dc.w 73,61,74,  195,196,197,  1,0
	dc.w 73,74,70,  198,199,200,  1,0
	dc.w 47,75,78,  201,202,203,  1,0
	dc.w 75,63,77,  204,205,206,  1,0
	dc.w 78,77,65,  207,208,209,  1,0
	dc.w 75,77,78,  210,211,212,  1,0
	dc.w 63,76,80,  213,214,215,  1,0
	dc.w 76,48,79,  216,217,218,  1,0
	dc.w 80,79,64,  219,220,221,  1,0
	dc.w 76,79,80,  222,223,224,  1,0
	dc.w 65,81,83,  225,226,227,  1,0
	dc.w 81,64,82,  228,229,230,  1,0
	dc.w 83,82,46,  231,232,233,  1,0
	dc.w 81,82,83,  234,235,236,  1,0
	dc.w 63,80,77,  237,238,239,  1,0
	dc.w 80,64,81,  240,241,242,  1,0
	dc.w 77,81,65,  243,244,245,  1,0
	dc.w 77,80,81,  246,247,248,  1,0
	dc.w 45,84,86,  249,250,251,  1,0
	dc.w 84,66,85,  252,253,254,  1,0
	dc.w 86,85,67,  255,256,257,  1,0
	dc.w 84,85,86,  258,259,260,  1,0
	dc.w 66,87,88,  261,262,263,  1,0
	dc.w 87,47,78,  264,265,266,  1,0
	dc.w 88,78,65,  267,268,269,  1,0
	dc.w 87,78,88,  270,271,272,  1,0
	dc.w 67,89,90,  273,274,275,  1,0
	dc.w 89,65,83,  276,277,278,  1,0
	dc.w 90,83,46,  279,280,281,  1,0
	dc.w 89,83,90,  282,283,284,  1,0
	dc.w 66,88,85,  285,286,287,  1,0
	dc.w 88,65,89,  288,289,290,  1,0
	dc.w 85,89,67,  291,292,293,  1,0
	dc.w 85,88,89,  294,295,296,  1,0
	dc.w 49,91,53,  297,298,299,  1,0
	dc.w 91,68,92,  300,301,302,  1,0
	dc.w 53,92,69,  303,304,305,  1,0
	dc.w 53,91,92,  306,307,308,  1,0
	dc.w 68,54,55,  309,310,311,  1,0
	dc.w 54,47,87,  312,313,314,  1,0
	dc.w 55,87,66,  315,316,317,  1,0
	dc.w 55,54,87,  318,319,320,  1,0
	dc.w 69,56,57,  321,322,323,  1,0
	dc.w 56,66,84,  324,325,326,  1,0
	dc.w 57,84,45,  327,328,329,  1,0
	dc.w 57,56,84,  330,331,332,  1,0
	dc.w 69,92,56,  333,334,335,  1,0
	dc.w 92,68,55,  336,337,338,  1,0
	dc.w 56,55,66,  339,340,341,  1,0
	dc.w 92,55,56,  342,343,344,  1,0
	dc.w 59,60,58,  345,346,347,  1,0
	dc.w 101,110,112,  348,349,350,  2,0
	dc.w 110,105,111,  351,352,353,  2,0
	dc.w 112,111,107,  354,355,356,  2,0
	dc.w 110,111,112,  357,358,359,  2,0
	dc.w 105,113,115,  360,361,362,  2,0
	dc.w 113,102,114,  363,364,365,  2,0
	dc.w 115,114,106,  366,367,368,  2,0
	dc.w 113,114,115,  369,370,371,  2,0
	dc.w 107,116,93,  372,373,374,  2,0
	dc.w 116,106,117,  375,376,377,  2,0
	dc.w 93,117,104,  378,379,380,  2,0
	dc.w 116,117,93,  381,382,383,  2,0
	dc.w 105,115,111,  384,385,386,  2,0
	dc.w 115,106,116,  387,388,389,  2,0
	dc.w 111,116,107,  390,391,392,  2,0
	dc.w 111,115,116,  393,394,395,  2,0
	dc.w 101,112,95,  396,397,398,  2,0
	dc.w 112,107,94,  399,400,401,  2,0
	dc.w 95,94,109,  402,403,404,  2,0
	dc.w 95,112,94,  405,406,407,  2,0
	dc.w 107,93,97,  408,409,410,  2,0
	dc.w 93,104,96,  411,412,413,  2,0
	dc.w 97,96,108,  414,415,416,  2,0
	dc.w 97,93,96,  417,418,419,  2,0
	dc.w 109,98,100,  420,421,422,  2,0
	dc.w 98,108,99,  423,424,425,  2,0
	dc.w 100,99,103,  426,427,428,  2,0
	dc.w 100,98,99,  429,430,431,  2,0
	dc.w 109,94,98,  432,433,434,  2,0
	dc.w 94,107,97,  435,436,437,  2,0
	dc.w 98,97,108,  438,439,440,  2,0
	dc.w 94,97,98,  441,442,443,  2,0
	dc.w 180,142,164,  444,445,446,  3,0
	dc.w 180,166,141,  447,448,449,  3,0
	dc.w 141,168,142,  450,451,452,  3,0
	dc.w 180,141,142,  453,454,455,  3,0
	dc.w 166,143,145,  456,457,458,  3,0
	dc.w 143,160,144,  459,460,461,  3,0
	dc.w 145,144,167,  462,463,464,  3,0
	dc.w 143,144,145,  465,466,467,  3,0
	dc.w 146,148,168,  468,469,470,  3,0
	dc.w 146,167,147,  471,472,473,  3,0
	dc.w 147,165,148,  474,475,476,  3,0
	dc.w 146,147,148,  477,478,479,  3,0
	dc.w 166,145,141,  480,481,482,  3,0
	dc.w 145,167,146,  483,484,485,  3,0
	dc.w 141,146,168,  486,487,488,  3,0
	dc.w 141,145,146,  489,490,491,  3,0
	dc.w 160,149,144,  492,493,494,  3,0
	dc.w 149,169,150,  495,496,497,  3,0
	dc.w 144,150,167,  498,499,500,  3,0
	dc.w 144,149,150,  501,502,503,  3,0
	dc.w 169,151,153,  504,505,506,  3,0
	dc.w 151,162,152,  507,508,509,  3,0
	dc.w 153,152,170,  510,511,512,  3,0
	dc.w 153,151,152,  513,514,515,  3,0
	dc.w 167,154,147,  516,517,518,  3,0
	dc.w 154,170,155,  519,520,521,  3,0
	dc.w 147,155,165,  522,523,524,  3,0
	dc.w 147,154,155,  525,526,527,  3,0
	dc.w 167,150,154,  528,529,530,  3,0
	dc.w 150,169,153,  531,532,533,  3,0
	dc.w 154,153,170,  534,535,536,  3,0
	dc.w 150,153,154,  537,538,539,  3,0
	dc.w 155,157,165,  540,541,542,  3,0
	dc.w 155,170,156,  543,544,545,  3,0
	dc.w 156,172,157,  546,547,548,  3,0
	dc.w 155,156,157,  549,550,551,  3,0
	dc.w 170,152,159,  552,553,554,  3,0
	dc.w 152,162,158,  555,556,557,  3,0
	dc.w 159,158,171,  558,559,560,  3,0
	dc.w 152,158,159,  561,562,563,  3,0
	dc.w 118,120,172,  564,565,566,  3,0
	dc.w 118,171,119,  567,568,569,  3,0
	dc.w 119,163,120,  570,571,572,  3,0
	dc.w 118,119,120,  573,574,575,  3,0
	dc.w 170,159,156,  576,577,578,  3,0
	dc.w 159,171,118,  579,580,581,  3,0
	dc.w 156,118,172,  582,583,584,  3,0
	dc.w 156,159,118,  585,586,587,  3,0
	dc.w 162,121,158,  588,589,590,  3,0
	dc.w 121,173,122,  591,592,593,  3,0
	dc.w 158,122,171,  594,595,596,  3,0
	dc.w 158,121,122,  597,598,599,  3,0
	dc.w 173,123,125,  600,601,602,  3,0
	dc.w 123,161,124,  603,604,605,  3,0
	dc.w 125,124,174,  606,607,608,  3,0
	dc.w 125,123,124,  609,610,611,  3,0
	dc.w 171,126,119,  612,613,614,  3,0
	dc.w 126,174,127,  615,616,617,  3,0
	dc.w 119,127,163,  618,619,620,  3,0
	dc.w 119,126,127,  621,622,623,  3,0
	dc.w 171,122,126,  624,625,626,  3,0
	dc.w 122,173,125,  627,628,629,  3,0
	dc.w 126,125,174,  630,631,632,  3,0
	dc.w 122,125,126,  633,634,635,  3,0
	dc.w 165,157,129,  636,637,638,  3,0
	dc.w 157,172,128,  639,640,641,  3,0
	dc.w 129,128,176,  642,643,644,  3,0
	dc.w 129,157,128,  645,646,647,  3,0
	dc.w 172,120,131,  648,649,650,  3,0
	dc.w 120,163,130,  651,652,653,  3,0
	dc.w 131,130,175,  654,655,656,  3,0
	dc.w 131,120,130,  657,658,659,  3,0
	dc.w 176,128,132,  660,661,662,  3,0
	dc.w 128,172,131,  663,664,665,  3,0
	dc.w 132,131,175,  666,667,668,  3,0
	dc.w 128,131,132,  669,670,671,  3,0
	dc.w 175,130,134,  672,673,674,  3,0
	dc.w 130,163,133,  675,676,677,  3,0
	dc.w 134,133,177,  678,679,680,  3,0
	dc.w 130,133,134,  681,682,683,  3,0
	dc.w 164,142,136,  684,685,686,  3,0
	dc.w 142,168,135,  687,688,689,  3,0
	dc.w 136,135,179,  690,691,692,  3,0
	dc.w 136,142,135,  693,694,695,  3,0
	dc.w 168,148,138,  696,697,698,  3,0
	dc.w 148,165,137,  699,700,701,  3,0
	dc.w 138,137,178,  702,703,704,  3,0
	dc.w 138,148,137,  705,706,707,  3,0
	dc.w 179,135,139,  708,709,710,  3,0
	dc.w 135,168,138,  711,712,713,  3,0
	dc.w 139,138,178,  714,715,716,  3,0
	dc.w 135,138,139,  717,718,719,  3,0
	dc.w 178,137,140,  720,721,722,  3,0
	dc.w 137,165,129,  723,724,725,  3,0
	dc.w 140,129,176,  726,727,728,  3,0
	dc.w 137,129,140,  729,730,731,  3,0
	dc.w 207,223,187,  732,733,734,  4,0
	dc.w 223,208,187,  735,736,737,  4,0
	dc.w 223,210,208,  738,739,740,  4,0
	dc.w 210,227,211,  741,742,743,  4,0
	dc.w 208,210,188,  744,745,746,  4,0
	dc.w 210,211,188,  747,748,749,  4,0
	dc.w 206,189,213,  750,751,752,  4,0
	dc.w 189,211,213,  753,754,755,  4,0
	dc.w 211,227,212,  756,757,758,  4,0
	dc.w 213,212,228,  759,760,761,  4,0
	dc.w 211,212,213,  762,763,764,  4,0
	dc.w 227,214,212,  765,766,767,  4,0
	dc.w 214,226,215,  768,769,770,  4,0
	dc.w 212,215,228,  771,772,773,  4,0
	dc.w 212,214,215,  774,775,776,  4,0
	dc.w 204,203,218,  777,778,779,  4,0
	dc.w 203,216,218,  780,781,782,  4,0
	dc.w 216,200,217,  783,784,785,  4,0
	dc.w 200,206,217,  786,787,788,  4,0
	dc.w 218,217,225,  789,790,791,  4,0
	dc.w 216,217,218,  792,793,794,  4,0
	dc.w 206,213,217,  795,796,797,  4,0
	dc.w 213,228,219,  798,799,800,  4,0
	dc.w 217,219,225,  801,802,803,  4,0
	dc.w 217,213,219,  804,805,806,  4,0
	dc.w 205,181,183,  807,808,809,  4,0
	dc.w 181,207,182,  810,811,812,  4,0
	dc.w 183,182,209,  813,814,815,  4,0
	dc.w 181,182,183,  816,817,818,  4,0
	dc.w 209,184,186,  819,820,821,  4,0
	dc.w 184,208,185,  822,823,824,  4,0
	dc.w 186,185,206,  825,826,827,  4,0
	dc.w 184,185,186,  828,829,830,  4,0
	dc.w 207,187,182,  831,832,833,  4,0
	dc.w 187,208,184,  834,835,836,  4,0
	dc.w 182,184,209,  837,838,839,  4,0
	dc.w 182,187,184,  840,841,842,  4,0
	dc.w 208,188,185,  843,844,845,  4,0
	dc.w 188,211,189,  846,847,848,  4,0
	dc.w 185,189,206,  849,850,851,  4,0
	dc.w 185,188,189,  852,853,854,  4,0
	dc.w 224,190,192,  855,856,857,  4,0
	dc.w 190,220,191,  858,859,860,  4,0
	dc.w 192,191,222,  861,862,863,  4,0
	dc.w 190,191,192,  864,865,866,  4,0
	dc.w 220,193,195,  867,868,869,  4,0
	dc.w 193,205,194,  870,871,872,  4,0
	dc.w 195,194,221,  873,874,875,  4,0
	dc.w 193,194,195,  876,877,878,  4,0
	dc.w 222,196,198,  879,880,881,  4,0
	dc.w 196,221,197,  882,883,884,  4,0
	dc.w 198,197,204,  885,886,887,  4,0
	dc.w 196,197,198,  888,889,890,  4,0
	dc.w 220,195,191,  891,892,893,  4,0
	dc.w 195,221,196,  894,895,896,  4,0
	dc.w 191,196,222,  897,898,899,  4,0
	dc.w 191,195,196,  900,901,902,  4,0
	dc.w 205,183,194,  903,904,905,  4,0
	dc.w 183,209,199,  906,907,908,  4,0
	dc.w 194,199,221,  909,910,911,  4,0
	dc.w 194,183,199,  912,913,914,  4,0
	dc.w 209,186,201,  915,916,917,  4,0
	dc.w 186,206,200,  918,919,920,  4,0
	dc.w 201,200,216,  921,922,923,  4,0
	dc.w 201,186,200,  924,925,926,  4,0
	dc.w 221,202,197,  927,928,929,  4,0
	dc.w 202,216,203,  930,931,932,  4,0
	dc.w 197,203,204,  933,934,935,  4,0
	dc.w 197,202,203,  936,937,938,  4,0
	dc.w 221,199,202,  939,940,941,  4,0
	dc.w 199,209,201,  942,943,944,  4,0
	dc.w 202,201,216,  945,946,947,  4,0
	dc.w 199,201,202,  948,949,950,  4,0
tcoords_hisp:				;u,v
	dc.s	0.993648,0.917283
	dc.s	0.910674,0.929324
	dc.s	0.993648,0.941365
	dc.s	0.910674,0.929324
	dc.s	0.827699,0.941365
	dc.s	0.993648,0.941365
	dc.s	0.527621,0.830721
	dc.s	0.677660,0.886043
	dc.s	0.760634,0.874002
	dc.s	0.677660,0.886043
	dc.s	0.827699,0.941365
	dc.s	0.910674,0.929324
	dc.s	0.760634,0.874002
	dc.s	0.910674,0.929324
	dc.s	0.993648,0.917283
	dc.s	0.760634,0.874002
	dc.s	0.677660,0.886043
	dc.s	0.910674,0.929324
	dc.s	0.993648,0.830721
	dc.s	0.760634,0.830721
	dc.s	0.993648,0.874002
	dc.s	0.760634,0.830721
	dc.s	0.527621,0.830721
	dc.s	0.760634,0.874002
	dc.s	0.993648,0.874002
	dc.s	0.760634,0.874002
	dc.s	0.993648,0.917283
	dc.s	0.760634,0.830721
	dc.s	0.760634,0.874002
	dc.s	0.993648,0.874002
	dc.s	0.993648,0.429991
	dc.s	0.748639,0.530431
	dc.s	0.993648,0.530431
	dc.s	0.748639,0.530431
	dc.s	0.503630,0.630871
	dc.s	0.748639,0.630871
	dc.s	0.993648,0.530431
	dc.s	0.748639,0.630871
	dc.s	0.993648,0.630871
	dc.s	0.993648,0.530431
	dc.s	0.748639,0.530431
	dc.s	0.748639,0.630871
	dc.s	0.503630,0.630871
	dc.s	0.258621,0.731311
	dc.s	0.503630,0.731311
	dc.s	0.258621,0.731311
	dc.s	0.013612,0.831751
	dc.s	0.258621,0.831751
	dc.s	0.503630,0.731311
	dc.s	0.258621,0.831751
	dc.s	0.503630,0.831751
	dc.s	0.503630,0.731311
	dc.s	0.258621,0.731311
	dc.s	0.258621,0.831751
	dc.s	0.993648,0.630871
	dc.s	0.748639,0.731311
	dc.s	0.993648,0.731311
	dc.s	0.748639,0.731311
	dc.s	0.503630,0.831751
	dc.s	0.748639,0.831751
	dc.s	0.993648,0.731311
	dc.s	0.748639,0.831751
	dc.s	0.993648,0.831751
	dc.s	0.993648,0.731311
	dc.s	0.748639,0.731311
	dc.s	0.748639,0.831751
	dc.s	0.993648,0.630871
	dc.s	0.748639,0.630871
	dc.s	0.748639,0.731311
	dc.s	0.748639,0.630871
	dc.s	0.503630,0.630871
	dc.s	0.503630,0.731311
	dc.s	0.748639,0.731311
	dc.s	0.503630,0.731311
	dc.s	0.503630,0.831751
	dc.s	0.748639,0.630871
	dc.s	0.503630,0.731311
	dc.s	0.748639,0.731311
	dc.s	0.013612,0.028232
	dc.s	0.013612,0.229112
	dc.s	0.258621,0.128672
	dc.s	0.013612,0.229112
	dc.s	0.013612,0.429991
	dc.s	0.258621,0.329552
	dc.s	0.258621,0.128672
	dc.s	0.258621,0.329552
	dc.s	0.503630,0.229112
	dc.s	0.258621,0.128672
	dc.s	0.013612,0.229112
	dc.s	0.258621,0.329552
	dc.s	0.013612,0.429991
	dc.s	0.013612,0.630871
	dc.s	0.258621,0.530431
	dc.s	0.013612,0.630871
	dc.s	0.013612,0.831751
	dc.s	0.258621,0.731311
	dc.s	0.258621,0.530431
	dc.s	0.258621,0.731311
	dc.s	0.503630,0.630871
	dc.s	0.258621,0.530431
	dc.s	0.013612,0.630871
	dc.s	0.258621,0.731311
	dc.s	0.503630,0.229112
	dc.s	0.503630,0.429991
	dc.s	0.748639,0.329552
	dc.s	0.503630,0.429991
	dc.s	0.503630,0.630871
	dc.s	0.748639,0.530431
	dc.s	0.748639,0.329552
	dc.s	0.748639,0.530431
	dc.s	0.993648,0.429991
	dc.s	0.748639,0.329552
	dc.s	0.503630,0.429991
	dc.s	0.748639,0.530431
	dc.s	0.503630,0.229112
	dc.s	0.258621,0.329552
	dc.s	0.503630,0.429991
	dc.s	0.258621,0.329552
	dc.s	0.013612,0.429991
	dc.s	0.258621,0.530431
	dc.s	0.503630,0.429991
	dc.s	0.258621,0.530431
	dc.s	0.503630,0.630871
	dc.s	0.258621,0.329552
	dc.s	0.258621,0.530431
	dc.s	0.503630,0.429991
	dc.s	0.993648,0.028232
	dc.s	0.748639,0.028232
	dc.s	0.993648,0.128672
	dc.s	0.748639,0.028232
	dc.s	0.503630,0.028232
	dc.s	0.748639,0.128672
	dc.s	0.993648,0.128672
	dc.s	0.748639,0.128672
	dc.s	0.993648,0.229112
	dc.s	0.748639,0.028232
	dc.s	0.748639,0.128672
	dc.s	0.993648,0.128672
	dc.s	0.503630,0.028232
	dc.s	0.258621,0.028232
	dc.s	0.503630,0.128672
	dc.s	0.258621,0.028232
	dc.s	0.013612,0.028232
	dc.s	0.258621,0.128672
	dc.s	0.503630,0.128672
	dc.s	0.258621,0.128672
	dc.s	0.503630,0.229112
	dc.s	0.258621,0.028232
	dc.s	0.258621,0.128672
	dc.s	0.503630,0.128672
	dc.s	0.993648,0.229112
	dc.s	0.748639,0.229112
	dc.s	0.993648,0.329552
	dc.s	0.748639,0.229112
	dc.s	0.503630,0.229112
	dc.s	0.748639,0.329552
	dc.s	0.993648,0.329552
	dc.s	0.748639,0.329552
	dc.s	0.993648,0.429991
	dc.s	0.748639,0.229112
	dc.s	0.748639,0.329552
	dc.s	0.993648,0.329552
	dc.s	0.503630,0.028232
	dc.s	0.503630,0.128672
	dc.s	0.748639,0.128672
	dc.s	0.503630,0.128672
	dc.s	0.503630,0.229112
	dc.s	0.748639,0.229112
	dc.s	0.748639,0.128672
	dc.s	0.748639,0.229112
	dc.s	0.993648,0.229112
	dc.s	0.748639,0.128672
	dc.s	0.503630,0.128672
	dc.s	0.748639,0.229112
	dc.s	0.000000,0.919103
	dc.s	0.000000,0.943290
	dc.s	0.066146,0.931197
	dc.s	0.066146,0.931197
	dc.s	0.000000,0.943290
	dc.s	0.132292,0.943290
	dc.s	0.000000,0.832164
	dc.s	0.066146,0.887727
	dc.s	0.219242,0.832164
	dc.s	0.066146,0.887727
	dc.s	0.132292,0.943290
	dc.s	0.285388,0.887727
	dc.s	0.219242,0.832164
	dc.s	0.285388,0.887727
	dc.s	0.438483,0.832164
	dc.s	0.219242,0.832164
	dc.s	0.066146,0.887727
	dc.s	0.285388,0.887727
	dc.s	0.000000,0.832164
	dc.s	0.000000,0.875633
	dc.s	0.066146,0.887727
	dc.s	0.000000,0.875633
	dc.s	0.000000,0.919103
	dc.s	0.066146,0.931197
	dc.s	0.000000,0.875633
	dc.s	0.066146,0.931197
	dc.s	0.066146,0.887727
	dc.s	0.000000,0.429686
	dc.s	0.000000,0.530564
	dc.s	0.250000,0.530564
	dc.s	0.000000,0.530564
	dc.s	0.000000,0.631442
	dc.s	0.250000,0.631442
	dc.s	0.250000,0.530564
	dc.s	0.250000,0.631442
	dc.s	0.500000,0.631442
	dc.s	0.000000,0.530564
	dc.s	0.250000,0.631442
	dc.s	0.250000,0.530564
	dc.s	0.000000,0.631442
	dc.s	0.000000,0.732320
	dc.s	0.250000,0.732320
	dc.s	0.000000,0.732320
	dc.s	0.000000,0.833198
	dc.s	0.250000,0.833198
	dc.s	0.250000,0.732320
	dc.s	0.250000,0.833198
	dc.s	0.500000,0.833198
	dc.s	0.000000,0.732320
	dc.s	0.250000,0.833198
	dc.s	0.250000,0.732320
	dc.s	0.500000,0.631442
	dc.s	0.500000,0.732320
	dc.s	0.750000,0.732320
	dc.s	0.500000,0.732320
	dc.s	0.500000,0.833198
	dc.s	0.750000,0.833198
	dc.s	0.750000,0.732320
	dc.s	0.750000,0.833198
	dc.s	1.000000,0.833198
	dc.s	0.500000,0.732320
	dc.s	0.750000,0.833198
	dc.s	0.750000,0.732320
	dc.s	0.000000,0.631442
	dc.s	0.250000,0.732320
	dc.s	0.250000,0.631442
	dc.s	0.250000,0.732320
	dc.s	0.500000,0.833198
	dc.s	0.500000,0.732320
	dc.s	0.250000,0.631442
	dc.s	0.500000,0.732320
	dc.s	0.500000,0.631442
	dc.s	0.250000,0.631442
	dc.s	0.250000,0.732320
	dc.s	0.500000,0.732320
	dc.s	1.000000,0.026174
	dc.s	0.750000,0.127052
	dc.s	1.000000,0.227930
	dc.s	0.750000,0.127052
	dc.s	0.500000,0.227930
	dc.s	0.750000,0.328808
	dc.s	1.000000,0.227930
	dc.s	0.750000,0.328808
	dc.s	1.000000,0.429686
	dc.s	0.750000,0.127052
	dc.s	0.750000,0.328808
	dc.s	1.000000,0.227930
	dc.s	0.500000,0.227930
	dc.s	0.250000,0.328808
	dc.s	0.500000,0.429686
	dc.s	0.250000,0.328808
	dc.s	0.000000,0.429686
	dc.s	0.250000,0.530564
	dc.s	0.500000,0.429686
	dc.s	0.250000,0.530564
	dc.s	0.500000,0.631442
	dc.s	0.250000,0.328808
	dc.s	0.250000,0.530564
	dc.s	0.500000,0.429686
	dc.s	1.000000,0.429686
	dc.s	0.750000,0.530564
	dc.s	1.000000,0.631442
	dc.s	0.750000,0.530564
	dc.s	0.500000,0.631442
	dc.s	0.750000,0.732320
	dc.s	1.000000,0.631442
	dc.s	0.750000,0.732320
	dc.s	1.000000,0.833198
	dc.s	0.750000,0.530564
	dc.s	0.750000,0.732320
	dc.s	1.000000,0.631442
	dc.s	0.500000,0.227930
	dc.s	0.500000,0.429686
	dc.s	0.750000,0.328808
	dc.s	0.500000,0.429686
	dc.s	0.500000,0.631442
	dc.s	0.750000,0.530564
	dc.s	0.750000,0.328808
	dc.s	0.750000,0.530564
	dc.s	1.000000,0.429686
	dc.s	0.750000,0.328808
	dc.s	0.500000,0.429686
	dc.s	0.750000,0.530564
	dc.s	0.000000,0.026174
	dc.s	0.000000,0.127052
	dc.s	0.250000,0.026174
	dc.s	0.000000,0.127052
	dc.s	0.000000,0.227930
	dc.s	0.250000,0.127052
	dc.s	0.250000,0.026174
	dc.s	0.250000,0.127052
	dc.s	0.500000,0.026174
	dc.s	0.250000,0.026174
	dc.s	0.000000,0.127052
	dc.s	0.250000,0.127052
	dc.s	0.000000,0.227930
	dc.s	0.000000,0.328808
	dc.s	0.250000,0.227930
	dc.s	0.000000,0.328808
	dc.s	0.000000,0.429686
	dc.s	0.250000,0.328808
	dc.s	0.250000,0.227930
	dc.s	0.250000,0.328808
	dc.s	0.500000,0.227930
	dc.s	0.250000,0.227930
	dc.s	0.000000,0.328808
	dc.s	0.250000,0.328808
	dc.s	0.500000,0.026174
	dc.s	0.500000,0.127052
	dc.s	0.750000,0.026174
	dc.s	0.500000,0.127052
	dc.s	0.500000,0.227930
	dc.s	0.750000,0.127052
	dc.s	0.750000,0.026174
	dc.s	0.750000,0.127052
	dc.s	1.000000,0.026174
	dc.s	0.750000,0.026174
	dc.s	0.500000,0.127052
	dc.s	0.750000,0.127052
	dc.s	0.500000,0.026174
	dc.s	0.250000,0.127052
	dc.s	0.500000,0.127052
	dc.s	0.250000,0.127052
	dc.s	0.000000,0.227930
	dc.s	0.250000,0.227930
	dc.s	0.500000,0.127052
	dc.s	0.250000,0.227930
	dc.s	0.500000,0.227930
	dc.s	0.250000,0.127052
	dc.s	0.250000,0.227930
	dc.s	0.500000,0.127052
	dc.s	0.066146,0.887727
	dc.s	0.066146,0.931197
	dc.s	0.132292,0.943290
	dc.s	0.891221,0.001348
	dc.s	0.695611,0.001348
	dc.s	0.695611,0.250674
	dc.s	0.695611,0.001348
	dc.s	0.500000,0.001348
	dc.s	0.500000,0.250674
	dc.s	0.695611,0.250674
	dc.s	0.500000,0.250674
	dc.s	0.500000,0.500000
	dc.s	0.695611,0.001348
	dc.s	0.500000,0.250674
	dc.s	0.695611,0.250674
	dc.s	0.500000,0.001348
	dc.s	0.304389,0.001348
	dc.s	0.304389,0.250674
	dc.s	0.304389,0.001348
	dc.s	0.108779,0.001348
	dc.s	0.108779,0.250674
	dc.s	0.304389,0.250674
	dc.s	0.108779,0.250674
	dc.s	0.108779,0.500000
	dc.s	0.304389,0.001348
	dc.s	0.108779,0.250674
	dc.s	0.304389,0.250674
	dc.s	0.500000,0.500000
	dc.s	0.304389,0.500000
	dc.s	0.304389,0.749326
	dc.s	0.304389,0.500000
	dc.s	0.108779,0.500000
	dc.s	0.108779,0.749326
	dc.s	0.304389,0.749326
	dc.s	0.108779,0.749326
	dc.s	0.108779,0.998652
	dc.s	0.304389,0.500000
	dc.s	0.108779,0.749326
	dc.s	0.304389,0.749326
	dc.s	0.500000,0.001348
	dc.s	0.304389,0.250674
	dc.s	0.500000,0.250674
	dc.s	0.304389,0.250674
	dc.s	0.108779,0.500000
	dc.s	0.304389,0.500000
	dc.s	0.500000,0.250674
	dc.s	0.304389,0.500000
	dc.s	0.500000,0.500000
	dc.s	0.500000,0.250674
	dc.s	0.304389,0.250674
	dc.s	0.304389,0.500000
	dc.s	0.891221,0.001348
	dc.s	0.695611,0.250674
	dc.s	0.891221,0.250674
	dc.s	0.695611,0.250674
	dc.s	0.500000,0.500000
	dc.s	0.695611,0.500000
	dc.s	0.891221,0.250674
	dc.s	0.695611,0.500000
	dc.s	0.891221,0.500000
	dc.s	0.891221,0.250674
	dc.s	0.695611,0.250674
	dc.s	0.695611,0.500000
	dc.s	0.500000,0.500000
	dc.s	0.304389,0.749326
	dc.s	0.500000,0.749326
	dc.s	0.304389,0.749326
	dc.s	0.108779,0.998652
	dc.s	0.304389,0.998652
	dc.s	0.500000,0.749326
	dc.s	0.304389,0.998652
	dc.s	0.500000,0.998652
	dc.s	0.500000,0.749326
	dc.s	0.304389,0.749326
	dc.s	0.304389,0.998652
	dc.s	0.891221,0.500000
	dc.s	0.695611,0.749326
	dc.s	0.891221,0.749326
	dc.s	0.695611,0.749326
	dc.s	0.500000,0.998652
	dc.s	0.695611,0.998652
	dc.s	0.891221,0.749326
	dc.s	0.695611,0.998652
	dc.s	0.891221,0.998652
	dc.s	0.891221,0.749326
	dc.s	0.695611,0.749326
	dc.s	0.695611,0.998652
	dc.s	0.891221,0.500000
	dc.s	0.695611,0.500000
	dc.s	0.695611,0.749326
	dc.s	0.695611,0.500000
	dc.s	0.500000,0.500000
	dc.s	0.500000,0.749326
	dc.s	0.695611,0.749326
	dc.s	0.500000,0.749326
	dc.s	0.500000,0.998652
	dc.s	0.695611,0.500000
	dc.s	0.500000,0.749326
	dc.s	0.695611,0.749326
	dc.s	0.475000,0.000000
	dc.s	0.633333,0.125000
	dc.s	0.633333,0.000000
	dc.s	0.475000,0.000000
	dc.s	0.316667,0.000000
	dc.s	0.475000,0.125000
	dc.s	0.475000,0.125000
	dc.s	0.633333,0.250000
	dc.s	0.633333,0.125000
	dc.s	0.475000,0.000000
	dc.s	0.475000,0.125000
	dc.s	0.633333,0.125000
	dc.s	0.316667,0.000000
	dc.s	0.158333,0.000000
	dc.s	0.316667,0.125000
	dc.s	0.158333,0.000000
	dc.s	0.000000,0.000000
	dc.s	0.158333,0.125000
	dc.s	0.316667,0.125000
	dc.s	0.158333,0.125000
	dc.s	0.316667,0.250000
	dc.s	0.158333,0.000000
	dc.s	0.158333,0.125000
	dc.s	0.316667,0.125000
	dc.s	0.475000,0.250000
	dc.s	0.633333,0.375000
	dc.s	0.633333,0.250000
	dc.s	0.475000,0.250000
	dc.s	0.316667,0.250000
	dc.s	0.475000,0.375000
	dc.s	0.475000,0.375000
	dc.s	0.633333,0.500000
	dc.s	0.633333,0.375000
	dc.s	0.475000,0.250000
	dc.s	0.475000,0.375000
	dc.s	0.633333,0.375000
	dc.s	0.316667,0.000000
	dc.s	0.316667,0.125000
	dc.s	0.475000,0.125000
	dc.s	0.316667,0.125000
	dc.s	0.316667,0.250000
	dc.s	0.475000,0.250000
	dc.s	0.475000,0.125000
	dc.s	0.475000,0.250000
	dc.s	0.633333,0.250000
	dc.s	0.475000,0.125000
	dc.s	0.316667,0.125000
	dc.s	0.475000,0.250000
	dc.s	0.000000,0.000000
	dc.s	0.000000,0.125000
	dc.s	0.158333,0.125000
	dc.s	0.000000,0.125000
	dc.s	0.000000,0.250000
	dc.s	0.158333,0.250000
	dc.s	0.158333,0.125000
	dc.s	0.158333,0.250000
	dc.s	0.316667,0.250000
	dc.s	0.158333,0.125000
	dc.s	0.000000,0.125000
	dc.s	0.158333,0.250000
	dc.s	0.000000,0.250000
	dc.s	0.000000,0.375000
	dc.s	0.158333,0.375000
	dc.s	0.000000,0.375000
	dc.s	0.000000,0.500000
	dc.s	0.158333,0.500000
	dc.s	0.158333,0.375000
	dc.s	0.158333,0.500000
	dc.s	0.316667,0.500000
	dc.s	0.158333,0.375000
	dc.s	0.000000,0.375000
	dc.s	0.158333,0.500000
	dc.s	0.316667,0.250000
	dc.s	0.316667,0.375000
	dc.s	0.475000,0.375000
	dc.s	0.316667,0.375000
	dc.s	0.316667,0.500000
	dc.s	0.475000,0.500000
	dc.s	0.475000,0.375000
	dc.s	0.475000,0.500000
	dc.s	0.633333,0.500000
	dc.s	0.475000,0.375000
	dc.s	0.316667,0.375000
	dc.s	0.475000,0.500000
	dc.s	0.316667,0.250000
	dc.s	0.158333,0.250000
	dc.s	0.316667,0.375000
	dc.s	0.158333,0.250000
	dc.s	0.000000,0.250000
	dc.s	0.158333,0.375000
	dc.s	0.316667,0.375000
	dc.s	0.158333,0.375000
	dc.s	0.316667,0.500000
	dc.s	0.158333,0.250000
	dc.s	0.158333,0.375000
	dc.s	0.316667,0.375000
	dc.s	0.475000,0.500000
	dc.s	0.633333,0.625000
	dc.s	0.633333,0.500000
	dc.s	0.475000,0.500000
	dc.s	0.316667,0.500000
	dc.s	0.475000,0.625000
	dc.s	0.475000,0.625000
	dc.s	0.633333,0.750000
	dc.s	0.633333,0.625000
	dc.s	0.475000,0.500000
	dc.s	0.475000,0.625000
	dc.s	0.633333,0.625000
	dc.s	0.316667,0.500000
	dc.s	0.158333,0.500000
	dc.s	0.316667,0.625000
	dc.s	0.158333,0.500000
	dc.s	0.000000,0.500000
	dc.s	0.158333,0.625000
	dc.s	0.316667,0.625000
	dc.s	0.158333,0.625000
	dc.s	0.316667,0.750000
	dc.s	0.158333,0.500000
	dc.s	0.158333,0.625000
	dc.s	0.316667,0.625000
	dc.s	0.475000,0.750000
	dc.s	0.633333,0.875000
	dc.s	0.633333,0.750000
	dc.s	0.475000,0.750000
	dc.s	0.316667,0.750000
	dc.s	0.475000,0.875000
	dc.s	0.475000,0.875000
	dc.s	0.633333,1.000000
	dc.s	0.633333,0.875000
	dc.s	0.475000,0.750000
	dc.s	0.475000,0.875000
	dc.s	0.633333,0.875000
	dc.s	0.316667,0.500000
	dc.s	0.316667,0.625000
	dc.s	0.475000,0.625000
	dc.s	0.316667,0.625000
	dc.s	0.316667,0.750000
	dc.s	0.475000,0.750000
	dc.s	0.475000,0.625000
	dc.s	0.475000,0.750000
	dc.s	0.633333,0.750000
	dc.s	0.475000,0.625000
	dc.s	0.316667,0.625000
	dc.s	0.475000,0.750000
	dc.s	0.000000,0.500000
	dc.s	0.000000,0.625000
	dc.s	0.158333,0.625000
	dc.s	0.000000,0.625000
	dc.s	0.000000,0.750000
	dc.s	0.158333,0.750000
	dc.s	0.158333,0.625000
	dc.s	0.158333,0.750000
	dc.s	0.316667,0.750000
	dc.s	0.158333,0.625000
	dc.s	0.000000,0.625000
	dc.s	0.158333,0.750000
	dc.s	0.000000,0.750000
	dc.s	0.000000,0.875000
	dc.s	0.158333,0.875000
	dc.s	0.000000,0.875000
	dc.s	0.000000,1.000000
	dc.s	0.158333,1.000000
	dc.s	0.158333,0.875000
	dc.s	0.158333,1.000000
	dc.s	0.316667,1.000000
	dc.s	0.158333,0.875000
	dc.s	0.000000,0.875000
	dc.s	0.158333,1.000000
	dc.s	0.316667,0.750000
	dc.s	0.316667,0.875000
	dc.s	0.475000,0.875000
	dc.s	0.316667,0.875000
	dc.s	0.316667,1.000000
	dc.s	0.475000,1.000000
	dc.s	0.475000,0.875000
	dc.s	0.475000,1.000000
	dc.s	0.633333,1.000000
	dc.s	0.475000,0.875000
	dc.s	0.316667,0.875000
	dc.s	0.475000,1.000000
	dc.s	0.316667,0.750000
	dc.s	0.158333,0.750000
	dc.s	0.316667,0.875000
	dc.s	0.158333,0.750000
	dc.s	0.000000,0.750000
	dc.s	0.158333,0.875000
	dc.s	0.316667,0.875000
	dc.s	0.158333,0.875000
	dc.s	0.316667,1.000000
	dc.s	0.158333,0.750000
	dc.s	0.158333,0.875000
	dc.s	0.316667,0.875000
	dc.s	0.633333,0.500000
	dc.s	0.633333,0.625000
	dc.s	0.816667,0.500000
	dc.s	0.633333,0.625000
	dc.s	0.633333,0.750000
	dc.s	0.816667,0.625000
	dc.s	0.816667,0.500000
	dc.s	0.816667,0.625000
	dc.s	1.000000,0.500000
	dc.s	0.816667,0.500000
	dc.s	0.633333,0.625000
	dc.s	0.816667,0.625000
	dc.s	0.633333,0.750000
	dc.s	0.633333,0.875000
	dc.s	0.816667,0.750000
	dc.s	0.633333,0.875000
	dc.s	0.633333,1.000000
	dc.s	0.816667,0.875000
	dc.s	0.816667,0.750000
	dc.s	0.816667,0.875000
	dc.s	1.000000,0.750000
	dc.s	0.816667,0.750000
	dc.s	0.633333,0.875000
	dc.s	0.816667,0.875000
	dc.s	1.000000,0.500000
	dc.s	0.816667,0.625000
	dc.s	1.000000,0.625000
	dc.s	0.816667,0.625000
	dc.s	0.633333,0.750000
	dc.s	0.816667,0.750000
	dc.s	1.000000,0.625000
	dc.s	0.816667,0.750000
	dc.s	1.000000,0.750000
	dc.s	0.816667,0.625000
	dc.s	0.816667,0.750000
	dc.s	1.000000,0.625000
	dc.s	1.000000,0.750000
	dc.s	0.816667,0.875000
	dc.s	1.000000,0.875000
	dc.s	0.816667,0.875000
	dc.s	0.633333,1.000000
	dc.s	0.816667,1.000000
	dc.s	1.000000,0.875000
	dc.s	0.816667,1.000000
	dc.s	1.000000,1.000000
	dc.s	0.816667,0.875000
	dc.s	0.816667,1.000000
	dc.s	1.000000,0.875000
	dc.s	0.633333,0.000000
	dc.s	0.633333,0.125000
	dc.s	0.816667,0.000000
	dc.s	0.633333,0.125000
	dc.s	0.633333,0.250000
	dc.s	0.816667,0.125000
	dc.s	0.816667,0.000000
	dc.s	0.816667,0.125000
	dc.s	1.000000,0.000000
	dc.s	0.816667,0.000000
	dc.s	0.633333,0.125000
	dc.s	0.816667,0.125000
	dc.s	0.633333,0.250000
	dc.s	0.633333,0.375000
	dc.s	0.816667,0.250000
	dc.s	0.633333,0.375000
	dc.s	0.633333,0.500000
	dc.s	0.816667,0.375000
	dc.s	0.816667,0.250000
	dc.s	0.816667,0.375000
	dc.s	1.000000,0.250000
	dc.s	0.816667,0.250000
	dc.s	0.633333,0.375000
	dc.s	0.816667,0.375000
	dc.s	1.000000,0.000000
	dc.s	0.816667,0.125000
	dc.s	1.000000,0.125000
	dc.s	0.816667,0.125000
	dc.s	0.633333,0.250000
	dc.s	0.816667,0.250000
	dc.s	1.000000,0.125000
	dc.s	0.816667,0.250000
	dc.s	1.000000,0.250000
	dc.s	0.816667,0.125000
	dc.s	0.816667,0.250000
	dc.s	1.000000,0.125000
	dc.s	1.000000,0.250000
	dc.s	0.816667,0.375000
	dc.s	1.000000,0.375000
	dc.s	0.816667,0.375000
	dc.s	0.633333,0.500000
	dc.s	0.816667,0.500000
	dc.s	1.000000,0.375000
	dc.s	0.816667,0.500000
	dc.s	1.000000,0.500000
	dc.s	0.816667,0.375000
	dc.s	0.816667,0.500000
	dc.s	1.000000,0.375000
	dc.s	0.250000,-0.000000
	dc.s	0.000000,-0.000000
	dc.s	0.250000,0.125000
	dc.s	0.000000,-0.000000
	dc.s	0.250000,0.250000
	dc.s	0.250000,0.125000
	dc.s	0.000000,-0.000000
	dc.s	0.000000,0.250000
	dc.s	0.250000,0.250000
	dc.s	0.000000,0.250000
	dc.s	0.000000,0.500000
	dc.s	0.250000,0.500000
	dc.s	0.250000,0.250000
	dc.s	0.000000,0.250000
	dc.s	0.250000,0.375000
	dc.s	0.000000,0.250000
	dc.s	0.250000,0.500000
	dc.s	0.250000,0.375000
	dc.s	0.500000,0.500000
	dc.s	0.375000,0.500000
	dc.s	0.500000,0.750000
	dc.s	0.375000,0.500000
	dc.s	0.250000,0.500000
	dc.s	0.500000,0.750000
	dc.s	0.250000,0.500000
	dc.s	0.000000,0.500000
	dc.s	0.250000,0.750000
	dc.s	0.500000,0.750000
	dc.s	0.250000,0.750000
	dc.s	0.500000,1.000000
	dc.s	0.250000,0.500000
	dc.s	0.250000,0.750000
	dc.s	0.500000,0.750000
	dc.s	0.000000,0.500000
	dc.s	0.000000,0.750000
	dc.s	0.250000,0.750000
	dc.s	0.000000,0.750000
	dc.s	0.000000,1.000000
	dc.s	0.250000,1.000000
	dc.s	0.250000,0.750000
	dc.s	0.250000,1.000000
	dc.s	0.500000,1.000000
	dc.s	0.250000,0.750000
	dc.s	0.000000,0.750000
	dc.s	0.250000,1.000000
	dc.s	1.000000,0.500000
	dc.s	0.875000,0.500000
	dc.s	1.000000,0.750000
	dc.s	0.875000,0.500000
	dc.s	0.750000,0.500000
	dc.s	1.000000,0.750000
	dc.s	0.750000,0.500000
	dc.s	0.625000,0.500000
	dc.s	0.750000,0.750000
	dc.s	0.625000,0.500000
	dc.s	0.500000,0.500000
	dc.s	0.750000,0.750000
	dc.s	1.000000,0.750000
	dc.s	0.750000,0.750000
	dc.s	1.000000,1.000000
	dc.s	0.750000,0.500000
	dc.s	0.750000,0.750000
	dc.s	1.000000,0.750000
	dc.s	0.500000,0.500000
	dc.s	0.500000,0.750000
	dc.s	0.750000,0.750000
	dc.s	0.500000,0.750000
	dc.s	0.500000,1.000000
	dc.s	0.750000,1.000000
	dc.s	0.750000,0.750000
	dc.s	0.750000,1.000000
	dc.s	1.000000,1.000000
	dc.s	0.750000,0.750000
	dc.s	0.500000,0.750000
	dc.s	0.750000,1.000000
	dc.s	0.500000,-0.000000
	dc.s	0.375000,-0.000000
	dc.s	0.500000,0.125000
	dc.s	0.375000,-0.000000
	dc.s	0.250000,-0.000000
	dc.s	0.375000,0.125000
	dc.s	0.500000,0.125000
	dc.s	0.375000,0.125000
	dc.s	0.500000,0.250000
	dc.s	0.375000,-0.000000
	dc.s	0.375000,0.125000
	dc.s	0.500000,0.125000
	dc.s	0.500000,0.250000
	dc.s	0.375000,0.250000
	dc.s	0.500000,0.375000
	dc.s	0.375000,0.250000
	dc.s	0.250000,0.250000
	dc.s	0.375000,0.375000
	dc.s	0.500000,0.375000
	dc.s	0.375000,0.375000
	dc.s	0.500000,0.500000
	dc.s	0.375000,0.250000
	dc.s	0.375000,0.375000
	dc.s	0.500000,0.375000
	dc.s	0.250000,-0.000000
	dc.s	0.250000,0.125000
	dc.s	0.375000,0.125000
	dc.s	0.250000,0.125000
	dc.s	0.250000,0.250000
	dc.s	0.375000,0.250000
	dc.s	0.375000,0.125000
	dc.s	0.375000,0.250000
	dc.s	0.500000,0.250000
	dc.s	0.375000,0.125000
	dc.s	0.250000,0.125000
	dc.s	0.375000,0.250000
	dc.s	0.250000,0.250000
	dc.s	0.250000,0.375000
	dc.s	0.375000,0.375000
	dc.s	0.250000,0.375000
	dc.s	0.250000,0.500000
	dc.s	0.375000,0.500000
	dc.s	0.375000,0.375000
	dc.s	0.375000,0.500000
	dc.s	0.500000,0.500000
	dc.s	0.375000,0.375000
	dc.s	0.250000,0.375000
	dc.s	0.375000,0.500000
	dc.s	1.000000,-0.000000
	dc.s	0.875000,-0.000000
	dc.s	1.000000,0.125000
	dc.s	0.875000,-0.000000
	dc.s	0.750000,-0.000000
	dc.s	0.875000,0.125000
	dc.s	1.000000,0.125000
	dc.s	0.875000,0.125000
	dc.s	1.000000,0.250000
	dc.s	0.875000,-0.000000
	dc.s	0.875000,0.125000
	dc.s	1.000000,0.125000
	dc.s	0.750000,-0.000000
	dc.s	0.625000,-0.000000
	dc.s	0.750000,0.125000
	dc.s	0.625000,-0.000000
	dc.s	0.500000,-0.000000
	dc.s	0.625000,0.125000
	dc.s	0.750000,0.125000
	dc.s	0.625000,0.125000
	dc.s	0.750000,0.250000
	dc.s	0.625000,-0.000000
	dc.s	0.625000,0.125000
	dc.s	0.750000,0.125000
	dc.s	1.000000,0.250000
	dc.s	0.875000,0.250000
	dc.s	1.000000,0.375000
	dc.s	0.875000,0.250000
	dc.s	0.750000,0.250000
	dc.s	0.875000,0.375000
	dc.s	1.000000,0.375000
	dc.s	0.875000,0.375000
	dc.s	1.000000,0.500000
	dc.s	0.875000,0.250000
	dc.s	0.875000,0.375000
	dc.s	1.000000,0.375000
	dc.s	0.750000,-0.000000
	dc.s	0.750000,0.125000
	dc.s	0.875000,0.125000
	dc.s	0.750000,0.125000
	dc.s	0.750000,0.250000
	dc.s	0.875000,0.250000
	dc.s	0.875000,0.125000
	dc.s	0.875000,0.250000
	dc.s	1.000000,0.250000
	dc.s	0.875000,0.125000
	dc.s	0.750000,0.125000
	dc.s	0.875000,0.250000
	dc.s	0.500000,-0.000000
	dc.s	0.500000,0.125000
	dc.s	0.625000,0.125000
	dc.s	0.500000,0.125000
	dc.s	0.500000,0.250000
	dc.s	0.625000,0.250000
	dc.s	0.625000,0.125000
	dc.s	0.625000,0.250000
	dc.s	0.750000,0.250000
	dc.s	0.625000,0.125000
	dc.s	0.500000,0.125000
	dc.s	0.625000,0.250000
	dc.s	0.500000,0.250000
	dc.s	0.500000,0.375000
	dc.s	0.625000,0.375000
	dc.s	0.500000,0.375000
	dc.s	0.500000,0.500000
	dc.s	0.625000,0.500000
	dc.s	0.625000,0.375000
	dc.s	0.625000,0.500000
	dc.s	0.750000,0.500000
	dc.s	0.625000,0.375000
	dc.s	0.500000,0.375000
	dc.s	0.625000,0.500000
	dc.s	0.750000,0.250000
	dc.s	0.750000,0.375000
	dc.s	0.875000,0.375000
	dc.s	0.750000,0.375000
	dc.s	0.750000,0.500000
	dc.s	0.875000,0.500000
	dc.s	0.875000,0.375000
	dc.s	0.875000,0.500000
	dc.s	1.000000,0.500000
	dc.s	0.875000,0.375000
	dc.s	0.750000,0.375000
	dc.s	0.875000,0.500000
	dc.s	0.750000,0.250000
	dc.s	0.625000,0.250000
	dc.s	0.750000,0.375000
	dc.s	0.625000,0.250000
	dc.s	0.500000,0.250000
	dc.s	0.625000,0.375000
	dc.s	0.750000,0.375000
	dc.s	0.625000,0.375000
	dc.s	0.750000,0.500000
	dc.s	0.625000,0.250000
	dc.s	0.625000,0.375000
	dc.s	0.750000,0.375000
