music	incbin	music.mdk

tf0	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000

tf1	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000

tf2	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000

tf3	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000
	dc.w	$000,$000,$000,$000,$000,$000,$000,$000,$000,$000,$000

col2	dc.b	$F0,0,30,$F1,0,1
	dc.b	0,3,$F0,0,24,$F1,0,4
	dc.b	0,6,$F0,0,18,$F1,0,7
	dc.b	0,9,$F0,0,12,$F1,0,10
	dc.b	0,12,$F0,0,6,$F1,0,13
	dc.b	0,15,$F0,$F1,0,16
	dc.b	0,18,$f0,0,18+50
	dc.b	0,15,$F1,$F0,0,16
	dc.b	0,12,$F1,0,6,$F0,0,13
	dc.b	0,9,$F1,0,12,$F0,0,10
	dc.b	0,6,$F1,0,18,$F0,0,7
	dc.b	0,3,$F1,0,24,$F0,0,4
	dc.b	$F1,0,30,$f0,0,1      
	dc.b	0,3,$f2,0,24,$f3,0,4
	dc.b	0,6,$f2,0,18,$f3,0,7
	dc.b	0,9,$f2,0,12,$f3,0,10
	dc.b	0,12,$f2,0,6,$f3,0,13
	dc.b	0,15,$f2,$f3,0,16
	dc.b	0,18,$f2,0,18+50
	dc.b	0,15,$f3,$f2,0,16
	dc.b	0,12,$f3,0,6,$f2,0,13
	dc.b	0,9,$f3,0,12,$f2,0,10
	dc.b	0,6,$f3,0,18,$f2,0,7
	dc.b	0,3,$f3,0,24,$f2,0,4
	dc.b	$ff
	even
	
pic1	incbin	mekannik.pc1
	even
	
pic2	incbin	gus_font.pc1
	even