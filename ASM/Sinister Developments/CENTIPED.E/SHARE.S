	dc.b	$fb
;		 0123456789012345678901234567890123456789
	dc.b	'            Shareware Details           '
	dc.b	'            =================           '
	dc.b	'                                        '
	dc.b	'This quality product has been developed '
	dc.b	'over the previous few months. It is our '
	dc.b	'intention to continue to write other    '
	dc.b	'quality products for the ATARI ST series'
	dc.b	'of computers at an affordable price.    '
	dc.b	'                                        '
	dc.b	'The registration fee for Centipede is   '
	dc.b	'five pounds sterling. By registering for'
	dc.b	'this product you will guarantee the     ' 
	dc.b	'future production of software by        ' 
	dc.b	'Sinister Developments. All registered   '
	dc.b	'users will receive our next production  '
	dc.b	'before general release.                 ' 
	dc.b	'                                        '
	dc.b	'Also available is the 68000 assembler   '
	dc.b	'source code for this program. If you    '
	dc.b	'would like to receive the source a      '
	dc.b	'registration fee of ten pounds sterling '
	dc.b	'is required.                            '
	dc.b	'                                        '
	dc.b	'          -Any key to continue-         ',-1

	dc.b	$fb
	dc.b	'Suggestions are also welcome for future '
	dc.b	'productions. You never know we may      '
	dc.b	'decide to implement your idea!          '
	dc.b	'                                        '
	dc.b	'Please make all cheques\international   '
	dc.b	'money orders\postal orders payable to   '
	dc.b	'Sinister Developments at:-              '
	dc.b	'                                        '
	dc.b	'16 (1f3) Downfield Place                '
	dc.b	'Edinburgh                               '
	dc.b	'EH11 2EL                                '
	dc.b	'Scotland                                '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'      Thankyou for your attention.      '
	dc.b	'    Sinister Developments August 1992   '
	dc.b	'                                        ',-1
