x	lea	crap(pc),a0
	lea	endc(pc),a1
.2	move.b	(a0),d0
	bmi.s	.1
	cmp.b	#$a,d0
	blt.s	.1
	sub.b	#' ',d0
.1	move.b	d0,(a0)+
	cmp.l	a0,a1
	bne.s	.2
	rts

crap	dc.b	$FF,$FB
	dc.b	'               HOW TO PLAY              '
	dc.b	'               ===========              '
	dc.b	'                                        '
	dc.b	'Use the mouse to control your ship.Press'
	dc.b	'either the left or right button to fire.'
	dc.b	'                                        '
	dc.b	'Destroy the advancing centipedes, when a'
	dc.b	'centipede has been completely destroyed '
	dc.b	'then a new one will appear and the game '
	dc.b	'will get progressively harder.          '
	dc.b	'                                        '
	dc.b	'Periodically throughout the game a bonus'
	dc.b	'wave will start. These bonus waves can  '
	dc.b	'consist of almost anything!             '
	dc.b	'                                        '
	dc.b	'The bonus wave ends after 20 seconds or '
	dc.b	'when a live has been lost.              '
	dc.b	'                                        '
	dc.b	'Beware of other creatures attacking you!'
	dc.b	$FF,$FB
	dc.b	'You start with 3 lives and are awarded a'
	dc.b	'bonus life every 20000 points.          '
	dc.b	'                                        '
	dc.b	'Scoring -   Mushroom  . . .    1 pt     '
	dc.b	'            Snail     . . .  100 pts    '
	dc.b	'            Centipede . . .  100 pts    '
	dc.b	'            Scorpion  . . .  500 pts    '
	dc.b	'            Bee       . . .  500 pts    '
	dc.b	'            Fly       . . .  500 pts    '
	dc.b	'            Spider    . . . 1000 pts    '
	dc.b	'                                        '
	dc.b	'You can abort the game at any time with '
	dc.b	'the UNDO key.                           '
	dc.b	'                                        '
	dc.b	'Pause the game with the HELP key.       '
	dc.b	'                                        '
	dc.b	'                                        '
	dc.b	'               GOOD LUCK!               '
	dc.b	$FF,$FB
	dc.b	'                CREDITS                 '
	dc.b	'                =======                 '
	dc.b	'                                        '
	dc.b	'CODING AND GRAPHICS  . . .  MIKE WATSON '
	dc.b	'                                        '
	dc.b	'CHIP FX DRIVER . . . . . .  DAVID COWAN '
	dc.b	'                                        '
	dc.b	'SOUND CHIP MUSIC . . . .  BIG ALEC (DF) '
	dc.b	'                                        '
	dc.b	'NASTY SPIDER PATHS!! . .  GORDON GIBSON '
	dc.b	'                                        '
	dc.b	'ORIGINAL COIN OP . . . . . . . .  ATARI '
	dc.b	'                                        '
	dc.b	'COIN OP CODE . . . . . . .  DONA BAILEY '
	dc.b	'                                        '
	dc.b	'LANGUAGE TRANSLATIONS  . .  JILL WATSON '
	dc.b	'                          MARSHALL DEAS '
	dc.b	'                         SHEILA FARRELL '
	dc.b	'                           SANDY MASSON '
	dc.b	'                                        '
	dc.b	$FF,$FB
	dc.b	'       SINISTER DEVLOPMENTS INTRO       '
	dc.b	'       ==========================       '
	dc.b	'                                        '
	dc.b	'CODING . . . . . . . . . .  DAVID COWAN '
	dc.b	'                                        '
	dc.b	'GRAPHICS . . . . . . . . . . . . .  FOX '
	dc.b	'                                        '
	dc.b	'MUSIC . . . . . . . . . . . . . STEWART '
	dc.b	'                                        '
	dc.b	'CONVERTED TO SOUNDTRACKER . . . . KENNY '
	dc.b	'                                        '
	dc.b	'REPLAY ROUTINE . . . . MARTIN GRIFFITHS '
	dc.b	$FF,$FB
	dc.b	'  SOFTWARE, HARDWARE & LITERATURE USED  '
	dc.b	'  ====================================  '
	dc.b	'                                        '
	dc.b	'DEVPAC2, HISOFT BASIC, NEOCHROME MASTER '
	dc.b	'                                        '
	dc.b	'ATOMIC PACKER, NOISEPACKER, FASTCOPY    '
	dc.b	'                                        '
	dc.b	'MEGA DEPACK2, KAOSDESK, NVDI            '
	dc.b	'                                        '
	DC.B	'PROTRACKER, ICD HARDDISK SOFTWARE....   '
	dc.b	'                                        '
	dc.b	'520 ST, 2.5 MEG RAM, POWER 900 DRIVE..  '
	dc.b	'                                        '
	dc.b	'ST INTERNALS, MOTOROLA 68020 AND 68030  '
	dc.b	'                                        '
	dc.b	'MICROPROCESSORS.......                  '
	dc.b	$FF
endc