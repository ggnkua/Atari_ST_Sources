; come in from right bounce mid position
y	set	314

	dc.w	y-0,120	; in from left 
	dc.w	y-2,121
	dc.w	y-4,122
	dc.w	y-6,123
	dc.w	y-8,124
	dc.w	y-10,126
	dc.w	y-12,128
	dc.w	y-14,130
	dc.w	y-16,132
	dc.w	y-18,134
	dc.w	y-20,136
	dc.w	y-22,138
	dc.w	y-24,140
	dc.w	y-26,143
	dc.w	y-28,146
	dc.w	y-30,149
	dc.w	y-32,152
	dc.w	y-34,155
	dc.w	y-36,158
	dc.w	y-38,161
	dc.w	y-40,163
	dc.w	y-42,166
	dc.w	y-44,169
	dc.w	y-46,172
	dc.w	y-48,176
	dc.w	y-50,180
	dc.w	y-52,183

	dc.w	y-52,180	; bounce up & right
	dc.w	y-54,176
	dc.w	y-56,172
	dc.w	y-58,169
	dc.w	y-60,166
	dc.w	y-62,163
	dc.w	y-64,161
	dc.w	y-66,158
	dc.w	y-68,155
	dc.w	y-70,152
	dc.w	y-72,149
	dc.w	y-74,146
	dc.w	y-76,143
	dc.w	y-78,140
	dc.w	y-80,138
	dc.w	y-82,136
	dc.w	y-84,134
	dc.w	y-86,132
	dc.w	y-88,130
	dc.w	y-90,128
	dc.w	y-92,126
	dc.w	y-94,125
	dc.w	y-96,124
	dc.w	y-98,123
	dc.w	y-100,122
	dc.w	y-102,121
	dc.w	y-104,120
	dc.w	y-106,120
	dc.w	y-108,120

	dc.w	y-110,120	bounce down & right
	dc.w	y-112,121
	dc.w	y-114,122
	dc.w	y-116,123
	dc.w	y-118,124
	dc.w	y-120,126
	dc.w	y-122,128
	dc.w	y-124,130
	dc.w	y-126,132
	dc.w	y-128,134
	dc.w	y-130,136
	dc.w	y-132,138
	dc.w	y-134,140
	dc.w	y-136,143
	dc.w	y-138,146
	dc.w	y-140,149
	dc.w	y-142,152
	dc.w	y-144,155
	dc.w	y-146,158
	dc.w	y-148,161
	dc.w	y-150,163
	dc.w	y-152,166
	dc.w	y-154,169
	dc.w	y-156,172
	dc.w	y-158,176
	dc.w	y-160,180
	dc.w	y-162,183
	dc.w	y-164,183

x	set	y-164
	rept	4
	dc.w	x,180	; bounce up
	dc.w	x,176
	dc.w	x,172
	dc.w	x,169
	dc.w	x,166
	dc.w	x,163
	dc.w	x,161
	dc.w	x,158
	dc.w	x,155
	dc.w	x,152
	dc.w	x,149
	dc.w	x,146
	dc.w	x,143
	dc.w	x,140
	dc.w	x,138
	dc.w	x,136
	dc.w	x,134
	dc.w	x,132
	dc.w	x,130
	dc.w	x,128
	dc.w	x,126
	dc.w	x,125
	dc.w	x,124
	dc.w	x,123
	dc.w	x,122
	dc.w	x,121
	dc.w	x,120
	dc.w	x,120
	dc.w	x,120
	dc.w	x,120
	dc.w	x,120

	dc.w	x,120	bounce down
	dc.w	x,121
	dc.w	x,122
	dc.w	x,123
	dc.w	x,124
	dc.w	x,126
	dc.w	x,128
	dc.w	x,130
	dc.w	x,132
	dc.w	x,134
	dc.w	x,136
	dc.w	x,138
	dc.w	x,140
	dc.w	x,143
	dc.w	x,146
	dc.w	x,149
	dc.w	x,152
	dc.w	x,155
	dc.w	x,158
	dc.w	x,161
	dc.w	x,163
	dc.w	x,166
	dc.w	x,169
	dc.w	x,172
	dc.w	x,176
	dc.w	x,180
	dc.w	x,183
	endr

	dc.w	y-166,180	; bounce up & right
	dc.w	y-168,176
	dc.w	y-170,172
	dc.w	y-172,169
	dc.w	y-174,166
	dc.w	y-176,163
	dc.w	y-178,161
	dc.w	y-180,158
	dc.w	y-182,155
	dc.w	y-184,152
	dc.w	y-186,149
	dc.w	y-188,146
	dc.w	y-190,143
	dc.w	y-192,140
	dc.w	y-194,138
	dc.w	y-196,136
	dc.w	y-198,134
	dc.w	y-200,132
	dc.w	y-202,130
	dc.w	y-204,128
	dc.w	y-206,126
	dc.w	y-208,125
	dc.w	y-210,124
	dc.w	y-212,123
	dc.w	y-214,122
	dc.w	y-216,121
	dc.w	y-218,120
	dc.w	y-220,120
	dc.w	y-222,120
	dc.w	y-224,120
	dc.w	y-226,120

	dc.w	y-228,120	bounce down & right
	dc.w	y-230,121
	dc.w	y-232,122
	dc.w	y-234,123
	dc.w	y-236,124
	dc.w	y-238,126
	dc.w	y-240,128
	dc.w	y-242,130
	dc.w	y-244,132
	dc.w	y-246,134
	dc.w	y-248,136
	dc.w	y-250,138
	dc.w	y-252,140
	dc.w	y-254,143
	dc.w	y-256,146
	dc.w	y-258,149
	dc.w	y-260,152
	dc.w	y-262,155
	dc.w	y-264,158
	dc.w	y-266,161
	dc.w	y-268,163
	dc.w	y-270,166
	dc.w	y-272,169
	dc.w	y-274,172
	dc.w	y-276,176
	dc.w	y-278,180
	dc.w	y-280,183

	dc.w	y-280,180	; bounce up & right
	dc.w	y-282,176
	dc.w	y-284,172
	dc.w	y-286,169
	dc.w	y-288,166
	dc.w	y-290,163
	dc.w	y-292,161
	dc.w	y-294,158
	dc.w	y-296,155
	dc.w	y-298,152
	dc.w	y-300,149
	dc.w	y-302,146
	dc.w	y-304,143
	dc.w	y-306,140
	dc.w	y-308,138
	dc.w	y-310,136
	dc.w	y-312,134
	dc.w	y-314,132
	dc.w	y-316,130
	dc.w	y-318,128
	dc.w	y-320,126
	dc.w	y-322,125
	dc.w	y-324,124
	dc.w	y-326,123
	dc.w	y-328,122

	dc.l	'MIKE'

