gem_ctrl_list
	dc.b	0,1,0,0	10
	dc.b	2,1,1,0	11
	dc.b	2,1,1,0	12
	dc.b	0,1,1,0	13
	dc.b	2,1,1,0	14
	dc.b	1,1,1,0	15
	dc.b	0,0,0,0	16*
	dc.b	0,0,0,0	17*
	dc.b	0,0,0,0	18*
	dc.b	0,1,0,0	19
	dc.b	0,1,0,0	20
	dc.b	3,5,0,0	21
	dc.b	5,5,0,0	22
	dc.b	0,1,1,0	23
	dc.b	2,1,0,0	24
	dc.b	16,7,1,0	25
	dc.b	2,1,0,0	26
	dc.b	0,0,0,0	27*
	dc.b	0,0,0,0	28*
	dc.b	0,0,0,0	29*
	dc.b	1,1,1,0	30
	dc.b	2,1,1,0	31
	dc.b	2,1,1,0	32
	dc.b	2,1,1,0	33
	dc.b	1,1,2,0	34
	dc.b	1,1,1,0	35
	dc.b	0,0,0,0	36*
	dc.b	0,0,0,0	37*
	dc.b	0,0,0,0	38*
	dc.b	0,0,0,0	39*
	dc.b	2,1,1,0	40
	dc.b	1,1,1,0	41
	dc.b	6,1,1,0	42
	dc.b	4,1,1,0	43
	dc.b	1,3,1,0	44
	dc.b	2,1,1,0	45
	dc.b	4,2,1,0	46
	dc.b	8,1,1,0	47
	dc.b	0,0,0,0	48*
	dc.b	0,0,0,0	49*
	dc.b	1,1,1,0	50
	dc.b	9,1,0,0	51
	dc.b	1,1,1,0	52
	dc.b	1,1,0,0	53
	dc.b	0,5,1,0	54
	dc.b	3,3,1,0	55
	dc.b	2,2,1,0	56
	dc.b	0,0,0,0	57*
	dc.b	0,0,0,0	58*
	dc.b	0,0,0,0	59*
	dc.b	0,0,0,0	60*
	dc.b	0,0,0,0	61*
	dc.b	0,0,0,0	62*
	dc.b	0,0,0,0	63*
	dc.b	0,0,0,0	64*
	dc.b	0,0,0,0	65*
	dc.b	0,0,0,0	66*
	dc.b	0,0,0,0	67*
	dc.b	0,0,0,0	68*
	dc.b	0,0,0,0	69*
	dc.b	4,3,0,0	70
	dc.b	8,3,0,0	71
	dc.b	6,1,0,0	72
	dc.b	8,1,0,0	73
	dc.b	8,1,0,0	74
	dc.b	4,1,1,0	75
	dc.b	3,1,1,0	76
	dc.b	0,5,0,0	77
	dc.b	1,1,1,0	78
	dc.b	0,5,0,0	79
	dc.b	0,1,1,0	80
	dc.b	0,1,1,0	81
	dc.b	0,0,0,0	82*
	dc.b	0,0,0,0	83*
	dc.b	0,0,0,0	84*
	dc.b	0,0,0,0	85*
	dc.b	0,0,0,0	86*
	dc.b	0,0,0,0	87*
	dc.b	0,0,0,0	88*
	dc.b	0,0,0,0	89*
	dc.b	0,2,2,0	90
	dc.b	0,2,3,0	91
	dc.b	0,0,0,0	92*
	dc.b	0,0,0,0	93*
	dc.b	0,0,0,0	94*
	dc.b	0,0,0,0	95*
	dc.b	0,0,0,0	96*
	dc.b	0,0,0,0	97*
	dc.b	0,0,0,0	98*
	dc.b	0,0,0,0	99*
	dc.b	5,1,0,0	100
	dc.b	5,1,0,0	101
	dc.b	1,1,0,0	102
	dc.b	1,1,0,0	103
	dc.b	2,5,0,0	104
	dc.b	6,1,0,0	105
	dc.b	2,1,0,0	106
	dc.b	1,1,0,0	107
	dc.b	6,5,0,0	108
	dc.b	0,0,0,0	109
	dc.b	0,1,1,0	110
	dc.b	0,1,0,0	111
	dc.b	2,1,0,1	112 ** Control(4)=1 **
	dc.b	2,1,1,0	113
	dc.b	1,1,1,0	114
	dc.b	0,0,0,0	115
	dc.b	0,0,0,0	116
	dc.b	0,0,0,0	117
	dc.b	0,0,0,0	118
	dc.b	0,0,0,0	119
	dc.b	0,1,2,0	120
	dc.b	3,1,2,0	121
	dc.b	1,1,1,0	122
	dc.b	1,1,1,0	123
	dc.b	0,1,1,0	124
	dc.b	0,1,3,0	125
	even
