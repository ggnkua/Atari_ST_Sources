
*---------------------------------------------------------------*
			rsreset
*---------------------------------------------------------------*
pmmu_tree_root		rs.l	1
pmmu_tree_end		rs.l	1
*---------------------------------------------------------------*
pmmu_read_pds		rs.l	1
pmmu_write_pds		rs.l	1
*---------------------------------------------------------------*
pmmu_chg_2_wt		rs.l	1
pmmu_chg_2_cb		rs.l	1
pmmu_chg_2_se		rs.l	1
pmmu_chg_2_ns		rs.l	1
*---------------------------------------------------------------*
pmmu_modify_pds		rs.l	1
pmmu_xlate_pds		rs.l	1
*---------------------------------------------------------------*
