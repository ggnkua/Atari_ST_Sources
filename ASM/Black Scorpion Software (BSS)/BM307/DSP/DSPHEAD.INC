
;-----------------------------------------------------------------------*
;	Port equates							*
;-----------------------------------------------------------------------*

PBC			=	$FFE0
HCR			=	$FFE8
HSR			=	$FFE9
HTX			=	$FFEB

;-----------------------------------------------------------------------*
;	Host macros							*
;-----------------------------------------------------------------------*

dspread			macro	var
_rd	jclr		#0,x:<<HSR,_rd
	movep		x:<<HTX,var
	endm

dspwrite		macro	var
_wr	jclr		#1,x:<<HSR,_wr
	movep		var,x:<<HTX
	endm

dspwaitread		macro
_rd	jclr		#0,x:<<HSR,_rd
	endm

dspwaitwrite		macro
_wr	jclr		#1,x:<<HSR,_wr
	endm

;-----------------------------------------------------------------------*
	org		p:0
;-----------------------------------------------------------------------*
	jmp		KickStart
;-----------------------------------------------------------------------*
