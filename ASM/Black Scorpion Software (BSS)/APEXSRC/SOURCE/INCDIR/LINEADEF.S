first_ade		=	36
off_table		=	72
data_table		=	76
form_width		=	80
form_height		=	82

