DOBLOCK			=	0
BLKHANDSHAKE		=	1
BLKUNPACKED			=	2
INSTREAM			=	3
OUTSTREAM			=	4
IOSTREAM			=	5
REMOVEINTERRUPTS		=	6
GETWORDSIZE			=	7
LOCK				=	8
UNLOCK			=	9
AVAILABLE			=	10
RESERVE			=	11
LOADPROG			=	12
EXECPROG			=	13
EXECBOOT			=	14
LODTOBINARY			=	15
TRIGGERHC			=	16
REQUESTUNIQUEABILITY	=	17
GETPROGABILITY		=	18
FLUSHSUBROUTINES		=	19
LOADSUBROUTINE		=	20
INQSUBRABILITY		=	21
RUNSUBROUTINE		=	22
HF0				=	23
HF1				=	24
HF2				=	25
HF3				=	26
BLKWORDS			=	27
BLKBYTES			=	28
HSTAT				=	29
SETVECTOR			=	30

CALLDRVR		macro
	moveq		\1,d0
	add.w		drvr_start(pc),d0
	move.w	d0,-(sp)
	trap		#14
	endm
