
COLOUR		=	$FFFF8240
SYNC			=	$FFFF820A

DIGICTRL		=	$FFF20000
DIGIPAGE		=	$FFF40000

DSPCTRL		=	$FFFFA202
DSPLONG		=	$FFFFA204
DSPWORD		=	$FFFFA206
