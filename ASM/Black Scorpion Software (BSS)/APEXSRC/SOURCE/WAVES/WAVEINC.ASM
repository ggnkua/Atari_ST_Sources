
bob	equ	4
