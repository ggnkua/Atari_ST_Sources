
e_intro_text:	dc.b	27,"Y",0,80,89+2," >--<> Apex Animator <>--< "
			dc.b	27,"Y",0,80,97+2," Registration system v1.00 "
			dc.b	0

e_warning1_text:	dc.b	27,"Y",0,80,93-16+2,"You have only one chance to"
			dc.b	27,"Y",0,80,93-08+2,"install the disk correctly."
			dc.b	27,"Y",0,80,93+00+2," If you are in doubt about "
			dc.b	27,"Y",0,80,93+08+2,"this process, please refer "
			dc.b	27,"Y",0,80,93+16+2,"to the supplied inlay card."
			dc.b	0

e_warning2_text:	dc.b	27,"Y",0,80,93-16+2,"This is your last chance to"
			dc.b	27,"Y",0,80,93-08+2," correct any details which "
			dc.b	27,"Y",0,80,93+00+2,"might be incorrect, or even"
			dc.b	27,"Y",0,80,93+08+2,"abort the process entirely."
			dc.b	27,"Y",0,80,93+16+2,"Do you want to install now?"
			dc.b	0

e_write_text:	dc.b	27,"Y",0,80,89+2," Please ensure this master "
			dc.b	27,"Y",0,80,97+2,"disk is not write-protected"
			dc.b	0

e_reg_text:		dc.b	27,"Y",0,32,55+0*20,"Name:"
			dc.b	27,"Y",0,32,55+1*20,"Address:"
			dc.b	27,"Y",0,32,55+2*20,"Town,City:"
			dc.b	27,"Y",0,32,55+3*20,"Zip/Postcode:"
			dc.b	27,"Y",0,32,55+4*20,"Country:"
			dc.b	0

e_error_text:	dc.b	27,"Y",0,80,93-16+2,"A disk error has caused the"
			dc.b	27,"Y",0,80,93-08+2,"  registration process to  "
			dc.b	27,"Y",0,80,93+00+2,"terminate. Please refer to "
			dc.b	27,"Y",0,80,93+08+2," the installation booklet  "
			dc.b	27,"Y",0,80,93+16+2,"before doing anything else."
			dc.b	0
