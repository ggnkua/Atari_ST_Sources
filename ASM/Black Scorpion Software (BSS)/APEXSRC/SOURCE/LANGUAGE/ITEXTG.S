
g_intro_text:	dc.b	27,"Y",0,80,89+2," >--<> Apex Animator <>--< "
			dc.b	27,"Y",0,80,97+2," Registrations system v1.0 "
			dc.b	0

g_warning1_text:	dc.b	27,"Y",0,80,93-20+2,"SIE HABEN NUR EINE CHANCE,"
			dc.b	27,"Y",0,80,93-12+2," DIE DISKETTE RICHTIG ZU  "
			dc.b	27,"Y",0,80,93-04+2,"  INSTALLIEREN. WENN SIE  "
			dc.b	27,"Y",0,80,93+04+2,"SICH HIERBEI NICHT SICHER "
			dc.b	27,"Y",0,80,93+12+2,"SIND, LESEN SIE BITTE DIE "
			dc.b	27,"Y",0,80,93+20+2,"     BEIGEFšGTE KARTE.    "
			dc.b	0

g_warning2_text:	dc.b	27,"Y",0,80,93-12+2,"DIES IST DIE LETZTE CHANCE,"
			dc.b	27,"Y",0,80,93-04+2," KORREKTUREN DURCHZUFšHREN "
			dc.b	27,"Y",0,80,93+04+2," ODER ABZUBRECHEN. M™CHTEN "
			dc.b	27,"Y",0,80,93+12+2,"  SIE JETZT INSTALLIEREN?  "
			dc.b	0

g_write_text:	dc.b	27,"Y",0,80,089+2-18," BITTE STELLEN SIE SICHER, "
			dc.b	27,"Y",0,80,097+2-18," DAá DIESE MASTERDISKETTE  "
			dc.b	27,"Y",0,80,105+2-18,"NICHT SCHREIBGESCHšTZT IST."
			dc.b	0

g_reg_text:		dc.b	27,"Y",0,32,55+0*20,"Name:"
			dc.b	27,"Y",0,32,55+1*20,"Adresse:"
			dc.b	27,"Y",0,32,55+2*20,"Ort:"
			dc.b	27,"Y",0,32,55+3*20,"Postleitzahl:"
			dc.b	27,"Y",0,32,55+4*20,"Land:"
			dc.b	0

g_error_text:	dc.b	27,"Y",0,80,93-20+2," EIN DISKETTENFEHLER HAT  "
			dc.b	27,"Y",0,80,93-12+2,"     ZUM ABBRUCH DES      "
			dc.b	27,"Y",0,80,93-04+2,"   REGISTRATIONVORGANGS   "
			dc.b	27,"Y",0,80,93+04+2,"  GEFšHRT. BITTE IN DER   "
			dc.b	27,"Y",0,80,93+12+2,"  REGISTRATIONSANLEITUNG  "
			dc.b	27,"Y",0,80,93+20+2,"        NACHSEHEN.        "
			dc.b	0
