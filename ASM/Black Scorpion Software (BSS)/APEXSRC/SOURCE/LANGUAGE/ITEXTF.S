
f_intro_text:	dc.b	27,"Y",0,80,89+2," >--<> Apex Animator <>--< "
			dc.b	27,"Y",0,80,97+2,"Systeme D'Enregistrement v1"
			dc.b	0

f_warning1_text:	dc.b	27,"Y",0,80,93-16+2," VOUS N'AVEZ QU'UNE CHANCE "
			dc.b	27,"Y",0,80,93-08+2,"D'INSTALLER CETTE DISQUETTE"
			dc.b	27,"Y",0,80,93+00+2,"CORRECTEMENT. SI VOUS AVEZ "
			dc.b	27,"Y",0,80,93+08+2," LE MOINDRE DOUTE REPORTEZ-"
			dc.b	27,"Y",0,80,93+16+2,"  VOUS Е LA CARTE FOURNIE. "
			dc.b	0

f_warning2_text:	dc.b	27,"Y",0,80,93-20+2,"  CECI EST VOTRE DERNIERE  "
			dc.b	27,"Y",0,80,93-12+2,"  CHANCE DE CORRIGER LES   "
			dc.b	27,"Y",0,80,93-04+2,"  INFORMATIONS SAISIES OU  "
			dc.b	27,"Y",0,80,93+04+2," D'ARRETER LE PROCESSUS EN "
			dc.b	27,"Y",0,80,93+12+2," COURS. VOULEZ-VOUS LANCER "
			dc.b	27,"Y",0,80,93+20+2,"      L'INSTALLATION?      "
			dc.b	0

f_write_text:	dc.b	27,"Y",0,80,089+2-11,"    ASSUREZ-VOUS QUE LA    "
			dc.b	27,"Y",0,80,097+2-11," N'EST PAS PROTEGEE CONTRE "
			dc.b	27,"Y",0,80,105+2-11,"        L'ECRITURE.        "
			dc.b	0

f_reg_text:		dc.b	27,"Y",0,32,55+0*20,"Nom:"
			dc.b	27,"Y",0,32,55+1*20,"Adresse:"
			dc.b	27,"Y",0,32,55+2*20,"Ville:"
			dc.b	27,"Y",0,32,55+3*20,"Code-postal:"
			dc.b	27,"Y",0,32,55+4*20,"Pays:"
			dc.b	0

f_error_text:	dc.b	27,"Y",0,80,93-20+2,"UNE ERREUR SUR LA DISQUETTE"
			dc.b	27,"Y",0,80,93-12+2,"   A PROVOQUР L'ARRИT DU   "
			dc.b	27,"Y",0,80,93-04+2,"PROCESSUS D'ENREGISTREMENT."
			dc.b	27,"Y",0,80,93+04+2,"  VEUILLEZ CONSULTER LES   "
			dc.b	27,"Y",0,80,93+12+2,"  INSTRUCTIONS CONCERNANT  "
			dc.b	27,"Y",0,80,93+20+2,"     L'ENREGISTREMENT.     "
			dc.b	0
