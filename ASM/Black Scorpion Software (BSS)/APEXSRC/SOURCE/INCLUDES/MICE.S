
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,11,00,00,00,00,00,00,00,00
		dc.b		05,05,05,05,05,00,00,00,00,00,05,05,05,05,05,00
		dc.b		31,31,31,31,31,11,00,31,00,11,31,31,31,31,31,00
		dc.b		05,05,05,05,05,00,00,00,00,00,05,05,05,05,05,00
		dc.b		00,00,00,00,00,00,00,11,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,05,31,05,00,00,00,00,00,00,00

		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,02,00,00,00,00,00,00,00,00,00,00,00,02,00,00
		dc.b		00,00,01,00,00,00,00,00,00,00,00,00,01,00,00,00
		dc.b		00,00,00,02,00,00,00,00,00,00,00,02,00,00,00,00
		dc.b		00,00,00,00,01,00,00,00,00,00,01,00,00,00,00,00
		dc.b		00,00,00,00,00,02,00,00,00,02,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,02,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,02,00,00,00,02,00,00,00,00,00,00
		dc.b		00,00,00,00,01,00,00,00,00,00,01,00,00,00,00,00
		dc.b		00,00,00,02,00,00,00,00,00,00,00,02,00,00,00,00
		dc.b		00,00,01,00,00,00,00,00,00,00,00,00,01,00,00,00
		dc.b		00,02,00,00,00,00,00,00,00,00,00,00,00,02,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00

		dc.b		00,00,00,00,00,04,04,04,04,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,01,01,01,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,01,00,01,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,01,00,01,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,01,00,01,04,00,00,00,00,00,00
		dc.b		04,04,04,04,04,04,01,00,01,04,04,04,04,04,04,00
		dc.b		04,01,01,01,01,01,01,00,01,01,01,01,01,01,04,00
		dc.b		04,01,00,00,00,00,00,00,00,00,00,00,00,01,04,00
		dc.b		04,01,01,01,01,01,01,00,01,01,01,01,01,01,04,00
		dc.b		04,04,04,04,04,04,01,00,01,04,04,04,04,04,04,00
		dc.b		00,00,00,00,00,04,01,00,01,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,01,00,01,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,01,00,01,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,01,01,01,04,00,00,00,00,00,00
		dc.b		00,00,00,00,00,04,04,04,04,04,00,00,00,00,00,00

		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,03,03,03,03,03,03,00,00,00
		dc.b		00,00,00,00,00,00,00,03,01,01,01,01,00,00,00,00
		dc.b		00,00,00,00,00,00,00,03,01,01,01,00,00,00,00,00
		dc.b		00,00,00,00,00,00,00,03,01,01,03,03,00,00,00,00
		dc.b		00,00,00,00,00,00,00,03,01,00,03,01,03,00,00,00
		dc.b		00,00,00,00,00,00,00,03,00,00,00,03,01,03,00,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,03,01,03,00
		dc.b		00,00,00,00,00,00,00,00,00,00,00,00,00,03,03,00
