*-------------------------------------------------------*
*	Mark end of TEXT, DATA & BSS sections		*
*-------------------------------------------------------*
			bss
*-------------------------------------------------------*
			align
*-------------------------------------------------------*
bss_end:
*-------------------------------------------------------*

*-------------------------------------------------------*
			ds.b		8192
*-------------------------------------------------------*
stack_start:
*-------------------------------------------------------*
			ds.b		user_stacksize
usp_stack:		even
*-------------------------------------------------------*
			ds.b		super_stacksize
ssp_stack:		even
*-------------------------------------------------------*
stack_end:
*-------------------------------------------------------*
			ds.b		8192
*-------------------------------------------------------*

*-------------------------------------------------------*
			ds.b		ext_isp_stacksize
extern_isp_stack:	even
*-------------------------------------------------------*
			ds.b		ext_usp_stacksize
extern_stack:		even
*-------------------------------------------------------*
basepage_ptr:		ds.l		1
cli_ptr:		ds.l		1
*-------------------------------------------------------*
bss_all_end:
*-------------------------------------------------------*
			data
*-------------------------------------------------------*
			align
*-------------------------------------------------------*
data_end:
*-------------------------------------------------------*
			text
*-------------------------------------------------------*
			align
*-------------------------------------------------------*
text_end:
*-------------------------------------------------------*
