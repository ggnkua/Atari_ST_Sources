*-------------------------------------------------------*
			rsreset
*-------------------------------------------------------*
clip_x1			rs.w	1
clip_y1			rs.w	1
clip_x2			rs.w	1
clip_y2			rs.w	1
clip_slen		rs.b	0
