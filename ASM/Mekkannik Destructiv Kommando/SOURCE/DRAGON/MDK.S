music incbin dragon\music.mdk
                
tf0   dc.w $030,$030,$030,$030,$030,$030,$030,$030,$030,$030,$030
      dc.w $050,$050,$050,$050,$050,$050,$050,$050,$050,$050,$050
      dc.w $070,$070,$070,$070,$070,$070,$070,$070,$070,$070,$070
      dc.w $050,$050,$050,$050,$050,$050,$050,$050,$050,$050,$050
      dc.w $030,$030,$030,$030,$030,$030,$030,$030,$030,$030,$030

tf1   dc.w $200,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $400,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $600,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $400,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $200,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      
tf2   dc.w $300,$300,$300,$300,$300,$300,$300,$300,$300,$300,$300
      dc.w $500,$500,$500,$500,$500,$500,$500,$500,$500,$500,$500
      dc.w $700,$700,$700,$700,$700,$700,$700,$700,$700,$700,$700
      dc.w $500,$500,$500,$500,$500,$500,$500,$500,$500,$500,$500
      dc.w $300,$300,$300,$300,$300,$300,$300,$300,$300,$300,$300

tf3   dc.w $020,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $040,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $060,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $040,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333
      dc.w $020,$003,$005,$007,$027,$057,$777,$666,$555,$444,$333


col2  dc.b $F0,0,30,$F1,0,1
      dc.b 0,3,$F0,0,24,$F1,0,4
      dc.b 0,6,$F0,0,18,$F1,0,7
      dc.b 0,9,$F0,0,12,$F1,0,10
      dc.b 0,12,$F0,0,6,$F1,0,13
      dc.b 0,15,$F0,$F1,0,16
      dc.b 0,18,$f0,0,18+50                    * milieu
      dc.b 0,15,$F1,$F0,0,16
      dc.b 0,12,$F1,0,6,$F0,0,13
      dc.b 0,9,$F1,0,12,$F0,0,10
      dc.b 0,6,$F1,0,18,$F0,0,7
      dc.b 0,3,$F1,0,24,$F0,0,4
      dc.b $F1,0,30,$f0,0,1
*----      
      dc.b 0,3,$f2,0,24,$f3,0,4
      dc.b 0,6,$f2,0,18,$f3,0,7
      dc.b 0,9,$f2,0,12,$f3,0,10
      dc.b 0,12,$f2,0,6,$f3,0,13
      dc.b 0,15,$f2,$f3,0,16
      dc.b 0,18,$f2,0,18+50                    * milieu
      dc.b 0,15,$f3,$f2,0,16
      dc.b 0,12,$f3,0,6,$f2,0,13
      dc.b 0,9,$f3,0,12,$f2,0,10
      dc.b 0,6,$f3,0,18,$f2,0,7
      dc.b 0,3,$f3,0,24,$f2,0,4
      dc.b $ff
 even
d_coo_met  dc.w 00,50
         dc.w 05,50
         dc.w 10,50
         dc.w 15,50
         dc.w 20,50
         dc.w 25,50
         dc.w 30,50
         dc.w 35,50
         dc.w 40,50
         dc.w 45,50
         dc.w 50,50
         dc.w 55,50
         dc.w 60,50
         dc.w 65,50
         dc.w 70,50
         dc.w 75,50
         dc.w 80,50
         dc.w 85,50
         dc.w 90,50
         dc.w 95,50
         dc.w 100,50
         dc.w 105,50
         dc.w 110,50
         dc.w 115,50
         dc.w 120,50
         dc.w 125,50
         dc.w 130,50
         dc.w 135,50
         dc.w 140,50
         dc.w 145,50
         dc.w 145,50
         dc.w 145,50
         dc.w 145,50
         
         dc.w 140,52
         dc.w 135,55
         dc.w 130,58
         dc.w 125,60
         dc.w 120,64
         dc.w 115,68
         dc.w 110,72
         dc.w 108,76
         dc.w 105,81
         dc.w 103,85
         dc.w 102,91
         dc.w 103,96
         dc.w 106,100
         dc.w 109,105
         dc.w 113,108
         dc.w 120,110
         dc.w 126,114
         dc.w 134,117
         dc.w 142,118
         
         dc.w 146,118
         dc.w 152,118
         dc.w 158,118
         dc.w 164,118
         dc.w 170,118
         dc.w 176,118
         dc.w 186,118
         dc.w 196,118
         dc.w 205,118
         dc.w 215,118
         dc.w 225,118
         dc.w 235,118
         dc.w 245,118
         dc.w 255,118
         dc.w 265,118
         dc.w 275,118
         dc.w 285,118
         dc.w 295,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,118
         dc.w 300,116
         dc.w 300,114
         dc.w 300,112
         dc.w 300,110
         dc.w 300,108
         dc.w 300,106
         dc.w 300,104
         dc.w 300,102
         dc.w 300,100
         dc.w 300,98
         dc.w 300,96
         dc.w 300,94
         dc.w 300,92
         dc.w 300,90
         dc.w 300,88
         dc.w 300,86
         dc.w 300,84
         dc.w 300,82
         dc.w 300,80
         dc.w 300,78
         dc.w 300,76
         dc.w 300,74
         dc.w 300,72
         dc.w 300,70
         dc.w 300,68
         dc.w 300,66
         dc.w 300,64
         
         dc.w 296,61
         dc.w 292,56
         dc.w 288,52
         dc.w 284,48
         dc.w 279,45
         dc.w 274,44
         dc.w 267,44
         dc.w 257,45
         dc.w 249,48
         dc.w 243,52
         dc.w 233,60
         dc.w 223,68
         dc.w 213,76
         dc.w 203,84
         dc.w 193,92
         dc.w 183,100
         dc.w 173,108
         dc.w 163,116
         dc.w 153,124
         dc.w 143,132
                  
         dc.w 138,132
         dc.w 132,132
         dc.w 126,132
         dc.w 120,132
         dc.w 113,132
         dc.w 106,132
         dc.w 99,132
         dc.w 91,132
         dc.w 83,132
         dc.w 75,132
         dc.w 66,132
         dc.w 57,132
         dc.w 48,132
         dc.w 38,132
         dc.w 28,132
         dc.w 18,132
         dc.w 6,132
f_coo_met

d_coo_cra  dc.w 300,40
         dc.w 296,40       
         dc.w 292,40       
         dc.w 288,40       
         dc.w 284,40 
         dc.w 280,41      
         dc.w 274,42       
         dc.w 265,43       
         dc.w 260,44       
         dc.w 254,45       
         dc.w 248,46       
         dc.w 244,48       
         dc.w 239,50       
         dc.w 236,52       
         dc.w 231,54       
         dc.w 227,58       
         dc.w 223,62       
         dc.w 220,67       
         dc.w 216,72       
         dc.w 214,78       
         dc.w 211,86       
         dc.w 210,92       
         dc.w 212,106       
         dc.w 213,112       
         dc.w 216,118       
         dc.w 219,123       
         dc.w 223,127       
         dc.w 228,131       
         dc.w 234,135       
         dc.w 240,137       
         dc.w 247,139       
         dc.w 254,139       
         dc.w 261,138       
         dc.w 268,138       
         dc.w 275,135       
         dc.w 281,130       
         dc.w 286,125       
         dc.w 290,120       
         dc.w 294,113       
         dc.w 296,106       
         dc.w 297,100       
         dc.w 297,94       
         dc.w 296,88       
         dc.w 294,81      
         dc.w 292,74       
         dc.w 289,72       
         dc.w 285,68       
         dc.w 281,63       
         dc.w 276,60       
         dc.w 270,57
         dc.w 266,56       
         dc.w 262,55
         dc.w 258,55
         dc.w 255,55
         dc.w 252,55
         dc.w 249,55
         dc.w 246,55
         dc.w 244,55
         dc.w 242,55       
         dc.w 240,55       
         dc.w 238,55       
         dc.w 236,55       
         dc.w 234,55       
         dc.w 232,55       
         dc.w 230,55       
         dc.w 226,55       
         dc.w 222,55       
         dc.w 218,55       
         dc.w 214,55       
         dc.w 210,55       
         dc.w 206,55       
         dc.w 200,55       
         dc.w 194,55       
         dc.w 188,55       
         dc.w 182,55       
         dc.w 176,55       
         dc.w 170,55       
         dc.w 162,55       
         dc.w 154,55       
         dc.w 146,55       
         dc.w 138,55       
         dc.w 130,55       
         dc.w 120,55       
         dc.w 110,55       
         dc.w 100,55       
         dc.w 95,55       
         dc.w 95,55       
         dc.w 95,55       
         dc.w 95,55       
         dc.w 95,55       
         dc.w 95,55       
         dc.w 95,55       
         dc.w 100,57       
         dc.w 104,58       
         dc.w 108,60       
         dc.w 112,62       
         dc.w 116,65       
         dc.w 120,68       
         dc.w 121,72       
         dc.w 123,75       
         dc.w 125,79       
         dc.w 126,84       
         dc.w 127,90       
         dc.w 127,96       
         dc.w 126,101       
         dc.w 124,105       
         dc.w 121,108      
         dc.w 117,112      
         dc.w 113,116      
         dc.w 109,119      
         dc.w 105,122      
         dc.w 100,123      
         dc.w 94,124      
         dc.w 87,125       
         dc.w 80,125       
         dc.w 72,125       
         dc.w 67,120       
         dc.w 62,115       
         dc.w 57,110       
         dc.w 52,105       
         dc.w 47,100       
         dc.w 42,95       
         dc.w 37,90       
         dc.w 32,85       
         dc.w 27,80       
         dc.w 22,75       
         dc.w 17,70       
         dc.w 12,65       
         dc.w 7,60       
         dc.w 2,55
f_coo_cra    
 
 even      
pic1 incbin dragon\mdk2.pc1
 even
pic2 incbin dragon\dragon.pc1
 even
message incbin dragon\texte.mdk
     

