pal		dc.w 1,2,3,4,5,6,7
		dc.w 6,5,4,3,2,1,0,0,0,0,0,0,0
		dc.w 17,18,19,20,21,22,23,22,21,20,19,18,17
		dc.w 0,0,0,0,0
		rept 4
		dc.w 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
		endr
palette		rept 101
		dc.w 0
		endr
rouleau		rept 2
*		dc.w $427,$527,$627,$727
		dc.w $726,$725,$724,$723,$722
		dc.w $732,$742,$752,$762,$772
		dc.w $772,$762,$752,$742,$732
		dc.w $722,$723,$724,$725,$726
		dc.w $727,$627,$527,$427,$427
		dc.w $427,$527,$627,$727
		dc.w $726,$725,$724,$723,$722
		dc.w $732,$742,$752,$762,$772
		dc.w $772,$762,$752,$742,$732
		dc.w $722,$723,$724,$725,$726
		dc.w $727
*,$627,$527,$427,$427
		endr
