	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$007F,$0000,$0000,$0000,$F000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$003C,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$7F00,$0000,$0000,$0000
	dc.w	$1F00,$0000,$0000,$0000,$3FDF,$0000,$0000,$0000
	dc.w	$C780,$0000,$0000,$0000,$01E0,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$003F,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$007E,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0001,$0000,$0000,$0000,$E3C0,$0000,$0000,$0000
	dc.w	$3F80,$0000,$0000,$0000,$0F07,$0000,$0000,$0000
	dc.w	$0FC0,$0000,$0000,$0000,$03F0,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$1C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$003C,$0000,$0000,$0000
	dc.w	$0007,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0003,$0000,$0000,$0000,$C1E0,$0000,$0000,$0000
	dc.w	$7F80,$0000,$0000,$0000,$0F07,$0000,$0000,$0000
	dc.w	$0780,$0000,$0000,$0000,$01E0,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$1E00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0007,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0007,$0000,$0000,$0000,$80F0,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$0F0E,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$1E00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$000F,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0007,$0000,$0000,$0000,$80F0,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$078E,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$1E1F,$0000,$0000,$0000
	dc.w	$03F0,$0000,$0000,$0000,$FE1C,$0000,$0000,$0000
	dc.w	$3F9F,$0000,$0000,$0000,$C3E0,$0000,$0000,$0000
	dc.w	$7F81,$0000,$0000,$0000,$FC1F,$0000,$0000,$0000
	dc.w	$000F,$0000,$0000,$0000,$0079,$0000,$0000,$0000
	dc.w	$FE00,$0000,$0000,$0000,$078E,$0000,$0000,$0000
	dc.w	$0387,$0000,$0000,$0000,$F0E0,$0000,$0000,$0000
	dc.w	$FE07,$0000,$0000,$0000,$F800,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$1C7B,$0000,$0000,$0000
	dc.w	$C7FB,$0000,$0000,$0000,$DE3C,$0000,$0000,$0000
	dc.w	$F78F,$0000,$0000,$0000,$0F78,$0000,$0000,$0000
	dc.w	$FFC7,$0000,$0000,$0000,$FE7B,$0000,$0000,$0000
	dc.w	$C00F,$0000,$0000,$0000,$0078,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$079C,$0000,$0000,$0000
	dc.w	$079E,$0000,$0000,$0000,$F1E3,$0000,$0000,$0000
	dc.w	$C78F,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001F,$0000,$0000,$0000,$3C73,$0000,$0000,$0000
	dc.w	$CFFB,$0000,$0000,$0000,$DE7C,$0000,$0000,$0000
	dc.w	$F78F,$0000,$0000,$0000,$0E79,$0000,$0000,$0000
	dc.w	$FBC7,$0000,$0000,$0000,$9E73,$0000,$0000,$0000
	dc.w	$C00F,$0000,$0000,$0000,$0078,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$03DC,$0000,$0000,$0000
	dc.w	$0F9E,$0000,$0000,$0000,$F3E3,$0000,$0000,$0000
	dc.w	$C79F,$0000,$0000,$0000,$BC00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001F,$0000,$0000,$0000,$F0F1,$0000,$0000,$0000
	dc.w	$E783,$0000,$0000,$0000,$CE3C,$0000,$0000,$0000
	dc.w	$F38F,$0000,$0000,$0000,$1E3C,$0000,$0000,$0000
	dc.w	$F3CF,$0000,$0000,$0000,$00F1,$0000,$0000,$0000
	dc.w	$E00F,$0000,$0000,$0000,$0078,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$03DC,$0000,$0000,$0000
	dc.w	$079E,$0000,$0000,$0000,$71E7,$0000,$0000,$0000
	dc.w	$83CF,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$00FF,$0000,$0000,$0000
	dc.w	$E781,$0000,$0000,$0000,$F03C,$0000,$0000,$0000
	dc.w	$7C0F,$0000,$0000,$0000,$1FFC,$0000,$0000,$0000
	dc.w	$F3CF,$0000,$0000,$0000,$00FF,$0000,$0000,$0000
	dc.w	$E00F,$0000,$0000,$0000,$0078,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$03F8,$0000,$0000,$0000
	dc.w	$078F,$0000,$0000,$0000,$81E7,$0000,$0000,$0000
	dc.w	$83CF,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$00F0,$0000,$0000,$0000
	dc.w	$0780,$0000,$0000,$0000,$FC3C,$0000,$0000,$0000
	dc.w	$3F0F,$0000,$0000,$0000,$1E00,$0000,$0000,$0000
	dc.w	$F3CF,$0000,$0000,$0000,$00F0,$0000,$0000,$0000
	dc.w	$000F,$0000,$0000,$0000,$0078,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$01F8,$0000,$0000,$0000
	dc.w	$0787,$0000,$0000,$0000,$E1E7,$0000,$0000,$0000
	dc.w	$83CF,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$00F0,$0000,$0000,$0000
	dc.w	$0780,$0000,$0000,$0000,$3E3C,$0000,$0000,$0000
	dc.w	$0F8F,$0000,$0000,$0000,$1E00,$0000,$0000,$0000
	dc.w	$F3CF,$0000,$0000,$0000,$00F0,$0000,$0000,$0000
	dc.w	$0007,$0000,$0000,$0000,$80F0,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$01F8,$0000,$0000,$0000
	dc.w	$0781,$0000,$0000,$0000,$F1E7,$0000,$0000,$0000
	dc.w	$83CF,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$00F8,$0000,$0000,$0000
	dc.w	$0783,$0000,$0000,$0000,$8F3C,$0000,$0000,$0000
	dc.w	$E3CF,$0000,$0000,$0000,$1F00,$0000,$0000,$0000
	dc.w	$F3CF,$0000,$0000,$0000,$8EF8,$0000,$0000,$0000
	dc.w	$0007,$0000,$0000,$0000,$80F0,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$01F0,$0000,$0000,$0000
	dc.w	$079C,$0000,$0000,$0000,$79E7,$0000,$0000,$0000
	dc.w	$83CF,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$007C,$0000,$0000,$0000
	dc.w	$E783,$0000,$0000,$0000,$CF3C,$0000,$0000,$0000
	dc.w	$F3CF,$0000,$0000,$0000,$0F9C,$0000,$0000,$0000
	dc.w	$F3C7,$0000,$0000,$0000,$CE7C,$0000,$0000,$0000
	dc.w	$E003,$0000,$0000,$0000,$C1E0,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$00F0,$0000,$0000,$0000
	dc.w	$079E,$0000,$0000,$0000,$79E3,$0000,$0000,$0000
	dc.w	$C78F,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001E,$0000,$0000,$0000,$007F,$0000,$0000,$0000
	dc.w	$C783,$0000,$0000,$0000,$CF3C,$0000,$0000,$0000
	dc.w	$F3CF,$0000,$0000,$0000,$CFF8,$0000,$0000,$0000
	dc.w	$F3C7,$0000,$0000,$0000,$FC7F,$0000,$0000,$0000
	dc.w	$C001,$0000,$0000,$0000,$E3C0,$0000,$0000,$0000
	dc.w	$7800,$0000,$0000,$0000,$00F0,$0000,$0000,$0000
	dc.w	$079E,$0000,$0000,$0000,$79E3,$0000,$0000,$0000
	dc.w	$C78F,$0000,$0000,$0000,$3C00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$007F,$0000,$0000,$0000,$801F,$0000,$0000,$0000
	dc.w	$8FC3,$0000,$0000,$0000,$FC7E,$0000,$0000,$0000
	dc.w	$FF07,$0000,$0000,$0000,$83F1,$0000,$0000,$0000
	dc.w	$FFE1,$0000,$0000,$0000,$F81F,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$7F01,$0000,$0000,$0000
	dc.w	$FE00,$0000,$0000,$0000,$00E0,$0000,$0000,$0000
	dc.w	$0FDF,$0000,$0000,$0000,$E3F0,$0000,$0000,$0000
	dc.w	$FE1F,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$889C,$0000,$0000,$0000,$7807,$0000,$0000,$0000
	dc.w	$A278,$0000,$0000,$0000,$0F1C,$0000,$0000,$0000
	dc.w	$F9C0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$1E78,$0000,$0000,$0000
	dc.w	$03D1,$0000,$0000,$0000,$45F0,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$000E,$0000,$0000,$0000,$2110,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$F1CF,$0000,$0000,$0000,$1C79,$0000,$0000,$0000
	dc.w	$8DA2,$0000,$0000,$0000,$8008,$0000,$0000,$0000
	dc.w	$2280,$0000,$0000,$0000,$08A2,$0000,$0000,$0000
	dc.w	$2220,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$1144,$0000,$0000,$0000
	dc.w	$0411,$0000,$0000,$0000,$6500,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0011,$0000,$0000,$0000,$2110,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$8A28,$0000,$0000,$0000,$8881,$0000,$0000,$0000
	dc.w	$8ABE,$0000,$0000,$0000,$8007,$0000,$0000,$0000
	dc.w	$1470,$0000,$0000,$0000,$08BE,$0000,$0000,$0000
	dc.w	$23E0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$1178,$0000,$0000,$0000
	dc.w	$038A,$0000,$0000,$0000,$55E0,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$001F,$0000,$0000,$0000,$20A0,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$F22F,$0000,$0000,$0000,$0871,$0000,$0000,$0000
	dc.w	$88A2,$0000,$0000,$0000,$8000,$0000,$0000,$0000
	dc.w	$8808,$0000,$0000,$0000,$08A2,$0000,$0000,$0000
	dc.w	$2220,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$1150,$0000,$0000,$0000
	dc.w	$6044,$0000,$0000,$0000,$4D00,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0011,$0000,$0000,$0000,$2040,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$8A2A,$0000,$0000,$0000,$0809,$0000,$0000,$0000
	dc.w	$88A2,$0000,$0000,$0000,$780F,$0000,$0000,$0000
	dc.w	$08F0,$0000,$0000,$0000,$0F22,$0000,$0000,$0000
	dc.w	$2220,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$1E4C,$0000,$0000,$0000
	dc.w	$6784,$0000,$0000,$0000,$45F0,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0011,$0000,$0000,$0000,$3C40,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$F1C9,$0000,$0000,$0000,$9CF1,$0000,$0000,$0000
	dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
	dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000

