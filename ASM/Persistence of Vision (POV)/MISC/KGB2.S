 TEXT
Begin	MOVEA.L	A7,A5
	LEA	L0023,A7
	MOVEA.L	4(A5),A5
	MOVE.L	12(A5),D0
	ADD.L	20(A5),D0
	ADD.L	28(A5),D0
	ADDI.L	#$100,D0
	MOVE.L	D0,-(A7)
	MOVE.L	A5,-(A7)
	MOVE.W	#0,-(A7)
	MOVE.W	#$4A,-(A7)
	TRAP	#1
	ADDA.L	#$C,A7

		pea	0.l
		move.w	#$20,-(sp)
		trap	#1
		addq.l	#6,sp

		clr.w	-(sp)
		pea	$FFFFFFFF.L
		pea	$FFFFFFFF.L
		move.w	#5,-(sp)
		trap	#$E

	dc.w	$A00A

	MOVE.W	#$18,$FFFFFC02.W

		lea	storage,a0
		move.l	$68.w,(a0)+
		move.l	$70.w,(a0)+
		move.l	$120.w,(a0)+
		move.b	$fffffa1b.w,(a0)+
		move.b	$fffffa21.w,(a0)+
		move.b	$fffffa07.w,(a0)+
		move.b	$fffffa09.w,(a0)+
		move.b	$fffffa13.w,(a0)+
		move.b	$ffff8201.w,(a0)+
		move.b	$ffff8203.w,(a0)+
		move.b	$484.w,(a0)+

		move.b	#6,$484.w

		moveq	#1,d0
		jsr	music

		movem.l	$ffff8240.w,d0-d7
		movem.l	d0-d7,old_pal

	LEA	$FFFF8240.W,A0
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	MOVE.L	$44E.L,D0
	SUBI.L	#$8000,D0
	MOVE.L	D0,L0025
	MOVEA.L	L0025,A0
	MOVE.L	#$3E7F,D0
L0000:
	CLR.L	(A0)+
	DBF	D0,L0000
	MOVE.L	L0025,D0
	LSR.W	#8,D0
	MOVE.L	D0,$FFFF8200.W
	LEA	L0098,A0
	LEA	L0099,A1
	MOVE.L	#$B3,D0
L0001:
	MOVE.L	(A0)+,(A1)+
	DBF	D0,L0001
	LEA	L002B,A0
	LEA	L0020,A1
	MOVEQ	#$21,D2
	MOVEQ	#0,D1
L0002:
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	ADD.W	D0,D0
	MOVE.W	D1,0(A1,D0.W)
	ADDI.W	#$100,D1
	DBF	D2,L0002
	MOVEA.L	L0025,A0
	LEA	160(A0),A0
	MOVE.W	#$5555,D1
	MOVE.W	#$3333,D2
	MOVE.W	#$F0F,D3
	MOVE.W	#$FF,D4
	MOVE.L	#$115,D5
L0003:
	MOVEQ	#$1B,D6
L0004:
	MOVE.W	D1,(A0)+
	MOVE.W	D2,(A0)+
	MOVE.W	D3,(A0)+
	MOVE.W	D4,(A0)+
	DBF	D6,L0004
	ADDQ.L	#6,A0
	DBF	D5,L0003
	MOVE	#$2700,SR
	MOVE.L	#L001D,$68.W
	MOVE.L	#L0007,$70.W
	CLR.B	$FFFFFA07.W
	CLR.B	$FFFFFA09.W
	MOVE	#$2100,SR
L0005	BTST	#0,$FFFFFC00.W
	BEQ.S	L0005
	CMPI.B	#$39,$FFFFFC02.W
	BNE.S	L0005

	move.w	#$2700,sr

	jsr	music+4

	lea	storage,a0
	move.l	(a0)+,$68.w
	move.l	(a0)+,$70.w
	move.l	(a0)+,$120.w
	move.b	(a0)+,$fffffa1b.w
	move.b	(a0)+,$fffffa21.w
	move.b	(a0)+,$fffffa07.w
	move.b	(a0)+,$fffffa09.w
	move.b	(a0)+,$fffffa13.w
	move.b	(a0)+,$fffff201.w
	move.b	(a0)+,$ffff8203.w
	move.b	(a0)+,$484.w

	move.w	#$2300,SR
	move.l	#$8080000,$ffff8800.w
	move.l	#$9090000,$ffff8800.w
	move.l	#$A0A0000,$ffff8800.w

	move.l	$44E.w,a0
	move.l	#32000/4-1,d0
.loop	clr.l	(a0)+
	dbf	d0,.loop

		dc.w	$A009

		move.w	#8,$fffffc02.w

		movem.l	old_pal,d0-d7
		movem.l	d0-d7,$ffff8240.w

	PEA	0.L
	TRAP	#1
L0007:
	CLR.B	L0029
	MOVE.L	#L001D,$68.W
	MOVE	#$2100,SR
	JSR	music+8
	ADDQ.W	#1,L0026
	CMPI.W	#17,L0026
	BNE	L0011
	MOVEQ	#0,D0
L0008:
	MOVE.B	scroll_text,D0
L0009	EQU	*-4
	ADDQ.L	#1,L0009
	CMP.B	#0,D0
	BNE.S	L000A
	MOVE.W	#$90D2,L0017
	MOVE.W	#$90D2,L0018
	MOVE.W	#$90D2,L0019
	MOVE.W	#$90D2,L001B
	MOVE.L	#0,L0014
	BRA.S	L0008
L000A	CMP.B	#1,D0
	BNE.S	L000B
	MOVE.W	#$90D2,L0017
	MOVE.W	#$90D2,L0018
	MOVE.W	#$90D2,L0019
	MOVE.W	#$90D2,L001B
	MOVE.L	#4,L0014
	BRA.S	L0008
L000B	CMP.B	#2,D0
	BNE.S	L000C
	MOVE.W	#$90DA,L0017
	MOVE.W	#$90DA,L0018
	MOVE.W	#$90DA,L0019
	MOVE.W	#$90DA,L001B
	MOVE.L	#4,L0014
	BRA	L0008
L000C	CMP.B	#3,D0
	BNE.S	L000D
	MOVE.W	#0,L0010
	BRA	L0008
L000D	CMP.B	#4,D0
	BNE.S	L000E
	MOVE.W	#$10,L0010
	BRA	L0008
L000E	CMP.B	#$FF,D0
	BNE.S	L000F
	MOVE.L	#scroll_text,L0009
	BRA	L0008
L000F:
	CLR.W	L0026
	LEA	L0020,A6
	ADD.W	D0,D0
	MOVE.W	0(A6,D0.W),L002A
	ADDI.W	#$10,L0027
L0010	EQU	*-6
	CMPI.W	#$90,L0027
	BNE.S	L0011
	CLR.W	L0027
L0011:
	LEA	L0098,A2
L0012	EQU	*-4
	CMPI.L	#L0099,L0012
	BNE.S	L0013
	MOVE.L	#L0098,L0012
L0013:
	ADDI.L	#4,L0012
L0014	EQU	*-8
L0015:
	MOVE.B	$FFFF8209.W,D0
	BEQ.S	L0015
	NEG.W	D0
	LSL.L	D0,D0
	MOVE	#$2700,SR
	LEA	L0022,A0
	LEA	64(A0),A3
	LEA	$FFFF8240.W,A4
	LEA	$FFFF8260.W,A5
	LEA	$FFFF820A.W,A6
	MOVE.L	#$E1,D7
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVEQ	#0,D2
	MOVEQ	#0,D3
	MOVEQ	#0,D4
	MOVEQ	#0,D5
	MOVEQ	#0,D6
	MOVEA.L	D6,A1
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVEM.L	D0-D2,(A4)
	NOP
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	MOVEM.L	A1/D3-D6,$FFFF824C.W
	ADDA.W	(A2),A0
	MOVEM.L	(A3),A1/D0-D6
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	(A0)+,D0-D3
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	#0,(A6)
	MOVE.W	A5,(A6)
	MOVEM.L	(A0)+,A1/D4-D6
	LEA	128(A3),A3
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	NOP
	NOP
	NOP
L0016:
	MOVEM.L	D0-D2,(A4)
	NOP
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	MOVEM.L	A1/D3-D6,$FFFF824C.W
L0017:
	SUBA.W	(A2),A0
	ADDA.W	(A2),A0
	LEA	32(A0),A0
	MOVEM.L	(A3),A1/D0-D6
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	(A0)+,D0-D3
	NOP
	MOVE.B	#0,(A6)
	MOVE.W	A5,(A6)
	MOVEM.L	(A0)+,A1/D4-D6
	LEA	128(A3),A3
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	DBF	D7,L0016
	MOVEM.L	D0-D2,(A4)
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	MOVEM.L	A1/D3-D6,$FFFF824C.W
L0018:
	SUBA.W	(A2),A0
	ADDA.W	(A2),A0
	LEA	32(A0),A0
	MOVEM.L	(A3),A1/D0-D6
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	(A0)+,D0-D3
	NOP
	MOVE.B	#0,(A6)
	MOVE.W	A5,(A6)
	MOVEM.L	(A0)+,A1/D4-D6
	LEA	128(A3),A3
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	MOVEM.L	D0-D1,(A4)
	NOP
	MOVE.B	#0,(A6)
	MOVE.W	A5,(A6)
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	MOVEM.L	A1/D2-D6,8(A4)
L0019	SUBA.W	(A2),A0
	ADDA.W	(A2),A0
	LEA	32(A0),A0
	MOVEM.L	(A3),A1/D0-D6
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	(A0)+,D0-D2
	NOP
	MOVE.B	#0,(A6)
	MOVE.W	A5,(A6)
	MOVEM.L	(A0)+,A1/D3-D6
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	LEA	128(A3),A3
	MOVEQ	#$2C,D7
L001A:
	MOVEM.L	D0-D2,(A4)
	NOP
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	MOVEM.L	A1/D3-D6,$FFFF824C.W
L001B:
	SUBA.W	(A2),A0
	ADDA.W	(A2),A0
	LEA	32(A0),A0
	MOVEM.L	(A3),A1/D0-D6
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	A1/D0-D6,-(A3)
	MOVEM.L	(A0)+,D0-D3
	NOP
	MOVE.B	#0,(A6)
	MOVE.W	A5,(A6)
	MOVEM.L	(A0)+,A1/D4-D6
	LEA	128(A3),A3
	MOVE.W	A5,(A5)
	MOVE.B	#0,(A5)
	DBF	D7,L001A
	LEA	-64(A3),A3
	LEA	L002C,A4
	ADDA.W	L0027,A4

	LEA	L002E,A0
	ADDA.W	L002A,A0
	ADDI.W	#$10,L002A
	CMPI.W	#$10,L0026
	BNE.S	L001C
	LEA	L0021,A0
L001C:
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	MOVE.W	0(A4,D0.W),D1
	MOVE.W	D1,(A3)+
	MOVE.W	D1,30(A3)
	LEA	$FFFF8240.W,A0
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.L	(A0)+
	MOVE	#$2300,SR
	RTE
L001D:
	MOVE	#$2700,SR
	ADDQ.B	#1,L0029
	CMPI.B	#$21,L0029
	BEQ	L001E
	MOVE	#$2100,SR
	RTE
L001E:
	MOVE.L	#L001F,$68.W
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	#0,$FFFF820A.W
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	#2,$FFFF820A.W
	MOVE	#$2300,SR
L001F	RTE
L0020:
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00,'!',$00
	DC.B	'!',$00,'!',$00,'!',$00
L0021:
	DCB.W	8,0
L0022:
	DCB.W	8968,0
L0023:
	DCB.W	2,0

old_pal	ds.b	32

L0025	DCB.W	2,0
L0026	DC.B	$00,$00
L0027	DC.B	$00,$00

storage	ds.b	20

	DC.B	$00
L0029	DC.B	$00
L002A	DC.B	'!',$00
L002B	DC.B	'ABCDEFGHIJKLMNOPQRSTUVWXYZ.:!?()- '





L002C	DC.W	$000,$310,$420,$530,$640,$750,$760,$777
	DC.W	$000,$101,$202,$303,$404,$505,$606,$707
	DC.W	$000,$222,$131,$242,$353,$464,$575,$676
	DC.W	$000,$200,$300,$400,$510,$610,$720,$730
	DC.W	$000,$110,$220,$330,$440,$550,$660,$770
	DC.W	$000,$111,$222,$333,$444,$555,$666,$777
	DC.W	$000,$210,$320,$420,$520,$630,$740,$750
	DC.W	$000,$011,$022,$033,$044,$055,$066,$077
	DC.W	$000,$201,$302,$402,$502,$603,$704,$705

scroll_text
; 0=
; 1=
; 2=ripple from side to side
; 3=
; 4=
	DC.B	0,3,'      PERSISTENCE OF VISION PRESENTS    '
	DC.B	'     THE'
	dc.b	4
	DC.B	' RAINBOW '
	dc.b	3
	dc.b	'SCROLL !!                 '
	dc.b	1 
	DC.B	'  THANKS ',4,'TO KGB FOR THE ORIGINAL CODE.    '
	DC.B	'             '
	DC.B	2,' THIS IS NOT A MOVING BACK !      '
	DC.B	'        '
	DC.B	'   ',1,' THIS IS SIMPLY A RASTER SCROLL IN OVERSCAN !       '
	DC.B	'        '
	DC.B	'  ',2,'YES ! WE ARE BACK WITH THIS MULTI-PARTS CODED'
	DC.B	' BY  M.F'
	DC.B	' ',3,'AND',4,' BEN      '
	DC.B	'        '
	DC.B	'   ',$FF 
L002E	DC.B	$00,$00,$04,$0C,$0E,$0C,$0A,$08 
	DC.B	$06,$04,$02,$02,$04,$04,$00,$00 
	DC.B	$00,$04,$0A,$06,$04,$04,$04,$06 
	DC.B	$08,$0A,$0A,$08,$06,$06,$06,$00 
	DC.B	$00,$08,$06,$02,$00,$00,$02,$04 
	DC.B	$06,$04,$00,$00,$02,$04,$0A,$00 
	DC.B	$00,$0A,$02,$00,$00,$02,$04,$06 
	DC.B	$0A,$06,$02,$00,$00,$02,$0C,$00 
	DC.B	$00,$06,$08,$04,$02,$02,$06,$0E 
	DC.B	$0A,$08,$04,$00,$02,$08,$0A,$00 
	DC.B	$00,$02,$06,$04,$04,$06,$0E,$06 
	DC.B	$08,$0C,$06,$04,$06,$0C,$06,$00 
	DC.B	$00,$00,$04,$08,$06,$0A,$04,$00 
	DC.B	$04,$0E,$08,$04,$06,$08,$02,$00 
	DC.B	$00,$04,$0A,$08,$08,$04,$00,$02 
	DC.B	$06,$0A,$0A,$06,$04,$02,$00,$00 
	DC.B	$02,$0A,$0C,$06,$04,$02,$06,$08 
	DC.B	$06,$06,$0C,$08,$06,$02,$00,$00 
	DC.B	$08,$0E,$06,$04,$04,$08,$0C,$0A 
	DC.B	$06,$02,$08,$06,$08,$04,$00,$00 
	DC.B	$0E,$0A,$04,$02,$06,$04,$02,$00 
	DC.B	$00,$00,$04,$04,$0A,$06,$00,$00 
	DC.B	$0E,$08,$04,$02,$04,$00,$00,$00 
	DC.B	$00,$00,$02,$02,$08,$0C,$02,$00 
	DC.B	$08,$0C,$06,$02,$02,$00,$00,$00 
	DC.B	$00,$00,$00,$02,$04,$0E,$06,$00 
	DC.B	$04,$0A,$08,$04,$04,$02,$00,$00 
	DC.B	$00,$00,$00,$02,$02,$0C,$0C,$00 
	DC.B	$02,$06,$06,$04,$06,$04,$02,$00 
	DCB.W	2,0 
	DC.B	$04,$08,$0E,$00,$00,$02,$04,$06 
	DC.B	$08,$0A,$06,$00,$00,$00,$00,$00 
	DC.B	$04,$06,$0C,$00,$00,$04,$08,$0C 
	DC.B	$0E,$0E,$0C,$08,$06,$04,$02,$00 
	DCB.W	2,0 
	DC.B	$06,$06,$04,$04,$06,$04,$02,$04 
	DC.B	$06,$08,$08,$04,$00,$00,$00,$00 
	DC.B	$0A,$04,$00,$06,$0A,$06,$00,$00 
	DC.B	$00,$02,$08,$0A,$02,$00,$00,$00 
	DC.B	$0C,$06,$00,$0A,$0C,$06,$00,$00 
	DC.B	$00,$00,$04,$0E,$04,$00,$00,$00 
	DC.B	$06,$0C,$06,$0C,$06,$06,$00,$00 
	DC.B	$00,$00,$02,$0E,$04,$00,$00,$00 
	DC.B	$00,$06,$0A,$0E,$04,$04,$02,$00 
	DC.B	$00,$00,$04,$08,$02,$00,$00,$00 
	DC.B	$00,$00,$04,$0E,$04,$02,$08,$06 
	DC.B	$02,$02,$04,$04,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$0E,$06,$00,$08,$0C 
	DC.B	$0A,$06,$04,$02,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$0C,$08,$00,$02,$04 
	DC.B	$0A,$0E,$08,$04,$02,$00,$00,$00 
	DC.B	$00,$00,$00,$06,$08,$02,$00,$00 
	DC.B	$00,$06,$0C,$06,$06,$02,$00,$00 
	DC.B	$00,$00,$00,$04,$08,$04,$00,$00 
	DC.B	$00,$00,$02,$0A,$08,$06,$00,$00 
	DC.B	$00,$00,$00,$02,$04,$06,$00,$00 
	DC.B	$00,$00,$00,$04,$08,$0C,$04,$00 
	DCB.W	2,0 
	DC.B	$04,$08,$00,$00,$00,$00,$00,$02 
	DC.B	$06,$0E,$06,$00,$00,$00,$00,$02 
	DC.B	$06,$0C,$00,$00,$00,$00,$02,$04 
	DC.B	$06,$0C,$06,$00,$00,$00,$02,$04 
	DC.B	$06,$0A,$0A,$06,$04,$02,$04,$06 
	DC.B	$0A,$08,$02,$00,$00,$02,$04,$04 
	DC.B	$02,$00,$02,$04,$06,$0A,$0C,$0A 
	DC.B	$06,$02,$00,$00,$00,$00,$00,$02 
	DC.B	$06,$08,$0A,$08,$06,$04,$02,$00 
	DCB.W	3,0 
	DC.B	$04,$0E,$0C,$0A,$06,$04,$04,$04 
	DC.B	$06,$04,$02,$00,$00,$00,$00,$04 
	DC.B	$0E,$08,$04,$00,$00,$02,$00,$00 
	DC.B	$04,$06,$04,$00,$00,$00,$00,$08 
	DC.B	$06,$04,$00,$00,$00,$06,$00,$00 
	DC.B	$00,$04,$06,$02,$00,$00,$04,$0A 
	DC.B	$04,$02,$00,$00,$00,$0A,$02,$00 
	DC.B	$00,$02,$08,$04,$00,$00,$08,$08 
	DC.B	$02,$00,$00,$00,$00,$06,$0A,$02 
	DC.B	$02,$06,$06,$02,$00,$00,$0A,$06 
	DCB.W	3,0 
	DC.B	$06,$0C,$0C,$08,$02,$00,$00,$00 
	DC.B	$0A,$06,$02,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$02,$00,$00,$00,$00,$00 
	DC.B	$08,$08,$06,$00,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$02,$00,$04,$08,$0A,$02,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$00,$02,$06,$0E,$06,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$00,$00,$04,$0A,$0E,$04,$00 
	DCB.W	3,0 
	DC.B	$00,$02,$06,$00,$00,$02,$04,$0A 
	DC.B	$0E,$06,$02,$00,$00,$00,$00,$00 
	DC.B	$02,$06,$04,$00,$00,$00,$02,$06 
	DC.B	$0A,$0C,$0A,$06,$04,$02,$02,$02 
	DC.B	$06,$08,$00,$00,$00,$00,$00,$02 
	DC.B	$04,$06,$06,$06,$06,$06,$06,$08 
	DC.B	$08,$04,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$06,$0A,$0C,$0E,$0A,$08 
	DC.B	$02,$00,$00,$00,$00,$04,$08,$0C 
	DC.B	$0E,$0E,$0C,$0C,$0C,$0A,$06,$02 
	DCB.W	2,0 
	DC.B	$06,$06,$04,$02,$02,$00,$02,$04 
	DC.B	$06,$06,$0C,$0C,$06,$00,$00,$00 
	DC.B	$0A,$04,$00,$06,$04,$00,$00,$00 
	DC.B	$00,$00,$06,$0A,$0C,$06,$00,$00 
	DC.B	$0C,$06,$00,$0C,$08,$02,$00,$00 
	DC.B	$00,$00,$00,$04,$0A,$0E,$02,$00 
	DC.B	$06,$0C,$06,$0E,$0A,$02,$00,$00 
	DC.B	$00,$00,$00,$02,$04,$0E,$08,$00 
	DC.B	$00,$06,$0A,$0C,$0A,$04,$00,$00 
	DCB.W	2,0 
	DC.B	$04,$0C,$0C,$00,$00,$00,$04,$0A 
	DC.B	$08,$04,$04,$00,$00,$00,$00,$00 
	DC.B	$06,$0C,$0C,$00,$00,$00,$00,$06 
	DC.B	$08,$06,$08,$06,$00,$00,$00,$00 
	DC.B	$08,$0A,$0A,$00,$00,$00,$00,$04 
	DC.B	$06,$0A,$06,$0A,$04,$00,$00,$00 
	DC.B	$0A,$08,$08,$00,$00,$00,$00,$02 
	DC.B	$04,$0C,$00,$06,$08,$00,$00,$00 
	DC.B	$0C,$06,$06,$00,$00,$00,$00,$04 
	DC.B	$02,$0A,$00,$02,$06,$00,$00,$04 
	DC.B	$0C,$04,$04,$00,$00,$00,$00,$08 
	DC.B	$02,$06,$00,$04,$00,$00,$00,$08 
	DC.B	$0E,$02,$02,$00,$00,$00,$00,$0C 
	DC.B	$02,$04,$02,$00,$00,$00,$04,$0C 
	DC.B	$0A,$04,$00,$00,$00,$00,$02,$0E 
	DC.B	$04,$02,$00,$00,$00,$04,$0C,$0C 
	DC.B	$04,$02,$00,$00,$00,$00,$08,$0C 
	DC.B	$06,$02,$00,$04,$06,$08,$0A,$06 
	DC.B	$04,$00,$00,$00,$00,$06,$0A,$0C 
	DC.B	$0C,$0E,$0C,$0C,$0A,$08,$06,$02 
	DCB.W	2,0 
	DC.B	$00,$04,$08,$0C,$0E,$0C,$0C,$0C 
	DC.B	$0A,$0A,$08,$06,$04,$02,$00,$00 
	DC.B	$06,$06,$04,$02,$02,$04,$04,$06 
	DC.B	$08,$0A,$0C,$0C,$08,$04,$00,$00 
	DC.B	$0A,$04,$00,$06,$04,$02,$00,$00 
	DC.B	$00,$00,$00,$08,$0A,$06,$02,$00 
	DC.B	$0C,$06,$00,$0C,$08,$06,$00,$00 
	DC.B	$00,$00,$06,$0E,$08,$04,$00,$00 
	DC.B	$06,$0C,$06,$0E,$0A,$06,$00,$00 
	DC.B	$00,$04,$0C,$08,$02,$00,$00,$00 
	DC.B	$00,$06,$0A,$0E,$0A,$04,$00,$02 
	DC.B	$04,$08,$06,$02,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$0E,$08,$04,$00,$06 
	DC.B	$08,$06,$02,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$0C,$08,$08,$0A,$0C 
	DC.B	$0E,$0C,$0A,$08,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$0A,$06,$04,$02,$02 
	DC.B	$00,$02,$04,$06,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$08,$06,$02,$00,$00 
	DCB.W	3,0 
	DC.B	$02,$00,$00,$00,$00,$06,$04,$02 
	DCB.W	4,0 
	DC.B	$06,$00,$00,$00,$00,$06,$02,$00 
	DCB.W	3,0 
	DC.B	$00,$02,$0A,$00,$00,$00,$00,$0A 
	DC.B	$00,$02,$04,$08,$0E,$0C,$0A,$06 
	DC.B	$02,$06,$0A,$00,$00,$00,$02,$0C 
	DC.B	$04,$08,$0C,$0C,$0A,$08,$06,$04 
	DC.B	$04,$06,$08,$00,$00,$00,$06,$08 
	DC.B	$08,$0A,$08,$06,$04,$02,$02,$02 
	DC.B	$04,$04,$04,$00,$00,$06,$08,$06 
	DC.B	$06,$04,$02,$00,$00,$00,$02,$00 
	DC.B	$02,$02,$00,$00,$00,$04,$08,$0C 
	DC.B	$0E,$0E,$0C,$0C,$0C,$0A,$08,$06 
	DC.B	$04,$02,$00,$00,$06,$06,$04,$02 
	DC.B	$02,$00,$02,$04,$06,$08,$0C,$0C 
	DC.B	$08,$04,$00,$00,$0A,$04,$00,$06 
	DC.B	$04,$00,$00,$00,$00,$00,$00,$08 
	DC.B	$0A,$06,$02,$00,$0C,$06,$00,$0C 
	DC.B	$08,$02,$00,$00,$00,$00,$06,$0E 
	DC.B	$08,$04,$00,$00,$06,$0C,$06,$0E 
	DC.B	$0A,$02,$00,$00,$00,$04,$0C,$08 
	DC.B	$02,$00,$00,$00,$00,$06,$0A,$0C 
	DC.B	$0A,$04,$00,$02,$04,$08,$06,$02 
	DCB.W	3,0 
	DC.B	$04,$0A,$08,$04,$00,$06,$08,$06 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$06,$08,$06,$08,$0C,$0C,$0E 
	DC.B	$0C,$0A,$08,$00,$00,$00,$00,$00 
	DC.B	$00,$04,$06,$0A,$04,$04,$02,$00 
	DC.B	$02,$04,$06,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$0C,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$02,$0A,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$08,$02,$06,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$0C,$02,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$0E,$04,$02,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$08,$0C,$06,$02,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$06,$0E,$0A,$06,$04,$02,$00 
	DCB.W	6,0 
	DC.B	$02,$06,$08,$0A,$08,$06,$04,$02 
	DCB.W	3,0 
	DC.B	$00,$06,$0E,$0C,$0A,$08,$0A,$0A 
	DC.B	$08,$06,$02,$00,$00,$00,$00,$00 
	DC.B	$08,$0E,$08,$06,$02,$00,$02,$0C 
	DC.B	$08,$04,$00,$00,$00,$00,$00,$06 
	DC.B	$0E,$08,$04,$00,$00,$02,$0E,$08 
	DC.B	$04,$00,$00,$00,$00,$00,$02,$0A 
	DC.B	$08,$04,$00,$00,$00,$0C,$08,$02 
	DCB.W	3,0 
	DC.B	$06,$08,$06,$00,$00,$00,$06,$08 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$0A,$06,$02,$00,$00,$00,$08,$04 
	DCB.W	4,0 
	DC.B	$0A,$04,$02,$00,$00,$00,$06,$00 
	DC.B	$00,$02,$04,$04,$06,$08,$0A,$00 
	DC.B	$08,$06,$02,$00,$00,$00,$04,$00 
	DC.B	$00,$00,$02,$04,$06,$08,$04,$00 
	DC.B	$06,$08,$06,$00,$00,$00,$02,$00 
	DC.B	$00,$00,$00,$04,$04,$08,$00,$00 
	DC.B	$04,$08,$0C,$04,$00,$00,$00,$02 
	DC.B	$00,$00,$00,$02,$02,$0A,$00,$00 
	DC.B	$02,$06,$0A,$0E,$00,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$04,$0E,$00,$00,$00,$04,$06,$0C 
	DC.B	$0E,$06,$00,$00,$00,$00,$00,$00 
	DC.B	$06,$0E,$00,$00,$00,$00,$04,$06 
	DC.B	$0A,$0C,$0A,$08,$06,$04,$00,$02 
	DC.B	$06,$0C,$00,$00,$00,$00,$00,$04 
	DC.B	$06,$06,$08,$06,$04,$02,$02,$04 
	DC.B	$06,$06,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$02,$04,$06,$08,$0A,$08 
	DC.B	$04,$02,$00,$00,$00,$02,$06,$08 
	DC.B	$0A,$0E,$0E,$0C,$04,$00,$04,$06 
	DC.B	$0A,$08,$06,$00,$02,$08,$06,$04 
	DC.B	$02,$06,$06,$0A,$0C,$00,$00,$02 
	DC.B	$04,$06,$08,$00,$06,$02,$00,$06 
	DC.B	$04,$0E,$00,$06,$0A,$00,$00,$00 
	DC.B	$02,$08,$08,$00,$04,$00,$00,$08 
	DC.B	$06,$0C,$04,$0A,$04,$00,$00,$00 
	DC.B	$02,$0A,$0A,$00,$00,$02,$06,$0A 
	DC.B	$08,$0C,$06,$04,$00,$00,$00,$00 
	DC.B	$04,$0A,$0C,$00,$00,$06,$00,$0C 
	DC.B	$0C,$08,$04,$00,$04,$02,$00,$00 
	DC.B	$06,$08,$0C,$00,$00,$00,$04,$0A 
	DC.B	$08,$04,$04,$06,$08,$06,$02,$00 
	DC.B	$08,$06,$08,$00,$00,$00,$00,$06 
	DC.B	$08,$06,$02,$06,$0A,$0C,$06,$04 
	DC.B	$0A,$04,$06,$00,$00,$00,$00,$04 
	DC.B	$06,$0A,$00,$00,$00,$06,$08,$08 
	DC.B	$0C,$02,$04,$00,$00,$00,$00,$02 
	DC.B	$04,$0C,$00,$00,$00,$00,$06,$08 
	DC.B	$0E,$02,$02,$00,$00,$00,$00,$04 
	DC.B	$02,$0A,$00,$00,$00,$00,$00,$06 
	DC.B	$0C,$04,$02,$00,$00,$00,$00,$08 
	DC.B	$02,$06,$00,$00,$00,$00,$00,$06 
	DC.B	$0C,$06,$00,$00,$00,$00,$00,$0C 
	DC.B	$02,$04,$00,$00,$00,$00,$00,$04 
	DC.B	$0A,$08,$02,$00,$00,$00,$02,$0E 
	DC.B	$04,$02,$00,$00,$00,$00,$00,$02 
	DC.B	$0A,$0A,$04,$00,$00,$00,$08,$0C 
	DC.B	$06,$02,$00,$00,$00,$00,$0E,$0C 
	DC.B	$0C,$0A,$06,$00,$00,$06,$0E,$0A 
	DC.B	$06,$04,$02,$00,$00,$00,$02,$04 
	DC.B	$06,$08,$0A,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$06,$0C,$0E,$0A,$08,$06 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$02,$08,$0C,$0A,$08,$06,$08,$0A 
	DC.B	$04,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$06,$0A,$06,$02,$04,$06,$0A,$06 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$0A,$06,$02,$02,$06,$08,$0A,$02 
	DCB.W	4,0 
	DC.B	$08,$02,$00,$04,$06,$0A,$08,$00 
	DCB.W	4,0 
	DC.B	$02,$06,$00,$08,$08,$0C,$06,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$04,$0C,$0A,$0A,$04,$00 
	DCB.W	5,0 
	DC.B	$00,$0E,$0C,$08,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$08,$0E,$04,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$0C,$06,$04,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$02,$00,$02,$0A,$06,$06,$02 
	DCB.W	4,0 
	DC.B	$02,$00,$00,$00,$08,$04,$08,$04 
	DCB.W	4,0 
	DC.B	$04,$00,$00,$00,$06,$04,$0A,$08 
	DCB.W	4,0 
	DC.B	$02,$06,$04,$02,$02,$06,$0E,$0A 
	DCB.W	4,0 
	DC.B	$00,$02,$06,$06,$06,$0A,$0C,$06 
	DCB.W	5,0 
	DC.B	$02,$04,$08,$0C,$08,$02,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$06,$08,$0A,$0E,$0E,$0C 
	DC.B	$04,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$02,$08,$06,$04,$02,$06,$06,$0A 
	DC.B	$0C,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$06,$02,$00,$06,$04,$0E,$00,$06 
	DC.B	$0A,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$04,$00,$00,$08,$06,$0C,$04,$0A 
	DC.B	$04,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$00,$0A,$08,$0C,$06,$04 
	DCB.W	5,0 
	DC.B	$00,$0C,$0C,$08,$04,$00,$00,$00 
	DC.B	$00,$00,$00,$02,$06,$02,$00,$00 
	DC.B	$00,$0C,$0C,$06,$02,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$02,$06,$00,$00,$00,$08,$0E,$04 
	DCB.W	3,0 
	DC.B	$00,$04,$0A,$04,$00,$00,$00,$04 
	DC.B	$0E,$02,$02,$00,$00,$00,$00,$00 
	DC.B	$04,$0C,$06,$02,$00,$00,$00,$02 
	DC.B	$0C,$04,$04,$00,$00,$00,$00,$04 
	DC.B	$0A,$04,$02,$00,$00,$00,$00,$00 
	DC.B	$0C,$06,$04,$00,$00,$00,$04,$0A 
	DC.B	$06,$02,$00,$00,$00,$00,$00,$00 
	DC.B	$0A,$08,$06,$00,$00,$00,$06,$0E 
	DC.B	$08,$04,$00,$00,$00,$00,$00,$00 
	DC.B	$08,$0A,$08,$00,$00,$00,$06,$0A 
	DC.B	$0C,$08,$04,$02,$00,$00,$00,$00 
	DC.B	$06,$0C,$0C,$00,$00,$00,$02,$06 
	DC.B	$08,$0A,$0C,$0A,$08,$06,$04,$02 
	DC.B	$04,$0E,$08,$00,$00,$00,$00,$02 
	DC.B	$04,$04,$02,$02,$04,$06,$08,$0C 
	DC.B	$0E,$0C,$04,$00,$00,$00,$00,$04 
	DC.B	$08,$0C,$0E,$0C,$06,$02,$00,$00 
	DC.B	$0A,$08,$06,$04,$02,$00,$06,$06 
	DC.B	$04,$04,$06,$04,$02,$00,$00,$00 
	DC.B	$0C,$0A,$06,$04,$00,$00,$0A,$04 
	DC.B	$00,$06,$0A,$06,$00,$00,$00,$02 
	DC.B	$0E,$0A,$06,$02,$00,$00,$0A,$06 
	DC.B	$00,$0A,$0C,$06,$00,$00,$00,$06 
	DC.B	$0E,$06,$04,$00,$00,$00,$06,$0E 
	DC.B	$06,$0C,$06,$06,$00,$00,$02,$0C 
	DC.B	$08,$04,$02,$00,$00,$00,$02,$06 
	DC.B	$0A,$0E,$04,$04,$02,$04,$0A,$06 
	DC.B	$04,$02,$00,$00,$00,$00,$00,$02 
	DC.B	$06,$0E,$04,$02,$04,$06,$06,$04 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$02,$0C,$06,$00,$04,$08,$06,$06 
	DC.B	$04,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$0A,$08,$00,$02,$0A,$0C,$0A 
	DC.B	$06,$04,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$06,$08,$02,$00,$00,$06,$0E 
	DC.B	$0E,$06,$02,$00,$00,$00,$00,$00 
	DC.B	$00,$04,$08,$04,$00,$00,$00,$04 
	DC.B	$0E,$0A,$04,$02,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$06,$00,$00,$00,$00 
	DC.B	$04,$0C,$06,$04,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$08,$00,$00,$00,$00 
	DC.B	$00,$0A,$06,$08,$00,$00,$00,$00 
	DC.B	$00,$02,$06,$0C,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$0A,$00,$00,$00,$00 
	DC.B	$02,$04,$06,$0A,$02,$00,$00,$00 
	DC.B	$02,$04,$06,$0E,$04,$00,$00,$02 
	DC.B	$04,$06,$08,$08,$04,$00,$00,$02 
	DC.B	$04,$06,$0A,$0C,$0A,$00,$04,$06 
	DC.B	$08,$0A,$0E,$0E,$0C,$04,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$02,$06,$06,$0A,$0C,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$04,$0E,$00,$06,$0A,$00,$00 
	DCB.W	4,0 
	DC.B	$08,$06,$0C,$04,$0A,$04,$00,$00 
	DCB.W	4,0 
	DC.B	$0A,$08,$0C,$06,$04,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$04,$0C,$0C,$08,$04,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$08,$0C,$0C,$06,$02,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$0A,$08,$0E,$04,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$0A,$04,$04,$0E,$02,$02,$00,$00 
	DC.B	$00,$00,$02,$06,$02,$00,$00,$00 
	DC.B	$06,$02,$02,$0C,$04,$04,$00,$00 
	DC.B	$00,$00,$06,$02,$00,$00,$00,$00 
	DC.B	$02,$06,$00,$0C,$06,$04,$00,$00 
	DC.B	$00,$00,$04,$0A,$04,$00,$00,$00 
	DC.B	$00,$00,$04,$0A,$08,$06,$00,$00 
	DC.B	$00,$00,$02,$06,$0C,$04,$00,$00 
	DC.B	$00,$00,$00,$08,$0A,$08,$00,$00 
	DC.B	$00,$00,$00,$02,$06,$0A,$04,$00 
	DC.B	$00,$00,$00,$0C,$0C,$06,$00,$00 
	DC.B	$00,$02,$04,$08,$0C,$0A,$06,$00 
	DC.B	$00,$00,$00,$08,$0E,$04,$04,$06 
	DC.B	$08,$0A,$0C,$0A,$08,$06,$02,$00 
	DC.B	$00,$00,$00,$04,$0C,$0E,$0C,$08 
	DC.B	$04,$02,$02,$04,$04,$02,$00,$00 
	DC.B	$04,$0A,$0C,$0E,$0C,$0A,$08,$06 
	DC.B	$04,$04,$02,$04,$06,$08,$04,$00 
	DC.B	$0A,$08,$06,$04,$06,$08,$08,$0A 
	DC.B	$0C,$0C,$0E,$0C,$0C,$0C,$08,$00 
	DC.B	$06,$06,$02,$08,$0A,$06,$00,$0A 
	DC.B	$00,$06,$0A,$0A,$00,$0C,$06,$00 
	DC.B	$04,$06,$08,$0C,$06,$00,$00,$08 
	DC.B	$00,$00,$06,$0C,$08,$04,$04,$00 
	DC.B	$02,$04,$0C,$08,$04,$04,$08,$0E 
	DC.B	$0C,$06,$04,$08,$0C,$06,$02,$00 
	DC.B	$02,$0A,$0A,$04,$02,$04,$06,$04 
	DC.B	$06,$08,$04,$04,$0A,$0C,$02,$00 
	DC.B	$06,$0C,$06,$02,$00,$00,$00,$08 
	DC.B	$00,$00,$00,$02,$06,$0E,$06,$00 
	DC.B	$0A,$0C,$04,$00,$00,$00,$00,$0A 
	DCB.W	2,0 
	DC.B	$04,$0C,$08,$00,$0A,$0A,$06,$00 
	DC.B	$00,$00,$00,$0C,$00,$00,$00,$00 
	DC.B	$06,$0A,$0A,$00,$08,$08,$08,$00 
	DC.B	$00,$00,$00,$0C,$00,$00,$00,$00 
	DC.B	$08,$08,$08,$00,$06,$06,$08,$00 
	DC.B	$00,$00,$00,$0E,$00,$00,$00,$00 
	DC.B	$0C,$06,$06,$00,$04,$04,$0A,$00 
	DC.B	$00,$00,$00,$0C,$00,$00,$00,$00 
	DC.B	$0E,$04,$04,$00,$02,$02,$0C,$02 
	DC.B	$00,$00,$00,$0A,$00,$00,$00,$02 
	DC.B	$0E,$02,$02,$00,$00,$02,$0E,$06 
	DC.B	$00,$00,$00,$06,$00,$00,$00,$06 
	DC.B	$0A,$02,$00,$00,$00,$02,$06,$0C 
	DC.B	$04,$00,$02,$06,$02,$00,$04,$0C 
	DC.B	$06,$02,$00,$00,$02,$04,$06,$0A 
	DC.B	$08,$02,$0A,$06,$04,$02,$08,$0A 
	DC.B	$06,$04,$02,$00,$00,$06,$0A,$0C 
	DC.B	$0E,$0C,$0A,$08,$06,$04,$02,$00 
	DCB.W	2,0 
	DC.B	$06,$06,$04,$02,$02,$04,$04,$06 
	DC.B	$08,$06,$06,$04,$00,$00,$00,$00 
	DC.B	$0A,$04,$00,$06,$04,$02,$04,$06 
	DC.B	$0A,$0C,$0A,$06,$04,$00,$00,$00 
	DC.B	$0C,$06,$00,$0C,$08,$02,$00,$00 
	DC.B	$02,$06,$0E,$0E,$06,$02,$00,$00 
	DC.B	$06,$0C,$06,$0E,$0A,$02,$00,$00 
	DC.B	$00,$00,$04,$0E,$0A,$04,$02,$00 
	DC.B	$00,$06,$0A,$0C,$0A,$04,$02,$00 
	DC.B	$00,$00,$00,$04,$0C,$06,$04,$00 
	DC.B	$00,$00,$04,$0A,$08,$04,$06,$02 
	DCB.W	2,0 
	DC.B	$08,$06,$06,$00,$00,$00,$00,$06 
	DC.B	$08,$06,$08,$06,$00,$00,$00,$00 
	DC.B	$04,$04,$08,$00,$00,$00,$00,$04 
	DC.B	$06,$0A,$00,$0C,$00,$00,$00,$00 
	DC.B	$02,$08,$08,$00,$00,$00,$00,$02 
	DC.B	$04,$0C,$02,$06,$00,$00,$00,$02 
	DC.B	$04,$0E,$06,$00,$00,$00,$00,$04 
	DC.B	$02,$0A,$06,$02,$00,$00,$00,$04 
	DC.B	$08,$0C,$04,$00,$00,$00,$00,$08 
	DC.B	$02,$06,$02,$00,$00,$00,$02,$04 
	DC.B	$0A,$0C,$02,$00,$00,$00,$00,$0C 
	DC.B	$02,$04,$00,$00,$00,$00,$04,$06 
	DC.B	$0C,$06,$00,$00,$00,$00,$02,$0E 
	DC.B	$04,$02,$00,$00,$00,$00,$06,$08 
	DC.B	$08,$02,$00,$00,$00,$00,$08,$0C 
	DC.B	$06,$02,$00,$00,$00,$00,$08,$0A 
	DC.B	$06,$04,$00,$00,$00,$06,$0E,$0A 
	DC.B	$06,$04,$02,$00,$00,$00,$04,$0C 
	DC.B	$0A,$06,$04,$00,$00,$00,$00,$00 
	DC.B	$02,$04,$02,$04,$06,$04,$02,$00 
	DCB.W	3,0 
	DC.B	$02,$06,$06,$0A,$0C,$0C,$0A,$08 
	DC.B	$06,$04,$00,$00,$00,$00,$00,$04 
	DC.B	$08,$08,$08,$04,$02,$00,$00,$00 
	DC.B	$08,$0A,$00,$02,$00,$00,$02,$0A 
	DC.B	$0A,$06,$02,$00,$00,$00,$00,$02 
	DC.B	$06,$08,$02,$06,$04,$00,$06,$0C 
	DC.B	$06,$04,$00,$00,$00,$00,$00,$04 
	DC.B	$0A,$06,$04,$08,$06,$00,$0C,$0C 
	DC.B	$04,$02,$00,$00,$00,$00,$02,$08 
	DC.B	$08,$02,$06,$06,$08,$00,$0C,$0C 
	DC.B	$04,$00,$00,$00,$00,$00,$06,$0A 
	DC.B	$04,$00,$04,$04,$0A,$00,$0E,$0E 
	DC.B	$02,$00,$00,$00,$00,$02,$0C,$04 
	DC.B	$00,$00,$02,$02,$0C,$00,$0E,$0C 
	DC.B	$02,$00,$00,$00,$04,$0A,$04,$00 
	DC.B	$00,$00,$04,$04,$0E,$00,$0C,$0A 
	DC.B	$04,$00,$00,$04,$08,$04,$00,$00 
	DC.B	$00,$02,$06,$08,$0C,$00,$0C,$08 
	DC.B	$04,$04,$06,$06,$04,$00,$00,$00 
	DC.B	$00,$04,$08,$0C,$08,$00,$06,$08 
	DC.B	$06,$08,$06,$04,$00,$00,$00,$00 
	DC.B	$02,$08,$0A,$0A,$06,$00,$02,$06 
	DC.B	$08,$08,$06,$00,$00,$00,$02,$04 
	DC.B	$08,$0A,$08,$0A,$02,$00,$00,$04 
	DC.B	$04,$08,$0A,$0A,$0C,$0E,$0E,$0C 
	DC.B	$0C,$08,$08,$04,$00,$00,$00,$00 
	DC.B	$04,$04,$06,$0A,$0C,$0E,$0C,$0A 
	DC.B	$08,$06,$04,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$04,$02,$02,$02,$04 
	DC.B	$04,$02,$00,$00,$00,$00,$00,$04 
	DC.B	$08,$0C,$0E,$0C,$0C,$0A,$08,$06 
	DC.B	$04,$02,$00,$00,$00,$00,$06,$06 
	DC.B	$04,$02,$02,$04,$06,$08,$0A,$0A 
	DC.B	$08,$04,$04,$00,$00,$00,$0A,$04 
	DC.B	$00,$06,$04,$02,$00,$00,$02,$06 
	DC.B	$0A,$0C,$06,$02,$00,$00,$0C,$06 
	DC.B	$00,$0C,$08,$06,$00,$00,$00,$00 
	DC.B	$04,$0E,$0C,$04,$02,$00,$06,$0C 
	DC.B	$06,$0E,$0C,$06,$00,$00,$00,$00 
	DC.B	$00,$06,$0A,$08,$04,$00,$00,$06 
	DC.B	$0A,$0E,$0C,$04,$02,$06,$08,$02 
	DC.B	$00,$02,$08,$06,$06,$00,$00,$02 
	DC.B	$04,$0E,$0A,$04,$04,$0C,$00,$06 
	DC.B	$02,$00,$06,$06,$08,$00,$00,$00 
	DC.B	$00,$0C,$08,$04,$06,$0A,$00,$00 
	DC.B	$04,$00,$04,$08,$0A,$00,$00,$00 
	DC.B	$00,$0A,$06,$04,$08,$08,$06,$04 
	DC.B	$02,$04,$06,$0C,$06,$00,$00,$00 
	DC.B	$00,$08,$04,$02,$04,$08,$0A,$0C 
	DC.B	$0C,$0E,$0C,$06,$00,$00,$00,$00 
	DC.B	$00,$06,$04,$02,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$02,$02,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$0A,$00,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$0C,$04,$06,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$08,$06,$0A,$06,$02,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$04,$08,$06,$06,$04,$08,$06 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$02,$04,$06,$08,$06 
	DC.B	$04,$02,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$06,$06,$0A,$0C,$0C 
	DC.B	$08,$06,$06,$02,$00,$00,$00,$00 
	DC.B	$00,$04,$08,$08,$08,$04,$02,$02 
	DC.B	$06,$08,$06,$08,$02,$00,$00,$00 
	DC.B	$02,$0A,$0A,$06,$02,$00,$00,$00 
	DC.B	$00,$02,$06,$08,$08,$00,$00,$00 
	DC.B	$06,$0C,$06,$04,$04,$00,$00,$00 
	DC.B	$00,$00,$04,$06,$0A,$06,$00,$00 
	DC.B	$0A,$0C,$04,$02,$06,$02,$00,$00 
	DC.B	$00,$00,$00,$04,$0A,$0C,$00,$00 
	DC.B	$0E,$0E,$04,$06,$08,$04,$00,$00 
	DC.B	$00,$00,$00,$02,$08,$0E,$00,$00 
	DC.B	$0E,$0C,$02,$02,$06,$0A,$02,$00 
	DC.B	$00,$00,$00,$04,$08,$0C,$00,$00 
	DC.B	$0C,$0C,$02,$00,$04,$06,$0C,$02 
	DC.B	$00,$00,$00,$06,$06,$0A,$00,$00 
	DC.B	$0A,$0A,$04,$00,$00,$04,$08,$0E 
	DC.B	$02,$00,$00,$08,$06,$08,$00,$00 
	DC.B	$0A,$08,$04,$00,$00,$00,$02,$08 
	DC.B	$0C,$02,$00,$06,$04,$06,$00,$00 
	DC.B	$06,$08,$06,$08,$00,$00,$00,$04 
	DC.B	$0A,$0C,$06,$02,$02,$04,$00,$00 
	DC.B	$02,$06,$08,$08,$06,$00,$00,$00 
	DC.B	$06,$08,$0A,$06,$04,$02,$00,$00 
	DC.B	$00,$04,$04,$08,$0A,$0A,$0E,$08 
	DC.B	$04,$08,$06,$08,$06,$02,$00,$00 
	DC.B	$00,$00,$04,$04,$06,$0A,$0E,$0C 
	DC.B	$08,$04,$0A,$08,$06,$06,$04,$00 
	DC.B	$00,$00,$00,$02,$04,$04,$02,$02 
	DC.B	$04,$06,$02,$06,$0A,$08,$06,$00 
	DC.B	$00,$06,$08,$0A,$0C,$0C,$0E,$0C 
	DC.B	$0C,$0A,$08,$06,$04,$02,$00,$00 
	DC.B	$06,$06,$04,$02,$02,$00,$02,$04 
	DC.B	$06,$06,$08,$0A,$06,$02,$02,$00 
	DC.B	$0A,$04,$00,$06,$04,$00,$00,$00 
	DC.B	$00,$02,$04,$0E,$0C,$06,$04,$00 
	DC.B	$0C,$06,$00,$0C,$08,$02,$00,$00 
	DC.B	$00,$00,$00,$04,$0A,$08,$02,$00 
	DC.B	$06,$0C,$06,$0E,$0A,$02,$00,$00 
	DC.B	$00,$00,$00,$02,$08,$04,$00,$00 
	DC.B	$00,$06,$0A,$0C,$0A,$04,$04,$02 
	DC.B	$00,$00,$02,$06,$06,$00,$00,$00 
	DC.B	$00,$00,$04,$0A,$08,$04,$0C,$0A 
	DC.B	$06,$04,$06,$08,$02,$00,$00,$00 
	DC.B	$00,$00,$00,$06,$08,$06,$02,$04 
	DC.B	$06,$08,$08,$0A,$06,$02,$00,$00 
	DC.B	$00,$00,$00,$04,$06,$0A,$00,$00 
	DC.B	$00,$02,$06,$0A,$0C,$06,$00,$00 
	DC.B	$00,$00,$00,$02,$04,$0C,$00,$00 
	DC.B	$00,$00,$02,$06,$0A,$0C,$02,$00 
	DC.B	$00,$00,$00,$04,$02,$0A,$00,$00 
	DC.B	$00,$00,$00,$04,$06,$0A,$08,$00 
	DC.B	$00,$00,$00,$08,$02,$06,$00,$00 
	DC.B	$00,$00,$00,$02,$02,$08,$0E,$00 
	DC.B	$00,$00,$00,$0C,$02,$04,$00,$00 
	DCB.W	2,0 
	DC.B	$04,$08,$0E,$00,$00,$00,$02,$0E 
	DC.B	$04,$02,$00,$00,$00,$00,$00,$00 
	DC.B	$06,$0A,$0C,$00,$00,$00,$08,$0C 
	DC.B	$06,$02,$00,$00,$00,$00,$00,$00 
	DC.B	$08,$0C,$0C,$00,$00,$06,$0E,$0A 
	DC.B	$06,$04,$00,$00,$00,$00,$00,$00 
	DC.B	$0C,$08,$08,$00,$00,$00,$04,$08 
	DC.B	$08,$08,$06,$04,$02,$04,$06,$04 
	DCB.W	2,0 
	DC.B	$00,$06,$0A,$06,$06,$08,$08,$0A 
	DC.B	$0C,$0C,$0C,$0A,$04,$00,$00,$00 
	DC.B	$00,$0C,$06,$04,$00,$00,$00,$00 
	DC.B	$00,$00,$02,$08,$06,$00,$00,$00 
	DC.B	$00,$0E,$04,$02,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$06,$04,$00,$00,$00 
	DC.B	$00,$0A,$06,$04,$02,$00,$00,$00 
	DC.B	$00,$00,$02,$04,$00,$00,$00,$00 
	DC.B	$00,$04,$0A,$06,$04,$06,$06,$04 
	DC.B	$02,$00,$00,$02,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$08,$08,$06,$04,$06 
	DC.B	$08,$06,$02,$00,$02,$00,$00,$00 
	DC.B	$00,$00,$00,$02,$04,$06,$08,$06 
	DC.B	$04,$06,$0A,$06,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$02,$00,$00,$00,$02 
	DC.B	$02,$04,$06,$0C,$0A,$00,$00,$00 
	DC.B	$00,$04,$02,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$0A,$0E,$08,$00,$00 
	DC.B	$02,$04,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$02,$06,$0C,$0C,$00,$00 
	DC.B	$04,$06,$02,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$02,$04,$0C,$0E,$00,$00 
	DC.B	$06,$08,$08,$04,$02,$00,$00,$00 
	DC.B	$00,$02,$04,$06,$0C,$08,$00,$00 
	DC.B	$04,$06,$08,$0A,$0C,$0E,$0C,$0C 
	DC.B	$0A,$0A,$08,$0C,$0C,$02,$00,$00 
	DC.B	$02,$04,$06,$0A,$0C,$0E,$0C,$0C 
	DC.B	$0A,$08,$0A,$0A,$04,$00,$00,$00 
	DC.B	$00,$02,$04,$06,$04,$02,$04,$06 
	DC.B	$08,$08,$06,$02,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$06,$08,$0A,$0C,$0E 
	DC.B	$0C,$0A,$08,$06,$04,$02,$00,$00 
	DC.B	$04,$04,$0C,$0A,$08,$06,$04,$02 
	DC.B	$06,$06,$08,$0A,$0C,$08,$02,$00 
	DC.B	$06,$06,$0A,$04,$00,$00,$00,$02 
	DC.B	$0E,$00,$00,$04,$0C,$08,$04,$00 
	DC.B	$02,$08,$08,$06,$00,$00,$00,$04 
	DC.B	$0C,$00,$00,$08,$0A,$06,$00,$00 
	DC.B	$00,$02,$0A,$08,$00,$00,$00,$06 
	DC.B	$0A,$00,$00,$0A,$08,$00,$00,$00 
	DC.B	$00,$00,$0C,$04,$00,$00,$00,$08 
	DC.B	$08,$00,$00,$04,$08,$00,$00,$00 
	DC.B	$00,$06,$02,$00,$00,$00,$00,$0A 
	DC.B	$06,$00,$00,$00,$02,$04,$00,$00 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$0C 
	DC.B	$04,$00,$00,$00,$00,$00,$02,$00 
	DCB.W	3,0 
	DC.B	$00,$0E,$02,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$0C,$04,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$0A,$06,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$08,$08,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$0A,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$0C,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$06,$0E,$08,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$02,$04,$06,$0C,$0C,$08,$00 
	DCB.W	2,0 
	DC.B	$00,$04,$06,$08,$0A,$0C,$0C,$06 
	DC.B	$00,$04,$06,$0A,$08,$06,$04,$00 
	DC.B	$04,$08,$0A,$06,$04,$02,$0C,$0C 
	DC.B	$00,$00,$02,$04,$06,$08,$02,$00 
	DC.B	$04,$0A,$08,$00,$00,$02,$0A,$0A 
	DC.B	$00,$00,$00,$02,$08,$08,$00,$00 
	DC.B	$02,$06,$0C,$00,$02,$04,$0A,$06 
	DC.B	$00,$00,$00,$02,$0A,$0A,$00,$00 
	DC.B	$00,$02,$06,$06,$04,$08,$08,$04 
	DC.B	$00,$00,$00,$04,$0A,$0C,$00,$00 
	DC.B	$00,$02,$04,$08,$08,$08,$04,$00 
	DC.B	$00,$00,$00,$06,$08,$0C,$00,$00 
	DC.B	$02,$06,$0A,$08,$06,$04,$06,$02 
	DC.B	$00,$00,$00,$08,$06,$08,$00,$00 
	DC.B	$06,$0C,$0A,$04,$02,$04,$0A,$06 
	DC.B	$02,$00,$00,$0A,$04,$06,$00,$00 
	DC.B	$0C,$0C,$04,$02,$00,$00,$04,$0C 
	DC.B	$04,$02,$00,$0C,$02,$04,$00,$00 
	DC.B	$0E,$08,$02,$00,$00,$00,$00,$04 
	DC.B	$0C,$06,$02,$0E,$02,$02,$00,$00 
	DC.B	$0E,$06,$02,$00,$00,$00,$00,$00 
	DC.B	$04,$0A,$06,$0C,$04,$02,$00,$00 
	DC.B	$0C,$08,$04,$02,$00,$00,$00,$00 
	DC.B	$00,$02,$06,$0C,$06,$00,$00,$00 
	DC.B	$06,$0C,$06,$04,$02,$00,$00,$00 
	DC.B	$00,$00,$04,$0A,$08,$02,$00,$00 
	DC.B	$02,$08,$08,$06,$06,$04,$02,$00 
	DC.B	$00,$00,$02,$0A,$0A,$04,$00,$00 
	DC.B	$00,$04,$08,$06,$08,$08,$0A,$0C 
	DC.B	$0C,$0E,$0C,$0C,$0A,$06,$02,$00 
	DC.B	$00,$00,$02,$06,$0C,$0A,$08,$06 
	DC.B	$04,$02,$04,$06,$08,$0A,$08,$00 
	DC.B	$0C,$0A,$08,$06,$04,$00,$00,$00 
	DC.B	$00,$00,$02,$06,$08,$06,$00,$00 
	DC.B	$00,$00,$02,$04,$08,$00,$00,$00 
	DC.B	$00,$02,$08,$06,$04,$0A,$06,$00 
	DC.B	$00,$04,$06,$0A,$04,$00,$00,$00 
	DC.B	$00,$06,$02,$00,$06,$0A,$08,$00 
	DC.B	$04,$08,$08,$04,$00,$00,$00,$00 
	DC.B	$00,$04,$00,$00,$06,$0C,$0C,$00 
	DC.B	$0A,$0A,$06,$02,$00,$00,$00,$00 
	DC.B	$00,$00,$02,$00,$06,$0C,$0C,$00 
	DC.B	$0C,$0C,$04,$02,$00,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$04,$0E,$0E,$00,$08,$0E,$04,$02 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$02 
	DC.B	$04,$0E,$0A,$00,$04,$0E,$08,$04 
	DC.B	$04,$00,$00,$00,$00,$00,$02,$04 
	DC.B	$08,$0C,$06,$00,$02,$08,$0C,$06 
	DC.B	$06,$04,$00,$00,$00,$00,$06,$06 
	DC.B	$0C,$08,$02,$00,$00,$04,$0A,$0A 
	DC.B	$08,$08,$00,$00,$00,$04,$0A,$0A 
	DC.B	$0A,$04,$00,$00,$00,$02,$06,$0A 
	DC.B	$08,$0A,$04,$00,$02,$0A,$0C,$0A 
	DC.B	$06,$02,$00,$00,$00,$00,$04,$08 
	DC.B	$08,$0C,$0A,$02,$06,$0C,$08,$06 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$04 
	DC.B	$08,$0C,$0C,$08,$0C,$06,$06,$02 
	DCB.W	3,0 
	DC.B	$00,$02,$06,$0C,$0E,$0C,$06,$04 
	DC.B	$02,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$02,$06,$06,$06,$04,$02 
	DCB.W	5,0 
	DC.B	$00,$02,$02,$02,$02,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$02,$04,$06,$0A,$08,$06,$02,$00 
	DC.B	$02,$06,$08,$0A,$06,$04,$02,$00 
	DC.B	$00,$04,$08,$0C,$04,$00,$00,$00 
	DC.B	$00,$00,$04,$0C,$06,$02,$00,$00 
	DC.B	$02,$08,$0A,$06,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$06,$0A,$02,$00,$00 
	DC.B	$06,$0C,$08,$02,$00,$00,$00,$00 
	DC.B	$00,$00,$00,$02,$0E,$02,$02,$00 
	DC.B	$0A,$08,$06,$00,$00,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$0E,$04,$04,$00,$0C,$04,$04,$00 
	DC.B	$00,$00,$0A,$08,$04,$00,$00,$00 
	DC.B	$0C,$06,$06,$00,$0E,$02,$02,$00 
	DC.B	$00,$00,$02,$0C,$02,$00,$00,$00 
	DC.B	$08,$08,$08,$00,$0C,$06,$02,$00 
	DC.B	$00,$00,$00,$0C,$00,$00,$00,$00 
	DC.B	$06,$0A,$0A,$00,$0A,$08,$04,$00 
	DC.B	$00,$00,$00,$0A,$00,$00,$00,$00 
	DC.B	$04,$0C,$08,$00,$06,$08,$04,$02 
	DC.B	$00,$00,$00,$08,$00,$00,$00,$02 
	DC.B	$06,$0E,$06,$00,$04,$08,$06,$06 
	DC.B	$02,$00,$00,$0C,$00,$00,$00,$04 
	DC.B	$0A,$0C,$02,$00,$02,$06,$06,$0A 
	DC.B	$04,$00,$00,$0E,$00,$00,$04,$08 
	DC.B	$0C,$06,$00,$00,$00,$02,$06,$0C 
	DC.B	$0A,$02,$00,$0C,$00,$00,$06,$0A 
	DC.B	$08,$04,$00,$00,$00,$00,$02,$06 
	DC.B	$0A,$06,$02,$08,$00,$06,$0A,$0C 
	DC.B	$04,$00,$00,$00,$00,$00,$00,$02 
	DC.B	$04,$08,$06,$0C,$08,$0A,$0A,$04 
	DCB.W	4,0 
	DC.B	$02,$04,$04,$0A,$04,$04,$02,$00 
	DCB.W	2,0 
	DC.B	$06,$04,$02,$00,$00,$00,$00,$00 
	DC.B	$02,$04,$08,$0C,$08,$02,$00,$00 
	DC.B	$04,$08,$08,$02,$00,$00,$00,$02 
	DC.B	$04,$06,$08,$08,$0A,$06,$00,$00 
	DC.B	$02,$04,$08,$0C,$04,$02,$02,$06 
	DC.B	$04,$02,$02,$0A,$08,$06,$00,$00 
	DC.B	$02,$04,$04,$0A,$0C,$06,$06,$02 
	DC.B	$00,$00,$04,$0A,$06,$02,$00,$00 
	DC.B	$00,$02,$06,$06,$0A,$0A,$04,$00 
	DC.B	$00,$02,$0A,$08,$04,$00,$00,$00 
	DC.B	$00,$00,$04,$08,$08,$08,$06,$02 
	DC.B	$04,$0A,$0E,$06,$02,$00,$00,$00 
	DC.B	$00,$00,$00,$04,$0A,$0A,$06,$04 
	DC.B	$04,$08,$06,$02,$00,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$06,$0C,$0C,$04,$02,$04,$02,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$0E,$0E,$04,$02,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$0A,$08,$0E,$0C,$04,$04,$02 
	DCB.W	3,0 
	DC.B	$00,$04,$0C,$06,$04,$06,$0C,$0A 
	DC.B	$06,$06,$04,$00,$00,$00,$00,$00 
	DC.B	$04,$0E,$08,$04,$00,$00,$06,$0A 
	DC.B	$08,$08,$08,$02,$00,$00,$00,$04 
	DC.B	$0C,$08,$02,$00,$00,$00,$00,$04 
	DC.B	$08,$08,$0A,$06,$00,$00,$04,$0A 
	DC.B	$08,$04,$00,$00,$00,$00,$00,$00 
	DC.B	$02,$06,$0A,$0E,$04,$00,$08,$08 
	DC.B	$06,$04,$02,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$06,$0A,$08,$00,$06,$08 
	DC.B	$0A,$0C,$0A,$06,$02,$00,$00,$00 
	DC.B	$00,$00,$02,$04,$0A,$00,$02,$06 
	DC.B	$08,$0A,$0C,$0E,$00,$00,$00,$02 
	DC.B	$06,$08,$0A,$0C,$0E,$00,$00,$00 
	DC.B	$00,$0A,$06,$00,$00,$00,$00,$00 
	DC.B	$02,$06,$06,$02,$00,$00,$00,$02 
	DC.B	$08,$06,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$08,$06,$00,$00,$00,$06 
	DC.B	$08,$02,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$0A,$04,$00,$02,$06 
	DC.B	$0C,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$0C,$06,$00,$02,$06 
	DC.B	$0E,$04,$00,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$0A,$0E,$04,$00,$00,$04 
	DC.B	$0A,$0C,$02,$00,$00,$00,$00,$00 
	DC.B	$02,$08,$0E,$06,$02,$00,$00,$02 
	DC.B	$04,$0A,$06,$02,$00,$00,$02,$04 
	DC.B	$08,$0A,$06,$04,$00,$00,$00,$00 
	DC.B	$02,$06,$06,$06,$04,$04,$06,$08 
	DC.B	$06,$06,$04,$00,$00,$00,$00,$00 
	DC.B	$00,$00,$04,$08,$0A,$0A,$06,$08 
	DC.B	$06,$02,$00,$00,$00,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$08,$0C,$04,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$0C,$04,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$0E,$02,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$0C,$04,$02,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$0A,$0A,$06,$06,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$08,$08,$06,$06,$08,$0A,$00 
	DCB.W	2,0 
	DC.B	$00,$02,$04,$04,$06,$08,$0A,$0A 
	DC.B	$0C,$0C,$0C,$0C,$0E,$0C,$04,$00 
	DC.B	$02,$02,$04,$06,$08,$0A,$0A,$0C 
	DC.B	$0C,$0C,$0C,$0E,$0E,$0C,$08,$00 
	DC.B	$04,$04,$0E,$0C,$0C,$0A,$08,$06 
	DC.B	$04,$02,$02,$02,$08,$0A,$06,$00 
	DC.B	$04,$06,$0C,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$04,$08,$08,$04,$00 
	DC.B	$02,$06,$0A,$00,$00,$00,$00,$00 
	DC.B	$02,$06,$04,$06,$08,$04,$00,$00 
	DC.B	$00,$06,$06,$00,$00,$00,$00,$04 
	DC.B	$08,$06,$06,$06,$04,$00,$00,$00 
	DC.B	$00,$06,$02,$00,$00,$00,$06,$0A 
	DC.B	$08,$06,$06,$04,$00,$00,$00,$00 
	DC.B	$04,$02,$00,$00,$00,$06,$0C,$0A 
	DC.B	$06,$04,$02,$00,$00,$00,$04,$00 
	DCB.W	2,0 
	DC.B	$06,$0E,$0C,$06,$02,$00,$00,$00 
	DC.B	$02,$06,$00,$00,$00,$00,$00,$04 
	DC.B	$0C,$0C,$06,$04,$00,$00,$00,$02 
	DC.B	$08,$02,$00,$00,$00,$00,$04,$0A 
	DC.B	$0A,$06,$06,$02,$00,$00,$00,$06 
	DC.B	$06,$02,$00,$00,$00,$04,$08,$08 
	DC.B	$08,$08,$04,$00,$00,$00,$00,$08 
	DC.B	$06,$04,$00,$00,$02,$06,$06,$06 
	DC.B	$0A,$04,$00,$00,$00,$00,$00,$04 
	DC.B	$0A,$06,$02,$00,$04,$02,$04,$08 
	DC.B	$0C,$0C,$0C,$0C,$0E,$0E,$0C,$0C 
	DC.B	$0A,$06,$04,$00,$02,$04,$08,$0A 
	DC.B	$0C,$08,$06,$04,$02,$04,$06,$08 
	DC.B	$0A,$0A,$04,$00,$02,$06,$0A,$0C 
	DC.B	$0A,$08,$06,$04,$02,$04,$06,$08 
	DC.B	$08,$0A,$02,$00,$00,$00,$00,$00 
	DCB.W	80,0
	DC.B	$00,$02,$06,$06,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$0E,$0A,$06,$04,$02,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$0A,$0C,$06,$02,$06,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$06,$06,$04,$02,$08,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$04,$02,$02,$06,$04,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$04,$06,$04,$00,$00,$00 
	DCB.W	20,0
	DC.B	$00,$02,$06,$06,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$0E,$0A,$06,$04,$02,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$0A,$0C,$06,$02,$06,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$06,$06,$04,$02,$08,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$04,$02,$02,$06,$04,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$04,$06,$04,$00,$00,$00 
	DCB.W	20,0
	DC.B	$00,$02,$06,$06,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$0E,$0A,$06,$04,$02,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$0A,$0C,$06,$02,$06,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$06,$06,$04,$02,$08,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$04,$02,$02,$06,$04,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$04,$06,$04,$00,$00,$00 
	DCB.W	5,0 
	DC.B	$02,$06,$02,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$02,$00,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$0A,$04,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$06,$0C,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$04,$0A,$04,$00,$00,$00 
	DCB.W	5,0 
	DC.B	$02,$06,$0A,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$08,$0E,$06,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$02,$04,$08,$0C,$0A,$06,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$08,$02,$02,$02,$02,$06,$02 
	DCB.W	5,0 
	DC.B	$02,$06,$06,$02,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$02,$0E,$0A,$06,$04,$02,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$0A,$0C,$06,$02,$06,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$06,$06,$04,$02,$08,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$04,$02,$02,$06,$04,$00 
	DCB.W	5,0 
	DC.B	$02,$04,$06,$04,$00,$00,$00,$00 
	DCB.W	9,0 
	DC.B	$00,$04,$06,$04,$02,$04,$06,$08 
	DC.B	$08,$08,$04,$00,$00,$00,$00,$00 
	DC.B	$04,$0A,$0C,$0C,$0C,$0A,$08,$08 
	DC.B	$06,$06,$0A,$06,$00,$00,$00,$00 
	DC.B	$06,$08,$02,$00,$00,$00,$00,$00 
	DC.B	$00,$04,$06,$0C,$00,$00,$00,$00 
	DC.B	$04,$06,$04,$00,$00,$00,$00,$00 
	DC.B	$00,$02,$04,$0E,$00,$00,$00,$00 
	DC.B	$00,$04,$02,$00,$00,$00,$00,$00 
	DC.B	$02,$04,$06,$0A,$00,$00,$00,$00 
	DC.B	$00,$00,$02,$00,$00,$02,$06,$06 
	DC.B	$04,$06,$0A,$04,$00,$00,$00,$00 
	DC.B	$00,$00,$02,$00,$02,$06,$04,$06 
	DC.B	$08,$08,$04,$00,$00,$00,$00,$00 
	DCB.W	2,0 
	DC.B	$06,$06,$08,$06,$04,$02,$00,$00 
	DCB.W	20,0
	DC.B	$02,$06,$06,$02,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$02,$0E,$0A,$06,$04,$02,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$0A,$0C,$06,$02,$06,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$06,$06,$04,$02,$08,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$04,$02,$02,$06,$04,$00 
	DCB.W	5,0 
	DC.B	$02,$04,$06,$04,$00,$00,$00,$00 
	DCB.W	7,0 
	DC.B	$02,$04,$04,$02,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$04,$0A,$0A,$08,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$0C,$0A,$06,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$04,$08,$0A,$06,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$0C,$08,$04,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$0C,$0A,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$0C,$06,$02,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$08,$0C,$04,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$08,$0C,$04,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$0E,$06,$02,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$02,$0C,$0A,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$0C,$08,$04,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$08,$0A,$06,$00,$00,$00 
	DCB.W	5,0 
	DC.B	$04,$0C,$0A,$06,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$0A,$0A,$08,$00,$00,$00 
	DCB.W	5,0 
	DC.B	$02,$04,$04,$02,$00,$00,$00,$02 
	DC.B	$04,$04,$02,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$08,$0A,$0A,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$06,$0A,$0C,$04,$00,$00,$00 
	DCB.W	5,0 
	DC.B	$06,$0A,$08,$04,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$08,$0C,$06,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$0A,$0C,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$02,$06,$0C,$06,$00,$00,$00 
	DCB.W	5,0 
	DC.B	$04,$0C,$08,$00,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$0C,$08,$00,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$02,$06,$0E,$06,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$00,$04,$0A,$0C,$02,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$04,$08,$0C,$06,$00,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$06,$0A,$08,$04,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$06,$0A,$0C,$04,$00,$00,$00 
	DCB.W	4,0 
	DC.B	$08,$0A,$0A,$04,$00,$00,$00,$00 
	DCB.W	3,0 
	DC.B	$00,$04,$04,$04,$04,$00,$00,$00 
	DCB.W	54,0
	DC.B	$0C,$08,$08,$0A,$0C,$0E,$0C,$0A 
	DC.B	$08,$00,$00,$00,$00,$00,$00,$00 
	DC.B	$0A,$06,$04,$02,$02,$00,$02,$04 
	DC.B	$06,$00,$00,$00,$00,$00,$00,$00 
	DCB.W	190,0 

music	incbin	g:\music\new_rips.mug\data.thk

	even
L0098:
	DC.B	$00,$00,$00,$02,$00,$06,$00,$08 
	DC.B	$00,$0A,$00,$0E,$00,$10,$00,$12 
	DC.B	$00,$16,$00,$18,$00,$1A,$00,$1C 
	DC.B	$00,$00,$00,$02,$00,$04,$00,$06 
	DC.B	$00,$08,$00,$0A,$00,$0C,$00,$0E 
	DC.B	$00,$10,$00,$12,$00,$14,$00,$16 
	DC.B	$00,$18,$00,$1A,$00,$1A,$00,$1C 
	DC.B	$00,$1E,$00,$1E,$00,$00,$00,$00 
	DC.B	$00,$02,$00,$02,$00,$02,$00,$04 
	DC.B	$00,$04,$00,$04,$00,$04,$00,$04 
	DC.B	$00,$04,$00,$04,$00,$04,$00,$04 
	DC.B	$00,$04,$00,$04,$00,$04,$00,$02 
	DC.B	$00,$02,$00,$00,$00,$00,$00,$1E 
	DC.B	$00,$1E,$00,$1C,$00,$1C,$00,$1A 
	DC.B	$00,$18,$00,$16,$00,$14,$00,$12 
	DC.B	$00,$10,$00,$0E,$00,$0C,$00,$0A 
	DC.B	$00,$08,$00,$06,$00,$04,$00,$00 
	DC.B	$00,$1E,$00,$1C,$00,$18,$00,$16 
	DC.B	$00,$12,$00,$10,$00,$0C,$00,$0A 
	DC.B	$00,$06,$00,$04,$00,$00,$00,$1E 
	DC.B	$00,$1A,$00,$16,$00,$14,$00,$10 
	DC.B	$00,$0C,$00,$08,$00,$06,$00,$02 
	DC.B	$00,$1E,$00,$1A,$00,$18,$00,$14 
	DC.B	$00,$10,$00,$0E,$00,$0A,$00,$06 
	DC.B	$00,$02,$00,$00,$00,$1C,$00,$18 
	DC.B	$00,$16,$00,$12,$00,$0E,$00,$0C 
	DC.B	$00,$08,$00,$06,$00,$02,$00,$00 
	DC.B	$00,$1C,$00,$1A,$00,$16,$00,$14 
	DC.B	$00,$10,$00,$0E,$00,$0C,$00,$0A 
	DC.B	$00,$06,$00,$04,$00,$02,$00,$00 
	DC.B	$00,$1E,$00,$1C,$00,$1A,$00,$18 
	DC.B	$00,$16,$00,$16,$00,$14,$00,$12 
	DC.B	$00,$12,$00,$10,$00,$10,$00,$0E 
	DC.B	$00,$0E,$00,$0C,$00,$0C,$00,$0C 
	DC.B	$00,$0A,$00,$0A,$00,$0A,$00,$0A 
	DC.B	$00,$0A,$00,$0A,$00,$0A,$00,$0A 
	DC.B	$00,$0C,$00,$0C,$00,$0C,$00,$0C 
	DC.B	$00,$0E,$00,$0E,$00,$10,$00,$10 
	DC.B	$00,$12,$00,$14,$00,$14,$00,$16 
	DC.B	$00,$18,$00,$1A,$00,$1A,$00,$1C 
	DC.B	$00,$1E,$00,$00,$00,$02,$00,$04 
	DC.B	$00,$06,$00,$08,$00,$0C,$00,$0E 
	DC.B	$00,$10,$00,$12,$00,$14,$00,$18 
	DC.B	$00,$1A,$00,$1C,$00,$00,$00,$02 
	DC.B	$00,$04,$00,$08,$00,$0A,$00,$0C 
	DC.B	$00,$10,$00,$12,$00,$16,$00,$18 
	DC.B	$00,$1A,$00,$1E,$00,$00,$00,$04 
	DC.B	$00,$06,$00,$08,$00,$0C,$00,$0E 
	DC.B	$00,$10,$00,$14,$00,$16,$00,$18 
	DC.B	$00,$1C,$00,$1E,$00,$00,$00,$02 
	DC.B	$00,$06,$00,$08,$00,$0A,$00,$0C 
	DC.B	$00,$0E,$00,$10,$00,$12,$00,$14 
	DC.B	$00,$16,$00,$18,$00,$1A,$00,$1C 
	DC.B	$00,$1E,$00,$00,$00,$00,$00,$02 
	DC.B	$00,$04,$00,$04,$00,$06,$00,$06 
	DC.B	$00,$08,$00,$08,$00,$0A,$00,$0A 
	DC.B	$00,$0A,$00,$0C,$00,$0C,$00,$0C 
	DC.B	$00,$0C,$00,$0C,$00,$0C,$00,$0C 
	DC.B	$00,$0C,$00,$0C,$00,$0C,$00,$0C 
	DC.B	$00,$0C,$00,$0A,$00,$0A,$00,$0A 
	DC.B	$00,$08,$00,$08,$00,$08,$00,$06 
	DC.B	$00,$06,$00,$04,$00,$02,$00,$02 
	DC.B	$00,$00,$00,$1E,$00,$1E,$00,$1C 
	DC.B	$00,$1A,$00,$18,$00,$16,$00,$16 
	DC.B	$00,$14,$00,$12,$00,$10,$00,$0E 
	DC.B	$00,$0C,$00,$0A,$00,$08,$00,$06 
	DC.B	$00,$04,$00,$02,$00,$00,$00,$1E 
	DC.B	$00,$1C,$00,$1A,$00,$18,$00,$16 
	DC.B	$00,$14,$00,$12,$00,$10,$00,$0E 
	DC.B	$00,$0C,$00,$0A,$00,$08,$00,$06 
	DC.B	$00,$04,$00,$02,$00,$00,$00,$1E 
	DC.B	$00,$1C,$00,$1A,$00,$18,$00,$16 
	DC.B	$00,$14,$00,$14,$00,$12,$00,$10 
	DC.B	$00,$0E,$00,$0E,$00,$0C,$00,$0C 
	DC.B	$00,$0A,$00,$08,$00,$08,$00,$08 
	DC.B	$00,$06,$00,$06,$00,$04,$00,$04 
	DC.B	$00,$04,$00,$04,$00,$02,$00,$02 
	DC.B	$00,$02,$00,$02,$00,$02,$00,$02 
	DC.B	$00,$02,$00,$02,$00,$04,$00,$04 
	DC.B	$00,$04,$00,$04,$00,$06,$00,$06 
	DC.B	$00,$08,$00,$08,$00,$0A,$00,$0A 
	DC.B	$00,$0C,$00,$0E,$00,$0E,$00,$10 
	DC.B	$00,$12,$00,$14,$00,$14,$00,$16 
	DC.B	$00,$18,$00,$1A,$00,$1C,$00,$1E 
	DC.B	$00,$00,$00,$02,$00,$06,$00,$08 
	DC.B	$00,$0A,$00,$0C,$00,$0E,$00,$12 
	DC.B	$00,$14,$00,$16,$00,$18,$00,$1C 
	DC.B	$00,$1E,$00,$00,$00,$04,$00,$06 
	DC.B	$00,$0A,$00,$0C,$00,$0E,$00,$12 
	DC.B	$00,$14,$00,$18,$00,$1A,$00,$1C 
L0099	DCB.W	360,0 

