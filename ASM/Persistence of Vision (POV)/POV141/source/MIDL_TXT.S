----------------------------------------
  WELCOME TO PERSISTENCE OF VISION 141
----------------------------------------

		CREDITS:

	     MENU CODED BY:

	      MAC SYS DATA


		ART BY:

      OZYMANDIAS AND MAC SYS DATA


	      MUSIC FROM:

	        LOGICAL^----------------------------------------
      1: SMELLS LIKE SCREEN SPIRIT

   2: ADMIRABLES FONT COMPIL 7 INTRO

	     3: ABC17A

4: THE ULTIMATE DENTRO 'THE DOTS DANCE'

      5: FANATICS MOD DISC 7 INTRO

    6: ADMIRABLES MOD COMPIL W INTRO

     7: MAD VISION 'UNLIMITED BOBS'

	 8: PURE ENERGY MENU 33

	      9: COPIER
----------------------------------------^



----------------------------------------
	      CONTACT US AT:

	  PERSISTENCE OF VISION
		P.O. BOX 40
	    THORNTON-CLEVELEYS
		LANCASHIRE
		 FY5 3PH
		 ENGLAND

----------------------------------------^

----------------------------------------

	 PERSISTENCE OF VISION

CAN BE FOUND ON THE FOLLOWING PLATFORMS:


    ST/E  (DEMOS/GAMES/COMPILATIONS)
	     AMIGA  (GAMES)
	     SNES  (GAMES)
	  MEGADRIVES  (GAMES)
	       VAX  (DCL)
		 UNIX
		ULTRIX


----------------------------------------^