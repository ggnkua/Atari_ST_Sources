----------------------------------------
  WELCOME TO PERSISTENCE OF VISION 142
----------------------------------------

		CREDITS:

	     MENU CODED BY:

	      MAC SYS DATA


		ART BY:

	      OZYMANDIAS


	       MUSIC BY:

	      OZYMANDIAS^



	 abbbbbbbbbbbbbbbbbbbbc
	 h   1: KULTUR MELK   d
	 h                    d
	 h   2: PARALLAX 1    d
	 h                    d
	 h   3: PARALLAX 2    d
	 h                    d
	 h    4: COPIER       d
	 gffffffffffffffffffffe^




	    QUICK GREETS TO

	      ADRENALIN UK
                 D-BUG
	      DIGIT OF TSN
      EDGE OF SANITY (ANNHILATOR)
	      PURE ENERGY^


----------------------------------------
	      CONTACT US AT:

	  PERSISTENCE OF VISION
		P.O. BOX 40
	    THORNTON-CLEVELEYS
		LANCASHIRE
		 FY5 3PH
		 ENGLAND

----------------------------------------^



          PERSISTENCE OF VISION
 ARE ACTIVE ON THE FOLLOWING PLATFORMS

	    APPLE MAC LC II
		ATARI ST
DIGITAL EQUIPMENT CORPORATION VAX (VMS)
	     NINTENDO SNES
	      SEGA MEGA CD
	     SEGA MEGADRIVE^
