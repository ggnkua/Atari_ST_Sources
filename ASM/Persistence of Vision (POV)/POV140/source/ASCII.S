         abbbbbbbbbbbbbbbbbbbbbc
         hPERSISTENCE OF VISIONd
         gfffffffffffffffffffffe
         abbbbbbbbbbbbbbbbbbbbbc
         hPERSISTENCE OF VISIONd
         gfffffffffffffffffffffe
         abbbbbbbbbbbbbbbbbbbbbc
         hPERSISTENCE OF VISIONd
         gfffffffffffffffffffffe
         abbbbbbbbbbbbbbbbbbbbbc
         hPERSISTENCE OF VISIONd
         gfffffffffffffffffffffe
         abbbbbbbbbbbbbbbbbbbbbc
         hPERSISTENCE OF VISIONd
         gfffffffffffffffffffffe
         abbbbbbbbbbbbbbbbbbbbbc
         hPERSISTENCE OF VISIONd
         gfffffffffffffffffffffe
         abbbbbbbbbbbbbbbbbbbbbc
         hPERSISTENCE OF VISIONd
         gfffffffffffffffffffffe^
abbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbc
h WELCOME TO PERSISTENCE OF VISION 140 d
gffffffffffffffffffffffffffffffffffffffe

              abbbbbbbbbbc
              h CREDITS: d
              gffffffffffe


MENU CODED BY:  MAC SYS DATA



     MUSIC BY:  NO-MORE OF A.M.



 RELEASE DATE:  7TH NOVEMBER 1993



ffffffffffffffffffffffffffffffffffffffff^

bbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbb

                1: ABC 16

              2: MAD VISION

       3: MAD VISION OVERSCAN PICTURE

             4: NLC MATHSHOW

              5: ELITE INTRO

            6: IMPACT MENU 71

             7: INSOMNIA INTRO

               8: JMP 5 DEMO

                9: COPIER

bbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbb^


IF YOU ARE WAITING FOR THE OFFICIAL POV
SOURCE CODE DISC THEN YOU'LL HAVE A LONG
WAIT AS I HAVEN'T EVEN STARTED THE CODE
                THE INTRO!

     WHAT DO YOU THINK OF THIS MENU?

              PRETTY NAFF EH?

THE WORST PART OF IT WAS TYPING ALL THE
COLOURS IN FOR THE RASTERS, STE ENHANCED
OF COURSE!

IF YOU WISH TO CONTACT POV FOR ANYTHING
 THEN WRITE TO THE FOLLOWING ADDRESS.


bbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbbb^




----------------------------------------
             CONTACT POV AT:

          PERSISTENCE OF VISION
                P.O. BOX 40
            THORNTON-CLEVELEYS
                  FY5 3PH
                 LANCASHIRE
                  ENGLAND

----------------------------------------^
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV,
POV,POV,POV,POV,POV,POV,POV,POV,POV,POV!^
